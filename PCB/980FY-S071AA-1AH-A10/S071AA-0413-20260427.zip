# Allegro board S071AA-0413-20260427.brd (continued)
## Nets (continued)
UT4_UW08: UTL4.A07
UT4_UW09: UTL4.B08
UT4_UW10: UTL4.A09
UT4_UW11: UTL4.B10
UT4_UW12: UTL4.A11
UT4_UW13: UTL4.B12
UT4_UW14: UTL4.A13
UT4_UW15: UTL4.B14
N18284685: KB2-4.1(TP) KS2.4
N18284703: LDB2.1(A) LRB2.2
N18284711: KB2-3.1(TP) KS2.3
N18284713: KB2-6.1(TP) KS2.6
N18284719: KB2-7.1(TP) KS2.7
N18284723: LDB3.1(A) LRB3.2
N18284731: KB1-4.1(TP) KS1.4
N18284735: KB1-3.1(TP) KS1.3
N18284737: KB1-6.1(TP) KS1.6
N18284739: KB1-7.1(TP) KS1.7
N18284747: KB1-2.1(TP) KS1.2
N18284749: KB1-8.1(TP) KS1.8
N18284751: KB2-2.1(TP) KS2.2
N18284753: KB2-8.1(TP) KS2.8
N18285026: LDB4.1(A) LRB4.2
N18285036: LDB5.1(A) LRB5.2
N18285067: KB4-4.1(TP) KS4.4
N18285069: KB4-5.1(TP) KS4.5
N18285071: KB4-8.1(TP) KS4.8
N18285089: KB3-8.1(TP) KS3.8
N18285091: KB3-4.1(TP) KS3.4
N18285093: KB3-5.1(TP) KS3.5
N18285182: LDB1.1(A) LRB1.1
N22954976: LD15.1(A) R15.1
N22955016: LD16.1(A) R16.1
N22955678: LD1.1(A) R1.1
N22955710: LD2.1(A) R2.1
N22955758: LD3.1(A) R3.1
N22955802: LD4.1(A) R4.1
N22955842: LD5.1(A) R5.1
N22955878: LD6.1(A) R6.1
N22955926: LD7.1(A) R7.1
N22955970: LD8.1(A) R8.1
N22956024: LD9.1(A) R9.1
N22956064: LD10.1(A) R10.1
N22956104: LD11.1(A) R11.1
N22956144: LD12.1(A) R12.1
N22956184: LD13.1(A) R13.1
N22956224: LD14.1(A) R14.1
N22963164: LD19.1(A) R19.1
N22963523: LD20.1(A) R20.1
N22963871: LD21.1(A) R21.1
N22964216: LD22.1(A) R22.1
N22964605: LD23.1(A) R23.1
N22964637: LD24.1(A) R24.1
N22965490: LD17.1(A) R17.1
N22965526: LD18.1(A) R18.1
N22974884: LD25.1(A) R25.1
N22974900: LD26.1(A) R26.1
N22974958: LD29.1(A) R29.1
N22975006: LD27.1(A) R27.1
N22975038: LD28.1(A) R28.1
N22975098: LD30.1(A) R30.1
N22976209: LD31.1(A) R31.1
N22976245: LD32.1(A) R32.1
N22984719: LD33.1(A) R33.1
N22984755: LD34.1(A) R34.1
N22984791: LD35.1(A) R35.1
N22984831: LD36.1(A) R36.1
N22984875: LD37.1(A) R37.1
N22984899: LD38.1(A) R38.1
N22984935: LD39.1(A) R39.1
N22984991: LD40.1(A) R40.1
N22985097: LD41.1(A) R41.1
N22985125: LD42.1(A) R42.1
N22988922: LD43.1(A) R43.1
N22989162: LD44.1(A) R44.1
N23040624: LD45.1(A) R45.1
N23040666: K45.4 OSC1.3(OUT)
N23043619: R123.1 R124.1 SH3.2
N23043647: R127.1 R128.1 SH4.2
N23050554: LD46.1(A) R46.1
N23057413: R129.1 R130.1 SH5.2
N23057441: R133.1 R134.1 SH6.2
N23058541: R135.1 R136.1 SH7.2
N23058569: R139.1 R140.1 SH8.2
N23059275: R141.1 R142.1 SH9.2
N23059303: R145.1 R146.1 SH10.2
N23060072: R147.1 R148.1 SH11.2
N23060100: R151.1 R152.1 SH12.2
N23060930: R153.1 R154.1 SH13.2
N23060958: R157.1 R158.1 SH14.2
N23062789: R159.1 R160.1 SH15.2
N23062817: R163.1 R164.1 SH16.2

Pads without a net: BGA289-12X12-P0.65 1; CSDPS225 A17 B17 C17 D17; CSDPS226 A17 D17; CSDPS229 A17 B17 C17 D17; CSDPS425 A17 B17 C17 D17; CSDPS426 A17 D17; CSDPS429 A17 B17 C17 D17; D101 17 A17 B17; D102 17 A17 B17; D103 17 A17 B17; D104 17 A17 B17; D105 17 A17 B17; D106 17 A17 B17; D107 17 A17 B17; D108 17 A17 B17; D109 17 A17 B17; D110 17 A17 B17; D111 17 A17 B17; D112 17 A17 B17; D113 17 A17 B17; D114 17 A17 B17; D115 17 A17 B17; D116 17 A17 B17; D117 17 A17 B17; D118 17 A17 B17; D119 17 A17 B17; D120 17 A17 B17; D121 17 A17 B17; D122 17 A17 B17; D123 17 A17 B17; D124 17 A17 B17; D227 01 02 03 05 06 07 08 09 10 11 12 13 14 15 16 17; D228 01 02 03 05 06 07 08 09 10 11 12 13 14 15 16 17; D301 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D302 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D303 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D304 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D305 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D306 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D307 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D308 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D309 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D310 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D311 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D312 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D313 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D314 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D315 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D316 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D317 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D318 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D319 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D320 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D321 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D322 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D323 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D324 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D427 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17; D428 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17; DPS1 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS2 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS3 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS8 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; FD7 1; FD8 1; FD9 1; FD10 1; FD11 1; FD12 1; FD13 1; FD14 1; FD15 1; FD16 1; FSS0AS071A 1; JG-250905AA011 1; K1 2; K2 2; K3 2; K4 2; K5 2; K6 2; K7 2; K8 2; K9 2; K10 2; K11 2; K12 2; K13 2; K14 2; K15 2; K16 2; K17 2; K18 2; K19 2; K20 2; K21 2; K22 2; K23 2; K24 2; K25 2; K26 2; K27 2; K28 2; K29 2; K30 2; K31 2; K32 2; K33 2; K34 2; K35 2; K36 2; K37 2; K38 2; K39 2; K40 2; K41 2; K42 2; K43 2; K44 2; K45 5 6 7; K46 2 7; KS3 2; KS4 2; LOGO1 1; LOGO2 1; M5 1; OSC1 1; SCREW1 NUT19 NUT20 NUT21 NUT22; SITE1 NUT1 NUT2 NUT3 NUT4 NUT5 NUT6 NUT7 NUT8; UNK038FY-S135BB14Q-A100 1; UNK980FY-S071AA-1AH 1; UTL1 A17 B17; UTL2 A17 B17; UTL3 A17 B17; UTL4 A17 B17

## Via types
v1: diameter 0.61, hole 0.305, TOP to BOTTOM, 1094 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 358 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
AGND: length 94144
  TOP w0.152: D231.A15 21.66,375.92 ; D231.A15 20.59,374.85 ; D231.A15 20.59,376.99 ; D231.A15 19.52,375.92 ; D102.A3 168.98,73.66 ; D102.A3 167.91,72.59 ; D102.A3 167.91,74.73 ; D102.A3 166.84,73.66 ; D109.B3 272.05,331.27 ; D109.B3 272.05,329.13 ; D109.B3 270.98,330.2 ; D109.B3 273.12,330.2 ; 127.27,351.99 CSDPS226.B2 ; CSDPS226.B2 128.34,353.06 ; CSDPS226.B2 126.2,353.06 ; CSDPS226.B2 127.27,354.13 ; D113.A11 178.07,336.35 ; D113.A11 178.07,334.21 ; D113.A11 177,335.28 ; D113.A11 179.14,335.28 ; 255.74,391.16 D112.B9 ; D112.B9 257.88,391.16 ; D112.B9 256.81,392.23 ; D112.B9 256.81,390.09 ; 42.38,342.9 CSDPS429.B6 ; CSDPS429.B6 44.52,342.9 ; CSDPS429.B6 43.45,341.83 ; CSDPS429.B6 43.45,343.97 ; 128.74,340.36 CSDPS425.C1 ; CSDPS425.C1 129.81,339.29 ; CSDPS425.C1 130.88,340.36 ; CSDPS425.C1 129.81,341.43 ; D228.B4 122.19,389.69 ; D228.B4 121.12,388.62 ; D228.B4 122.19,387.55 ; D228.B4 123.26,388.62 ; D118.B11 40.91,79.81 ; D118.B11 41.98,78.74 ; D118.B11 40.91,77.67 ; D118.B11 39.84,78.74 ; D109.B6 265.5,327.66 ; D109.B6 264.43,326.59 ; D109.B6 264.43,328.73 ; D109.B6 263.36,327.66 ; 269.51,34.49 D108.A14 ; D108.A14 268.44,35.56 ; D108.A14 269.51,36.63 ; D108.A14 270.58,35.56 ; 250.66,396.24 D112.A11 ; D112.A11 252.8,396.24 ; D112.A11 251.73,397.31 ; D112.A11 251.73,395.17 ; UHC230.G3_13 44.38,349.1 ; UHC230.G3_13 44.38,347.48 ; UHC230.G3_13 43.57,348.29 ; UHC230.G3_13 45.19,348.29 ; 254.27,54.81 D107.A8 ; D107.A8 254.27,56.95 ; D107.A8 253.2,55.88 ; D107.A8 255.34,55.88 ; D431.A7 41.98,386.08 ; D431.A7 40.91,387.15 ; D431.A7 39.84,386.08 ; D431.A7 40.91,385.01 ; 123.66,16.51 DPS3.B15 ; DPS3.B15 124.73,17.58 ; DPS3.B15 125.8,16.51 ; DPS3.B15 124.73,15.44 ; 179.54,373.38 D115.A10 ; D115.A10 180.61,372.31 ; D115.A10 180.61,374.45 ; D115.A10 181.68,373.38 ; D228.A17 90.24,396.24 ; D228.A17 89.17,395.17 ; D228.A17 89.17,397.31 ; D228.A17 88.1,396.24 ; D115.A9 183.15,376.99 ; D115.A9 184.22,375.92 ; D115.A9 182.08,375.92 ; D115.A9 183.15,374.85 ; 259.35,95.45 D105.A10 ; D105.A10 259.35,97.59 ; D105.A10 258.28,96.52 ; D105.A10 260.42,96.52 ; D228.A12 101.87,394.77 ; D228.A12 100.8,393.7 ; D228.A12 101.87,392.63 ; D228.A12 102.94,393.7 ; 167.91,97.99 D101.B3 ; D101.B3 168.98,99.06 ; D101.B3 166.84,99.06 ; D101.B3 167.91,100.13 ; 20.59,329.13 CSDPS229.C15 ; CSDPS229.C15 20.59,331.27 ; CSDPS229.C15 21.66,330.2 ; CSDPS229.C15 19.52,330.2 ; 268.44,388.62 D112.B4 ; D112.B4 269.51,387.55 ; D112.B4 269.51,389.69 ; D112.B4 270.58,388.62 ; 44.38,350.98 UHC230.G3_8 ; UHC230.G3_8 44.38,352.6 ; UHC230.G3_8 45.19,351.79 ; UHC230.G3_8 43.57,351.79 ; D122.B6 101.87,82.35 ; D122.B6 101.87,80.21 ; D122.B6 100.8,81.28 ; D122.B6 102.94,81.28 ; D103.B16 200.93,62.03 ; D103.B16 200.93,59.89 ; D103.B16 202,60.96 ; D103.B16 199.86,60.96 ; 246.65,329.13 D109.B13 ; D109.B13 247.72,330.2 ; D109.B13 245.58,330.2 ; D109.B13 246.65,331.27 ; 109.49,339.29 CSDPS425.C9 ; CSDPS425.C9 109.49,341.43 ; CSDPS425.C9 110.56,340.36 ; CSDPS425.C9 108.42,340.36 ; CSDPS429.C9 36.9,340.36 ; CSDPS429.C9 35.83,339.29 ; CSDPS429.C9 34.76,340.36 ; CSDPS429.C9 35.83,341.43 ; D113.B3 199.46,330.2 ; D113.B3 198.39,331.27 ; D113.B3 198.39,329.13 ; D113.B3 197.32,330.2 ; DPS3.B05 100.4,16.51 ; DPS3.B05 99.33,17.58 ; DPS3.B05 98.26,16.51 ; DPS3.B05 99.33,15.44 ; 199.86,40.64 D104.B16 ; D104.B16 200.93,41.71 ; D104.B16 202,40.64 ; D104.B16 200.93,39.57 ; D121.A1 89.17,95.05 ; D121.A1 88.1,93.98 ; D121.A1 89.17,92.91 ; D121.A1 90.24,93.98 ; 113.5,406.4 D428.A7 ; D428.A7 115.64,406.4 ; D428.A7 114.57,405.33 ; D428.A7 114.57,407.47 ; 177,396.24 D116.A11 ; D116.A11 178.07,397.31 ; D116.A11 179.14,396.24 ; D116.A11 178.07,395.17 ; D232.B17 15.51,392.23 ; D232.B17 14.44,391.16 ; D232.B17 15.51,390.09 ; D232.B17 16.58,391.16 ; 101.87,351.99 CSDPS226.B12 ; CSDPS226.B12 100.8,353.06 ; CSDPS226.B12 102.94,353.06 ; CSDPS226.B12 101.87,354.13 ; 122.19,54.81 D123.A14 ; D123.A14 121.12,55.88 ; D123.A14 122.19,56.95 ; D123.A14 123.26,55.88 ; 110.96,55.88 D123.A10 ; D123.A10 112.03,56.95 ; D123.A10 113.1,55.88 ; D123.A10 112.03,54.81 ; 203.47,395.17 D116.A1 ; D116.A1 204.54,396.24 ; D116.A1 202.4,396.24 ; D116.A1 203.47,397.31 ; D231.A17 16.58,375.92 ; D231.A17 15.51,376.99 ; D231.A17 14.44,375.92 ; D231.A17 15.51,374.85 ; D117.A12 44.52,96.52 ; D117.A12 42.38,96.52 ; D117.A12 43.45,95.45 ; D117.A12 43.45,97.59 ; 25.67,92.91 D117.A5 ; D117.A5 25.67,95.05 ; D117.A5 26.74,93.98 ; D117.A5 24.6,93.98 ; CSDPS225.B8 113.1,332.74 ; CSDPS225.B8 110.96,332.74 ; CSDPS225.B8 112.03,331.67 ; CSDPS225.B8 112.03,333.81 ; 177,370.84 D115.B11 ; D115.B11 179.14,370.84 ; D115.B11 178.07,371.91 ; D115.B11 178.07,369.77 ; 15.51,52.27 D119.A1 ; D119.A1 14.44,53.34 ; D119.A1 16.58,53.34 ; D119.A1 15.51,54.41 ; 166.84,53.34 D103.A3 ; D103.A3 167.91,54.41 ; D103.A3 167.91,52.27 ; D103.A3 168.98,53.34 ; D109.A11 252.8,335.28 ; D109.A11 250.66,335.28 ; D109.A11 251.73,336.35 ; D109.A11 251.73,334.21 ; 174.46,388.62 D116.B12 ; D116.B12 175.53,387.55 ; D116.B12 176.6,388.62 ; D116.B12 175.53,389.69 ; D113.B16 165.37,328.73 ; D113.B16 166.44,327.66 ; D113.B16 164.3,327.66 ; D113.B16 165.37,326.59 ; 52.54,368.3 D231.B2 ; D231.B2 53.61,367.23 ; D231.B2 54.68,368.3 ; D231.B2 53.61,369.37 ; 235.42,93.98 D105.A1 ; D105.A1 236.49,95.05 ; D105.A1 237.56,93.98 ; D105.A1 236.49,92.91 ; 263.36,388.62 D112.B6 ; D112.B6 264.43,387.55 ; D112.B6 264.43,389.69 ; D112.B6 265.5,388.62 ; D114.A1 203.47,356.67 ; D114.A1 204.54,355.6 ; D114.A1 203.47,354.53 ; D114.A1 202.4,355.6 ; 50,375.92 D231.A3 ; D231.A3 52.14,375.92 ; D231.A3 51.07,376.99 ; D231.A3 51.07,374.85 ; D116.A4 195.85,394.77 ; D116.A4 195.85,392.63 ; D116.A4 196.92,393.7 ; D116.A4 194.78,393.7 ; DPS2.A05 193.31,416.36 ; DPS2.A05 194.38,415.29 ; DPS2.A05 193.31,414.22 ; DPS2.A05 192.24,415.29 ; D108.A15 273.12,33.02 ; D108.A15 270.98,33.02 ; D108.A15 272.05,34.09 ; D108.A15 272.05,31.95 ; 122.19,377.39 D427.B4 ; D427.B4 123.26,378.46 ; D427.B4 122.19,379.53 ; D427.B4 121.12,378.46 ; 15.73,359.39 UHC430.G1_10 ; UHC430.G1_10 16.54,360.2 ; UHC430.G1_10 15.73,361.01 ; UHC430.G1_10 14.92,360.2 ; 101.87,341.83 CSDPS425.B12 ; CSDPS425.B12 100.8,342.9 ; CSDPS425.B12 102.94,342.9 ; CSDPS425.B12 101.87,343.97 ; D109.B11 252.8,330.2 ; D109.B11 250.66,330.2 ; D109.B11 251.73,329.13 ; D109.B11 251.73,331.27 ; CSDPS426.C11 105.48,360.68 ; CSDPS426.C11 104.41,359.61 ; CSDPS426.C11 103.34,360.68 ; CSDPS426.C11 104.41,361.75 ; 51.07,52.27 D119.A15 ; D119.A15 51.07,54.41 ; D119.A15 52.14,53.34 ; D119.A15 50,53.34 ; D116.B10 180.61,389.69 ; D116.B10 180.61,387.55 ; D116.B10 179.54,388.62 ; D116.B10 181.68,388.62 ; 117.11,80.21 D122.B12 ; D122.B12 117.11,82.35 ; D122.B12 118.18,81.28 ; D122.B12 116.04,81.28 ; D103.B7 179.14,58.42 ; D103.B7 178.07,57.35 ; D103.B7 178.07,59.49 ; D103.B7 177,58.42 ; D120.B14 49.6,40.64 ; D120.B14 48.53,39.57 ; D120.B14 48.53,41.71 ; D120.B14 47.46,40.64 ; D112.B15 242.64,391.16 ; D112.B15 240.5,391.16 ; D112.B15 241.57,392.23 ; D112.B15 241.57,390.09 ; D102.B3 167.91,79.81 ; D102.B3 167.91,77.67 ; D102.B3 166.84,78.74 ; D102.B3 168.98,78.74 ; 29.68,58.42 D119.B7 ; D119.B7 30.75,57.35 ; D119.B7 31.82,58.42 ; D119.B7 30.75,59.49 ; 114.57,77.67 D122.B11 ; D122.B11 115.64,78.74 ; D122.B11 113.5,78.74 ; D122.B11 114.57,79.81 ; D107.B15 273.12,58.42 ; D107.B15 272.05,57.35 ; D107.B15 270.98,58.42 ; D107.B15 272.05,59.49 ; D112.A3 272.05,397.31 ; D112.A3 273.12,396.24 ; D112.A3 272.05,395.17 ; D112.A3 270.98,396.24 ; 44.92,73.66 D118.A13 ; D118.A13 45.99,74.73 ; D118.A13 47.06,73.66 ; D118.A13 45.99,72.59 ; 110.96,40.64 D124.B10 ; D124.B10 113.1,40.64 ; D124.B10 112.03,41.71 ; D124.B10 112.03,39.57 ; 254.27,326.59 D109.B10 ; D109.B10 255.34,327.66 ; D109.B10 254.27,328.73 ; D109.B10 253.2,327.66 ; 119.65,92.91 D121.A13 ; D121.A13 118.58,93.98 ; D121.A13 119.65,95.05 ; D121.A13 120.72,93.98 ; 98.26,396.24 D228.A13 ; D228.A13 99.33,397.31 ; D228.A13 100.4,396.24 ; D228.A13 99.33,395.17 ; 253.2,96.52 D105.A8 ; D105.A8 254.27,97.59 ; D105.A8 255.34,96.52 ; D105.A8 254.27,95.45 ; 170.45,59.89 D103.B4 ; D103.B4 170.45,62.03 ; D103.B4 171.52,60.96 ; D103.B4 169.38,60.96 ; D101.A5 172.99,95.05 ; D101.A5 174.06,93.98 ; D101.A5 171.92,93.98 ; D101.A5 172.99,92.91 ; 16.07,351.79 UHC230.G4 ; UHC230.G4 16.88,350.98 ; UHC230.G4 17.69,351.79 ; UHC230.G4 16.88,352.6 ; D107.B13 266.97,59.49 ; D107.B13 265.9,58.42 ; D107.B13 268.04,58.42 ; D107.B13 266.97,57.35 ; 239.03,326.59 D109.B16 ; D109.B16 240.1,327.66 ; D109.B16 237.96,327.66 ; D109.B16 239.03,328.73 ; 244.11,39.57 D108.B4 ; D108.B4 244.11,41.71 ; D108.B4 243.04,40.64 ; D108.B4 245.18,40.64 ; DPS3.C05 99.33,20.12 ; DPS3.C05 100.4,19.05 ; DPS3.C05 98.26,19.05 ; DPS3.C05 99.33,17.98 ; D121.B5 99.33,100.13 ; D121.B5 98.26,99.06 ; D121.B5 99.33,97.99 ; D121.B5 100.4,99.06 ; D427.A15 94.25,387.15 ; D427.A15 93.18,386.08 ; D427.A15 95.32,386.08 ; D427.A15 94.25,385.01 ; UHC230.G4_4 18.03,354.35 ; UHC230.G4_4 18.03,352.73 ; UHC230.G4_4 18.84,353.54 ; UHC230.G4_4 17.22,353.54 ; 23.13,54.81 D119.A4 ; D119.A4 23.13,56.95 ; D119.A4 22.06,55.88 ; D119.A4 24.2,55.88 ; D107.B6 250.26,60.96 ; D107.B6 248.12,60.96 ; D107.B6 249.19,62.03 ; D107.B6 249.19,59.89 ; DPS3.B01 90.24,16.51 ; DPS3.B01 89.17,15.44 ; DPS3.B01 88.1,16.51 ; DPS3.B01 89.17,17.58 ; 27.14,60.96 D119.B6 ; D119.B6 29.28,60.96 ; D119.B6 28.21,59.89 ; D119.B6 28.21,62.03 ; 24.6,73.66 D118.A5 ; D118.A5 25.67,74.73 ; D118.A5 25.67,72.59 ; D118.A5 26.74,73.66 ; 52.54,81.28 D118.B16 ; D118.B16 53.61,80.21 ; D118.B16 53.61,82.35 ; D118.B16 54.68,81.28 ; D110.A13 247.72,355.6 ; D110.A13 246.65,354.53 ; D110.A13 245.58,355.6 ; D110.A13 246.65,356.67 ; 48.53,367.23 D231.B4 ; D231.B4 49.6,368.3 ; D231.B4 48.53,369.37 ; D231.B4 47.46,368.3 ; 44.92,381 D431.B5 ; D431.B5 45.99,379.93 ; D431.B5 45.99,382.07 ; D431.B5 47.06,381 ; 126.2,373.38 D227.A2 ; D227.A2 127.27,374.45 ; D227.A2 128.34,373.38 ; D227.A2 127.27,372.31 ; 190.77,80.21 D102.B12 ; D102.B12 190.77,82.35 ; D102.B12 191.84,81.28 ; D102.B12 189.7,81.28 ; 24.6,38.1 D120.B5 ; D120.B5 25.67,37.03 ; D120.B5 26.74,38.1 ; D120.B5 25.67,39.17 ; 194.78,96.52 D101.A14 ; D101.A14 195.85,95.45 ; D101.A14 196.92,96.52 ; D101.A14 195.85,97.59 ; 50,396.24 D232.A3 ; D232.A3 51.07,397.31 ; D232.A3 52.14,396.24 ; D232.A3 51.07,395.17 ; 103.34,406.4 D428.A11 ; D428.A11 104.41,405.33 ; D428.A11 105.48,406.4 ; D428.A11 104.41,407.47 ; 44.92,375.92 D231.A5 ; D231.A5 45.99,374.85 ; D231.A5 45.99,376.99 ; D231.A5 47.06,375.92 ; D232.A17 16.58,396.24 ; D232.A17 15.51,397.31 ; D232.A17 14.44,396.24 ; D232.A17 15.51,395.17 ; 122.19,80.21 D122.B14 ; D122.B14 122.19,82.35 ; D122.B14 121.12,81.28 ; D122.B14 123.26,81.28 ; 38.37,59.89 D119.B10 ; D119.B10 38.37,62.03 ; D119.B10 39.44,60.96 ; D119.B10 37.3,60.96 ; 33.29,54.81 D119.A8 ; D119.A8 32.22,55.88 ; D119.A8 33.29,56.95 ; D119.A8 34.36,55.88 ; 16.88,347.48 UHC230.G4_12 ; UHC230.G4_12 17.69,348.29 ; UHC230.G4_12 16.07,348.29 ; UHC230.G4_12 16.88,349.1 ; D111.B10 254.27,369.37 ; D111.B10 253.2,368.3 ; D111.B10 255.34,368.3 ; D111.B10 254.27,367.23 ; D112.A15 241.57,397.31 ; D112.A15 242.64,396.24 ; D112.A15 240.5,396.24 ; D112.A15 241.57,395.17 ; D122.A13 120.72,73.66 ; D122.A13 118.58,73.66 ; D122.A13 119.65,72.59 ; D122.A13 119.65,74.73 ; D431.A10 34.36,383.54 ; D431.A10 33.29,384.61 ; D431.A10 33.29,382.47 ; D431.A10 32.22,383.54 ; CSDPS425.B6 118.18,342.9 ; CSDPS425.B6 116.04,342.9 ; CSDPS425.B6 117.11,343.97 ; CSDPS425.B6 117.11,341.83 ; D111.B4 270.58,368.3 ; D111.B4 268.44,368.3 ; D111.B4 269.51,369.37 ; D111.B4 269.51,367.23 ; D117.A11 41.98,93.98 ; D117.A11 40.91,92.91 ; D117.A11 39.84,93.98 ; D117.A11 40.91,95.05 ; 42.38,101.6 D117.B12 ; D117.B12 43.45,100.53 ; D117.B12 43.45,102.67 ; D117.B12 44.52,101.6 ; 30.75,400.25 D432.B11 ; D432.B11 30.75,402.39 ; D432.B11 31.82,401.32 ; D432.B11 29.68,401.32 ; 164.3,35.56 D104.A2 ; D104.A2 165.37,34.49 ; D104.A2 165.37,36.63 ; D104.A2 166.44,35.56 ; D111.A15 242.64,375.92 ; D111.A15 241.57,374.85 ; D111.A15 241.57,376.99 ; D111.A15 240.5,375.92 ; D106.B13 266.97,79.81 ; D106.B13 266.97,77.67 ; D106.B13 268.04,78.74 ; D106.B13 265.9,78.74 ; 19.52,340.36 CSDPS429.C15 ; CSDPS429.C15 20.59,339.29 ; CSDPS429.C15 21.66,340.36 ; CSDPS429.C15 20.59,341.43 ; D113.A8 186.76,332.74 ; D113.A8 185.69,331.67 ; D113.A8 185.69,333.81 ; D113.A8 184.62,332.74 ; D122.B13 120.72,78.74 ; D122.B13 119.65,79.81 ; D122.B13 119.65,77.67 ; D122.B13 118.58,78.74 ; D107.B9 257.88,58.42 ; D107.B9 256.81,59.49 ; D107.B9 256.81,57.35 ; D107.B9 255.74,58.42 ; 39.84,381 D431.B7 ; D431.B7 40.91,379.93 ; D431.B7 41.98,381 ; D431.B7 40.91,382.07 ; 43.57,365.45 UHC430.G2_3 ; UHC430.G2_3 44.38,366.26 ; UHC430.G2_3 44.38,364.64 ; UHC430.G2_3 45.19,365.45 ; 38.37,100.53 D117.B10 ; D117.B10 39.44,101.6 ; D117.B10 37.3,101.6 ; D117.B10 38.37,102.67 ; DPS8.C05 47.06,410.21 ; DPS8.C05 45.99,409.14 ; DPS8.C05 45.99,411.28 ; DPS8.C05 44.92,410.21 ; D104.A5 172.99,34.09 ; D104.A5 171.92,33.02 ; D104.A5 172.99,31.95 ; D104.A5 174.06,33.02 ; D121.B11 114.57,100.13 ; D121.B11 114.57,97.99 ; D121.B11 115.64,99.06 ; D121.B11 113.5,99.06 ; D108.B9 256.81,39.17 ; D108.B9 257.88,38.1 ; D108.B9 255.74,38.1 ; D108.B9 256.81,37.03 ; D120.B16 54.68,40.64 ; D120.B16 53.61,39.57 ; D120.B16 53.61,41.71 ; D120.B16 52.54,40.64 ; D109.A1 278.2,335.28 ; D109.A1 276.06,335.28 ; D109.A1 277.13,336.35 ; D109.A1 277.13,334.21 ; D108.B8 255.34,40.64 ; D108.B8 254.27,41.71 ; D108.B8 253.2,40.64 ; D108.B8 254.27,39.57 ; 197.32,375.92 D115.A3 ; D115.A3 198.39,376.99 ; D115.A3 199.46,375.92 ; D115.A3 198.39,374.85 ; 16.07,361.95 UHC430.G1 ; UHC430.G1 16.88,362.76 ; UHC430.G1 16.88,361.14 ; UHC430.G1 17.69,361.95 ; D431.A12 28.21,384.61 ; D431.A12 29.28,383.54 ; D431.A12 27.14,383.54 ; D431.A12 28.21,382.47 ; 182.08,38.1 D104.B9 ; D104.B9 183.15,37.03 ; D104.B9 183.15,39.17 ; D104.B9 184.22,38.1 ; 104.41,400.25 D428.B11 ; D428.B11 104.41,402.39 ; D428.B11 105.48,401.32 ; D428.B11 103.34,401.32 ; CSDPS226.C13 99.33,351.59 ; CSDPS226.C13 99.33,349.45 ; CSDPS226.C13 100.4,350.52 ; CSDPS226.C13 98.26,350.52 ; 256.81,31.95 D108.A9 ; D108.A9 255.74,33.02 ; D108.A9 256.81,34.09 ; D108.A9 257.88,33.02 ; 29.68,386.08 D431.A11 ; D431.A11 30.75,387.15 ; D431.A11 31.82,386.08 ; D431.A11 30.75,385.01 ; CSDPS425.C15 95.32,340.36 ; CSDPS425.C15 94.25,339.29 ; CSDPS425.C15 94.25,341.43 ; CSDPS425.C15 93.18,340.36 ; 94.25,390.09 D228.B15 ; D228.B15 93.18,391.16 ; D228.B15 95.32,391.16 ; D228.B15 94.25,392.23 ; D105.A12 265.5,96.52 ; D105.A12 264.43,97.59 ; D105.A12 263.36,96.52 ; D105.A12 264.43,95.45 ; 116.04,388.62 D228.B6 ; D228.B6 117.11,389.69 ; D228.B6 117.11,387.55 ; D228.B6 118.18,388.62 ; CSDPS426.B8 112.03,364.29 ; CSDPS426.B8 110.96,363.22 ; CSDPS426.B8 113.1,363.22 ; CSDPS426.B8 112.03,362.15 ; 108.42,58.42 D123.B9 ; D123.B9 109.49,59.49 ; D123.B9 109.49,57.35 ; D123.B9 110.56,58.42 ; 165.37,75.13 D102.A2 ; D102.A2 165.37,77.27 ; D102.A2 164.3,76.2 ; D102.A2 166.44,76.2 ; 245.58,58.42 D107.B5 ; D107.B5 246.65,59.49 ; D107.B5 247.72,58.42 ; D107.B5 246.65,57.35 ; CSDPS225.B4 122.19,333.81 ; CSDPS225.B4 122.19,331.67 ; CSDPS225.B4 121.12,332.74 ; CSDPS225.B4 123.26,332.74 ; D110.A11 251.73,356.67 ; D110.A11 251.73,354.53 ; D110.A11 252.8,355.6 ; D110.A11 250.66,355.6 ; D231.A9 36.9,375.92 ; D231.A9 34.76,375.92 ; D231.A9 35.83,376.99 ; D231.A9 35.83,374.85 ; D227.B8 113.1,368.3 ; D227.B8 110.96,368.3 ; D227.B8 112.03,369.37 ; D227.B8 112.03,367.23 ; D122.B7 105.48,78.74 ; D122.B7 104.41,79.81 ; D122.B7 103.34,78.74 ; D122.B7 104.41,77.67 ; 39.54,149.1 KS3.7 ; KS3.7 41.77,149.1 ; KS3.7 40.66,150.22 ; KS3.7 40.66,147.98 ; 187.16,350.52 D114.B7 ; D114.B7 188.23,349.45 ; D114.B7 188.23,351.59 ; D114.B7 189.3,350.52 ; UHC430.G2_9 47.83,361.01 ; UHC430.G2_9 47.02,360.2 ; UHC430.G2_9 47.83,359.39 ; UHC430.G2_9 48.64,360.2 ; D227.B1 130.88,370.84 ; D227.B1 129.81,371.91 ; D227.B1 129.81,369.77 ; D227.B1 128.74,370.84 ; 166.84,330.2 D113.B15 ; D113.B15 167.91,331.27 ; D113.B15 167.91,329.13 ; D113.B15 168.98,330.2 ; 96.79,362.15 CSDPS426.B14 ; CSDPS426.B14 97.86,363.22 ; CSDPS426.B14 96.79,364.29 ; CSDPS426.B14 95.72,363.22 ; 35.83,57.35 D119.B9 ; D119.B9 34.76,58.42 ; D119.B9 35.83,59.49 ; D119.B9 36.9,58.42 ; D112.B14 244.11,389.69 ; D112.B14 245.18,388.62 ; D112.B14 243.04,388.62 ; D112.B14 244.11,387.55 ; 24.6,340.36 CSDPS429.C13 ; CSDPS429.C13 25.67,339.29 ; CSDPS429.C13 25.67,341.43 ; CSDPS429.C13 26.74,340.36 ; 19.52,406.4 D432.A15 ; D432.A15 20.59,405.33 ; D432.A15 20.59,407.47 ; D432.A15 21.66,406.4 ; 235.42,58.42 D107.B1 ; D107.B1 236.49,57.35 ; D107.B1 237.56,58.42 ; D107.B1 236.49,59.49 ; CSDPS225.B6 117.11,333.81 ; CSDPS225.B6 116.04,332.74 ; CSDPS225.B6 117.11,331.67 ; CSDPS225.B6 118.18,332.74 ; 22.06,368.3 D231.B14 ; D231.B14 23.13,367.23 ; D231.B14 24.2,368.3 ; D231.B14 23.13,369.37 ; D428.B1 130.88,401.32 ; D428.B1 129.81,400.25 ; D428.B1 129.81,402.39 ; D428.B1 128.74,401.32 ; 113.5,386.08 D427.A7 ; D427.A7 114.57,387.15 ; D427.A7 114.57,385.01 ; D427.A7 115.64,386.08 ; 40.91,395.17 D232.A7 ; D232.A7 41.98,396.24 ; D232.A7 39.84,396.24 ; D232.A7 40.91,397.31 ; 264.43,367.23 D111.B6 ; D111.B6 263.36,368.3 ; D111.B6 265.5,368.3 ; D111.B6 264.43,369.37 ; 101.87,331.67 CSDPS225.B12 ; CSDPS225.B12 102.94,332.74 ; CSDPS225.B12 101.87,333.81 ; CSDPS225.B12 100.8,332.74 ; 14.58,350.98 UHC230.G4_8 ; UHC230.G4_8 14.58,352.6 ; UHC230.G4_8 13.77,351.79 ; UHC230.G4_8 15.39,351.79 ; DPS1.B05 246.65,17.58 ; DPS1.B05 247.72,16.51 ; DPS1.B05 246.65,15.44 ; DPS1.B05 245.58,16.51 ; 187.16,33.02 D104.A11 ; D104.A11 189.3,33.02 ; D104.A11 188.23,31.95 ; D104.A11 188.23,34.09 ; 121.12,398.78 D428.B4 ; D428.B4 123.26,398.78 ; D428.B4 122.19,399.85 ; D428.B4 122.19,397.71 ; 248.12,393.7 D112.A12 ; D112.A12 250.26,393.7 ; D112.A12 249.19,392.63 ; D112.A12 249.19,394.77 ; D228.B11 105.48,391.16 ; D228.B11 104.41,390.09 ; D228.B11 104.41,392.23 ; D228.B11 103.34,391.16 ; 110.96,388.62 D228.B8 ; D228.B8 112.03,389.69 ; D228.B8 113.1,388.62 ; D228.B8 112.03,387.55 ; 192.24,350.52 D114.B5 ; D114.B5 193.31,349.45 ; D114.B5 193.31,351.59 ; D114.B5 194.38,350.52 ; 22.06,96.52 D117.A4 ; D117.A4 23.13,97.59 ; D117.A4 24.2,96.52 ; D117.A4 23.13,95.45 ; 258.28,40.64 D108.B10 ; D108.B10 259.35,41.71 ; D108.B10 260.42,40.64 ; D108.B10 259.35,39.57 ; D102.A13 193.31,74.73 ; D102.A13 194.38,73.66 ; D102.A13 192.24,73.66 ; D102.A13 193.31,72.59 ; D119.B11 41.98,58.42 ; D119.B11 39.84,58.42 ; D119.B11 40.91,59.49 ; D119.B11 40.91,57.35 ; 162.83,97.99 D101.B1 ; D101.B1 162.83,100.13 ; D101.B1 161.76,99.06 ; D101.B1 163.9,99.06 ; 99.33,390.09 D228.B13 ; D228.B13 98.26,391.16 ; D228.B13 100.4,391.16 ; D228.B13 99.33,392.23 ; 104.41,374.85 D227.A11 ; D227.A11 103.34,375.92 ; D227.A11 104.41,376.99 ; D227.A11 105.48,375.92 ; D102.A5 174.06,73.66 ; D102.A5 172.99,74.73 ; D102.A5 172.99,72.59 ; D102.A5 171.92,73.66 ; D101.A9 184.22,93.98 ; D101.A9 183.15,95.05 ; D101.A9 183.15,92.91 ; D101.A9 182.08,93.98 ; 244.11,351.99 D110.A14 ; D110.A14 243.04,353.06 ; D110.A14 244.11,354.13 ; D110.A14 245.18,353.06 ; 50,73.66 D118.A15 ; D118.A15 51.07,72.59 ; D118.A15 52.14,73.66 ; D118.A15 51.07,74.73 ; D117.B2 19.12,101.6 ; D117.B2 18.05,100.53 ; D117.B2 16.98,101.6 ; D117.B2 18.05,102.67 ; D428.A9 110.56,406.4 ; D428.A9 109.49,405.33 ; D428.A9 109.49,407.47 ; D428.A9 108.42,406.4 ; 248.12,40.64 D108.B6 ; D108.B6 249.19,39.57 ; D108.B6 249.19,41.71 ; D108.B6 250.26,40.64 ; 265.9,375.92 D111.A5 ; D111.A5 268.04,375.92 ; D111.A5 266.97,374.85 ; D111.A5 266.97,376.99 ; D115.B12 175.53,369.37 ; D115.B12 174.46,368.3 ; D115.B12 175.53,367.23 ; D115.B12 176.6,368.3 ; 203.47,334.21 D113.A1 ; D113.A1 203.47,336.35 ; D113.A1 204.54,335.28 ; D113.A1 202.4,335.28 ; D120.A1 16.58,33.02 ; D120.A1 15.51,31.95 ; D120.A1 14.44,33.02 ; D120.A1 15.51,34.09 ; D228.B9 110.56,391.16 ; D228.B9 109.49,390.09 ; D228.B9 109.49,392.23 ; D228.B9 108.42,391.16 ; D106.B4 244.11,82.35 ; D106.B4 243.04,81.28 ; D106.B4 245.18,81.28 ; D106.B4 244.11,80.21 ; SB15.1 31.4,416.93 30.75,416.28 DPS8.A11 ; 193.31,354.53 D114.A5 ; D114.A5 193.31,356.67 ; D114.A5 192.24,355.6 ; D114.A5 194.38,355.6 ; 101.87,382.47 D427.A12 ; D427.A12 100.8,383.54 ; D427.A12 102.94,383.54 ; D427.A12 101.87,384.61 ; D232.B5 45.99,392.23 ; D232.B5 44.92,391.16 ; D232.B5 45.99,390.09 ; D232.B5 47.06,391.16 ; D228.B7 115.64,391.16 ; D228.B7 114.57,392.23 ; D228.B7 114.57,390.09 ; D228.B7 113.5,391.16 ; 253.2,76.2 D106.A8 ; D106.A8 254.27,77.27 ; D106.A8 254.27,75.13 ; D106.A8 255.34,76.2 ; 104.41,349.45 CSDPS226.C11 ; CSDPS226.C11 105.48,350.52 ; CSDPS226.C11 104.41,351.59 ; CSDPS226.C11 103.34,350.52 ; D123.A1 89.17,54.41 ; D123.A1 90.24,53.34 ; D123.A1 89.17,52.27 ; D123.A1 88.1,53.34 ; D107.A15 273.12,53.34 ; D107.A15 270.98,53.34 ; D107.A15 272.05,52.27 ; D107.A15 272.05,54.41 ; D114.A4 196.92,353.06 ; D114.A4 195.85,351.99 ; D114.A4 195.85,354.13 ; D114.A4 194.78,353.06 ; D117.B13 45.99,100.13 ; D117.B13 45.99,97.99 ; D117.B13 47.06,99.06 ; D117.B13 44.92,99.06 ; 197.32,350.52 D114.B3 ; D114.B3 199.46,350.52 ; D114.B3 198.39,351.59 ; D114.B3 198.39,349.45 ; 42.38,373.38 D231.A6 ; D231.A6 44.52,373.38 ; D231.A6 43.45,372.31 ; D231.A6 43.45,374.45 ; 96.79,377.39 D427.B14 ; D427.B14 95.72,378.46 ; D427.B14 97.86,378.46 ; D427.B14 96.79,379.53 ; D106.A16 275.66,76.2 ; D106.A16 274.59,75.13 ; D106.A16 273.52,76.2 ; D106.A16 274.59,77.27 ; 194.78,81.28 D102.B14 ; D102.B14 196.92,81.28 ; D102.B14 195.85,82.35 ; D102.B14 195.85,80.21 ; D103.A6 175.53,56.95 ; D103.A6 174.46,55.88 ; D103.A6 176.6,55.88 ; D103.A6 175.53,54.81 ; 119.65,359.61 CSDPS426.C5 ; CSDPS426.C5 119.65,361.75 ; CSDPS426.C5 118.58,360.68 ; CSDPS426.C5 120.72,360.68 ; 121.12,383.54 D427.A4 ; D427.A4 123.26,383.54 ; D427.A4 122.19,384.61 ; D427.A4 122.19,382.47 ; D114.A8 186.76,353.06 ; D114.A8 185.69,354.13 ; D114.A8 184.62,353.06 ; D114.A8 185.69,351.99 ; D105.A3 241.57,95.05 ; D105.A3 241.57,92.91 ; D105.A3 242.64,93.98 ; D105.A3 240.5,93.98 ; 108.42,33.02 D124.A9 ; D124.A9 110.56,33.02 ; D124.A9 109.49,31.95 ; D124.A9 109.49,34.09 ; 124.73,395.17 D228.A3 ; D228.A3 125.8,396.24 ; D228.A3 123.66,396.24 ; D228.A3 124.73,397.31 ; 91.71,351.99 CSDPS226.B16 ; CSDPS226.B16 92.78,353.06 ; CSDPS226.B16 90.64,353.06 ; CSDPS226.B16 91.71,354.13 ; D110.A15 241.57,356.67 ; D110.A15 242.64,355.6 ; D110.A15 240.5,355.6 ; D110.A15 241.57,354.53 ; D228.A7 115.64,396.24 ; D228.A7 114.57,395.17 ; D228.A7 113.5,396.24 ; D228.A7 114.57,397.31 ; 23.13,100.53 D117.B4 ; D117.B4 24.2,101.6 ; D117.B4 23.13,102.67 ; D117.B4 22.06,101.6 ; D431.B8 38.37,379.53 ; D431.B8 38.37,377.39 ; D431.B8 37.3,378.46 ; D431.B8 39.44,378.46 ; 263.36,347.98 D110.B6 ; D110.B6 265.5,347.98 ; D110.B6 264.43,346.91 ; D110.B6 264.43,349.05 ; 106.95,377.39 D427.B10 ; D427.B10 105.88,378.46 ; D427.B10 108.02,378.46 ; D427.B10 106.95,379.53 ; 127.27,95.45 D121.A16 ; D121.A16 126.2,96.52 ; D121.A16 128.34,96.52 ; D121.A16 127.27,97.59 ; 15.73,349.23 UHC230.G4_10 ; UHC230.G4_10 15.73,350.85 ; UHC230.G4_10 16.54,350.04 ; UHC230.G4_10 14.92,350.04 ; 184.62,373.38 D115.A8 ; D115.A8 186.76,373.38 ; D115.A8 185.69,372.31 ; D115.A8 185.69,374.45 ; 101.87,397.71 D428.B12 ; D428.B12 100.8,398.78 ; D428.B12 101.87,399.85 ; D428.B12 102.94,398.78 ; 116.04,378.46 D427.B6 ; D427.B6 118.18,378.46 ; D427.B6 117.11,379.53 ; D427.B6 117.11,377.39 ; 268.44,353.06 D110.A4 ; D110.A4 270.58,353.06 ; D110.A4 269.51,351.99 ; D110.A4 269.51,354.13 ; D109.B4 269.51,328.73 ; D109.B4 268.44,327.66 ; D109.B4 270.58,327.66 ; D109.B4 269.51,326.59 ; D122.A2 91.71,77.27 ; D122.A2 92.78,76.2 ; D122.A2 90.64,76.2 ; D122.A2 91.71,75.13 ; 244.11,75.13 D106.A4 ; D106.A4 244.11,77.27 ; D106.A4 243.04,76.2 ; D106.A4 245.18,76.2 ; D112.A7 262.96,396.24 ; D112.A7 261.89,397.31 ; D112.A7 261.89,395.17 ; D112.A7 260.82,396.24 ; 119.65,374.85 D227.A5 ; D227.A5 118.58,375.92 ; D227.A5 119.65,376.99 ; D227.A5 120.72,375.92 ; 22.06,40.64 D120.B4 ; D120.B4 23.13,41.71 ; D120.B4 24.2,40.64 ; D120.B4 23.13,39.57 ; 263.36,40.64 D108.B12 ; D108.B12 264.43,39.57 ; D108.B12 264.43,41.71 ; D108.B12 265.5,40.64 ; CSDPS225.B14 96.79,333.81 ; CSDPS225.B14 95.72,332.74 ; CSDPS225.B14 97.86,332.74 ; CSDPS225.B14 96.79,331.67 ; UHC230.G3_5 46.34,353.54 ; UHC230.G3_5 45.53,354.35 ; UHC230.G3_5 45.53,352.73 ; UHC230.G3_5 44.72,353.54 ; D428.A14 96.79,404.93 ; D428.A14 97.86,403.86 ; D428.A14 96.79,402.79 ; D428.A14 95.72,403.86 ; 22.06,383.54 D431.A14 ; D431.A14 23.13,382.47 ; D431.A14 24.2,383.54 ; D431.A14 23.13,384.61 ; 44.92,33.02 D120.A13 ; D120.A13 45.99,31.95 ; D120.A13 45.99,34.09 ; D120.A13 47.06,33.02 ; 183.15,77.67 D102.B9 ; D102.B9 182.08,78.74 ; D102.B9 184.22,78.74 ; D102.B9 183.15,79.81 ; 121.12,393.7 D228.A4 ; D228.A4 122.19,392.63 ; D228.A4 123.26,393.7 ; D228.A4 122.19,394.77 ; D108.A6 250.26,35.56 ; D108.A6 249.19,36.63 ; D108.A6 249.19,34.49 ; D108.A6 248.12,35.56 ; D227.A16 92.78,373.38 ; D227.A16 91.71,374.45 ; D227.A16 90.64,373.38 ; D227.A16 91.71,372.31 ; D107.A7 251.73,54.41 ; D107.A7 250.66,53.34 ; D107.A7 252.8,53.34 ; D107.A7 251.73,52.27 ; D119.A11 40.91,54.41 ; D119.A11 40.91,52.27 ; D119.A11 39.84,53.34 ; D119.A11 41.98,53.34 ; 16.88,364.64 UHC430.G1_2 ; UHC430.G1_2 16.88,366.26 ; UHC430.G1_2 16.07,365.45 ; UHC430.G1_2 17.69,365.45 ; D431.A8 39.44,383.54 ; D431.A8 38.37,382.47 ; D431.A8 38.37,384.61 ; D431.A8 37.3,383.54 ; D103.A16 202,55.88 ; D103.A16 200.93,56.95 ; D103.A16 199.86,55.88 ; D103.A16 200.93,54.81 ; 55.08,410.21 DPS8.C01 ; DPS8.C01 56.15,411.28 ; DPS8.C01 56.15,409.14 ; DPS8.C01 57.22,410.21 ; D428.A8 113.1,403.86 ; D428.A8 112.03,404.93 ; D428.A8 112.03,402.79 ; D428.A8 110.96,403.86 ; D231.A11 31.82,375.92 ; D231.A11 29.68,375.92 ; D231.A11 30.75,374.85 ; D231.A11 30.75,376.99 ; D118.A6 29.28,76.2 ; D118.A6 27.14,76.2 ; D118.A6 28.21,75.13 ; D118.A6 28.21,77.27 ; CSDPS225.B2 127.27,333.81 ; CSDPS225.B2 127.27,331.67 ; CSDPS225.B2 126.2,332.74 ; CSDPS225.B2 128.34,332.74 ; D108.A7 252.8,33.02 ; D108.A7 251.73,34.09 ; D108.A7 250.66,33.02 ; D108.A7 251.73,31.95 ; D109.A3 273.12,335.28 ; D109.A3 272.05,334.21 ; D109.A3 272.05,336.35 ; D109.A3 270.98,335.28 ; D110.B9 256.81,351.59 ; D110.B9 256.81,349.45 ; D110.B9 255.74,350.52 ; D110.B9 257.88,350.52 ; D232.A15 21.66,396.24 ; D232.A15 20.59,397.31 ; D232.A15 20.59,395.17 ; D232.A15 19.52,396.24 ; CSDPS426.C15 95.32,360.68 ; CSDPS426.C15 94.25,361.75 ; CSDPS426.C15 93.18,360.68 ; CSDPS426.C15 94.25,359.61 ; 182.08,355.6 D114.A9 ; D114.A9 183.15,356.67 ; D114.A9 183.15,354.53 ; D114.A9 184.22,355.6 ; D428.B16 91.71,399.85 ; D428.B16 92.78,398.78 ; D428.B16 90.64,398.78 ; D428.B16 91.71,397.71 ; D102.A11 189.3,73.66 ; D102.A11 188.23,74.73 ; D102.A11 187.16,73.66 ; D102.A11 188.23,72.59 ; 241.57,77.67 D106.B3 ; D106.B3 241.57,79.81 ; D106.B3 240.5,78.74 ; D106.B3 242.64,78.74 ; D115.B14 171.52,368.3 ; D115.B14 170.45,369.37 ; D115.B14 169.38,368.3 ; D115.B14 170.45,367.23 ; D123.B4 97.86,60.96 ; D123.B4 96.79,62.03 ; D123.B4 95.72,60.96 ; D123.B4 96.79,59.89 ; 256.81,354.53 D110.A9 ; D110.A9 257.88,355.6 ; D110.A9 255.74,355.6 ; D110.A9 256.81,356.67 ; D431.A2 53.61,384.61 ; D431.A2 54.68,383.54 ; D431.A2 53.61,382.47 ; D431.A2 52.54,383.54 ; 98.26,406.4 D428.A13 ; D428.A13 99.33,407.47 ; D428.A13 100.4,406.4 ; D428.A13 99.33,405.33 ; D108.B13 268.04,38.1 ; D108.B13 266.97,39.17 ; D108.B13 266.97,37.03 ; D108.B13 265.9,38.1 ; 261.89,369.77 D111.B7 ; D111.B7 260.82,370.84 ; D111.B7 261.89,371.91 ; D111.B7 262.96,370.84 ; DPS1.A15 272.05,15.04 ; DPS1.A15 273.12,13.97 ; DPS1.A15 272.05,12.9 ; DPS1.A15 270.98,13.97 ; D111.B13 247.72,370.84 ; D111.B13 245.58,370.84 ; D111.B13 246.65,369.77 ; D111.B13 246.65,371.91 ; 258.28,81.28 D106.B10 ; D106.B10 259.35,82.35 ; D106.B10 259.35,80.21 ; D106.B10 260.42,81.28 ; D124.B3 94.25,39.17 ; D124.B3 94.25,37.03 ; D124.B3 93.18,38.1 ; D124.B3 95.32,38.1 ; D103.A1 162.83,54.41 ; D103.A1 163.9,53.34 ; D103.A1 162.83,52.27 ; D103.A1 161.76,53.34 ; 103.34,340.36 CSDPS425.C11 ; CSDPS425.C11 105.48,340.36 ; CSDPS425.C11 104.41,339.29 ; CSDPS425.C11 104.41,341.43 ; KS4.7 40.66,157.84 ; KS4.7 41.77,156.72 ; KS4.7 40.66,155.6 ; KS4.7 39.54,156.72 ; D120.A14 49.6,35.56 ; D120.A14 48.53,36.63 ; D120.A14 48.53,34.49 ; D120.A14 47.46,35.56 ; 51.07,329.13 CSDPS229.C3 ; CSDPS229.C3 50,330.2 ; CSDPS229.C3 51.07,331.27 ; CSDPS229.C3 52.14,330.2 ; 99.33,77.67 D122.B5 ; D122.B5 100.4,78.74 ; D122.B5 99.33,79.81 ; D122.B5 98.26,78.74 ; 105.88,368.3 D227.B10 ; D227.B10 106.95,367.23 ; D227.B10 108.02,368.3 ; D227.B10 106.95,369.37 ; 55.08,370.84 D231.B1 ; D231.B1 57.22,370.84 ; D231.B1 56.15,371.91 ; D231.B1 56.15,369.77 ; 276.06,355.6 D110.A1 ; D110.A1 277.13,356.67 ; D110.A1 278.2,355.6 ; D110.A1 277.13,354.53 ; 248.12,81.28 D106.B6 ; D106.B6 249.19,82.35 ; D106.B6 249.19,80.21 ; D106.B6 250.26,81.28 ; D121.A4 96.79,97.59 ; D121.A4 97.86,96.52 ; D121.A4 95.72,96.52 ; D121.A4 96.79,95.45 ; 108.42,330.2 CSDPS225.C9 ; CSDPS225.C9 109.49,329.13 ; CSDPS225.C9 109.49,331.27 ; CSDPS225.C9 110.56,330.2 ; 91.71,100.53 D121.B2 ; D121.B2 91.71,102.67 ; D121.B2 92.78,101.6 ; D121.B2 90.64,101.6 ; 166.84,370.84 D115.B15 ; D115.B15 167.91,371.91 ; D115.B15 167.91,369.77 ; D115.B15 168.98,370.84 ; 183.15,390.09 D116.B9 ; D116.B9 184.22,391.16 ; D116.B9 182.08,391.16 ; D116.B9 183.15,392.23 ; 202.4,391.16 D116.B1 ; D116.B1 203.47,390.09 ; D116.B1 203.47,392.23 ; D116.B1 204.54,391.16 ; D106.A14 270.58,76.2 ; D106.A14 269.51,75.13 ; D106.A14 269.51,77.27 ; D106.A14 268.44,76.2 ; 119.65,369.77 D227.B5 ; D227.B5 120.72,370.84 ; D227.B5 118.58,370.84 ; D227.B5 119.65,371.91 ; 103.34,381 D427.B11 ; D427.B11 104.41,382.07 ; D427.B11 104.41,379.93 ; D427.B11 105.48,381 ; 23.13,34.49 D120.A4 ; D120.A4 23.13,36.63 ; D120.A4 22.06,35.56 ; D120.A4 24.2,35.56 ; D427.A2 128.34,383.54 ; D427.A2 127.27,384.61 ; D427.A2 127.27,382.47 ; D427.A2 126.2,383.54 ; 40.91,405.33 D432.A7 ; D432.A7 40.91,407.47 ; D432.A7 41.98,406.4 ; D432.A7 39.84,406.4 ; CSDPS426.B4 123.26,363.22 ; CSDPS426.B4 122.19,362.15 ; CSDPS426.B4 122.19,364.29 ; CSDPS426.B4 121.12,363.22 ; 162.83,92.91 D101.A1 ; D101.A1 161.76,93.98 ; D101.A1 163.9,93.98 ; D101.A1 162.83,95.05 ; 108.42,396.24 D228.A9 ; D228.A9 109.49,397.31 ; D228.A9 110.56,396.24 ; D228.A9 109.49,395.17 ; 48.17,355.29 UHC230.G3_1 ; UHC230.G3_1 49.79,355.29 ; UHC230.G3_1 48.98,356.1 ; UHC230.G3_1 48.98,354.48 ; 256.81,92.91 D105.A9 ; D105.A9 255.74,93.98 ; D105.A9 257.88,93.98 ; D105.A9 256.81,95.05 ; D101.B4 171.52,101.6 ; D101.B4 170.45,102.67 ; D101.B4 169.38,101.6 ; D101.B4 170.45,100.53 ; 25.67,369.77 D231.B13 ; D231.B13 26.74,370.84 ; D231.B13 25.67,371.91 ; D231.B13 24.6,370.84 ; 200.93,387.55 D116.B2 ; D116.B2 199.86,388.62 ; D116.B2 202,388.62 ; D116.B2 200.93,389.69 ; D102.B13 193.31,79.81 ; D102.B13 192.24,78.74 ; D102.B13 194.38,78.74 ; D102.B13 193.31,77.67 ; D119.B8 33.29,62.03 ; D119.B8 32.22,60.96 ; D119.B8 33.29,59.89 ; D119.B8 34.36,60.96 ; D227.B15 95.32,370.84 ; D227.B15 93.18,370.84 ; D227.B15 94.25,371.91 ; D227.B15 94.25,369.77 ; 265.9,33.02 D108.A13 ; D108.A13 266.97,34.09 ; D108.A13 266.97,31.95 ; D108.A13 268.04,33.02 ; D427.B1 129.81,382.07 ; D427.B1 128.74,381 ; D427.B1 129.81,379.93 ; D427.B1 130.88,381 ; 185.69,95.45 D101.A10 ; D101.A10 186.76,96.52 ; D101.A10 184.62,96.52 ; D101.A10 185.69,97.59 ; 42.38,388.62 D232.B6 ; D232.B6 43.45,389.69 ; D232.B6 44.52,388.62 ; D232.B6 43.45,387.55 ; D113.A12 175.53,333.81 ; D113.A12 175.53,331.67 ; D113.A12 176.6,332.74 ; D113.A12 174.46,332.74 ; 164.3,40.64 D104.B2 ; D104.B2 165.37,41.71 ; D104.B2 166.44,40.64 ; D104.B2 165.37,39.57 ; 192.24,396.24 D116.A5 ; D116.A5 194.38,396.24 ; D116.A5 193.31,395.17 ; D116.A5 193.31,397.31 ; D123.B13 119.65,59.49 ; D123.B13 120.72,58.42 ; D123.B13 118.58,58.42 ; D123.B13 119.65,57.35 ; D101.A15 198.39,95.05 ; D101.A15 197.32,93.98 ; D101.A15 199.46,93.98 ; D101.A15 198.39,92.91 ; D117.A8 33.29,97.59 ; D117.A8 34.36,96.52 ; D117.A8 33.29,95.45 ; D117.A8 32.22,96.52 ; 245.58,93.98 D105.A5 ; D105.A5 246.65,95.05 ; D105.A5 247.72,93.98 ; D105.A5 246.65,92.91 ; 253.2,347.98 D110.B10 ; D110.B10 254.27,346.91 ; D110.B10 255.34,347.98 ; D110.B10 254.27,349.05 ; D121.B8 106.95,102.67 ; D121.B8 105.88,101.6 ; D121.B8 108.02,101.6 ; D121.B8 106.95,100.53 ; 270.98,391.16 D112.B3 ; D112.B3 272.05,390.09 ; D112.B3 273.12,391.16 ; D112.B3 272.05,392.23 ; 42.38,398.78 D432.B6 ; D432.B6 43.45,397.71 ; D432.B6 44.52,398.78 ; D432.B6 43.45,399.85 ; 269.51,392.63 D112.A4 ; D112.A4 269.51,394.77 ; D112.A4 268.44,393.7 ; D112.A4 270.58,393.7 ; KS3.6 53.36,150.22 ; KS3.6 54.47,149.1 ; KS3.6 53.36,147.98 ; KS3.6 52.24,149.1 ; DPS8.A11 29.68,415.29 ; DPS8.A11 30.75,414.22 ; DPS8.A11 31.82,415.29 ; 24.6,53.34 D119.A5 ; D119.A5 25.67,52.27 ; D119.A5 26.74,53.34 ; D119.A5 25.67,54.41 ; D117.A16 53.61,97.59 ; D117.A16 53.61,95.45 ; D117.A16 52.54,96.52 ; D117.A16 54.68,96.52 ; 122.19,351.99 CSDPS226.B4 ; CSDPS226.B4 122.19,354.13 ; CSDPS226.B4 123.26,353.06 ; CSDPS226.B4 121.12,353.06 ; CSDPS426.C7 114.57,361.75 ; CSDPS426.C7 113.5,360.68 ; CSDPS426.C7 115.64,360.68 ; CSDPS426.C7 114.57,359.61 ; 44.92,38.1 D120.B13 ; D120.B13 47.06,38.1 ; D120.B13 45.99,39.17 ; D120.B13 45.99,37.03 ; D116.B11 178.07,392.23 ; D116.B11 178.07,390.09 ; D116.B11 177,391.16 ; D116.B11 179.14,391.16 ; 32.22,35.56 D120.A8 ; D120.A8 33.29,34.49 ; D120.A8 33.29,36.63 ; D120.A8 34.36,35.56 ; 180.61,392.63 D116.A10 ; D116.A10 181.68,393.7 ; D116.A10 179.54,393.7 ; D116.A10 180.61,394.77 ; 88.1,58.42 D123.B1 ; D123.B1 89.17,59.49 ; D123.B1 90.24,58.42 ; D123.B1 89.17,57.35 ; D109.A8 259.35,333.81 ; D109.A8 258.28,332.74 ; D109.A8 259.35,331.67 ; D109.A8 260.42,332.74 ; 45.87,355.29 UHC230.G3_2 ; UHC230.G3_2 46.68,354.48 ; UHC230.G3_2 46.68,356.1 ; UHC230.G3_2 47.49,355.29 ; D119.A14 48.53,56.95 ; D119.A14 49.6,55.88 ; D119.A14 48.53,54.81 ; D119.A14 47.46,55.88 ; D107.A16 274.59,56.95 ; D107.A16 275.66,55.88 ; D107.A16 273.52,55.88 ; D107.A16 274.59,54.81 ; 249.19,346.91 D110.B12 ; D110.B12 248.12,347.98 ; D110.B12 249.19,349.05 ; D110.B12 250.26,347.98 ; 265.9,93.98 D105.A13 ; D105.A13 266.97,92.91 ; D105.A13 268.04,93.98 ; D105.A13 266.97,95.05 ; D111.A7 261.89,376.99 ; D111.A7 262.96,375.92 ; D111.A7 261.89,374.85 ; D111.A7 260.82,375.92 ; D106.A12 264.43,77.27 ; D106.A12 263.36,76.2 ; D106.A12 265.5,76.2 ; D106.A12 264.43,75.13 ; D108.A12 264.43,36.63 ; D108.A12 263.36,35.56 ; D108.A12 265.5,35.56 ; D108.A12 264.43,34.49 ; 34.76,370.84 D231.B9 ; D231.B9 36.9,370.84 ; D231.B9 35.83,371.91 ; D231.B9 35.83,369.77 ; D232.B3 52.14,391.16 ; D232.B3 50,391.16 ; D232.B3 51.07,392.23 ; D232.B3 51.07,390.09 ; D123.A5 100.4,53.34 ; D123.A5 99.33,52.27 ; D123.A5 99.33,54.41 ; D123.A5 98.26,53.34 ; 166.84,38.1 D104.B3 ; D104.B3 167.91,37.03 ; D104.B3 168.98,38.1 ; D104.B3 167.91,39.17 ; 27.14,398.78 D432.B12 ; D432.B12 29.28,398.78 ; D432.B12 28.21,399.85 ; D432.B12 28.21,397.71 ; 253.2,388.62 D112.B10 ; D112.B10 255.34,388.62 ; D112.B10 254.27,387.55 ; D112.B10 254.27,389.69 ; 180.61,54.81 D103.A8 ; D103.A8 180.61,56.95 ; D103.A8 179.54,55.88 ; D103.A8 181.68,55.88 ; 175.53,75.13 D102.A6 ; D102.A6 175.53,77.27 ; D102.A6 176.6,76.2 ; D102.A6 174.46,76.2 ; D102.B5 172.99,79.81 ; D102.B5 171.92,78.74 ; D102.B5 174.06,78.74 ; D102.B5 172.99,77.67 ; D428.A3 125.8,406.4 ; D428.A3 124.73,405.33 ; D428.A3 123.66,406.4 ; D428.A3 124.73,407.47 ; D113.B5 194.38,330.2 ; D113.B5 192.24,330.2 ; D113.B5 193.31,331.27 ; D113.B5 193.31,329.13 ; 45.99,400.25 D432.B5 ; D432.B5 47.06,401.32 ; D432.B5 45.99,402.39 ; D432.B5 44.92,401.32 ; 42.38,55.88 D119.A12 ; D119.A12 44.52,55.88 ; D119.A12 43.45,56.95 ; D119.A12 43.45,54.81 ; D110.A6 265.5,353.06 ; D110.A6 264.43,351.99 ; D110.A6 264.43,354.13 ; D110.A6 263.36,353.06 ; UHC230.G3_11 48.98,349.1 ; UHC230.G3_11 48.98,347.48 ; UHC230.G3_11 49.79,348.29 ; UHC230.G3_11 48.17,348.29 ; 18.05,75.13 D118.A2 ; D118.A2 16.98,76.2 ; D118.A2 18.05,77.27 ; D118.A2 19.12,76.2 ; D122.B10 112.03,82.35 ; D122.B10 110.96,81.28 ; D122.B10 113.1,81.28 ; D122.B10 112.03,80.21 ; 192.24,412.75 DPS2.B05 ; DPS2.B05 193.31,413.82 ; DPS2.B05 193.31,411.68 ; DPS2.B05 194.38,412.75 ; D109.B2 274.59,328.73 ; D109.B2 273.52,327.66 ; D109.B2 275.66,327.66 ; D109.B2 274.59,326.59 ; D101.B15 198.39,100.13 ; D101.B15 198.39,97.99 ; D101.B15 197.32,99.06 ; D101.B15 199.46,99.06 ; D122.A1 89.17,74.73 ; D122.A1 89.17,72.59 ; D122.A1 90.24,73.66 ; D122.A1 88.1,73.66 ; D121.B13 119.65,100.13 ; D121.B13 120.72,99.06 ; D121.B13 119.65,97.99 ; D121.B13 118.58,99.06 ; D113.A13 174.06,335.28 ; D113.A13 172.99,336.35 ; D113.A13 171.92,335.28 ; D113.A13 172.99,334.21 ; D228.A15 95.32,396.24 ; D228.A15 93.18,396.24 ; D228.A15 94.25,395.17 ; D228.A15 94.25,397.31 ; D428.A17 89.17,407.47 ; D428.A17 90.24,406.4 ; D428.A17 89.17,405.33 ; D428.A17 88.1,406.4 ; D103.A5 172.99,54.41 ; D103.A5 174.06,53.34 ; D103.A5 171.92,53.34 ; D103.A5 172.99,52.27 ; 94.25,329.13 CSDPS225.C15 ; CSDPS225.C15 95.32,330.2 ; CSDPS225.C15 93.18,330.2 ; CSDPS225.C15 94.25,331.27 ; D108.B15 272.05,39.17 ; D108.B15 272.05,37.03 ; D108.B15 273.12,38.1 ; D108.B15 270.98,38.1 ; D124.B9 110.56,38.1 ; D124.B9 109.49,37.03 ; D124.B9 108.42,38.1 ; D124.B9 109.49,39.17 ; 253.2,81.28 D106.B8 ; D106.B8 254.27,82.35 ; D106.B8 254.27,80.21 ; D106.B8 255.34,81.28 ; D431.B16 18.05,379.53 ; D431.B16 19.12,378.46 ; D431.B16 18.05,377.39 ; D431.B16 16.98,378.46 ; D119.B14 49.6,60.96 ; D119.B14 47.46,60.96 ; D119.B14 48.53,59.89 ; D119.B14 48.53,62.03 ; 259.35,372.31 D111.A8 ; D111.A8 259.35,374.45 ; D111.A8 258.28,373.38 ; D111.A8 260.42,373.38 ; 90.64,368.3 D227.B16 ; D227.B16 91.71,369.37 ; D227.B16 91.71,367.23 ; D227.B16 92.78,368.3 ; D103.B8 180.61,62.03 ; D103.B8 181.68,60.96 ; D103.B8 179.54,60.96 ; D103.B8 180.61,59.89 ; D107.B11 262.96,58.42 ; D107.B11 261.89,59.49 ; D107.B11 260.82,58.42 ; D107.B11 261.89,57.35 ; 56.15,400.25 D432.B1 ; D432.B1 57.22,401.32 ; D432.B1 55.08,401.32 ; D432.B1 56.15,402.39 ; D109.B1 277.13,331.27 ; D109.B1 278.2,330.2 ; D109.B1 277.13,329.13 ; D109.B1 276.06,330.2 ; 270.98,375.92 D111.A3 ; D111.A3 272.05,374.85 ; D111.A3 273.12,375.92 ; D111.A3 272.05,376.99 ; 126.2,403.86 D428.A2 ; D428.A2 127.27,404.93 ; D428.A2 127.27,402.79 ; D428.A2 128.34,403.86 ; 253.2,101.6 D105.B8 ; D105.B8 254.27,102.67 ; D105.B8 254.27,100.53 ; D105.B8 255.34,101.6 ; 32.22,332.74 CSDPS229.B10 ; CSDPS229.B10 33.29,331.67 ; CSDPS229.B10 34.36,332.74 ; CSDPS229.B10 33.29,333.81 ; D113.B12 175.53,328.73 ; D113.B12 176.6,327.66 ; D113.B12 174.46,327.66 ; D113.B12 175.53,326.59 ; 114.57,349.45 CSDPS226.C7 ; CSDPS226.C7 114.57,351.59 ; CSDPS226.C7 113.5,350.52 ; CSDPS226.C7 115.64,350.52 ; D107.A5 246.65,54.41 ; D107.A5 246.65,52.27 ; D107.A5 245.58,53.34 ; D107.A5 247.72,53.34 ; 16.98,393.7 D232.A16 ; D232.A16 18.05,392.63 ; D232.A16 18.05,394.77 ; D232.A16 19.12,393.7 ; CSDPS429.C3 52.14,340.36 ; CSDPS429.C3 51.07,341.43 ; CSDPS429.C3 50,340.36 ; CSDPS429.C3 51.07,339.29 ; CSDPS229.B16 18.05,333.81 ; CSDPS229.B16 18.05,331.67 ; CSDPS229.B16 19.12,332.74 ; CSDPS229.B16 16.98,332.74 ; 99.33,329.13 CSDPS225.C13 ; CSDPS225.C13 98.26,330.2 ; CSDPS225.C13 99.33,331.27 ; CSDPS225.C13 100.4,330.2 ; D228.B2 128.34,388.62 ; D228.B2 127.27,387.55 ; D228.B2 126.2,388.62 ; D228.B2 127.27,389.69 ; D227.B7 115.64,370.84 ; D227.B7 114.57,369.77 ; D227.B7 113.5,370.84 ; D227.B7 114.57,371.91 ; 164.3,332.74 D113.A16 ; D113.A16 166.44,332.74 ; D113.A16 165.37,331.67 ; D113.A16 165.37,333.81 ; 47.46,342.9 CSDPS429.B4 ; CSDPS429.B4 48.53,343.97 ; CSDPS429.B4 48.53,341.83 ; CSDPS429.B4 49.6,342.9 ; D427.A11 105.48,386.08 ; D427.A11 103.34,386.08 ; D427.A11 104.41,385.01 ; D427.A11 104.41,387.15 ; CSDPS226.C15 94.25,351.59 ; CSDPS226.C15 93.18,350.52 ; CSDPS226.C15 95.32,350.52 ; CSDPS226.C15 94.25,349.45 ; 110.96,76.2 D122.A10 ; D122.A10 113.1,76.2 ; D122.A10 112.03,77.27 ; D122.A10 112.03,75.13 ; 198.39,354.53 D114.A3 ; D114.A3 199.46,355.6 ; D114.A3 198.39,356.67 ; D114.A3 197.32,355.6 ; CSDPS426.C1 129.81,361.75 ; CSDPS426.C1 130.88,360.68 ; CSDPS426.C1 128.74,360.68 ; CSDPS426.C1 129.81,359.61 ; 25.67,329.13 CSDPS229.C13 ; CSDPS229.C13 24.6,330.2 ; CSDPS229.C13 26.74,330.2 ; CSDPS229.C13 25.67,331.27 ; D231.B5 47.06,370.84 ; D231.B5 44.92,370.84 ; D231.B5 45.99,371.91 ; D231.B5 45.99,369.77 ; 197.32,370.84 D115.B3 ; D115.B3 199.46,370.84 ; D115.B3 198.39,369.77 ; D115.B3 198.39,371.91 ; 197.32,335.28 D113.A3 ; D113.A3 199.46,335.28 ; D113.A3 198.39,334.21 ; D113.A3 198.39,336.35 ; D120.A2 18.05,36.63 ; D120.A2 19.12,35.56 ; D120.A2 18.05,34.49 ; D120.A2 16.98,35.56 ; D111.B14 244.11,369.37 ; D111.B14 245.18,368.3 ; D111.B14 243.04,368.3 ; D111.B14 244.11,367.23 ; D431.A13 26.74,386.08 ; D431.A13 25.67,385.01 ; D431.A13 25.67,387.15 ; D431.A13 24.6,386.08 ; 248.12,373.38 D111.A12 ; D111.A12 249.19,374.45 ; D111.A12 249.19,372.31 ; D111.A12 250.26,373.38 ; D227.A14 96.79,374.45 ; D227.A14 95.72,373.38 ; D227.A14 97.86,373.38 ; D227.A14 96.79,372.31 ; 47.83,362.89 UHC430.G2_4 ; UHC430.G2_4 48.64,363.7 ; UHC430.G2_4 47.83,364.51 ; UHC430.G2_4 47.02,363.7 ; 250.66,350.52 D110.B11 ; D110.B11 252.8,350.52 ; D110.B11 251.73,351.59 ; D110.B11 251.73,349.45 ; D431.B11 31.82,381 ; D431.B11 29.68,381 ; D431.B11 30.75,382.07 ; D431.B11 30.75,379.93 ; 55.08,330.2 CSDPS229.C1 ; CSDPS229.C1 56.15,331.27 ; CSDPS229.C1 56.15,329.13 ; CSDPS229.C1 57.22,330.2 ; 249.19,95.45 D105.A6 ; D105.A6 250.26,96.52 ; D105.A6 249.19,97.59 ; D105.A6 248.12,96.52 ; D111.B1 277.13,371.91 ; D111.B1 278.2,370.84 ; D111.B1 276.06,370.84 ; D111.B1 277.13,369.77 ; 106.95,59.89 D123.B8 ; D123.B8 106.95,62.03 ; D123.B8 108.02,60.96 ; D123.B8 105.88,60.96 ; D110.A12 249.19,354.13 ; D110.A12 249.19,351.99 ; D110.A12 248.12,353.06 ; D110.A12 250.26,353.06 ; D124.A11 115.64,33.02 ; D124.A11 114.57,31.95 ; D124.A11 113.5,33.02 ; D124.A11 114.57,34.09 ; D228.B12 102.94,388.62 ; D228.B12 101.87,389.69 ; D228.B12 101.87,387.55 ; D228.B12 100.8,388.62 ; 99.33,369.77 D227.B13 ; D227.B13 98.26,370.84 ; D227.B13 100.4,370.84 ; D227.B13 99.33,371.91 ; 90.64,35.56 D124.A2 ; D124.A2 92.78,35.56 ; D124.A2 91.71,34.49 ; D124.A2 91.71,36.63 ; CSDPS425.C3 124.73,341.43 ; CSDPS425.C3 124.73,339.29 ; CSDPS425.C3 125.8,340.36 ; CSDPS425.C3 123.66,340.36 ; 195.85,75.13 D102.A14 ; D102.A14 196.92,76.2 ; D102.A14 195.85,77.27 ; D102.A14 194.78,76.2 ; 48.53,100.53 D117.B14 ; D117.B14 49.6,101.6 ; D117.B14 48.53,102.67 ; D117.B14 47.46,101.6 ; 256.81,52.27 D107.A9 ; D107.A9 255.74,53.34 ; D107.A9 257.88,53.34 ; D107.A9 256.81,54.41 ; 51.07,369.77 D231.B3 ; D231.B3 50,370.84 ; D231.B3 52.14,370.84 ; D231.B3 51.07,371.91 ; 268.44,81.28 D106.B14 ; D106.B14 270.58,81.28 ; D106.B14 269.51,80.21 ; D106.B14 269.51,82.35 ; D104.B11 188.23,39.17 ; D104.B11 187.16,38.1 ; D104.B11 189.3,38.1 ; D104.B11 188.23,37.03 ; 172.99,395.17 D116.A13 ; D116.A13 172.99,397.31 ; D116.A13 171.92,396.24 ; D116.A13 174.06,396.24 ; 194.78,347.98 D114.B4 ; D114.B4 195.85,349.05 ; D114.B4 196.92,347.98 ; D114.B4 195.85,346.91 ; 167.91,92.91 D101.A3 ; D101.A3 167.91,95.05 ; D101.A3 166.84,93.98 ; D101.A3 168.98,93.98 ; 93.18,406.4 D428.A15 ; D428.A15 94.25,407.47 ; D428.A15 94.25,405.33 ; D428.A15 95.32,406.4 ; D116.B13 172.99,392.23 ; D116.B13 172.99,390.09 ; D116.B13 174.06,391.16 ; D116.B13 171.92,391.16 ; D112.B13 246.65,392.23 ; D112.B13 247.72,391.16 ; D112.B13 245.58,391.16 ; D112.B13 246.65,390.09 ; D103.B1 163.9,58.42 ; D103.B1 162.83,59.49 ; D103.B1 161.76,58.42 ; D103.B1 162.83,57.35 ; 39.84,375.92 D231.A7 ; D231.A7 40.91,374.85 ; D231.A7 40.91,376.99 ; D231.A7 41.98,375.92 ; UHC430.G2_11 48.98,359.26 ; UHC430.G2_11 48.98,357.64 ; UHC430.G2_11 48.17,358.45 ; UHC430.G2_11 49.79,358.45 ; D428.B2 127.27,399.85 ; D428.B2 128.34,398.78 ; D428.B2 127.27,397.71 ; D428.B2 126.2,398.78 ; 93.18,381 D427.B15 ; D427.B15 94.25,379.93 ; D427.B15 95.32,381 ; D427.B15 94.25,382.07 ; D104.A3 167.91,34.09 ; D104.A3 166.84,33.02 ; D104.A3 167.91,31.95 ; D104.A3 168.98,33.02 ; 47.46,388.62 D232.B4 ; D232.B4 49.6,388.62 ; D232.B4 48.53,387.55 ; D232.B4 48.53,389.69 ; 33.29,100.53 D117.B8 ; D117.B8 33.29,102.67 ; D117.B8 32.22,101.6 ; D117.B8 34.36,101.6 ; 19.52,78.74 D118.B3 ; D118.B3 20.59,77.67 ; D118.B3 21.66,78.74 ; D118.B3 20.59,79.81 ; 175.53,392.63 D116.A12 ; D116.A12 174.46,393.7 ; D116.A12 176.6,393.7 ; D116.A12 175.53,394.77 ; DPS1.A05 246.65,15.04 ; DPS1.A05 247.72,13.97 ; DPS1.A05 245.58,13.97 ; DPS1.A05 246.65,12.9 ; 188.23,395.17 D116.A7 ; D116.A7 188.23,397.31 ; D116.A7 187.16,396.24 ; D116.A7 189.3,396.24 ; 237.96,353.06 D110.A16 ; D110.A16 239.03,354.13 ; D110.A16 240.1,353.06 ; D110.A16 239.03,351.99 ; 100.8,363.22 CSDPS426.B12 ; CSDPS426.B12 101.87,362.15 ; CSDPS426.B12 102.94,363.22 ; CSDPS426.B12 101.87,364.29 ; 162.83,72.59 D102.A1 ; D102.A1 163.9,73.66 ; D102.A1 161.76,73.66 ; D102.A1 162.83,74.73 ; CSDPS225.B10 106.95,333.81 ; CSDPS225.B10 105.88,332.74 ; CSDPS225.B10 108.02,332.74 ; CSDPS225.B10 106.95,331.67 ; 161.76,38.1 D104.B1 ; D104.B1 162.83,37.03 ; D104.B1 163.9,38.1 ; D104.B1 162.83,39.17 ; D103.B6 176.6,60.96 ; D103.B6 174.46,60.96 ; D103.B6 175.53,59.89 ; D103.B6 175.53,62.03 ; D110.A2 274.59,354.13 ; D110.A2 273.52,353.06 ; D110.A2 274.59,351.99 ; D110.A2 275.66,353.06 ; D113.B7 189.3,330.2 ; D113.B7 188.23,329.13 ; D113.B7 188.23,331.27 ; D113.B7 187.16,330.2 ; D432.B14 24.2,398.78 ; D432.B14 23.13,399.85 ; D432.B14 23.13,397.71 ; D432.B14 22.06,398.78 ; 183.15,369.77 D115.B9 ; D115.B9 183.15,371.91 ; D115.B9 184.22,370.84 ; D115.B9 182.08,370.84 ; D101.A12 190.77,97.59 ; D101.A12 189.7,96.52 ; D101.A12 190.77,95.45 ; D101.A12 191.84,96.52 ; CSDPS229.C11 30.75,331.27 ; CSDPS229.C11 29.68,330.2 ; CSDPS229.C11 30.75,329.13 ; CSDPS229.C11 31.82,330.2 ; D108.B2 239.03,41.71 ; D108.B2 237.96,40.64 ; D108.B2 240.1,40.64 ; D108.B2 239.03,39.57 ; D114.A10 181.68,353.06 ; D114.A10 179.54,353.06 ; D114.A10 180.61,351.99 ; D114.A10 180.61,354.13 ; 195.85,387.55 D116.B4 ; D116.B4 195.85,389.69 ; D116.B4 194.78,388.62 ; D116.B4 196.92,388.62 ; 93.18,401.32 D428.B15 ; D428.B15 95.32,401.32 ; D428.B15 94.25,400.25 ; D428.B15 94.25,402.39 ; D115.B1 204.54,370.84 ; D115.B1 203.47,371.91 ; D115.B1 202.4,370.84 ; D115.B1 203.47,369.77 ; D428.A10 108.02,403.86 ; D428.A10 106.95,404.93 ; D428.A10 105.88,403.86 ; D428.A10 106.95,402.79 ; D122.A11 114.57,74.73 ; D122.A11 114.57,72.59 ; D122.A11 113.5,73.66 ; D122.A11 115.64,73.66 ; 127.27,39.57 D124.B16 ; D124.B16 128.34,40.64 ; D124.B16 126.2,40.64 ; D124.B16 127.27,41.71 ; 253.2,353.06 D110.A10 ; D110.A10 254.27,354.13 ; D110.A10 255.34,353.06 ; D110.A10 254.27,351.99 ; 197.32,33.02 D104.A15 ; D104.A15 198.39,31.95 ; D104.A15 199.46,33.02 ; D104.A15 198.39,34.09 ; D109.B5 266.97,331.27 ; D109.B5 266.97,329.13 ; D109.B5 265.9,330.2 ; D109.B5 268.04,330.2 ; D124.B6 101.87,41.71 ; D124.B6 101.87,39.57 ; D124.B6 102.94,40.64 ; D124.B6 100.8,40.64 ; 170.45,80.21 D102.B4 ; D102.B4 170.45,82.35 ; D102.B4 171.52,81.28 ; D102.B4 169.38,81.28 ; D122.A4 96.79,77.27 ; D122.A4 97.86,76.2 ; D122.A4 96.79,75.13 ; D122.A4 95.72,76.2 ; 46.68,361.14 UHC430.G2 ; UHC430.G2 45.87,361.95 ; UHC430.G2 46.68,362.76 ; UHC430.G2 47.49,361.95 ; 126.2,342.9 CSDPS425.B2 ; CSDPS425.B2 127.27,341.83 ; CSDPS425.B2 128.34,342.9 ; CSDPS425.B2 127.27,343.97 ; 37.3,373.38 D231.A8 ; D231.A8 38.37,372.31 ; D231.A8 38.37,374.45 ; D231.A8 39.44,373.38 ; DPS1.B15 272.05,17.58 ; DPS1.B15 270.98,16.51 ; DPS1.B15 273.12,16.51 ; DPS1.B15 272.05,15.44 ; 43.45,75.13 D118.A12 ; D118.A12 42.38,76.2 ; D118.A12 44.52,76.2 ; D118.A12 43.45,77.27 ; 268.44,55.88 D107.A14 ; D107.A14 270.58,55.88 ; D107.A14 269.51,54.81 ; D107.A14 269.51,56.95 ; 99.33,31.95 D124.A5 ; D124.A5 99.33,34.09 ; D124.A5 98.26,33.02 ; D124.A5 100.4,33.02 ; 199.86,347.98 D114.B2 ; D114.B2 200.93,346.91 ; D114.B2 200.93,349.05 ; D114.B2 202,347.98 ; UHC430.G2_12 47.49,358.45 ; UHC430.G2_12 46.68,359.26 ; UHC430.G2_12 45.87,358.45 ; UHC430.G2_12 46.68,357.64 ; 118.58,396.24 D228.A5 ; D228.A5 120.72,396.24 ; D228.A5 119.65,395.17 ; D228.A5 119.65,397.31 ; D120.A16 54.68,35.56 ; D120.A16 53.61,34.49 ; D120.A16 52.54,35.56 ; D120.A16 53.61,36.63 ; 239.03,100.53 D105.B2 ; D105.B2 237.96,101.6 ; D105.B2 240.1,101.6 ; D105.B2 239.03,102.67 ; D124.A4 96.79,36.63 ; D124.A4 95.72,35.56 ; D124.A4 96.79,34.49 ; D124.A4 97.86,35.56 ; 91.71,54.81 D123.A2 ; D123.A2 92.78,55.88 ; D123.A2 90.64,55.88 ; D123.A2 91.71,56.95 ; 126.2,76.2 D122.A16 ; D122.A16 128.34,76.2 ; D122.A16 127.27,77.27 ; D122.A16 127.27,75.13 ; D432.A16 18.05,404.93 ; D432.A16 19.12,403.86 ; D432.A16 16.98,403.86 ; D432.A16 18.05,402.79 ; D103.A10 186.76,55.88 ; D103.A10 185.69,54.81 ; D103.A10 185.69,56.95 ; D103.A10 184.62,55.88 ; 47.46,373.38 D231.A4 ; D231.A4 49.6,373.38 ; D231.A4 48.53,374.45 ; D231.A4 48.53,372.31 ; 189.7,35.56 D104.A12 ; D104.A12 190.77,36.63 ; D104.A12 191.84,35.56 ; D104.A12 190.77,34.49 ; 245.58,375.92 D111.A13 ; D111.A13 246.65,376.99 ; D111.A13 247.72,375.92 ; D111.A13 246.65,374.85 ; D113.A15 168.98,335.28 ; D113.A15 167.91,336.35 ; D113.A15 166.84,335.28 ; D113.A15 167.91,334.21 ; 37.3,393.7 D232.A8 ; D232.A8 38.37,392.63 ; D232.A8 39.44,393.7 ; D232.A8 38.37,394.77 ; D427.B5 120.72,381 ; D427.B5 118.58,381 ; D427.B5 119.65,382.07 ; D427.B5 119.65,379.93 ; 52.24,156.72 KS4.6 ; KS4.6 53.36,155.6 ; KS4.6 53.36,157.84 ; KS4.6 54.47,156.72 ; 38.37,341.83 CSDPS429.B8 ; CSDPS429.B8 38.37,343.97 ; CSDPS429.B8 39.44,342.9 ; CSDPS429.B8 37.3,342.9 ; 188.23,97.99 D101.B11 ; D101.B11 188.23,100.13 ; D101.B11 189.3,99.06 ; D101.B11 187.16,99.06 ; 184.62,347.98 D114.B8 ; D114.B8 185.69,346.91 ; D114.B8 185.69,349.05 ; D114.B8 186.76,347.98 ; 255.74,73.66 D106.A9 ; D106.A9 256.81,72.59 ; D106.A9 256.81,74.73 ; D106.A9 257.88,73.66 ; 274.59,331.67 D109.A2 ; D109.A2 275.66,332.74 ; D109.A2 274.59,333.81 ; D109.A2 273.52,332.74 ; 273.52,393.7 D112.A2 ; D112.A2 274.59,394.77 ; D112.A2 275.66,393.7 ; D112.A2 274.59,392.63 ; 129.81,385.01 D427.A1 ; D427.A1 129.81,387.15 ; D427.A1 130.88,386.08 ; D427.A1 128.74,386.08 ; D428.B6 117.11,399.85 ; D428.B6 117.11,397.71 ; D428.B6 118.18,398.78 ; D428.B6 116.04,398.78 ; D432.B7 41.98,401.32 ; D432.B7 39.84,401.32 ; D432.B7 40.91,402.39 ; D432.B7 40.91,400.25 ; CSDPS426.B16 91.71,364.29 ; CSDPS426.B16 91.71,362.15 ; CSDPS426.B16 90.64,363.22 ; CSDPS426.B16 92.78,363.22 ; 30.75,37.03 D120.B7 ; D120.B7 30.75,39.17 ; D120.B7 29.68,38.1 ; D120.B7 31.82,38.1 ; 174.46,40.64 D104.B6 ; D104.B6 175.53,39.57 ; D104.B6 176.6,40.64 ; D104.B6 175.53,41.71 ; 193.31,374.85 D115.A5 ; D115.A5 193.31,376.99 ; D115.A5 194.38,375.92 ; D115.A5 192.24,375.92 ; DPS1.C01 236.49,20.12 ; DPS1.C01 235.42,19.05 ; DPS1.C01 236.49,17.98 ; DPS1.C01 237.56,19.05 ; DPS8.C11 30.75,411.28 ; DPS8.C11 29.68,410.21 ; DPS8.C11 31.82,410.21 ; DPS8.C11 30.75,409.14 ; 25.67,390.09 D232.B13 ; D232.B13 24.6,391.16 ; D232.B13 26.74,391.16 ; D232.B13 25.67,392.23 ; DPS8.B05 45.99,413.82 ; DPS8.B05 45.99,411.68 ; DPS8.B05 47.06,412.75 ; DPS8.B05 44.92,412.75 ; CSDPS225.C5 120.72,330.2 ; CSDPS225.C5 119.65,329.13 ; CSDPS225.C5 119.65,331.27 ; CSDPS225.C5 118.58,330.2 ; 250.66,93.98 D105.A7 ; D105.A7 251.73,95.05 ; D105.A7 251.73,92.91 ; D105.A7 252.8,93.98 ; D431.B13 25.67,382.07 ; D431.B13 24.6,381 ; D431.B13 25.67,379.93 ; D431.B13 26.74,381 ; D113.B9 183.15,331.27 ; D113.B9 182.08,330.2 ; D113.B9 184.22,330.2 ; D113.B9 183.15,329.13 ; CSDPS225.C1 130.88,330.2 ; CSDPS225.C1 129.81,331.27 ; CSDPS225.C1 129.81,329.13 ; CSDPS225.C1 128.74,330.2 ; D122.A12 117.11,77.27 ; D122.A12 117.11,75.13 ; D122.A12 118.18,76.2 ; D122.A12 116.04,76.2 ; D112.A5 268.04,396.24 ; D112.A5 265.9,396.24 ; D112.A5 266.97,395.17 ; D112.A5 266.97,397.31 ; D121.A2 92.78,96.52 ; D121.A2 91.71,97.59 ; D121.A2 90.64,96.52 ; D121.A2 91.71,95.45 ; D111.A14 245.18,373.38 ; D111.A14 243.04,373.38 ; D111.A14 244.11,372.31 ; D111.A14 244.11,374.45 ; 95.72,353.06 CSDPS226.B14 ; CSDPS226.B14 97.86,353.06 ; CSDPS226.B14 96.79,354.13 ; CSDPS226.B14 96.79,351.99 ; 22.06,60.96 D119.B4 ; D119.B4 24.2,60.96 ; D119.B4 23.13,62.03 ; D119.B4 23.13,59.89 ; D110.B15 242.64,350.52 ; D110.B15 240.5,350.52 ; D110.B15 241.57,351.59 ; D110.B15 241.57,349.45 ; 129.81,395.17 D228.A1 ; D228.A1 129.81,397.31 ; D228.A1 128.74,396.24 ; D228.A1 130.88,396.24 ; 188.23,354.53 D114.A7 ; D114.A7 188.23,356.67 ; D114.A7 187.16,355.6 ; D114.A7 189.3,355.6 ; 123.66,360.68 CSDPS426.C3 ; CSDPS426.C3 124.73,359.61 ; CSDPS426.C3 125.8,360.68 ; CSDPS426.C3 124.73,361.75 ; D124.B1 90.24,38.1 ; D124.B1 88.1,38.1 ; D124.B1 89.17,39.17 ; D124.B1 89.17,37.03 ; 20.59,409.14 DPS8.C15 ; DPS8.C15 21.66,410.21 ; DPS8.C15 19.52,410.21 ; DPS8.C15 20.59,411.28 ; 180.61,39.57 D104.B8 ; D104.B8 180.61,41.71 ; D104.B8 181.68,40.64 ; D104.B8 179.54,40.64 ; 194.78,55.88 D103.A14 ; D103.A14 195.85,54.81 ; D103.A14 195.85,56.95 ; D103.A14 196.92,55.88 ; D118.B6 28.21,82.35 ; D118.B6 28.21,80.21 ; D118.B6 29.28,81.28 ; D118.B6 27.14,81.28 ; 129.81,390.09 D228.B1 ; D228.B1 130.88,391.16 ; D228.B1 128.74,391.16 ; D228.B1 129.81,392.23 ; D108.B16 274.59,41.71 ; D108.B16 273.52,40.64 ; D108.B16 274.59,39.57 ; D108.B16 275.66,40.64 ; D232.B2 54.68,388.62 ; D232.B2 52.54,388.62 ; D232.B2 53.61,387.55 ; D232.B2 53.61,389.69 ; 56.15,390.09 D232.B1 ; D232.B1 55.08,391.16 ; D232.B1 56.15,392.23 ; D232.B1 57.22,391.16 ; 122.19,341.83 CSDPS425.B4 ; CSDPS425.B4 121.12,342.9 ; CSDPS425.B4 123.26,342.9 ; CSDPS425.B4 122.19,343.97 ; D432.A5 45.99,407.47 ; D432.A5 47.06,406.4 ; D432.A5 44.92,406.4 ; D432.A5 45.99,405.33 ; 259.35,387.55 D112.B8 ; D112.B8 260.42,388.62 ; D112.B8 258.28,388.62 ; D112.B8 259.35,389.69 ; 48.53,382.47 D431.A4 ; D431.A4 49.6,383.54 ; D431.A4 47.46,383.54 ; D431.A4 48.53,384.61 ; D432.A8 38.37,404.93 ; D432.A8 39.44,403.86 ; D432.A8 37.3,403.86 ; D432.A8 38.37,402.79 ; 119.65,405.33 D428.A5 ; D428.A5 120.72,406.4 ; D428.A5 118.58,406.4 ; D428.A5 119.65,407.47 ; D118.A10 39.44,76.2 ; D118.A10 37.3,76.2 ; D118.A10 38.37,77.27 ; D118.A10 38.37,75.13 ; 22.06,373.38 D231.A14 ; D231.A14 23.13,372.31 ; D231.A14 23.13,374.45 ; D231.A14 24.2,373.38 ; 44.72,363.7 UHC430.G2_5 ; UHC430.G2_5 45.53,364.51 ; UHC430.G2_5 46.34,363.7 ; UHC430.G2_5 45.53,362.89 ; D109.B14 245.18,327.66 ; D109.B14 244.11,326.59 ; D109.B14 244.11,328.73 ; D109.B14 243.04,327.66 ; D112.A6 264.43,394.77 ; D112.A6 264.43,392.63 ; D112.A6 263.36,393.7 ; D112.A6 265.5,393.7 ; DPS8.A05 45.99,416.36 ; DPS8.A05 45.99,414.22 ; DPS8.A05 47.06,415.29 ; DPS8.A05 44.92,415.29 ; D105.B10 259.35,102.67 ; D105.B10 258.28,101.6 ; D105.B10 260.42,101.6 ; D105.B10 259.35,100.53 ; D115.A16 166.44,373.38 ; D115.A16 164.3,373.38 ; D115.A16 165.37,374.45 ; D115.A16 165.37,372.31 ; D427.B16 91.71,379.53 ; D427.B16 92.78,378.46 ; D427.B16 90.64,378.46 ; D427.B16 91.71,377.39 ; 272.05,349.45 D110.B3 ; D110.B3 272.05,351.59 ; D110.B3 273.12,350.52 ; D110.B3 270.98,350.52 ; 248.12,76.2 D106.A6 ; D106.A6 249.19,75.13 ; D106.A6 250.26,76.2 ; D106.A6 249.19,77.27 ; 165.37,387.55 D116.B16 ; D116.B16 166.44,388.62 ; D116.B16 164.3,388.62 ; D116.B16 165.37,389.69 ; D427.A14 97.86,383.54 ; D427.A14 96.79,382.47 ; D427.A14 95.72,383.54 ; D427.A14 96.79,384.61 ; 89.17,17.98 DPS3.C01 ; DPS3.C01 90.24,19.05 ; DPS3.C01 89.17,20.12 ; DPS3.C01 88.1,19.05 ; 245.58,19.05 DPS1.C05 ; DPS1.C05 246.65,20.12 ; DPS1.C05 246.65,17.98 ; DPS1.C05 247.72,19.05 ; 272.05,72.59 D106.A15 ; D106.A15 273.12,73.66 ; D106.A15 272.05,74.73 ; D106.A15 270.98,73.66 ; D231.B7 41.98,370.84 ; D231.B7 39.84,370.84 ; D231.B7 40.91,371.91 ; D231.B7 40.91,369.77 ; D104.B14 196.92,40.64 ; D104.B14 195.85,41.71 ; D104.B14 194.78,40.64 ; D104.B14 195.85,39.57 ; D112.A1 277.13,397.31 ; D112.A1 277.13,395.17 ; D112.A1 278.2,396.24 ; D112.A1 276.06,396.24 ; UHC230.G4_1 19.99,355.29 ; UHC230.G4_1 18.37,355.29 ; UHC230.G4_1 19.18,356.1 ; UHC230.G4_1 19.18,354.48 ; D119.A16 54.68,55.88 ; D119.A16 53.61,56.95 ; D119.A16 53.61,54.81 ; D119.A16 52.54,55.88 ; D119.A2 18.05,56.95 ; D119.A2 18.05,54.81 ; D119.A2 19.12,55.88 ; D119.A2 16.98,55.88 ; D115.A15 167.91,376.99 ; D115.A15 166.84,375.92 ; D115.A15 168.98,375.92 ; D115.A15 167.91,374.85 ; D114.A11 179.14,355.6 ; D114.A11 177,355.6 ; D114.A11 178.07,356.67 ; D114.A11 178.07,354.53 ; 89.17,374.85 D227.A17 ; D227.A17 90.24,375.92 ; D227.A17 88.1,375.92 ; D227.A17 89.17,376.99 ; D118.A9 36.9,73.66 ; D118.A9 34.76,73.66 ; D118.A9 35.83,72.59 ; D118.A9 35.83,74.73 ; 47.46,403.86 D432.A4 ; D432.A4 48.53,402.79 ; D432.A4 49.6,403.86 ; D432.A4 48.53,404.93 ; 255.74,370.84 D111.B9 ; D111.B9 256.81,369.77 ; D111.B9 257.88,370.84 ; D111.B9 256.81,371.91 ; 190.77,326.59 D113.B6 ; D113.B6 189.7,327.66 ; D113.B6 191.84,327.66 ; D113.B6 190.77,328.73 ; D114.A15 167.91,356.67 ; D114.A15 166.84,355.6 ; D114.A15 168.98,355.6 ; D114.A15 167.91,354.53 ; D118.A3 20.59,74.73 ; D118.A3 20.59,72.59 ; D118.A3 21.66,73.66 ; D118.A3 19.52,73.66 ; D231.B8 39.44,368.3 ; D231.B8 38.37,367.23 ; D231.B8 38.37,369.37 ; D231.B8 37.3,368.3 ; D431.A16 18.05,384.61 ; D431.A16 18.05,382.47 ; D431.A16 16.98,383.54 ; D431.A16 19.12,383.54 ; 52.54,60.96 D119.B16 ; D119.B16 53.61,59.89 ; D119.B16 53.61,62.03 ; D119.B16 54.68,60.96 ; 266.97,97.99 D105.B13 ; D105.B13 268.04,99.06 ; D105.B13 266.97,100.13 ; D105.B13 265.9,99.06 ; 105.88,76.2 D122.A8 ; D122.A8 106.95,77.27 ; D122.A8 108.02,76.2 ; D122.A8 106.95,75.13 ; 108.42,73.66 D122.A9 ; D122.A9 109.49,74.73 ; D122.A9 109.49,72.59 ; D122.A9 110.56,73.66 ; 48.53,75.13 D118.A14 ; D118.A14 48.53,77.27 ; D118.A14 47.46,76.2 ; D118.A14 49.6,76.2 ; D110.A7 261.89,356.67 ; D110.A7 260.82,355.6 ; D110.A7 262.96,355.6 ; D110.A7 261.89,354.53 ; D432.A2 54.68,403.86 ; D432.A2 53.61,404.93 ; D432.A2 52.54,403.86 ; D432.A2 53.61,402.79 ; D113.A6 191.84,332.74 ; D113.A6 190.77,331.67 ; D113.A6 189.7,332.74 ; D113.A6 190.77,333.81 ; D227.B2 127.27,369.37 ; D227.B2 128.34,368.3 ; D227.B2 127.27,367.23 ; D227.B2 126.2,368.3 ; 14.58,361.14 UHC430.G1_8 ; UHC430.G1_8 13.77,361.95 ; UHC430.G1_8 14.58,362.76 ; UHC430.G1_8 15.39,361.95 ; 124.73,369.77 D227.B3 ; D227.B3 124.73,371.91 ; D227.B3 125.8,370.84 ; D227.B3 123.66,370.84 ; D228.B10 108.02,388.62 ; D228.B10 106.95,389.69 ; D228.B10 105.88,388.62 ; D228.B10 106.95,387.55 ; D109.A15 241.57,336.35 ; D109.A15 241.57,334.21 ; D109.A15 242.64,335.28 ; D109.A15 240.5,335.28 ; 195.85,34.49 D104.A14 ; D104.A14 194.78,35.56 ; D104.A14 196.92,35.56 ; D104.A14 195.85,36.63 ; 180.61,367.23 D115.B10 ; D115.B10 181.68,368.3 ; D115.B10 179.54,368.3 ; D115.B10 180.61,369.37 ; 45.87,365.45 UHC430.G2_2 ; UHC430.G2_2 46.68,364.64 ; UHC430.G2_2 46.68,366.26 ; UHC430.G2_2 47.49,365.45 ; D121.A12 118.18,96.52 ; D121.A12 117.11,95.45 ; D121.A12 116.04,96.52 ; D121.A12 117.11,97.59 ; 185.69,80.21 D102.B10 ; D102.B10 185.69,82.35 ; D102.B10 184.62,81.28 ; D102.B10 186.76,81.28 ; 93.18,73.66 D122.A3 ; D122.A3 94.25,72.59 ; D122.A3 95.32,73.66 ; D122.A3 94.25,74.73 ; D116.A15 168.98,396.24 ; D116.A15 167.91,397.31 ; D116.A15 166.84,396.24 ; D116.A15 167.91,395.17 ; D431.A6 44.52,383.54 ; D431.A6 42.38,383.54 ; D431.A6 43.45,384.61 ; D431.A6 43.45,382.47 ; 24.6,375.92 D231.A13 ; D231.A13 26.74,375.92 ; D231.A13 25.67,376.99 ; D231.A13 25.67,374.85 ; D108.B11 262.96,38.1 ; D108.B11 260.82,38.1 ; D108.B11 261.89,37.03 ; D108.B11 261.89,39.17 ; 192.24,38.1 D104.B13 ; D104.B13 194.38,38.1 ; D104.B13 193.31,37.03 ; D104.B13 193.31,39.17 ; 178.07,92.91 D101.A7 ; D101.A7 177,93.98 ; D101.A7 179.14,93.98 ; D101.A7 178.07,95.05 ; 124.73,52.27 D123.A15 ; D123.A15 123.66,53.34 ; D123.A15 125.8,53.34 ; D123.A15 124.73,54.41 ; D115.A6 190.77,374.45 ; D115.A6 189.7,373.38 ; D115.A6 191.84,373.38 ; D115.A6 190.77,372.31 ; 187.16,58.42 D103.B11 ; D103.B11 188.23,59.49 ; D103.B11 189.3,58.42 ; D103.B11 188.23,57.35 ; CSDPS426.B10 108.02,363.22 ; CSDPS426.B10 106.95,364.29 ; CSDPS426.B10 106.95,362.15 ; CSDPS426.B10 105.88,363.22 ; D117.B11 40.91,100.13 ; D117.B11 41.98,99.06 ; D117.B11 40.91,97.99 ; D117.B11 39.84,99.06 ; D106.B5 246.65,79.81 ; D106.B5 245.58,78.74 ; D106.B5 247.72,78.74 ; D106.B5 246.65,77.67 ; D122.B4 97.86,81.28 ; D122.B4 95.72,81.28 ; D122.B4 96.79,82.35 ; D122.B4 96.79,80.21 ; 52.54,332.74 CSDPS229.B2 ; CSDPS229.B2 53.61,331.67 ; CSDPS229.B2 54.68,332.74 ; CSDPS229.B2 53.61,333.81 ; 20.59,411.68 DPS8.B15 ; DPS8.B15 20.59,413.82 ; DPS8.B15 21.66,412.75 ; DPS8.B15 19.52,412.75 ; D104.A9 184.22,33.02 ; D104.A9 182.08,33.02 ; D104.A9 183.15,31.95 ; D104.A9 183.15,34.09 ; D108.B1 236.49,39.17 ; D108.B1 236.49,37.03 ; D108.B1 237.56,38.1 ; D108.B1 235.42,38.1 ; SB14.1 113.9,11.83 114.57,12.5 DPS3.A11 ; D117.B7 30.75,100.13 ; D117.B7 29.68,99.06 ; D117.B7 31.82,99.06 ; D117.B7 30.75,97.99 ; 164.3,55.88 D103.A2 ; D103.A2 166.44,55.88 ; D103.A2 165.37,56.95 ; D103.A2 165.37,54.81 ; D115.B13 174.06,370.84 ; D115.B13 172.99,371.91 ; D115.B13 171.92,370.84 ; D115.B13 172.99,369.77 ; DPS3.A11 114.57,15.04 ; DPS3.A11 113.5,13.97 ; DPS3.A11 115.64,13.97 ; 18.05,372.31 D231.A16 ; D231.A16 19.12,373.38 ; D231.A16 16.98,373.38 ; D231.A16 18.05,374.45 ; 192.24,33.02 D104.A13 ; D104.A13 193.31,31.95 ; D104.A13 194.38,33.02 ; D104.A13 193.31,34.09 ; DPS2.B01 203.47,413.82 ; DPS2.B01 202.4,412.75 ; DPS2.B01 204.54,412.75 ; DPS2.B01 203.47,411.68 ; D108.A3 241.57,34.09 ; D108.A3 242.64,33.02 ; D108.A3 241.57,31.95 ; D108.A3 240.5,33.02 ; 113.5,375.92 D227.A7 ; D227.A7 115.64,375.92 ; D227.A7 114.57,376.99 ; D227.A7 114.57,374.85 ; 185.69,387.55 D116.B8 ; D116.B8 186.76,388.62 ; D116.B8 185.69,389.69 ; D116.B8 184.62,388.62 ; 259.35,351.99 D110.A8 ; D110.A8 260.42,353.06 ; D110.A8 258.28,353.06 ; D110.A8 259.35,354.13 ; 95.72,40.64 D124.B4 ; D124.B4 96.79,39.57 ; D124.B4 97.86,40.64 ; D124.B4 96.79,41.71 ; 52.54,398.78 D432.B2 ; D432.B2 54.68,398.78 ; D432.B2 53.61,399.85 ; D432.B2 53.61,397.71 ; D108.A1 237.56,33.02 ; D108.A1 236.49,34.09 ; D108.A1 236.49,31.95 ; D108.A1 235.42,33.02 ; 276.06,391.16 D112.B1 ; D112.B1 277.13,392.23 ; D112.B1 278.2,391.16 ; D112.B1 277.13,390.09 ; 259.35,392.63 D112.A8 ; D112.A8 258.28,393.7 ; D112.A8 259.35,394.77 ; D112.A8 260.42,393.7 ; D428.A16 92.78,403.86 ; D428.A16 90.64,403.86 ; D428.A16 91.71,402.79 ; D428.A16 91.71,404.93 ; D121.B6 102.94,101.6 ; D121.B6 101.87,102.67 ; D121.B6 100.8,101.6 ; D121.B6 101.87,100.53 ; D232.B7 40.91,392.23 ; D232.B7 39.84,391.16 ; D232.B7 40.91,390.09 ; D232.B7 41.98,391.16 ; 113.5,340.36 CSDPS425.C7 ; CSDPS425.C7 114.57,341.43 ; CSDPS425.C7 114.57,339.29 ; CSDPS425.C7 115.64,340.36 ; D103.A4 171.52,55.88 ; D103.A4 170.45,56.95 ; D103.A4 170.45,54.81 ; D103.A4 169.38,55.88 ; 251.73,57.35 D107.B7 ; D107.B7 251.73,59.49 ; D107.B7 252.8,58.42 ; D107.B7 250.66,58.42 ; D227.A9 109.49,376.99 ; D227.A9 110.56,375.92 ; D227.A9 109.49,374.85 ; D227.A9 108.42,375.92 ; 260.82,78.74 D106.B11 ; D106.B11 262.96,78.74 ; D106.B11 261.89,77.67 ; D106.B11 261.89,79.81 ; 253.2,373.38 D111.A10 ; D111.A10 254.27,374.45 ; D111.A10 254.27,372.31 ; D111.A10 255.34,373.38 ; D110.A3 273.12,355.6 ; D110.A3 272.05,354.53 ; D110.A3 270.98,355.6 ; D110.A3 272.05,356.67 ; 94.25,52.27 D123.A3 ; D123.A3 93.18,53.34 ; D123.A3 94.25,54.41 ; D123.A3 95.32,53.34 ; 48.17,365.45 UHC430.G2_1 ; UHC430.G2_1 48.98,364.64 ; UHC430.G2_1 48.98,366.26 ; UHC430.G2_1 49.79,365.45 ; D123.B3 95.32,58.42 ; D123.B3 94.25,59.49 ; D123.B3 93.18,58.42 ; D123.B3 94.25,57.35 ; 253.2,393.7 D112.A10 ; D112.A10 254.27,392.63 ; D112.A10 254.27,394.77 ; D112.A10 255.34,393.7 ; 106.95,34.49 D124.A8 ; D124.A8 108.02,35.56 ; D124.A8 106.95,36.63 ; D124.A8 105.88,35.56 ; D427.B7 114.57,382.07 ; D427.B7 114.57,379.93 ; D427.B7 115.64,381 ; D427.B7 113.5,381 ; 236.49,12.9 DPS1.A01 ; DPS1.A01 235.42,13.97 ; DPS1.A01 237.56,13.97 ; DPS1.A01 236.49,15.04 ; 19.18,357.64 UHC430.G1_11 ; UHC430.G1_11 19.18,359.26 ; UHC430.G1_11 18.37,358.45 ; UHC430.G1_11 19.99,358.45 ; 112.03,95.45 D121.A10 ; D121.A10 113.1,96.52 ; D121.A10 112.03,97.59 ; D121.A10 110.96,96.52 ; 177,410.21 DPS2.C11 ; DPS2.C11 178.07,411.28 ; DPS2.C11 179.14,410.21 ; DPS2.C11 178.07,409.14 ; 52.54,342.9 CSDPS429.B2 ; CSDPS429.B2 53.61,341.83 ; CSDPS429.B2 53.61,343.97 ; CSDPS429.B2 54.68,342.9 ; D232.A13 25.67,397.31 ; D232.A13 25.67,395.17 ; D232.A13 24.6,396.24 ; D232.A13 26.74,396.24 ; 116.04,60.96 D123.B12 ; D123.B12 117.11,62.03 ; D123.B12 117.11,59.89 ; D123.B12 118.18,60.96 ; D109.A7 262.96,335.28 ; D109.A7 261.89,336.35 ; D109.A7 260.82,335.28 ; D109.A7 261.89,334.21 ; 116.04,40.64 D124.B12 ; D124.B12 118.18,40.64 ; D124.B12 117.11,39.57 ; D124.B12 117.11,41.71 ; 35.83,31.95 D120.A9 ; D120.A9 35.83,34.09 ; D120.A9 36.9,33.02 ; D120.A9 34.76,33.02 ; D102.B7 178.07,79.81 ; D102.B7 179.14,78.74 ; D102.B7 177,78.74 ; D102.B7 178.07,77.67 ; 193.31,52.27 D103.A13 ; D103.A13 192.24,53.34 ; D103.A13 194.38,53.34 ; D103.A13 193.31,54.41 ; D113.B4 196.92,327.66 ; D113.B4 194.78,327.66 ; D113.B4 195.85,328.73 ; D113.B4 195.85,326.59 ; 18.05,387.55 D232.B16 ; D232.B16 19.12,388.62 ; D232.B16 16.98,388.62 ; D232.B16 18.05,389.69 ; 190.77,367.23 D115.B6 ; D115.B6 190.77,369.37 ; D115.B6 189.7,368.3 ; D115.B6 191.84,368.3 ; 88.1,33.02 D124.A1 ; D124.A1 89.17,34.09 ; D124.A1 89.17,31.95 ; D124.A1 90.24,33.02 ; 33.29,397.71 D432.B10 ; D432.B10 34.36,398.78 ; D432.B10 33.29,399.85 ; D432.B10 32.22,398.78 ; D112.A13 246.65,397.31 ; D112.A13 245.58,396.24 ; D112.A13 246.65,395.17 ; D112.A13 247.72,396.24 ; 28.21,341.83 CSDPS429.B12 ; CSDPS429.B12 29.28,342.9 ; CSDPS429.B12 27.14,342.9 ; CSDPS429.B12 28.21,343.97 ; D123.B5 99.33,59.49 ; D123.B5 99.33,57.35 ; D123.B5 98.26,58.42 ; D123.B5 100.4,58.42 ; 19.52,58.42 D119.B3 ; D119.B3 20.59,59.49 ; D119.B3 20.59,57.35 ; D119.B3 21.66,58.42 ; D118.B10 39.44,81.28 ; D118.B10 38.37,80.21 ; D118.B10 37.3,81.28 ; D118.B10 38.37,82.35 ; 239.03,34.49 D108.A2 ; D108.A2 237.96,35.56 ; D108.A2 240.1,35.56 ; D108.A2 239.03,36.63 ; 118.58,38.1 D124.B13 ; D124.B13 120.72,38.1 ; D124.B13 119.65,39.17 ; D124.B13 119.65,37.03 ; 164.3,393.7 D116.A16 ; D116.A16 165.37,392.63 ; D116.A16 166.44,393.7 ; D116.A16 165.37,394.77 ; 126.2,393.7 D228.A2 ; D228.A2 127.27,392.63 ; D228.A2 127.27,394.77 ; D228.A2 128.34,393.7 ; 251.73,72.59 D106.A7 ; D106.A7 251.73,74.73 ; D106.A7 250.66,73.66 ; D106.A7 252.8,73.66 ; D110.B7 262.96,350.52 ; D110.B7 261.89,351.59 ; D110.B7 261.89,349.45 ; D110.B7 260.82,350.52 ; D119.A9 35.83,54.41 ; D119.A9 34.76,53.34 ; D119.A9 36.9,53.34 ; D119.A9 35.83,52.27 ; 108.42,370.84 D227.B9 ; D227.B9 110.56,370.84 ; D227.B9 109.49,371.91 ; D227.B9 109.49,369.77 ; D109.A10 255.34,332.74 ; D109.A10 254.27,333.81 ; D109.A10 254.27,331.67 ; D109.A10 253.2,332.74 ; 246.65,31.95 D108.A5 ; D108.A5 247.72,33.02 ; D108.A5 246.65,34.09 ; D108.A5 245.58,33.02 ; D112.A14 244.11,394.77 ; D112.A14 243.04,393.7 ; D112.A14 245.18,393.7 ; D112.A14 244.11,392.63 ; 29.68,406.4 D432.A11 ; D432.A11 30.75,405.33 ; D432.A11 30.75,407.47 ; D432.A11 31.82,406.4 ; D121.B4 97.86,101.6 ; D121.B4 95.72,101.6 ; D121.B4 96.79,100.53 ; D121.B4 96.79,102.67 ; 199.86,96.52 D101.A16 ; D101.A16 202,96.52 ; D101.A16 200.93,95.45 ; D101.A16 200.93,97.59 ; 88.1,391.16 D228.B17 ; D228.B17 90.24,391.16 ; D228.B17 89.17,392.23 ; D228.B17 89.17,390.09 ; 108.42,381 D427.B9 ; D427.B9 109.49,382.07 ; D427.B9 110.56,381 ; D427.B9 109.49,379.93 ; D431.B17 16.58,381 ; D431.B17 14.44,381 ; D431.B17 15.51,379.93 ; D431.B17 15.51,382.07 ; 265.9,53.34 D107.A13 ; D107.A13 266.97,52.27 ; D107.A13 266.97,54.41 ; D107.A13 268.04,53.34 ; 35.83,77.67 D118.B9 ; D118.B9 36.9,78.74 ; D118.B9 34.76,78.74 ; D118.B9 35.83,79.81 ; D231.B17 16.58,370.84 ; D231.B17 15.51,371.91 ; D231.B17 14.44,370.84 ; D231.B17 15.51,369.77 ; 248.12,368.3 D111.B12 ; D111.B12 249.19,367.23 ; D111.B12 249.19,369.37 ; D111.B12 250.26,368.3 ; D427.B8 112.03,379.53 ; D427.B8 113.1,378.46 ; D427.B8 112.03,377.39 ; D427.B8 110.96,378.46 ; CSDPS226.B10 108.02,353.06 ; CSDPS226.B10 105.88,353.06 ; CSDPS226.B10 106.95,354.13 ; CSDPS226.B10 106.95,351.99 ; 114.57,92.91 D121.A11 ; D121.A11 115.64,93.98 ; D121.A11 113.5,93.98 ; D121.A11 114.57,95.05 ; 128.74,350.52 CSDPS226.C1 ; CSDPS226.C1 129.81,351.59 ; CSDPS226.C1 129.81,349.45 ; CSDPS226.C1 130.88,350.52 ; 171.92,99.06 D101.B5 ; D101.B5 172.99,100.13 ; D101.B5 172.99,97.99 ; D101.B5 174.06,99.06 ; 261.89,31.95 D108.A11 ; D108.A11 260.82,33.02 ; D108.A11 262.96,33.02 ; D108.A11 261.89,34.09 ; 24.6,58.42 D119.B5 ; D119.B5 25.67,59.49 ; D119.B5 25.67,57.35 ; D119.B5 26.74,58.42 ; CSDPS226.B8 113.1,353.06 ; CSDPS226.B8 110.96,353.06 ; CSDPS226.B8 112.03,354.13 ; CSDPS226.B8 112.03,351.99 ; 165.37,95.45 D101.A2 ; D101.A2 164.3,96.52 ; D101.A2 165.37,97.59 ; D101.A2 166.44,96.52 ; 14.58,354.48 UHC230.G4_3 ; UHC230.G4_3 15.39,355.29 ; UHC230.G4_3 14.58,356.1 ; UHC230.G4_3 13.77,355.29 ; 237.96,76.2 D106.A2 ; D106.A2 240.1,76.2 ; D106.A2 239.03,75.13 ; D106.A2 239.03,77.27 ; D105.A4 244.11,97.59 ; D105.A4 243.04,96.52 ; D105.A4 245.18,96.52 ; D105.A4 244.11,95.45 ; 179.54,81.28 D102.B8 ; D102.B8 180.61,80.21 ; D102.B8 181.68,81.28 ; D102.B8 180.61,82.35 ; D107.A3 242.64,53.34 ; D107.A3 240.5,53.34 ; D107.A3 241.57,54.41 ; D107.A3 241.57,52.27 ; 18.03,362.89 UHC430.G1_4 ; UHC430.G1_4 17.22,363.7 ; UHC430.G1_4 18.84,363.7 ; UHC430.G1_4 18.03,364.51 ; 112.03,100.53 D121.B10 ; D121.B10 113.1,101.6 ; D121.B10 112.03,102.67 ; D121.B10 110.96,101.6 ; D432.A9 35.83,407.47 ; D432.A9 34.76,406.4 ; D432.A9 35.83,405.33 ; D432.A9 36.9,406.4 ; 16.98,368.3 D231.B16 ; D231.B16 19.12,368.3 ; D231.B16 18.05,369.37 ; D231.B16 18.05,367.23 ; D118.A4 23.13,77.27 ; D118.A4 23.13,75.13 ; D118.A4 24.2,76.2 ; D118.A4 22.06,76.2 ; D118.A7 30.75,74.73 ; D118.A7 29.68,73.66 ; D118.A7 30.75,72.59 ; D118.A7 31.82,73.66 ; D124.A12 118.18,35.56 ; D124.A12 116.04,35.56 ; D124.A12 117.11,36.63 ; D124.A12 117.11,34.49 ; 239.03,387.55 D112.B16 ; D112.B16 240.1,388.62 ; D112.B16 239.03,389.69 ; D112.B16 237.96,388.62 ; 177,33.02 D104.A7 ; D104.A7 178.07,31.95 ; D104.A7 179.14,33.02 ; D104.A7 178.07,34.09 ; D105.B4 245.18,101.6 ; D105.B4 244.11,102.67 ; D105.B4 243.04,101.6 ; D105.B4 244.11,100.53 ; 235.42,16.51 DPS1.B01 ; DPS1.B01 236.49,15.44 ; DPS1.B01 237.56,16.51 ; DPS1.B01 236.49,17.58 ; D123.B7 105.48,58.42 ; D123.B7 103.34,58.42 ; D123.B7 104.41,57.35 ; D123.B7 104.41,59.49 ; D120.B6 29.28,40.64 ; D120.B6 28.21,41.71 ; D120.B6 27.14,40.64 ; D120.B6 28.21,39.57 ; D428.B5 119.65,402.39 ; D428.B5 119.65,400.25 ; D428.B5 120.72,401.32 ; D428.B5 118.58,401.32 ; 88.1,381 D427.B17 ; D427.B17 89.17,382.07 ; D427.B17 90.24,381 ; D427.B17 89.17,379.93 ; 174.46,353.06 D114.A12 ; D114.A12 176.6,353.06 ; D114.A12 175.53,351.99 ; D114.A12 175.53,354.13 ; 117.11,100.53 D121.B12 ; D121.B12 118.18,101.6 ; D121.B12 117.11,102.67 ; D121.B12 116.04,101.6 ; D109.B9 256.81,331.27 ; D109.B9 256.81,329.13 ; D109.B9 255.74,330.2 ; D109.B9 257.88,330.2 ; 33.29,392.63 D232.A10 ; D232.A10 32.22,393.7 ; D232.A10 33.29,394.77 ; D232.A10 34.36,393.7 ; D427.A10 106.95,384.61 ; D427.A10 105.88,383.54 ; D427.A10 108.02,383.54 ; D427.A10 106.95,382.47 ; 240.5,58.42 D107.B3 ; D107.B3 241.57,59.49 ; D107.B3 241.57,57.35 ; D107.B3 242.64,58.42 ; DPS1.B11 262.96,16.51 ; DPS1.B11 260.82,16.51 ; DPS1.B11 261.89,15.44 ; DPS1.B11 261.89,17.58 ; D103.B3 167.91,59.49 ; D103.B3 166.84,58.42 ; D103.B3 167.91,57.35 ; D103.B3 168.98,58.42 ; 123.66,93.98 D121.A15 ; D121.A15 124.73,95.05 ; D121.A15 124.73,92.91 ; D121.A15 125.8,93.98 ; 23.13,402.79 D432.A14 ; D432.A14 22.06,403.86 ; D432.A14 23.13,404.93 ; D432.A14 24.2,403.86 ; 273.52,81.28 D106.B16 ; D106.B16 274.59,80.21 ; D106.B16 274.59,82.35 ; D106.B16 275.66,81.28 ; D117.A7 31.82,93.98 ; D117.A7 29.68,93.98 ; D117.A7 30.75,95.05 ; D117.A7 30.75,92.91 ; 239.03,54.81 D107.A2 ; D107.A2 237.96,55.88 ; D107.A2 240.1,55.88 ; D107.A2 239.03,56.95 ; 114.57,52.27 D123.A11 ; D123.A11 115.64,53.34 ; D123.A11 113.5,53.34 ; D123.A11 114.57,54.41 ; D117.A6 29.28,96.52 ; D117.A6 28.21,97.59 ; D117.A6 27.14,96.52 ; D117.A6 28.21,95.45 ; 183.15,334.21 D113.A9 ; D113.A9 184.22,335.28 ; D113.A9 183.15,336.35 ; D113.A9 182.08,335.28 ; 55.08,415.29 DPS8.A01 ; DPS8.A01 56.15,416.36 ; DPS8.A01 56.15,414.22 ; DPS8.A01 57.22,415.29 ; 268.44,332.74 D109.A4 ; D109.A4 269.51,331.67 ; D109.A4 269.51,333.81 ; D109.A4 270.58,332.74 ; 203.47,374.85 D115.A1 ; D115.A1 203.47,376.99 ; D115.A1 202.4,375.92 ; D115.A1 204.54,375.92 ; D113.A2 202,332.74 ; D113.A2 199.86,332.74 ; D113.A2 200.93,333.81 ; D113.A2 200.93,331.67 ; 28.21,377.39 D431.B12 ; D431.B12 29.28,378.46 ; D431.B12 27.14,378.46 ; D431.B12 28.21,379.53 ; 122.19,367.23 D227.B4 ; D227.B4 122.19,369.37 ; D227.B4 123.26,368.3 ; D227.B4 121.12,368.3 ; D432.B16 19.12,398.78 ; D432.B16 16.98,398.78 ; D432.B16 18.05,399.85 ; D432.B16 18.05,397.71 ; 255.74,396.24 D112.A9 ; D112.A9 257.88,396.24 ; D112.A9 256.81,397.31 ; D112.A9 256.81,395.17 ; D121.A3 95.32,93.98 ; D121.A3 94.25,95.05 ; D121.A3 93.18,93.98 ; D121.A3 94.25,92.91 ; D124.A3 94.25,34.09 ; D124.A3 93.18,33.02 ; D124.A3 94.25,31.95 ; D124.A3 95.32,33.02 ; CSDPS425.C13 99.33,341.43 ; CSDPS425.C13 100.4,340.36 ; CSDPS425.C13 99.33,339.29 ; CSDPS425.C13 98.26,340.36 ; DPS3.A15 125.8,13.97 ; DPS3.A15 123.66,13.97 ; DPS3.A15 124.73,15.04 ; DPS3.A15 124.73,12.9 ; 189.7,55.88 D103.A12 ; D103.A12 190.77,56.95 ; D103.A12 191.84,55.88 ; D103.A12 190.77,54.81 ; D117.A14 48.53,97.59 ; D117.A14 49.6,96.52 ; D117.A14 47.46,96.52 ; D117.A14 48.53,95.45 ; D102.B15 198.39,79.81 ; D102.B15 197.32,78.74 ; D102.B15 199.46,78.74 ; D102.B15 198.39,77.67 ; 177,375.92 D115.A11 ; D115.A11 179.14,375.92 ; D115.A11 178.07,376.99 ; D115.A11 178.07,374.85 ; 108.42,78.74 D122.B9 ; D122.B9 109.49,79.81 ; D122.B9 110.56,78.74 ; D122.B9 109.49,77.67 ; D104.B10 186.76,40.64 ; D104.B10 184.62,40.64 ; D104.B10 185.69,39.57 ; D104.B10 185.69,41.71 ; D121.A8 106.95,97.59 ; D121.A8 105.88,96.52 ; D121.A8 106.95,95.45 ; D121.A8 108.02,96.52 ; D121.A6 101.87,97.59 ; D121.A6 100.8,96.52 ; D121.A6 101.87,95.45 ; D121.A6 102.94,96.52 ; D105.B15 272.05,100.13 ; D105.B15 273.12,99.06 ; D105.B15 270.98,99.06 ; D105.B15 272.05,97.99 ; 194.78,101.6 D101.B14 ; D101.B14 195.85,102.67 ; D101.B14 195.85,100.53 ; D101.B14 196.92,101.6 ; 164.3,101.6 D101.B2 ; D101.B2 166.44,101.6 ; D101.B2 165.37,100.53 ; D101.B2 165.37,102.67 ; 171.92,330.2 D113.B13 ; D113.B13 172.99,329.13 ; D113.B13 172.99,331.27 ; D113.B13 174.06,330.2 ; D432.A1 56.15,407.47 ; D432.A1 55.08,406.4 ; D432.A1 57.22,406.4 ; D432.A1 56.15,405.33 ; 35.83,400.25 D432.B9 ; D432.B9 35.83,402.39 ; D432.B9 34.76,401.32 ; D432.B9 36.9,401.32 ; D111.A2 274.59,374.45 ; D111.A2 274.59,372.31 ; D111.A2 273.52,373.38 ; D111.A2 275.66,373.38 ; 118.58,350.52 CSDPS226.C5 ; CSDPS226.C5 119.65,351.59 ; CSDPS226.C5 119.65,349.45 ; CSDPS226.C5 120.72,350.52 ; 96.79,54.81 D123.A4 ; D123.A4 97.86,55.88 ; D123.A4 96.79,56.95 ; D123.A4 95.72,55.88 ; 109.49,97.99 D121.B9 ; D121.B9 110.56,99.06 ; D121.B9 108.42,99.06 ; D121.B9 109.49,100.13 ; D105.A15 273.12,93.98 ; D105.A15 270.98,93.98 ; D105.A15 272.05,92.91 ; D105.A15 272.05,95.05 ; D111.B8 260.42,368.3 ; D111.B8 258.28,368.3 ; D111.B8 259.35,367.23 ; D111.B8 259.35,369.37 ; CSDPS425.B14 96.79,343.97 ; CSDPS425.B14 97.86,342.9 ; CSDPS425.B14 95.72,342.9 ; CSDPS425.B14 96.79,341.83 ; 188.23,390.09 D116.B7 ; D116.B7 189.3,391.16 ; D116.B7 187.16,391.16 ; D116.B7 188.23,392.23 ; D117.A9 35.83,95.05 ; D117.A9 34.76,93.98 ; D117.A9 36.9,93.98 ; D117.A9 35.83,92.91 ; DPS1.A11 262.96,13.97 ; DPS1.A11 260.82,13.97 ; DPS1.A11 261.89,15.04 ; DPS1.A11 261.89,12.98 261.09,12.18 SB1.1 ; 52.54,373.38 D231.A2 ; D231.A2 53.61,374.45 ; D231.A2 54.68,373.38 ; D231.A2 53.61,372.31 ; 241.57,72.59 D106.A3 ; D106.A3 242.64,73.66 ; D106.A3 241.57,74.73 ; D106.A3 240.5,73.66 ; D122.A5 100.4,73.66 ; D122.A5 98.26,73.66 ; D122.A5 99.33,72.59 ; D122.A5 99.33,74.73 ; 124.73,72.59 D122.A15 ; D122.A15 125.8,73.66 ; D122.A15 124.73,74.73 ; D122.A15 123.66,73.66 ; 236.49,72.59 D106.A1 ; D106.A1 235.42,73.66 ; D106.A1 237.56,73.66 ; D106.A1 236.49,74.73 ; 112.03,372.31 D227.A8 ; D227.A8 113.1,373.38 ; D227.A8 112.03,374.45 ; D227.A8 110.96,373.38 ; 164.3,368.3 D115.B16 ; D115.B16 166.44,368.3 ; D115.B16 165.37,369.37 ; D115.B16 165.37,367.23 ; 37.3,398.78 D432.B8 ; D432.B8 39.44,398.78 ; D432.B8 38.37,397.71 ; D432.B8 38.37,399.85 ; D110.B8 260.42,347.98 ; D110.B8 258.28,347.98 ; D110.B8 259.35,349.05 ; D110.B8 259.35,346.91 ; 235.42,99.06 D105.B1 ; D105.B1 236.49,100.13 ; D105.B1 237.56,99.06 ; D105.B1 236.49,97.99 ; 15.51,57.35 D119.B1 ; D119.B1 16.58,58.42 ; D119.B1 15.51,59.49 ; D119.B1 14.44,58.42 ; 47.46,378.46 D431.B4 ; D431.B4 49.6,378.46 ; D431.B4 48.53,379.53 ; D431.B4 48.53,377.39 ; 124.73,390.09 D228.B3 ; D228.B3 125.8,391.16 ; D228.B3 124.73,392.23 ; D228.B3 123.66,391.16 ; 19.52,33.02 D120.A3 ; D120.A3 21.66,33.02 ; D120.A3 20.59,31.95 ; D120.A3 20.59,34.09 ; D427.A3 124.73,387.15 ; D427.A3 123.66,386.08 ; D427.A3 124.73,385.01 ; D427.A3 125.8,386.08 ; 121.12,403.86 D428.A4 ; D428.A4 122.19,402.79 ; D428.A4 122.19,404.93 ; D428.A4 123.26,403.86 ; CSDPS229.C5 47.06,330.2 ; CSDPS229.C5 45.99,329.13 ; CSDPS229.C5 45.99,331.27 ; CSDPS229.C5 44.92,330.2 ; 18.05,95.45 D117.A2 ; D117.A2 18.05,97.59 ; D117.A2 16.98,96.52 ; D117.A2 19.12,96.52 ; 18.37,348.29 UHC230.G4_11 ; UHC230.G4_11 19.99,348.29 ; UHC230.G4_11 19.18,347.48 ; UHC230.G4_11 19.18,349.1 ; 101.87,75.13 D122.A6 ; D122.A6 101.87,77.27 ; D122.A6 102.94,76.2 ; D122.A6 100.8,76.2 ; CSDPS426.B2 128.34,363.22 ; CSDPS426.B2 126.2,363.22 ; CSDPS426.B2 127.27,362.15 ; CSDPS426.B2 127.27,364.29 ; 165.37,346.91 D114.B16 ; D114.B16 164.3,347.98 ; D114.B16 165.37,349.05 ; D114.B16 166.44,347.98 ; D227.A4 123.26,373.38 ; D227.A4 122.19,372.31 ; D227.A4 121.12,373.38 ; D227.A4 122.19,374.45 ; 194.78,332.74 D113.A4 ; D113.A4 196.92,332.74 ; D113.A4 195.85,331.67 ; D113.A4 195.85,333.81 ; D106.A10 260.42,76.2 ; D106.A10 259.35,77.27 ; D106.A10 259.35,75.13 ; D106.A10 258.28,76.2 ; D102.A12 191.84,76.2 ; D102.A12 190.77,77.27 ; D102.A12 190.77,75.13 ; D102.A12 189.7,76.2 ; D113.A10 181.68,332.74 ; D113.A10 179.54,332.74 ; D113.A10 180.61,333.81 ; D113.A10 180.61,331.67 ; CSDPS429.B16 19.12,342.9 ; CSDPS429.B16 16.98,342.9 ; CSDPS429.B16 18.05,343.97 ; CSDPS429.B16 18.05,341.83 ; D115.A14 170.45,374.45 ; D115.A14 171.52,373.38 ; D115.A14 169.38,373.38 ; D115.A14 170.45,372.31 ; D120.B15 51.07,39.17 ; D120.B15 51.07,37.03 ; D120.B15 52.14,38.1 ; D120.B15 50,38.1 ; D120.A6 29.28,35.56 ; D120.A6 28.21,34.49 ; D120.A6 27.14,35.56 ; D120.A6 28.21,36.63 ; 51.07,77.67 D118.B15 ; D118.B15 52.14,78.74 ; D118.B15 51.07,79.81 ; D118.B15 50,78.74 ; D111.B3 273.12,370.84 ; D111.B3 272.05,369.77 ; D111.B3 272.05,371.91 ; D111.B3 270.98,370.84 ; D428.B13 99.33,402.39 ; D428.B13 99.33,400.25 ; D428.B13 98.26,401.32 ; D428.B13 100.4,401.32 ; 108.42,53.34 D123.A9 ; D123.A9 109.49,52.27 ; D123.A9 110.56,53.34 ; D123.A9 109.49,54.41 ; D432.B17 16.58,401.32 ; D432.B17 15.51,402.39 ; D432.B17 14.44,401.32 ; D432.B17 15.51,400.25 ; 89.17,369.77 D227.B17 ; D227.B17 90.24,370.84 ; D227.B17 88.1,370.84 ; D227.B17 89.17,371.91 ; D114.B1 204.54,350.52 ; D114.B1 203.47,351.59 ; D114.B1 203.47,349.45 ; D114.B1 202.4,350.52 ; 190.77,346.91 D114.B6 ; D114.B6 190.77,349.05 ; D114.B6 189.7,347.98 ; D114.B6 191.84,347.98 ; 90.64,60.96 D123.B2 ; D123.B2 91.71,59.89 ; D123.B2 91.71,62.03 ; D123.B2 92.78,60.96 ; 169.38,327.66 D113.B14 ; D113.B14 171.52,327.66 ; D113.B14 170.45,328.73 ; D113.B14 170.45,326.59 ; D232.B9 35.83,392.23 ; D232.B9 35.83,390.09 ; D232.B9 34.76,391.16 ; D232.B9 36.9,391.16 ; 184.62,101.6 D101.B10 ; D101.B10 185.69,102.67 ; D101.B10 186.76,101.6 ; D101.B10 185.69,100.53 ; 268.44,101.6 D105.B14 ; D105.B14 270.58,101.6 ; D105.B14 269.51,100.53 ; D105.B14 269.51,102.67 ; 237.96,368.3 D111.B16 ; D111.B16 239.03,367.23 ; D111.B16 240.1,368.3 ; D111.B16 239.03,369.37 ; D101.B9 183.15,100.13 ; D101.B9 184.22,99.06 ; D101.B9 182.08,99.06 ; D101.B9 183.15,97.99 ; D107.B14 269.51,62.03 ; D107.B14 268.44,60.96 ; D107.B14 270.58,60.96 ; D107.B14 269.51,59.89 ; 91.71,331.67 CSDPS225.B16 ; CSDPS225.B16 91.71,333.81 ; CSDPS225.B16 90.64,332.74 ; CSDPS225.B16 92.78,332.74 ; 258.28,55.88 D107.A10 ; D107.A10 259.35,56.95 ; D107.A10 260.42,55.88 ; D107.A10 259.35,54.81 ; D124.B11 115.64,38.1 ; D124.B11 114.57,37.03 ; D124.B11 114.57,39.17 ; D124.B11 113.5,38.1 ; DPS2.B11 179.14,412.75 ; DPS2.B11 177,412.75 ; DPS2.B11 178.07,413.82 ; DPS2.B11 178.07,411.68 ; 50,33.02 D120.A15 ; D120.A15 52.14,33.02 ; D120.A15 51.07,31.95 ; D120.A15 51.07,34.09 ; 116.04,393.7 D228.A6 ; D228.A6 117.11,392.63 ; D228.A6 118.18,393.7 ; D228.A6 117.11,394.77 ; D103.A11 189.3,53.34 ; D103.A11 188.23,52.27 ; D103.A11 188.23,54.41 ; D103.A11 187.16,53.34 ; D105.B5 247.72,99.06 ; D105.B5 246.65,100.13 ; D105.B5 246.65,97.99 ; D105.B5 245.58,99.06 ; 244.11,346.91 D110.B14 ; D110.B14 243.04,347.98 ; D110.B14 244.11,349.05 ; D110.B14 245.18,347.98 ; D112.B11 251.73,392.23 ; D112.B11 250.66,391.16 ; D112.B11 251.73,390.09 ; D112.B11 252.8,391.16 ; 199.86,353.06 D114.A2 ; D114.A2 200.93,351.99 ; D114.A2 202,353.06 ; D114.A2 200.93,354.13 ; D124.B15 125.8,38.1 ; D124.B15 124.73,37.03 ; D124.B15 124.73,39.17 ; D124.B15 123.66,38.1 ; D102.B6 176.6,81.28 ; D102.B6 174.46,81.28 ; D102.B6 175.53,80.21 ; D102.B6 175.53,82.35 ; 53.61,100.53 D117.B16 ; D117.B16 54.68,101.6 ; D117.B16 52.54,101.6 ; D117.B16 53.61,102.67 ; 14.44,406.4 D432.A17 ; D432.A17 15.51,405.33 ; D432.A17 16.58,406.4 ; D432.A17 15.51,407.47 ; D431.B10 33.29,379.53 ; D431.B10 34.36,378.46 ; D431.B10 32.22,378.46 ; D431.B10 33.29,377.39 ; 42.38,393.7 D232.A6 ; D232.A6 43.45,394.77 ; D232.A6 43.45,392.63 ; D232.A6 44.52,393.7 ; 14.92,363.7 UHC430.G1_5 ; UHC430.G1_5 15.73,364.51 ; UHC430.G1_5 16.54,363.7 ; UHC430.G1_5 15.73,362.89 ; D118.A16 54.68,76.2 ; D118.A16 53.61,77.27 ; D118.A16 53.61,75.13 ; D118.A16 52.54,76.2 ; D116.A9 183.15,397.31 ; D116.A9 183.15,395.17 ; D116.A9 184.22,396.24 ; D116.A9 182.08,396.24 ; UHC230.G3 46.68,352.6 ; UHC230.G3 47.49,351.79 ; UHC230.G3 45.87,351.79 ; UHC230.G3 46.68,350.98 ; 32.22,368.3 D231.B10 ; D231.B10 33.29,369.37 ; D231.B10 34.36,368.3 ; D231.B10 33.29,367.23 ; D115.B7 188.23,371.91 ; D115.B7 189.3,370.84 ; D115.B7 187.16,370.84 ; D115.B7 188.23,369.77 ; D232.B8 39.44,388.62 ; D232.B8 38.37,387.55 ; D232.B8 37.3,388.62 ; D232.B8 38.37,389.69 ; 25.67,31.95 D120.A5 ; D120.A5 24.6,33.02 ; D120.A5 25.67,34.09 ; D120.A5 26.74,33.02 ; 171.92,355.6 D114.A13 ; D114.A13 172.99,356.67 ; D114.A13 172.99,354.53 ; D114.A13 174.06,355.6 ; 40.91,329.13 CSDPS229.C7 ; CSDPS229.C7 41.98,330.2 ; CSDPS229.C7 40.91,331.27 ; CSDPS229.C7 39.84,330.2 ; 260.82,73.66 D106.A11 ; D106.A11 261.89,72.59 ; D106.A11 262.96,73.66 ; D106.A11 261.89,74.73 ; 121.12,76.2 D122.A14 ; D122.A14 122.19,75.13 ; D122.A14 122.19,77.27 ; D122.A14 123.26,76.2 ; D124.B7 105.48,38.1 ; D124.B7 104.41,37.03 ; D124.B7 103.34,38.1 ; D124.B7 104.41,39.17 ; 43.45,402.79 D432.A6 ; D432.A6 44.52,403.86 ; D432.A6 43.45,404.93 ; D432.A6 42.38,403.86 ; 127.27,80.21 D122.B16 ; D122.B16 127.27,82.35 ; D122.B16 128.34,81.28 ; D122.B16 126.2,81.28 ; 263.36,55.88 D107.A12 ; D107.A12 265.5,55.88 ; D107.A12 264.43,56.95 ; D107.A12 264.43,54.81 ; D228.B16 92.78,388.62 ; D228.B16 91.71,387.55 ; D228.B16 91.71,389.69 ; D228.B16 90.64,388.62 ; 45.53,359.39 UHC430.G2_10 ; UHC430.G2_10 44.72,360.2 ; UHC430.G2_10 45.53,361.01 ; UHC430.G2_10 46.34,360.2 ; 32.22,373.38 D231.A10 ; D231.A10 33.29,372.31 ; D231.A10 34.36,373.38 ; D231.A10 33.29,374.45 ; D121.A5 99.33,95.05 ; D121.A5 100.4,93.98 ; D121.A5 99.33,92.91 ; D121.A5 98.26,93.98 ; D103.A7 179.14,53.34 ; D103.A7 177,53.34 ; D103.A7 178.07,54.41 ; D103.A7 178.07,52.27 ; 20.59,369.77 D231.B15 ; D231.B15 19.52,370.84 ; D231.B15 20.59,371.91 ; D231.B15 21.66,370.84 ; D113.B11 179.14,330.2 ; D113.B11 177,330.2 ; D113.B11 178.07,331.27 ; D113.B11 178.07,329.13 ; 200.93,367.23 D115.B2 ; D115.B2 202,368.3 ; D115.B2 199.86,368.3 ; D115.B2 200.93,369.37 ; UHC430.G1_1 19.99,365.45 ; UHC430.G1_1 19.18,364.64 ; UHC430.G1_1 19.18,366.26 ; UHC430.G1_1 18.37,365.45 ; UHC430.G1_9 18.03,361.01 ; UHC430.G1_9 18.84,360.2 ; UHC430.G1_9 17.22,360.2 ; UHC430.G1_9 18.03,359.39 ; 91.71,392.63 D228.A16 ; D228.A16 92.78,393.7 ; D228.A16 90.64,393.7 ; D228.A16 91.71,394.77 ; 28.21,54.81 D119.A6 ; D119.A6 28.21,56.95 ; D119.A6 29.28,55.88 ; D119.A6 27.14,55.88 ; 20.59,92.91 D117.A3 ; D117.A3 19.52,93.98 ; D117.A3 20.59,95.05 ; D117.A3 21.66,93.98 ; D103.B13 193.31,59.49 ; D103.B13 194.38,58.42 ; D103.B13 193.31,57.35 ; D103.B13 192.24,58.42 ; 167.91,414.22 DPS2.A15 ; DPS2.A15 166.84,415.29 ; DPS2.A15 167.91,416.36 ; DPS2.A15 168.98,415.29 ; 106.95,39.57 D124.B8 ; D124.B8 106.95,41.71 ; D124.B8 108.02,40.64 ; D124.B8 105.88,40.64 ; 44.92,58.42 D119.B13 ; D119.B13 45.99,59.49 ; D119.B13 45.99,57.35 ; D119.B13 47.06,58.42 ; D102.A4 170.45,77.27 ; D102.A4 169.38,76.2 ; D102.A4 170.45,75.13 ; D102.A4 171.52,76.2 ; 123.66,33.02 D124.A15 ; D124.A15 125.8,33.02 ; D124.A15 124.73,34.09 ; D124.A15 124.73,31.95 ; D232.B14 24.2,388.62 ; D232.B14 22.06,388.62 ; D232.B14 23.13,389.69 ; D232.B14 23.13,387.55 ; 18.05,59.89 D119.B2 ; D119.B2 16.98,60.96 ; D119.B2 18.05,62.03 ; D119.B2 19.12,60.96 ; D428.B14 96.79,399.85 ; D428.B14 97.86,398.78 ; D428.B14 96.79,397.71 ; D428.B14 95.72,398.78 ; 199.86,393.7 D116.A2 ; D116.A2 200.93,392.63 ; D116.A2 200.93,394.77 ; D116.A2 202,393.7 ; 108.42,386.08 D427.A9 ; D427.A9 110.56,386.08 ; D427.A9 109.49,385.01 ; D427.A9 109.49,387.15 ; UHC430.G2_6 48.98,362.76 ; UHC430.G2_6 49.79,361.95 ; UHC430.G2_6 48.17,361.95 ; UHC430.G2_6 48.98,361.14 ; D120.B11 41.98,38.1 ; D120.B11 40.91,37.03 ; D120.B11 39.84,38.1 ; D120.B11 40.91,39.17 ; D232.B12 29.28,388.62 ; D232.B12 28.21,387.55 ; D232.B12 27.14,388.62 ; D232.B12 28.21,389.69 ; D121.B1 90.24,99.06 ; D121.B1 89.17,100.13 ; D121.B1 89.17,97.99 ; D121.B1 88.1,99.06 ; 274.59,346.91 D110.B2 ; D110.B2 273.52,347.98 ; D110.B2 274.59,349.05 ; D110.B2 275.66,347.98 ; D101.A6 176.6,96.52 ; D101.A6 174.46,96.52 ; D101.A6 175.53,95.45 ; D101.A6 175.53,97.59 ; 53.61,377.39 D431.B2 ; D431.B2 54.68,378.46 ; D431.B2 52.54,378.46 ; D431.B2 53.61,379.53 ; D111.B2 274.59,369.37 ; D111.B2 275.66,368.3 ; D111.B2 274.59,367.23 ; D111.B2 273.52,368.3 ; D119.B15 51.07,59.49 ; D119.B15 52.14,58.42 ; D119.B15 51.07,57.35 ; D119.B15 50,58.42 ; CSDPS426.C9 110.56,360.68 ; CSDPS426.C9 109.49,359.61 ; CSDPS426.C9 108.42,360.68 ; CSDPS426.C9 109.49,361.75 ; 182.08,58.42 D103.B9 ; D103.B9 183.15,59.49 ; D103.B9 183.15,57.35 ; D103.B9 184.22,58.42 ; 48.17,351.79 UHC230.G3_6 ; UHC230.G3_6 49.79,351.79 ; UHC230.G3_6 48.98,350.98 ; UHC230.G3_6 48.98,352.6 ; D104.A1 162.83,34.09 ; D104.A1 161.76,33.02 ; D104.A1 162.83,31.95 ; D104.A1 163.9,33.02 ; 183.15,72.59 D102.A9 ; D102.A9 183.15,74.73 ; D102.A9 182.08,73.66 ; D102.A9 184.22,73.66 ; DPS8.B11 30.75,413.82 ; DPS8.B11 29.68,412.75 ; DPS8.B11 30.75,411.68 ; DPS8.B11 31.82,412.75 ; 245.58,38.1 D108.B5 ; D108.B5 246.65,37.03 ; D108.B5 246.65,39.17 ; D108.B5 247.72,38.1 ; 103.34,330.2 CSDPS225.C11 ; CSDPS225.C11 104.41,331.27 ; CSDPS225.C11 104.41,329.13 ; CSDPS225.C11 105.48,330.2 ; 265.9,350.52 D110.B5 ; D110.B5 268.04,350.52 ; D110.B5 266.97,351.59 ; D110.B5 266.97,349.45 ; 180.61,100.53 D101.B8 ; D101.B8 179.54,101.6 ; D101.B8 181.68,101.6 ; D101.B8 180.61,102.67 ; CSDPS229.B8 38.37,333.81 ; CSDPS229.B8 37.3,332.74 ; CSDPS229.B8 38.37,331.67 ; CSDPS229.B8 39.44,332.74 ; 35.83,97.99 D117.B9 ; D117.B9 36.9,99.06 ; D117.B9 35.83,100.13 ; D117.B9 34.76,99.06 ; 14.44,99.06 D117.B1 ; D117.B1 16.58,99.06 ; D117.B1 15.51,100.13 ; D117.B1 15.51,97.99 ; 276.06,350.52 D110.B1 ; D110.B1 277.13,349.45 ; D110.B1 277.13,351.59 ; D110.B1 278.2,350.52 ; D432.B4 48.53,399.85 ; D432.B4 48.53,397.71 ; D432.B4 47.46,398.78 ; D432.B4 49.6,398.78 ; D104.A10 186.76,35.56 ; D104.A10 185.69,34.49 ; D104.A10 185.69,36.63 ; D104.A10 184.62,35.56 ; D227.B14 96.79,369.37 ; D227.B14 95.72,368.3 ; D227.B14 96.79,367.23 ; D227.B14 97.86,368.3 ; 170.45,351.99 D114.A14 ; D114.A14 170.45,354.13 ; D114.A14 171.52,353.06 ; D114.A14 169.38,353.06 ; D111.B11 251.73,371.91 ; D111.B11 251.73,369.77 ; D111.B11 252.8,370.84 ; D111.B11 250.66,370.84 ; 39.84,33.02 D120.A11 ; D120.A11 40.91,31.95 ; D120.A11 40.91,34.09 ; D120.A11 41.98,33.02 ; 127.27,377.39 D427.B2 ; D427.B2 127.27,379.53 ; D427.B2 128.34,378.46 ; D427.B2 126.2,378.46 ; D228.A14 97.86,393.7 ; D228.A14 95.72,393.7 ; D228.A14 96.79,392.63 ; D228.A14 96.79,394.77 ; D428.A12 101.87,404.93 ; D428.A12 101.87,402.79 ; D428.A12 100.8,403.86 ; D428.A12 102.94,403.86 ; D113.A7 189.3,335.28 ; D113.A7 188.23,334.21 ; D113.A7 187.16,335.28 ; D113.A7 188.23,336.35 ; 274.59,34.49 D108.A16 ; D108.A16 275.66,35.56 ; D108.A16 273.52,35.56 ; D108.A16 274.59,36.63 ; 273.52,60.96 D107.B16 ; D107.B16 274.59,59.89 ; D107.B16 275.66,60.96 ; D107.B16 274.59,62.03 ; 192.24,93.98 D101.A13 ; D101.A13 193.31,92.91 ; D101.A13 194.38,93.98 ; D101.A13 193.31,95.05 ; UHC430.G2_13 45.19,358.45 ; UHC430.G2_13 44.38,357.64 ; UHC430.G2_13 43.57,358.45 ; UHC430.G2_13 44.38,359.26 ; 122.19,100.53 D121.B14 ; D121.B14 123.26,101.6 ; D121.B14 122.19,102.67 ; D121.B14 121.12,101.6 ; 43.45,80.21 D118.B12 ; D118.B12 42.38,81.28 ; D118.B12 44.52,81.28 ; D118.B12 43.45,82.35 ; D114.B12 175.53,349.05 ; D114.B12 176.6,347.98 ; D114.B12 174.46,347.98 ; D114.B12 175.53,346.91 ; D121.A7 104.41,95.05 ; D121.A7 104.41,92.91 ; D121.A7 105.48,93.98 ; D121.A7 103.34,93.98 ; 170.45,387.55 D116.B14 ; D116.B14 171.52,388.62 ; D116.B14 169.38,388.62 ; D116.B14 170.45,389.69 ; D101.B7 178.07,100.13 ; D101.B7 179.14,99.06 ; D101.B7 177,99.06 ; D101.B7 178.07,97.99 ; 246.65,334.21 D109.A13 ; D109.A13 246.65,336.35 ; D109.A13 247.72,335.28 ; D109.A13 245.58,335.28 ; 14.44,78.74 D118.B1 ; D118.B1 15.51,77.67 ; D118.B1 15.51,79.81 ; D118.B1 16.58,78.74 ; 189.7,393.7 D116.A6 ; D116.A6 190.77,392.63 ; D116.A6 191.84,393.7 ; D116.A6 190.77,394.77 ; 193.31,390.09 D116.B5 ; D116.B5 194.38,391.16 ; D116.B5 192.24,391.16 ; D116.B5 193.31,392.23 ; D427.B13 100.4,381 ; D427.B13 98.26,381 ; D427.B13 99.33,379.93 ; D427.B13 99.33,382.07 ; D123.A13 120.72,53.34 ; D123.A13 119.65,52.27 ; D123.A13 119.65,54.41 ; D123.A13 118.58,53.34 ; 260.82,53.34 D107.A11 ; D107.A11 262.96,53.34 ; D107.A11 261.89,52.27 ; D107.A11 261.89,54.41 ; D103.B15 198.39,59.49 ; D103.B15 199.46,58.42 ; D103.B15 198.39,57.35 ; D103.B15 197.32,58.42 ; 50,381 D431.B3 ; D431.B3 51.07,382.07 ; D431.B3 51.07,379.93 ; D431.B3 52.14,381 ; 18.05,80.21 D118.B2 ; D118.B2 19.12,81.28 ; D118.B2 18.05,82.35 ; D118.B2 16.98,81.28 ; 276.06,375.92 D111.A1 ; D111.A1 277.13,376.99 ; D111.A1 278.2,375.92 ; D111.A1 277.13,374.85 ; 169.38,332.74 D113.A14 ; D113.A14 171.52,332.74 ; D113.A14 170.45,331.67 ; D113.A14 170.45,333.81 ; 25.67,97.99 D117.B5 ; D117.B5 26.74,99.06 ; D117.B5 24.6,99.06 ; D117.B5 25.67,100.13 ; 89.17,12.9 DPS3.A01 ; DPS3.A01 88.1,13.97 ; DPS3.A01 89.17,15.04 ; DPS3.A01 90.24,13.97 ; D227.A15 95.32,375.92 ; D227.A15 94.25,374.85 ; D227.A15 93.18,375.92 ; D227.A15 94.25,376.99 ; D231.A12 29.28,373.38 ; D231.A12 28.21,374.45 ; D231.A12 27.14,373.38 ; D231.A12 28.21,372.31 ; 250.66,375.92 D111.A11 ; D111.A11 252.8,375.92 ; D111.A11 251.73,376.99 ; D111.A11 251.73,374.85 ; 266.97,354.53 D110.A5 ; D110.A5 266.97,356.67 ; D110.A5 265.9,355.6 ; D110.A5 268.04,355.6 ; 253.2,35.56 D108.A8 ; D108.A8 255.34,35.56 ; D108.A8 254.27,34.49 ; D108.A8 254.27,36.63 ; 56.15,411.68 DPS8.B01 ; DPS8.B01 57.22,412.75 ; DPS8.B01 55.08,412.75 ; DPS8.B01 56.15,413.82 ; DPS2.C05 194.38,410.21 ; DPS2.C05 193.31,411.28 ; DPS2.C05 193.31,409.14 ; DPS2.C05 192.24,410.21 ; 43.45,34.49 D120.A12 ; D120.A12 42.38,35.56 ; D120.A12 43.45,36.63 ; D120.A12 44.52,35.56 ; D104.A4 170.45,36.63 ; D104.A4 170.45,34.49 ; D104.A4 171.52,35.56 ; D104.A4 169.38,35.56 ; D111.A4 269.51,374.45 ; D111.A4 268.44,373.38 ; D111.A4 269.51,372.31 ; D111.A4 270.58,373.38 ; 169.38,40.64 D104.B4 ; D104.B4 170.45,41.71 ; D104.B4 171.52,40.64 ; D104.B4 170.45,39.57 ; 184.62,60.96 D103.B10 ; D103.B10 186.76,60.96 ; D103.B10 185.69,59.89 ; D103.B10 185.69,62.03 ; 124.73,400.25 D428.B3 ; D428.B3 125.8,401.32 ; D428.B3 123.66,401.32 ; D428.B3 124.73,402.39 ; D113.B8 186.76,327.66 ; D113.B8 185.69,326.59 ; D113.B8 185.69,328.73 ; D113.B8 184.62,327.66 ; D232.B15 21.66,391.16 ; D232.B15 20.59,392.23 ; D232.B15 19.52,391.16 ; D232.B15 20.59,390.09 ; D118.B5 26.74,78.74 ; D118.B5 25.67,77.67 ; D118.B5 24.6,78.74 ; D118.B5 25.67,79.81 ; D105.B12 265.5,101.6 ; D105.B12 264.43,102.67 ; D105.B12 263.36,101.6 ; D105.B12 264.43,100.53 ; D431.A5 47.06,386.08 ; D431.A5 44.92,386.08 ; D431.A5 45.99,385.01 ; D431.A5 45.99,387.15 ; 51.07,97.99 D117.B15 ; D117.B15 50,99.06 ; D117.B15 51.07,100.13 ; D117.B15 52.14,99.06 ; UHC430.G1_12 17.69,358.45 ; UHC430.G1_12 16.88,357.64 ; UHC430.G1_12 16.07,358.45 ; UHC430.G1_12 16.88,359.26 ; D104.B7 179.14,38.1 ; D104.B7 178.07,37.03 ; D104.B7 178.07,39.17 ; D104.B7 177,38.1 ; 56.15,374.85 D231.A1 ; D231.A1 55.08,375.92 ; D231.A1 56.15,376.99 ; D231.A1 57.22,375.92 ; D232.A12 29.28,393.7 ; D232.A12 28.21,392.63 ; D232.A12 27.14,393.7 ; D232.A12 28.21,394.77 ; 244.11,34.49 D108.A4 ; D108.A4 244.11,36.63 ; D108.A4 243.04,35.56 ; D108.A4 245.18,35.56 ; CSDPS229.B12 29.28,332.74 ; CSDPS229.B12 27.14,332.74 ; CSDPS229.B12 28.21,331.67 ; CSDPS229.B12 28.21,333.81 ; D124.A16 127.27,36.63 ; D124.A16 126.2,35.56 ; D124.A16 127.27,34.49 ; D124.A16 128.34,35.56 ; 100.8,35.56 D124.A6 ; D124.A6 101.87,34.49 ; D124.A6 101.87,36.63 ; D124.A6 102.94,35.56 ; D232.A2 53.61,394.77 ; D232.A2 53.61,392.63 ; D232.A2 52.54,393.7 ; D232.A2 54.68,393.7 ; 103.34,396.24 D228.A11 ; D228.A11 104.41,397.31 ; D228.A11 105.48,396.24 ; D228.A11 104.41,395.17 ; 241.57,369.77 D111.B15 ; D111.B15 241.57,371.91 ; D111.B15 242.64,370.84 ; D111.B15 240.5,370.84 ; 199.86,81.28 D102.B16 ; D102.B16 200.93,82.35 ; D102.B16 200.93,80.21 ; D102.B16 202,81.28 ; D428.A6 118.18,403.86 ; D428.A6 116.04,403.86 ; D428.A6 117.11,402.79 ; D428.A6 117.11,404.93 ; CSDPS425.B8 112.03,343.97 ; CSDPS425.B8 110.96,342.9 ; CSDPS425.B8 112.03,341.83 ; CSDPS425.B8 113.1,342.9 ; 47.83,349.23 UHC230.G3_9 ; UHC230.G3_9 48.64,350.04 ; UHC230.G3_9 47.02,350.04 ; UHC230.G3_9 47.83,350.85 ; D110.B4 270.58,347.98 ; D110.B4 268.44,347.98 ; D110.B4 269.51,346.91 ; D110.B4 269.51,349.05 ; D115.B4 196.92,368.3 ; D115.B4 195.85,367.23 ; D115.B4 195.85,369.37 ; D115.B4 194.78,368.3 ; 192.24,335.28 D113.A5 ; D113.A5 193.31,334.21 ; D113.A5 193.31,336.35 ; D113.A5 194.38,335.28 ; D101.B12 190.77,102.67 ; D101.B12 190.77,100.53 ; D101.B12 191.84,101.6 ; D101.B12 189.7,101.6 ; D109.A9 256.81,336.35 ; D109.A9 255.74,335.28 ; D109.A9 257.88,335.28 ; D109.A9 256.81,334.21 ; 255.74,99.06 D105.B9 ; D105.B9 256.81,97.99 ; D105.B9 257.88,99.06 ; D105.B9 256.81,100.13 ; D231.B12 29.28,368.3 ; D231.B12 28.21,367.23 ; D231.B12 28.21,369.37 ; D231.B12 27.14,368.3 ; D428.B7 115.64,401.32 ; D428.B7 114.57,402.39 ; D428.B7 113.5,401.32 ; D428.B7 114.57,400.25 ; D119.B12 44.52,60.96 ; D119.B12 43.45,59.89 ; D119.B12 42.38,60.96 ; D119.B12 43.45,62.03 ; 91.71,39.57 D124.B2 ; D124.B2 90.64,40.64 ; D124.B2 92.78,40.64 ; D124.B2 91.71,41.71 ; D115.A12 176.6,373.38 ; D115.A12 175.53,372.31 ; D115.A12 174.46,373.38 ; D115.A12 175.53,374.45 ; 122.19,59.89 D123.B14 ; D123.B14 121.12,60.96 ; D123.B14 123.26,60.96 ; D123.B14 122.19,62.03 ; D227.B12 102.94,368.3 ; D227.B12 100.8,368.3 ; D227.B12 101.87,369.37 ; D227.B12 101.87,367.23 ; D105.B7 251.73,100.13 ; D105.B7 252.8,99.06 ; D105.B7 250.66,99.06 ; D105.B7 251.73,97.99 ; UHC230.G4_9 18.03,350.85 ; UHC230.G4_9 18.84,350.04 ; UHC230.G4_9 18.03,349.23 ; UHC230.G4_9 17.22,350.04 ; 268.44,40.64 D108.B14 ; D108.B14 270.58,40.64 ; D108.B14 269.51,39.57 ; D108.B14 269.51,41.71 ; D119.A3 21.66,53.34 ; D119.A3 20.59,52.27 ; D119.A3 20.59,54.41 ; D119.A3 19.52,53.34 ; D122.B2 91.71,82.35 ; D122.B2 90.64,81.28 ; D122.B2 92.78,81.28 ; D122.B2 91.71,80.21 ; CSDPS429.C5 47.06,340.36 ; CSDPS429.C5 44.92,340.36 ; CSDPS429.C5 45.99,341.43 ; CSDPS429.C5 45.99,339.29 ; 100.8,373.38 D227.A12 ; D227.A12 101.87,374.45 ; D227.A12 102.94,373.38 ; D227.A12 101.87,372.31 ; 45.99,77.67 D118.B13 ; D118.B13 47.06,78.74 ; D118.B13 44.92,78.74 ; D118.B13 45.99,79.81 ; D124.B5 99.33,39.17 ; D124.B5 100.4,38.1 ; D124.B5 99.33,37.03 ; D124.B5 98.26,38.1 ; D121.A14 123.26,96.52 ; D121.A14 122.19,95.45 ; D121.A14 121.12,96.52 ; D121.A14 122.19,97.59 ; CSDPS429.C1 56.15,341.43 ; CSDPS429.C1 55.08,340.36 ; CSDPS429.C1 57.22,340.36 ; CSDPS429.C1 56.15,339.29 ; 127.27,54.81 D123.A16 ; D123.A16 127.27,56.95 ; D123.A16 128.34,55.88 ; D123.A16 126.2,55.88 ; 260.82,330.2 D109.B7 ; D109.B7 262.96,330.2 ; D109.B7 261.89,329.13 ; D109.B7 261.89,331.27 ; 33.29,387.55 D232.B10 ; D232.B10 34.36,388.62 ; D232.B10 33.29,389.69 ; D232.B10 32.22,388.62 ; 101.87,377.39 D427.B12 ; D427.B12 101.87,379.53 ; D427.B12 102.94,378.46 ; D427.B12 100.8,378.46 ; 237.96,81.28 D106.B2 ; D106.B2 239.03,82.35 ; D106.B2 240.1,81.28 ; D106.B2 239.03,80.21 ; 172.99,374.85 D115.A13 ; D115.A13 174.06,375.92 ; D115.A13 171.92,375.92 ; D115.A13 172.99,376.99 ; D111.A9 256.81,376.99 ; D111.A9 256.81,374.85 ; D111.A9 257.88,375.92 ; D111.A9 255.74,375.92 ; D118.A8 34.36,76.2 ; D118.A8 33.29,75.13 ; D118.A8 32.22,76.2 ; D118.A8 33.29,77.27 ; D431.A3 52.14,386.08 ; D431.A3 50,386.08 ; D431.A3 51.07,385.01 ; D431.A3 51.07,387.15 ; D432.A10 33.29,404.93 ; D432.A10 34.36,403.86 ; D432.A10 32.22,403.86 ; D432.A10 33.29,402.79 ; 164.3,81.28 D102.B2 ; D102.B2 166.44,81.28 ; D102.B2 165.37,82.35 ; D102.B2 165.37,80.21 ; 177,350.52 D114.B11 ; D114.B11 178.07,349.45 ; D114.B11 179.14,350.52 ; D114.B11 178.07,351.59 ; 169.38,393.7 D116.A14 ; D116.A14 171.52,393.7 ; D116.A14 170.45,392.63 ; D116.A14 170.45,394.77 ; 127.27,100.53 D121.B16 ; D121.B16 126.2,101.6 ; D121.B16 127.27,102.67 ; D121.B16 128.34,101.6 ; D110.B13 247.72,350.52 ; D110.B13 246.65,351.59 ; D110.B13 246.65,349.45 ; D110.B13 245.58,350.52 ; D118.B14 48.53,82.35 ; D118.B14 49.6,81.28 ; D118.B14 48.53,80.21 ; D118.B14 47.46,81.28 ; D123.A7 105.48,53.34 ; D123.A7 104.41,54.41 ; D123.A7 104.41,52.27 ; D123.A7 103.34,53.34 ; CSDPS429.B14 24.2,342.9 ; CSDPS429.B14 23.13,341.83 ; CSDPS429.B14 23.13,343.97 ; CSDPS429.B14 22.06,342.9 ; 172.99,349.45 D114.B13 ; D114.B13 171.92,350.52 ; D114.B13 172.99,351.59 ; D114.B13 174.06,350.52 ; D228.B5 119.65,392.23 ; D228.B5 120.72,391.16 ; D228.B5 118.58,391.16 ; D228.B5 119.65,390.09 ; 264.43,59.89 D107.B12 ; D107.B12 265.5,60.96 ; D107.B12 263.36,60.96 ; D107.B12 264.43,62.03 ; D111.A6 265.5,373.38 ; D111.A6 263.36,373.38 ; D111.A6 264.43,374.45 ; D111.A6 264.43,372.31 ; D431.A1 56.15,387.15 ; D431.A1 56.15,385.01 ; D431.A1 55.08,386.08 ; D431.A1 57.22,386.08 ; D105.A2 239.03,97.59 ; D105.A2 239.03,95.45 ; D105.A2 237.96,96.52 ; D105.A2 240.1,96.52 ; 13.77,365.45 UHC430.G1_3 ; UHC430.G1_3 15.39,365.45 ; UHC430.G1_3 14.58,364.64 ; UHC430.G1_3 14.58,366.26 ; D428.B17 89.17,402.39 ; D428.B17 88.1,401.32 ; D428.B17 90.24,401.32 ; D428.B17 89.17,400.25 ; 237.96,373.38 D111.A16 ; D111.A16 239.03,374.45 ; D111.A16 240.1,373.38 ; D111.A16 239.03,372.31 ; 179.54,76.2 D102.A8 ; D102.A8 180.61,75.13 ; D102.A8 180.61,77.27 ; D102.A8 181.68,76.2 ; 124.73,374.85 D227.A3 ; D227.A3 124.73,376.99 ; D227.A3 125.8,375.92 ; D227.A3 123.66,375.92 ; 265.9,370.84 D111.B5 ; D111.B5 266.97,369.77 ; D111.B5 268.04,370.84 ; D111.B5 266.97,371.91 ; 261.89,92.91 D105.A11 ; D105.A11 261.89,95.05 ; D105.A11 260.82,93.98 ; D105.A11 262.96,93.98 ; 34.76,381 D431.B9 ; D431.B9 36.9,381 ; D431.B9 35.83,382.07 ; D431.B9 35.83,379.93 ; 124.73,349.45 CSDPS226.C3 ; CSDPS226.C3 123.66,350.52 ; CSDPS226.C3 125.8,350.52 ; CSDPS226.C3 124.73,351.59 ; 114.57,15.44 DPS3.B11 ; DPS3.B11 114.57,17.58 ; DPS3.B11 113.5,16.51 ; DPS3.B11 115.64,16.51 ; 199.86,373.38 D115.A2 ; D115.A2 200.93,374.45 ; D115.A2 202,373.38 ; D115.A2 200.93,372.31 ; 244.11,54.81 D107.A4 ; D107.A4 243.04,55.88 ; D107.A4 244.11,56.95 ; D107.A4 245.18,55.88 ; 99.33,12.9 DPS3.A05 ; DPS3.A05 98.26,13.97 ; DPS3.A05 99.33,15.04 ; DPS3.A05 100.4,13.97 ; CSDPS425.B16 92.78,342.9 ; CSDPS425.B16 90.64,342.9 ; CSDPS425.B16 91.71,343.97 ; CSDPS425.B16 91.71,341.83 ; D232.B11 30.75,392.23 ; D232.B11 31.82,391.16 ; D232.B11 30.75,390.09 ; D232.B11 29.68,391.16 ; 166.84,391.16 D116.B15 ; D116.B15 168.98,391.16 ; D116.B15 167.91,392.23 ; D116.B15 167.91,390.09 ; D101.B6 176.6,101.6 ; D101.B6 174.46,101.6 ; D101.B6 175.53,100.53 ; D101.B6 175.53,102.67 ; 188.23,77.67 D102.B11 ; D102.B11 187.16,78.74 ; D102.B11 189.3,78.74 ; D102.B11 188.23,79.81 ; 118.58,386.08 D427.A5 ; D427.A5 119.65,387.15 ; D427.A5 120.72,386.08 ; D427.A5 119.65,385.01 ; 35.83,37.03 D120.B9 ; D120.B9 34.76,38.1 ; D120.B9 36.9,38.1 ; D120.B9 35.83,39.17 ; D112.B5 266.97,392.23 ; D112.B5 266.97,390.09 ; D112.B5 268.04,391.16 ; D112.B5 265.9,391.16 ; D122.B3 95.32,78.74 ; D122.B3 93.18,78.74 ; D122.B3 94.25,79.81 ; D122.B3 94.25,77.67 ; D120.B3 20.59,39.17 ; D120.B3 21.66,38.1 ; D120.B3 20.59,37.03 ; D120.B3 19.52,38.1 ; 116.04,373.38 D227.A6 ; D227.A6 117.11,374.45 ; D227.A6 118.18,373.38 ; D227.A6 117.11,372.31 ; 34.76,386.08 D431.A9 ; D431.A9 35.83,387.15 ; D431.A9 36.9,386.08 ; D431.A9 35.83,385.01 ; 15.51,72.59 D118.A1 ; D118.A1 16.58,73.66 ; D118.A1 15.51,74.73 ; D118.A1 14.44,73.66 ; CSDPS226.C9 109.49,351.59 ; CSDPS226.C9 108.42,350.52 ; CSDPS226.C9 110.56,350.52 ; CSDPS226.C9 109.49,349.45 ; D427.A16 91.71,384.61 ; D427.A16 92.78,383.54 ; D427.A16 90.64,383.54 ; D427.A16 91.71,382.47 ; D112.B7 262.96,391.16 ; D112.B7 261.89,390.09 ; D112.B7 261.89,392.23 ; D112.B7 260.82,391.16 ; 13.77,358.45 UHC430.G1_13 ; UHC430.G1_13 15.39,358.45 ; UHC430.G1_13 14.58,357.64 ; UHC430.G1_13 14.58,359.26 ; 30.75,395.17 D232.A11 ; D232.A11 30.75,397.31 ; D232.A11 31.82,396.24 ; D232.A11 29.68,396.24 ; 27.14,101.6 D117.B6 ; D117.B6 28.21,100.53 ; D117.B6 28.21,102.67 ; D117.B6 29.28,101.6 ; D114.B15 168.98,350.52 ; D114.B15 166.84,350.52 ; D114.B15 167.91,351.59 ; D114.B15 167.91,349.45 ; UHC230.G3_12 46.68,349.1 ; UHC230.G3_12 47.49,348.29 ; UHC230.G3_12 46.68,347.48 ; UHC230.G3_12 45.87,348.29 ; D104.A16 200.93,36.63 ; D104.A16 200.93,34.49 ; D104.A16 202,35.56 ; D104.A16 199.86,35.56 ; 24.6,406.4 D432.A13 ; D432.A13 25.67,405.33 ; D432.A13 25.67,407.47 ; D432.A13 26.74,406.4 ; 106.95,392.63 D228.A10 ; D228.A10 108.02,393.7 ; D228.A10 105.88,393.7 ; D228.A10 106.95,394.77 ; DPS3.C11 114.57,20.12 ; DPS3.C11 114.57,17.98 ; DPS3.C11 115.64,19.05 ; DPS3.C11 113.5,19.05 ; D102.A16 200.93,77.27 ; D102.A16 199.86,76.2 ; D102.A16 202,76.2 ; D102.A16 200.93,75.13 ; 106.95,341.83 CSDPS425.B10 ; CSDPS425.B10 106.95,343.97 ; CSDPS425.B10 105.88,342.9 ; CSDPS425.B10 108.02,342.9 ; 189.7,388.62 D116.B6 ; D116.B6 190.77,387.55 ; D116.B6 191.84,388.62 ; D116.B6 190.77,389.69 ; D116.B3 199.46,391.16 ; D116.B3 198.39,392.23 ; D116.B3 198.39,390.09 ; D116.B3 197.32,391.16 ; 182.08,53.34 D103.A9 ; D103.A9 184.22,53.34 ; D103.A9 183.15,54.41 ; D103.A9 183.15,52.27 ; D106.B9 256.81,79.81 ; D106.B9 256.81,77.67 ; D106.B9 257.88,78.74 ; D106.B9 255.74,78.74 ; 34.76,330.2 CSDPS229.C9 ; CSDPS229.C9 36.9,330.2 ; CSDPS229.C9 35.83,331.27 ; CSDPS229.C9 35.83,329.13 ; 30.75,77.67 D118.B7 ; D118.B7 31.82,78.74 ; D118.B7 29.68,78.74 ; D118.B7 30.75,79.81 ; 33.29,80.21 D118.B8 ; D118.B8 34.36,81.28 ; D118.B8 32.22,81.28 ; D118.B8 33.29,82.35 ; D117.A10 38.37,97.59 ; D117.A10 39.44,96.52 ; D117.A10 37.3,96.52 ; D117.A10 38.37,95.45 ; D123.B10 113.1,60.96 ; D123.B10 110.96,60.96 ; D123.B10 112.03,62.03 ; D123.B10 112.03,59.89 ; D124.B14 123.26,40.64 ; D124.B14 121.12,40.64 ; D124.B14 122.19,41.71 ; D124.B14 122.19,39.57 ; UHC430.G1_6 19.18,362.76 ; UHC430.G1_6 18.37,361.95 ; UHC430.G1_6 19.18,361.14 ; UHC430.G1_6 19.99,361.95 ; D124.A13 119.65,34.09 ; D124.A13 119.65,31.95 ; D124.A13 118.58,33.02 ; D124.A13 120.72,33.02 ; CSDPS229.B6 43.45,333.81 ; CSDPS229.B6 42.38,332.74 ; CSDPS229.B6 44.52,332.74 ; CSDPS229.B6 43.45,331.67 ; 110.96,393.7 D228.A8 ; D228.A8 113.1,393.7 ; D228.A8 112.03,394.77 ; D228.A8 112.03,392.63 ; D106.A5 247.72,73.66 ; D106.A5 245.58,73.66 ; D106.A5 246.65,72.59 ; D106.A5 246.65,74.73 ; D101.B13 194.38,99.06 ; D101.B13 192.24,99.06 ; D101.B13 193.31,100.13 ; D101.B13 193.31,97.99 ; 248.12,388.62 D112.B12 ; D112.B12 249.19,387.55 ; D112.B12 250.26,388.62 ; D112.B12 249.19,389.69 ; 95.72,388.62 D228.B14 ; D228.B14 96.79,387.55 ; D228.B14 97.86,388.62 ; D228.B14 96.79,389.69 ; D432.A3 52.14,406.4 ; D432.A3 50,406.4 ; D432.A3 51.07,407.47 ; D432.A3 51.07,405.33 ; DPS1.C15 273.12,19.05 ; DPS1.C15 272.05,17.98 ; DPS1.C15 272.05,20.12 ; DPS1.C15 270.98,19.05 ; 45.99,92.91 D117.A13 ; D117.A13 45.99,95.05 ; D117.A13 47.06,93.98 ; D117.A13 44.92,93.98 ; D115.B5 193.31,371.91 ; D115.B5 194.38,370.84 ; D115.B5 193.31,369.77 ; D115.B5 192.24,370.84 ; D106.B15 272.05,79.81 ; D106.B15 272.05,77.67 ; D106.B15 270.98,78.74 ; D106.B15 273.12,78.74 ; 23.13,331.67 CSDPS229.B14 ; CSDPS229.B14 24.2,332.74 ; CSDPS229.B14 22.06,332.74 ; CSDPS229.B14 23.13,333.81 ; 273.52,388.62 D112.B2 ; D112.B2 274.59,387.55 ; D112.B2 274.59,389.69 ; D112.B2 275.66,388.62 ; CSDPS225.C7 114.57,331.27 ; CSDPS225.C7 114.57,329.13 ; CSDPS225.C7 113.5,330.2 ; CSDPS225.C7 115.64,330.2 ; D109.A5 266.97,336.35 ; D109.A5 265.9,335.28 ; D109.A5 268.04,335.28 ; D109.A5 266.97,334.21 ; 22.06,393.7 D232.A14 ; D232.A14 24.2,393.7 ; D232.A14 23.13,394.77 ; D232.A14 23.13,392.63 ; D122.B8 106.95,82.35 ; D122.B8 106.95,80.21 ; D122.B8 108.02,81.28 ; D122.B8 105.88,81.28 ; D117.A1 16.58,93.98 ; D117.A1 15.51,95.05 ; D117.A1 14.44,93.98 ; D117.A1 15.51,92.91 ; D431.A17 16.58,386.08 ; D431.A17 15.51,385.01 ; D431.A17 15.51,387.15 ; D431.A17 14.44,386.08 ; 260.82,19.05 DPS1.C11 ; DPS1.C11 261.89,20.12 ; DPS1.C11 261.89,17.98 ; DPS1.C11 262.96,19.05 ; 99.33,374.85 D227.A13 ; D227.A13 98.26,375.92 ; D227.A13 99.33,376.99 ; D227.A13 100.4,375.92 ; D121.B15 125.8,99.06 ; D121.B15 124.73,97.99 ; D121.B15 124.73,100.13 ; D121.B15 123.66,99.06 ; 118.58,340.36 CSDPS425.C5 ; CSDPS425.C5 120.72,340.36 ; CSDPS425.C5 119.65,341.43 ; CSDPS425.C5 119.65,339.29 ; DPS2.C15 168.98,410.21 ; DPS2.C15 167.91,411.28 ; DPS2.C15 166.84,410.21 ; DPS2.C15 167.91,409.14 ; 180.61,95.45 D101.A8 ; D101.A8 179.54,96.52 ; D101.A8 181.68,96.52 ; D101.A8 180.61,97.59 ; D431.B14 23.13,379.53 ; D431.B14 24.2,378.46 ; D431.B14 22.06,378.46 ; D431.B14 23.13,377.39 ; D101.A11 189.3,93.98 ; D101.A11 187.16,93.98 ; D101.A11 188.23,95.05 ; D101.A11 188.23,92.91 ; D120.A10 39.44,35.56 ; D120.A10 38.37,36.63 ; D120.A10 37.3,35.56 ; D120.A10 38.37,34.49 ; CSDPS426.C13 100.4,360.68 ; CSDPS426.C13 99.33,359.61 ; CSDPS426.C13 98.26,360.68 ; CSDPS426.C13 99.33,361.75 ; 202.4,410.21 DPS2.C01 ; DPS2.C01 204.54,410.21 ; DPS2.C01 203.47,411.28 ; DPS2.C01 203.47,409.14 ; 44.92,53.34 D119.A13 ; D119.A13 45.99,54.41 ; D119.A13 47.06,53.34 ; D119.A13 45.99,52.27 ; 198.39,395.17 D116.A3 ; D116.A3 199.46,396.24 ; D116.A3 198.39,397.31 ; D116.A3 197.32,396.24 ; 55.08,381 D431.B1 ; D431.B1 57.22,381 ; D431.B1 56.15,382.07 ; D431.B1 56.15,379.93 ; 30.75,369.77 D231.B11 ; D231.B11 30.75,371.91 ; D231.B11 31.82,370.84 ; D231.B11 29.68,370.84 ; 42.38,368.3 D231.B6 ; D231.B6 44.52,368.3 ; D231.B6 43.45,369.37 ; D231.B6 43.45,367.23 ; D104.A8 181.68,35.56 ; D104.A8 180.61,34.49 ; D104.A8 180.61,36.63 ; D104.A8 179.54,35.56 ; 164.3,353.06 D114.A16 ; D114.A16 165.37,354.13 ; D114.A16 165.37,351.99 ; D114.A16 166.44,353.06 ; D227.B6 117.11,369.37 ; D227.B6 118.18,368.3 ; D227.B6 116.04,368.3 ; D227.B6 117.11,367.23 ; 264.43,331.67 D109.A6 ; D109.A6 264.43,333.81 ; D109.A6 263.36,332.74 ; D109.A6 265.5,332.74 ; UHC230.G4_5 16.54,353.54 ; UHC230.G4_5 14.92,353.54 ; UHC230.G4_5 15.73,352.73 ; UHC230.G4_5 15.73,354.35 ; 44.92,396.24 D232.A5 ; D232.A5 45.99,397.31 ; D232.A5 47.06,396.24 ; D232.A5 45.99,395.17 ; D106.B1 236.49,79.81 ; D106.B1 235.42,78.74 ; D106.B1 236.49,77.67 ; D106.B1 237.56,78.74 ; D124.A10 113.1,35.56 ; D124.A10 112.03,36.63 ; D124.A10 112.03,34.49 ; D124.A10 110.96,35.56 ; D123.A8 106.95,56.95 ; D123.A8 105.88,55.88 ; D123.A8 106.95,54.81 ; D123.A8 108.02,55.88 ; D115.A4 195.85,374.45 ; D115.A4 194.78,373.38 ; D115.A4 195.85,372.31 ; D115.A4 196.92,373.38 ; D105.A14 269.51,97.59 ; D105.A14 270.58,96.52 ; D105.A14 268.44,96.52 ; D105.A14 269.51,95.45 ; 19.52,415.29 DPS8.A15 ; DPS8.A15 20.59,414.22 ; DPS8.A15 20.59,416.36 ; DPS8.A15 21.66,415.29 ; D118.B4 24.2,81.28 ; D118.B4 23.13,82.35 ; D118.B4 22.06,81.28 ; D118.B4 23.13,80.21 ; D114.A6 191.84,353.06 ; D114.A6 189.7,353.06 ; D114.A6 190.77,351.99 ; D114.A6 190.77,354.13 ; D431.B6 43.45,379.53 ; D431.B6 42.38,378.46 ; D431.B6 43.45,377.39 ; D431.B6 44.52,378.46 ; 239.03,331.67 D109.A16 ; D109.A16 237.96,332.74 ; D109.A16 240.1,332.74 ; D109.A16 239.03,333.81 ; D108.A10 260.42,35.56 ; D108.A10 259.35,36.63 ; D108.A10 258.28,35.56 ; D108.A10 259.35,34.49 ; D427.B3 125.8,381 ; D427.B3 123.66,381 ; D427.B3 124.73,382.07 ; D427.B3 124.73,379.93 ; 123.66,330.2 CSDPS225.C3 ; CSDPS225.C3 124.73,329.13 ; CSDPS225.C3 125.8,330.2 ; CSDPS225.C3 124.73,331.27 ; 126.2,60.96 D123.B16 ; D123.B16 127.27,59.89 ; D123.B16 127.27,62.03 ; D123.B16 128.34,60.96 ; 29.68,53.34 D119.A7 ; D119.A7 31.82,53.34 ; D119.A7 30.75,52.27 ; D119.A7 30.75,54.41 ; 165.37,59.89 D103.B2 ; D103.B2 164.3,60.96 ; D103.B2 165.37,62.03 ; D103.B2 166.44,60.96 ; 104.41,72.59 D122.A7 ; D122.A7 104.41,74.73 ; D122.A7 103.34,73.66 ; D122.A7 105.48,73.66 ; 114.57,57.35 D123.B11 ; D123.B11 113.5,58.42 ; D123.B11 115.64,58.42 ; D123.B11 114.57,59.49 ; D232.A1 57.22,396.24 ; D232.A1 56.15,395.17 ; D232.A1 56.15,397.31 ; D232.A1 55.08,396.24 ; UHC230.G4_2 16.88,356.1 ; UHC230.G4_2 17.69,355.29 ; UHC230.G4_2 16.88,354.48 ; UHC230.G4_2 16.07,355.29 ; 239.03,59.89 D107.B2 ; D107.B2 240.1,60.96 ; D107.B2 239.03,62.03 ; D107.B2 237.96,60.96 ; D122.B15 124.73,79.81 ; D122.B15 125.8,78.74 ; D122.B15 123.66,78.74 ; D122.B15 124.73,77.67 ; D104.B15 198.39,39.17 ; D104.B15 199.46,38.1 ; D104.B15 197.32,38.1 ; D104.B15 198.39,37.03 ; 200.93,326.59 D113.B2 ; D113.B2 199.86,327.66 ; D113.B2 202,327.66 ; D113.B2 200.93,328.73 ; 182.08,350.52 D114.B9 ; D114.B9 184.22,350.52 ; D114.B9 183.15,351.59 ; D114.B9 183.15,349.45 ; D103.B14 195.85,62.03 ; D103.B14 195.85,59.89 ; D103.B14 194.78,60.96 ; D103.B14 196.92,60.96 ; D427.A13 99.33,387.15 ; D427.A13 99.33,385.01 ; D427.A13 100.4,386.08 ; D427.A13 98.26,386.08 ; 48.53,331.67 CSDPS229.B4 ; CSDPS229.B4 49.6,332.74 ; CSDPS229.B4 47.46,332.74 ; CSDPS229.B4 48.53,333.81 ; 241.57,97.99 D105.B3 ; D105.B3 240.5,99.06 ; D105.B3 241.57,100.13 ; D105.B3 242.64,99.06 ; 263.36,81.28 D106.B12 ; D106.B12 265.5,81.28 ; D106.B12 264.43,82.35 ; D106.B12 264.43,80.21 ; D428.A1 129.81,407.47 ; D428.A1 129.81,405.33 ; D428.A1 130.88,406.4 ; D428.A1 128.74,406.4 ; D120.B1 16.58,38.1 ; D120.B1 14.44,38.1 ; D120.B1 15.51,39.17 ; D120.B1 15.51,37.03 ; 89.17,385.01 D427.A17 ; D427.A17 90.24,386.08 ; D427.A17 88.1,386.08 ; D427.A17 89.17,387.15 ; 197.32,73.66 D102.A15 ; D102.A15 198.39,74.73 ; D102.A15 199.46,73.66 ; D102.A15 198.39,72.59 ; D105.B16 274.59,102.67 ; D105.B16 275.66,101.6 ; D105.B16 273.52,101.6 ; D105.B16 274.59,100.53 ; D431.B15 21.66,381 ; D431.B15 20.59,382.07 ; D431.B15 20.59,379.93 ; D431.B15 19.52,381 ; 244.11,59.89 D107.B4 ; D107.B4 243.04,60.96 ; D107.B4 244.11,62.03 ; D107.B4 245.18,60.96 ; D114.B10 180.61,349.05 ; D114.B10 179.54,347.98 ; D114.B10 181.68,347.98 ; D114.B10 180.61,346.91 ; 110.96,383.54 D427.A8 ; D427.A8 113.1,383.54 ; D427.A8 112.03,384.61 ; D427.A8 112.03,382.47 ; CSDPS429.B10 33.29,343.97 ; CSDPS429.B10 32.22,342.9 ; CSDPS429.B10 33.29,341.83 ; CSDPS429.B10 34.36,342.9 ; 117.11,382.47 D427.A6 ; D427.A6 118.18,383.54 ; D427.A6 116.04,383.54 ; D427.A6 117.11,384.61 ; D227.A10 108.02,373.38 ; D227.A10 105.88,373.38 ; D227.A10 106.95,374.45 ; D227.A10 106.95,372.31 ; D113.B10 180.61,328.73 ; D113.B10 179.54,327.66 ; D113.B10 180.61,326.59 ; D113.B10 181.68,327.66 ; 188.23,374.85 D115.A7 ; D115.A7 189.3,375.92 ; D115.A7 187.16,375.92 ; D115.A7 188.23,376.99 ; 18.05,39.57 D120.B2 ; D120.B2 19.12,40.64 ; D120.B2 18.05,41.71 ; D120.B2 16.98,40.64 ; D104.B12 191.84,40.64 ; D104.B12 190.77,41.71 ; D104.B12 189.7,40.64 ; D104.B12 190.77,39.57 ; D116.A8 186.76,393.7 ; D116.A8 185.69,392.63 ; D116.A8 184.62,393.7 ; D116.A8 185.69,394.77 ; 237.96,347.98 D110.B16 ; D110.B16 239.03,346.91 ; D110.B16 239.03,349.05 ; D110.B16 240.1,347.98 ; 42.38,40.64 D120.B12 ; D120.B12 43.45,39.57 ; D120.B12 43.45,41.71 ; D120.B12 44.52,40.64 ; D108.B3 241.57,39.17 ; D108.B3 242.64,38.1 ; D108.B3 241.57,37.03 ; D108.B3 240.5,38.1 ; 248.12,101.6 D105.B6 ; D105.B6 249.19,102.67 ; D105.B6 249.19,100.53 ; D105.B6 250.26,101.6 ; 32.22,40.64 D120.B8 ; D120.B8 33.29,41.71 ; D120.B8 33.29,39.57 ; D120.B8 34.36,40.64 ; 38.37,54.81 D119.A10 ; D119.A10 37.3,55.88 ; D119.A10 39.44,55.88 ; D119.A10 38.37,56.95 ; D122.B1 89.17,79.81 ; D122.B1 89.17,77.67 ; D122.B1 88.1,78.74 ; D122.B1 90.24,78.74 ; 185.69,75.13 D102.A10 ; D102.A10 184.62,76.2 ; D102.A10 186.76,76.2 ; D102.A10 185.69,77.27 ; 171.92,38.1 D104.B5 ; D104.B5 172.99,39.17 ; D104.B5 172.99,37.03 ; D104.B5 174.06,38.1 ; 104.41,31.95 D124.A7 ; D124.A7 105.48,33.02 ; D124.A7 104.41,34.09 ; D124.A7 103.34,33.02 ; D105.B11 261.89,100.13 ; D105.B11 261.89,97.99 ; D105.B11 262.96,99.06 ; D105.B11 260.82,99.06 ; 47.46,393.7 D232.A4 ; D232.A4 49.6,393.7 ; D232.A4 48.53,392.63 ; D232.A4 48.53,394.77 ; D102.B1 162.83,79.81 ; D102.B1 162.83,77.67 ; D102.B1 163.9,78.74 ; D102.B1 161.76,78.74 ; D105.A16 274.59,97.59 ; D105.A16 274.59,95.45 ; D105.A16 275.66,96.52 ; D105.A16 273.52,96.52 ; D114.B14 171.52,347.98 ; D114.B14 169.38,347.98 ; D114.B14 170.45,346.91 ; D114.B14 170.45,349.05 ; 184.62,368.3 D115.B8 ; D115.B8 185.69,369.37 ; D115.B8 185.69,367.23 ; D115.B8 186.76,368.3 ; 198.39,52.27 D103.A15 ; D103.A15 198.39,54.41 ; D103.A15 197.32,53.34 ; D103.A15 199.46,53.34 ; D123.B15 125.8,58.42 ; D123.B15 123.66,58.42 ; D123.B15 124.73,57.35 ; D123.B15 124.73,59.49 ; 248.12,55.88 D107.A6 ; D107.A6 249.19,56.95 ; D107.A6 249.19,54.81 ; D107.A6 250.26,55.88 ; D117.A15 52.14,93.98 ; D117.A15 51.07,92.91 ; D117.A15 50,93.98 ; D117.A15 51.07,95.05 ; D123.B6 101.87,62.03 ; D123.B6 101.87,59.89 ; D123.B6 102.94,60.96 ; D123.B6 100.8,60.96 ; 243.04,332.74 D109.A14 ; D109.A14 244.11,333.81 ; D109.A14 244.11,331.67 ; D109.A14 245.18,332.74 ; D432.A12 28.21,404.93 ; D432.A12 28.21,402.79 ; D432.A12 29.28,403.86 ; D432.A12 27.14,403.86 ; 40.91,339.29 CSDPS429.C7 ; CSDPS429.C7 40.91,341.43 ; CSDPS429.C7 39.84,340.36 ; CSDPS429.C7 41.98,340.36 ; 199.86,101.6 D101.B16 ; D101.B16 200.93,102.67 ; D101.B16 200.93,100.53 ; D101.B16 202,101.6 ; 24.6,401.32 D432.B13 ; D432.B13 26.74,401.32 ; D432.B13 25.67,402.39 ; D432.B13 25.67,400.25 ; 128.74,375.92 D227.A1 ; D227.A1 129.81,374.85 ; D227.A1 130.88,375.92 ; D227.A1 129.81,376.99 ; D113.B1 204.54,330.2 ; D113.B1 203.47,331.27 ; D113.B1 202.4,330.2 ; D113.B1 203.47,329.13 ; UHC230.G3_3 45.19,355.29 ; UHC230.G3_3 43.57,355.29 ; UHC230.G3_3 44.38,354.48 ; UHC230.G3_3 44.38,356.1 ; D101.A4 170.45,97.59 ; D101.A4 171.52,96.52 ; D101.A4 170.45,95.45 ; D101.A4 169.38,96.52 ; 13.77,348.29 UHC230.G4_13 ; UHC230.G4_13 14.58,349.1 ; UHC230.G4_13 15.39,348.29 ; UHC230.G4_13 14.58,347.48 ; 249.19,331.67 D109.A12 ; D109.A12 250.26,332.74 ; D109.A12 249.19,333.81 ; D109.A12 248.12,332.74 ; 43.57,361.95 UHC430.G2_8 ; UHC430.G2_8 44.38,362.76 ; UHC430.G2_8 44.38,361.14 ; UHC430.G2_8 45.19,361.95 ; 30.75,31.95 D120.A7 ; D120.A7 31.82,33.02 ; D120.A7 30.75,34.09 ; D120.A7 29.68,33.02 ; DPS2.A11 179.14,415.29 ; DPS2.A11 178.07,416.38 178.74,417.05 SB13.1 ; DPS2.A11 177,415.29 ; DPS2.A11 178.07,414.22 ; 50,401.32 D432.B3 ; D432.B3 51.07,400.25 ; D432.B3 51.07,402.39 ; D432.B3 52.14,401.32 ; D120.B10 38.37,41.71 ; D120.B10 38.37,39.57 ; D120.B10 39.44,40.64 ; D120.B10 37.3,40.64 ; D121.B3 95.32,99.06 ; D121.B3 93.18,99.06 ; D121.B3 94.25,97.99 ; D121.B3 94.25,100.13 ; UHC230.G4_6 19.99,351.79 ; UHC230.G4_6 18.37,351.79 ; UHC230.G4_6 19.18,352.6 ; UHC230.G4_6 19.18,350.98 ; D232.A9 36.9,396.24 ; D232.A9 35.83,397.31 ; D232.A9 34.76,396.24 ; D232.A9 35.83,395.17 ; D123.A12 118.18,55.88 ; D123.A12 116.04,55.88 ; D123.A12 117.11,56.95 ; D123.A12 117.11,54.81 ; D107.B8 254.27,62.03 ; D107.B8 254.27,59.89 ; D107.B8 255.34,60.96 ; D107.B8 253.2,60.96 ; DPS3.C15 124.73,20.12 ; DPS3.C15 123.66,19.05 ; DPS3.C15 125.8,19.05 ; DPS3.C15 124.73,17.98 ; D107.B10 260.42,60.96 ; D107.B10 258.28,60.96 ; D107.B10 259.35,59.89 ; D107.B10 259.35,62.03 ; 259.35,326.59 D109.B8 ; D109.B8 260.42,327.66 ; D109.B8 258.28,327.66 ; D109.B8 259.35,328.73 ; 172.99,57.35 D103.B5 ; D103.B5 171.92,58.42 ; D103.B5 174.06,58.42 ; D103.B5 172.99,59.49 ; DPS2.B15 168.98,412.75 ; DPS2.B15 167.91,413.82 ; DPS2.B15 166.84,412.75 ; DPS2.B15 167.91,411.68 ; 190.77,59.89 D103.B12 ; D103.B12 189.7,60.96 ; D103.B12 190.77,62.03 ; D103.B12 191.84,60.96 ; 117.11,362.15 CSDPS426.B6 ; CSDPS426.B6 116.04,363.22 ; CSDPS426.B6 118.18,363.22 ; CSDPS426.B6 117.11,364.29 ; UHC230.G3_4 47.83,354.35 ; UHC230.G3_4 47.83,352.73 ; UHC230.G3_4 47.02,353.54 ; UHC230.G3_4 48.64,353.54 ; D118.A11 40.91,74.73 ; D118.A11 41.98,73.66 ; D118.A11 39.84,73.66 ; D118.A11 40.91,72.59 ; D104.A6 176.6,35.56 ; D104.A6 175.53,36.63 ; D104.A6 175.53,34.49 ; D104.A6 174.46,35.56 ; D124.A14 123.26,35.56 ; D124.A14 122.19,36.63 ; D124.A14 121.12,35.56 ; D124.A14 122.19,34.49 ; D428.B8 112.03,399.85 ; D428.B8 110.96,398.78 ; D428.B8 113.1,398.78 ; D428.B8 112.03,397.71 ; D428.B10 108.02,398.78 ; D428.B10 106.95,397.71 ; D428.B10 106.95,399.85 ; D428.B10 105.88,398.78 ; D108.B7 252.8,38.1 ; D108.B7 250.66,38.1 ; D108.B7 251.73,39.17 ; D108.B7 251.73,37.03 ; 45.53,349.23 UHC230.G3_10 ; UHC230.G3_10 45.53,350.85 ; UHC230.G3_10 46.34,350.04 ; UHC230.G3_10 44.72,350.04 ; D109.B12 249.19,328.73 ; D109.B12 249.19,326.59 ; D109.B12 248.12,327.66 ; D109.B12 250.26,327.66 ; 251.73,77.67 D106.B7 ; D106.B7 251.73,79.81 ; D106.B7 250.66,78.74 ; D106.B7 252.8,78.74 ; 241.57,329.13 D109.B15 ; D109.B15 241.57,331.27 ; D109.B15 240.5,330.2 ; D109.B15 242.64,330.2 ; 116.04,353.06 CSDPS226.B6 ; CSDPS226.B6 117.11,354.13 ; CSDPS226.B6 118.18,353.06 ; CSDPS226.B6 117.11,351.99 ; 239.03,392.63 D112.A16 ; D112.A16 240.1,393.7 ; D112.A16 237.96,393.7 ; D112.A16 239.03,394.77 ; D121.B7 105.48,99.06 ; D121.B7 104.41,100.13 ; D121.B7 104.41,97.99 ; D121.B7 103.34,99.06 ; D123.A6 102.94,55.88 ; D123.A6 101.87,56.95 ; D123.A6 100.8,55.88 ; D123.A6 101.87,54.81 ; D106.A13 268.04,73.66 ; D106.A13 266.97,72.59 ; D106.A13 266.97,74.73 ; D106.A13 265.9,73.66 ; 109.49,400.25 D428.B9 ; D428.B9 108.42,401.32 ; D428.B9 109.49,402.39 ; D428.B9 110.56,401.32 ; 203.47,414.22 DPS2.A01 ; DPS2.A01 204.54,415.29 ; DPS2.A01 202.4,415.29 ; DPS2.A01 203.47,416.36 ; 104.41,369.77 D227.B11 ; D227.B11 105.48,370.84 ; D227.B11 104.41,371.91 ; D227.B11 103.34,370.84 ; 108.42,93.98 D121.A9 ; D121.A9 110.56,93.98 ; D121.A9 109.49,92.91 ; D121.A9 109.49,95.05 ; D431.A15 21.66,386.08 ; D431.A15 20.59,385.01 ; D431.A15 19.52,386.08 ; D431.A15 20.59,387.15 ; CSDPS429.C11 30.75,341.43 ; CSDPS429.C11 29.68,340.36 ; CSDPS429.C11 30.75,339.29 ; CSDPS429.C11 31.82,340.36 ; 19.52,401.32 D432.B15 ; D432.B15 20.59,402.39 ; D432.B15 21.66,401.32 ; D432.B15 20.59,400.25 ; D107.A1 236.49,54.41 ; D107.A1 236.49,52.27 ; D107.A1 235.42,53.34 ; D107.A1 237.56,53.34 ; 177,73.66 D102.A7 ; D102.A7 178.07,72.59 ; D102.A7 179.14,73.66 ; D102.A7 178.07,74.73 ; D117.B3 21.66,99.06 ; D117.B3 20.59,100.13 ; D117.B3 19.52,99.06 ; D117.B3 20.59,97.99
  L02_DGND w0.203: D102.A14 195.85,77.01 ; D102.A14 196.66,76.2 ; D102.A14 195.04,76.2 ; D102.A14 195.85,75.39 ; D103.A7 178.07,54.15 ; D103.A7 178.88,53.34 ; D103.A7 178.07,52.53 ; D103.A7 177.26,53.34 ; D431.A5 46.8,386.08 ; D431.A5 45.18,386.08 ; D431.A5 45.99,385.27 ; D431.A5 45.99,386.89 ; 24.86,340.36 CSDPS429.C13 ; CSDPS429.C13 26.48,340.36 ; CSDPS429.C13 25.67,339.55 ; CSDPS429.C13 25.67,341.17 ; 122.19,75.39 D122.A14 ; D122.A14 123,76.2 ; D122.A14 122.19,77.01 ; D122.A14 121.38,76.2 ; 195.04,347.98 D114.B4 ; D114.B4 196.66,347.98 ; D114.B4 195.85,347.17 ; D114.B4 195.85,348.79 ; D228.B5 120.46,391.16 ; D228.B5 119.65,390.35 ; D228.B5 119.65,391.97 ; D228.B5 118.84,391.16 ; 17.22,360.2 UHC430.G1_9 ; UHC430.G1_9 18.84,360.2 ; UHC430.G1_9 18.03,361.01 ; UHC430.G1_9 18.03,359.39 ; 44.38,361.14 UHC430.G2_8 ; UHC430.G2_8 44.38,362.76 ; UHC430.G2_8 43.57,361.95 ; UHC430.G2_8 45.19,361.95 ; 93.44,33.02 D124.A3 ; D124.A3 94.25,33.83 ; D124.A3 95.06,33.02 ; D124.A3 94.25,32.21 ; 241.57,370.03 D111.B15 ; D111.B15 242.38,370.84 ; D111.B15 241.57,371.65 ; D111.B15 240.76,370.84 ; 90.9,101.6 D121.B2 ; D121.B2 91.71,100.79 ; D121.B2 92.52,101.6 ; D121.B2 91.71,102.41 ; 104.41,390.35 D228.B11 ; D228.B11 104.41,391.97 ; D228.B11 105.22,391.16 ; D228.B11 103.6,391.16 ; D104.A10 186.5,35.56 ; D104.A10 185.69,36.37 ; D104.A10 184.88,35.56 ; D104.A10 185.69,34.75 ; 47.72,342.9 CSDPS429.B4 ; CSDPS429.B4 49.34,342.9 ; CSDPS429.B4 48.53,343.71 ; CSDPS429.B4 48.53,342.09 ; 266.16,370.84 D111.B5 ; D111.B5 266.97,371.65 ; D111.B5 266.97,370.03 ; D111.B5 267.78,370.84 ; 258.54,368.3 D111.B8 ; D111.B8 259.35,367.49 ; D111.B8 259.35,369.11 ; D111.B8 260.16,368.3 ; 13.77,358.45 UHC430.G1_13 ; UHC430.G1_13 14.58,359.26 ; UHC430.G1_13 14.58,357.64 ; UHC430.G1_13 15.39,358.45 ; 126.46,40.64 D124.B16 ; D124.B16 127.27,39.83 ; D124.B16 128.08,40.64 ; D124.B16 127.27,41.45 ; D231.A8 39.18,373.38 ; D231.A8 38.37,372.57 ; D231.A8 38.37,374.19 ; D231.A8 37.56,373.38 ; 52.8,373.38 D231.A2 ; D231.A2 54.42,373.38 ; D231.A2 53.61,372.57 ; D231.A2 53.61,374.19 ; 167.1,335.28 D113.A15 ; D113.A15 167.91,334.47 ; D113.A15 168.72,335.28 ; D113.A15 167.91,336.09 ; 129.81,405.59 D428.A1 ; D428.A1 130.62,406.4 ; D428.A1 129,406.4 ; D428.A1 129.81,407.21 ; 177.26,38.1 D104.B7 ; D104.B7 178.88,38.1 ; D104.B7 178.07,38.91 ; D104.B7 178.07,37.29 ; D122.B1 89.17,79.55 ; D122.B1 89.98,78.74 ; D122.B1 88.36,78.74 ; D122.B1 89.17,77.93 ; D112.B7 261.89,391.97 ; D112.B7 261.08,391.16 ; D112.B7 261.89,390.35 ; D112.B7 262.7,391.16 ; UHC430.G1_3 14.58,366.26 ; UHC430.G1_3 14.58,364.64 ; UHC430.G1_3 13.77,365.45 ; UHC430.G1_3 15.39,365.45 ; D432.B14 23.94,398.78 ; D432.B14 23.13,399.59 ; D432.B14 22.32,398.78 ; D432.B14 23.13,397.97 ; D106.B9 257.62,78.74 ; D106.B9 256,78.74 ; D106.B9 256.81,77.93 ; D106.B9 256.81,79.55 ; 169.64,327.66 D113.B14 ; D113.B14 170.45,326.85 ; D113.B14 170.45,328.47 ; D113.B14 171.26,327.66 ; 117.11,403.05 D428.A6 ; D428.A6 116.3,403.86 ; D428.A6 117.11,404.67 ; D428.A6 117.92,403.86 ; D427.A12 101.87,384.35 ; D427.A12 101.87,382.73 ; D427.A12 101.06,383.54 ; D427.A12 102.68,383.54 ; D427.B11 104.41,381.81 ; D427.B11 104.41,380.19 ; D427.B11 103.6,381 ; D427.B11 105.22,381 ; 250.92,396.24 D112.A11 ; D112.A11 251.73,395.43 ; D112.A11 251.73,397.05 ; D112.A11 252.54,396.24 ; D112.A1 277.94,396.24 ; D112.A1 277.13,397.05 ; D112.A1 276.32,396.24 ; D112.A1 277.13,395.43 ; D427.A16 92.52,383.54 ; D427.A16 90.9,383.54 ; D427.A16 91.71,384.35 ; D427.A16 91.71,382.73 ; D427.B4 123,378.46 ; D427.B4 122.19,379.27 ; D427.B4 121.38,378.46 ; D427.B4 122.19,377.65 ; D228.B1 130.62,391.16 ; D228.B1 129,391.16 ; D228.B1 129.81,391.97 ; D228.B1 129.81,390.35 ; D106.B10 259.35,82.09 ; D106.B10 258.54,81.28 ; D106.B10 260.16,81.28 ; D106.B10 259.35,80.47 ; D231.B6 44.26,368.3 ; D231.B6 43.45,369.11 ; D231.B6 43.45,367.49 ; D231.B6 42.64,368.3 ; CSDPS229.B10 34.1,332.74 ; CSDPS229.B10 32.48,332.74 ; CSDPS229.B10 33.29,333.55 ; CSDPS229.B10 33.29,331.93 ; D121.B8 107.76,101.6 ; D121.B8 106.14,101.6 ; D121.B8 106.95,102.41 ; D121.B8 106.95,100.79 ; D231.B10 33.29,369.11 ; D231.B10 34.1,368.3 ; D231.B10 33.29,367.49 ; D231.B10 32.48,368.3 ; D123.A4 97.6,55.88 ; D123.A4 95.98,55.88 ; D123.A4 96.79,55.07 ; D123.A4 96.79,56.69 ; 256.81,375.11 D111.A9 ; D111.A9 257.62,375.92 ; D111.A9 256.81,376.73 ; D111.A9 256,375.92 ; D119.A6 28.21,56.69 ; D119.A6 27.4,55.88 ; D119.A6 28.21,55.07 ; D119.A6 29.02,55.88 ; 112.03,403.05 D428.A8 ; D428.A8 112.84,403.86 ; D428.A8 112.03,404.67 ; D428.A8 111.22,403.86 ; D102.A6 176.34,76.2 ; D102.A6 175.53,75.39 ; D102.A6 175.53,77.01 ; D102.A6 174.72,76.2 ; 254.27,347.17 D110.B10 ; D110.B10 254.27,348.79 ; D110.B10 253.46,347.98 ; D110.B10 255.08,347.98 ; 91.71,95.71 D121.A2 ; D121.A2 92.52,96.52 ; D121.A2 91.71,97.33 ; D121.A2 90.9,96.52 ; D432.B17 16.32,401.32 ; D432.B17 15.51,400.51 ; D432.B17 14.7,401.32 ; D432.B17 15.51,402.13 ; 53.61,39.83 D120.B16 ; D120.B16 53.61,41.45 ; D120.B16 54.42,40.64 ; D120.B16 52.8,40.64 ; DPS3.A05 100.14,13.97 ; DPS3.A05 99.33,14.78 ; DPS3.A05 98.52,13.97 ; DPS3.A05 99.33,13.16 ; D119.A11 40.91,54.15 ; D119.A11 40.91,52.53 ; D119.A11 40.1,53.34 ; D119.A11 41.72,53.34 ; D107.B2 239.84,60.96 ; D107.B2 239.03,61.77 ; D107.B2 238.22,60.96 ; D107.B2 239.03,60.15 ; 263.62,76.2 D106.A12 ; D106.A12 264.43,77.01 ; D106.A12 264.43,75.39 ; D106.A12 265.24,76.2 ; D106.B11 262.7,78.74 ; D106.B11 261.89,77.93 ; D106.B11 261.89,79.55 ; D106.B11 261.08,78.74 ; 15.51,380.19 D431.B17 ; D431.B17 16.32,381 ; D431.B17 15.51,381.81 ; D431.B17 14.7,381 ; D115.A2 201.74,373.38 ; D115.A2 200.12,373.38 ; D115.A2 200.93,372.57 ; D115.A2 200.93,374.19 ; 19.78,330.2 CSDPS229.C15 ; CSDPS229.C15 20.59,331.01 ; CSDPS229.C15 20.59,329.39 ; CSDPS229.C15 21.4,330.2 ; 103.6,350.52 CSDPS226.C11 ; CSDPS226.C11 104.41,349.71 ; CSDPS226.C11 104.41,351.33 ; CSDPS226.C11 105.22,350.52 ; 119.65,93.17 D121.A13 ; D121.A13 119.65,94.79 ; D121.A13 118.84,93.98 ; D121.A13 120.46,93.98 ; 240.76,391.16 D112.B15 ; D112.B15 241.57,391.97 ; D112.B15 242.38,391.16 ; D112.B15 241.57,390.35 ; 200.12,327.66 D113.B2 ; D113.B2 201.74,327.66 ; D113.B2 200.93,326.85 ; D113.B2 200.93,328.47 ; D116.B11 178.88,391.16 ; D116.B11 178.07,391.97 ; D116.B11 177.26,391.16 ; D116.B11 178.07,390.35 ; D232.A10 33.29,394.51 ; D232.A10 33.29,392.89 ; D232.A10 34.1,393.7 ; D232.A10 32.48,393.7 ; D227.A10 106.95,374.19 ; D227.A10 106.95,372.57 ; D227.A10 106.14,373.38 ; D227.A10 107.76,373.38 ; D110.A13 246.65,356.41 ; D110.A13 247.46,355.6 ; D110.A13 245.84,355.6 ; D110.A13 246.65,354.79 ; 240.76,58.42 D107.B3 ; D107.B3 242.38,58.42 ; D107.B3 241.57,59.23 ; D107.B3 241.57,57.61 ; 103.6,33.02 D124.A7 ; D124.A7 104.41,33.83 ; D124.A7 105.22,33.02 ; D124.A7 104.41,32.21 ; D428.B1 129.81,402.13 ; D428.B1 129,401.32 ; D428.B1 130.62,401.32 ; D428.B1 129.81,400.51 ; UHC230.G3_13 45.19,348.29 ; UHC230.G3_13 44.38,347.48 ; UHC230.G3_13 43.57,348.29 ; UHC230.G3_13 44.38,349.1 ; 121.38,393.7 D228.A4 ; D228.A4 123,393.7 ; D228.A4 122.19,394.51 ; D228.A4 122.19,392.89 ; D120.A3 20.59,33.83 ; D120.A3 20.59,32.21 ; D120.A3 19.78,33.02 ; D120.A3 21.4,33.02 ; CSDPS426.C3 125.54,360.68 ; CSDPS426.C3 124.73,359.87 ; CSDPS426.C3 124.73,361.49 ; CSDPS426.C3 123.92,360.68 ; D107.B15 272.86,58.42 ; D107.B15 271.24,58.42 ; D107.B15 272.05,59.23 ; D107.B15 272.05,57.61 ; D102.B6 175.53,82.09 ; D102.B6 175.53,80.47 ; D102.B6 174.72,81.28 ; D102.B6 176.34,81.28 ; 187.42,38.1 D104.B11 ; D104.B11 188.23,37.29 ; D104.B11 189.04,38.1 ; D104.B11 188.23,38.91 ; D108.A16 275.4,35.56 ; D108.A16 273.78,35.56 ; D108.A16 274.59,34.75 ; D108.A16 274.59,36.37 ; D122.A10 112.03,77.01 ; D122.A10 112.84,76.2 ; D122.A10 112.03,75.39 ; D122.A10 111.22,76.2 ; 274.59,347.17 D110.B2 ; D110.B2 275.4,347.98 ; D110.B2 274.59,348.79 ; D110.B2 273.78,347.98 ; 99.33,18.24 DPS3.C05 ; DPS3.C05 100.14,19.05 ; DPS3.C05 98.52,19.05 ; DPS3.C05 99.33,19.86 ; D120.B3 21.4,38.1 ; D120.B3 19.78,38.1 ; D120.B3 20.59,37.29 ; D120.B3 20.59,38.91 ; D102.B16 200.93,82.09 ; D102.B16 200.93,80.47 ; D102.B16 200.12,81.28 ; D102.B16 201.74,81.28 ; 174.72,347.98 D114.B12 ; D114.B12 176.34,347.98 ; D114.B12 175.53,347.17 ; D114.B12 175.53,348.79 ; 17.24,55.88 D119.A2 ; D119.A2 18.05,56.69 ; D119.A2 18.05,55.07 ; D119.A2 18.86,55.88 ; CSDPS225.C13 100.14,330.2 ; CSDPS225.C13 99.33,329.39 ; CSDPS225.C13 98.52,330.2 ; CSDPS225.C13 99.33,331.01 ; 119.65,375.11 D227.A5 ; D227.A5 118.84,375.92 ; D227.A5 120.46,375.92 ; D227.A5 119.65,376.73 ; D103.B6 176.34,60.96 ; D103.B6 174.72,60.96 ; D103.B6 175.53,61.77 ; D103.B6 175.53,60.15 ; CSDPS229.B16 18.05,333.55 ; CSDPS229.B16 18.86,332.74 ; CSDPS229.B16 17.24,332.74 ; CSDPS229.B16 18.05,331.93 ; 193.31,375.11 D115.A5 ; D115.A5 193.31,376.73 ; D115.A5 192.5,375.92 ; D115.A5 194.12,375.92 ; D106.A16 274.59,77.01 ; D106.A16 275.4,76.2 ; D106.A16 273.78,76.2 ; D106.A16 274.59,75.39 ; D106.A8 255.08,76.2 ; D106.A8 254.27,77.01 ; D106.A8 253.46,76.2 ; D106.A8 254.27,75.39 ; 40.1,396.24 D232.A7 ; D232.A7 40.91,395.43 ; D232.A7 41.72,396.24 ; D232.A7 40.91,397.05 ; 88.36,58.42 D123.B1 ; D123.B1 89.98,58.42 ; D123.B1 89.17,59.23 ; D123.B1 89.17,57.61 ; D432.A9 35.83,407.21 ; D432.A9 35.83,405.59 ; D432.A9 36.64,406.4 ; D432.A9 35.02,406.4 ; D113.B4 196.66,327.66 ; D113.B4 195.04,327.66 ; D113.B4 195.85,326.85 ; D113.B4 195.85,328.47 ; D228.B15 94.25,391.97 ; D228.B15 94.25,390.35 ; D228.B15 95.06,391.16 ; D228.B15 93.44,391.16 ; D109.A13 246.65,336.09 ; D109.A13 245.84,335.28 ; D109.A13 247.46,335.28 ; D109.A13 246.65,334.47 ; 251.73,93.17 D105.A7 ; D105.A7 251.73,94.79 ; D105.A7 252.54,93.98 ; D105.A7 250.92,93.98 ; D431.B15 21.4,381 ; D431.B15 19.78,381 ; D431.B15 20.59,381.81 ; D431.B15 20.59,380.19 ; 35.02,58.42 D119.B9 ; D119.B9 35.83,57.61 ; D119.B9 36.64,58.42 ; D119.B9 35.83,59.23 ; 25.67,370.03 D231.B13 ; D231.B13 24.86,370.84 ; D231.B13 26.48,370.84 ; D231.B13 25.67,371.65 ; D122.B16 128.08,81.28 ; D122.B16 127.27,80.47 ; D122.B16 127.27,82.09 ; D122.B16 126.46,81.28 ; D110.A9 257.62,355.6 ; D110.A9 256.81,356.41 ; D110.A9 256,355.6 ; D110.A9 256.81,354.79 ; D106.A14 270.32,76.2 ; D106.A14 268.7,76.2 ; D106.A14 269.51,75.39 ; D106.A14 269.51,77.01 ; D119.A1 15.51,54.15 ; D119.A1 16.32,53.34 ; D119.A1 15.51,52.53 ; D119.A1 14.7,53.34 ; D104.A14 195.85,36.37 ; D104.A14 196.66,35.56 ; D104.A14 195.85,34.75 ; D104.A14 195.04,35.56 ; D121.B1 89.98,99.06 ; D121.B1 89.17,99.87 ; D121.B1 89.17,98.25 ; D121.B1 88.36,99.06 ; 256.81,93.17 D105.A9 ; D105.A9 256.81,94.79 ; D105.A9 257.62,93.98 ; D105.A9 256,93.98 ; D105.A16 275.4,96.52 ; D105.A16 273.78,96.52 ; D105.A16 274.59,95.71 ; D105.A16 274.59,97.33 ; 178.07,409.4 DPS2.C11 ; DPS2.C11 178.88,410.21 ; DPS2.C11 178.07,411.02 ; DPS2.C11 177.26,410.21 ; D102.B4 170.45,82.09 ; D102.B4 169.64,81.28 ; D102.B4 171.26,81.28 ; D102.B4 170.45,80.47 ; 127.27,372.57 D227.A2 ; D227.A2 127.27,374.19 ; D227.A2 128.08,373.38 ; D227.A2 126.46,373.38 ; D111.A16 239.84,373.38 ; D111.A16 239.03,372.57 ; D111.A16 238.22,373.38 ; D111.A16 239.03,374.19 ; D432.A4 48.53,404.67 ; D432.A4 47.72,403.86 ; D432.A4 49.34,403.86 ; D432.A4 48.53,403.05 ; D123.B13 119.65,59.23 ; D123.B13 118.84,58.42 ; D123.B13 119.65,57.61 ; D123.B13 120.46,58.42 ; 46.68,361.14 UHC430.G2 ; UHC430.G2 45.87,361.95 ; UHC430.G2 46.68,362.76 ; UHC430.G2 47.49,361.95 ; 33.29,403.05 D432.A10 ; D432.A10 33.29,404.67 ; D432.A10 32.48,403.86 ; D432.A10 34.1,403.86 ; D114.B8 186.5,347.98 ; D114.B8 184.88,347.98 ; D114.B8 185.69,347.17 ; D114.B8 185.69,348.79 ; 256.81,329.39 D109.B9 ; D109.B9 256.81,331.01 ; D109.B9 256,330.2 ; D109.B9 257.62,330.2 ; 101.87,362.41 CSDPS426.B12 ; CSDPS426.B12 102.68,363.22 ; CSDPS426.B12 101.06,363.22 ; CSDPS426.B12 101.87,364.03 ; 188.23,334.47 D113.A7 ; D113.A7 189.04,335.28 ; D113.A7 188.23,336.09 ; D113.A7 187.42,335.28 ; 20.59,400.51 D432.B15 ; D432.B15 20.59,402.13 ; D432.B15 21.4,401.32 ; D432.B15 19.78,401.32 ; 40.91,400.51 D432.B7 ; D432.B7 40.1,401.32 ; D432.B7 40.91,402.13 ; D432.B7 41.72,401.32 ; D111.B6 265.24,368.3 ; D111.B6 264.43,369.11 ; D111.B6 263.62,368.3 ; D111.B6 264.43,367.49 ; CSDPS429.C5 45.99,341.17 ; CSDPS429.C5 45.99,339.55 ; CSDPS429.C5 45.18,340.36 ; CSDPS429.C5 46.8,340.36 ; 40.1,370.84 D231.B7 ; D231.B7 40.91,370.03 ; D231.B7 41.72,370.84 ; D231.B7 40.91,371.65 ; D232.A3 51.07,397.05 ; D232.A3 51.88,396.24 ; D232.A3 51.07,395.43 ; D232.A3 50.26,396.24 ; D113.A6 191.58,332.74 ; D113.A6 190.77,331.93 ; D113.A6 189.96,332.74 ; D113.A6 190.77,333.55 ; 19.18,357.64 UHC430.G1_11 ; UHC430.G1_11 19.18,359.26 ; UHC430.G1_11 18.37,358.45 ; UHC430.G1_11 19.99,358.45 ; 187.42,355.6 D114.A7 ; D114.A7 188.23,356.41 ; D114.A7 189.04,355.6 ; D114.A7 188.23,354.79 ; D102.A12 190.77,77.01 ; D102.A12 189.96,76.2 ; D102.A12 191.58,76.2 ; D102.A12 190.77,75.39 ; 50.26,330.2 CSDPS229.C3 ; CSDPS229.C3 51.88,330.2 ; CSDPS229.C3 51.07,329.39 ; CSDPS229.C3 51.07,331.01 ; 256,99.06 D105.B9 ; D105.B9 257.62,99.06 ; D105.B9 256.81,98.25 ; D105.B9 256.81,99.87 ; D109.A16 239.84,332.74 ; D109.A16 238.22,332.74 ; D109.A16 239.03,331.93 ; D109.A16 239.03,333.55 ; D227.A16 92.52,373.38 ; D227.A16 91.71,374.19 ; D227.A16 91.71,372.57 ; D227.A16 90.9,373.38 ; D109.B8 259.35,328.47 ; D109.B8 260.16,327.66 ; D109.B8 258.54,327.66 ; D109.B8 259.35,326.85 ; 29.94,73.66 D118.A7 ; D118.A7 30.75,74.47 ; D118.A7 30.75,72.85 ; D118.A7 31.56,73.66 ; 32.48,378.46 D431.B10 ; D431.B10 34.1,378.46 ; D431.B10 33.29,379.27 ; D431.B10 33.29,377.65 ; D104.A4 171.26,35.56 ; D104.A4 169.64,35.56 ; D104.A4 170.45,36.37 ; D104.A4 170.45,34.75 ; 129,330.2 CSDPS225.C1 ; CSDPS225.C1 129.81,331.01 ; CSDPS225.C1 130.62,330.2 ; CSDPS225.C1 129.81,329.39 ; 165.37,34.75 D104.A2 ; D104.A2 166.18,35.56 ; D104.A2 164.56,35.56 ; D104.A2 165.37,36.37 ; UHC230.G3_8 45.19,351.79 ; UHC230.G3_8 43.57,351.79 ; UHC230.G3_8 44.38,350.98 ; UHC230.G3_8 44.38,352.6 ; 19.78,58.42 D119.B3 ; D119.B3 20.59,59.23 ; D119.B3 20.59,57.61 ; D119.B3 21.4,58.42 ; 239.03,367.49 D111.B16 ; D111.B16 239.03,369.11 ; D111.B16 239.84,368.3 ; D111.B16 238.22,368.3 ; D116.A8 185.69,394.51 ; D116.A8 186.5,393.7 ; D116.A8 184.88,393.7 ; D116.A8 185.69,392.89 ; D123.B12 117.11,61.77 ; D123.B12 117.92,60.96 ; D123.B12 117.11,60.15 ; D123.B12 116.3,60.96 ; 197.58,73.66 D102.A15 ; D102.A15 199.2,73.66 ; D102.A15 198.39,74.47 ; D102.A15 198.39,72.85 ; 98.52,391.16 D228.B13 ; D228.B13 100.14,391.16 ; D228.B13 99.33,390.35 ; D228.B13 99.33,391.97 ; D105.B8 255.08,101.6 ; D105.B8 254.27,102.41 ; D105.B8 254.27,100.79 ; D105.B8 253.46,101.6 ; 167.91,77.93 D102.B3 ; D102.B3 168.72,78.74 ; D102.B3 167.91,79.55 ; D102.B3 167.1,78.74 ; D432.B12 29.02,398.78 ; D432.B12 28.21,397.97 ; D432.B12 27.4,398.78 ; D432.B12 28.21,399.59 ; 88.36,73.66 D122.A1 ; D122.A1 89.17,74.47 ; D122.A1 89.17,72.85 ; D122.A1 89.98,73.66 ; 56.15,409.4 DPS8.C01 ; DPS8.C01 56.15,411.02 ; DPS8.C01 56.96,410.21 ; DPS8.C01 55.34,410.21 ; 195.04,60.96 D103.B14 ; D103.B14 195.85,60.15 ; D103.B14 195.85,61.77 ; D103.B14 196.66,60.96 ; 271.24,78.74 D106.B15 ; D106.B15 272.86,78.74 ; D106.B15 272.05,77.93 ; D106.B15 272.05,79.55 ; 35.02,53.34 D119.A9 ; D119.A9 35.83,54.15 ; D119.A9 36.64,53.34 ; D119.A9 35.83,52.53 ; 177.26,73.66 D102.A7 ; D102.A7 178.88,73.66 ; D102.A7 178.07,72.85 ; D102.A7 178.07,74.47 ; 178.07,414.48 DPS2.A11 ; DPS2.A11 177.26,415.29 ; DPS2.A11 178.07,416.1 ; DPS2.A11 178.88,415.29 ; D106.A6 250,76.2 ; D106.A6 249.19,75.39 ; D106.A6 248.38,76.2 ; D106.A6 249.19,77.01 ; 165.37,75.39 D102.A2 ; D102.A2 165.37,77.01 ; D102.A2 164.56,76.2 ; D102.A2 166.18,76.2 ; 271.24,370.84 D111.B3 ; D111.B3 272.86,370.84 ; D111.B3 272.05,370.03 ; D111.B3 272.05,371.65 ; 261.08,53.34 D107.A11 ; D107.A11 261.89,52.53 ; D107.A11 261.89,54.15 ; D107.A11 262.7,53.34 ; 90.9,353.06 CSDPS226.B16 ; CSDPS226.B16 91.71,353.87 ; CSDPS226.B16 91.71,352.25 ; CSDPS226.B16 92.52,353.06 ; D115.A16 166.18,373.38 ; D115.A16 165.37,372.57 ; D115.A16 164.56,373.38 ; D115.A16 165.37,374.19 ; 48.53,331.93 CSDPS229.B4 ; CSDPS229.B4 48.53,333.55 ; CSDPS229.B4 47.72,332.74 ; CSDPS229.B4 49.34,332.74 ; 273.78,60.96 D107.B16 ; D107.B16 275.4,60.96 ; D107.B16 274.59,60.15 ; D107.B16 274.59,61.77 ; 259.35,75.39 D106.A10 ; D106.A10 260.16,76.2 ; D106.A10 258.54,76.2 ; D106.A10 259.35,77.01 ; 99.33,32.21 D124.A5 ; D124.A5 99.33,33.83 ; D124.A5 98.52,33.02 ; D124.A5 100.14,33.02 ; 203.47,414.48 DPS2.A01 ; DPS2.A01 203.47,416.1 ; DPS2.A01 202.66,415.29 ; DPS2.A01 204.28,415.29 ; 184.88,81.28 D102.B10 ; D102.B10 186.5,81.28 ; D102.B10 185.69,82.09 ; D102.B10 185.69,80.47 ; 271.24,99.06 D105.B15 ; D105.B15 272.05,98.25 ; D105.B15 272.05,99.87 ; D105.B15 272.86,99.06 ; 19.78,410.21 DPS8.C15 ; DPS8.C15 20.59,411.02 ; DPS8.C15 21.4,410.21 ; DPS8.C15 20.59,409.4 ; 117.11,372.57 D227.A6 ; D227.A6 116.3,373.38 ; D227.A6 117.11,374.19 ; D227.A6 117.92,373.38 ; 188.23,390.35 D116.B7 ; D116.B7 187.42,391.16 ; D116.B7 188.23,391.97 ; D116.B7 189.04,391.16 ; 30.75,409.4 DPS8.C11 ; DPS8.C11 30.75,411.02 ; DPS8.C11 31.56,410.21 ; DPS8.C11 29.94,410.21 ; 195.85,39.83 D104.B14 ; D104.B14 196.66,40.64 ; D104.B14 195.04,40.64 ; D104.B14 195.85,41.45 ; D101.A5 173.8,93.98 ; D101.A5 172.18,93.98 ; D101.A5 172.99,94.79 ; D101.A5 172.99,93.17 ; 266.97,334.47 D109.A5 ; D109.A5 266.97,336.09 ; D109.A5 267.78,335.28 ; D109.A5 266.16,335.28 ; 123.92,58.42 D123.B15 ; D123.B15 124.73,57.61 ; D123.B15 124.73,59.23 ; D123.B15 125.54,58.42 ; 106.14,60.96 D123.B8 ; D123.B8 106.95,61.77 ; D123.B8 107.76,60.96 ; D123.B8 106.95,60.15 ; D111.B7 262.7,370.84 ; D111.B7 261.89,371.65 ; D111.B7 261.89,370.03 ; D111.B7 261.08,370.84 ; D110.A3 272.05,356.41 ; D110.A3 272.86,355.6 ; D110.A3 271.24,355.6 ; D110.A3 272.05,354.79 ; UHC430.G2_12 47.49,358.45 ; UHC430.G2_12 46.68,357.64 ; UHC430.G2_12 45.87,358.45 ; UHC430.G2_12 46.68,359.26 ; D110.B11 252.54,350.52 ; D110.B11 251.73,351.33 ; D110.B11 250.92,350.52 ; D110.B11 251.73,349.71 ; 192.5,53.34 D103.A13 ; D103.A13 193.31,54.15 ; D103.A13 194.12,53.34 ; D103.A13 193.31,52.53 ; CSDPS426.C9 109.49,361.49 ; CSDPS426.C9 108.68,360.68 ; CSDPS426.C9 110.3,360.68 ; CSDPS426.C9 109.49,359.87 ; 123.92,33.02 D124.A15 ; D124.A15 125.54,33.02 ; D124.A15 124.73,33.83 ; D124.A15 124.73,32.21 ; D120.A1 16.32,33.02 ; D120.A1 14.7,33.02 ; D120.A1 15.51,33.83 ; D120.A1 15.51,32.21 ; 30.75,411.94 DPS8.B11 ; DPS8.B11 31.56,412.75 ; DPS8.B11 30.75,413.56 ; DPS8.B11 29.94,412.75 ; 259.35,387.81 D112.B8 ; D112.B8 260.16,388.62 ; D112.B8 259.35,389.43 ; D112.B8 258.54,388.62 ; 53.61,55.07 D119.A16 ; D119.A16 54.42,55.88 ; D119.A16 52.8,55.88 ; D119.A16 53.61,56.69 ; CSDPS425.B2 128.08,342.9 ; CSDPS425.B2 127.27,342.09 ; CSDPS425.B2 127.27,343.71 ; CSDPS425.B2 126.46,342.9 ; 185.69,387.81 D116.B8 ; D116.B8 184.88,388.62 ; D116.B8 186.5,388.62 ; D116.B8 185.69,389.43 ; D119.B14 49.34,60.96 ; D119.B14 48.53,61.77 ; D119.B14 48.53,60.15 ; D119.B14 47.72,60.96 ; D231.B9 36.64,370.84 ; D231.B9 35.83,370.03 ; D231.B9 35.02,370.84 ; D231.B9 35.83,371.65 ; 200.12,76.2 D102.A16 ; D102.A16 200.93,77.01 ; D102.A16 201.74,76.2 ; D102.A16 200.93,75.39 ; 20.59,395.43 D232.A15 ; D232.A15 21.4,396.24 ; D232.A15 19.78,396.24 ; D232.A15 20.59,397.05 ; 195.85,331.93 D113.A4 ; D113.A4 196.66,332.74 ; D113.A4 195.04,332.74 ; D113.A4 195.85,333.55 ; 253.46,353.06 D110.A10 ; D110.A10 255.08,353.06 ; D110.A10 254.27,353.87 ; D110.A10 254.27,352.25 ; D102.B2 166.18,81.28 ; D102.B2 165.37,82.09 ; D102.B2 164.56,81.28 ; D102.B2 165.37,80.47 ; 15.73,349.23 UHC230.G4_10 ; UHC230.G4_10 14.92,350.04 ; UHC230.G4_10 16.54,350.04 ; UHC230.G4_10 15.73,350.85 ; D116.A16 166.18,393.7 ; D116.A16 164.56,393.7 ; D116.A16 165.37,392.89 ; D116.A16 165.37,394.51 ; 91.71,55.07 D123.A2 ; D123.A2 90.9,55.88 ; D123.A2 91.71,56.69 ; D123.A2 92.52,55.88 ; D104.B2 166.18,40.64 ; D104.B2 165.37,41.45 ; D104.B2 164.56,40.64 ; D104.B2 165.37,39.83 ; CSDPS425.B16 92.52,342.9 ; CSDPS425.B16 90.9,342.9 ; CSDPS425.B16 91.71,342.09 ; CSDPS425.B16 91.71,343.71 ; 20.59,390.35 D232.B15 ; D232.B15 21.4,391.16 ; D232.B15 19.78,391.16 ; D232.B15 20.59,391.97 ; CSDPS425.C15 95.06,340.36 ; CSDPS425.C15 94.25,341.17 ; CSDPS425.C15 93.44,340.36 ; CSDPS425.C15 94.25,339.55 ; 30.75,32.21 D120.A7 ; D120.A7 31.56,33.02 ; D120.A7 29.94,33.02 ; D120.A7 30.75,33.83 ; 112.03,39.83 D124.B10 ; D124.B10 112.84,40.64 ; D124.B10 111.22,40.64 ; D124.B10 112.03,41.45 ; 256.81,32.21 D108.A9 ; D108.A9 256,33.02 ; D108.A9 257.62,33.02 ; D108.A9 256.81,33.83 ; 119.65,77.93 D122.B13 ; D122.B13 118.84,78.74 ; D122.B13 120.46,78.74 ; D122.B13 119.65,79.55 ; 236.49,37.29 D108.B1 ; D108.B1 236.49,38.91 ; D108.B1 237.3,38.1 ; D108.B1 235.68,38.1 ; UHC430.G1_2 17.69,365.45 ; UHC430.G1_2 16.88,366.26 ; UHC430.G1_2 16.88,364.64 ; UHC430.G1_2 16.07,365.45 ; 121.38,40.64 D124.B14 ; D124.B14 122.19,39.83 ; D124.B14 123,40.64 ; D124.B14 122.19,41.45 ; D231.A11 30.75,376.73 ; D231.A11 29.94,375.92 ; D231.A11 31.56,375.92 ; D231.A11 30.75,375.11 ; D105.B6 249.19,102.41 ; D105.B6 249.19,100.79 ; D105.B6 248.38,101.6 ; D105.B6 250,101.6 ; D120.B9 35.83,38.91 ; D120.B9 36.64,38.1 ; D120.B9 35.83,37.29 ; D120.B9 35.02,38.1 ; 179.8,393.7 D116.A10 ; D116.A10 181.42,393.7 ; D116.A10 180.61,392.89 ; D116.A10 180.61,394.51 ; 99.33,52.53 D123.A5 ; D123.A5 100.14,53.34 ; D123.A5 99.33,54.15 ; D123.A5 98.52,53.34 ; 108.68,99.06 D121.B9 ; D121.B9 110.3,99.06 ; D121.B9 109.49,99.87 ; D121.B9 109.49,98.25 ; 119.65,32.21 D124.A13 ; D124.A13 119.65,33.83 ; D124.A13 118.84,33.02 ; D124.A13 120.46,33.02 ; D116.B16 165.37,389.43 ; D116.B16 164.56,388.62 ; D116.B16 165.37,387.81 ; D116.B16 166.18,388.62 ; 53.61,377.65 D431.B2 ; D431.B2 52.8,378.46 ; D431.B2 53.61,379.27 ; D431.B2 54.42,378.46 ; D122.A8 107.76,76.2 ; D122.A8 106.95,75.39 ; D122.A8 106.14,76.2 ; D122.A8 106.95,77.01 ; D124.A6 102.68,35.56 ; D124.A6 101.87,34.75 ; D124.A6 101.87,36.37 ; D124.A6 101.06,35.56 ; 14.58,347.48 UHC230.G4_13 ; UHC230.G4_13 14.58,349.1 ; UHC230.G4_13 15.39,348.29 ; UHC230.G4_13 13.77,348.29 ; 175.53,387.81 D116.B12 ; D116.B12 174.72,388.62 ; D116.B12 175.53,389.43 ; D116.B12 176.34,388.62 ; 18.05,60.15 D119.B2 ; D119.B2 17.24,60.96 ; D119.B2 18.05,61.77 ; D119.B2 18.86,60.96 ; DPS8.C05 45.99,411.02 ; DPS8.C05 46.8,410.21 ; DPS8.C05 45.99,409.4 ; DPS8.C05 45.18,410.21 ; 20.59,370.03 D231.B15 ; D231.B15 20.59,371.65 ; D231.B15 19.78,370.84 ; D231.B15 21.4,370.84 ; D104.A6 176.34,35.56 ; D104.A6 174.72,35.56 ; D104.A6 175.53,34.75 ; D104.A6 175.53,36.37 ; D109.B16 239.84,327.66 ; D109.B16 239.03,326.85 ; D109.B16 238.22,327.66 ; D109.B16 239.03,328.47 ; 111.22,342.9 CSDPS425.B8 ; CSDPS425.B8 112.84,342.9 ; CSDPS425.B8 112.03,343.71 ; CSDPS425.B8 112.03,342.09 ; 113.76,386.08 D427.A7 ; D427.A7 115.38,386.08 ; D427.A7 114.57,386.89 ; D427.A7 114.57,385.27 ; D123.A1 89.17,54.15 ; D123.A1 89.98,53.34 ; D123.A1 89.17,52.53 ; D123.A1 88.36,53.34 ; D104.B9 183.15,38.91 ; D104.B9 183.96,38.1 ; D104.B9 182.34,38.1 ; D104.B9 183.15,37.29 ; D115.A7 189.04,375.92 ; D115.A7 187.42,375.92 ; D115.A7 188.23,375.11 ; D115.A7 188.23,376.73 ; D428.B6 117.92,398.78 ; D428.B6 117.11,397.97 ; D428.B6 117.11,399.59 ; D428.B6 116.3,398.78 ; UHC430.G2_6 48.98,362.76 ; UHC430.G2_6 48.17,361.95 ; UHC430.G2_6 49.79,361.95 ; UHC430.G2_6 48.98,361.14 ; 95.98,363.22 CSDPS426.B14 ; CSDPS426.B14 96.79,362.41 ; CSDPS426.B14 97.6,363.22 ; CSDPS426.B14 96.79,364.03 ; 47.02,353.54 UHC230.G3_4 ; UHC230.G3_4 47.83,354.35 ; UHC230.G3_4 48.64,353.54 ; UHC230.G3_4 47.83,352.73 ; D113.A9 183.15,336.09 ; D113.A9 183.96,335.28 ; D113.A9 182.34,335.28 ; D113.A9 183.15,334.47 ; 112.03,80.47 D122.B10 ; D122.B10 112.03,82.09 ; D122.B10 112.84,81.28 ; D122.B10 111.22,81.28 ; 264.43,39.83 D108.B12 ; D108.B12 263.62,40.64 ; D108.B12 265.24,40.64 ; D108.B12 264.43,41.45 ; 35.02,340.36 CSDPS429.C9 ; CSDPS429.C9 35.83,339.55 ; CSDPS429.C9 36.64,340.36 ; CSDPS429.C9 35.83,341.17 ; 266.97,77.93 D106.B13 ; D106.B13 266.16,78.74 ; D106.B13 267.78,78.74 ; D106.B13 266.97,79.55 ; D115.B5 194.12,370.84 ; D115.B5 192.5,370.84 ; D115.B5 193.31,370.03 ; D115.B5 193.31,371.65 ; D428.A12 101.87,404.67 ; D428.A12 101.87,403.05 ; D428.A12 101.06,403.86 ; D428.A12 102.68,403.86 ; D103.A4 171.26,55.88 ; D103.A4 169.64,55.88 ; D103.A4 170.45,56.69 ; D103.A4 170.45,55.07 ; UHC430.G2_9 47.83,361.01 ; UHC430.G2_9 48.64,360.2 ; UHC430.G2_9 47.83,359.39 ; UHC430.G2_9 47.02,360.2 ; 261.08,13.97 DPS1.A11 ; DPS1.A11 261.89,14.78 ; DPS1.A11 262.7,13.97 ; DPS1.A11 261.89,13.16 ; D109.A12 250,332.74 ; D109.A12 248.38,332.74 ; D109.A12 249.19,331.93 ; D109.A12 249.19,333.55 ; D103.A15 199.2,53.34 ; D103.A15 197.58,53.34 ; D103.A15 198.39,54.15 ; D103.A15 198.39,52.53 ; D231.B8 39.18,368.3 ; D231.B8 38.37,369.11 ; D231.B8 37.56,368.3 ; D231.B8 38.37,367.49 ; D101.A13 193.31,94.79 ; D101.A13 192.5,93.98 ; D101.A13 193.31,93.17 ; D101.A13 194.12,93.98 ; D124.B2 92.52,40.64 ; D124.B2 91.71,41.45 ; D124.B2 91.71,39.83 ; D124.B2 90.9,40.64 ; D119.A4 23.13,56.69 ; D119.A4 22.32,55.88 ; D119.A4 23.94,55.88 ; D119.A4 23.13,55.07 ; 96.79,392.89 D228.A14 ; D228.A14 96.79,394.51 ; D228.A14 97.6,393.7 ; D228.A14 95.98,393.7 ; 112.03,372.57 D227.A8 ; D227.A8 112.03,374.19 ; D227.A8 112.84,373.38 ; D227.A8 111.22,373.38 ; D116.A5 193.31,397.05 ; D116.A5 194.12,396.24 ; D116.A5 192.5,396.24 ; D116.A5 193.31,395.43 ; 167.91,390.35 D116.B15 ; D116.B15 168.72,391.16 ; D116.B15 167.1,391.16 ; D116.B15 167.91,391.97 ; 162.83,37.29 D104.B1 ; D104.B1 163.64,38.1 ; D104.B1 162.83,38.91 ; D104.B1 162.02,38.1 ; 103.6,406.4 D428.A11 ; D428.A11 104.41,407.21 ; D428.A11 105.22,406.4 ; D428.A11 104.41,405.59 ; D114.A16 166.18,353.06 ; D114.A16 165.37,353.87 ; D114.A16 165.37,352.25 ; D114.A16 164.56,353.06 ; 15.73,352.73 UHC230.G4_5 ; UHC230.G4_5 14.92,353.54 ; UHC230.G4_5 16.54,353.54 ; UHC230.G4_5 15.73,354.35 ; D112.B5 267.78,391.16 ; D112.B5 266.16,391.16 ; D112.B5 266.97,390.35 ; D112.B5 266.97,391.97 ; 114.57,15.7 DPS3.B11 ; DPS3.B11 115.38,16.51 ; DPS3.B11 113.76,16.51 ; DPS3.B11 114.57,17.32 ; 245.84,38.1 D108.B5 ; D108.B5 246.65,37.29 ; D108.B5 247.46,38.1 ; D108.B5 246.65,38.91 ; 42.64,378.46 D431.B6 ; D431.B6 43.45,379.27 ; D431.B6 43.45,377.65 ; D431.B6 44.26,378.46 ; D106.B5 246.65,79.55 ; D106.B5 246.65,77.93 ; D106.B5 247.46,78.74 ; D106.B5 245.84,78.74 ; D232.A13 25.67,397.05 ; D232.A13 26.48,396.24 ; D232.A13 25.67,395.43 ; D232.A13 24.86,396.24 ; 122.19,362.41 CSDPS426.B4 ; CSDPS426.B4 123,363.22 ; CSDPS426.B4 122.19,364.03 ; CSDPS426.B4 121.38,363.22 ; 15.51,370.03 D231.B17 ; D231.B17 16.32,370.84 ; D231.B17 15.51,371.65 ; D231.B17 14.7,370.84 ; D122.A2 92.52,76.2 ; D122.A2 91.71,77.01 ; D122.A2 91.71,75.39 ; D122.A2 90.9,76.2 ; 44.38,354.48 UHC230.G3_3 ; UHC230.G3_3 45.19,355.29 ; UHC230.G3_3 44.38,356.1 ; UHC230.G3_3 43.57,355.29 ; 109.49,32.21 D124.A9 ; D124.A9 108.68,33.02 ; D124.A9 110.3,33.02 ; D124.A9 109.49,33.83 ; UHC430.G2_5 45.53,364.51 ; UHC430.G2_5 45.53,362.89 ; UHC430.G2_5 44.72,363.7 ; UHC430.G2_5 46.34,363.7 ; DPS8.A11 30.75,416.1 ; DPS8.A11 30.75,414.48 ; DPS8.A11 31.56,415.29 ; DPS8.A11 29.94,415.29 ; D113.A12 175.53,333.55 ; D113.A12 176.34,332.74 ; D113.A12 174.72,332.74 ; D113.A12 175.53,331.93 ; D227.B9 109.49,371.65 ; D227.B9 109.49,370.03 ; D227.B9 108.68,370.84 ; D227.B9 110.3,370.84 ; D228.B9 110.3,391.16 ; D228.B9 109.49,391.97 ; D228.B9 108.68,391.16 ; D228.B9 109.49,390.35 ; 50.26,73.66 D118.A15 ; D118.A15 51.88,73.66 ; D118.A15 51.07,72.85 ; D118.A15 51.07,74.47 ; D121.A8 106.95,97.33 ; D121.A8 107.76,96.52 ; D121.A8 106.95,95.71 ; D121.A8 106.14,96.52 ; D232.A8 38.37,394.51 ; D232.A8 38.37,392.89 ; D232.A8 37.56,393.7 ; D232.A8 39.18,393.7 ; D114.A15 167.91,356.41 ; D114.A15 167.1,355.6 ; D114.A15 167.91,354.79 ; D114.A15 168.72,355.6 ; D106.A1 237.3,73.66 ; D106.A1 235.68,73.66 ; D106.A1 236.49,74.47 ; D106.A1 236.49,72.85 ; D231.B4 48.53,369.11 ; D231.B4 49.34,368.3 ; D231.B4 47.72,368.3 ; D231.B4 48.53,367.49 ; D116.A3 199.2,396.24 ; D116.A3 197.58,396.24 ; D116.A3 198.39,395.43 ; D116.A3 198.39,397.05 ; D112.B11 252.54,391.16 ; D112.B11 251.73,390.35 ; D112.B11 250.92,391.16 ; D112.B11 251.73,391.97 ; D101.B15 198.39,99.87 ; D101.B15 199.2,99.06 ; D101.B15 198.39,98.25 ; D101.B15 197.58,99.06 ; D110.A1 277.13,356.41 ; D110.A1 277.94,355.6 ; D110.A1 276.32,355.6 ; D110.A1 277.13,354.79 ; 24.86,406.4 D432.A13 ; D432.A13 25.67,405.59 ; D432.A13 26.48,406.4 ; D432.A13 25.67,407.21 ; D114.B11 178.88,350.52 ; D114.B11 177.26,350.52 ; D114.B11 178.07,351.33 ; D114.B11 178.07,349.71 ; D111.A12 249.19,374.19 ; D111.A12 248.38,373.38 ; D111.A12 249.19,372.57 ; D111.A12 250,373.38 ; D109.B2 275.4,327.66 ; D109.B2 274.59,326.85 ; D109.B2 273.78,327.66 ; D109.B2 274.59,328.47 ; 14.7,58.42 D119.B1 ; D119.B1 15.51,57.61 ; D119.B1 15.51,59.23 ; D119.B1 16.32,58.42 ; 264.43,60.15 D107.B12 ; D107.B12 265.24,60.96 ; D107.B12 264.43,61.77 ; D107.B12 263.62,60.96 ; 174.72,327.66 D113.B12 ; D113.B12 176.34,327.66 ; D113.B12 175.53,326.85 ; D113.B12 175.53,328.47 ; 258.54,393.7 D112.A8 ; D112.A8 260.16,393.7 ; D112.A8 259.35,394.51 ; D112.A8 259.35,392.89 ; 50.26,33.02 D120.A15 ; D120.A15 51.07,32.21 ; D120.A15 51.07,33.83 ; D120.A15 51.88,33.02 ; 20.59,375.11 D231.A15 ; D231.A15 20.59,376.73 ; D231.A15 21.4,375.92 ; D231.A15 19.78,375.92 ; 167.91,52.53 D103.A3 ; D103.A3 168.72,53.34 ; D103.A3 167.1,53.34 ; D103.A3 167.91,54.15 ; D103.B5 173.8,58.42 ; D103.B5 172.18,58.42 ; D103.B5 172.99,59.23 ; D103.B5 172.99,57.61 ; D123.B16 127.27,61.77 ; D123.B16 128.08,60.96 ; D123.B16 127.27,60.15 ; D123.B16 126.46,60.96 ; 99.33,77.93 D122.B5 ; D122.B5 98.52,78.74 ; D122.B5 99.33,79.55 ; D122.B5 100.14,78.74 ; D109.B12 250,327.66 ; D109.B12 249.19,326.85 ; D109.B12 248.38,327.66 ; D109.B12 249.19,328.47 ; D114.B16 166.18,347.98 ; D114.B16 164.56,347.98 ; D114.B16 165.37,348.79 ; D114.B16 165.37,347.17 ; 95.98,383.54 D427.A14 ; D427.A14 97.6,383.54 ; D427.A14 96.79,382.73 ; D427.A14 96.79,384.35 ; CSDPS229.C7 41.72,330.2 ; CSDPS229.C7 40.1,330.2 ; CSDPS229.C7 40.91,331.01 ; CSDPS229.C7 40.91,329.39 ; D228.B10 107.76,388.62 ; D228.B10 106.95,387.81 ; D228.B10 106.14,388.62 ; D228.B10 106.95,389.43 ; 127.27,34.75 D124.A16 ; D124.A16 126.46,35.56 ; D124.A16 127.27,36.37 ; D124.A16 128.08,35.56 ; D232.A2 53.61,394.51 ; D232.A2 54.42,393.7 ; D232.A2 53.61,392.89 ; D232.A2 52.8,393.7 ; UHC230.G3_10 45.53,350.85 ; UHC230.G3_10 45.53,349.23 ; UHC230.G3_10 46.34,350.04 ; UHC230.G3_10 44.72,350.04 ; 117.11,392.89 D228.A6 ; D228.A6 117.92,393.7 ; D228.A6 116.3,393.7 ; D228.A6 117.11,394.51 ; 33.29,372.57 D231.A10 ; D231.A10 34.1,373.38 ; D231.A10 32.48,373.38 ; D231.A10 33.29,374.19 ; 162.02,58.42 D103.B1 ; D103.B1 163.64,58.42 ; D103.B1 162.83,59.23 ; D103.B1 162.83,57.61 ; 172.18,33.02 D104.A5 ; D104.A5 172.99,33.83 ; D104.A5 173.8,33.02 ; D104.A5 172.99,32.21 ; D115.B1 203.47,371.65 ; D115.B1 204.28,370.84 ; D115.B1 203.47,370.03 ; D115.B1 202.66,370.84 ; 167.91,414.48 DPS2.A15 ; DPS2.A15 167.1,415.29 ; DPS2.A15 168.72,415.29 ; DPS2.A15 167.91,416.1 ; CSDPS425.B12 101.87,343.71 ; CSDPS425.B12 101.06,342.9 ; CSDPS425.B12 102.68,342.9 ; CSDPS425.B12 101.87,342.09 ; D110.B1 277.13,351.33 ; D110.B1 277.13,349.71 ; D110.B1 277.94,350.52 ; D110.B1 276.32,350.52 ; 104.41,52.53 D123.A7 ; D123.A7 103.6,53.34 ; D123.A7 105.22,53.34 ; D123.A7 104.41,54.15 ; 25.67,390.35 D232.B13 ; D232.B13 25.67,391.97 ; D232.B13 24.86,391.16 ; D232.B13 26.48,391.16 ; 19.18,364.64 UHC430.G1_1 ; UHC430.G1_1 18.37,365.45 ; UHC430.G1_1 19.18,366.26 ; UHC430.G1_1 19.99,365.45 ; 98.52,350.52 CSDPS226.C13 ; CSDPS226.C13 99.33,351.33 ; CSDPS226.C13 100.14,350.52 ; CSDPS226.C13 99.33,349.71 ; D107.B7 252.54,58.42 ; D107.B7 251.73,59.23 ; D107.B7 250.92,58.42 ; D107.B7 251.73,57.61 ; D123.A13 119.65,54.15 ; D123.A13 120.46,53.34 ; D123.A13 118.84,53.34 ; D123.A13 119.65,52.53 ; D124.B12 117.11,41.45 ; D124.B12 117.11,39.83 ; D124.B12 117.92,40.64 ; D124.B12 116.3,40.64 ; D109.B13 247.46,330.2 ; D109.B13 246.65,331.01 ; D109.B13 246.65,329.39 ; D109.B13 245.84,330.2 ; 33.29,60.15 D119.B8 ; D119.B8 32.48,60.96 ; D119.B8 33.29,61.77 ; D119.B8 34.1,60.96 ; 202.66,410.21 DPS2.C01 ; DPS2.C01 203.47,411.02 ; DPS2.C01 204.28,410.21 ; DPS2.C01 203.47,409.4 ; 121.38,101.6 D121.B14 ; D121.B14 123,101.6 ; D121.B14 122.19,100.79 ; D121.B14 122.19,102.41 ; 40.91,32.21 D120.A11 ; D120.A11 40.1,33.02 ; D120.A11 41.72,33.02 ; D120.A11 40.91,33.83 ; D428.B15 95.06,401.32 ; D428.B15 94.25,400.51 ; D428.B15 93.44,401.32 ; D428.B15 94.25,402.13 ; D428.A9 109.49,407.21 ; D428.A9 109.49,405.59 ; D428.A9 110.3,406.4 ; D428.A9 108.68,406.4 ; 271.24,19.05 DPS1.C15 ; DPS1.C15 272.05,18.24 ; DPS1.C15 272.86,19.05 ; DPS1.C15 272.05,19.86 ; 94.25,57.61 D123.B3 ; D123.B3 95.06,58.42 ; D123.B3 94.25,59.23 ; D123.B3 93.44,58.42 ; 268.7,55.88 D107.A14 ; D107.A14 269.51,56.69 ; D107.A14 269.51,55.07 ; D107.A14 270.32,55.88 ; UHC230.G4_4 18.84,353.54 ; UHC230.G4_4 18.03,352.73 ; UHC230.G4_4 18.03,354.35 ; UHC230.G4_4 17.22,353.54 ; D428.A17 89.17,407.21 ; D428.A17 89.98,406.4 ; D428.A17 89.17,405.59 ; D428.A17 88.36,406.4 ; D122.A5 99.33,74.47 ; D122.A5 98.52,73.66 ; D122.A5 100.14,73.66 ; D122.A5 99.33,72.85 ; 103.6,396.24 D228.A11 ; D228.A11 104.41,395.43 ; D228.A11 105.22,396.24 ; D228.A11 104.41,397.05 ; D112.A16 239.03,394.51 ; D112.A16 239.84,393.7 ; D112.A16 239.03,392.89 ; D112.A16 238.22,393.7 ; 195.85,387.81 D116.B4 ; D116.B4 195.04,388.62 ; D116.B4 196.66,388.62 ; D116.B4 195.85,389.43 ; 111.22,398.78 D428.B8 ; D428.B8 112.84,398.78 ; D428.B8 112.03,397.97 ; D428.B8 112.03,399.59 ; 192.5,58.42 D103.B13 ; D103.B13 193.31,59.23 ; D103.B13 194.12,58.42 ; D103.B13 193.31,57.61 ; 18.05,372.57 D231.A16 ; D231.A16 18.05,374.19 ; D231.A16 17.24,373.38 ; D231.A16 18.86,373.38 ; 189.96,55.88 D103.A12 ; D103.A12 190.77,56.69 ; D103.A12 190.77,55.07 ; D103.A12 191.58,55.88 ; 266.16,93.98 D105.A13 ; D105.A13 267.78,93.98 ; D105.A13 266.97,94.79 ; D105.A13 266.97,93.17 ; 113.76,78.74 D122.B11 ; D122.B11 114.57,77.93 ; D122.B11 114.57,79.55 ; D122.B11 115.38,78.74 ; 99.33,405.59 D428.A13 ; D428.A13 100.14,406.4 ; D428.A13 99.33,407.21 ; D428.A13 98.52,406.4 ; 118.84,396.24 D228.A5 ; D228.A5 119.65,395.43 ; D228.A5 120.46,396.24 ; D228.A5 119.65,397.05 ; 52.8,342.9 CSDPS429.B2 ; CSDPS429.B2 53.61,343.71 ; CSDPS429.B2 53.61,342.09 ; CSDPS429.B2 54.42,342.9 ; 122.19,34.75 D124.A14 ; D124.A14 123,35.56 ; D124.A14 122.19,36.37 ; D124.A14 121.38,35.56 ; 245.84,53.34 D107.A5 ; D107.A5 246.65,54.15 ; D107.A5 247.46,53.34 ; D107.A5 246.65,52.53 ; D112.B9 256.81,391.97 ; D112.B9 256,391.16 ; D112.B9 257.62,391.16 ; D112.B9 256.81,390.35 ; D103.A11 189.04,53.34 ; D103.A11 188.23,54.15 ; D103.A11 188.23,52.53 ; D103.A11 187.42,53.34 ; CSDPS425.C7 115.38,340.36 ; CSDPS425.C7 114.57,341.17 ; CSDPS425.C7 113.76,340.36 ; CSDPS425.C7 114.57,339.55 ; 98.52,340.36 CSDPS425.C13 ; CSDPS425.C13 100.14,340.36 ; CSDPS425.C13 99.33,341.17 ; CSDPS425.C13 99.33,339.55 ; 88.36,391.16 D228.B17 ; D228.B17 89.98,391.16 ; D228.B17 89.17,390.35 ; D228.B17 89.17,391.97 ; D105.B4 244.11,102.41 ; D105.B4 244.92,101.6 ; D105.B4 243.3,101.6 ; D105.B4 244.11,100.79 ; D106.B6 249.19,82.09 ; D106.B6 248.38,81.28 ; D106.B6 249.19,80.47 ; D106.B6 250,81.28 ; D115.A3 199.2,375.92 ; D115.A3 198.39,376.73 ; D115.A3 198.39,375.11 ; D115.A3 197.58,375.92 ; 253.46,81.28 D106.B8 ; D106.B8 254.27,82.09 ; D106.B8 254.27,80.47 ; D106.B8 255.08,81.28 ; D121.B16 128.08,101.6 ; D121.B16 126.46,101.6 ; D121.B16 127.27,102.41 ; D121.B16 127.27,100.79 ; D428.B13 99.33,402.13 ; D428.B13 98.52,401.32 ; D428.B13 99.33,400.51 ; D428.B13 100.14,401.32 ; D113.A3 199.2,335.28 ; D113.A3 198.39,334.47 ; D113.A3 197.58,335.28 ; D113.A3 198.39,336.09 ; 189.96,393.7 D116.A6 ; D116.A6 190.77,394.51 ; D116.A6 190.77,392.89 ; D116.A6 191.58,393.7 ; D427.B17 89.98,381 ; D427.B17 88.36,381 ; D427.B17 89.17,381.81 ; D427.B17 89.17,380.19 ; D107.A16 275.4,55.88 ; D107.A16 274.59,56.69 ; D107.A16 274.59,55.07 ; D107.A16 273.78,55.88 ; 24.86,375.92 D231.A13 ; D231.A13 25.67,375.11 ; D231.A13 26.48,375.92 ; D231.A13 25.67,376.73 ; 250.92,78.74 D106.B7 ; D106.B7 251.73,79.55 ; D106.B7 251.73,77.93 ; D106.B7 252.54,78.74 ; 29.94,406.4 D432.A11 ; D432.A11 30.75,405.59 ; D432.A11 30.75,407.21 ; D432.A11 31.56,406.4 ; UHC230.G3_5 46.34,353.54 ; UHC230.G3_5 45.53,352.73 ; UHC230.G3_5 45.53,354.35 ; UHC230.G3_5 44.72,353.54 ; D122.B7 105.22,78.74 ; D122.B7 103.6,78.74 ; D122.B7 104.41,79.55 ; D122.B7 104.41,77.93 ; D428.A3 125.54,406.4 ; D428.A3 124.73,407.21 ; D428.A3 123.92,406.4 ; D428.A3 124.73,405.59 ; D431.B12 28.21,379.27 ; D431.B12 28.21,377.65 ; D431.B12 29.02,378.46 ; D431.B12 27.4,378.46 ; D113.A16 165.37,333.55 ; D113.A16 165.37,331.93 ; D113.A16 166.18,332.74 ; D113.A16 164.56,332.74 ; 256.81,395.43 D112.A9 ; D112.A9 257.62,396.24 ; D112.A9 256,396.24 ; D112.A9 256.81,397.05 ; D111.A6 264.43,374.19 ; D111.A6 265.24,373.38 ; D111.A6 263.62,373.38 ; D111.A6 264.43,372.57 ; 45.18,415.29 DPS8.A05 ; DPS8.A05 46.8,415.29 ; DPS8.A05 45.99,414.48 ; DPS8.A05 45.99,416.1 ; D121.A10 112.84,96.52 ; D121.A10 112.03,95.71 ; D121.A10 111.22,96.52 ; D121.A10 112.03,97.33 ; D114.A13 173.8,355.6 ; D114.A13 172.18,355.6 ; D114.A13 172.99,356.41 ; D114.A13 172.99,354.79 ; 202.66,396.24 D116.A1 ; D116.A1 203.47,397.05 ; D116.A1 203.47,395.43 ; D116.A1 204.28,396.24 ; 190.77,372.57 D115.A6 ; D115.A6 189.96,373.38 ; D115.A6 191.58,373.38 ; D115.A6 190.77,374.19 ; 45.18,396.24 D232.A5 ; D232.A5 46.8,396.24 ; D232.A5 45.99,395.43 ; D232.A5 45.99,397.05 ; 203.47,349.71 D114.B1 ; D114.B1 204.28,350.52 ; D114.B1 202.66,350.52 ; D114.B1 203.47,351.33 ; D108.A10 260.16,35.56 ; D108.A10 258.54,35.56 ; D108.A10 259.35,36.37 ; D108.A10 259.35,34.75 ; D428.A2 127.27,404.67 ; D428.A2 127.27,403.05 ; D428.A2 126.46,403.86 ; D428.A2 128.08,403.86 ; 261.89,18.24 DPS1.C11 ; DPS1.C11 262.7,19.05 ; DPS1.C11 261.08,19.05 ; DPS1.C11 261.89,19.86 ; 113.76,19.05 DPS3.C11 ; DPS3.C11 114.57,19.86 ; DPS3.C11 114.57,18.24 ; DPS3.C11 115.38,19.05 ; 170.45,39.83 D104.B4 ; D104.B4 171.26,40.64 ; D104.B4 169.64,40.64 ; D104.B4 170.45,41.45 ; 47.72,383.54 D431.A4 ; D431.A4 49.34,383.54 ; D431.A4 48.53,382.73 ; D431.A4 48.53,384.35 ; CSDPS225.C7 115.38,330.2 ; CSDPS225.C7 114.57,331.01 ; CSDPS225.C7 113.76,330.2 ; CSDPS225.C7 114.57,329.39 ; D105.A12 265.24,96.52 ; D105.A12 264.43,95.71 ; D105.A12 263.62,96.52 ; D105.A12 264.43,97.33 ; 235.68,13.97 DPS1.A01 ; DPS1.A01 237.3,13.97 ; DPS1.A01 236.49,14.78 ; DPS1.A01 236.49,13.16 ; 200.12,347.98 D114.B2 ; D114.B2 201.74,347.98 ; D114.B2 200.93,348.79 ; D114.B2 200.93,347.17 ; 240.76,93.98 D105.A3 ; D105.A3 242.38,93.98 ; D105.A3 241.57,93.17 ; D105.A3 241.57,94.79 ; CSDPS425.B10 106.95,343.71 ; CSDPS425.B10 107.76,342.9 ; CSDPS425.B10 106.95,342.09 ; CSDPS425.B10 106.14,342.9 ; CSDPS225.B8 112.03,333.55 ; CSDPS225.B8 112.84,332.74 ; CSDPS225.B8 112.03,331.93 ; CSDPS225.B8 111.22,332.74 ; D227.B3 125.54,370.84 ; D227.B3 124.73,370.03 ; D227.B3 123.92,370.84 ; D227.B3 124.73,371.65 ; 20.59,339.55 CSDPS429.C15 ; CSDPS429.C15 21.4,340.36 ; CSDPS429.C15 19.78,340.36 ; CSDPS429.C15 20.59,341.17 ; 268.7,388.62 D112.B4 ; D112.B4 269.51,387.81 ; D112.B4 269.51,389.43 ; D112.B4 270.32,388.62 ; D431.B13 26.48,381 ; D431.B13 25.67,380.19 ; D431.B13 25.67,381.81 ; D431.B13 24.86,381 ; D107.B5 247.46,58.42 ; D107.B5 246.65,59.23 ; D107.B5 246.65,57.61 ; D107.B5 245.84,58.42 ; 106.14,383.54 D427.A10 ; D427.A10 107.76,383.54 ; D427.A10 106.95,384.35 ; D427.A10 106.95,382.73 ; D119.B5 25.67,59.23 ; D119.B5 25.67,57.61 ; D119.B5 24.86,58.42 ; D119.B5 26.48,58.42 ; 106.95,80.47 D122.B8 ; D122.B8 106.95,82.09 ; D122.B8 106.14,81.28 ; D122.B8 107.76,81.28 ; 170.45,60.15 D103.B4 ; D103.B4 171.26,60.96 ; D103.B4 170.45,61.77 ; D103.B4 169.64,60.96 ; DPS8.B15 20.59,413.56 ; DPS8.B15 21.4,412.75 ; DPS8.B15 19.78,412.75 ; DPS8.B15 20.59,411.94 ; 43.45,39.83 D120.B12 ; D120.B12 44.26,40.64 ; D120.B12 42.64,40.64 ; D120.B12 43.45,41.45 ; 248.38,388.62 D112.B12 ; D112.B12 249.19,389.43 ; D112.B12 250,388.62 ; D112.B12 249.19,387.81 ; 127.27,352.25 CSDPS226.B2 ; CSDPS226.B2 127.27,353.87 ; CSDPS226.B2 128.08,353.06 ; CSDPS226.B2 126.46,353.06 ; 182.34,58.42 D103.B9 ; D103.B9 183.15,57.61 ; D103.B9 183.96,58.42 ; D103.B9 183.15,59.23 ; CSDPS425.C3 125.54,340.36 ; CSDPS425.C3 124.73,341.17 ; CSDPS425.C3 123.92,340.36 ; CSDPS425.C3 124.73,339.55 ; D432.B5 45.99,402.13 ; D432.B5 46.8,401.32 ; D432.B5 45.99,400.51 ; D432.B5 45.18,401.32 ; D113.B3 199.2,330.2 ; D113.B3 197.58,330.2 ; D113.B3 198.39,329.39 ; D113.B3 198.39,331.01 ; D106.B4 244.92,81.28 ; D106.B4 244.11,80.47 ; D106.B4 243.3,81.28 ; D106.B4 244.11,82.09 ; 30.75,385.27 D431.A11 ; D431.A11 30.75,386.89 ; D431.A11 29.94,386.08 ; D431.A11 31.56,386.08 ; 235.68,93.98 D105.A1 ; D105.A1 236.49,94.79 ; D105.A1 236.49,93.17 ; D105.A1 237.3,93.98 ; 261.89,93.17 D105.A11 ; D105.A11 261.89,94.79 ; D105.A11 262.7,93.98 ; D105.A11 261.08,93.98 ; 37.56,398.78 D432.B8 ; D432.B8 39.18,398.78 ; D432.B8 38.37,399.59 ; D432.B8 38.37,397.97 ; 123.92,375.92 D227.A3 ; D227.A3 125.54,375.92 ; D227.A3 124.73,375.11 ; D227.A3 124.73,376.73 ; 123.92,396.24 D228.A3 ; D228.A3 124.73,397.05 ; D228.A3 125.54,396.24 ; D228.A3 124.73,395.43 ; 254.27,387.81 D112.B10 ; D112.B10 255.08,388.62 ; D112.B10 253.46,388.62 ; D112.B10 254.27,389.43 ; D110.B16 239.84,347.98 ; D110.B16 239.03,347.17 ; D110.B16 239.03,348.79 ; D110.B16 238.22,347.98 ; 109.49,57.61 D123.B9 ; D123.B9 110.3,58.42 ; D123.B9 108.68,58.42 ; D123.B9 109.49,59.23 ; 192.5,38.1 D104.B13 ; D104.B13 193.31,38.91 ; D104.B13 194.12,38.1 ; D104.B13 193.31,37.29 ; 261.08,396.24 D112.A7 ; D112.A7 261.89,395.43 ; D112.A7 262.7,396.24 ; D112.A7 261.89,397.05 ; 89.17,400.51 D428.B17 ; D428.B17 88.36,401.32 ; D428.B17 89.17,402.13 ; D428.B17 89.98,401.32 ; 106.95,367.49 D227.B10 ; D227.B10 106.14,368.3 ; D227.B10 106.95,369.11 ; D227.B10 107.76,368.3 ; 254.27,60.15 D107.B8 ; D107.B8 253.46,60.96 ; D107.B8 255.08,60.96 ; D107.B8 254.27,61.77 ; D107.B6 249.19,61.77 ; D107.B6 250,60.96 ; D107.B6 249.19,60.15 ; D107.B6 248.38,60.96 ; D227.A17 89.98,375.92 ; D227.A17 88.36,375.92 ; D227.A17 89.17,376.73 ; D227.A17 89.17,375.11 ; CSDPS429.C7 41.72,340.36 ; CSDPS429.C7 40.91,341.17 ; CSDPS429.C7 40.1,340.36 ; CSDPS429.C7 40.91,339.55 ; D231.A9 36.64,375.92 ; D231.A9 35.83,376.73 ; D231.A9 35.02,375.92 ; D231.A9 35.83,375.11 ; D115.B14 171.26,368.3 ; D115.B14 170.45,369.11 ; D115.B14 170.45,367.49 ; D115.B14 169.64,368.3 ; D231.A12 29.02,373.38 ; D231.A12 27.4,373.38 ; D231.A12 28.21,372.57 ; D231.A12 28.21,374.19 ; 178.07,57.61 D103.B7 ; D103.B7 178.88,58.42 ; D103.B7 177.26,58.42 ; D103.B7 178.07,59.23 ; D105.B3 241.57,99.87 ; D105.B3 240.76,99.06 ; D105.B3 241.57,98.25 ; D105.B3 242.38,99.06 ; D112.B2 275.4,388.62 ; D112.B2 274.59,387.81 ; D112.B2 273.78,388.62 ; D112.B2 274.59,389.43 ; 251.73,334.47 D109.A11 ; D109.A11 252.54,335.28 ; D109.A11 250.92,335.28 ; D109.A11 251.73,336.09 ; D231.B2 53.61,369.11 ; D231.B2 54.42,368.3 ; D231.B2 53.61,367.49 ; D231.B2 52.8,368.3 ; D122.A11 114.57,74.47 ; D122.A11 115.38,73.66 ; D122.A11 114.57,72.85 ; D122.A11 113.76,73.66 ; D123.B14 123,60.96 ; D123.B14 122.19,61.77 ; D123.B14 122.19,60.15 ; D123.B14 121.38,60.96 ; 123.92,401.32 D428.B3 ; D428.B3 125.54,401.32 ; D428.B3 124.73,402.13 ; D428.B3 124.73,400.51 ; D111.B13 247.46,370.84 ; D111.B13 246.65,370.03 ; D111.B13 245.84,370.84 ; D111.B13 246.65,371.65 ; D228.B2 127.27,389.43 ; D228.B2 127.27,387.81 ; D228.B2 126.46,388.62 ; D228.B2 128.08,388.62 ; D119.A13 45.99,54.15 ; D119.A13 46.8,53.34 ; D119.A13 45.99,52.53 ; D119.A13 45.18,53.34 ; 35.02,391.16 D232.B9 ; D232.B9 36.64,391.16 ; D232.B9 35.83,391.97 ; D232.B9 35.83,390.35 ; UHC230.G3_9 47.83,350.85 ; UHC230.G3_9 47.83,349.23 ; UHC230.G3_9 47.02,350.04 ; UHC230.G3_9 48.64,350.04 ; 17.24,35.56 D120.A2 ; D120.A2 18.86,35.56 ; D120.A2 18.05,36.37 ; D120.A2 18.05,34.75 ; D110.B9 257.62,350.52 ; D110.B9 256.81,349.71 ; D110.B9 256.81,351.33 ; D110.B9 256,350.52 ; 266.97,57.61 D107.B13 ; D107.B13 266.16,58.42 ; D107.B13 266.97,59.23 ; D107.B13 267.78,58.42 ; D123.A11 114.57,54.15 ; D123.A11 115.38,53.34 ; D123.A11 113.76,53.34 ; D123.A11 114.57,52.53 ; 253.46,55.88 D107.A8 ; D107.A8 254.27,56.69 ; D107.A8 254.27,55.07 ; D107.A8 255.08,55.88 ; UHC430.G2_2 46.68,366.26 ; UHC430.G2_2 47.49,365.45 ; UHC430.G2_2 46.68,364.64 ; UHC430.G2_2 45.87,365.45 ; D123.B7 104.41,59.23 ; D123.B7 104.41,57.61 ; D123.B7 103.6,58.42 ; D123.B7 105.22,58.42 ; 190.77,80.47 D102.B12 ; D102.B12 190.77,82.09 ; D102.B12 191.58,81.28 ; D102.B12 189.96,81.28 ; 195.85,372.57 D115.A4 ; D115.A4 195.04,373.38 ; D115.A4 195.85,374.19 ; D115.A4 196.66,373.38 ; D122.B6 102.68,81.28 ; D122.B6 101.06,81.28 ; D122.B6 101.87,80.47 ; D122.B6 101.87,82.09 ; D124.A8 106.95,36.37 ; D124.A8 107.76,35.56 ; D124.A8 106.95,34.75 ; D124.A8 106.14,35.56 ; D228.A17 89.98,396.24 ; D228.A17 89.17,397.05 ; D228.A17 89.17,395.43 ; D228.A17 88.36,396.24 ; 187.42,33.02 D104.A11 ; D104.A11 188.23,32.21 ; D104.A11 188.23,33.83 ; D104.A11 189.04,33.02 ; 264.43,55.07 D107.A12 ; D107.A12 264.43,56.69 ; D107.A12 265.24,55.88 ; D107.A12 263.62,55.88 ; CSDPS229.C5 45.99,331.01 ; CSDPS229.C5 45.18,330.2 ; CSDPS229.C5 45.99,329.39 ; CSDPS229.C5 46.8,330.2 ; CSDPS429.C1 56.96,340.36 ; CSDPS429.C1 55.34,340.36 ; CSDPS429.C1 56.15,341.17 ; CSDPS429.C1 56.15,339.55 ; UHC230.G3_11 48.98,349.1 ; UHC230.G3_11 49.79,348.29 ; UHC230.G3_11 48.98,347.48 ; UHC230.G3_11 48.17,348.29 ; 42.64,398.78 D432.B6 ; D432.B6 43.45,397.97 ; D432.B6 43.45,399.59 ; D432.B6 44.26,398.78 ; 119.65,370.03 D227.B5 ; D227.B5 118.84,370.84 ; D227.B5 119.65,371.65 ; D227.B5 120.46,370.84 ; D119.A3 20.59,54.15 ; D119.A3 20.59,52.53 ; D119.A3 21.4,53.34 ; D119.A3 19.78,53.34 ; D228.A12 101.87,394.51 ; D228.A12 101.87,392.89 ; D228.A12 102.68,393.7 ; D228.A12 101.06,393.7 ; D119.B10 39.18,60.96 ; D119.B10 37.56,60.96 ; D119.B10 38.37,61.77 ; D119.B10 38.37,60.15 ; 98.52,38.1 D124.B5 ; D124.B5 100.14,38.1 ; D124.B5 99.33,38.91 ; D124.B5 99.33,37.29 ; D232.B10 34.1,388.62 ; D232.B10 32.48,388.62 ; D232.B10 33.29,389.43 ; D232.B10 33.29,387.81 ; D231.B1 56.96,370.84 ; D231.B1 55.34,370.84 ; D231.B1 56.15,371.65 ; D231.B1 56.15,370.03 ; 55.34,415.29 DPS8.A01 ; DPS8.A01 56.15,416.1 ; DPS8.A01 56.15,414.48 ; DPS8.A01 56.96,415.29 ; 200.93,100.79 D101.B16 ; D101.B16 201.74,101.6 ; D101.B16 200.12,101.6 ; D101.B16 200.93,102.41 ; 96.79,352.25 CSDPS226.B14 ; CSDPS226.B14 97.6,353.06 ; CSDPS226.B14 95.98,353.06 ; CSDPS226.B14 96.79,353.87 ; D124.B6 101.87,41.45 ; D124.B6 102.68,40.64 ; D124.B6 101.87,39.83 ; D124.B6 101.06,40.64 ; D427.A1 130.62,386.08 ; D427.A1 129,386.08 ; D427.A1 129.81,386.89 ; D427.A1 129.81,385.27 ; UHC430.G2_13 45.19,358.45 ; UHC430.G2_13 44.38,357.64 ; UHC430.G2_13 43.57,358.45 ; UHC430.G2_13 44.38,359.26 ; D124.B8 106.95,41.45 ; D124.B8 106.14,40.64 ; D124.B8 106.95,39.83 ; D124.B8 107.76,40.64 ; 246.65,98.25 D105.B5 ; D105.B5 246.65,99.87 ; D105.B5 245.84,99.06 ; D105.B5 247.46,99.06 ; 236.49,15.7 DPS1.B01 ; DPS1.B01 237.3,16.51 ; DPS1.B01 235.68,16.51 ; DPS1.B01 236.49,17.32 ; 184.88,40.64 D104.B10 ; D104.B10 186.5,40.64 ; D104.B10 185.69,39.83 ; D104.B10 185.69,41.45 ; 200.12,60.96 D103.B16 ; D103.B16 201.74,60.96 ; D103.B16 200.93,60.15 ; D103.B16 200.93,61.77 ; 119.65,359.87 CSDPS426.C5 ; CSDPS426.C5 118.84,360.68 ; CSDPS426.C5 119.65,361.49 ; CSDPS426.C5 120.46,360.68 ; 96.79,367.49 D227.B14 ; D227.B14 96.79,369.11 ; D227.B14 97.6,368.3 ; D227.B14 95.98,368.3 ; DPS2.A05 193.31,416.1 ; DPS2.A05 193.31,414.48 ; DPS2.A05 194.12,415.29 ; DPS2.A05 192.5,415.29 ; D231.A4 49.34,373.38 ; D231.A4 48.53,372.57 ; D231.A4 47.72,373.38 ; D231.A4 48.53,374.19 ; 192.5,330.2 D113.B5 ; D113.B5 193.31,331.01 ; D113.B5 194.12,330.2 ; D113.B5 193.31,329.39 ; 187.42,396.24 D116.A7 ; D116.A7 188.23,397.05 ; D116.A7 189.04,396.24 ; D116.A7 188.23,395.43 ; 266.97,37.29 D108.B13 ; D108.B13 267.78,38.1 ; D108.B13 266.97,38.91 ; D108.B13 266.16,38.1 ; CSDPS226.C3 124.73,351.33 ; CSDPS226.C3 125.54,350.52 ; CSDPS226.C3 124.73,349.71 ; CSDPS226.C3 123.92,350.52 ; 179.8,373.38 D115.A10 ; D115.A10 180.61,372.57 ; D115.A10 180.61,374.19 ; D115.A10 181.42,373.38 ; 93.44,396.24 D228.A15 ; D228.A15 95.06,396.24 ; D228.A15 94.25,395.43 ; D228.A15 94.25,397.05 ; 246.65,18.24 DPS1.C05 ; DPS1.C05 245.84,19.05 ; DPS1.C05 247.46,19.05 ; DPS1.C05 246.65,19.86 ; 266.16,99.06 D105.B13 ; D105.B13 266.97,99.87 ; D105.B13 266.97,98.25 ; D105.B13 267.78,99.06 ; 264.43,326.85 D109.B6 ; D109.B6 265.24,327.66 ; D109.B6 263.62,327.66 ; D109.B6 264.43,328.47 ; 174.72,40.64 D104.B6 ; D104.B6 175.53,39.83 ; D104.B6 175.53,41.45 ; D104.B6 176.34,40.64 ; D107.A7 252.54,53.34 ; D107.A7 251.73,54.15 ; D107.A7 250.92,53.34 ; D107.A7 251.73,52.53 ; D231.A17 16.32,375.92 ; D231.A17 14.7,375.92 ; D231.A17 15.51,376.73 ; D231.A17 15.51,375.11 ; 250.92,370.84 D111.B11 ; D111.B11 251.73,370.03 ; D111.B11 251.73,371.65 ; D111.B11 252.54,370.84 ; 243.3,353.06 D110.A14 ; D110.A14 244.92,353.06 ; D110.A14 244.11,352.25 ; D110.A14 244.11,353.87 ; CSDPS225.C3 124.73,331.01 ; CSDPS225.C3 123.92,330.2 ; CSDPS225.C3 124.73,329.39 ; CSDPS225.C3 125.54,330.2 ; 127.27,377.65 D427.B2 ; D427.B2 127.27,379.27 ; D427.B2 128.08,378.46 ; D427.B2 126.46,378.46 ; 198.39,37.29 D104.B15 ; D104.B15 198.39,38.91 ; D104.B15 199.2,38.1 ; D104.B15 197.58,38.1 ; 126.46,398.78 D428.B2 ; D428.B2 128.08,398.78 ; D428.B2 127.27,399.59 ; D428.B2 127.27,397.97 ; 254.27,331.93 D109.A10 ; D109.A10 253.46,332.74 ; D109.A10 255.08,332.74 ; D109.A10 254.27,333.55 ; 109.49,385.27 D427.A9 ; D427.A9 110.3,386.08 ; D427.A9 108.68,386.08 ; D427.A9 109.49,386.89 ; 251.73,354.79 D110.A11 ; D110.A11 252.54,355.6 ; D110.A11 251.73,356.41 ; D110.A11 250.92,355.6 ; D428.A14 97.6,403.86 ; D428.A14 96.79,403.05 ; D428.A14 96.79,404.67 ; D428.A14 95.98,403.86 ; 172.18,391.16 D116.B13 ; D116.B13 172.99,391.97 ; D116.B13 173.8,391.16 ; D116.B13 172.99,390.35 ; CSDPS229.C1 56.96,330.2 ; CSDPS229.C1 56.15,331.01 ; CSDPS229.C1 56.15,329.39 ; CSDPS229.C1 55.34,330.2 ; 93.44,78.74 D122.B3 ; D122.B3 95.06,78.74 ; D122.B3 94.25,77.93 ; D122.B3 94.25,79.55 ; DPS3.C01 89.17,19.86 ; DPS3.C01 89.17,18.24 ; DPS3.C01 88.36,19.05 ; DPS3.C01 89.98,19.05 ; 42.64,35.56 D120.A12 ; D120.A12 44.26,35.56 ; D120.A12 43.45,36.37 ; D120.A12 43.45,34.75 ; D121.A3 94.25,94.79 ; D121.A3 93.44,93.98 ; D121.A3 94.25,93.17 ; D121.A3 95.06,93.98 ; 89.17,93.17 D121.A1 ; D121.A1 88.36,93.98 ; D121.A1 89.98,93.98 ; D121.A1 89.17,94.79 ; 118.84,340.36 CSDPS425.C5 ; CSDPS425.C5 120.46,340.36 ; CSDPS425.C5 119.65,339.55 ; CSDPS425.C5 119.65,341.17 ; D113.A2 201.74,332.74 ; D113.A2 200.93,333.55 ; D113.A2 200.12,332.74 ; D113.A2 200.93,331.93 ; 93.44,381 D427.B15 ; D427.B15 95.06,381 ; D427.B15 94.25,380.19 ; D427.B15 94.25,381.81 ; D106.A11 262.7,73.66 ; D106.A11 261.89,74.47 ; D106.A11 261.89,72.85 ; D106.A11 261.08,73.66 ; 266.16,33.02 D108.A13 ; D108.A13 267.78,33.02 ; D108.A13 266.97,32.21 ; D108.A13 266.97,33.83 ; D102.A10 186.5,76.2 ; D102.A10 185.69,77.01 ; D102.A10 184.88,76.2 ; D102.A10 185.69,75.39 ; D227.B17 89.98,370.84 ; D227.B17 88.36,370.84 ; D227.B17 89.17,370.03 ; D227.B17 89.17,371.65 ; D112.A13 247.46,396.24 ; D112.A13 246.65,397.05 ; D112.A13 246.65,395.43 ; D112.A13 245.84,396.24 ; UHC230.G4_6 19.18,352.6 ; UHC230.G4_6 18.37,351.79 ; UHC230.G4_6 19.99,351.79 ; UHC230.G4_6 19.18,350.98 ; D432.B13 26.48,401.32 ; D432.B13 25.67,402.13 ; D432.B13 24.86,401.32 ; D432.B13 25.67,400.51 ; D121.B15 125.54,99.06 ; D121.B15 124.73,98.25 ; D121.B15 123.92,99.06 ; D121.B15 124.73,99.87 ; 112.03,387.81 D228.B8 ; D228.B8 112.84,388.62 ; D228.B8 111.22,388.62 ; D228.B8 112.03,389.43 ; 268.7,60.96 D107.B14 ; D107.B14 270.32,60.96 ; D107.B14 269.51,60.15 ; D107.B14 269.51,61.77 ; 169.64,347.98 D114.B14 ; D114.B14 170.45,348.79 ; D114.B14 171.26,347.98 ; D114.B14 170.45,347.17 ; D427.B5 120.46,381 ; D427.B5 119.65,380.19 ; D427.B5 119.65,381.81 ; D427.B5 118.84,381 ; 25.67,37.29 D120.B5 ; D120.B5 24.86,38.1 ; D120.B5 26.48,38.1 ; D120.B5 25.67,38.91 ; 243.3,40.64 D108.B4 ; D108.B4 244.11,41.45 ; D108.B4 244.92,40.64 ; D108.B4 244.11,39.83 ; D111.A14 244.92,373.38 ; D111.A14 243.3,373.38 ; D111.A14 244.11,372.57 ; D111.A14 244.11,374.19 ; D118.A9 35.83,74.47 ; D118.A9 35.83,72.85 ; D118.A9 35.02,73.66 ; D118.A9 36.64,73.66 ; DPS8.B05 46.8,412.75 ; DPS8.B05 45.99,413.56 ; DPS8.B05 45.99,411.94 ; DPS8.B05 45.18,412.75 ; D102.B7 178.07,79.55 ; D102.B7 177.26,78.74 ; D102.B7 178.88,78.74 ; D102.B7 178.07,77.93 ; 47.72,378.46 D431.B4 ; D431.B4 49.34,378.46 ; D431.B4 48.53,379.27 ; D431.B4 48.53,377.65 ; D431.B11 31.56,381 ; D431.B11 29.94,381 ; D431.B11 30.75,381.81 ; D431.B11 30.75,380.19 ; 104.41,370.03 D227.B11 ; D227.B11 104.41,371.65 ; D227.B11 105.22,370.84 ; D227.B11 103.6,370.84 ; D111.A2 275.4,373.38 ; D111.A2 274.59,374.19 ; D111.A2 274.59,372.57 ; D111.A2 273.78,373.38 ; 263.62,101.6 D105.B12 ; D105.B12 264.43,100.79 ; D105.B12 265.24,101.6 ; D105.B12 264.43,102.41 ; D110.A15 241.57,356.41 ; D110.A15 240.76,355.6 ; D110.A15 242.38,355.6 ; D110.A15 241.57,354.79 ; D108.B9 257.62,38.1 ; D108.B9 256.81,38.91 ; D108.B9 256,38.1 ; D108.B9 256.81,37.29 ; D232.A16 18.86,393.7 ; D232.A16 18.05,392.89 ; D232.A16 18.05,394.51 ; D232.A16 17.24,393.7 ; 273.78,101.6 D105.B16 ; D105.B16 274.59,100.79 ; D105.B16 275.4,101.6 ; D105.B16 274.59,102.41 ; 25.67,72.85 D118.A5 ; D118.A5 26.48,73.66 ; D118.A5 25.67,74.47 ; D118.A5 24.86,73.66 ; 271.24,38.1 D108.B15 ; D108.B15 272.05,37.29 ; D108.B15 272.05,38.91 ; D108.B15 272.86,38.1 ; 244.11,331.93 D109.A14 ; D109.A14 244.92,332.74 ; D109.A14 243.3,332.74 ; D109.A14 244.11,333.55 ; D115.B13 173.8,370.84 ; D115.B13 172.18,370.84 ; D115.B13 172.99,371.65 ; D115.B13 172.99,370.03 ; D110.A12 250,353.06 ; D110.A12 249.19,353.87 ; D110.A12 249.19,352.25 ; D110.A12 248.38,353.06 ; D113.B9 183.96,330.2 ; D113.B9 183.15,331.01 ; D113.B9 183.15,329.39 ; D113.B9 182.34,330.2 ; 42.64,60.96 D119.B12 ; D119.B12 44.26,60.96 ; D119.B12 43.45,61.77 ; D119.B12 43.45,60.15 ; D120.A6 28.21,36.37 ; D120.A6 28.21,34.75 ; D120.A6 29.02,35.56 ; D120.A6 27.4,35.56 ; D119.A10 38.37,56.69 ; D119.A10 39.18,55.88 ; D119.A10 38.37,55.07 ; D119.A10 37.56,55.88 ; D102.A8 180.61,77.01 ; D102.A8 179.8,76.2 ; D102.A8 181.42,76.2 ; D102.A8 180.61,75.39 ; D108.B7 251.73,38.91 ; D108.B7 251.73,37.29 ; D108.B7 252.54,38.1 ; D108.B7 250.92,38.1 ; 14.7,38.1 D120.B1 ; D120.B1 15.51,37.29 ; D120.B1 16.32,38.1 ; D120.B1 15.51,38.91 ; CSDPS425.C9 109.49,341.17 ; CSDPS425.C9 108.68,340.36 ; CSDPS425.C9 110.3,340.36 ; CSDPS425.C9 109.49,339.55 ; D108.A8 254.27,36.37 ; D108.A8 254.27,34.75 ; D108.A8 255.08,35.56 ; D108.A8 253.46,35.56 ; 52.8,383.54 D431.A2 ; D431.A2 53.61,382.73 ; D431.A2 54.42,383.54 ; D431.A2 53.61,384.35 ; 195.04,96.52 D101.A14 ; D101.A14 196.66,96.52 ; D101.A14 195.85,97.33 ; D101.A14 195.85,95.71 ; D120.B6 28.21,41.45 ; D120.B6 29.02,40.64 ; D120.B6 28.21,39.83 ; D120.B6 27.4,40.64 ; D121.A5 100.14,93.98 ; D121.A5 98.52,93.98 ; D121.A5 99.33,93.17 ; D121.A5 99.33,94.79 ; 113.76,401.32 D428.B7 ; D428.B7 114.57,400.51 ; D428.B7 114.57,402.13 ; D428.B7 115.38,401.32 ; D124.B1 89.17,38.91 ; D124.B1 88.36,38.1 ; D124.B1 89.17,37.29 ; D124.B1 89.98,38.1 ; CSDPS429.B16 18.86,342.9 ; CSDPS429.B16 18.05,343.71 ; CSDPS429.B16 17.24,342.9 ; CSDPS429.B16 18.05,342.09 ; D112.A14 244.92,393.7 ; D112.A14 244.11,394.51 ; D112.A14 244.11,392.89 ; D112.A14 243.3,393.7 ; 42.64,342.9 CSDPS429.B6 ; CSDPS429.B6 43.45,342.09 ; CSDPS429.B6 44.26,342.9 ; CSDPS429.B6 43.45,343.71 ; 35.83,385.27 D431.A9 ; D431.A9 35.83,386.89 ; D431.A9 36.64,386.08 ; D431.A9 35.02,386.08 ; 182.34,391.16 D116.B9 ; D116.B9 183.15,390.35 ; D116.B9 183.15,391.97 ; D116.B9 183.96,391.16 ; 187.42,330.2 D113.B7 ; D113.B7 188.23,329.39 ; D113.B7 189.04,330.2 ; D113.B7 188.23,331.01 ; 94.25,37.29 D124.B3 ; D124.B3 95.06,38.1 ; D124.B3 93.44,38.1 ; D124.B3 94.25,38.91 ; 95.98,342.9 CSDPS425.B14 ; CSDPS425.B14 97.6,342.9 ; CSDPS425.B14 96.79,343.71 ; CSDPS425.B14 96.79,342.09 ; D432.B1 56.96,401.32 ; D432.B1 56.15,402.13 ; D432.B1 55.34,401.32 ; D432.B1 56.15,400.51 ; 42.64,373.38 D231.A6 ; D231.A6 43.45,374.19 ; D231.A6 43.45,372.57 ; D231.A6 44.26,373.38 ; D110.B4 270.32,347.98 ; D110.B4 269.51,347.17 ; D110.B4 268.7,347.98 ; D110.B4 269.51,348.79 ; 193.31,354.79 D114.A5 ; D114.A5 194.12,355.6 ; D114.A5 192.5,355.6 ; D114.A5 193.31,356.41 ; 192.5,99.06 D101.B13 ; D101.B13 193.31,98.25 ; D101.B13 193.31,99.87 ; D101.B13 194.12,99.06 ; 200.12,353.06 D114.A2 ; D114.A2 200.93,352.25 ; D114.A2 201.74,353.06 ; D114.A2 200.93,353.87 ; 192.5,350.52 D114.B5 ; D114.B5 194.12,350.52 ; D114.B5 193.31,349.71 ; D114.B5 193.31,351.33 ; D106.A2 239.03,77.01 ; D106.A2 239.84,76.2 ; D106.A2 239.03,75.39 ; D106.A2 238.22,76.2 ; 269.51,100.79 D105.B14 ; D105.B14 268.7,101.6 ; D105.B14 269.51,102.41 ; D105.B14 270.32,101.6 ; D105.A5 246.65,94.79 ; D105.A5 245.84,93.98 ; D105.A5 247.46,93.98 ; D105.A5 246.65,93.17 ; 17.22,350.04 UHC230.G4_9 ; UHC230.G4_9 18.03,350.85 ; UHC230.G4_9 18.03,349.23 ; UHC230.G4_9 18.84,350.04 ; 264.43,352.25 D110.A6 ; D110.A6 265.24,353.06 ; D110.A6 263.62,353.06 ; D110.A6 264.43,353.87 ; D104.A9 183.15,33.83 ; D104.A9 182.34,33.02 ; D104.A9 183.15,32.21 ; D104.A9 183.96,33.02 ; 203.47,375.11 D115.A1 ; D115.A1 202.66,375.92 ; D115.A1 204.28,375.92 ; D115.A1 203.47,376.73 ; D106.A15 272.05,74.47 ; D106.A15 272.05,72.85 ; D106.A15 271.24,73.66 ; D106.A15 272.86,73.66 ; 98.52,370.84 D227.B13 ; D227.B13 99.33,370.03 ; D227.B13 99.33,371.65 ; D227.B13 100.14,370.84 ; D122.A9 110.3,73.66 ; D122.A9 109.49,74.47 ; D122.A9 108.68,73.66 ; D122.A9 109.49,72.85 ; 127.27,55.07 D123.A16 ; D123.A16 128.08,55.88 ; D123.A16 126.46,55.88 ; D123.A16 127.27,56.69 ; 272.05,395.43 D112.A3 ; D112.A3 272.86,396.24 ; D112.A3 272.05,397.05 ; D112.A3 271.24,396.24 ; 165.37,326.85 D113.B16 ; D113.B16 164.56,327.66 ; D113.B16 165.37,328.47 ; D113.B16 166.18,327.66 ; D431.B16 18.86,378.46 ; D431.B16 18.05,379.27 ; D431.B16 17.24,378.46 ; D431.B16 18.05,377.65 ; 45.53,359.39 UHC430.G2_10 ; UHC430.G2_10 44.72,360.2 ; UHC430.G2_10 46.34,360.2 ; UHC430.G2_10 45.53,361.01 ; 27.4,342.9 CSDPS429.B12 ; CSDPS429.B12 28.21,342.09 ; CSDPS429.B12 29.02,342.9 ; CSDPS429.B12 28.21,343.71 ; 238.22,55.88 D107.A2 ; D107.A2 239.84,55.88 ; D107.A2 239.03,56.69 ; D107.A2 239.03,55.07 ; D121.A12 117.92,96.52 ; D121.A12 116.3,96.52 ; D121.A12 117.11,95.71 ; D121.A12 117.11,97.33 ; 29.94,53.34 D119.A7 ; D119.A7 30.75,54.15 ; D119.A7 31.56,53.34 ; D119.A7 30.75,52.53 ; D102.B1 162.83,79.55 ; D102.B1 162.02,78.74 ; D102.B1 162.83,77.93 ; D102.B1 163.64,78.74 ; D231.A14 23.13,374.19 ; D231.A14 22.32,373.38 ; D231.A14 23.13,372.57 ; D231.A14 23.94,373.38 ; D107.A4 244.11,56.69 ; D107.A4 244.11,55.07 ; D107.A4 243.3,55.88 ; D107.A4 244.92,55.88 ; 190.77,34.75 D104.A12 ; D104.A12 190.77,36.37 ; D104.A12 189.96,35.56 ; D104.A12 191.58,35.56 ; 121.38,383.54 D427.A4 ; D427.A4 123,383.54 ; D427.A4 122.19,384.35 ; D427.A4 122.19,382.73 ; D123.A14 123,55.88 ; D123.A14 121.38,55.88 ; D123.A14 122.19,55.07 ; D123.A14 122.19,56.69 ; D227.B16 91.71,369.11 ; D227.B16 92.52,368.3 ; D227.B16 91.71,367.49 ; D227.B16 90.9,368.3 ; 240.76,335.28 D109.A15 ; D109.A15 241.57,334.47 ; D109.A15 241.57,336.09 ; D109.A15 242.38,335.28 ; D432.A5 46.8,406.4 ; D432.A5 45.99,407.21 ; D432.A5 45.99,405.59 ; D432.A5 45.18,406.4 ; 239.03,39.83 D108.B2 ; D108.B2 239.03,41.45 ; D108.B2 238.22,40.64 ; D108.B2 239.84,40.64 ; 111.22,383.54 D427.A8 ; D427.A8 112.03,382.73 ; D427.A8 112.84,383.54 ; D427.A8 112.03,384.35 ; 50.26,38.1 D120.B15 ; D120.B15 51.07,38.91 ; D120.B15 51.88,38.1 ; D120.B15 51.07,37.29 ; D232.A11 31.56,396.24 ; D232.A11 30.75,395.43 ; D232.A11 29.94,396.24 ; D232.A11 30.75,397.05 ; D227.B8 112.84,368.3 ; D227.B8 112.03,367.49 ; D227.B8 112.03,369.11 ; D227.B8 111.22,368.3 ; 183.15,77.93 D102.B9 ; D102.B9 183.15,79.55 ; D102.B9 183.96,78.74 ; D102.B9 182.34,78.74 ; D115.A8 185.69,374.19 ; D115.A8 184.88,373.38 ; D115.A8 186.5,373.38 ; D115.A8 185.69,372.57 ; CSDPS426.B6 117.92,363.22 ; CSDPS426.B6 116.3,363.22 ; CSDPS426.B6 117.11,362.41 ; CSDPS426.B6 117.11,364.03 ; 195.85,392.89 D116.A4 ; D116.A4 195.85,394.51 ; D116.A4 196.66,393.7 ; D116.A4 195.04,393.7 ; 56.15,411.94 DPS8.B01 ; DPS8.B01 56.96,412.75 ; DPS8.B01 55.34,412.75 ; DPS8.B01 56.15,413.56 ; D103.B15 198.39,59.23 ; D103.B15 197.58,58.42 ; D103.B15 198.39,57.61 ; D103.B15 199.2,58.42 ; 14.7,396.24 D232.A17 ; D232.A17 15.51,397.05 ; D232.A17 16.32,396.24 ; D232.A17 15.51,395.43 ; D114.B13 173.8,350.52 ; D114.B13 172.18,350.52 ; D114.B13 172.99,351.33 ; D114.B13 172.99,349.71 ; UHC430.G2_3 45.19,365.45 ; UHC430.G2_3 44.38,366.26 ; UHC430.G2_3 43.57,365.45 ; UHC430.G2_3 44.38,364.64 ; D228.A2 127.27,394.51 ; D228.A2 127.27,392.89 ; D228.A2 128.08,393.7 ; D228.A2 126.46,393.7 ; 95.98,373.38 D227.A14 ; D227.A14 96.79,372.57 ; D227.A14 96.79,374.19 ; D227.A14 97.6,373.38 ; D115.A14 170.45,374.19 ; D115.A14 169.64,373.38 ; D115.A14 171.26,373.38 ; D115.A14 170.45,372.57 ; 190.77,367.49 D115.B6 ; D115.B6 190.77,369.11 ; D115.B6 191.58,368.3 ; D115.B6 189.96,368.3 ; D112.B14 244.11,389.43 ; D112.B14 244.92,388.62 ; D112.B14 244.11,387.81 ; D112.B14 243.3,388.62 ; D111.A10 255.08,373.38 ; D111.A10 254.27,374.19 ; D111.A10 254.27,372.57 ; D111.A10 253.46,373.38 ; D109.B15 242.38,330.2 ; D109.B15 241.57,331.01 ; D109.B15 240.76,330.2 ; D109.B15 241.57,329.39 ; D120.A16 53.61,36.37 ; D120.A16 54.42,35.56 ; D120.A16 52.8,35.56 ; D120.A16 53.61,34.75 ; D107.A9 257.62,53.34 ; D107.A9 256,53.34 ; D107.A9 256.81,52.53 ; D107.A9 256.81,54.15 ; 45.18,391.16 D232.B5 ; D232.B5 45.99,390.35 ; D232.B5 45.99,391.97 ; D232.B5 46.8,391.16 ; CSDPS229.B6 43.45,333.55 ; CSDPS229.B6 42.64,332.74 ; CSDPS229.B6 44.26,332.74 ; CSDPS229.B6 43.45,331.93 ; D106.B14 270.32,81.28 ; D106.B14 269.51,80.47 ; D106.B14 268.7,81.28 ; D106.B14 269.51,82.09 ; 88.36,33.02 D124.A1 ; D124.A1 89.17,32.21 ; D124.A1 89.17,33.83 ; D124.A1 89.98,33.02 ; D107.A15 272.05,54.15 ; D107.A15 272.86,53.34 ; D107.A15 272.05,52.53 ; D107.A15 271.24,53.34 ; 167.91,409.4 DPS2.C15 ; DPS2.C15 167.91,411.02 ; DPS2.C15 167.1,410.21 ; DPS2.C15 168.72,410.21 ; UHC430.G1_10 16.54,360.2 ; UHC430.G1_10 14.92,360.2 ; UHC430.G1_10 15.73,359.39 ; UHC430.G1_10 15.73,361.01 ; D122.B2 92.52,81.28 ; D122.B2 90.9,81.28 ; D122.B2 91.71,82.09 ; D122.B2 91.71,80.47 ; D114.A11 178.88,355.6 ; D114.A11 178.07,354.79 ; D114.A11 177.26,355.6 ; D114.A11 178.07,356.41 ; D232.B16 18.05,389.43 ; D232.B16 18.86,388.62 ; D232.B16 18.05,387.81 ; D232.B16 17.24,388.62 ; D227.B4 123,368.3 ; D227.B4 121.38,368.3 ; D227.B4 122.19,367.49 ; D227.B4 122.19,369.11 ; D111.B9 256.81,371.65 ; D111.B9 257.62,370.84 ; D111.B9 256.81,370.03 ; D111.B9 256,370.84 ; 124.73,385.27 D427.A3 ; D427.A3 123.92,386.08 ; D427.A3 124.73,386.89 ; D427.A3 125.54,386.08 ; D124.B9 109.49,38.91 ; D124.B9 110.3,38.1 ; D124.B9 109.49,37.29 ; D124.B9 108.68,38.1 ; 238.22,353.06 D110.A16 ; D110.A16 239.03,353.87 ; D110.A16 239.84,353.06 ; D110.A16 239.03,352.25 ; D123.A8 107.76,55.88 ; D123.A8 106.95,55.07 ; D123.A8 106.14,55.88 ; D123.A8 106.95,56.69 ; 50.26,370.84 D231.B3 ; D231.B3 51.07,370.03 ; D231.B3 51.07,371.65 ; D231.B3 51.88,370.84 ; 183.15,395.43 D116.A9 ; D116.A9 183.96,396.24 ; D116.A9 182.34,396.24 ; D116.A9 183.15,397.05 ; CSDPS226.B10 106.95,353.87 ; CSDPS226.B10 107.76,353.06 ; CSDPS226.B10 106.14,353.06 ; CSDPS226.B10 106.95,352.25 ; 101.87,60.15 D123.B6 ; D123.B6 101.87,61.77 ; D123.B6 101.06,60.96 ; D123.B6 102.68,60.96 ; 109.49,380.19 D427.B9 ; D427.B9 110.3,381 ; D427.B9 108.68,381 ; D427.B9 109.49,381.81 ; 16.88,357.64 UHC430.G1_12 ; UHC430.G1_12 16.07,358.45 ; UHC430.G1_12 17.69,358.45 ; UHC430.G1_12 16.88,359.26 ; D232.B1 56.15,391.97 ; D232.B1 56.15,390.35 ; D232.B1 56.96,391.16 ; D232.B1 55.34,391.16 ; D123.A6 101.87,56.69 ; D123.A6 101.06,55.88 ; D123.A6 102.68,55.88 ; D123.A6 101.87,55.07 ; 14.92,363.7 UHC430.G1_5 ; UHC430.G1_5 15.73,364.51 ; UHC430.G1_5 15.73,362.89 ; UHC430.G1_5 16.54,363.7 ; CSDPS226.C7 115.38,350.52 ; CSDPS226.C7 114.57,349.71 ; CSDPS226.C7 114.57,351.33 ; CSDPS226.C7 113.76,350.52 ; D111.B4 269.51,369.11 ; D111.B4 268.7,368.3 ; D111.B4 269.51,367.49 ; D111.B4 270.32,368.3 ; 249.19,392.89 D112.A12 ; D112.A12 250,393.7 ; D112.A12 249.19,394.51 ; D112.A12 248.38,393.7 ; D432.A7 41.72,406.4 ; D432.A7 40.91,405.59 ; D432.A7 40.1,406.4 ; D432.A7 40.91,407.21 ; 98.52,360.68 CSDPS426.C13 ; CSDPS426.C13 99.33,359.87 ; CSDPS426.C13 100.14,360.68 ; CSDPS426.C13 99.33,361.49 ; D111.A15 241.57,376.73 ; D111.A15 242.38,375.92 ; D111.A15 240.76,375.92 ; D111.A15 241.57,375.11 ; D103.B10 186.5,60.96 ; D103.B10 185.69,61.77 ; D103.B10 185.69,60.15 ; D103.B10 184.88,60.96 ; D431.A8 39.18,383.54 ; D431.A8 37.56,383.54 ; D431.A8 38.37,384.35 ; D431.A8 38.37,382.73 ; 127.27,95.71 D121.A16 ; D121.A16 126.46,96.52 ; D121.A16 127.27,97.33 ; D121.A16 128.08,96.52 ; 248.38,368.3 D111.B12 ; D111.B12 250,368.3 ; D111.B12 249.19,369.11 ; D111.B12 249.19,367.49 ; 106.14,363.22 CSDPS426.B10 ; CSDPS426.B10 106.95,364.03 ; CSDPS426.B10 107.76,363.22 ; CSDPS426.B10 106.95,362.41 ; D116.A2 200.93,394.51 ; D116.A2 200.93,392.89 ; D116.A2 201.74,393.7 ; D116.A2 200.12,393.7 ; 126.46,383.54 D427.A2 ; D427.A2 127.27,384.35 ; D427.A2 128.08,383.54 ; D427.A2 127.27,382.73 ; D111.A11 252.54,375.92 ; D111.A11 251.73,375.11 ; D111.A11 251.73,376.73 ; D111.A11 250.92,375.92 ; 123.92,19.05 DPS3.C15 ; DPS3.C15 125.54,19.05 ; DPS3.C15 124.73,19.86 ; DPS3.C15 124.73,18.24 ; 203.47,334.47 D113.A1 ; D113.A1 204.28,335.28 ; D113.A1 202.66,335.28 ; D113.A1 203.47,336.09 ; D228.A9 110.3,396.24 ; D228.A9 109.49,397.05 ; D228.A9 108.68,396.24 ; D228.A9 109.49,395.43 ; D115.B10 181.42,368.3 ; D115.B10 180.61,369.11 ; D115.B10 180.61,367.49 ; D115.B10 179.8,368.3 ; D122.A16 128.08,76.2 ; D122.A16 127.27,77.01 ; D122.A16 126.46,76.2 ; D122.A16 127.27,75.39 ; CSDPS226.B12 102.68,353.06 ; CSDPS226.B12 101.06,353.06 ; CSDPS226.B12 101.87,353.87 ; CSDPS226.B12 101.87,352.25 ; D428.B12 101.87,399.59 ; D428.B12 101.06,398.78 ; D428.B12 101.87,397.97 ; D428.B12 102.68,398.78 ; D232.A12 28.21,394.51 ; D232.A12 28.21,392.89 ; D232.A12 27.4,393.7 ; D232.A12 29.02,393.7 ; D102.A4 171.26,76.2 ; D102.A4 170.45,75.39 ; D102.A4 170.45,77.01 ; D102.A4 169.64,76.2 ; D427.B3 125.54,381 ; D427.B3 123.92,381 ; D427.B3 124.73,380.19 ; D427.B3 124.73,381.81 ; D121.B3 94.25,99.87 ; D121.B3 95.06,99.06 ; D121.B3 94.25,98.25 ; D121.B3 93.44,99.06 ; D114.B6 190.77,348.79 ; D114.B6 189.96,347.98 ; D114.B6 190.77,347.17 ; D114.B6 191.58,347.98 ; 259.35,60.15 D107.B10 ; D107.B10 260.16,60.96 ; D107.B10 259.35,61.77 ; D107.B10 258.54,60.96 ; D432.B11 30.75,402.13 ; D432.B11 31.56,401.32 ; D432.B11 30.75,400.51 ; D432.B11 29.94,401.32 ; 96.79,377.65 D427.B14 ; D427.B14 97.6,378.46 ; D427.B14 96.79,379.27 ; D427.B14 95.98,378.46 ; CSDPS229.B8 38.37,333.55 ; CSDPS229.B8 38.37,331.93 ; CSDPS229.B8 37.56,332.74 ; CSDPS229.B8 39.18,332.74 ; 96.79,95.71 D121.A4 ; D121.A4 95.98,96.52 ; D121.A4 97.6,96.52 ; D121.A4 96.79,97.33 ; D432.A3 51.88,406.4 ; D432.A3 51.07,407.21 ; D432.A3 50.26,406.4 ; D432.A3 51.07,405.59 ; 90.9,60.96 D123.B2 ; D123.B2 92.52,60.96 ; D123.B2 91.71,60.15 ; D123.B2 91.71,61.77 ; 99.33,98.25 D121.B5 ; D121.B5 100.14,99.06 ; D121.B5 99.33,99.87 ; D121.B5 98.52,99.06 ; UHC430.G1_6 19.18,362.76 ; UHC430.G1_6 19.18,361.14 ; UHC430.G1_6 18.37,361.95 ; UHC430.G1_6 19.99,361.95 ; 271.24,93.98 D105.A15 ; D105.A15 272.05,93.17 ; D105.A15 272.86,93.98 ; D105.A15 272.05,94.79 ; D124.A2 91.71,36.37 ; D124.A2 92.52,35.56 ; D124.A2 91.71,34.75 ; D124.A2 90.9,35.56 ; 122.19,95.71 D121.A14 ; D121.A14 123,96.52 ; D121.A14 122.19,97.33 ; D121.A14 121.38,96.52 ; D427.A11 104.41,386.89 ; D427.A11 105.22,386.08 ; D427.A11 103.6,386.08 ; D427.A11 104.41,385.27 ; D228.B4 122.19,389.43 ; D228.B4 123,388.62 ; D228.B4 122.19,387.81 ; D228.B4 121.38,388.62 ; UHC230.G3_2 47.49,355.29 ; UHC230.G3_2 45.87,355.29 ; UHC230.G3_2 46.68,354.48 ; UHC230.G3_2 46.68,356.1 ; CSDPS426.C15 95.06,360.68 ; CSDPS426.C15 94.25,361.49 ; CSDPS426.C15 93.44,360.68 ; CSDPS426.C15 94.25,359.87 ; 18.05,403.05 D432.A16 ; D432.A16 18.86,403.86 ; D432.A16 18.05,404.67 ; D432.A16 17.24,403.86 ; D110.B13 246.65,351.33 ; D110.B13 247.46,350.52 ; D110.B13 246.65,349.71 ; D110.B13 245.84,350.52 ; 179.8,327.66 D113.B10 ; D113.B10 181.42,327.66 ; D113.B10 180.61,326.85 ; D113.B10 180.61,328.47 ; 43.45,55.07 D119.A12 ; D119.A12 44.26,55.88 ; D119.A12 42.64,55.88 ; D119.A12 43.45,56.69 ; D104.A1 162.83,33.83 ; D104.A1 162.02,33.02 ; D104.A1 162.83,32.21 ; D104.A1 163.64,33.02 ; 264.43,80.47 D106.B12 ; D106.B12 263.62,81.28 ; D106.B12 265.24,81.28 ; D106.B12 264.43,82.09 ; D115.B12 175.53,369.11 ; D115.B12 175.53,367.49 ; D115.B12 174.72,368.3 ; D115.B12 176.34,368.3 ; D101.A11 188.23,94.79 ; D101.A11 187.42,93.98 ; D101.A11 188.23,93.17 ; D101.A11 189.04,93.98 ; 259.35,352.25 D110.A8 ; D110.A8 260.16,353.06 ; D110.A8 258.54,353.06 ; D110.A8 259.35,353.87 ; D121.B7 104.41,99.87 ; D121.B7 104.41,98.25 ; D121.B7 105.22,99.06 ; D121.B7 103.6,99.06 ; D105.A14 270.32,96.52 ; D105.A14 269.51,95.71 ; D105.A14 269.51,97.33 ; D105.A14 268.7,96.52 ; D114.A3 199.2,355.6 ; D114.A3 198.39,356.41 ; D114.A3 198.39,354.79 ; D114.A3 197.58,355.6 ; D108.B3 241.57,38.91 ; D108.B3 242.38,38.1 ; D108.B3 240.76,38.1 ; D108.B3 241.57,37.29 ; D106.A7 252.54,73.66 ; D106.A7 250.92,73.66 ; D106.A7 251.73,72.85 ; D106.A7 251.73,74.47 ; 266.97,375.11 D111.A5 ; D111.A5 266.16,375.92 ; D111.A5 267.78,375.92 ; D111.A5 266.97,376.73 ; 124.73,52.53 D123.A15 ; D123.A15 124.73,54.15 ; D123.A15 125.54,53.34 ; D123.A15 123.92,53.34 ; D102.A13 193.31,74.47 ; D102.A13 194.12,73.66 ; D102.A13 192.5,73.66 ; D102.A13 193.31,72.85 ; D120.A9 36.64,33.02 ; D120.A9 35.83,33.83 ; D120.A9 35.02,33.02 ; D120.A9 35.83,32.21 ; DPS1.A15 272.05,14.78 ; DPS1.A15 272.86,13.97 ; DPS1.A15 271.24,13.97 ; DPS1.A15 272.05,13.16 ; 117.11,100.79 D121.B12 ; D121.B12 117.11,102.41 ; D121.B12 116.3,101.6 ; D121.B12 117.92,101.6 ; 23.13,367.49 D231.B14 ; D231.B14 22.32,368.3 ; D231.B14 23.13,369.11 ; D231.B14 23.94,368.3 ; D118.A3 20.59,74.47 ; D118.A3 21.4,73.66 ; D118.A3 19.78,73.66 ; D118.A3 20.59,72.85 ; DPS3.B15 125.54,16.51 ; DPS3.B15 124.73,17.32 ; DPS3.B15 123.92,16.51 ; DPS3.B15 124.73,15.7 ; D432.A8 38.37,404.67 ; D432.A8 39.18,403.86 ; D432.A8 38.37,403.05 ; D432.A8 37.56,403.86 ; 22.32,332.74 CSDPS229.B14 ; CSDPS229.B14 23.94,332.74 ; CSDPS229.B14 23.13,331.93 ; CSDPS229.B14 23.13,333.55 ; 236.49,57.61 D107.B1 ; D107.B1 236.49,59.23 ; D107.B1 235.68,58.42 ; D107.B1 237.3,58.42 ; 167.1,350.52 D114.B15 ; D114.B15 168.72,350.52 ; D114.B15 167.91,351.33 ; D114.B15 167.91,349.71 ; D109.B1 277.94,330.2 ; D109.B1 277.13,331.01 ; D109.B1 277.13,329.39 ; D109.B1 276.32,330.2 ; D232.B7 40.91,391.97 ; D232.B7 41.72,391.16 ; D232.B7 40.91,390.35 ; D232.B7 40.1,391.16 ; 184.88,332.74 D113.A8 ; D113.A8 185.69,333.55 ; D113.A8 186.5,332.74 ; D113.A8 185.69,331.93 ; 52.8,332.74 CSDPS229.B2 ; CSDPS229.B2 53.61,331.93 ; CSDPS229.B2 54.42,332.74 ; CSDPS229.B2 53.61,333.55 ; D427.B16 92.52,378.46 ; D427.B16 91.71,377.65 ; D427.B16 90.9,378.46 ; D427.B16 91.71,379.27 ; D232.A6 44.26,393.7 ; D232.A6 43.45,394.51 ; D232.A6 43.45,392.89 ; D232.A6 42.64,393.7 ; CSDPS429.C11 30.75,341.17 ; CSDPS429.C11 29.94,340.36 ; CSDPS429.C11 31.56,340.36 ; CSDPS429.C11 30.75,339.55 ; 15.51,405.59 D432.A17 ; D432.A17 15.51,407.21 ; D432.A17 14.7,406.4 ; D432.A17 16.32,406.4 ; D112.B6 265.24,388.62 ; D112.B6 264.43,387.81 ; D112.B6 263.62,388.62 ; D112.B6 264.43,389.43 ; 95.98,81.28 D122.B4 ; D122.B4 96.79,80.47 ; D122.B4 96.79,82.09 ; D122.B4 97.6,81.28 ; 35.02,401.32 D432.B9 ; D432.B9 36.64,401.32 ; D432.B9 35.83,400.51 ; D432.B9 35.83,402.13 ; D227.B1 129.81,371.65 ; D227.B1 129,370.84 ; D227.B1 130.62,370.84 ; D227.B1 129.81,370.03 ; D228.A7 114.57,397.05 ; D228.A7 113.76,396.24 ; D228.A7 115.38,396.24 ; D228.A7 114.57,395.43 ; CSDPS225.B16 91.71,333.55 ; CSDPS225.B16 92.52,332.74 ; CSDPS225.B16 91.71,331.93 ; CSDPS225.B16 90.9,332.74 ; 271.24,350.52 D110.B3 ; D110.B3 272.05,351.33 ; D110.B3 272.86,350.52 ; D110.B3 272.05,349.71 ; 103.6,360.68 CSDPS426.C11 ; CSDPS426.C11 105.22,360.68 ; CSDPS426.C11 104.41,361.49 ; CSDPS426.C11 104.41,359.87 ; 47.72,55.88 D119.A14 ; D119.A14 48.53,55.07 ; D119.A14 48.53,56.69 ; D119.A14 49.34,55.88 ; 27.4,388.62 D232.B12 ; D232.B12 28.21,387.81 ; D232.B12 28.21,389.43 ; D232.B12 29.02,388.62 ; D103.B12 191.58,60.96 ; D103.B12 190.77,61.77 ; D103.B12 190.77,60.15 ; D103.B12 189.96,60.96 ; 203.47,329.39 D113.B1 ; D113.B1 202.66,330.2 ; D113.B1 203.47,331.01 ; D113.B1 204.28,330.2 ; D108.A12 265.24,35.56 ; D108.A12 264.43,36.37 ; D108.A12 263.62,35.56 ; D108.A12 264.43,34.75 ; 129.81,349.71 CSDPS226.C1 ; CSDPS226.C1 129,350.52 ; CSDPS226.C1 129.81,351.33 ; CSDPS226.C1 130.62,350.52 ; 172.18,73.66 D102.A5 ; D102.A5 172.99,74.47 ; D102.A5 173.8,73.66 ; D102.A5 172.99,72.85 ; D108.A5 247.46,33.02 ; D108.A5 246.65,32.21 ; D108.A5 245.84,33.02 ; D108.A5 246.65,33.83 ; D431.B1 56.96,381 ; D431.B1 56.15,381.81 ; D431.B1 55.34,381 ; D431.B1 56.15,380.19 ; 101.06,101.6 D121.B6 ; D121.B6 102.68,101.6 ; D121.B6 101.87,102.41 ; D121.B6 101.87,100.79 ; 101.06,373.38 D227.A12 ; D227.A12 101.87,374.19 ; D227.A12 102.68,373.38 ; D227.A12 101.87,372.57 ; D228.B6 117.11,389.43 ; D228.B6 117.11,387.81 ; D228.B6 116.3,388.62 ; D228.B6 117.92,388.62 ; 40.1,386.08 D431.A7 ; D431.A7 41.72,386.08 ; D431.A7 40.91,386.89 ; D431.A7 40.91,385.27 ; D116.B14 171.26,388.62 ; D116.B14 170.45,387.81 ; D116.B14 169.64,388.62 ; D116.B14 170.45,389.43 ; D105.A4 244.92,96.52 ; D105.A4 243.3,96.52 ; D105.A4 244.11,97.33 ; D105.A4 244.11,95.71 ; 241.57,52.53 D107.A3 ; D107.A3 241.57,54.15 ; D107.A3 242.38,53.34 ; D107.A3 240.76,53.34 ; 45.99,72.85 D118.A13 ; D118.A13 45.18,73.66 ; D118.A13 46.8,73.66 ; D118.A13 45.99,74.47 ; D428.B4 123,398.78 ; D428.B4 121.38,398.78 ; D428.B4 122.19,399.59 ; D428.B4 122.19,397.97 ; D432.A6 43.45,404.67 ; D432.A6 44.26,403.86 ; D432.A6 42.64,403.86 ; D432.A6 43.45,403.05 ; 47.72,398.78 D432.B4 ; D432.B4 49.34,398.78 ; D432.B4 48.53,397.97 ; D432.B4 48.53,399.59 ; 51.07,390.35 D232.B3 ; D232.B3 51.07,391.97 ; D232.B3 50.26,391.16 ; D232.B3 51.88,391.16 ; CSDPS425.B6 117.92,342.9 ; CSDPS425.B6 116.3,342.9 ; CSDPS425.B6 117.11,343.71 ; CSDPS425.B6 117.11,342.09 ; D120.B13 45.99,38.91 ; D120.B13 46.8,38.1 ; D120.B13 45.18,38.1 ; D120.B13 45.99,37.29 ; DPS3.B01 89.17,17.32 ; DPS3.B01 88.36,16.51 ; DPS3.B01 89.98,16.51 ; DPS3.B01 89.17,15.7 ; D107.A1 237.3,53.34 ; D107.A1 236.49,52.53 ; D107.A1 235.68,53.34 ; D107.A1 236.49,54.15 ; D121.B13 120.46,99.06 ; D121.B13 119.65,99.87 ; D121.B13 119.65,98.25 ; D121.B13 118.84,99.06 ; D112.A4 270.32,393.7 ; D112.A4 268.7,393.7 ; D112.A4 269.51,392.89 ; D112.A4 269.51,394.51 ; 129.81,380.19 D427.B1 ; D427.B1 129,381 ; D427.B1 129.81,381.81 ; D427.B1 130.62,381 ; 197.58,370.84 D115.B3 ; D115.B3 199.2,370.84 ; D115.B3 198.39,371.65 ; D115.B3 198.39,370.03 ; D112.B13 246.65,391.97 ; D112.B13 246.65,390.35 ; D112.B13 245.84,391.16 ; D112.B13 247.46,391.16 ; D109.B10 254.27,328.47 ; D109.B10 255.08,327.66 ; D109.B10 254.27,326.85 ; D109.B10 253.46,327.66 ; 175.53,352.25 D114.A12 ; D114.A12 175.53,353.87 ; D114.A12 174.72,353.06 ; D114.A12 176.34,353.06 ; 263.62,347.98 D110.B6 ; D110.B6 264.43,348.79 ; D110.B6 265.24,347.98 ; D110.B6 264.43,347.17 ; 162.02,73.66 D102.A1 ; D102.A1 162.83,74.47 ; D102.A1 163.64,73.66 ; D102.A1 162.83,72.85 ; D102.A3 167.91,74.47 ; D102.A3 167.1,73.66 ; D102.A3 167.91,72.85 ; D102.A3 168.72,73.66 ; 53.61,403.05 D432.A2 ; D432.A2 54.42,403.86 ; D432.A2 53.61,404.67 ; D432.A2 52.8,403.86 ; D427.B6 117.92,378.46 ; D427.B6 117.11,379.27 ; D427.B6 117.11,377.65 ; D427.B6 116.3,378.46 ; 259.35,331.93 D109.A8 ; D109.A8 259.35,333.55 ; D109.A8 258.54,332.74 ; D109.A8 260.16,332.74 ; 243.3,347.98 D110.B14 ; D110.B14 244.92,347.98 ; D110.B14 244.11,348.79 ; D110.B14 244.11,347.17 ; 48.17,351.79 UHC230.G3_6 ; UHC230.G3_6 48.98,352.6 ; UHC230.G3_6 48.98,350.98 ; UHC230.G3_6 49.79,351.79 ; D232.B11 30.75,391.97 ; D232.B11 30.75,390.35 ; D232.B11 31.56,391.16 ; D232.B11 29.94,391.16 ; 178.07,93.17 D101.A7 ; D101.A7 178.07,94.79 ; D101.A7 177.26,93.98 ; D101.A7 178.88,93.98 ; 119.65,385.27 D427.A5 ; D427.A5 119.65,386.89 ; D427.A5 118.84,386.08 ; D427.A5 120.46,386.08 ; 114.57,57.61 D123.B11 ; D123.B11 114.57,59.23 ; D123.B11 115.38,58.42 ; D123.B11 113.76,58.42 ; 172.18,375.92 D115.A13 ; D115.A13 172.99,376.73 ; D115.A13 172.99,375.11 ; D115.A13 173.8,375.92 ; 23.13,39.83 D120.B4 ; D120.B4 23.13,41.45 ; D120.B4 23.94,40.64 ; D120.B4 22.32,40.64 ; 245.84,13.97 DPS1.A05 ; DPS1.A05 246.65,13.16 ; DPS1.A05 246.65,14.78 ; DPS1.A05 247.46,13.97 ; D120.A14 49.34,35.56 ; D120.A14 48.53,34.75 ; D120.A14 47.72,35.56 ; D120.A14 48.53,36.37 ; 96.79,397.97 D428.B14 ; D428.B14 97.6,398.78 ; D428.B14 95.98,398.78 ; D428.B14 96.79,399.59 ; D110.B15 242.38,350.52 ; D110.B15 241.57,351.33 ; D110.B15 241.57,349.71 ; D110.B15 240.76,350.52 ; 45.18,370.84 D231.B5 ; D231.B5 45.99,370.03 ; D231.B5 46.8,370.84 ; D231.B5 45.99,371.65 ; CSDPS229.C11 30.75,331.01 ; CSDPS229.C11 31.56,330.2 ; CSDPS229.C11 29.94,330.2 ; CSDPS229.C11 30.75,329.39 ; 261.89,15.7 DPS1.B11 ; DPS1.B11 261.08,16.51 ; DPS1.B11 262.7,16.51 ; DPS1.B11 261.89,17.32 ; D116.B1 204.28,391.16 ; D116.B1 203.47,391.97 ; D116.B1 203.47,390.35 ; D116.B1 202.66,391.16 ; D120.A8 34.1,35.56 ; D120.A8 33.29,36.37 ; D120.A8 33.29,34.75 ; D120.A8 32.48,35.56 ; 104.41,400.51 D428.B11 ; D428.B11 104.41,402.13 ; D428.B11 103.6,401.32 ; D428.B11 105.22,401.32 ; 245.84,73.66 D106.A5 ; D106.A5 246.65,74.47 ; D106.A5 246.65,72.85 ; D106.A5 247.46,73.66 ; 117.11,34.75 D124.A12 ; D124.A12 117.11,36.37 ; D124.A12 117.92,35.56 ; D124.A12 116.3,35.56 ; 182.34,355.6 D114.A9 ; D114.A9 183.15,354.79 ; D114.A9 183.15,356.41 ; D114.A9 183.96,355.6 ; D102.B14 196.66,81.28 ; D102.B14 195.85,80.47 ; D102.B14 195.85,82.09 ; D102.B14 195.04,81.28 ; D104.A13 194.12,33.02 ; D104.A13 193.31,32.21 ; D104.A13 193.31,33.83 ; D104.A13 192.5,33.02 ; CSDPS425.C11 105.22,340.36 ; CSDPS425.C11 104.41,341.17 ; CSDPS425.C11 104.41,339.55 ; CSDPS425.C11 103.6,340.36 ; D432.B2 54.42,398.78 ; D432.B2 53.61,399.59 ; D432.B2 53.61,397.97 ; D432.B2 52.8,398.78 ; 46.68,350.98 UHC230.G3 ; UHC230.G3 45.87,351.79 ; UHC230.G3 46.68,352.6 ; UHC230.G3 47.49,351.79 ; 45.18,381 D431.B5 ; D431.B5 46.8,381 ; D431.B5 45.99,381.81 ; D431.B5 45.99,380.19 ; 124.73,93.17 D121.A15 ; D121.A15 123.92,93.98 ; D121.A15 125.54,93.98 ; D121.A15 124.73,94.79 ; UHC230.G4_3 15.39,355.29 ; UHC230.G4_3 14.58,356.1 ; UHC230.G4_3 13.77,355.29 ; UHC230.G4_3 14.58,354.48 ; D120.B2 18.86,40.64 ; D120.B2 18.05,39.83 ; D120.B2 18.05,41.45 ; D120.B2 17.24,40.64 ; D121.A7 105.22,93.98 ; D121.A7 104.41,93.17 ; D121.A7 103.6,93.98 ; D121.A7 104.41,94.79 ; D124.A11 115.38,33.02 ; D124.A11 113.76,33.02 ; D124.A11 114.57,33.83 ; D124.A11 114.57,32.21 ; D432.B16 18.05,399.59 ; D432.B16 18.86,398.78 ; D432.B16 17.24,398.78 ; D432.B16 18.05,397.97 ; D103.A2 166.18,55.88 ; D103.A2 165.37,55.07 ; D103.A2 164.56,55.88 ; D103.A2 165.37,56.69 ; 202.66,355.6 D114.A1 ; D114.A1 203.47,354.79 ; D114.A1 204.28,355.6 ; D114.A1 203.47,356.41 ; D121.A6 102.68,96.52 ; D121.A6 101.87,97.33 ; D121.A6 101.06,96.52 ; D121.A6 101.87,95.71 ; D431.A16 18.05,384.35 ; D431.A16 18.05,382.73 ; D431.A16 18.86,383.54 ; D431.A16 17.24,383.54 ; CSDPS225.B4 122.19,333.55 ; CSDPS225.B4 123,332.74 ; CSDPS225.B4 121.38,332.74 ; CSDPS225.B4 122.19,331.93 ; D105.B7 252.54,99.06 ; D105.B7 251.73,98.25 ; D105.B7 251.73,99.87 ; D105.B7 250.92,99.06 ; 264.43,331.93 D109.A6 ; D109.A6 263.62,332.74 ; D109.A6 264.43,333.55 ; D109.A6 265.24,332.74 ; UHC230.G4_1 19.18,356.1 ; UHC230.G4_1 19.18,354.48 ; UHC230.G4_1 18.37,355.29 ; UHC230.G4_1 19.99,355.29 ; D120.A13 45.99,33.83 ; D120.A13 45.99,32.21 ; D120.A13 46.8,33.02 ; D120.A13 45.18,33.02 ; D123.A9 109.49,54.15 ; D123.A9 110.3,53.34 ; D123.A9 109.49,52.53 ; D123.A9 108.68,53.34 ; 239.03,100.79 D105.B2 ; D105.B2 238.22,101.6 ; D105.B2 239.84,101.6 ; D105.B2 239.03,102.41 ; 200.12,35.56 D104.A16 ; D104.A16 200.93,34.75 ; D104.A16 201.74,35.56 ; D104.A16 200.93,36.37 ; D116.B2 200.93,389.43 ; D116.B2 200.12,388.62 ; D116.B2 201.74,388.62 ; D116.B2 200.93,387.81 ; D109.B14 244.92,327.66 ; D109.B14 244.11,326.85 ; D109.B14 244.11,328.47 ; D109.B14 243.3,327.66 ; D107.A10 260.16,55.88 ; D107.A10 259.35,56.69 ; D107.A10 259.35,55.07 ; D107.A10 258.54,55.88 ; 50.26,53.34 D119.A15 ; D119.A15 51.88,53.34 ; D119.A15 51.07,54.15 ; D119.A15 51.07,52.53 ; D228.A16 91.71,394.51 ; D228.A16 91.71,392.89 ; D228.A16 90.9,393.7 ; D228.A16 92.52,393.7 ; D109.B7 262.7,330.2 ; D109.B7 261.89,331.01 ; D109.B7 261.89,329.39 ; D109.B7 261.08,330.2 ; 195.04,101.6 D101.B14 ; D101.B14 195.85,100.79 ; D101.B14 196.66,101.6 ; D101.B14 195.85,102.41 ; 40.91,72.85 D118.A11 ; D118.A11 40.1,73.66 ; D118.A11 41.72,73.66 ; D118.A11 40.91,74.47 ; D428.B5 119.65,402.13 ; D428.B5 120.46,401.32 ; D428.B5 119.65,400.51 ; D428.B5 118.84,401.32 ; D103.A10 186.5,55.88 ; D103.A10 185.69,55.07 ; D103.A10 184.88,55.88 ; D103.A10 185.69,56.69 ; 167.91,395.43 D116.A15 ; D116.A15 167.1,396.24 ; D116.A15 167.91,397.05 ; D116.A15 168.72,396.24 ; 56.15,395.43 D232.A1 ; D232.A1 56.96,396.24 ; D232.A1 56.15,397.05 ; D232.A1 55.34,396.24 ; D227.B15 95.06,370.84 ; D227.B15 94.25,370.03 ; D227.B15 94.25,371.65 ; D227.B15 93.44,370.84 ; DPS3.B05 100.14,16.51 ; DPS3.B05 99.33,15.7 ; DPS3.B05 98.52,16.51 ; DPS3.B05 99.33,17.32 ; D110.A7 261.89,356.41 ; D110.A7 261.08,355.6 ; D110.A7 261.89,354.79 ; D110.A7 262.7,355.6 ; D115.B8 186.5,368.3 ; D115.B8 185.69,367.49 ; D115.B8 185.69,369.11 ; D115.B8 184.88,368.3 ; D110.B8 259.35,348.79 ; D110.B8 259.35,347.17 ; D110.B8 260.16,347.98 ; D110.B8 258.54,347.98 ; 271.24,335.28 D109.A3 ; D109.A3 272.86,335.28 ; D109.A3 272.05,336.09 ; D109.A3 272.05,334.47 ; D112.A2 274.59,394.51 ; D112.A2 274.59,392.89 ; D112.A2 275.4,393.7 ; D112.A2 273.78,393.7 ; D109.A2 274.59,333.55 ; D109.A2 274.59,331.93 ; D109.A2 273.78,332.74 ; D109.A2 275.4,332.74 ; UHC230.G4_12 16.88,349.1 ; UHC230.G4_12 16.88,347.48 ; UHC230.G4_12 17.69,348.29 ; UHC230.G4_12 16.07,348.29 ; 266.16,73.66 D106.A13 ; D106.A13 267.78,73.66 ; D106.A13 266.97,72.85 ; D106.A13 266.97,74.47 ; 175.53,55.07 D103.A6 ; D103.A6 175.53,56.69 ; D103.A6 174.72,55.88 ; D103.A6 176.34,55.88 ; 123.92,38.1 D124.B15 ; D124.B15 124.73,37.29 ; D124.B15 125.54,38.1 ; D124.B15 124.73,38.91 ; 25.67,52.53 D119.A5 ; D119.A5 25.67,54.15 ; D119.A5 26.48,53.34 ; D119.A5 24.86,53.34 ; 256,73.66 D106.A9 ; D106.A9 256.81,74.47 ; D106.A9 257.62,73.66 ; D106.A9 256.81,72.85 ; 190.77,39.83 D104.B12 ; D104.B12 191.58,40.64 ; D104.B12 189.96,40.64 ; D104.B12 190.77,41.45 ; D228.B3 124.73,391.97 ; D228.B3 124.73,390.35 ; D228.B3 123.92,391.16 ; D228.B3 125.54,391.16 ; 119.65,349.71 CSDPS226.C5 ; CSDPS226.C5 119.65,351.33 ; CSDPS226.C5 120.46,350.52 ; CSDPS226.C5 118.84,350.52 ; 88.36,386.08 D427.A17 ; D427.A17 89.17,385.27 ; D427.A17 89.98,386.08 ; D427.A17 89.17,386.89 ; D116.B5 193.31,391.97 ; D116.B5 192.5,391.16 ; D116.B5 194.12,391.16 ; D116.B5 193.31,390.35 ; D106.B16 274.59,82.09 ; D106.B16 275.4,81.28 ; D106.B16 273.78,81.28 ; D106.B16 274.59,80.47 ; D114.B3 198.39,351.33 ; D114.B3 199.2,350.52 ; D114.B3 197.58,350.52 ; D114.B3 198.39,349.71 ; D113.A11 178.07,336.09 ; D113.A11 178.88,335.28 ; D113.A11 177.26,335.28 ; D113.A11 178.07,334.47 ; 189.96,353.06 D114.A6 ; D114.A6 191.58,353.06 ; D114.A6 190.77,353.87 ; D114.A6 190.77,352.25 ; D428.A7 115.38,406.4 ; D428.A7 113.76,406.4 ; D428.A7 114.57,407.21 ; D428.A7 114.57,405.59 ; D110.A5 267.78,355.6 ; D110.A5 266.16,355.6 ; D110.A5 266.97,354.79 ; D110.A5 266.97,356.41 ; 268.7,373.38 D111.A4 ; D111.A4 270.32,373.38 ; D111.A4 269.51,374.19 ; D111.A4 269.51,372.57 ; D124.B7 104.41,38.91 ; D124.B7 103.6,38.1 ; D124.B7 104.41,37.29 ; D124.B7 105.22,38.1 ; D107.B11 262.7,58.42 ; D107.B11 261.08,58.42 ; D107.B11 261.89,59.23 ; D107.B11 261.89,57.61 ; CSDPS426.B16 91.71,364.03 ; CSDPS426.B16 90.9,363.22 ; CSDPS426.B16 91.71,362.41 ; CSDPS426.B16 92.52,363.22 ; D122.B14 123,81.28 ; D122.B14 121.38,81.28 ; D122.B14 122.19,80.47 ; D122.B14 122.19,82.09 ; D121.A11 114.57,94.79 ; D121.A11 115.38,93.98 ; D121.A11 113.76,93.98 ; D121.A11 114.57,93.17 ; D104.A3 167.91,33.83 ; D104.A3 168.72,33.02 ; D104.A3 167.91,32.21 ; D104.A3 167.1,33.02 ; 32.48,55.88 D119.A8 ; D119.A8 34.1,55.88 ; D119.A8 33.29,56.69 ; D119.A8 33.29,55.07 ; 33.29,342.09 CSDPS429.B10 ; CSDPS429.B10 34.1,342.9 ; CSDPS429.B10 33.29,343.71 ; CSDPS429.B10 32.48,342.9 ; 272.05,15.7 DPS1.B15 ; DPS1.B15 272.86,16.51 ; DPS1.B15 272.05,17.32 ; DPS1.B15 271.24,16.51 ; D431.A13 26.48,386.08 ; D431.A13 25.67,386.89 ; D431.A13 24.86,386.08 ; D431.A13 25.67,385.27 ; 95.98,101.6 D121.B4 ; D121.B4 97.6,101.6 ; D121.B4 96.79,102.41 ; D121.B4 96.79,100.79 ; D116.B10 180.61,389.43 ; D116.B10 179.8,388.62 ; D116.B10 180.61,387.81 ; D116.B10 181.42,388.62 ; 239.03,80.47 D106.B2 ; D106.B2 238.22,81.28 ; D106.B2 239.84,81.28 ; D106.B2 239.03,82.09 ; D123.A10 112.84,55.88 ; D123.A10 111.22,55.88 ; D123.A10 112.03,56.69 ; D123.A10 112.03,55.07 ; D113.B15 168.72,330.2 ; D113.B15 167.1,330.2 ; D113.B15 167.91,329.39 ; D113.B15 167.91,331.01 ; 261.08,99.06 D105.B11 ; D105.B11 262.7,99.06 ; D105.B11 261.89,99.87 ; D105.B11 261.89,98.25 ; 185.69,326.85 D113.B8 ; D113.B8 185.69,328.47 ; D113.B8 186.5,327.66 ; D113.B8 184.88,327.66 ; 113.76,360.68 CSDPS426.C7 ; CSDPS426.C7 115.38,360.68 ; CSDPS426.C7 114.57,361.49 ; CSDPS426.C7 114.57,359.87 ; D111.A3 272.86,375.92 ; D111.A3 272.05,376.73 ; D111.A3 272.05,375.11 ; D111.A3 271.24,375.92 ; D431.A12 29.02,383.54 ; D431.A12 28.21,382.73 ; D431.A12 28.21,384.35 ; D431.A12 27.4,383.54 ; 119.65,72.85 D122.A13 ; D122.A13 120.46,73.66 ; D122.A13 118.84,73.66 ; D122.A13 119.65,74.47 ; D232.B8 38.37,389.43 ; D232.B8 37.56,388.62 ; D232.B8 38.37,387.81 ; D232.B8 39.18,388.62 ; 167.91,57.61 D103.B3 ; D103.B3 167.1,58.42 ; D103.B3 168.72,58.42 ; D103.B3 167.91,59.23 ; D102.B5 173.8,78.74 ; D102.B5 172.99,79.55 ; D102.B5 172.99,77.93 ; D102.B5 172.18,78.74 ; 197.58,78.74 D102.B15 ; D102.B15 198.39,79.55 ; D102.B15 198.39,77.93 ; D102.B15 199.2,78.74 ; 48.98,354.48 UHC230.G3_1 ; UHC230.G3_1 49.79,355.29 ; UHC230.G3_1 48.98,356.1 ; UHC230.G3_1 48.17,355.29 ; D227.A9 109.49,376.73 ; D227.A9 108.68,375.92 ; D227.A9 109.49,375.11 ; D227.A9 110.3,375.92 ; 183.15,72.85 D102.A9 ; D102.A9 183.15,74.47 ; D102.A9 183.96,73.66 ; D102.A9 182.34,73.66 ; 169.64,332.74 D113.A14 ; D113.A14 170.45,331.93 ; D113.A14 170.45,333.55 ; D113.A14 171.26,332.74 ; D232.B2 53.61,389.43 ; D232.B2 52.8,388.62 ; D232.B2 53.61,387.81 ; D232.B2 54.42,388.62 ; 37.56,342.9 CSDPS429.B8 ; CSDPS429.B8 38.37,342.09 ; CSDPS429.B8 38.37,343.71 ; CSDPS429.B8 39.18,342.9 ; 112.03,362.41 CSDPS426.B8 ; CSDPS426.B8 112.03,364.03 ; CSDPS426.B8 112.84,363.22 ; CSDPS426.B8 111.22,363.22 ; D104.B5 173.8,38.1 ; D104.B5 172.99,38.91 ; D104.B5 172.99,37.29 ; D104.B5 172.18,38.1 ; 96.79,387.81 D228.B14 ; D228.B14 95.98,388.62 ; D228.B14 96.79,389.43 ; D228.B14 97.6,388.62 ; D431.B3 51.88,381 ; D431.B3 51.07,381.81 ; D431.B3 51.07,380.19 ; D431.B3 50.26,381 ; D111.B14 244.92,368.3 ; D111.B14 244.11,367.49 ; D111.B14 244.11,369.11 ; D111.B14 243.3,368.3 ; D102.B8 180.61,82.09 ; D102.B8 179.8,81.28 ; D102.B8 181.42,81.28 ; D102.B8 180.61,80.47 ; 56.15,375.11 D231.A1 ; D231.A1 55.34,375.92 ; D231.A1 56.15,376.73 ; D231.A1 56.96,375.92 ; D432.A15 21.4,406.4 ; D432.A15 19.78,406.4 ; D432.A15 20.59,407.21 ; D432.A15 20.59,405.59 ; D104.B3 168.72,38.1 ; D104.B3 167.91,37.29 ; D104.B3 167.91,38.91 ; D104.B3 167.1,38.1 ; D104.A8 180.61,36.37 ; D104.A8 181.42,35.56 ; D104.A8 179.8,35.56 ; D104.A8 180.61,34.75 ; CSDPS226.C9 110.3,350.52 ; CSDPS226.C9 108.68,350.52 ; CSDPS226.C9 109.49,349.71 ; CSDPS226.C9 109.49,351.33 ; 243.3,35.56 D108.A4 ; D108.A4 244.11,34.75 ; D108.A4 244.92,35.56 ; D108.A4 244.11,36.37 ; D428.A16 92.52,403.86 ; D428.A16 91.71,403.05 ; D428.A16 90.9,403.86 ; D428.A16 91.71,404.67 ; CSDPS226.C15 94.25,351.33 ; CSDPS226.C15 95.06,350.52 ; CSDPS226.C15 94.25,349.71 ; CSDPS226.C15 93.44,350.52 ; 30.75,57.61 D119.B7 ; D119.B7 30.75,59.23 ; D119.B7 29.94,58.42 ; D119.B7 31.56,58.42 ; D231.A5 45.99,376.73 ; D231.A5 46.8,375.92 ; D231.A5 45.99,375.11 ; D231.A5 45.18,375.92 ; 18.05,367.49 D231.B16 ; D231.B16 17.24,368.3 ; D231.B16 18.86,368.3 ; D231.B16 18.05,369.11 ; D111.A13 247.46,375.92 ; D111.A13 246.65,375.11 ; D111.A13 245.84,375.92 ; D111.A13 246.65,376.73 ; D115.B16 165.37,369.11 ; D115.B16 165.37,367.49 ; D115.B16 164.56,368.3 ; D115.B16 166.18,368.3 ; 266.97,349.71 D110.B5 ; D110.B5 266.97,351.33 ; D110.B5 267.78,350.52 ; D110.B5 266.16,350.52 ; D108.A11 261.89,33.83 ; D108.A11 261.89,32.21 ; D108.A11 261.08,33.02 ; D108.A11 262.7,33.02 ; D114.A8 186.5,353.06 ; D114.A8 184.88,353.06 ; D114.A8 185.69,352.25 ; D114.A8 185.69,353.87 ; D431.A6 43.45,384.35 ; D431.A6 44.26,383.54 ; D431.A6 43.45,382.73 ; D431.A6 42.64,383.54 ; D431.B9 35.83,381.81 ; D431.B9 35.02,381 ; D431.B9 36.64,381 ; D431.B9 35.83,380.19 ; 239.03,34.75 D108.A2 ; D108.A2 239.03,36.37 ; D108.A2 238.22,35.56 ; D108.A2 239.84,35.56 ; 40.91,375.11 D231.A7 ; D231.A7 40.91,376.73 ; D231.A7 41.72,375.92 ; D231.A7 40.1,375.92 ; D124.A4 97.6,35.56 ; D124.A4 96.79,36.37 ; D124.A4 95.98,35.56 ; D124.A4 96.79,34.75 ; 192.5,335.28 D113.A5 ; D113.A5 193.31,336.09 ; D113.A5 194.12,335.28 ; D113.A5 193.31,334.47 ; 178.07,375.11 D115.A11 ; D115.A11 177.26,375.92 ; D115.A11 178.07,376.73 ; D115.A11 178.88,375.92 ; 96.79,39.83 D124.B4 ; D124.B4 95.98,40.64 ; D124.B4 97.6,40.64 ; D124.B4 96.79,41.45 ; 203.47,411.94 DPS2.B01 ; DPS2.B01 203.47,413.56 ; DPS2.B01 202.66,412.75 ; DPS2.B01 204.28,412.75 ; DPS2.B15 167.91,413.56 ; DPS2.B15 167.1,412.75 ; DPS2.B15 168.72,412.75 ; DPS2.B15 167.91,411.94 ; D112.B16 239.84,388.62 ; D112.B16 238.22,388.62 ; D112.B16 239.03,387.81 ; D112.B16 239.03,389.43 ; 178.07,395.43 D116.A11 ; D116.A11 178.07,397.05 ; D116.A11 178.88,396.24 ; D116.A11 177.26,396.24 ; 94.25,375.11 D227.A15 ; D227.A15 94.25,376.73 ; D227.A15 93.44,375.92 ; D227.A15 95.06,375.92 ; 190.77,326.85 D113.B6 ; D113.B6 189.96,327.66 ; D113.B6 190.77,328.47 ; D113.B6 191.58,327.66 ; 122.19,342.09 CSDPS425.B4 ; CSDPS425.B4 122.19,343.71 ; CSDPS425.B4 121.38,342.9 ; CSDPS425.B4 123,342.9 ; 101.87,387.81 D228.B12 ; D228.B12 102.68,388.62 ; D228.B12 101.87,389.43 ; D228.B12 101.06,388.62 ; 111.22,101.6 D121.B10 ; D121.B10 112.84,101.6 ; D121.B10 112.03,102.41 ; D121.B10 112.03,100.79 ; D432.B3 51.88,401.32 ; D432.B3 51.07,400.51 ; D432.B3 50.26,401.32 ; D432.B3 51.07,402.13 ; 46.68,347.48 UHC230.G3_12 ; UHC230.G3_12 45.87,348.29 ; UHC230.G3_12 46.68,349.1 ; UHC230.G3_12 47.49,348.29 ; D431.A1 56.96,386.08 ; D431.A1 56.15,385.27 ; D431.A1 55.34,386.08 ; D431.A1 56.15,386.89 ; DPS3.A15 124.73,14.78 ; DPS3.A15 125.54,13.97 ; DPS3.A15 124.73,13.16 ; DPS3.A15 123.92,13.97 ; 114.57,37.29 D124.B11 ; D124.B11 115.38,38.1 ; D124.B11 114.57,38.91 ; D124.B11 113.76,38.1 ; 266.97,52.53 D107.A13 ; D107.A13 266.97,54.15 ; D107.A13 266.16,53.34 ; D107.A13 267.78,53.34 ; D116.A12 176.34,393.7 ; D116.A12 174.72,393.7 ; D116.A12 175.53,392.89 ; D116.A12 175.53,394.51 ; D116.A14 171.26,393.7 ; D116.A14 170.45,392.89 ; D116.A14 170.45,394.51 ; D116.A14 169.64,393.7 ; D115.B9 183.15,371.65 ; D115.B9 183.96,370.84 ; D115.B9 183.15,370.03 ; D115.B9 182.34,370.84 ; 127.27,367.49 D227.B2 ; D227.B2 126.46,368.3 ; D227.B2 128.08,368.3 ; D227.B2 127.27,369.11 ; D105.B10 259.35,102.41 ; D105.B10 260.16,101.6 ; D105.B10 258.54,101.6 ; D105.B10 259.35,100.79 ; D432.A12 28.21,404.67 ; D432.A12 29.02,403.86 ; D432.A12 27.4,403.86 ; D432.A12 28.21,403.05 ; D101.A9 183.96,93.98 ; D101.A9 183.15,94.79 ; D101.A9 182.34,93.98 ; D101.A9 183.15,93.17 ; 112.03,34.75 D124.A10 ; D124.A10 112.84,35.56 ; D124.A10 112.03,36.37 ; D124.A10 111.22,35.56 ; 16.07,355.29 UHC230.G4_2 ; UHC230.G4_2 17.69,355.29 ; UHC230.G4_2 16.88,356.1 ; UHC230.G4_2 16.88,354.48 ; 47.83,362.89 UHC430.G2_4 ; UHC430.G2_4 47.83,364.51 ; UHC430.G2_4 47.02,363.7 ; UHC430.G2_4 48.64,363.7 ; D120.B8 33.29,41.45 ; D120.B8 34.1,40.64 ; D120.B8 33.29,39.83 ; D120.B8 32.48,40.64 ; 264.43,392.89 D112.A6 ; D112.A6 264.43,394.51 ; D112.A6 265.24,393.7 ; D112.A6 263.62,393.7 ; 172.99,395.43 D116.A13 ; D116.A13 173.8,396.24 ; D116.A13 172.18,396.24 ; D116.A13 172.99,397.05 ; D103.A5 173.8,53.34 ; D103.A5 172.99,54.15 ; D103.A5 172.99,52.53 ; D103.A5 172.18,53.34 ; 23.13,392.89 D232.A14 ; D232.A14 23.94,393.7 ; D232.A14 23.13,394.51 ; D232.A14 22.32,393.7 ; 240.76,396.24 D112.A15 ; D112.A15 241.57,395.43 ; D112.A15 242.38,396.24 ; D112.A15 241.57,397.05 ; D428.B9 110.3,401.32 ; D428.B9 109.49,400.51 ; D428.B9 109.49,402.13 ; D428.B9 108.68,401.32 ; D113.A10 181.42,332.74 ; D113.A10 180.61,333.55 ; D113.A10 179.8,332.74 ; D113.A10 180.61,331.93 ; D232.A9 36.64,396.24 ; D232.A9 35.83,395.43 ; D232.A9 35.02,396.24 ; D232.A9 35.83,397.05 ; 124.73,72.85 D122.A15 ; D122.A15 125.54,73.66 ; D122.A15 124.73,74.47 ; D122.A15 123.92,73.66 ; 32.48,383.54 D431.A10 ; D431.A10 33.29,384.35 ; D431.A10 33.29,382.73 ; D431.A10 34.1,383.54 ; 48.17,365.45 UHC430.G2_1 ; UHC430.G2_1 49.79,365.45 ; UHC430.G2_1 48.98,366.26 ; UHC430.G2_1 48.98,364.64 ; D108.B8 255.08,40.64 ; D108.B8 254.27,41.45 ; D108.B8 254.27,39.83 ; D108.B8 253.46,40.64 ; D231.A3 51.88,375.92 ; D231.A3 51.07,376.73 ; D231.A3 50.26,375.92 ; D231.A3 51.07,375.11 ; 200.93,367.49 D115.B2 ; D115.B2 201.74,368.3 ; D115.B2 200.93,369.11 ; D115.B2 200.12,368.3 ; DPS2.B11 178.88,412.75 ; DPS2.B11 178.07,411.94 ; DPS2.B11 177.26,412.75 ; DPS2.B11 178.07,413.56 ; 273.78,353.06 D110.A2 ; D110.A2 275.4,353.06 ; D110.A2 274.59,352.25 ; D110.A2 274.59,353.87 ; 103.6,73.66 D122.A7 ; D122.A7 104.41,74.47 ; D122.A7 105.22,73.66 ; D122.A7 104.41,72.85 ; D121.B11 114.57,99.87 ; D121.B11 115.38,99.06 ; D121.B11 113.76,99.06 ; D121.B11 114.57,98.25 ; D105.A6 249.19,97.33 ; D105.A6 248.38,96.52 ; D105.A6 250,96.52 ; D105.A6 249.19,95.71 ; D104.A7 178.07,33.83 ; D104.A7 178.07,32.21 ; D104.A7 178.88,33.02 ; D104.A7 177.26,33.02 ; 129.81,359.87 CSDPS426.C1 ; CSDPS426.C1 129,360.68 ; CSDPS426.C1 129.81,361.49 ; CSDPS426.C1 130.62,360.68 ; 25.67,329.39 CSDPS229.C13 ; CSDPS229.C13 24.86,330.2 ; CSDPS229.C13 26.48,330.2 ; CSDPS229.C13 25.67,331.01 ; 240.76,73.66 D106.A3 ; D106.A3 241.57,74.47 ; D106.A3 241.57,72.85 ; D106.A3 242.38,73.66 ; D432.A1 56.96,406.4 ; D432.A1 56.15,405.59 ; D432.A1 55.34,406.4 ; D432.A1 56.15,407.21 ; D114.B7 188.23,351.33 ; D114.B7 188.23,349.71 ; D114.B7 189.04,350.52 ; D114.B7 187.42,350.52 ; D428.A5 119.65,407.21 ; D428.A5 119.65,405.59 ; D428.A5 120.46,406.4 ; D428.A5 118.84,406.4 ; 167.1,370.84 D115.B15 ; D115.B15 167.91,370.03 ; D115.B15 168.72,370.84 ; D115.B15 167.91,371.65 ; 122.19,372.57 D227.A4 ; D227.A4 122.19,374.19 ; D227.A4 121.38,373.38 ; D227.A4 123,373.38 ; 98.52,375.92 D227.A13 ; D227.A13 99.33,376.73 ; D227.A13 99.33,375.11 ; D227.A13 100.14,375.92 ; 258.54,96.52 D105.A10 ; D105.A10 260.16,96.52 ; D105.A10 259.35,97.33 ; D105.A10 259.35,95.71 ; 106.14,332.74 CSDPS225.B10 ; CSDPS225.B10 106.95,333.55 ; CSDPS225.B10 106.95,331.93 ; CSDPS225.B10 107.76,332.74 ; D104.B8 181.42,40.64 ; D104.B8 179.8,40.64 ; D104.B8 180.61,41.45 ; D104.B8 180.61,39.83 ; CSDPS225.C15 95.06,330.2 ; CSDPS225.C15 94.25,329.39 ; CSDPS225.C15 93.44,330.2 ; CSDPS225.C15 94.25,331.01 ; D113.A13 172.99,336.09 ; D113.A13 173.8,335.28 ; D113.A13 172.99,334.47 ; D113.A13 172.18,335.28 ; 95.98,60.96 D123.B4 ; D123.B4 97.6,60.96 ; D123.B4 96.79,60.15 ; D123.B4 96.79,61.77 ; 18.03,362.89 UHC430.G1_4 ; UHC430.G1_4 18.03,364.51 ; UHC430.G1_4 17.22,363.7 ; UHC430.G1_4 18.84,363.7 ; D108.A6 249.19,36.37 ; D108.A6 249.19,34.75 ; D108.A6 248.38,35.56 ; D108.A6 250,35.56 ; DPS2.C05 193.31,411.02 ; DPS2.C05 194.12,410.21 ; DPS2.C05 193.31,409.4 ; DPS2.C05 192.5,410.21 ; 122.19,403.05 D428.A4 ; D428.A4 122.19,404.67 ; D428.A4 123,403.86 ; D428.A4 121.38,403.86 ; 117.11,382.73 D427.A6 ; D427.A6 116.3,383.54 ; D427.A6 117.92,383.54 ; D427.A6 117.11,384.35 ; 192.5,412.75 DPS2.B05 ; DPS2.B05 193.31,413.56 ; DPS2.B05 193.31,411.94 ; DPS2.B05 194.12,412.75 ; 180.61,352.25 D114.A10 ; D114.A10 181.42,353.06 ; D114.A10 179.8,353.06 ; D114.A10 180.61,353.87 ; D115.B4 195.85,369.11 ; D115.B4 195.04,368.3 ; D115.B4 195.85,367.49 ; D115.B4 196.66,368.3 ; 47.72,388.62 D232.B4 ; D232.B4 49.34,388.62 ; D232.B4 48.53,389.43 ; D232.B4 48.53,387.81 ; 246.65,15.7 DPS1.B05 ; DPS1.B05 247.46,16.51 ; DPS1.B05 246.65,17.32 ; DPS1.B05 245.84,16.51 ; D103.B2 165.37,61.77 ; D103.B2 165.37,60.15 ; D103.B2 166.18,60.96 ; D103.B2 164.56,60.96 ; D114.A4 196.66,353.06 ; D114.A4 195.85,353.87 ; D114.A4 195.04,353.06 ; D114.A4 195.85,352.25 ; D431.A14 23.13,384.35 ; D431.A14 23.13,382.73 ; D431.A14 22.32,383.54 ; D431.A14 23.94,383.54 ; 116.3,55.88 D123.A12 ; D123.A12 117.11,56.69 ; D123.A12 117.92,55.88 ; D123.A12 117.11,55.07 ; D108.A1 236.49,33.83 ; D108.A1 236.49,32.21 ; D108.A1 237.3,33.02 ; D108.A1 235.68,33.02 ; 269.51,331.93 D109.A4 ; D109.A4 270.32,332.74 ; D109.A4 269.51,333.55 ; D109.A4 268.7,332.74 ; 14.7,391.16 D232.B17 ; D232.B17 15.51,390.35 ; D232.B17 15.51,391.97 ; D232.B17 16.32,391.16 ; 111.22,378.46 D427.B8 ; D427.B8 112.03,379.27 ; D427.B8 112.84,378.46 ; D427.B8 112.03,377.65 ; D101.A15 198.39,94.79 ; D101.A15 197.58,93.98 ; D101.A15 198.39,93.17 ; D101.A15 199.2,93.98 ; 106.95,397.97 D428.B10 ; D428.B10 107.76,398.78 ; D428.B10 106.95,399.59 ; D428.B10 106.14,398.78 ; D105.A8 255.08,96.52 ; D105.A8 253.46,96.52 ; D105.A8 254.27,95.71 ; D105.A8 254.27,97.33 ; 240.76,33.02 D108.A3 ; D108.A3 241.57,32.21 ; D108.A3 242.38,33.02 ; D108.A3 241.57,33.83 ; D120.B10 39.18,40.64 ; D120.B10 38.37,39.83 ; D120.B10 38.37,41.45 ; D120.B10 37.56,40.64 ; 106.14,378.46 D427.B10 ; D427.B10 106.95,379.27 ; D427.B10 107.76,378.46 ; D427.B10 106.95,377.65 ; D123.B5 99.33,59.23 ; D123.B5 99.33,57.61 ; D123.B5 100.14,58.42 ; D123.B5 98.52,58.42 ; 23.13,403.05 D432.A14 ; D432.A14 23.94,403.86 ; D432.A14 22.32,403.86 ; D432.A14 23.13,404.67 ; D122.B12 117.11,82.09 ; D122.B12 116.3,81.28 ; D122.B12 117.11,80.47 ; D122.B12 117.92,81.28 ; UHC230.G4 17.69,351.79 ; UHC230.G4 16.88,350.98 ; UHC230.G4 16.88,352.6 ; UHC230.G4 16.07,351.79 ; 23.13,387.81 D232.B14 ; D232.B14 22.32,388.62 ; D232.B14 23.94,388.62 ; D232.B14 23.13,389.43 ; D228.A1 129.81,397.05 ; D228.A1 129,396.24 ; D228.A1 130.62,396.24 ; D228.A1 129.81,395.43 ; 271.24,33.02 D108.A15 ; D108.A15 272.05,33.83 ; D108.A15 272.05,32.21 ; D108.A15 272.86,33.02 ; 188.23,57.61 D103.B11 ; D103.B11 189.04,58.42 ; D103.B11 188.23,59.23 ; D103.B11 187.42,58.42 ; D101.A1 163.64,93.98 ; D101.A1 162.83,94.79 ; D101.A1 162.83,93.17 ; D101.A1 162.02,93.98 ; 16.88,361.14 UHC430.G1 ; UHC430.G1 16.88,362.76 ; UHC430.G1 17.69,361.95 ; UHC430.G1 16.07,361.95 ; 268.7,327.66 D109.B4 ; D109.B4 270.32,327.66 ; D109.B4 269.51,326.85 ; D109.B4 269.51,328.47 ; D431.A15 20.59,386.89 ; D431.A15 20.59,385.27 ; D431.A15 19.78,386.08 ; D431.A15 21.4,386.08 ; D107.B9 257.62,58.42 ; D107.B9 256.81,57.61 ; D107.B9 256,58.42 ; D107.B9 256.81,59.23 ; 29.94,370.84 D231.B11 ; D231.B11 30.75,371.65 ; D231.B11 30.75,370.03 ; D231.B11 31.56,370.84 ; D120.B14 48.53,41.45 ; D120.B14 47.72,40.64 ; D120.B14 49.34,40.64 ; D120.B14 48.53,39.83 ; D122.A6 101.87,77.01 ; D122.A6 102.68,76.2 ; D122.A6 101.87,75.39 ; D122.A6 101.06,76.2 ; D427.A15 95.06,386.08 ; D427.A15 94.25,385.27 ; D427.A15 93.44,386.08 ; D427.A15 94.25,386.89 ; D228.B16 92.52,388.62 ; D228.B16 91.71,389.43 ; D228.B16 90.9,388.62 ; D228.B16 91.71,387.81 ; 25.67,32.21 D120.A5 ; D120.A5 26.48,33.02 ; D120.A5 25.67,33.83 ; D120.A5 24.86,33.02 ; D431.A3 51.88,386.08 ; D431.A3 51.07,385.27 ; D431.A3 50.26,386.08 ; D431.A3 51.07,386.89 ; 244.11,60.15 D107.B4 ; D107.B4 243.3,60.96 ; D107.B4 244.11,61.77 ; D107.B4 244.92,60.96 ; D109.B5 267.78,330.2 ; D109.B5 266.97,331.01 ; D109.B5 266.16,330.2 ; D109.B5 266.97,329.39 ; DPS8.A15 21.4,415.29 ; DPS8.A15 20.59,416.1 ; DPS8.A15 20.59,414.48 ; DPS8.A15 19.78,415.29 ; 200.93,55.07 D103.A16 ; D103.A16 200.93,56.69 ; D103.A16 201.74,55.88 ; D103.A16 200.12,55.88 ; 48.17,358.45 UHC430.G2_11 ; UHC430.G2_11 48.98,359.26 ; UHC430.G2_11 48.98,357.64 ; UHC430.G2_11 49.79,358.45 ; D115.B11 178.07,371.65 ; D115.B11 178.88,370.84 ; D115.B11 177.26,370.84 ; D115.B11 178.07,370.03 ; D110.B7 262.7,350.52 ; D110.B7 261.08,350.52 ; D110.B7 261.89,351.33 ; D110.B7 261.89,349.71 ; 28.21,331.93 CSDPS229.B12 ; CSDPS229.B12 29.02,332.74 ; CSDPS229.B12 28.21,333.55 ; CSDPS229.B12 27.4,332.74 ; 241.57,77.93 D106.B3 ; D106.B3 240.76,78.74 ; D106.B3 241.57,79.55 ; D106.B3 242.38,78.74 ; D101.A16 200.93,97.33 ; D101.A16 201.74,96.52 ; D101.A16 200.93,95.71 ; D101.A16 200.12,96.52 ; 250.92,33.02 D108.A7 ; D108.A7 251.73,33.83 ; D108.A7 251.73,32.21 ; D108.A7 252.54,33.02 ; D120.B7 31.56,38.1 ; D120.B7 30.75,37.29 ; D120.B7 29.94,38.1 ; D120.B7 30.75,38.91 ; 14.7,386.08 D431.A17 ; D431.A17 16.32,386.08 ; D431.A17 15.51,385.27 ; D431.A17 15.51,386.89 ; 172.99,329.39 D113.B13 ; D113.B13 172.99,331.01 ; D113.B13 172.18,330.2 ; D113.B13 173.8,330.2 ; 266.16,396.24 D112.A5 ; D112.A5 267.78,396.24 ; D112.A5 266.97,397.05 ; D112.A5 266.97,395.43 ; 268.7,35.56 D108.A14 ; D108.A14 270.32,35.56 ; D108.A14 269.51,36.37 ; D108.A14 269.51,34.75 ; 183.15,52.53 D103.A9 ; D103.A9 183.96,53.34 ; D103.A9 183.15,54.15 ; D103.A9 182.34,53.34 ; 53.61,60.15 D119.B16 ; D119.B16 52.8,60.96 ; D119.B16 53.61,61.77 ; D119.B16 54.42,60.96 ; CSDPS225.B14 97.6,332.74 ; CSDPS225.B14 96.79,331.93 ; CSDPS225.B14 95.98,332.74 ; CSDPS225.B14 96.79,333.55 ; 268.7,40.64 D108.B14 ; D108.B14 269.51,39.83 ; D108.B14 270.32,40.64 ; D108.B14 269.51,41.45 ; 195.04,55.88 D103.A14 ; D103.A14 195.85,55.07 ; D103.A14 196.66,55.88 ; D103.A14 195.85,56.69 ; D122.B15 124.73,79.55 ; D122.B15 125.54,78.74 ; D122.B15 124.73,77.93 ; D122.B15 123.92,78.74 ; 93.44,53.34 D123.A3 ; D123.A3 95.06,53.34 ; D123.A3 94.25,54.15 ; D123.A3 94.25,52.53 ; D120.A10 38.37,36.37 ; D120.A10 38.37,34.75 ; D120.A10 39.18,35.56 ; D120.A10 37.56,35.56 ; D106.A4 244.11,77.01 ; D106.A4 243.3,76.2 ; D106.A4 244.11,75.39 ; D106.A4 244.92,76.2 ; 40.91,37.29 D120.B11 ; D120.B11 40.91,38.91 ; D120.B11 40.1,38.1 ; D120.B11 41.72,38.1 ; D109.A7 261.89,336.09 ; D109.A7 261.89,334.47 ; D109.A7 261.08,335.28 ; D109.A7 262.7,335.28 ; D427.B13 99.33,381.81 ; D427.B13 100.14,381 ; D427.B13 99.33,380.19 ; D427.B13 98.52,381 ; CSDPS226.B4 123,353.06 ; CSDPS226.B4 122.19,352.25 ; CSDPS226.B4 122.19,353.87 ; CSDPS226.B4 121.38,353.06 ; 127.27,362.41 CSDPS426.B2 ; CSDPS426.B2 127.27,364.03 ; CSDPS426.B2 128.08,363.22 ; CSDPS426.B2 126.46,363.22 ; 248.38,55.88 D107.A6 ; D107.A6 249.19,56.69 ; D107.A6 250,55.88 ; D107.A6 249.19,55.07 ; 114.57,370.03 D227.B7 ; D227.B7 115.38,370.84 ; D227.B7 113.76,370.84 ; D227.B7 114.57,371.65 ; D102.B11 188.23,79.55 ; D102.B11 189.04,78.74 ; D102.B11 187.42,78.74 ; D102.B11 188.23,77.93 ; CSDPS226.B6 117.11,353.87 ; CSDPS226.B6 116.3,353.06 ; CSDPS226.B6 117.92,353.06 ; CSDPS226.B6 117.11,352.25 ; 193.31,77.93 D102.B13 ; D102.B13 194.12,78.74 ; D102.B13 192.5,78.74 ; D102.B13 193.31,79.55 ; UHC230.G4_8 14.58,352.6 ; UHC230.G4_8 15.39,351.79 ; UHC230.G4_8 13.77,351.79 ; UHC230.G4_8 14.58,350.98 ; 15.51,72.85 D118.A1 ; D118.A1 14.7,73.66 ; D118.A1 16.32,73.66 ; D118.A1 15.51,74.47 ; D232.B6 43.45,389.43 ; D232.B6 44.26,388.62 ; D232.B6 42.64,388.62 ; D232.B6 43.45,387.81 ; 273.78,40.64 D108.B16 ; D108.B16 275.4,40.64 ; D108.B16 274.59,39.83 ; D108.B16 274.59,41.45 ; 101.06,368.3 D227.B12 ; D227.B12 101.87,369.11 ; D227.B12 102.68,368.3 ; D227.B12 101.87,367.49 ; DPS1.C01 237.3,19.05 ; DPS1.C01 236.49,19.86 ; DPS1.C01 235.68,19.05 ; DPS1.C01 236.49,18.24 ; 40.1,381 D431.B7 ; D431.B7 41.72,381 ; D431.B7 40.91,380.19 ; D431.B7 40.91,381.81 ; D228.A13 99.33,397.05 ; D228.A13 100.14,396.24 ; D228.A13 99.33,395.43 ; D228.A13 98.52,396.24 ; 249.19,39.83 D108.B6 ; D108.B6 250,40.64 ; D108.B6 248.38,40.64 ; D108.B6 249.19,41.45 ; 113.76,381 D427.B7 ; D427.B7 114.57,380.19 ; D427.B7 114.57,381.81 ; D427.B7 115.38,381 ; D232.A4 49.34,393.7 ; D232.A4 48.53,394.51 ; D232.A4 47.72,393.7 ; D232.A4 48.53,392.89 ; D427.B12 102.68,378.46 ; D427.B12 101.87,379.27 ; D427.B12 101.87,377.65 ; D427.B12 101.06,378.46 ; 23.13,342.09 CSDPS429.B14 ; CSDPS429.B14 22.32,342.9 ; CSDPS429.B14 23.94,342.9 ; CSDPS429.B14 23.13,343.71 ; 167.91,93.17 D101.A3 ; D101.A3 167.91,94.79 ; D101.A3 168.72,93.98 ; D101.A3 167.1,93.98 ; D122.A4 97.6,76.2 ; D122.A4 96.79,75.39 ; D122.A4 96.79,77.01 ; D122.A4 95.98,76.2 ; D428.A10 107.76,403.86 ; D428.A10 106.14,403.86 ; D428.A10 106.95,403.05 ; D428.A10 106.95,404.67 ; 180.61,347.17 D114.B10 ; D114.B10 181.42,347.98 ; D114.B10 179.8,347.98 ; D114.B10 180.61,348.79 ; D111.A1 277.13,376.73 ; D111.A1 277.94,375.92 ; D111.A1 276.32,375.92 ; D111.A1 277.13,375.11 ; CSDPS226.B8 112.03,353.87 ; CSDPS226.B8 111.22,353.06 ; CSDPS226.B8 112.84,353.06 ; CSDPS226.B8 112.03,352.25 ; D227.A1 130.62,375.92 ; D227.A1 129,375.92 ; D227.A1 129.81,376.73 ; D227.A1 129.81,375.11 ; 111.22,393.7 D228.A8 ; D228.A8 112.03,394.51 ; D228.A8 112.84,393.7 ; D228.A8 112.03,392.89 ; 22.32,35.56 D120.A4 ; D120.A4 23.13,36.37 ; D120.A4 23.13,34.75 ; D120.A4 23.94,35.56 ; 126.46,332.74 CSDPS225.B2 ; CSDPS225.B2 127.27,331.93 ; CSDPS225.B2 127.27,333.55 ; CSDPS225.B2 128.08,332.74 ; CSDPS229.C9 35.83,331.01 ; CSDPS229.C9 35.02,330.2 ; CSDPS229.C9 36.64,330.2 ; CSDPS229.C9 35.83,329.39 ; 250.92,330.2 D109.B11 ; D109.B11 252.54,330.2 ; D109.B11 251.73,331.01 ; D109.B11 251.73,329.39 ; D119.B6 29.02,60.96 ; D119.B6 28.21,60.15 ; D119.B6 27.4,60.96 ; D119.B6 28.21,61.77 ; D103.A8 181.42,55.88 ; D103.A8 179.8,55.88 ; D103.A8 180.61,56.69 ; D103.A8 180.61,55.07 ; 93.44,73.66 D122.A3 ; D122.A3 94.25,74.47 ; D122.A3 95.06,73.66 ; D122.A3 94.25,72.85 ; D103.B8 180.61,61.77 ; D103.B8 179.8,60.96 ; D103.B8 180.61,60.15 ; D103.B8 181.42,60.96 ; D116.B3 198.39,391.97 ; D116.B3 197.58,391.16 ; D116.B3 199.2,391.16 ; D116.B3 198.39,390.35 ; D108.B11 261.89,38.91 ; D108.B11 261.08,38.1 ; D108.B11 261.89,37.29 ; D108.B11 262.7,38.1 ; D104.B16 201.74,40.64 ; D104.B16 200.93,39.83 ; D104.B16 200.93,41.45 ; D104.B16 200.12,40.64 ; D227.A7 115.38,375.92 ; D227.A7 113.76,375.92 ; D227.A7 114.57,375.11 ; D227.A7 114.57,376.73 ; 13.77,361.95 UHC430.G1_8 ; UHC430.G1_8 14.58,362.76 ; UHC430.G1_8 15.39,361.95 ; UHC430.G1_8 14.58,361.14 ; 32.48,398.78 D432.B10 ; D432.B10 33.29,399.59 ; D432.B10 34.1,398.78 ; D432.B10 33.29,397.97 ; 99.33,385.27 D427.A13 ; D427.A13 98.52,386.08 ; D427.A13 99.33,386.89 ; D427.A13 100.14,386.08 ; D112.B3 272.86,391.16 ; D112.B3 272.05,390.35 ; D112.B3 271.24,391.16 ; D112.B3 272.05,391.97 ; DPS3.A11 115.38,13.97 ; DPS3.A11 113.76,13.97 ; DPS3.A11 114.57,13.16 ; DPS3.A11 114.57,14.78 ; 258.54,373.38 D111.A8 ; D111.A8 260.16,373.38 ; D111.A8 259.35,374.19 ; D111.A8 259.35,372.57 ; 113.76,391.16 D228.B7 ; D228.B7 115.38,391.16 ; D228.B7 114.57,390.35 ; D228.B7 114.57,391.97 ; 18.37,348.29 UHC230.G4_11 ; UHC230.G4_11 19.18,347.48 ; UHC230.G4_11 19.18,349.1 ; UHC230.G4_11 19.99,348.29 ; 177.26,330.2 D113.B11 ; D113.B11 178.07,329.39 ; D113.B11 178.88,330.2 ; D113.B11 178.07,331.01 ; D123.B10 112.84,60.96 ; D123.B10 112.03,60.15 ; D123.B10 111.22,60.96 ; D123.B10 112.03,61.77 ; CSDPS225.C11 104.41,331.01 ; CSDPS225.C11 105.22,330.2 ; CSDPS225.C11 103.6,330.2 ; CSDPS225.C11 104.41,329.39 ; DPS3.A01 89.98,13.97 ; DPS3.A01 89.17,13.16 ; DPS3.A01 89.17,14.78 ; DPS3.A01 88.36,13.97 ; 269.51,352.25 D110.A4 ; D110.A4 270.32,353.06 ; D110.A4 269.51,353.87 ; D110.A4 268.7,353.06 ; 116.3,76.2 D122.A12 ; D122.A12 117.11,77.01 ; D122.A12 117.11,75.39 ; D122.A12 117.92,76.2 ; D428.B16 92.52,398.78 ; D428.B16 91.71,397.97 ; D428.B16 90.9,398.78 ; D428.B16 91.71,399.59 ; 191.58,96.52 D101.A12 190.77,95.71 ; 189.96,388.62 D116.B6 ; D116.B6 191.58,388.62 ; D116.B6 190.77,387.81 ; D116.B6 190.77,389.43 ; 129,340.36 CSDPS425.C1 ; CSDPS425.C1 129.81,339.55 ; CSDPS425.C1 129.81,341.17 ; CSDPS425.C1 130.62,340.36 ; D115.A15 168.72,375.92 ; D115.A15 167.91,375.11 ; D115.A15 167.1,375.92 ; D115.A15 167.91,376.73 ; 116.3,368.3 D227.B6 ; D227.B6 117.11,369.11 ; D227.B6 117.92,368.3 ; D227.B6 117.11,367.49 ; D112.B1 277.94,391.16 ; D112.B1 277.13,390.35 ; D112.B1 277.13,391.97 ; D112.B1 276.32,391.16 ; D231.B12 29.02,368.3 ; D231.B12 28.21,367.49 ; D231.B12 28.21,369.11 ; D231.B12 27.4,368.3 ; 94.25,405.59 D428.A15 ; D428.A15 95.06,406.4 ; D428.A15 93.44,406.4 ; D428.A15 94.25,407.21 ; D115.B7 188.23,371.65 ; D115.B7 188.23,370.03 ; D115.B7 187.42,370.84 ; D115.B7 189.04,370.84 ; D111.B10 254.27,369.11 ; D111.B10 253.46,368.3 ; D111.B10 254.27,367.49 ; D111.B10 255.08,368.3 ; CSDPS225.C5 119.65,331.01 ; CSDPS225.C5 119.65,329.39 ; CSDPS225.C5 118.84,330.2 ; CSDPS225.C5 120.46,330.2 ; 235.68,78.74 D106.B1 ; D106.B1 236.49,77.93 ; D106.B1 237.3,78.74 ; D106.B1 236.49,79.55 ; CSDPS429.C3 51.07,341.17 ; CSDPS429.C3 50.26,340.36 ; CSDPS429.C3 51.88,340.36 ; CSDPS429.C3 51.07,339.55 ; 51.07,57.61 D119.B15 ; D119.B15 51.88,58.42 ; D119.B15 50.26,58.42 ; D119.B15 51.07,59.23 ; 117.11,331.93 CSDPS225.B6 ; CSDPS225.B6 117.11,333.55 ; CSDPS225.B6 117.92,332.74 ; CSDPS225.B6 116.3,332.74 ; 198.39,32.21 D104.A15 ; D104.A15 197.58,33.02 ; D104.A15 199.2,33.02 ; D104.A15 198.39,33.83 ; 258.54,40.64 D108.B10 ; D108.B10 259.35,41.45 ; D108.B10 259.35,39.83 ; D108.B10 260.16,40.64 ; D114.B9 183.96,350.52 ; D114.B9 183.15,351.33 ; D114.B9 182.34,350.52 ; D114.B9 183.15,349.71 ; CSDPS225.C9 109.49,331.01 ; CSDPS225.C9 109.49,329.39 ; CSDPS225.C9 108.68,330.2 ; CSDPS225.C9 110.3,330.2 ; 274.59,367.49 D111.B2 ; D111.B2 273.78,368.3 ; D111.B2 274.59,369.11 ; D111.B2 275.4,368.3 ; 45.18,58.42 D119.B13 ; D119.B13 46.8,58.42 ; D119.B13 45.99,57.61 ; D119.B13 45.99,59.23 ; 239.03,95.71 D105.A2 ; D105.A2 239.03,97.33 ; D105.A2 239.84,96.52 ; D105.A2 238.22,96.52 ; D109.A9 256.81,336.09 ; D109.A9 256.81,334.47 ; D109.A9 256,335.28 ; D109.A9 257.62,335.28 ; D431.B14 23.94,378.46 ; D431.B14 23.13,377.65 ; D431.B14 22.32,378.46 ; D431.B14 23.13,379.27 ; D119.B4 23.94,60.96 ; D119.B4 22.32,60.96 ; D119.B4 23.13,60.15 ; D119.B4 23.13,61.77 ; 187.42,73.66 D102.A11 ; D102.A11 189.04,73.66 ; D102.A11 188.23,72.85 ; D102.A11 188.23,74.47 ; 175.53,372.57 D115.A12 ; D115.A12 174.72,373.38 ; D115.A12 176.34,373.38 ; D115.A12 175.53,374.19 ; 103.6,375.92 D227.A11 ; D227.A11 104.41,376.73 ; D227.A11 104.41,375.11 ; D227.A11 105.22,375.92 ; D112.A10 254.27,394.51 ; D112.A10 253.46,393.7 ; D112.A10 254.27,392.89 ; D112.A10 255.08,393.7 ; D111.B1 277.94,370.84 ; D111.B1 276.32,370.84 ; D111.B1 277.13,371.65 ; D111.B1 277.13,370.03 ; 108.68,93.98 D121.A9 ; D121.A9 109.49,93.17 ; D121.A9 109.49,94.79 ; D121.A9 110.3,93.98 ; D124.B13 120.46,38.1 ; D124.B13 119.65,38.91 ; D124.B13 119.65,37.29 ; D124.B13 118.84,38.1 ; D119.B11 41.72,58.42 ; D119.B11 40.91,59.23 ; D119.B11 40.1,58.42 ; D119.B11 40.91,57.61 ; D103.A1 163.64,53.34 ; D103.A1 162.83,52.53 ; D103.A1 162.83,54.15 ; D103.A1 162.02,53.34 ; 271.24,330.2 D109.B3 ; D109.B3 272.05,331.01 ; D109.B3 272.05,329.39 ; D109.B3 272.86,330.2 ; 261.89,375.11 D111.A7 ; D111.A7 262.7,375.92 ; D111.A7 261.89,376.73 ; D111.A7 261.08,375.92 ; D122.B9 110.3,78.74 ; D122.B9 109.49,77.93 ; D122.B9 109.49,79.55 ; D122.B9 108.68,78.74 ; D109.A1 277.94,335.28 ; D109.A1 277.13,334.47 ; D109.A1 276.32,335.28 ; D109.A1 277.13,336.09 ; CSDPS225.B12 101.87,333.55 ; CSDPS225.B12 102.68,332.74 ; CSDPS225.B12 101.06,332.74 ; CSDPS225.B12 101.87,331.93 ; D110.B12 249.19,348.79 ; D110.B12 249.19,347.17 ; D110.B12 248.38,347.98 ; D110.B12 250,347.98 ; D115.A9 183.15,376.73 ; D115.A9 183.15,375.11 ; D115.A9 183.96,375.92 ; D115.A9 182.34,375.92 ; D228.A10 107.76,393.7 ; D228.A10 106.14,393.7 ; D228.A10 106.95,392.89 ; D228.A10 106.95,394.51 ; 169.64,353.06 D114.A14 ; D114.A14 170.45,353.87 ; D114.A14 170.45,352.25 ; D114.A14 171.26,353.06 ; D431.B8 38.37,379.27 ; D431.B8 37.56,378.46 ; D431.B8 38.37,377.65 ; D431.B8 39.18,378.46
  L03_DIG w0.132: D118.B15 51.07,79.55 ; D118.B15 51.07,77.93 ; D118.B15 51.88,78.74 ; D118.B15 50.26,78.74 ; 14.58,347.48 UHC230.G4_13 ; UHC230.G4_13 15.39,348.29 ; UHC230.G4_13 13.77,348.29 ; UHC230.G4_13 14.58,349.1 ; D124.B2 92.52,40.64 ; D124.B2 90.9,40.64 ; D124.B2 91.71,41.45 ; D124.B2 91.71,39.83 ; D117.B1 16.32,99.06 ; D117.B1 15.51,98.25 ; D117.B1 15.51,99.87 ; D117.B1 14.7,99.06 ; 127.27,352.25 CSDPS226.B2 ; CSDPS226.B2 127.27,353.87 ; CSDPS226.B2 128.08,353.06 ; CSDPS226.B2 126.46,353.06 ; D101.B7 178.07,99.87 ; D101.B7 178.88,99.06 ; D101.B7 178.07,98.25 ; D101.B7 177.26,99.06 ; 37.56,76.2 D118.A10 ; D118.A10 38.37,75.39 ; D118.A10 38.37,77.01 ; D118.A10 39.18,76.2 ; D103.B4 171.26,60.96 ; D103.B4 169.64,60.96 ; D103.B4 170.45,60.15 ; D103.B4 170.45,61.77 ; 169.64,76.2 D102.A4 ; D102.A4 171.26,76.2 ; D102.A4 170.45,75.39 ; D102.A4 170.45,77.01 ; 271.24,330.2 D109.B3 ; D109.B3 272.05,329.39 ; D109.B3 272.05,331.01 ; D109.B3 272.86,330.2 ; 25.67,52.53 D119.A5 ; D119.A5 26.48,53.34 ; D119.A5 24.86,53.34 ; D119.A5 25.67,54.15 ; 35.02,391.16 D232.B9 ; D232.B9 35.83,390.35 ; D232.B9 36.64,391.16 ; D232.B9 35.83,391.97 ; D123.A7 104.41,54.15 ; D123.A7 103.6,53.34 ; D123.A7 104.41,52.53 ; D123.A7 105.22,53.34 ; 23.13,60.15 D119.B4 ; D119.B4 23.94,60.96 ; D119.B4 22.32,60.96 ; D119.B4 23.13,61.77 ; 122.19,352.25 CSDPS226.B4 ; CSDPS226.B4 121.38,353.06 ; CSDPS226.B4 123,353.06 ; CSDPS226.B4 122.19,353.87 ; 200.93,392.89 D116.A2 ; D116.A2 201.74,393.7 ; D116.A2 200.93,394.51 ; D116.A2 200.12,393.7 ; UHC430.G1_9 18.03,361.01 ; UHC430.G1_9 18.84,360.2 ; UHC430.G1_9 17.22,360.2 ; UHC430.G1_9 18.03,359.39 ; 20.59,32.21 D120.A3 ; D120.A3 20.59,33.83 ; D120.A3 21.4,33.02 ; D120.A3 19.78,33.02 ; DPS2.A11 178.88,415.29 ; DPS2.A11 177.26,415.29 ; DPS2.A11 178.07,416.1 ; DPS2.A11 178.07,414.48 ; D432.B4 49.34,398.78 ; D432.B4 47.72,398.78 ; D432.B4 48.53,399.59 ; D432.B4 48.53,397.97 ; 184.88,347.98 D114.B8 ; D114.B8 186.5,347.98 ; D114.B8 185.69,348.79 ; D114.B8 185.69,347.17 ; DPS1.B05 246.65,17.32 ; DPS1.B05 246.65,15.7 ; DPS1.B05 247.46,16.51 ; DPS1.B05 245.84,16.51 ; D102.A15 199.2,73.66 ; D102.A15 197.58,73.66 ; D102.A15 198.39,74.47 ; D102.A15 198.39,72.85 ; 37.56,55.88 D119.A10 ; D119.A10 38.37,55.07 ; D119.A10 38.37,56.69 ; D119.A10 39.18,55.88 ; 44.38,364.64 UHC430.G2_3 ; UHC430.G2_3 44.38,366.26 ; UHC430.G2_3 43.57,365.45 ; UHC430.G2_3 45.19,365.45 ; D232.A15 20.59,397.05 ; D232.A15 21.4,396.24 ; D232.A15 19.78,396.24 ; D232.A15 20.59,395.43 ; CSDPS429.C7 40.91,341.17 ; CSDPS429.C7 40.1,340.36 ; CSDPS429.C7 40.91,339.55 ; CSDPS429.C7 41.72,340.36 ; 198.39,52.53 D103.A15 ; D103.A15 198.39,54.15 ; D103.A15 197.58,53.34 ; D103.A15 199.2,53.34 ; 116.3,55.88 D123.A12 ; D123.A12 117.92,55.88 ; D123.A12 117.11,55.07 ; D123.A12 117.11,56.69 ; 32.48,403.86 D432.A10 ; D432.A10 33.29,403.05 ; D432.A10 34.1,403.86 ; D432.A10 33.29,404.67 ; 43.45,55.07 D119.A12 ; D119.A12 44.26,55.88 ; D119.A12 42.64,55.88 ; D119.A12 43.45,56.69 ; UHC430.G1_1 19.99,365.45 ; UHC430.G1_1 19.18,364.64 ; UHC430.G1_1 19.18,366.26 ; UHC430.G1_1 18.37,365.45 ; 266.16,38.1 D108.B13 ; D108.B13 266.97,37.29 ; D108.B13 266.97,38.91 ; D108.B13 267.78,38.1 ; D232.A4 48.53,394.51 ; D232.A4 47.72,393.7 ; D232.A4 48.53,392.89 ; D232.A4 49.34,393.7 ; D124.A12 117.11,36.37 ; D124.A12 117.92,35.56 ; D124.A12 117.11,34.75 ; D124.A12 116.3,35.56 ; D431.A3 51.88,386.08 ; D431.A3 50.26,386.08 ; D431.A3 51.07,386.89 ; D431.A3 51.07,385.27 ; D431.B6 43.45,379.27 ; D431.B6 42.64,378.46 ; D431.B6 43.45,377.65 ; D431.B6 44.26,378.46 ; 16.88,361.14 UHC430.G1 ; UHC430.G1 16.07,361.95 ; UHC430.G1 17.69,361.95 ; UHC430.G1 16.88,362.76 ; 113.76,33.02 D124.A11 ; D124.A11 115.38,33.02 ; D124.A11 114.57,32.21 ; D124.A11 114.57,33.83 ; D120.B9 35.83,38.91 ; D120.B9 35.83,37.29 ; D120.B9 36.64,38.1 ; D120.B9 35.02,38.1 ; DPS1.C01 237.3,19.05 ; DPS1.C01 236.49,18.24 ; DPS1.C01 236.49,19.86 ; DPS1.C01 235.68,19.05 ; D431.A7 40.91,386.89 ; D431.A7 40.1,386.08 ; D431.A7 41.72,386.08 ; D431.A7 40.91,385.27 ; 266.16,370.84 D111.B5 ; D111.B5 266.97,370.03 ; D111.B5 267.78,370.84 ; D111.B5 266.97,371.65 ; 33.29,95.71 D117.A8 ; D117.A8 32.48,96.52 ; D117.A8 34.1,96.52 ; D117.A8 33.29,97.33 ; 55.34,415.29 DPS8.A01 ; DPS8.A01 56.96,415.29 ; DPS8.A01 56.15,414.48 ; DPS8.A01 56.15,416.1 ; 121.38,388.62 D228.B4 ; D228.B4 122.19,387.81 ; D228.B4 123,388.62 ; D228.B4 122.19,389.43 ; 108.68,93.98 D121.A9 ; D121.A9 110.3,93.98 ; D121.A9 109.49,93.17 ; D121.A9 109.49,94.79 ; 271.24,370.84 D111.B3 ; D111.B3 272.05,370.03 ; D111.B3 272.05,371.65 ; D111.B3 272.86,370.84 ; D122.A6 101.87,77.01 ; D122.A6 101.06,76.2 ; D122.A6 101.87,75.39 ; D122.A6 102.68,76.2 ; D112.A2 274.59,394.51 ; D112.A2 273.78,393.7 ; D112.A2 274.59,392.89 ; D112.A2 275.4,393.7 ; D102.A11 189.04,73.66 ; D102.A11 187.42,73.66 ; D102.A11 188.23,74.47 ; D102.A11 188.23,72.85 ; 183.15,349.71 D114.B9 ; D114.B9 182.34,350.52 ; D114.B9 183.96,350.52 ; D114.B9 183.15,351.33 ; 51.07,375.11 D231.A3 ; D231.A3 51.88,375.92 ; D231.A3 50.26,375.92 ; D231.A3 51.07,376.73 ; 15.51,400.51 D432.B17 ; D432.B17 16.32,401.32 ; D432.B17 15.51,402.13 ; D432.B17 14.7,401.32 ; 109.49,390.35 D228.B9 ; D228.B9 108.68,391.16 ; D228.B9 110.3,391.16 ; D228.B9 109.49,391.97 ; D109.A9 257.62,335.28 ; D109.A9 256,335.28 ; D109.A9 256.81,334.47 ; D109.A9 256.81,336.09 ; 202.66,370.84 D115.B1 ; D115.B1 203.47,370.03 ; D115.B1 204.28,370.84 ; D115.B1 203.47,371.65 ; 45.87,351.79 UHC230.G3 ; UHC230.G3 46.68,350.98 ; UHC230.G3 46.68,352.6 ; UHC230.G3 47.49,351.79 ; 47.72,101.6 D117.B14 ; D117.B14 48.53,102.41 ; D117.B14 49.34,101.6 ; D117.B14 48.53,100.79 ; 89.17,390.35 D228.B17 ; D228.B17 88.36,391.16 ; D228.B17 89.98,391.16 ; D228.B17 89.17,391.97 ; 261.08,78.74 D106.B11 ; D106.B11 261.89,79.55 ; D106.B11 261.89,77.93 ; D106.B11 262.7,78.74 ; 238.22,35.56 D108.A2 ; D108.A2 239.03,34.75 ; D108.A2 239.03,36.37 ; D108.A2 239.84,35.56 ; D118.B8 34.1,81.28 ; D118.B8 32.48,81.28 ; D118.B8 33.29,80.47 ; D118.B8 33.29,82.09 ; 276.32,350.52 D110.B1 ; D110.B1 277.13,351.33 ; D110.B1 277.13,349.71 ; D110.B1 277.94,350.52 ; DPS3.B15 125.54,16.51 ; DPS3.B15 123.92,16.51 ; DPS3.B15 124.73,15.7 ; DPS3.B15 124.73,17.32 ; D106.B13 266.97,79.55 ; D106.B13 266.97,77.93 ; D106.B13 267.78,78.74 ; D106.B13 266.16,78.74 ; D113.B12 176.34,327.66 ; D113.B12 174.72,327.66 ; D113.B12 175.53,326.85 ; D113.B12 175.53,328.47 ; 162.02,93.98 D101.A1 ; D101.A1 163.64,93.98 ; D101.A1 162.83,94.79 ; D101.A1 162.83,93.17 ; 261.89,329.39 D109.B7 ; D109.B7 261.08,330.2 ; D109.B7 261.89,331.01 ; D109.B7 262.7,330.2 ; D117.B7 31.56,99.06 ; D117.B7 29.94,99.06 ; D117.B7 30.75,98.25 ; D117.B7 30.75,99.87 ; 40.1,99.06 D117.B11 ; D117.B11 40.91,98.25 ; D117.B11 41.72,99.06 ; D117.B11 40.91,99.87 ; 268.7,60.96 D107.B14 ; D107.B14 269.51,60.15 ; D107.B14 269.51,61.77 ; D107.B14 270.32,60.96 ; 195.04,55.88 D103.A14 ; D103.A14 196.66,55.88 ; D103.A14 195.85,56.69 ; D103.A14 195.85,55.07 ; 175.53,34.75 D104.A6 ; D104.A6 175.53,36.37 ; D104.A6 176.34,35.56 ; D104.A6 174.72,35.56 ; D232.A8 38.37,394.51 ; D232.A8 39.18,393.7 ; D232.A8 38.37,392.89 ; D232.A8 37.56,393.7 ; CSDPS426.C15 95.06,360.68 ; CSDPS426.C15 93.44,360.68 ; CSDPS426.C15 94.25,359.87 ; CSDPS426.C15 94.25,361.49 ; 53.61,39.83 D120.B16 ; D120.B16 53.61,41.45 ; D120.B16 52.8,40.64 ; D120.B16 54.42,40.64 ; 111.22,353.06 CSDPS226.B8 ; CSDPS226.B8 112.84,353.06 ; CSDPS226.B8 112.03,353.87 ; CSDPS226.B8 112.03,352.25 ; D122.B3 94.25,79.55 ; D122.B3 95.06,78.74 ; D122.B3 94.25,77.93 ; D122.B3 93.44,78.74 ; 269.51,326.85 D109.B4 ; D109.B4 268.7,327.66 ; D109.B4 270.32,327.66 ; D109.B4 269.51,328.47 ; UHC230.G3_1 48.98,356.1 ; UHC230.G3_1 49.79,355.29 ; UHC230.G3_1 48.98,354.48 ; UHC230.G3_1 48.17,355.29 ; 271.24,99.06 D105.B15 ; D105.B15 272.05,99.87 ; D105.B15 272.05,98.25 ; D105.B15 272.86,99.06 ; D431.B17 16.32,381 ; D431.B17 15.51,380.19 ; D431.B17 15.51,381.81 ; D431.B17 14.7,381 ; D231.B17 15.51,371.65 ; D231.B17 15.51,370.03 ; D231.B17 16.32,370.84 ; D231.B17 14.7,370.84 ; DPS8.B11 31.56,412.75 ; DPS8.B11 30.75,413.56 ; DPS8.B11 30.75,411.94 ; DPS8.B11 29.94,412.75 ; D101.A15 198.39,94.79 ; D101.A15 198.39,93.17 ; D101.A15 199.2,93.98 ; D101.A15 197.58,93.98 ; 104.41,37.29 D124.B7 ; D124.B7 103.6,38.1 ; D124.B7 104.41,38.91 ; D124.B7 105.22,38.1 ; D115.B12 176.34,368.3 ; D115.B12 174.72,368.3 ; D115.B12 175.53,369.11 ; D115.B12 175.53,367.49 ; D115.A8 186.5,373.38 ; D115.A8 185.69,374.19 ; D115.A8 184.88,373.38 ; D115.A8 185.69,372.57 ; D432.A3 51.88,406.4 ; D432.A3 51.07,405.59 ; D432.A3 50.26,406.4 ; D432.A3 51.07,407.21 ; D112.A1 277.13,397.05 ; D112.A1 276.32,396.24 ; D112.A1 277.13,395.43 ; D112.A1 277.94,396.24 ; 127.27,39.83 D124.B16 ; D124.B16 128.08,40.64 ; D124.B16 127.27,41.45 ; D124.B16 126.46,40.64 ; 47.02,350.04 UHC230.G3_9 ; UHC230.G3_9 47.83,350.85 ; UHC230.G3_9 47.83,349.23 ; UHC230.G3_9 48.64,350.04 ; D122.A15 125.54,73.66 ; D122.A15 124.73,74.47 ; D122.A15 124.73,72.85 ; D122.A15 123.92,73.66 ; CSDPS429.C3 51.07,341.17 ; CSDPS429.C3 51.88,340.36 ; CSDPS429.C3 50.26,340.36 ; CSDPS429.C3 51.07,339.55 ; 261.08,58.42 D107.B11 ; D107.B11 262.7,58.42 ; D107.B11 261.89,59.23 ; D107.B11 261.89,57.61 ; CSDPS426.B8 112.03,364.03 ; CSDPS426.B8 112.03,362.41 ; CSDPS426.B8 112.84,363.22 ; CSDPS426.B8 111.22,363.22 ; 249.19,80.47 D106.B6 ; D106.B6 249.19,82.09 ; D106.B6 248.38,81.28 ; D106.B6 250,81.28 ; UHC230.G3_6 49.79,351.79 ; UHC230.G3_6 48.17,351.79 ; UHC230.G3_6 48.98,352.6 ; UHC230.G3_6 48.98,350.98 ; 119.65,375.11 D227.A5 ; D227.A5 118.84,375.92 ; D227.A5 120.46,375.92 ; D227.A5 119.65,376.73 ; D120.B11 41.72,38.1 ; D120.B11 40.1,38.1 ; D120.B11 40.91,37.29 ; D120.B11 40.91,38.91 ; D119.B13 46.8,58.42 ; D119.B13 45.18,58.42 ; D119.B13 45.99,59.23 ; D119.B13 45.99,57.61 ; 47.72,60.96 D119.B14 ; D119.B14 48.53,61.77 ; D119.B14 48.53,60.15 ; D119.B14 49.34,60.96 ; 167.91,370.03 D115.B15 ; D115.B15 167.1,370.84 ; D115.B15 168.72,370.84 ; D115.B15 167.91,371.65 ; 91.71,80.47 D122.B2 ; D122.B2 91.71,82.09 ; D122.B2 92.52,81.28 ; D122.B2 90.9,81.28 ; 18.05,80.47 D118.B2 ; D118.B2 18.05,82.09 ; D118.B2 18.86,81.28 ; D118.B2 17.24,81.28 ; 25.67,77.93 D118.B5 ; D118.B5 26.48,78.74 ; D118.B5 25.67,79.55 ; D118.B5 24.86,78.74 ; D228.B2 127.27,389.43 ; D228.B2 127.27,387.81 ; D228.B2 126.46,388.62 ; D228.B2 128.08,388.62 ; D427.A5 119.65,386.89 ; D427.A5 120.46,386.08 ; D427.A5 118.84,386.08 ; D427.A5 119.65,385.27 ; UHC430.G2_1 49.79,365.45 ; UHC430.G2_1 48.98,364.64 ; UHC430.G2_1 48.98,366.26 ; UHC430.G2_1 48.17,365.45 ; 188.23,395.43 D116.A7 ; D116.A7 189.04,396.24 ; D116.A7 188.23,397.05 ; D116.A7 187.42,396.24 ; D110.A9 257.62,355.6 ; D110.A9 256,355.6 ; D110.A9 256.81,356.41 ; D110.A9 256.81,354.79 ; 45.18,391.16 D232.B5 ; D232.B5 46.8,391.16 ; D232.B5 45.99,391.97 ; D232.B5 45.99,390.35 ; D427.A7 114.57,386.89 ; D427.A7 113.76,386.08 ; D427.A7 114.57,385.27 ; D427.A7 115.38,386.08 ; 106.14,342.9 CSDPS425.B10 ; CSDPS425.B10 106.95,343.71 ; CSDPS425.B10 106.95,342.09 ; CSDPS425.B10 107.76,342.9 ; 246.65,329.39 D109.B13 ; D109.B13 246.65,331.01 ; D109.B13 247.46,330.2 ; D109.B13 245.84,330.2 ; D103.B11 188.23,59.23 ; D103.B11 188.23,57.61 ; D103.B11 187.42,58.42 ; D103.B11 189.04,58.42 ; 106.14,393.7 D228.A10 ; D228.A10 106.95,394.51 ; D228.A10 106.95,392.89 ; D228.A10 107.76,393.7 ; 45.18,330.2 CSDPS229.C5 ; CSDPS229.C5 46.8,330.2 ; CSDPS229.C5 45.99,329.39 ; CSDPS229.C5 45.99,331.01 ; 268.7,347.98 D110.B4 ; D110.B4 270.32,347.98 ; D110.B4 269.51,348.79 ; D110.B4 269.51,347.17 ; 55.34,370.84 D231.B1 ; D231.B1 56.15,370.03 ; D231.B1 56.96,370.84 ; D231.B1 56.15,371.65 ; 108.68,386.08 D427.A9 ; D427.A9 109.49,385.27 ; D427.A9 109.49,386.89 ; D427.A9 110.3,386.08 ; 101.87,95.71 D121.A6 ; D121.A6 101.87,97.33 ; D121.A6 101.06,96.52 ; D121.A6 102.68,96.52 ; 89.17,72.85 D122.A1 ; D122.A1 88.36,73.66 ; D122.A1 89.98,73.66 ; D122.A1 89.17,74.47 ; D101.B12 190.77,102.41 ; D101.B12 190.77,100.79 ; D101.B12 191.58,101.6 ; D101.B12 189.96,101.6 ; D113.B1 203.47,331.01 ; D113.B1 203.47,329.39 ; D113.B1 202.66,330.2 ; D113.B1 204.28,330.2 ; D118.A9 36.64,73.66 ; D118.A9 35.83,74.47 ; D118.A9 35.02,73.66 ; D118.A9 35.83,72.85 ; 113.76,330.2 CSDPS225.C7 ; CSDPS225.C7 114.57,329.39 ; CSDPS225.C7 114.57,331.01 ; CSDPS225.C7 115.38,330.2 ; 45.99,395.43 D232.A5 ; D232.A5 45.18,396.24 ; D232.A5 46.8,396.24 ; D232.A5 45.99,397.05 ; 90.9,398.78 D428.B16 ; D428.B16 92.52,398.78 ; D428.B16 91.71,399.59 ; D428.B16 91.71,397.97 ; D432.B14 23.13,399.59 ; D432.B14 22.32,398.78 ; D432.B14 23.13,397.97 ; D432.B14 23.94,398.78 ; 127.27,377.65 D427.B2 ; D427.B2 127.27,379.27 ; D427.B2 126.46,378.46 ; D427.B2 128.08,378.46 ; CSDPS226.C11 104.41,351.33 ; CSDPS226.C11 104.41,349.71 ; CSDPS226.C11 103.6,350.52 ; CSDPS226.C11 105.22,350.52 ; 200.12,332.74 D113.A2 ; D113.A2 201.74,332.74 ; D113.A2 200.93,331.93 ; D113.A2 200.93,333.55 ; D109.B1 277.13,331.01 ; D109.B1 277.94,330.2 ; D109.B1 276.32,330.2 ; D109.B1 277.13,329.39 ; 127.27,382.73 D427.A2 ; D427.A2 126.46,383.54 ; D427.A2 127.27,384.35 ; D427.A2 128.08,383.54 ; 167.1,38.1 D104.B3 ; D104.B3 167.91,37.29 ; D104.B3 167.91,38.91 ; D104.B3 168.72,38.1 ; 195.85,387.81 D116.B4 ; D116.B4 195.04,388.62 ; D116.B4 195.85,389.43 ; D116.B4 196.66,388.62 ; 112.03,342.09 CSDPS425.B8 ; CSDPS425.B8 112.84,342.9 ; CSDPS425.B8 111.22,342.9 ; CSDPS425.B8 112.03,343.71 ; D110.A6 265.24,353.06 ; D110.A6 264.43,352.25 ; D110.A6 263.62,353.06 ; D110.A6 264.43,353.87 ; D115.A12 175.53,374.19 ; D115.A12 174.72,373.38 ; D115.A12 176.34,373.38 ; D115.A12 175.53,372.57 ; D107.A6 249.19,56.69 ; D107.A6 249.19,55.07 ; D107.A6 250,55.88 ; D107.A6 248.38,55.88 ; D227.A17 89.98,375.92 ; D227.A17 89.17,375.11 ; D227.A17 88.36,375.92 ; D227.A17 89.17,376.73 ; 32.48,76.2 D118.A8 ; D118.A8 34.1,76.2 ; D118.A8 33.29,77.01 ; D118.A8 33.29,75.39 ; D117.A6 28.21,97.33 ; D117.A6 29.02,96.52 ; D117.A6 27.4,96.52 ; D117.A6 28.21,95.71 ; 250.92,391.16 D112.B11 ; D112.B11 252.54,391.16 ; D112.B11 251.73,390.35 ; D112.B11 251.73,391.97 ; D123.B11 114.57,59.23 ; D123.B11 113.76,58.42 ; D123.B11 115.38,58.42 ; D123.B11 114.57,57.61 ; 172.99,77.93 D102.B5 ; D102.B5 172.18,78.74 ; D102.B5 172.99,79.55 ; D102.B5 173.8,78.74 ; D232.B10 33.29,389.43 ; D232.B10 33.29,387.81 ; D232.B10 32.48,388.62 ; D232.B10 34.1,388.62 ; 193.31,329.39 D113.B5 ; D113.B5 194.12,330.2 ; D113.B5 193.31,331.01 ; D113.B5 192.5,330.2 ; D105.B7 252.54,99.06 ; D105.B7 250.92,99.06 ; D105.B7 251.73,98.25 ; D105.B7 251.73,99.87 ; 47.83,352.73 UHC230.G3_4 ; UHC230.G3_4 47.02,353.54 ; UHC230.G3_4 48.64,353.54 ; UHC230.G3_4 47.83,354.35 ; 189.96,76.2 D102.A12 ; D102.A12 190.77,75.39 ; D102.A12 191.58,76.2 ; D102.A12 190.77,77.01 ; D124.B11 115.38,38.1 ; D124.B11 114.57,37.29 ; D124.B11 114.57,38.91 ; D124.B11 113.76,38.1 ; D123.B5 100.14,58.42 ; D123.B5 99.33,59.23 ; D123.B5 98.52,58.42 ; D123.B5 99.33,57.61 ; 240.76,391.16 D112.B15 ; D112.B15 241.57,390.35 ; D112.B15 241.57,391.97 ; D112.B15 242.38,391.16 ; D110.A12 249.19,353.87 ; D110.A12 249.19,352.25 ; D110.A12 250,353.06 ; D110.A12 248.38,353.06 ; 19.78,375.92 D231.A15 ; D231.A15 20.59,376.73 ; D231.A15 21.4,375.92 ; D231.A15 20.59,375.11 ; 14.7,406.4 D432.A17 ; D432.A17 15.51,405.59 ; D432.A17 16.32,406.4 ; D432.A17 15.51,407.21 ; D115.A15 168.72,375.92 ; D115.A15 167.91,375.11 ; D115.A15 167.1,375.92 ; D115.A15 167.91,376.73 ; 198.39,349.71 D114.B3 ; D114.B3 199.2,350.52 ; D114.B3 198.39,351.33 ; D114.B3 197.58,350.52 ; 182.34,73.66 D102.A9 ; D102.A9 183.96,73.66 ; D102.A9 183.15,74.47 ; D102.A9 183.15,72.85 ; D432.A14 23.13,404.67 ; D432.A14 22.32,403.86 ; D432.A14 23.13,403.05 ; D432.A14 23.94,403.86 ; DPS8.A15 20.59,416.1 ; DPS8.A15 21.4,415.29 ; DPS8.A15 19.78,415.29 ; DPS8.A15 20.59,414.48 ; D228.B11 104.41,391.97 ; D228.B11 104.41,390.35 ; D228.B11 103.6,391.16 ; D228.B11 105.22,391.16 ; 91.71,55.07 D123.A2 ; D123.A2 92.52,55.88 ; D123.A2 90.9,55.88 ; D123.A2 91.71,56.69 ; 174.72,40.64 D104.B6 ; D104.B6 175.53,41.45 ; D104.B6 175.53,39.83 ; D104.B6 176.34,40.64 ; 170.45,387.81 D116.B14 ; D116.B14 170.45,389.43 ; D116.B14 169.64,388.62 ; D116.B14 171.26,388.62 ; 56.15,405.59 D432.A1 ; D432.A1 56.15,407.21 ; D432.A1 55.34,406.4 ; D432.A1 56.96,406.4 ; UHC230.G3_8 45.19,351.79 ; UHC230.G3_8 44.38,352.6 ; UHC230.G3_8 44.38,350.98 ; UHC230.G3_8 43.57,351.79 ; D105.B16 274.59,102.41 ; D105.B16 273.78,101.6 ; D105.B16 275.4,101.6 ; D105.B16 274.59,100.79 ; 28.21,387.81 D232.B12 ; D232.B12 28.21,389.43 ; D232.B12 27.4,388.62 ; D232.B12 29.02,388.62 ; 19.18,357.64 UHC430.G1_11 ; UHC430.G1_11 18.37,358.45 ; UHC430.G1_11 19.99,358.45 ; UHC430.G1_11 19.18,359.26 ; 167.1,410.21 DPS2.C15 ; DPS2.C15 168.72,410.21 ; DPS2.C15 167.91,409.4 ; DPS2.C15 167.91,411.02 ; 184.88,101.6 D101.B10 ; D101.B10 186.5,101.6 ; D101.B10 185.69,100.79 ; D101.B10 185.69,102.41 ; 269.51,95.71 D105.A14 ; D105.A14 268.7,96.52 ; D105.A14 269.51,97.33 ; D105.A14 270.32,96.52 ; 18.37,348.29 UHC230.G4_11 ; UHC230.G4_11 19.18,347.48 ; UHC230.G4_11 19.99,348.29 ; UHC230.G4_11 19.18,349.1 ; D113.B11 178.07,331.01 ; D113.B11 177.26,330.2 ; D113.B11 178.07,329.39 ; D113.B11 178.88,330.2 ; 187.42,78.74 D102.B11 ; D102.B11 188.23,79.55 ; D102.B11 189.04,78.74 ; D102.B11 188.23,77.93 ; 124.73,400.51 D428.B3 ; D428.B3 123.92,401.32 ; D428.B3 125.54,401.32 ; D428.B3 124.73,402.13 ; DPS1.B11 262.7,16.51 ; DPS1.B11 261.89,17.32 ; DPS1.B11 261.08,16.51 ; DPS1.B11 261.89,15.7 ; D105.A13 266.97,94.79 ; D105.A13 266.16,93.98 ; D105.A13 267.78,93.98 ; D105.A13 266.97,93.17 ; D122.A10 112.03,77.01 ; D122.A10 112.03,75.39 ; D122.A10 111.22,76.2 ; D122.A10 112.84,76.2 ; 187.42,33.02 D104.A11 ; D104.A11 188.23,33.83 ; D104.A11 189.04,33.02 ; D104.A11 188.23,32.21 ; D108.B15 272.05,38.91 ; D108.B15 272.05,37.29 ; D108.B15 272.86,38.1 ; D108.B15 271.24,38.1 ; 106.14,332.74 CSDPS225.B10 ; CSDPS225.B10 106.95,333.55 ; CSDPS225.B10 107.76,332.74 ; CSDPS225.B10 106.95,331.93 ; D105.A2 239.03,97.33 ; D105.A2 239.03,95.71 ; D105.A2 238.22,96.52 ; D105.A2 239.84,96.52 ; D110.B5 267.78,350.52 ; D110.B5 266.97,349.71 ; D110.B5 266.97,351.33 ; D110.B5 266.16,350.52 ; D113.A1 203.47,336.09 ; D113.A1 202.66,335.28 ; D113.A1 204.28,335.28 ; D113.A1 203.47,334.47 ; D120.B8 33.29,41.45 ; D120.B8 32.48,40.64 ; D120.B8 34.1,40.64 ; D120.B8 33.29,39.83 ; 112.03,372.57 D227.A8 ; D227.A8 111.22,373.38 ; D227.A8 112.84,373.38 ; D227.A8 112.03,374.19 ; D231.A9 35.83,376.73 ; D231.A9 35.02,375.92 ; D231.A9 36.64,375.92 ; D231.A9 35.83,375.11 ; 195.85,60.15 D103.B14 ; D103.B14 195.85,61.77 ; D103.B14 195.04,60.96 ; D103.B14 196.66,60.96 ; 42.64,398.78 D432.B6 ; D432.B6 43.45,397.97 ; D432.B6 44.26,398.78 ; D432.B6 43.45,399.59 ; D428.A7 114.57,407.21 ; D428.A7 113.76,406.4 ; D428.A7 115.38,406.4 ; D428.A7 114.57,405.59 ; 195.85,75.39 D102.A14 ; D102.A14 196.66,76.2 ; D102.A14 195.85,77.01 ; D102.A14 195.04,76.2 ; D111.A8 260.16,373.38 ; D111.A8 259.35,372.57 ; D111.A8 258.54,373.38 ; D111.A8 259.35,374.19 ; D428.B7 115.38,401.32 ; D428.B7 113.76,401.32 ; D428.B7 114.57,402.13 ; D428.B7 114.57,400.51 ; 190.77,352.25 D114.A6 ; D114.A6 190.77,353.87 ; D114.A6 189.96,353.06 ; D114.A6 191.58,353.06 ; 89.17,32.21 D124.A1 ; D124.A1 89.17,33.83 ; D124.A1 89.98,33.02 ; D124.A1 88.36,33.02 ; D117.A12 44.26,96.52 ; D117.A12 43.45,97.33 ; D117.A12 42.64,96.52 ; D117.A12 43.45,95.71 ; 235.68,93.98 D105.A1 ; D105.A1 236.49,94.79 ; D105.A1 236.49,93.17 ; D105.A1 237.3,93.98 ; D115.A6 190.77,374.19 ; D115.A6 189.96,373.38 ; D115.A6 191.58,373.38 ; D115.A6 190.77,372.57 ; 16.07,358.45 UHC430.G1_12 ; UHC430.G1_12 16.88,359.26 ; UHC430.G1_12 17.69,358.45 ; UHC430.G1_12 16.88,357.64 ; D114.A7 189.04,355.6 ; D114.A7 188.23,356.41 ; D114.A7 188.23,354.79 ; D114.A7 187.42,355.6 ; 256,350.52 D110.B9 ; D110.B9 257.62,350.52 ; D110.B9 256.81,351.33 ; D110.B9 256.81,349.71 ; 182.34,355.6 D114.A9 ; D114.A9 183.96,355.6 ; D114.A9 183.15,356.41 ; D114.A9 183.15,354.79 ; D121.A5 100.14,93.98 ; D121.A5 99.33,94.79 ; D121.A5 98.52,93.98 ; D121.A5 99.33,93.17 ; 101.06,35.56 D124.A6 ; D124.A6 101.87,34.75 ; D124.A6 102.68,35.56 ; D124.A6 101.87,36.37 ; 42.64,101.6 D117.B12 ; D117.B12 43.45,100.79 ; D117.B12 44.26,101.6 ; D117.B12 43.45,102.41 ; D104.B15 198.39,38.91 ; D104.B15 198.39,37.29 ; D104.B15 197.58,38.1 ; D104.B15 199.2,38.1 ; 45.18,73.66 D118.A13 ; D118.A13 45.99,72.85 ; D118.A13 46.8,73.66 ; D118.A13 45.99,74.47 ; 129,360.68 CSDPS426.C1 ; CSDPS426.C1 129.81,361.49 ; CSDPS426.C1 130.62,360.68 ; CSDPS426.C1 129.81,359.87 ; 106.14,353.06 CSDPS226.B10 ; CSDPS226.B10 107.76,353.06 ; CSDPS226.B10 106.95,353.87 ; CSDPS226.B10 106.95,352.25 ; 20.59,77.93 D118.B3 ; D118.B3 21.4,78.74 ; D118.B3 20.59,79.55 ; D118.B3 19.78,78.74 ; D116.A14 171.26,393.7 ; D116.A14 169.64,393.7 ; D116.A14 170.45,394.51 ; D116.A14 170.45,392.89 ; 263.62,40.64 D108.B12 ; D108.B12 264.43,39.83 ; D108.B12 264.43,41.45 ; D108.B12 265.24,40.64 ; 17.24,373.38 D231.A16 ; D231.A16 18.05,374.19 ; D231.A16 18.86,373.38 ; D231.A16 18.05,372.57 ; 123.92,360.68 CSDPS426.C3 ; CSDPS426.C3 125.54,360.68 ; CSDPS426.C3 124.73,359.87 ; CSDPS426.C3 124.73,361.49 ; D101.B8 181.42,101.6 ; D101.B8 180.61,102.41 ; D101.B8 179.8,101.6 ; D101.B8 180.61,100.79 ; UHC430.G2_13 44.38,359.26 ; UHC430.G2_13 43.57,358.45 ; UHC430.G2_13 45.19,358.45 ; UHC430.G2_13 44.38,357.64 ; 94.25,339.55 CSDPS425.C15 ; CSDPS425.C15 94.25,341.17 ; CSDPS425.C15 93.44,340.36 ; CSDPS425.C15 95.06,340.36 ; 169.64,55.88 D103.A4 ; D103.A4 171.26,55.88 ; D103.A4 170.45,55.07 ; D103.A4 170.45,56.69 ; D115.B4 196.66,368.3 ; D115.B4 195.04,368.3 ; D115.B4 195.85,369.11 ; D115.B4 195.85,367.49 ; D427.A14 96.79,384.35 ; D427.A14 96.79,382.73 ; D427.A14 97.6,383.54 ; D427.A14 95.98,383.54 ; CSDPS426.C13 100.14,360.68 ; CSDPS426.C13 99.33,359.87 ; CSDPS426.C13 99.33,361.49 ; CSDPS426.C13 98.52,360.68 ; 203.47,349.71 D114.B1 ; D114.B1 202.66,350.52 ; D114.B1 204.28,350.52 ; D114.B1 203.47,351.33 ; 129,391.16 D228.B1 ; D228.B1 129.81,390.35 ; D228.B1 130.62,391.16 ; D228.B1 129.81,391.97 ; 40.91,329.39 CSDPS229.C7 ; CSDPS229.C7 41.72,330.2 ; CSDPS229.C7 40.1,330.2 ; CSDPS229.C7 40.91,331.01 ; 121.38,40.64 D124.B14 ; D124.B14 122.19,41.45 ; D124.B14 122.19,39.83 ; D124.B14 123,40.64 ; 268.7,35.56 D108.A14 ; D108.A14 270.32,35.56 ; D108.A14 269.51,34.75 ; D108.A14 269.51,36.37 ; 94.25,400.51 D428.B15 ; D428.B15 93.44,401.32 ; D428.B15 94.25,402.13 ; D428.B15 95.06,401.32 ; D110.B2 274.59,348.79 ; D110.B2 275.4,347.98 ; D110.B2 273.78,347.98 ; D110.B2 274.59,347.17 ; D428.B4 122.19,399.59 ; D428.B4 122.19,397.97 ; D428.B4 123,398.78 ; D428.B4 121.38,398.78 ; 43.45,39.83 D120.B12 ; D120.B12 44.26,40.64 ; D120.B12 43.45,41.45 ; D120.B12 42.64,40.64 ; 40.1,58.42 D119.B11 ; D119.B11 40.91,59.23 ; D119.B11 41.72,58.42 ; D119.B11 40.91,57.61 ; 20.59,329.39 CSDPS229.C15 ; CSDPS229.C15 20.59,331.01 ; CSDPS229.C15 19.78,330.2 ; CSDPS229.C15 21.4,330.2 ; 251.73,354.79 D110.A11 ; D110.A11 251.73,356.41 ; D110.A11 252.54,355.6 ; D110.A11 250.92,355.6 ; D119.A8 34.1,55.88 ; D119.A8 33.29,55.07 ; D119.A8 32.48,55.88 ; D119.A8 33.29,56.69 ; DPS2.A01 203.47,416.1 ; DPS2.A01 203.47,414.48 ; DPS2.A01 204.28,415.29 ; DPS2.A01 202.66,415.29 ; 258.54,332.74 D109.A8 ; D109.A8 259.35,331.93 ; D109.A8 260.16,332.74 ; D109.A8 259.35,333.55 ; 22.32,332.74 CSDPS229.B14 ; CSDPS229.B14 23.13,331.93 ; CSDPS229.B14 23.94,332.74 ; CSDPS229.B14 23.13,333.55 ; 51.07,390.35 D232.B3 ; D232.B3 51.07,391.97 ; D232.B3 50.26,391.16 ; D232.B3 51.88,391.16 ; D118.A14 48.53,77.01 ; D118.A14 47.72,76.2 ; D118.A14 48.53,75.39 ; D118.A14 49.34,76.2 ; D112.A6 264.43,394.51 ; D112.A6 263.62,393.7 ; D112.A6 265.24,393.7 ; D112.A6 264.43,392.89 ; 195.04,393.7 D116.A4 ; D116.A4 195.85,394.51 ; D116.A4 196.66,393.7 ; D116.A4 195.85,392.89 ; 174.72,332.74 D113.A12 ; D113.A12 175.53,333.55 ; D113.A12 176.34,332.74 ; D113.A12 175.53,331.93 ; 124.73,13.16 DPS3.A15 ; DPS3.A15 124.73,14.78 ; DPS3.A15 123.92,13.97 ; DPS3.A15 125.54,13.97 ; D107.B8 254.27,61.77 ; D107.B8 254.27,60.15 ; D107.B8 255.08,60.96 ; D107.B8 253.46,60.96 ; D105.B13 266.97,99.87 ; D105.B13 266.97,98.25 ; D105.B13 266.16,99.06 ; D105.B13 267.78,99.06 ; 101.06,342.9 CSDPS425.B12 ; CSDPS425.B12 101.87,342.09 ; CSDPS425.B12 101.87,343.71 ; CSDPS425.B12 102.68,342.9 ; 180.61,80.47 D102.B8 ; D102.B8 181.42,81.28 ; D102.B8 179.8,81.28 ; D102.B8 180.61,82.09 ; D231.A4 49.34,373.38 ; D231.A4 48.53,372.57 ; D231.A4 47.72,373.38 ; D231.A4 48.53,374.19 ; 90.9,101.6 D121.B2 ; D121.B2 92.52,101.6 ; D121.B2 91.71,102.41 ; D121.B2 91.71,100.79 ; D427.B11 105.22,381 ; D427.B11 104.41,381.81 ; D427.B11 103.6,381 ; D427.B11 104.41,380.19 ; 14.92,363.7 UHC430.G1_5 ; UHC430.G1_5 15.73,364.51 ; UHC430.G1_5 15.73,362.89 ; UHC430.G1_5 16.54,363.7 ; 28.21,331.93 CSDPS229.B12 ; CSDPS229.B12 27.4,332.74 ; CSDPS229.B12 28.21,333.55 ; CSDPS229.B12 29.02,332.74 ; D106.A7 252.54,73.66 ; D106.A7 250.92,73.66 ; D106.A7 251.73,72.85 ; D106.A7 251.73,74.47 ; D117.B16 53.61,102.41 ; D117.B16 52.8,101.6 ; D117.B16 54.42,101.6 ; D117.B16 53.61,100.79 ; 197.58,335.28 D113.A3 ; D113.A3 198.39,334.47 ; D113.A3 198.39,336.09 ; D113.A3 199.2,335.28 ; D112.B2 275.4,388.62 ; D112.B2 274.59,389.43 ; D112.B2 273.78,388.62 ; D112.B2 274.59,387.81 ; 14.7,386.08 D431.A17 ; D431.A17 15.51,385.27 ; D431.A17 16.32,386.08 ; D431.A17 15.51,386.89 ; D112.B13 247.46,391.16 ; D112.B13 246.65,390.35 ; D112.B13 245.84,391.16 ; D112.B13 246.65,391.97 ; 99.33,52.53 D123.A5 ; D123.A5 99.33,54.15 ; D123.A5 100.14,53.34 ; D123.A5 98.52,53.34 ; CSDPS229.B6 43.45,333.55 ; CSDPS229.B6 43.45,331.93 ; CSDPS229.B6 44.26,332.74 ; CSDPS229.B6 42.64,332.74 ; 192.5,78.74 D102.B13 ; D102.B13 193.31,79.55 ; D102.B13 193.31,77.93 ; D102.B13 194.12,78.74 ; 99.33,370.03 D227.B13 ; D227.B13 100.14,370.84 ; D227.B13 98.52,370.84 ; D227.B13 99.33,371.65 ; D428.A17 89.17,407.21 ; D428.A17 89.98,406.4 ; D428.A17 88.36,406.4 ; D428.A17 89.17,405.59 ; D101.B3 168.72,99.06 ; D101.B3 167.1,99.06 ; D101.B3 167.91,98.25 ; D101.B3 167.91,99.87 ; 18.05,34.75 D120.A2 ; D120.A2 18.05,36.37 ; D120.A2 18.86,35.56 ; D120.A2 17.24,35.56 ; D232.A9 36.64,396.24 ; D232.A9 35.02,396.24 ; D232.A9 35.83,395.43 ; D232.A9 35.83,397.05 ; 169.64,368.3 D115.B14 ; D115.B14 170.45,367.49 ; D115.B14 171.26,368.3 ; D115.B14 170.45,369.11 ; 256,99.06 D105.B9 ; D105.B9 256.81,99.87 ; D105.B9 257.62,99.06 ; D105.B9 256.81,98.25 ; D118.A7 30.75,74.47 ; D118.A7 29.94,73.66 ; D118.A7 31.56,73.66 ; D118.A7 30.75,72.85 ; 245.84,38.1 D108.B5 ; D108.B5 246.65,38.91 ; D108.B5 246.65,37.29 ; D108.B5 247.46,38.1 ; D122.B15 124.73,79.55 ; D122.B15 123.92,78.74 ; D122.B15 124.73,77.93 ; D122.B15 125.54,78.74 ; 38.37,95.71 D117.A10 ; D117.A10 37.56,96.52 ; D117.A10 38.37,97.33 ; D117.A10 39.18,96.52 ; D227.B3 124.73,371.65 ; D227.B3 125.54,370.84 ; D227.B3 124.73,370.03 ; D227.B3 123.92,370.84 ; D231.A14 23.13,374.19 ; D231.A14 23.94,373.38 ; D231.A14 22.32,373.38 ; D231.A14 23.13,372.57 ; 167.1,53.34 D103.A3 ; D103.A3 168.72,53.34 ; D103.A3 167.91,54.15 ; D103.A3 167.91,52.53 ; D104.A3 167.91,33.83 ; D104.A3 167.1,33.02 ; D104.A3 168.72,33.02 ; D104.A3 167.91,32.21 ; 236.49,77.93 D106.B1 ; D106.B1 235.68,78.74 ; D106.B1 236.49,79.55 ; D106.B1 237.3,78.74 ; D108.B10 259.35,41.45 ; D108.B10 259.35,39.83 ; D108.B10 258.54,40.64 ; D108.B10 260.16,40.64 ; D104.A16 200.93,36.37 ; D104.A16 201.74,35.56 ; D104.A16 200.93,34.75 ; D104.A16 200.12,35.56 ; 90.9,378.46 D427.B16 ; D427.B16 91.71,377.65 ; D427.B16 91.71,379.27 ; D427.B16 92.52,378.46 ; 190.77,60.15 D103.B12 ; D103.B12 191.58,60.96 ; D103.B12 189.96,60.96 ; D103.B12 190.77,61.77 ; 35.83,385.27 D431.A9 ; D431.A9 35.02,386.08 ; D431.A9 35.83,386.89 ; D431.A9 36.64,386.08 ; 99.33,405.59 D428.A13 ; D428.A13 99.33,407.21 ; D428.A13 98.52,406.4 ; D428.A13 100.14,406.4 ; 38.37,60.15 D119.B10 ; D119.B10 38.37,61.77 ; D119.B10 39.18,60.96 ; D119.B10 37.56,60.96 ; 96.79,352.25 CSDPS226.B14 ; CSDPS226.B14 96.79,353.87 ; CSDPS226.B14 95.98,353.06 ; CSDPS226.B14 97.6,353.06 ; 53.36,147.98 KS3.6 ; KS3.6 54.47,149.1 ; KS3.6 53.36,150.22 ; KS3.6 52.24,149.1 ; 19.78,412.75 DPS8.B15 ; DPS8.B15 21.4,412.75 ; DPS8.B15 20.59,411.94 ; DPS8.B15 20.59,413.56 ; 259.35,75.39 D106.A10 ; D106.A10 259.35,77.01 ; D106.A10 260.16,76.2 ; D106.A10 258.54,76.2 ; 261.89,349.71 D110.B7 ; D110.B7 261.89,351.33 ; D110.B7 261.08,350.52 ; D110.B7 262.7,350.52 ; 104.41,93.17 D121.A7 ; D121.A7 105.22,93.98 ; D121.A7 104.41,94.79 ; D121.A7 103.6,93.98 ; 123.92,53.34 D123.A15 ; D123.A15 124.73,52.53 ; D123.A15 124.73,54.15 ; D123.A15 125.54,53.34 ; 30.75,32.21 D120.A7 ; D120.A7 30.75,33.83 ; D120.A7 29.94,33.02 ; D120.A7 31.56,33.02 ; 123.92,340.36 CSDPS425.C3 ; CSDPS425.C3 125.54,340.36 ; CSDPS425.C3 124.73,339.55 ; CSDPS425.C3 124.73,341.17 ; 122.19,403.05 D428.A4 ; D428.A4 123,403.86 ; D428.A4 122.19,404.67 ; D428.A4 121.38,403.86 ; D104.A12 191.58,35.56 ; D104.A12 189.96,35.56 ; D104.A12 190.77,34.75 ; D104.A12 190.77,36.37 ; 127.27,331.93 CSDPS225.B2 ; CSDPS225.B2 126.46,332.74 ; CSDPS225.B2 128.08,332.74 ; CSDPS225.B2 127.27,333.55 ; 167.1,58.42 D103.B3 ; D103.B3 167.91,59.23 ; D103.B3 168.72,58.42 ; D103.B3 167.91,57.61 ; 24.86,406.4 D432.A13 ; D432.A13 25.67,407.21 ; D432.A13 25.67,405.59 ; D432.A13 26.48,406.4 ; 18.03,349.23 UHC230.G4_9 ; UHC230.G4_9 17.22,350.04 ; UHC230.G4_9 18.03,350.85 ; UHC230.G4_9 18.84,350.04 ; 117.11,362.41 CSDPS426.B6 ; CSDPS426.B6 117.92,363.22 ; CSDPS426.B6 117.11,364.03 ; CSDPS426.B6 116.3,363.22 ; D431.A6 44.26,383.54 ; D431.A6 43.45,384.35 ; D431.A6 42.64,383.54 ; D431.A6 43.45,382.73 ; 182.34,391.16 D116.B9 ; D116.B9 183.96,391.16 ; D116.B9 183.15,390.35 ; D116.B9 183.15,391.97 ; 44.72,353.54 UHC230.G3_5 ; UHC230.G3_5 46.34,353.54 ; UHC230.G3_5 45.53,354.35 ; UHC230.G3_5 45.53,352.73 ; D107.A16 274.59,56.69 ; D107.A16 273.78,55.88 ; D107.A16 275.4,55.88 ; D107.A16 274.59,55.07 ; D228.A13 99.33,397.05 ; D228.A13 98.52,396.24 ; D228.A13 99.33,395.43 ; D228.A13 100.14,396.24 ; 103.6,370.84 D227.B11 ; D227.B11 105.22,370.84 ; D227.B11 104.41,370.03 ; D227.B11 104.41,371.65 ; D116.A16 165.37,394.51 ; D116.A16 166.18,393.7 ; D116.A16 165.37,392.89 ; D116.A16 164.56,393.7 ; 126.46,81.28 D122.B16 ; D122.B16 127.27,82.09 ; D122.B16 128.08,81.28 ; D122.B16 127.27,80.47 ; D122.B6 101.87,82.09 ; D122.B6 101.06,81.28 ; D122.B6 102.68,81.28 ; D122.B6 101.87,80.47 ; 261.89,72.85 D106.A11 ; D106.A11 261.08,73.66 ; D106.A11 262.7,73.66 ; D106.A11 261.89,74.47 ; 48.98,361.14 UHC430.G2_6 ; UHC430.G2_6 48.98,362.76 ; UHC430.G2_6 49.79,361.95 ; UHC430.G2_6 48.17,361.95 ; D427.B1 130.62,381 ; D427.B1 129.81,380.19 ; D427.B1 129.81,381.81 ; D427.B1 129,381 ; DPS8.A05 45.99,416.1 ; DPS8.A05 46.8,415.29 ; DPS8.A05 45.18,415.29 ; DPS8.A05 45.99,414.48 ; 164.56,347.98 D114.B16 ; D114.B16 166.18,347.98 ; D114.B16 165.37,348.79 ; D114.B16 165.37,347.17 ; 249.19,100.79 D105.B6 ; D105.B6 250,101.6 ; D105.B6 248.38,101.6 ; D105.B6 249.19,102.41 ; D103.A11 189.04,53.34 ; D103.A11 188.23,52.53 ; D103.A11 188.23,54.15 ; D103.A11 187.42,53.34 ; 129,375.92 D227.A1 ; D227.A1 129.81,375.11 ; D227.A1 130.62,375.92 ; D227.A1 129.81,376.73 ; 129,386.08 D427.A1 ; D427.A1 129.81,385.27 ; D427.A1 129.81,386.89 ; D427.A1 130.62,386.08 ; 177.26,53.34 D103.A7 ; D103.A7 178.88,53.34 ; D103.A7 178.07,52.53 ; D103.A7 178.07,54.15 ; D123.B16 127.27,61.77 ; D123.B16 127.27,60.15 ; D123.B16 126.46,60.96 ; D123.B16 128.08,60.96 ; D227.A12 102.68,373.38 ; D227.A12 101.87,374.19 ; D227.A12 101.06,373.38 ; D227.A12 101.87,372.57 ; 253.46,353.06 D110.A10 ; D110.A10 254.27,352.25 ; D110.A10 254.27,353.87 ; D110.A10 255.08,353.06 ; 101.06,353.06 CSDPS226.B12 ; CSDPS226.B12 101.87,352.25 ; CSDPS226.B12 101.87,353.87 ; CSDPS226.B12 102.68,353.06 ; D228.B5 120.46,391.16 ; D228.B5 119.65,391.97 ; D228.B5 118.84,391.16 ; D228.B5 119.65,390.35 ; D102.B7 178.88,78.74 ; D102.B7 177.26,78.74 ; D102.B7 178.07,79.55 ; D102.B7 178.07,77.93 ; 45.18,386.08 D431.A5 ; D431.A5 45.99,386.89 ; D431.A5 46.8,386.08 ; D431.A5 45.99,385.27 ; 46.68,361.14 UHC430.G2 ; UHC430.G2 45.87,361.95 ; UHC430.G2 47.49,361.95 ; UHC430.G2 46.68,362.76 ; D227.B14 97.6,368.3 ; D227.B14 96.79,369.11 ; D227.B14 96.79,367.49 ; D227.B14 95.98,368.3 ; 35.02,401.32 D432.B9 ; D432.B9 36.64,401.32 ; D432.B9 35.83,400.51 ; D432.B9 35.83,402.13 ; D428.A1 130.62,406.4 ; D428.A1 129.81,407.21 ; D428.A1 129,406.4 ; D428.A1 129.81,405.59 ; 96.79,387.81 D228.B14 ; D228.B14 97.6,388.62 ; D228.B14 96.79,389.43 ; D228.B14 95.98,388.62 ; 112.03,100.79 D121.B10 ; D121.B10 111.22,101.6 ; D121.B10 112.84,101.6 ; D121.B10 112.03,102.41 ; D231.A10 34.1,373.38 ; D231.A10 33.29,374.19 ; D231.A10 32.48,373.38 ; D231.A10 33.29,372.57 ; 277.13,390.35 D112.B1 ; D112.B1 277.13,391.97 ; D112.B1 276.32,391.16 ; D112.B1 277.94,391.16 ; D101.B15 199.2,99.06 ; D101.B15 198.39,98.25 ; D101.B15 198.39,99.87 ; D101.B15 197.58,99.06 ; 93.44,93.98 D121.A3 ; D121.A3 94.25,93.17 ; D121.A3 94.25,94.79 ; D121.A3 95.06,93.98 ; 183.15,52.53 D103.A9 ; D103.A9 183.96,53.34 ; D103.A9 183.15,54.15 ; D103.A9 182.34,53.34 ; 106.95,39.83 D124.B8 ; D124.B8 106.95,41.45 ; D124.B8 107.76,40.64 ; D124.B8 106.14,40.64 ; D115.A16 165.37,374.19 ; D115.A16 164.56,373.38 ; D115.A16 165.37,372.57 ; D115.A16 166.18,373.38 ; 18.05,392.89 D232.A16 ; D232.A16 17.24,393.7 ; D232.A16 18.05,394.51 ; D232.A16 18.86,393.7 ; D432.A12 28.21,404.67 ; D432.A12 28.21,403.05 ; D432.A12 29.02,403.86 ; D432.A12 27.4,403.86 ; 250.92,53.34 D107.A7 ; D107.A7 252.54,53.34 ; D107.A7 251.73,52.53 ; D107.A7 251.73,54.15 ; 162.83,37.29 D104.B1 ; D104.B1 162.83,38.91 ; D104.B1 162.02,38.1 ; D104.B1 163.64,38.1 ; D121.A13 120.46,93.98 ; D121.A13 119.65,93.17 ; D121.A13 118.84,93.98 ; D121.A13 119.65,94.79 ; D231.B5 46.8,370.84 ; D231.B5 45.99,371.65 ; D231.B5 45.99,370.03 ; D231.B5 45.18,370.84 ; D105.B10 260.16,101.6 ; D105.B10 258.54,101.6 ; D105.B10 259.35,102.41 ; D105.B10 259.35,100.79 ; 264.43,60.15 D107.B12 ; D107.B12 263.62,60.96 ; D107.B12 264.43,61.77 ; D107.B12 265.24,60.96 ; 109.49,77.93 D122.B9 ; D122.B9 110.3,78.74 ; D122.B9 109.49,79.55 ; D122.B9 108.68,78.74 ; 175.53,352.25 D114.A12 ; D114.A12 175.53,353.87 ; D114.A12 176.34,353.06 ; D114.A12 174.72,353.06 ; D109.B9 257.62,330.2 ; D109.B9 256.81,331.01 ; D109.B9 256,330.2 ; D109.B9 256.81,329.39 ; 162.83,57.61 D103.B1 ; D103.B1 162.02,58.42 ; D103.B1 162.83,59.23 ; D103.B1 163.64,58.42 ; 106.14,378.46 D427.B10 ; D427.B10 106.95,379.27 ; D427.B10 106.95,377.65 ; D427.B10 107.76,378.46 ; 51.07,32.21 D120.A15 ; D120.A15 50.26,33.02 ; D120.A15 51.07,33.83 ; D120.A15 51.88,33.02 ; 90.9,393.7 D228.A16 ; D228.A16 92.52,393.7 ; D228.A16 91.71,394.51 ; D228.A16 91.71,392.89 ; D114.B6 190.77,348.79 ; D114.B6 189.96,347.98 ; D114.B6 190.77,347.17 ; D114.B6 191.58,347.98 ; 239.03,372.57 D111.A16 ; D111.A16 239.84,373.38 ; D111.A16 239.03,374.19 ; D111.A16 238.22,373.38 ; D232.A2 54.42,393.7 ; D232.A2 53.61,392.89 ; D232.A2 52.8,393.7 ; D232.A2 53.61,394.51 ; 18.37,351.79 UHC230.G4_6 ; UHC230.G4_6 19.99,351.79 ; UHC230.G4_6 19.18,352.6 ; UHC230.G4_6 19.18,350.98 ; D114.A4 195.85,353.87 ; D114.A4 196.66,353.06 ; D114.A4 195.04,353.06 ; D114.A4 195.85,352.25 ; D106.A9 257.62,73.66 ; D106.A9 256.81,72.85 ; D106.A9 256,73.66 ; D106.A9 256.81,74.47 ; D109.B14 244.92,327.66 ; D109.B14 244.11,328.47 ; D109.B14 244.11,326.85 ; D109.B14 243.3,327.66 ; 240.76,330.2 D109.B15 ; D109.B15 241.57,331.01 ; D109.B15 241.57,329.39 ; D109.B15 242.38,330.2 ; D118.B4 23.13,82.09 ; D118.B4 23.13,80.47 ; D118.B4 23.94,81.28 ; D118.B4 22.32,81.28 ; D109.B6 265.24,327.66 ; D109.B6 264.43,328.47 ; D109.B6 264.43,326.85 ; D109.B6 263.62,327.66 ; 111.22,368.3 D227.B8 ; D227.B8 112.03,367.49 ; D227.B8 112.03,369.11 ; D227.B8 112.84,368.3 ; 103.6,360.68 CSDPS426.C11 ; CSDPS426.C11 104.41,359.87 ; CSDPS426.C11 104.41,361.49 ; CSDPS426.C11 105.22,360.68 ; D427.A11 104.41,386.89 ; D427.A11 105.22,386.08 ; D427.A11 104.41,385.27 ; D427.A11 103.6,386.08 ; D427.A10 106.95,384.35 ; D427.A10 107.76,383.54 ; D427.A10 106.95,382.73 ; D427.A10 106.14,383.54 ; 113.76,78.74 D122.B11 ; D122.B11 114.57,79.55 ; D122.B11 115.38,78.74 ; D122.B11 114.57,77.93 ; 22.32,393.7 D232.A14 ; D232.A14 23.13,392.89 ; D232.A14 23.94,393.7 ; D232.A14 23.13,394.51 ; 245.84,99.06 D105.B5 ; D105.B5 246.65,99.87 ; D105.B5 246.65,98.25 ; D105.B5 247.46,99.06 ; D428.B12 101.87,399.59 ; D428.B12 101.06,398.78 ; D428.B12 102.68,398.78 ; D428.B12 101.87,397.97 ; CSDPS226.C5 119.65,351.33 ; CSDPS226.C5 120.46,350.52 ; CSDPS226.C5 119.65,349.71 ; CSDPS226.C5 118.84,350.52 ; 249.19,34.75 D108.A6 ; D108.A6 248.38,35.56 ; D108.A6 250,35.56 ; D108.A6 249.19,36.37 ; D115.B9 183.15,371.65 ; D115.B9 183.15,370.03 ; D115.B9 183.96,370.84 ; D115.B9 182.34,370.84 ; 190.77,326.85 D113.B6 ; D113.B6 190.77,328.47 ; D113.B6 189.96,327.66 ; D113.B6 191.58,327.66 ; 129,340.36 CSDPS425.C1 ; CSDPS425.C1 130.62,340.36 ; CSDPS425.C1 129.81,341.17 ; CSDPS425.C1 129.81,339.55 ; D111.B6 264.43,369.11 ; D111.B6 263.62,368.3 ; D111.B6 264.43,367.49 ; D111.B6 265.24,368.3 ; D227.B17 89.17,371.65 ; D227.B17 88.36,370.84 ; D227.B17 89.98,370.84 ; D227.B17 89.17,370.03 ; D119.B9 35.83,59.23 ; D119.B9 36.64,58.42 ; D119.B9 35.02,58.42 ; D119.B9 35.83,57.61 ; D432.A4 48.53,404.67 ; D432.A4 47.72,403.86 ; D432.A4 48.53,403.05 ; D432.A4 49.34,403.86 ; D104.B16 200.93,41.45 ; D104.B16 200.93,39.83 ; D104.B16 201.74,40.64 ; D104.B16 200.12,40.64 ; 99.33,13.16 DPS3.A05 ; DPS3.A05 99.33,14.78 ; DPS3.A05 98.52,13.97 ; DPS3.A05 100.14,13.97 ; D116.B13 173.8,391.16 ; D116.B13 172.99,390.35 ; D116.B13 172.18,391.16 ; D116.B13 172.99,391.97 ; D231.B6 44.26,368.3 ; D231.B6 43.45,369.11 ; D231.B6 42.64,368.3 ; D231.B6 43.45,367.49 ; D104.B13 194.12,38.1 ; D104.B13 193.31,38.91 ; D104.B13 192.5,38.1 ; D104.B13 193.31,37.29 ; D104.A15 199.2,33.02 ; D104.A15 198.39,32.21 ; D104.A15 197.58,33.02 ; D104.A15 198.39,33.83 ; CSDPS229.B8 38.37,333.55 ; CSDPS229.B8 39.18,332.74 ; CSDPS229.B8 38.37,331.93 ; CSDPS229.B8 37.56,332.74 ; 103.6,330.2 CSDPS225.C11 ; CSDPS225.C11 105.22,330.2 ; CSDPS225.C11 104.41,331.01 ; CSDPS225.C11 104.41,329.39 ; 114.57,339.55 CSDPS425.C7 ; CSDPS425.C7 113.76,340.36 ; CSDPS425.C7 114.57,341.17 ; CSDPS425.C7 115.38,340.36 ; 96.79,100.79 D121.B4 ; D121.B4 97.6,101.6 ; D121.B4 95.98,101.6 ; D121.B4 96.79,102.41 ; 271.24,396.24 D112.A3 ; D112.A3 272.05,395.43 ; D112.A3 272.86,396.24 ; D112.A3 272.05,397.05 ; D432.A8 38.37,404.67 ; D432.A8 39.18,403.86 ; D432.A8 38.37,403.05 ; D432.A8 37.56,403.86 ; D227.A3 124.73,376.73 ; D227.A3 124.73,375.11 ; D227.A3 125.54,375.92 ; D227.A3 123.92,375.92 ; D109.A7 261.89,336.09 ; D109.A7 261.89,334.47 ; D109.A7 261.08,335.28 ; D109.A7 262.7,335.28 ; 113.76,381 D427.B7 ; D427.B7 114.57,381.81 ; D427.B7 115.38,381 ; D427.B7 114.57,380.19 ; 23.13,342.09 CSDPS429.B14 ; CSDPS429.B14 22.32,342.9 ; CSDPS429.B14 23.94,342.9 ; CSDPS429.B14 23.13,343.71 ; 25.67,72.85 D118.A5 ; D118.A5 26.48,73.66 ; D118.A5 25.67,74.47 ; D118.A5 24.86,73.66 ; 99.33,72.85 D122.A5 ; D122.A5 99.33,74.47 ; D122.A5 98.52,73.66 ; D122.A5 100.14,73.66 ; 200.93,60.15 D103.B16 ; D103.B16 201.74,60.96 ; D103.B16 200.12,60.96 ; D103.B16 200.93,61.77 ; 261.08,19.05 DPS1.C11 ; DPS1.C11 261.89,18.24 ; DPS1.C11 262.7,19.05 ; DPS1.C11 261.89,19.86 ; D108.B9 256.81,38.91 ; D108.B9 256.81,37.29 ; D108.B9 257.62,38.1 ; D108.B9 256,38.1 ; D109.A4 269.51,333.55 ; D109.A4 268.7,332.74 ; D109.A4 270.32,332.74 ; D109.A4 269.51,331.93 ; D119.A2 18.05,56.69 ; D119.A2 18.05,55.07 ; D119.A2 17.24,55.88 ; D119.A2 18.86,55.88 ; 14.7,53.34 D119.A1 ; D119.A1 15.51,52.53 ; D119.A1 15.51,54.15 ; D119.A1 16.32,53.34 ; D227.A2 127.27,374.19 ; D227.A2 127.27,372.57 ; D227.A2 128.08,373.38 ; D227.A2 126.46,373.38 ; D111.A6 264.43,374.19 ; D111.A6 264.43,372.57 ; D111.A6 265.24,373.38 ; D111.A6 263.62,373.38 ; D116.A8 185.69,394.51 ; D116.A8 185.69,392.89 ; D116.A8 184.88,393.7 ; D116.A8 186.5,393.7 ; D427.B4 123,378.46 ; D427.B4 122.19,379.27 ; D427.B4 122.19,377.65 ; D427.B4 121.38,378.46 ; D121.B8 107.76,101.6 ; D121.B8 106.14,101.6 ; D121.B8 106.95,100.79 ; D121.B8 106.95,102.41 ; 17.24,378.46 D431.B16 ; D431.B16 18.05,379.27 ; D431.B16 18.86,378.46 ; D431.B16 18.05,377.65 ; D111.A13 246.65,376.73 ; D111.A13 247.46,375.92 ; D111.A13 245.84,375.92 ; D111.A13 246.65,375.11 ; 167.1,350.52 D114.B15 ; D114.B15 167.91,349.71 ; D114.B15 167.91,351.33 ; D114.B15 168.72,350.52 ; 126.46,393.7 D228.A2 ; D228.A2 128.08,393.7 ; D228.A2 127.27,392.89 ; D228.A2 127.27,394.51 ; CSDPS429.C5 46.8,340.36 ; CSDPS429.C5 45.99,341.17 ; CSDPS429.C5 45.99,339.55 ; CSDPS429.C5 45.18,340.36 ; 123.92,33.02 D124.A15 ; D124.A15 124.73,33.83 ; D124.A15 124.73,32.21 ; D124.A15 125.54,33.02 ; DPS3.A01 89.17,14.78 ; DPS3.A01 89.17,13.16 ; DPS3.A01 88.36,13.97 ; DPS3.A01 89.98,13.97 ; D120.A9 35.83,33.83 ; D120.A9 36.64,33.02 ; D120.A9 35.02,33.02 ; D120.A9 35.83,32.21 ; 264.43,75.39 D106.A12 ; D106.A12 263.62,76.2 ; D106.A12 265.24,76.2 ; D106.A12 264.43,77.01 ; 40.91,390.35 D232.B7 ; D232.B7 40.1,391.16 ; D232.B7 41.72,391.16 ; D232.B7 40.91,391.97 ; 126.46,55.88 D123.A16 ; D123.A16 128.08,55.88 ; D123.A16 127.27,55.07 ; D123.A16 127.27,56.69 ; 101.87,331.93 CSDPS225.B12 ; CSDPS225.B12 101.06,332.74 ; CSDPS225.B12 101.87,333.55 ; CSDPS225.B12 102.68,332.74 ; 256,53.34 D107.A9 ; D107.A9 257.62,53.34 ; D107.A9 256.81,52.53 ; D107.A9 256.81,54.15 ; 96.79,95.71 D121.A4 ; D121.A4 96.79,97.33 ; D121.A4 97.6,96.52 ; D121.A4 95.98,96.52 ; D122.B14 123,81.28 ; D122.B14 122.19,80.47 ; D122.B14 121.38,81.28 ; D122.B14 122.19,82.09 ; UHC230.G3_13 45.19,348.29 ; UHC230.G3_13 43.57,348.29 ; UHC230.G3_13 44.38,347.48 ; UHC230.G3_13 44.38,349.1 ; UHC230.G4_5 16.54,353.54 ; UHC230.G4_5 15.73,352.73 ; UHC230.G4_5 15.73,354.35 ; UHC230.G4_5 14.92,353.54 ; D428.A8 112.84,403.86 ; D428.A8 111.22,403.86 ; D428.A8 112.03,404.67 ; D428.A8 112.03,403.05 ; 192.5,391.16 D116.B5 ; D116.B5 194.12,391.16 ; D116.B5 193.31,391.97 ; D116.B5 193.31,390.35 ; 174.72,76.2 D102.A6 ; D102.A6 176.34,76.2 ; D102.A6 175.53,75.39 ; D102.A6 175.53,77.01 ; 95.98,40.64 D124.B4 ; D124.B4 97.6,40.64 ; D124.B4 96.79,41.45 ; D124.B4 96.79,39.83 ; 193.31,334.47 D113.A5 ; D113.A5 192.5,335.28 ; D113.A5 193.31,336.09 ; D113.A5 194.12,335.28 ; 15.51,77.93 D118.B1 ; D118.B1 16.32,78.74 ; D118.B1 14.7,78.74 ; D118.B1 15.51,79.55 ; 243.3,55.88 D107.A4 ; D107.A4 244.11,55.07 ; D107.A4 244.11,56.69 ; D107.A4 244.92,55.88 ; 167.1,93.98 D101.A3 ; D101.A3 168.72,93.98 ; D101.A3 167.91,94.79 ; D101.A3 167.91,93.17 ; 18.05,95.71 D117.A2 ; D117.A2 18.86,96.52 ; D117.A2 18.05,97.33 ; D117.A2 17.24,96.52 ; D112.B14 244.11,389.43 ; D112.B14 243.3,388.62 ; D112.B14 244.92,388.62 ; D112.B14 244.11,387.81 ; UHC430.G2_8 45.19,361.95 ; UHC430.G2_8 43.57,361.95 ; UHC430.G2_8 44.38,361.14 ; UHC430.G2_8 44.38,362.76 ; 28.21,55.07 D119.A6 ; D119.A6 27.4,55.88 ; D119.A6 29.02,55.88 ; D119.A6 28.21,56.69 ; 165.37,331.93 D113.A16 ; D113.A16 164.56,332.74 ; D113.A16 165.37,333.55 ; D113.A16 166.18,332.74 ; 104.41,77.93 D122.B7 ; D122.B7 104.41,79.55 ; D122.B7 103.6,78.74 ; D122.B7 105.22,78.74 ; D122.A16 128.08,76.2 ; D122.A16 127.27,75.39 ; D122.A16 126.46,76.2 ; D122.A16 127.27,77.01 ; D105.A6 249.19,97.33 ; D105.A6 248.38,96.52 ; D105.A6 249.19,95.71 ; D105.A6 250,96.52 ; D115.B13 173.8,370.84 ; D115.B13 172.18,370.84 ; D115.B13 172.99,370.03 ; D115.B13 172.99,371.65 ; D232.B17 16.32,391.16 ; D232.B17 15.51,391.97 ; D232.B17 14.7,391.16 ; D232.B17 15.51,390.35 ; D431.B9 35.83,381.81 ; D431.B9 35.83,380.19 ; D431.B9 36.64,381 ; D431.B9 35.02,381 ; 170.45,100.79 D101.B4 ; D101.B4 171.26,101.6 ; D101.B4 170.45,102.41 ; D101.B4 169.64,101.6 ; DPS2.C01 204.28,410.21 ; DPS2.C01 203.47,411.02 ; DPS2.C01 202.66,410.21 ; DPS2.C01 203.47,409.4 ; D106.B4 244.11,82.09 ; D106.B4 243.3,81.28 ; D106.B4 244.11,80.47 ; D106.B4 244.92,81.28 ; D117.A4 23.13,97.33 ; D117.A4 23.13,95.71 ; D117.A4 23.94,96.52 ; D117.A4 22.32,96.52 ; UHC230.G4_2 16.88,356.1 ; UHC230.G4_2 16.07,355.29 ; UHC230.G4_2 17.69,355.29 ; UHC230.G4_2 16.88,354.48 ; D428.A15 95.06,406.4 ; D428.A15 93.44,406.4 ; D428.A15 94.25,407.21 ; D428.A15 94.25,405.59 ; 30.75,395.43 D232.A11 ; D232.A11 29.94,396.24 ; D232.A11 31.56,396.24 ; D232.A11 30.75,397.05 ; 117.11,387.81 D228.B6 ; D228.B6 116.3,388.62 ; D228.B6 117.92,388.62 ; D228.B6 117.11,389.43 ; D122.B12 117.11,82.09 ; D122.B12 117.92,81.28 ; D122.B12 117.11,80.47 ; D122.B12 116.3,81.28 ; 117.11,100.79 D121.B12 ; D121.B12 116.3,101.6 ; D121.B12 117.11,102.41 ; D121.B12 117.92,101.6 ; 94.25,72.85 D122.A3 ; D122.A3 95.06,73.66 ; D122.A3 93.44,73.66 ; D122.A3 94.25,74.47 ; D231.A8 39.18,373.38 ; D231.A8 38.37,374.19 ; D231.A8 37.56,373.38 ; D231.A8 38.37,372.57 ; 245.84,370.84 D111.B13 ; D111.B13 246.65,371.65 ; D111.B13 246.65,370.03 ; D111.B13 247.46,370.84 ; 245.84,19.05 DPS1.C05 ; DPS1.C05 246.65,19.86 ; DPS1.C05 246.65,18.24 ; DPS1.C05 247.46,19.05 ; D123.B4 97.6,60.96 ; D123.B4 96.79,60.15 ; D123.B4 96.79,61.77 ; D123.B4 95.98,60.96 ; 45.99,52.53 D119.A13 ; D119.A13 45.18,53.34 ; D119.A13 46.8,53.34 ; D119.A13 45.99,54.15 ; 177.26,335.28 D113.A11 ; D113.A11 178.07,334.47 ; D113.A11 178.88,335.28 ; D113.A11 178.07,336.09 ; 14.58,364.64 UHC430.G1_3 ; UHC430.G1_3 13.77,365.45 ; UHC430.G1_3 14.58,366.26 ; UHC430.G1_3 15.39,365.45 ; 203.47,354.79 D114.A1 ; D114.A1 203.47,356.41 ; D114.A1 202.66,355.6 ; D114.A1 204.28,355.6 ; 106.14,96.52 D121.A8 ; D121.A8 106.95,95.71 ; D121.A8 107.76,96.52 ; D121.A8 106.95,97.33 ; D107.B2 239.03,61.77 ; D107.B2 239.84,60.96 ; D107.B2 238.22,60.96 ; D107.B2 239.03,60.15 ; 258.54,388.62 D112.B8 ; D112.B8 259.35,389.43 ; D112.B8 259.35,387.81 ; D112.B8 260.16,388.62 ; 253.46,76.2 D106.A8 ; D106.A8 254.27,77.01 ; D106.A8 254.27,75.39 ; D106.A8 255.08,76.2 ; 93.44,53.34 D123.A3 ; D123.A3 94.25,52.53 ; D123.A3 95.06,53.34 ; D123.A3 94.25,54.15 ; 20.59,98.25 D117.B3 ; D117.B3 21.4,99.06 ; D117.B3 20.59,99.87 ; D117.B3 19.78,99.06 ; DPS2.C11 178.88,410.21 ; DPS2.C11 178.07,411.02 ; DPS2.C11 177.26,410.21 ; DPS2.C11 178.07,409.4 ; D107.B16 275.4,60.96 ; D107.B16 274.59,60.15 ; D107.B16 273.78,60.96 ; D107.B16 274.59,61.77 ; 25.67,32.21 D120.A5 ; D120.A5 24.86,33.02 ; D120.A5 25.67,33.83 ; D120.A5 26.48,33.02 ; 244.11,100.79 D105.B4 ; D105.B4 244.92,101.6 ; D105.B4 244.11,102.41 ; D105.B4 243.3,101.6 ; D123.A8 107.76,55.88 ; D123.A8 106.14,55.88 ; D123.A8 106.95,55.07 ; D123.A8 106.95,56.69 ; 40.91,93.17 D117.A11 ; D117.A11 40.1,93.98 ; D117.A11 40.91,94.79 ; D117.A11 41.72,93.98 ; D105.A12 265.24,96.52 ; D105.A12 264.43,97.33 ; D105.A12 263.62,96.52 ; D105.A12 264.43,95.71 ; 45.87,365.45 UHC430.G2_2 ; UHC430.G2_2 46.68,366.26 ; UHC430.G2_2 46.68,364.64 ; UHC430.G2_2 47.49,365.45 ; CSDPS225.C13 99.33,331.01 ; CSDPS225.C13 100.14,330.2 ; CSDPS225.C13 98.52,330.2 ; CSDPS225.C13 99.33,329.39 ; D428.B9 110.3,401.32 ; D428.B9 109.49,402.13 ; D428.B9 109.49,400.51 ; D428.B9 108.68,401.32 ; 198.39,375.11 D115.A3 ; D115.A3 198.39,376.73 ; D115.A3 199.2,375.92 ; D115.A3 197.58,375.92 ; CSDPS425.C11 105.22,340.36 ; CSDPS425.C11 104.41,341.17 ; CSDPS425.C11 104.41,339.55 ; CSDPS425.C11 103.6,340.36 ; D116.B1 204.28,391.16 ; D116.B1 202.66,391.16 ; D116.B1 203.47,391.97 ; D116.B1 203.47,390.35 ; CSDPS229.C3 51.07,331.01 ; CSDPS229.C3 51.07,329.39 ; CSDPS229.C3 51.88,330.2 ; CSDPS229.C3 50.26,330.2 ; 43.45,342.09 CSDPS429.B6 ; CSDPS429.B6 42.64,342.9 ; CSDPS429.B6 44.26,342.9 ; CSDPS429.B6 43.45,343.71 ; D110.A4 270.32,353.06 ; D110.A4 269.51,353.87 ; D110.A4 268.7,353.06 ; D110.A4 269.51,352.25 ; D103.A12 190.77,56.69 ; D103.A12 189.96,55.88 ; D103.A12 191.58,55.88 ; D103.A12 190.77,55.07 ; D103.A6 176.34,55.88 ; D103.A6 175.53,56.69 ; D103.A6 174.72,55.88 ; D103.A6 175.53,55.07 ; 29.94,370.84 D231.B11 ; D231.B11 30.75,371.65 ; D231.B11 30.75,370.03 ; D231.B11 31.56,370.84 ; D428.B8 112.84,398.78 ; D428.B8 112.03,397.97 ; D428.B8 112.03,399.59 ; D428.B8 111.22,398.78 ; 124.73,380.19 D427.B3 ; D427.B3 123.92,381 ; D427.B3 125.54,381 ; D427.B3 124.73,381.81 ; D427.A8 112.84,383.54 ; D427.A8 111.22,383.54 ; D427.A8 112.03,384.35 ; D427.A8 112.03,382.73 ; D109.B11 251.73,331.01 ; D109.B11 252.54,330.2 ; D109.B11 250.92,330.2 ; D109.B11 251.73,329.39 ; 30.75,329.39 CSDPS229.C11 ; CSDPS229.C11 29.94,330.2 ; CSDPS229.C11 30.75,331.01 ; CSDPS229.C11 31.56,330.2 ; D227.A11 105.22,375.92 ; D227.A11 103.6,375.92 ; D227.A11 104.41,375.11 ; D227.A11 104.41,376.73 ; D106.A2 239.03,77.01 ; D106.A2 239.03,75.39 ; D106.A2 239.84,76.2 ; D106.A2 238.22,76.2 ; CSDPS425.C5 119.65,341.17 ; CSDPS425.C5 119.65,339.55 ; CSDPS425.C5 120.46,340.36 ; CSDPS425.C5 118.84,340.36 ; D110.B12 250,347.98 ; D110.B12 249.19,347.17 ; D110.B12 249.19,348.79 ; D110.B12 248.38,347.98 ; 43.57,355.29 UHC230.G3_3 ; UHC230.G3_3 44.38,356.1 ; UHC230.G3_3 44.38,354.48 ; UHC230.G3_3 45.19,355.29 ; D104.B8 180.61,41.45 ; D104.B8 181.42,40.64 ; D104.B8 180.61,39.83 ; D104.B8 179.8,40.64 ; 271.24,16.51 DPS1.B15 ; DPS1.B15 272.05,15.7 ; DPS1.B15 272.05,17.32 ; DPS1.B15 272.86,16.51 ; 124.73,18.24 DPS3.C15 ; DPS3.C15 125.54,19.05 ; DPS3.C15 123.92,19.05 ; DPS3.C15 124.73,19.86 ; 245.84,355.6 D110.A13 ; D110.A13 246.65,354.79 ; D110.A13 246.65,356.41 ; D110.A13 247.46,355.6 ; CSDPS425.C9 109.49,341.17 ; CSDPS425.C9 110.3,340.36 ; CSDPS425.C9 109.49,339.55 ; CSDPS425.C9 108.68,340.36 ; 167.1,355.6 D114.A15 ; D114.A15 167.91,356.41 ; D114.A15 168.72,355.6 ; D114.A15 167.91,354.79 ; 253.46,81.28 D106.B8 ; D106.B8 254.27,82.09 ; D106.B8 254.27,80.47 ; D106.B8 255.08,81.28 ; D113.A7 189.04,335.28 ; D113.A7 188.23,334.47 ; D113.A7 188.23,336.09 ; D113.A7 187.42,335.28 ; 271.24,19.05 DPS1.C15 ; DPS1.C15 272.05,18.24 ; DPS1.C15 272.05,19.86 ; DPS1.C15 272.86,19.05 ; 238.22,368.3 D111.B16 ; D111.B16 239.03,367.49 ; D111.B16 239.84,368.3 ; D111.B16 239.03,369.11 ; CSDPS229.B10 33.29,333.55 ; CSDPS229.B10 32.48,332.74 ; CSDPS229.B10 33.29,331.93 ; CSDPS229.B10 34.1,332.74 ; D113.A14 171.26,332.74 ; D113.A14 170.45,333.55 ; D113.A14 170.45,331.93 ; D113.A14 169.64,332.74 ; 129,350.52 CSDPS226.C1 ; CSDPS226.C1 129.81,349.71 ; CSDPS226.C1 130.62,350.52 ; CSDPS226.C1 129.81,351.33 ; 35.83,93.17 D117.A9 ; D117.A9 36.64,93.98 ; D117.A9 35.83,94.79 ; D117.A9 35.02,93.98 ; D431.A10 34.1,383.54 ; D431.A10 33.29,384.35 ; D431.A10 33.29,382.73 ; D431.A10 32.48,383.54 ; 183.15,395.43 D116.A9 ; D116.A9 182.34,396.24 ; D116.A9 183.96,396.24 ; D116.A9 183.15,397.05 ; 239.03,352.25 D110.A16 ; D110.A16 239.03,353.87 ; D110.A16 238.22,353.06 ; D110.A16 239.84,353.06 ; D120.B13 45.99,38.91 ; D120.B13 45.99,37.29 ; D120.B13 46.8,38.1 ; D120.B13 45.18,38.1 ; 28.21,392.89 D232.A12 ; D232.A12 29.02,393.7 ; D232.A12 27.4,393.7 ; D232.A12 28.21,394.51 ; 266.16,330.2 D109.B5 ; D109.B5 267.78,330.2 ; D109.B5 266.97,329.39 ; D109.B5 266.97,331.01 ; 37.56,388.62 D232.B8 ; D232.B8 39.18,388.62 ; D232.B8 38.37,389.43 ; D232.B8 38.37,387.81 ; 94.25,57.61 D123.B3 ; D123.B3 95.06,58.42 ; D123.B3 94.25,59.23 ; D123.B3 93.44,58.42 ; 277.13,334.47 D109.A1 ; D109.A1 277.94,335.28 ; D109.A1 276.32,335.28 ; D109.A1 277.13,336.09 ; 266.97,57.61 D107.B13 ; D107.B13 266.16,58.42 ; D107.B13 266.97,59.23 ; D107.B13 267.78,58.42 ; 45.99,411.94 DPS8.B05 ; DPS8.B05 45.99,413.56 ; DPS8.B05 46.8,412.75 ; DPS8.B05 45.18,412.75 ; 197.58,78.74 D102.B15 ; D102.B15 198.39,79.55 ; D102.B15 198.39,77.93 ; D102.B15 199.2,78.74 ; 30.75,380.19 D431.B11 ; D431.B11 29.94,381 ; D431.B11 31.56,381 ; D431.B11 30.75,381.81 ; 253.46,55.88 D107.A8 ; D107.A8 255.08,55.88 ; D107.A8 254.27,55.07 ; D107.A8 254.27,56.69 ; 28.21,39.83 D120.B6 ; D120.B6 28.21,41.45 ; D120.B6 29.02,40.64 ; D120.B6 27.4,40.64 ; D119.B6 29.02,60.96 ; D119.B6 28.21,60.15 ; D119.B6 28.21,61.77 ; D119.B6 27.4,60.96 ; 15.51,37.29 D120.B1 ; D120.B1 14.7,38.1 ; D120.B1 16.32,38.1 ; D120.B1 15.51,38.91 ; D111.A5 266.97,376.73 ; D111.A5 266.97,375.11 ; D111.A5 267.78,375.92 ; D111.A5 266.16,375.92 ; D122.A14 122.19,77.01 ; D122.A14 121.38,76.2 ; D122.A14 122.19,75.39 ; D122.A14 123,76.2 ; D432.A2 53.61,404.67 ; D432.A2 53.61,403.05 ; D432.A2 54.42,403.86 ; D432.A2 52.8,403.86 ; D228.A4 123,393.7 ; D228.A4 122.19,392.89 ; D228.A4 122.19,394.51 ; D228.A4 121.38,393.7 ; 53.61,377.65 D431.B2 ; D431.B2 53.61,379.27 ; D431.B2 52.8,378.46 ; D431.B2 54.42,378.46 ; D122.A7 104.41,74.47 ; D122.A7 104.41,72.85 ; D122.A7 105.22,73.66 ; D122.A7 103.6,73.66 ; 43.45,403.05 D432.A6 ; D432.A6 42.64,403.86 ; D432.A6 43.45,404.67 ; D432.A6 44.26,403.86 ; D122.A9 110.3,73.66 ; D122.A9 109.49,72.85 ; D122.A9 108.68,73.66 ; D122.A9 109.49,74.47 ; D105.A5 247.46,93.98 ; D105.A5 246.65,93.17 ; D105.A5 246.65,94.79 ; D105.A5 245.84,93.98 ; 129.81,400.51 D428.B1 ; D428.B1 129,401.32 ; D428.B1 130.62,401.32 ; D428.B1 129.81,402.13 ; D123.B9 110.3,58.42 ; D123.B9 109.49,57.61 ; D123.B9 108.68,58.42 ; D123.B9 109.49,59.23 ; 101.87,55.07 D123.A6 ; D123.A6 101.06,55.88 ; D123.A6 102.68,55.88 ; D123.A6 101.87,56.69 ; D117.B9 36.64,99.06 ; D117.B9 35.83,99.87 ; D117.B9 35.83,98.25 ; D117.B9 35.02,99.06 ; 178.07,72.85 D102.A7 ; D102.A7 178.88,73.66 ; D102.A7 178.07,74.47 ; D102.A7 177.26,73.66 ; D101.B5 172.99,99.87 ; D101.B5 172.18,99.06 ; D101.B5 173.8,99.06 ; D101.B5 172.99,98.25 ; 88.36,16.51 DPS3.B01 ; DPS3.B01 89.17,15.7 ; DPS3.B01 89.98,16.51 ; DPS3.B01 89.17,17.32 ; 202.66,375.92 D115.A1 ; D115.A1 203.47,376.73 ; D115.A1 203.47,375.11 ; D115.A1 204.28,375.92 ; 259.35,347.17 D110.B8 ; D110.B8 258.54,347.98 ; D110.B8 260.16,347.98 ; D110.B8 259.35,348.79 ; 180.61,347.17 D114.B10 ; D114.B10 179.8,347.98 ; D114.B10 181.42,347.98 ; D114.B10 180.61,348.79 ; 192.5,93.98 D101.A13 ; D101.A13 193.31,93.17 ; D101.A13 194.12,93.98 ; D101.A13 193.31,94.79 ; 28.21,372.57 D231.A12 ; D231.A12 27.4,373.38 ; D231.A12 28.21,374.19 ; D231.A12 29.02,373.38 ; D427.B12 101.87,379.27 ; D427.B12 101.87,377.65 ; D427.B12 101.06,378.46 ; D427.B12 102.68,378.46 ; D227.B9 110.3,370.84 ; D227.B9 108.68,370.84 ; D227.B9 109.49,370.03 ; D227.B9 109.49,371.65 ; 109.49,395.43 D228.A9 ; D228.A9 110.3,396.24 ; D228.A9 109.49,397.05 ; D228.A9 108.68,396.24 ; D228.A7 114.57,397.05 ; D228.A7 114.57,395.43 ; D228.A7 115.38,396.24 ; D228.A7 113.76,396.24 ; 238.22,40.64 D108.B2 ; D108.B2 239.03,39.83 ; D108.B2 239.03,41.45 ; D108.B2 239.84,40.64 ; D124.A9 110.3,33.02 ; D124.A9 109.49,32.21 ; D124.A9 109.49,33.83 ; D124.A9 108.68,33.02 ; 244.11,372.57 D111.A14 ; D111.A14 244.11,374.19 ; D111.A14 243.3,373.38 ; D111.A14 244.92,373.38 ; 174.72,388.62 D116.B12 ; D116.B12 175.53,387.81 ; D116.B12 176.34,388.62 ; D116.B12 175.53,389.43 ; CSDPS225.C1 129.81,331.01 ; CSDPS225.C1 129.81,329.39 ; CSDPS225.C1 129,330.2 ; CSDPS225.C1 130.62,330.2 ; D114.A16 165.37,353.87 ; D114.A16 165.37,352.25 ; D114.A16 166.18,353.06 ; D114.A16 164.56,353.06 ; D432.B16 18.05,399.59 ; D432.B16 17.24,398.78 ; D432.B16 18.86,398.78 ; D432.B16 18.05,397.97 ; UHC430.G1_10 15.73,361.01 ; UHC430.G1_10 15.73,359.39 ; UHC430.G1_10 14.92,360.2 ; UHC430.G1_10 16.54,360.2 ; 272.05,390.35 D112.B3 ; D112.B3 272.86,391.16 ; D112.B3 271.24,391.16 ; D112.B3 272.05,391.97 ; D123.B13 120.46,58.42 ; D123.B13 118.84,58.42 ; D123.B13 119.65,57.61 ; D123.B13 119.65,59.23 ; 179.8,327.66 D113.B10 ; D113.B10 181.42,327.66 ; D113.B10 180.61,326.85 ; D113.B10 180.61,328.47 ; 195.04,96.52 D101.A14 ; D101.A14 196.66,96.52 ; D101.A14 195.85,95.71 ; D101.A14 195.85,97.33 ; 272.05,72.85 D106.A15 ; D106.A15 272.86,73.66 ; D106.A15 272.05,74.47 ; D106.A15 271.24,73.66 ; 174.72,60.96 D103.B6 ; D103.B6 175.53,60.15 ; D103.B6 176.34,60.96 ; D103.B6 175.53,61.77 ; 42.64,393.7 D232.A6 ; D232.A6 43.45,392.89 ; D232.A6 44.26,393.7 ; D232.A6 43.45,394.51 ; 189.96,332.74 D113.A6 ; D113.A6 190.77,331.93 ; D113.A6 191.58,332.74 ; D113.A6 190.77,333.55 ; D121.A12 117.11,97.33 ; D121.A12 117.11,95.71 ; D121.A12 117.92,96.52 ; D121.A12 116.3,96.52 ; D124.B9 109.49,38.91 ; D124.B9 110.3,38.1 ; D124.B9 109.49,37.29 ; D124.B9 108.68,38.1 ; 94.25,37.29 D124.B3 ; D124.B3 95.06,38.1 ; D124.B3 93.44,38.1 ; D124.B3 94.25,38.91 ; 269.51,387.81 D112.B4 ; D112.B4 270.32,388.62 ; D112.B4 268.7,388.62 ; D112.B4 269.51,389.43 ; 271.24,350.52 D110.B3 ; D110.B3 272.05,349.71 ; D110.B3 272.86,350.52 ; D110.B3 272.05,351.33 ; D118.B7 31.56,78.74 ; D118.B7 30.75,77.93 ; D118.B7 30.75,79.55 ; D118.B7 29.94,78.74 ; CSDPS225.C5 120.46,330.2 ; CSDPS225.C5 119.65,329.39 ; CSDPS225.C5 119.65,331.01 ; CSDPS225.C5 118.84,330.2 ; D113.A13 172.99,336.09 ; D113.A13 172.99,334.47 ; D113.A13 173.8,335.28 ; D113.A13 172.18,335.28 ; D122.A13 120.46,73.66 ; D122.A13 118.84,73.66 ; D122.A13 119.65,74.47 ; D122.A13 119.65,72.85 ; D106.B16 275.4,81.28 ; D106.B16 274.59,82.09 ; D106.B16 274.59,80.47 ; D106.B16 273.78,81.28 ; CSDPS226.C13 100.14,350.52 ; CSDPS226.C13 98.52,350.52 ; CSDPS226.C13 99.33,349.71 ; CSDPS226.C13 99.33,351.33 ; D116.A13 172.99,397.05 ; D116.A13 172.99,395.43 ; D116.A13 173.8,396.24 ; D116.A13 172.18,396.24 ; D115.B6 190.77,369.11 ; D115.B6 191.58,368.3 ; D115.B6 190.77,367.49 ; D115.B6 189.96,368.3 ; D108.A12 265.24,35.56 ; D108.A12 264.43,34.75 ; D108.A12 264.43,36.37 ; D108.A12 263.62,35.56 ; 45.18,78.74 D118.B13 ; D118.B13 46.8,78.74 ; D118.B13 45.99,77.93 ; D118.B13 45.99,79.55 ; 195.04,332.74 D113.A4 ; D113.A4 195.85,331.93 ; D113.A4 196.66,332.74 ; D113.A4 195.85,333.55 ; DPS3.B11 114.57,17.32 ; DPS3.B11 113.76,16.51 ; DPS3.B11 115.38,16.51 ; DPS3.B11 114.57,15.7 ; 259.35,60.15 D107.B10 ; D107.B10 258.54,60.96 ; D107.B10 259.35,61.77 ; D107.B10 260.16,60.96 ; D228.A14 97.6,393.7 ; D228.A14 96.79,394.51 ; D228.A14 96.79,392.89 ; D228.A14 95.98,393.7 ; CSDPS429.B8 38.37,343.71 ; CSDPS429.B8 39.18,342.9 ; CSDPS429.B8 37.56,342.9 ; CSDPS429.B8 38.37,342.09 ; 122.19,100.79 D121.B14 ; D121.B14 122.19,102.41 ; D121.B14 123,101.6 ; D121.B14 121.38,101.6 ; 183.15,93.17 D101.A9 ; D101.A9 183.96,93.98 ; D101.A9 183.15,94.79 ; D101.A9 182.34,93.98 ; D108.A15 272.86,33.02 ; D108.A15 272.05,32.21 ; D108.A15 271.24,33.02 ; D108.A15 272.05,33.83 ; 241.57,72.85 D106.A3 ; D106.A3 240.76,73.66 ; D106.A3 242.38,73.66 ; D106.A3 241.57,74.47 ; D231.B2 53.61,369.11 ; D231.B2 53.61,367.49 ; D231.B2 54.42,368.3 ; D231.B2 52.8,368.3 ; 183.15,98.25 D101.B9 ; D101.B9 182.34,99.06 ; D101.B9 183.15,99.87 ; D101.B9 183.96,99.06 ; 261.08,370.84 D111.B7 ; D111.B7 262.7,370.84 ; D111.B7 261.89,370.03 ; D111.B7 261.89,371.65 ; 248.38,373.38 D111.A12 ; D111.A12 249.19,372.57 ; D111.A12 250,373.38 ; D111.A12 249.19,374.19 ; D118.A4 23.13,77.01 ; D118.A4 23.94,76.2 ; D118.A4 22.32,76.2 ; D118.A4 23.13,75.39 ; D115.B16 166.18,368.3 ; D115.B16 164.56,368.3 ; D115.B16 165.37,369.11 ; D115.B16 165.37,367.49 ; 114.57,370.03 D227.B7 ; D227.B7 115.38,370.84 ; D227.B7 114.57,371.65 ; D227.B7 113.76,370.84 ; CSDPS229.B16 18.86,332.74 ; CSDPS229.B16 18.05,333.55 ; CSDPS229.B16 17.24,332.74 ; CSDPS229.B16 18.05,331.93 ; 45.18,33.02 D120.A13 ; D120.A13 45.99,33.83 ; D120.A13 45.99,32.21 ; D120.A13 46.8,33.02 ; D231.A13 26.48,375.92 ; D231.A13 25.67,375.11 ; D231.A13 24.86,375.92 ; D231.A13 25.67,376.73 ; D427.A12 101.87,384.35 ; D427.A12 101.87,382.73 ; D427.A12 101.06,383.54 ; D427.A12 102.68,383.54 ; 99.33,375.11 D227.A13 ; D227.A13 100.14,375.92 ; D227.A13 98.52,375.92 ; D227.A13 99.33,376.73 ; 256,370.84 D111.B9 ; D111.B9 256.81,371.65 ; D111.B9 257.62,370.84 ; D111.B9 256.81,370.03 ; DPS2.C05 194.12,410.21 ; DPS2.C05 192.5,410.21 ; DPS2.C05 193.31,411.02 ; DPS2.C05 193.31,409.4 ; 253.46,35.56 D108.A8 ; D108.A8 254.27,36.37 ; D108.A8 255.08,35.56 ; D108.A8 254.27,34.75 ; 89.17,385.27 D427.A17 ; D427.A17 88.36,386.08 ; D427.A17 89.98,386.08 ; D427.A17 89.17,386.89 ; 113.76,99.06 D121.B11 ; D121.B11 114.57,99.87 ; D121.B11 115.38,99.06 ; D121.B11 114.57,98.25 ; D113.B2 201.74,327.66 ; D113.B2 200.93,328.47 ; D113.B2 200.12,327.66 ; D113.B2 200.93,326.85 ; 183.15,32.21 D104.A9 ; D104.A9 183.15,33.83 ; D104.A9 182.34,33.02 ; D104.A9 183.96,33.02 ; D112.A15 241.57,397.05 ; D112.A15 242.38,396.24 ; D112.A15 240.76,396.24 ; D112.A15 241.57,395.43 ; 126.46,363.22 CSDPS426.B2 ; CSDPS426.B2 127.27,364.03 ; CSDPS426.B2 128.08,363.22 ; CSDPS426.B2 127.27,362.41 ; 165.37,55.07 D103.A2 ; D103.A2 166.18,55.88 ; D103.A2 165.37,56.69 ; D103.A2 164.56,55.88 ; D116.B15 167.91,391.97 ; D116.B15 167.1,391.16 ; D116.B15 168.72,391.16 ; D116.B15 167.91,390.35 ; UHC430.G2_5 45.53,364.51 ; UHC430.G2_5 44.72,363.7 ; UHC430.G2_5 46.34,363.7 ; UHC430.G2_5 45.53,362.89 ; UHC430.G2_10 46.34,360.2 ; UHC430.G2_10 44.72,360.2 ; UHC430.G2_10 45.53,359.39 ; UHC430.G2_10 45.53,361.01 ; 259.35,55.07 D107.A10 ; D107.A10 260.16,55.88 ; D107.A10 258.54,55.88 ; D107.A10 259.35,56.69 ; D120.B4 23.94,40.64 ; D120.B4 22.32,40.64 ; D120.B4 23.13,41.45 ; D120.B4 23.13,39.83 ; 180.61,75.39 D102.A8 ; D102.A8 179.8,76.2 ; D102.A8 180.61,77.01 ; D102.A8 181.42,76.2 ; DPS3.C01 89.98,19.05 ; DPS3.C01 89.17,19.86 ; DPS3.C01 88.36,19.05 ; DPS3.C01 89.17,18.24 ; CSDPS229.C13 25.67,331.01 ; CSDPS229.C13 26.48,330.2 ; CSDPS229.C13 24.86,330.2 ; CSDPS229.C13 25.67,329.39 ; 37.56,101.6 D117.B10 ; D117.B10 38.37,102.41 ; D117.B10 38.37,100.79 ; D117.B10 39.18,101.6 ; D227.B10 106.95,369.11 ; D227.B10 106.14,368.3 ; D227.B10 107.76,368.3 ; D227.B10 106.95,367.49 ; CSDPS226.B16 92.52,353.06 ; CSDPS226.B16 90.9,353.06 ; CSDPS226.B16 91.71,352.25 ; CSDPS226.B16 91.71,353.87 ; 250.92,375.92 D111.A11 ; D111.A11 252.54,375.92 ; D111.A11 251.73,375.11 ; D111.A11 251.73,376.73 ; 46.68,354.48 UHC230.G3_2 ; UHC230.G3_2 46.68,356.1 ; UHC230.G3_2 45.87,355.29 ; UHC230.G3_2 47.49,355.29 ; 239.03,80.47 D106.B2 ; D106.B2 239.84,81.28 ; D106.B2 238.22,81.28 ; D106.B2 239.03,82.09 ; UHC430.G2_9 48.64,360.2 ; UHC430.G2_9 47.83,359.39 ; UHC430.G2_9 47.83,361.01 ; UHC430.G2_9 47.02,360.2 ; D101.B16 200.93,102.41 ; D101.B16 201.74,101.6 ; D101.B16 200.93,100.79 ; D101.B16 200.12,101.6 ; 32.48,101.6 D117.B8 ; D117.B8 33.29,100.79 ; D117.B8 34.1,101.6 ; D117.B8 33.29,102.41 ; D118.B6 29.02,81.28 ; D118.B6 28.21,80.47 ; D118.B6 27.4,81.28 ; D118.B6 28.21,82.09 ; 259.35,367.49 D111.B8 ; D111.B8 260.16,368.3 ; D111.B8 258.54,368.3 ; D111.B8 259.35,369.11 ; D431.A16 18.86,383.54 ; D431.A16 18.05,384.35 ; D431.A16 18.05,382.73 ; D431.A16 17.24,383.54 ; 121.38,60.96 D123.B14 ; D123.B14 122.19,60.15 ; D123.B14 123,60.96 ; D123.B14 122.19,61.77 ; 20.59,339.55 CSDPS429.C15 ; CSDPS429.C15 19.78,340.36 ; CSDPS429.C15 21.4,340.36 ; CSDPS429.C15 20.59,341.17 ; D105.B12 265.24,101.6 ; D105.B12 264.43,102.41 ; D105.B12 264.43,100.79 ; D105.B12 263.62,101.6 ; 88.36,401.32 D428.B17 ; D428.B17 89.17,400.51 ; D428.B17 89.98,401.32 ; D428.B17 89.17,402.13 ; 162.83,98.25 D101.B1 ; D101.B1 163.64,99.06 ; D101.B1 162.83,99.87 ; D232.B13 26.48,391.16 ; D232.B13 25.67,391.97 ; D232.B13 25.67,390.35 ; D232.B13 24.86,391.16 ; D115.B8 185.69,369.11 ; D115.B8 184.88,368.3 ; D115.B8 186.5,368.3 ; D115.B8 185.69,367.49 ; D101.A6 175.53,97.33 ; D101.A6 174.72,96.52 ; D101.A6 175.53,95.71 ; D101.A6 176.34,96.52 ; D431.A8 39.18,383.54 ; D431.A8 37.56,383.54 ; D431.A8 38.37,384.35 ; D431.A8 38.37,382.73 ; CSDPS426.B10 106.95,364.03 ; CSDPS426.B10 106.14,363.22 ; CSDPS426.B10 107.76,363.22 ; CSDPS426.B10 106.95,362.41 ; 48.53,342.09 CSDPS429.B4 ; CSDPS429.B4 47.72,342.9 ; CSDPS429.B4 49.34,342.9 ; CSDPS429.B4 48.53,343.71 ; DPS8.B01 56.15,413.56 ; DPS8.B01 56.15,411.94 ; DPS8.B01 56.96,412.75 ; DPS8.B01 55.34,412.75 ; 180.61,34.75 D104.A8 ; D104.A8 181.42,35.56 ; D104.A8 179.8,35.56 ; D104.A8 180.61,36.37 ; UHC230.G3_11 48.98,349.1 ; UHC230.G3_11 48.98,347.48 ; UHC230.G3_11 49.79,348.29 ; UHC230.G3_11 48.17,348.29 ; D428.A3 124.73,407.21 ; D428.A3 125.54,406.4 ; D428.A3 123.92,406.4 ; D428.A3 124.73,405.59 ; 167.91,72.85 D102.A3 ; D102.A3 167.1,73.66 ; D102.A3 168.72,73.66 ; D102.A3 167.91,74.47 ; 193.31,52.53 D103.A13 ; D103.A13 193.31,54.15 ; D103.A13 194.12,53.34 ; D103.A13 192.5,53.34 ; 90.9,363.22 CSDPS426.B16 ; CSDPS426.B16 91.71,362.41 ; CSDPS426.B16 91.71,364.03 ; CSDPS426.B16 92.52,363.22 ; 251.73,57.61 D107.B7 ; D107.B7 252.54,58.42 ; D107.B7 250.92,58.42 ; D107.B7 251.73,59.23 ; 116.3,398.78 D428.B6 ; D428.B6 117.11,399.59 ; D428.B6 117.11,397.97 ; D428.B6 117.92,398.78 ; 13.77,351.79 UHC230.G4_8 ; UHC230.G4_8 15.39,351.79 ; UHC230.G4_8 14.58,350.98 ; UHC230.G4_8 14.58,352.6 ; D101.B6 175.53,102.41 ; D101.B6 176.34,101.6 ; D101.B6 175.53,100.79 ; 236.49,52.53 D107.A1 ; D107.A1 236.49,54.15 ; D107.A1 235.68,53.34 ; D107.A1 237.3,53.34 ; 188.23,93.17 D101.A11 ; D101.A11 187.42,93.98 ; D101.A11 189.04,93.98 ; D101.A11 188.23,94.79 ; D105.B1 236.49,99.87 ; D105.B1 236.49,98.25 ; D105.B1 237.3,99.06 ; 91.71,387.81 D228.B16 ; D228.B16 90.9,388.62 ; D228.B16 92.52,388.62 ; D228.B16 91.71,389.43 ; UHC430.G2_11 48.98,359.26 ; UHC430.G2_11 48.98,357.64 ; UHC430.G2_11 49.79,358.45 ; UHC430.G2_11 48.17,358.45 ; D103.B9 183.96,58.42 ; D103.B9 182.34,58.42 ; D103.B9 183.15,57.61 ; D103.B9 183.15,59.23 ; D427.A3 125.54,386.08 ; D427.A3 123.92,386.08 ; D427.A3 124.73,386.89 ; D427.A3 124.73,385.27 ; D232.A7 40.91,397.05 ; D232.A7 40.1,396.24 ; D232.A7 40.91,395.43 ; D232.A7 41.72,396.24 ; D102.A16 200.93,77.01 ; D102.A16 200.93,75.39 ; D102.A16 200.12,76.2 ; D102.A16 201.74,76.2 ; 164.56,60.96 D103.B2 ; D103.B2 166.18,60.96 ; D103.B2 165.37,61.77 ; D103.B2 165.37,60.15 ; 197.58,355.6 D114.A3 ; D114.A3 199.2,355.6 ; D114.A3 198.39,356.41 ; D114.A3 198.39,354.79 ; 29.94,415.29 DPS8.A11 ; DPS8.A11 30.75,416.1 ; DPS8.A11 31.56,415.29 ; DPS8.A11 30.75,414.48 ; D228.B12 102.68,388.62 ; D228.B12 101.06,388.62 ; D228.B12 101.87,387.81 ; D228.B12 101.87,389.43 ; D112.A4 270.32,393.7 ; D112.A4 268.7,393.7 ; D112.A4 269.51,392.89 ; D112.A4 269.51,394.51 ; 200.93,367.49 D115.B2 ; D115.B2 201.74,368.3 ; D115.B2 200.93,369.11 ; D115.B2 200.12,368.3 ; D431.B10 34.1,378.46 ; D431.B10 33.29,379.27 ; D431.B10 33.29,377.65 ; D431.B10 32.48,378.46 ; D103.B7 178.07,59.23 ; D103.B7 178.88,58.42 ; D103.B7 178.07,57.61 ; D103.B7 177.26,58.42 ; 30.75,385.27 D431.A11 ; D431.A11 29.94,386.08 ; D431.A11 30.75,386.89 ; D431.A11 31.56,386.08 ; 170.45,34.75 D104.A4 ; D104.A4 169.64,35.56 ; D104.A4 170.45,36.37 ; D104.A4 171.26,35.56 ; D123.B7 105.22,58.42 ; D123.B7 104.41,59.23 ; D123.B7 104.41,57.61 ; D123.B7 103.6,58.42 ; 117.11,377.65 D427.B6 ; D427.B6 117.92,378.46 ; D427.B6 117.11,379.27 ; D427.B6 116.3,378.46 ; 200.93,95.71 D101.A16 ; D101.A16 200.93,97.33 ; D101.A16 201.74,96.52 ; D101.A16 200.12,96.52 ; 40.1,381 D431.B7 ; D431.B7 41.72,381 ; D431.B7 40.91,380.19 ; D431.B7 40.91,381.81 ; D122.A2 92.52,76.2 ; D122.A2 91.71,77.01 ; D122.A2 90.9,76.2 ; D122.A2 91.71,75.39 ; D119.B1 15.51,59.23 ; D119.B1 16.32,58.42 ; D119.B1 14.7,58.42 ; D119.B1 15.51,57.61 ; D231.A5 45.99,376.73 ; D231.A5 45.18,375.92 ; D231.A5 45.99,375.11 ; D231.A5 46.8,375.92 ; CSDPS226.C9 109.49,351.33 ; CSDPS226.C9 110.3,350.52 ; CSDPS226.C9 108.68,350.52 ; CSDPS226.C9 109.49,349.71 ; D109.A15 241.57,336.09 ; D109.A15 242.38,335.28 ; D109.A15 240.76,335.28 ; D109.A15 241.57,334.47 ; 45.99,405.59 D432.A5 ; D432.A5 45.99,407.21 ; D432.A5 46.8,406.4 ; D432.A5 45.18,406.4 ; 177.26,93.98 D101.A7 ; D101.A7 178.07,93.17 ; D101.A7 178.07,94.79 ; D101.A7 178.88,93.98 ; D106.A6 250,76.2 ; D106.A6 249.19,75.39 ; D106.A6 248.38,76.2 ; D106.A6 249.19,77.01 ; 106.95,372.57 D227.A10 ; D227.A10 107.76,373.38 ; D227.A10 106.14,373.38 ; D227.A10 106.95,374.19 ; D431.B3 51.07,381.81 ; D431.B3 50.26,381 ; D431.B3 51.07,380.19 ; D431.B3 51.88,381 ; D121.A14 122.19,97.33 ; D121.A14 121.38,96.52 ; D121.A14 122.19,95.71 ; D121.A14 123,96.52 ; DPS2.A05 193.31,416.1 ; DPS2.A05 192.5,415.29 ; DPS2.A05 194.12,415.29 ; DPS2.A05 193.31,414.48 ; D112.B5 267.78,391.16 ; D112.B5 266.16,391.16 ; D112.B5 266.97,390.35 ; D112.B5 266.97,391.97 ; D112.A5 266.97,397.05 ; D112.A5 266.16,396.24 ; D112.A5 266.97,395.43 ; D112.A5 267.78,396.24 ; D432.B8 39.18,398.78 ; D432.B8 37.56,398.78 ; D432.B8 38.37,399.59 ; D432.B8 38.37,397.97 ; 99.33,77.93 D122.B5 ; D122.B5 100.14,78.74 ; D122.B5 99.33,79.55 ; D122.B5 98.52,78.74 ; D119.B8 34.1,60.96 ; D119.B8 32.48,60.96 ; D119.B8 33.29,61.77 ; D119.B8 33.29,60.15 ; D117.B2 18.86,101.6 ; D117.B2 17.24,101.6 ; D117.B2 18.05,102.41 ; D117.B2 18.05,100.79 ; 56.15,400.51 D432.B1 ; D432.B1 56.15,402.13 ; D432.B1 56.96,401.32 ; D432.B1 55.34,401.32 ; 19.78,53.34 D119.A3 ; D119.A3 20.59,54.15 ; D119.A3 20.59,52.53 ; D119.A3 21.4,53.34 ; 30.75,375.11 D231.A11 ; D231.A11 30.75,376.73 ; D231.A11 29.94,375.92 ; D231.A11 31.56,375.92 ; 95.98,35.56 D124.A4 ; D124.A4 96.79,34.75 ; D124.A4 97.6,35.56 ; D124.A4 96.79,36.37 ; D427.A6 117.11,384.35 ; D427.A6 117.11,382.73 ; D427.A6 117.92,383.54 ; D427.A6 116.3,383.54 ; D120.B5 25.67,38.91 ; D120.B5 24.86,38.1 ; D120.B5 26.48,38.1 ; D120.B5 25.67,37.29 ; KS4.7 40.66,157.84 ; KS4.7 41.77,156.72 ; KS4.7 40.66,155.6 ; KS4.7 39.54,156.72 ; 48.53,39.83 D120.B14 ; D120.B14 47.72,40.64 ; D120.B14 49.34,40.64 ; D120.B14 48.53,41.45 ; D117.A7 30.75,94.79 ; D117.A7 29.94,93.98 ; D117.A7 30.75,93.17 ; D117.A7 31.56,93.98 ; D124.A7 104.41,33.83 ; D124.A7 103.6,33.02 ; D124.A7 105.22,33.02 ; D124.A7 104.41,32.21 ; 106.95,403.05 D428.A10 ; D428.A10 106.95,404.67 ; D428.A10 106.14,403.86 ; D428.A10 107.76,403.86 ; 18.37,361.95 UHC430.G1_6 ; UHC430.G1_6 19.18,362.76 ; UHC430.G1_6 19.99,361.95 ; UHC430.G1_6 19.18,361.14 ; 172.18,58.42 D103.B5 ; D103.B5 173.8,58.42 ; D103.B5 172.99,59.23 ; D103.B5 172.99,57.61 ; D117.A13 45.99,94.79 ; D117.A13 45.18,93.98 ; D117.A13 45.99,93.17 ; D117.A13 46.8,93.98 ; D105.B2 239.84,101.6 ; D105.B2 239.03,100.79 ; D105.B2 238.22,101.6 ; D105.B2 239.03,102.41 ; 91.71,331.93 CSDPS225.B16 ; CSDPS225.B16 91.71,333.55 ; CSDPS225.B16 92.52,332.74 ; CSDPS225.B16 90.9,332.74 ; KS3.7 40.66,150.22 ; KS3.7 41.77,149.1 ; KS3.7 39.54,149.1 ; KS3.7 40.66,147.98 ; D116.A3 199.2,396.24 ; D116.A3 197.58,396.24 ; D116.A3 198.39,395.43 ; D116.A3 198.39,397.05 ; D227.A4 123,373.38 ; D227.A4 121.38,373.38 ; D227.A4 122.19,374.19 ; D227.A4 122.19,372.57 ; 23.13,100.79 D117.B4 ; D117.B4 23.13,102.41 ; D117.B4 22.32,101.6 ; D117.B4 23.94,101.6 ; 25.67,370.03 D231.B13 ; D231.B13 24.86,370.84 ; D231.B13 26.48,370.84 ; D231.B13 25.67,371.65 ; D114.A11 178.07,356.41 ; D114.A11 177.26,355.6 ; D114.A11 178.07,354.79 ; D114.A11 178.88,355.6 ; D109.B16 239.03,328.47 ; D109.B16 239.84,327.66 ; D109.B16 239.03,326.85 ; D109.B16 238.22,327.66 ; D124.B12 117.92,40.64 ; D124.B12 117.11,41.45 ; D124.B12 117.11,39.83 ; D124.B12 116.3,40.64 ; 174.72,81.28 D102.B6 ; D102.B6 175.53,80.47 ; D102.B6 176.34,81.28 ; D102.B6 175.53,82.09 ; 53.61,397.97 D432.B2 ; D432.B2 52.8,398.78 ; D432.B2 54.42,398.78 ; D432.B2 53.61,399.59 ; 177.26,396.24 D116.A11 ; D116.A11 178.07,397.05 ; D116.A11 178.88,396.24 ; D116.A11 178.07,395.43 ; D120.A10 38.37,36.37 ; D120.A10 37.56,35.56 ; D120.A10 39.18,35.56 ; D120.A10 38.37,34.75 ; 263.62,81.28 D106.B12 ; D106.B12 264.43,82.09 ; D106.B12 264.43,80.47 ; D106.B12 265.24,81.28 ; D112.A12 249.19,394.51 ; D112.A12 250,393.7 ; D112.A12 249.19,392.89 ; D112.A12 248.38,393.7 ; 47.72,368.3 D231.B4 ; D231.B4 48.53,369.11 ; D231.B4 49.34,368.3 ; D231.B4 48.53,367.49 ; 55.34,375.92 D231.A1 ; D231.A1 56.15,375.11 ; D231.A1 56.96,375.92 ; D231.A1 56.15,376.73 ; 248.38,332.74 D109.A12 ; D109.A12 249.19,331.93 ; D109.A12 250,332.74 ; D109.A12 249.19,333.55 ; 180.61,392.89 D116.A10 ; D116.A10 179.8,393.7 ; D116.A10 180.61,394.51 ; D116.A10 181.42,393.7 ; 98.52,381 D427.B13 ; D427.B13 99.33,381.81 ; D427.B13 100.14,381 ; D427.B13 99.33,380.19 ; 19.78,410.21 DPS8.C15 ; DPS8.C15 20.59,411.02 ; DPS8.C15 20.59,409.4 ; DPS8.C15 21.4,410.21 ; D231.A17 15.51,376.73 ; D231.A17 15.51,375.11 ; D231.A17 14.7,375.92 ; D231.A17 16.32,375.92 ; 264.43,387.81 D112.B6 ; D112.B6 263.62,388.62 ; D112.B6 264.43,389.43 ; D112.B6 265.24,388.62 ; 24.86,381 D431.B13 ; D431.B13 25.67,380.19 ; D431.B13 25.67,381.81 ; D431.B13 26.48,381 ; 99.33,390.35 D228.B13 ; D228.B13 100.14,391.16 ; D228.B13 99.33,391.97 ; D228.B13 98.52,391.16 ; D108.B7 252.54,38.1 ; D108.B7 251.73,37.29 ; D108.B7 250.92,38.1 ; D108.B7 251.73,38.91 ; D114.A10 180.61,353.87 ; D114.A10 180.61,352.25 ; D114.A10 181.42,353.06 ; D114.A10 179.8,353.06 ; 116.3,332.74 CSDPS225.B6 ; CSDPS225.B6 117.11,331.93 ; CSDPS225.B6 117.11,333.55 ; CSDPS225.B6 117.92,332.74 ; D232.B16 18.05,389.43 ; D232.B16 18.86,388.62 ; D232.B16 18.05,387.81 ; D232.B16 17.24,388.62 ; 192.5,396.24 D116.A5 ; D116.A5 193.31,397.05 ; D116.A5 193.31,395.43 ; D116.A5 194.12,396.24 ; 101.06,40.64 D124.B6 ; D124.B6 102.68,40.64 ; D124.B6 101.87,39.83 ; D124.B6 101.87,41.45 ; D120.A6 28.21,36.37 ; D120.A6 29.02,35.56 ; D120.A6 27.4,35.56 ; D120.A6 28.21,34.75 ; 244.11,39.83 D108.B4 ; D108.B4 244.92,40.64 ; D108.B4 244.11,41.45 ; D108.B4 243.3,40.64 ; D232.A17 15.51,397.05 ; D232.A17 15.51,395.43 ; D232.A17 16.32,396.24 ; D232.A17 14.7,396.24 ; D113.B7 188.23,331.01 ; D113.B7 188.23,329.39 ; D113.B7 187.42,330.2 ; D113.B7 189.04,330.2 ; DPS3.B05 100.14,16.51 ; DPS3.B05 99.33,17.32 ; DPS3.B05 98.52,16.51 ; DPS3.B05 99.33,15.7 ; D124.A13 120.46,33.02 ; D124.A13 118.84,33.02 ; D124.A13 119.65,32.21 ; D124.A13 119.65,33.83 ; D428.B2 128.08,398.78 ; D428.B2 127.27,399.59 ; D428.B2 126.46,398.78 ; D428.B2 127.27,397.97 ; 101.87,392.89 D228.A12 ; D228.A12 101.06,393.7 ; D228.A12 101.87,394.51 ; D228.A12 102.68,393.7 ; 261.89,52.53 D107.A11 ; D107.A11 262.7,53.34 ; D107.A11 261.89,54.15 ; D107.A11 261.08,53.34 ; D108.B14 270.32,40.64 ; D108.B14 269.51,39.83 ; D108.B14 269.51,41.45 ; D108.B14 268.7,40.64 ; 164.56,76.2 D102.A2 ; D102.A2 165.37,77.01 ; D102.A2 166.18,76.2 ; D102.A2 165.37,75.39 ; 188.23,390.35 D116.B7 ; D116.B7 188.23,391.97 ; D116.B7 187.42,391.16 ; D116.B7 189.04,391.16 ; 180.61,95.71 D101.A8 ; D101.A8 181.42,96.52 ; D101.A8 180.61,97.33 ; D101.A8 179.8,96.52 ; D115.A11 178.07,376.73 ; D115.A11 177.26,375.92 ; D115.A11 178.88,375.92 ; D115.A11 178.07,375.11 ; D432.A11 30.75,407.21 ; D432.A11 29.94,406.4 ; D432.A11 30.75,405.59 ; D432.A11 31.56,406.4 ; 94.25,385.27 D427.A15 ; D427.A15 95.06,386.08 ; D427.A15 93.44,386.08 ; D427.A15 94.25,386.89 ; D115.A4 195.85,374.19 ; D115.A4 195.04,373.38 ; D115.A4 195.85,372.57 ; D115.A4 196.66,373.38 ; D102.B14 196.66,81.28 ; D102.B14 195.04,81.28 ; D102.B14 195.85,80.47 ; D102.B14 195.85,82.09 ; D120.A16 53.61,36.37 ; D120.A16 53.61,34.75 ; D120.A16 54.42,35.56 ; D120.A16 52.8,35.56 ; 89.17,57.61 D123.B1 ; D123.B1 88.36,58.42 ; D123.B1 89.17,59.23 ; D123.B1 89.98,58.42 ; 243.3,347.98 D110.B14 ; D110.B14 244.11,347.17 ; D110.B14 244.11,348.79 ; D110.B14 244.92,347.98 ; UHC230.G3_12 47.49,348.29 ; UHC230.G3_12 45.87,348.29 ; UHC230.G3_12 46.68,347.48 ; UHC230.G3_12 46.68,349.1 ; 18.05,39.83 D120.B2 ; D120.B2 18.05,41.45 ; D120.B2 17.24,40.64 ; D120.B2 18.86,40.64 ; D431.B15 21.4,381 ; D431.B15 20.59,381.81 ; D431.B15 19.78,381 ; D431.B15 20.59,380.19 ; 89.17,77.93 D122.B1 ; D122.B1 89.17,79.55 ; D122.B1 88.36,78.74 ; D122.B1 89.98,78.74 ; D124.A2 92.52,35.56 ; D124.A2 91.71,34.75 ; D124.A2 91.71,36.37 ; D124.A2 90.9,35.56 ; 43.45,60.15 D119.B12 ; D119.B12 44.26,60.96 ; D119.B12 42.64,60.96 ; D119.B12 43.45,61.77 ; D227.B16 92.52,368.3 ; D227.B16 91.71,369.11 ; D227.B16 90.9,368.3 ; D227.B16 91.71,367.49 ; D112.A13 247.46,396.24 ; D112.A13 246.65,395.43 ; D112.A13 246.65,397.05 ; D112.A13 245.84,396.24 ; 90.9,373.38 D227.A16 ; D227.A16 92.52,373.38 ; D227.A16 91.71,374.19 ; D227.A16 91.71,372.57 ; 162.02,33.02 D104.A1 ; D104.A1 162.83,33.83 ; D104.A1 163.64,33.02 ; D104.A1 162.83,32.21 ; D432.B3 51.88,401.32 ; D432.B3 50.26,401.32 ; D432.B3 51.07,402.13 ; D432.B3 51.07,400.51 ; D432.B10 33.29,399.59 ; D432.B10 34.1,398.78 ; D432.B10 33.29,397.97 ; D432.B10 32.48,398.78 ; D113.B15 167.91,331.01 ; D113.B15 167.91,329.39 ; D113.B15 167.1,330.2 ; D113.B15 168.72,330.2 ; D431.A2 53.61,384.35 ; D431.A2 52.8,383.54 ; D431.A2 54.42,383.54 ; D431.A2 53.61,382.73 ; 175.53,347.17 D114.B12 ; D114.B12 175.53,348.79 ; D114.B12 174.72,347.98 ; D114.B12 176.34,347.98 ; 167.1,396.24 D116.A15 ; D116.A15 167.91,397.05 ; D116.A15 167.91,395.43 ; D116.A15 168.72,396.24 ; D227.B12 101.87,369.11 ; D227.B12 101.87,367.49 ; D227.B12 101.06,368.3 ; D227.B12 102.68,368.3 ; 266.16,33.02 D108.A13 ; D108.A13 267.78,33.02 ; D108.A13 266.97,33.83 ; D108.A13 266.97,32.21 ; 189.96,40.64 D104.B12 ; D104.B12 190.77,41.45 ; D104.B12 190.77,39.83 ; D104.B12 191.58,40.64 ; 101.87,100.79 D121.B6 ; D121.B6 101.87,102.41 ; D121.B6 102.68,101.6 ; D121.B6 101.06,101.6 ; 177.26,33.02 D104.A7 ; D104.A7 178.88,33.02 ; D104.A7 178.07,32.21 ; D104.A7 178.07,33.83 ; D227.B1 129.81,371.65 ; D227.B1 129,370.84 ; D227.B1 130.62,370.84 ; D227.B1 129.81,370.03 ; 35.02,406.4 D432.A9 ; D432.A9 35.83,407.21 ; D432.A9 35.83,405.59 ; D432.A9 36.64,406.4 ; 112.03,55.07 D123.A10 ; D123.A10 112.84,55.88 ; D123.A10 112.03,56.69 ; D123.A10 111.22,55.88 ; D115.A7 189.04,375.92 ; D115.A7 188.23,375.11 ; D115.A7 187.42,375.92 ; D115.A7 188.23,376.73 ; 28.21,377.65 D431.B12 ; D431.B12 27.4,378.46 ; D431.B12 29.02,378.46 ; D431.B12 28.21,379.27 ; D227.A9 110.3,375.92 ; D227.A9 109.49,375.11 ; D227.A9 108.68,375.92 ; D227.A9 109.49,376.73 ; 236.49,37.29 D108.B1 ; D108.B1 237.3,38.1 ; D108.B1 236.49,38.91 ; D108.B1 235.68,38.1 ; 261.08,13.97 DPS1.A11 ; DPS1.A11 261.89,14.78 ; DPS1.A11 261.89,13.16 ; DPS1.A11 262.7,13.97 ; D113.A8 185.69,333.55 ; D113.A8 186.5,332.74 ; D113.A8 185.69,331.93 ; D113.A8 184.88,332.74 ; D113.B13 173.8,330.2 ; D113.B13 172.99,331.01 ; D113.B13 172.99,329.39 ; D113.B13 172.18,330.2 ; D111.A7 262.7,375.92 ; D111.A7 261.89,375.11 ; D111.A7 261.89,376.73 ; D111.A7 261.08,375.92 ; 29.94,401.32 D432.B11 ; D432.B11 30.75,402.13 ; D432.B11 31.56,401.32 ; D432.B11 30.75,400.51 ; 116.3,403.86 D428.A6 ; D428.A6 117.11,404.67 ; D428.A6 117.92,403.86 ; D428.A6 117.11,403.05 ; CSDPS425.B2 127.27,343.71 ; CSDPS425.B2 128.08,342.9 ; CSDPS425.B2 127.27,342.09 ; CSDPS425.B2 126.46,342.9 ; D106.B9 257.62,78.74 ; D106.B9 256.81,77.93 ; D106.B9 256.81,79.55 ; D106.B9 256,78.74 ; D114.B7 188.23,351.33 ; D114.B7 188.23,349.71 ; D114.B7 189.04,350.52 ; D114.B7 187.42,350.52 ; D232.A10 34.1,393.7 ; D232.A10 33.29,392.89 ; D232.A10 32.48,393.7 ; D232.A10 33.29,394.51 ; 118.84,53.34 D123.A13 ; D123.A13 119.65,52.53 ; D123.A13 119.65,54.15 ; D123.A13 120.46,53.34 ; D120.B15 51.07,38.91 ; D120.B15 51.07,37.29 ; D120.B15 50.26,38.1 ; D120.B15 51.88,38.1 ; D118.B9 35.83,79.55 ; D118.B9 35.83,77.93 ; D118.B9 35.02,78.74 ; D118.B9 36.64,78.74 ; DPS1.A05 246.65,14.78 ; DPS1.A05 247.46,13.97 ; DPS1.A05 246.65,13.16 ; DPS1.A05 245.84,13.97 ; D428.B5 120.46,401.32 ; D428.B5 118.84,401.32 ; D428.B5 119.65,402.13 ; D428.B5 119.65,400.51 ; 250.92,370.84 D111.B11 ; D111.B11 251.73,371.65 ; D111.B11 252.54,370.84 ; D111.B11 251.73,370.03 ; D114.B5 194.12,350.52 ; D114.B5 193.31,351.33 ; D114.B5 192.5,350.52 ; D114.B5 193.31,349.71 ; 40.91,32.21 D120.A11 ; D120.A11 40.91,33.83 ; D120.A11 41.72,33.02 ; D120.A11 40.1,33.02 ; 50.26,370.84 D231.B3 ; D231.B3 51.07,371.65 ; D231.B3 51.07,370.03 ; D231.B3 51.88,370.84 ; D107.B15 272.05,59.23 ; D107.B15 272.05,57.61 ; D107.B15 272.86,58.42 ; D107.B15 271.24,58.42 ; D431.A4 49.34,383.54 ; D431.A4 47.72,383.54 ; D431.A4 48.53,384.35 ; D431.A4 48.53,382.73 ; 111.22,393.7 D228.A8 ; D228.A8 112.84,393.7 ; D228.A8 112.03,394.51 ; D228.A8 112.03,392.89 ; D231.A2 53.61,374.19 ; D231.A2 53.61,372.57 ; D231.A2 52.8,373.38 ; D231.A2 54.42,373.38 ; D105.B8 255.08,101.6 ; D105.B8 254.27,100.79 ; D105.B8 254.27,102.41 ; D105.B8 253.46,101.6 ; D103.B13 194.12,58.42 ; D103.B13 193.31,57.61 ; D103.B13 192.5,58.42 ; D103.B13 193.31,59.23 ; 16.07,348.29 UHC230.G4_12 ; UHC230.G4_12 17.69,348.29 ; UHC230.G4_12 16.88,349.1 ; UHC230.G4_12 16.88,347.48 ; D112.B10 254.27,389.43 ; D112.B10 253.46,388.62 ; D112.B10 254.27,387.81 ; D112.B10 255.08,388.62 ; 261.89,93.17 D105.A11 ; D105.A11 261.89,94.79 ; D105.A11 261.08,93.98 ; D105.A11 262.7,93.98 ; D110.A14 244.92,353.06 ; D110.A14 244.11,352.25 ; D110.A14 244.11,353.87 ; D110.A14 243.3,353.06 ; DPS2.B15 167.91,413.56 ; DPS2.B15 167.1,412.75 ; DPS2.B15 168.72,412.75 ; DPS2.B15 167.91,411.94 ; 24.86,386.08 D431.A13 ; D431.A13 25.67,386.89 ; D431.A13 26.48,386.08 ; D431.A13 25.67,385.27 ; DPS8.C05 45.99,411.02 ; DPS8.C05 46.8,410.21 ; DPS8.C05 45.18,410.21 ; DPS8.C05 45.99,409.4 ; 200.93,352.25 D114.A2 ; D114.A2 200.93,353.87 ; D114.A2 201.74,353.06 ; D114.A2 200.12,353.06 ; D122.B10 112.84,81.28 ; D122.B10 111.22,81.28 ; D122.B10 112.03,82.09 ; D122.B10 112.03,80.47 ; 268.7,373.38 D111.A4 ; D111.A4 269.51,374.19 ; D111.A4 270.32,373.38 ; D111.A4 269.51,372.57 ; 273.78,96.52 D105.A16 ; D105.A16 274.59,95.71 ; D105.A16 274.59,97.33 ; D105.A16 275.4,96.52 ; D122.B4 97.6,81.28 ; D122.B4 95.98,81.28 ; D122.B4 96.79,80.47 ; D122.B4 96.79,82.09 ; 121.38,383.54 D427.A4 ; D427.A4 122.19,384.35 ; D427.A4 122.19,382.73 ; D427.A4 123,383.54 ; 185.69,34.75 D104.A10 ; D104.A10 184.88,35.56 ; D104.A10 185.69,36.37 ; D104.A10 186.5,35.56 ; D104.B7 178.07,38.91 ; D104.B7 177.26,38.1 ; D104.B7 178.07,37.29 ; D104.B7 178.88,38.1 ; CSDPS429.B12 28.21,343.71 ; CSDPS429.B12 29.02,342.9 ; CSDPS429.B12 27.4,342.9 ; CSDPS429.B12 28.21,342.09 ; 188.23,370.03 D115.B7 ; D115.B7 188.23,371.65 ; D115.B7 189.04,370.84 ; D115.B7 187.42,370.84 ; 123.92,391.16 D228.B3 ; D228.B3 125.54,391.16 ; D228.B3 124.73,391.97 ; D228.B3 124.73,390.35 ; D231.B7 40.91,371.65 ; D231.B7 41.72,370.84 ; D231.B7 40.91,370.03 ; D231.B7 40.1,370.84 ; D232.B14 23.94,388.62 ; D232.B14 23.13,387.81 ; D232.B14 22.32,388.62 ; D232.B14 23.13,389.43 ; D123.B10 112.84,60.96 ; D123.B10 112.03,60.15 ; D123.B10 111.22,60.96 ; D123.B10 112.03,61.77 ; D428.B13 99.33,402.13 ; D428.B13 98.52,401.32 ; D428.B13 99.33,400.51 ; D428.B13 100.14,401.32 ; 18.05,75.39 D118.A2 ; D118.A2 17.24,76.2 ; D118.A2 18.86,76.2 ; D118.A2 18.05,77.01 ; 239.03,55.07 D107.A2 ; D107.A2 239.03,56.69 ; D107.A2 238.22,55.88 ; D107.A2 239.84,55.88 ; 185.69,39.83 D104.B10 ; D104.B10 186.5,40.64 ; D104.B10 184.88,40.64 ; D104.B10 185.69,41.45 ; 261.89,354.79 D110.A7 ; D110.A7 261.08,355.6 ; D110.A7 262.7,355.6 ; D110.A7 261.89,356.41 ; 123.92,58.42 D123.B15 ; D123.B15 125.54,58.42 ; D123.B15 124.73,59.23 ; D123.B15 124.73,57.61 ; 119.65,98.25 D121.B13 ; D121.B13 120.46,99.06 ; D121.B13 119.65,99.87 ; D121.B13 118.84,99.06 ; D109.B10 254.27,328.47 ; D109.B10 253.46,327.66 ; D109.B10 254.27,326.85 ; D109.B10 255.08,327.66 ; 116.3,373.38 D227.A6 ; D227.A6 117.92,373.38 ; D227.A6 117.11,372.57 ; D227.A6 117.11,374.19 ; D108.B11 262.7,38.1 ; D108.B11 261.08,38.1 ; D108.B11 261.89,37.29 ; D108.B11 261.89,38.91 ; 182.34,375.92 D115.A9 ; D115.A9 183.96,375.92 ; D115.A9 183.15,375.11 ; D115.A9 183.15,376.73 ; CSDPS425.B16 91.71,343.71 ; CSDPS425.B16 91.71,342.09 ; CSDPS425.B16 92.52,342.9 ; CSDPS425.B16 90.9,342.9 ; D104.B5 173.8,38.1 ; D104.B5 172.18,38.1 ; D104.B5 172.99,37.29 ; D104.B5 172.99,38.91 ; 89.17,93.17 D121.A1 ; D121.A1 89.98,93.98 ; D121.A1 89.17,94.79 ; D121.A1 88.36,93.98 ; 190.77,95.71 D101.A12 ; D101.A12 189.96,96.52 ; D101.A12 190.77,97.33 ; D101.A12 191.58,96.52 ; UHC430.G2_12 46.68,359.26 ; UHC430.G2_12 45.87,358.45 ; UHC430.G2_12 47.49,358.45 ; UHC430.G2_12 46.68,357.64 ; 93.44,381 D427.B15 ; D427.B15 94.25,380.19 ; D427.B15 94.25,381.81 ; D427.B15 95.06,381 ; 193.31,375.11 D115.A5 ; D115.A5 194.12,375.92 ; D115.A5 193.31,376.73 ; D115.A5 192.5,375.92 ; 109.49,98.25 D121.B9 ; D121.B9 108.68,99.06 ; D121.B9 109.49,99.87 ; D121.B9 110.3,99.06 ; 114.57,349.71 CSDPS226.C7 ; CSDPS226.C7 115.38,350.52 ; CSDPS226.C7 114.57,351.33 ; CSDPS226.C7 113.76,350.52 ; 96.79,75.39 D122.A4 ; D122.A4 96.79,77.01 ; D122.A4 97.6,76.2 ; D122.A4 95.98,76.2 ; 18.05,342.09 CSDPS429.B16 ; CSDPS429.B16 18.86,342.9 ; CSDPS429.B16 18.05,343.71 ; CSDPS429.B16 17.24,342.9 ; D232.B15 20.59,391.97 ; D232.B15 21.4,391.16 ; D232.B15 19.78,391.16 ; D232.B15 20.59,390.35 ; 96.79,403.05 D428.A14 ; D428.A14 97.6,403.86 ; D428.A14 95.98,403.86 ; D428.A14 96.79,404.67 ; 56.15,409.4 DPS8.C01 ; DPS8.C01 55.34,410.21 ; DPS8.C01 56.96,410.21 ; DPS8.C01 56.15,411.02 ; 17.24,403.86 D432.A16 ; D432.A16 18.86,403.86 ; D432.A16 18.05,404.67 ; D432.A16 18.05,403.05 ; UHC430.G2_4 48.64,363.7 ; UHC430.G2_4 47.83,362.89 ; UHC430.G2_4 47.02,363.7 ; UHC430.G2_4 47.83,364.51 ; CSDPS225.B14 96.79,333.55 ; CSDPS225.B14 96.79,331.93 ; CSDPS225.B14 97.6,332.74 ; CSDPS225.B14 95.98,332.74 ; 116.3,368.3 D227.B6 ; D227.B6 117.92,368.3 ; D227.B6 117.11,367.49 ; D227.B6 117.11,369.11 ; 239.03,392.89 D112.A16 ; D112.A16 238.22,393.7 ; D112.A16 239.84,393.7 ; D112.A16 239.03,394.51 ; 51.07,98.25 D117.B15 ; D117.B15 50.26,99.06 ; D117.B15 51.07,99.87 ; 28.21,367.49 D231.B12 ; D231.B12 27.4,368.3 ; D231.B12 28.21,369.11 ; D231.B12 29.02,368.3 ; D124.B13 120.46,38.1 ; D124.B13 119.65,37.29 ; D124.B13 118.84,38.1 ; D124.B13 119.65,38.91 ; DPS1.A15 272.86,13.97 ; DPS1.A15 272.05,13.16 ; DPS1.A15 272.05,14.78 ; DPS1.A15 271.24,13.97 ; 13.77,355.29 UHC230.G4_3 ; UHC230.G4_3 14.58,354.48 ; UHC230.G4_3 15.39,355.29 ; UHC230.G4_3 14.58,356.1 ; 271.24,53.34 D107.A15 ; D107.A15 272.86,53.34 ; D107.A15 272.05,54.15 ; D107.A15 272.05,52.53 ; 40.91,52.53 D119.A11 ; D119.A11 40.1,53.34 ; D119.A11 40.91,54.15 ; D119.A11 41.72,53.34 ; D106.B5 246.65,79.55 ; D106.B5 246.65,77.93 ; D106.B5 245.84,78.74 ; D106.B5 247.46,78.74 ; D119.A4 23.94,55.88 ; D119.A4 23.13,56.69 ; D119.A4 22.32,55.88 ; D119.A4 23.13,55.07 ; DPS2.A15 168.72,415.29 ; DPS2.A15 167.1,415.29 ; DPS2.A15 167.91,416.1 ; DPS2.A15 167.91,414.48 ; 91.71,95.71 D121.A2 ; D121.A2 91.71,97.33 ; D121.A2 92.52,96.52 ; D121.A2 90.9,96.52 ; 53.61,387.81 D232.B2 ; D232.B2 54.42,388.62 ; D232.B2 53.61,389.43 ; D232.B2 52.8,388.62 ; CSDPS229.C9 36.64,330.2 ; CSDPS229.C9 35.02,330.2 ; CSDPS229.C9 35.83,331.01 ; CSDPS229.C9 35.83,329.39 ; 259.35,352.25 D110.A8 ; D110.A8 258.54,353.06 ; D110.A8 260.16,353.06 ; D110.A8 259.35,353.87 ; D428.B11 105.22,401.32 ; D428.B11 103.6,401.32 ; D428.B11 104.41,402.13 ; D428.B11 104.41,400.51 ; D104.B9 183.15,38.91 ; D104.B9 183.96,38.1 ; D104.B9 182.34,38.1 ; D104.B9 183.15,37.29 ; D101.B13 194.12,99.06 ; D101.B13 193.31,98.25 ; D101.B13 192.5,99.06 ; D101.B13 193.31,99.87 ; 200.12,81.28 D102.B16 ; D102.B16 200.93,80.47 ; D102.B16 201.74,81.28 ; D102.B16 200.93,82.09 ; D105.B14 269.51,102.41 ; D105.B14 269.51,100.79 ; D105.B14 270.32,101.6 ; D105.B14 268.7,101.6 ; 118.84,396.24 D228.A5 ; D228.A5 119.65,397.05 ; D228.A5 119.65,395.43 ; D228.A5 120.46,396.24 ; 240.76,375.92 D111.A15 ; D111.A15 242.38,375.92 ; D111.A15 241.57,376.73 ; D111.A15 241.57,375.11 ; 23.13,382.73 D431.A14 ; D431.A14 22.32,383.54 ; D431.A14 23.94,383.54 ; D431.A14 23.13,384.35 ; D123.A4 96.79,56.69 ; D123.A4 95.98,55.88 ; D123.A4 96.79,55.07 ; D123.A4 97.6,55.88 ; 246.65,52.53 D107.A5 ; D107.A5 247.46,53.34 ; D107.A5 246.65,54.15 ; D107.A5 245.84,53.34 ; D109.B2 275.4,327.66 ; D109.B2 273.78,327.66 ; D109.B2 274.59,326.85 ; D109.B2 274.59,328.47 ; D228.A1 130.62,396.24 ; D228.A1 129.81,397.05 ; D228.A1 129,396.24 ; D228.A1 129.81,395.43 ; D431.B5 45.99,381.81 ; D431.B5 45.18,381 ; D431.B5 46.8,381 ; D431.B5 45.99,380.19 ; 272.05,77.93 D106.B15 ; D106.B15 272.05,79.55 ; D106.B15 271.24,78.74 ; D106.B15 272.86,78.74 ; 198.39,57.61 D103.B15 ; D103.B15 199.2,58.42 ; D103.B15 197.58,58.42 ; D103.B15 198.39,59.23 ; D104.B2 166.18,40.64 ; D104.B2 165.37,41.45 ; D104.B2 164.56,40.64 ; D104.B2 165.37,39.83 ; D107.B5 247.46,58.42 ; D107.B5 246.65,57.61 ; D107.B5 245.84,58.42 ; D107.B5 246.65,59.23 ; 271.24,93.98 D105.A15 ; D105.A15 272.05,93.17 ; D105.A15 272.05,94.79 ; D105.A15 272.86,93.98 ; D122.A11 115.38,73.66 ; D122.A11 114.57,74.47 ; D122.A11 114.57,72.85 ; D122.A11 113.76,73.66 ; D101.A5 173.8,93.98 ; D101.A5 172.99,93.17 ; D101.A5 172.99,94.79 ; D101.A5 172.18,93.98 ; 269.51,367.49 D111.B4 ; D111.B4 270.32,368.3 ; D111.B4 268.7,368.3 ; D111.B4 269.51,369.11 ; CSDPS226.C15 94.25,351.33 ; CSDPS226.C15 95.06,350.52 ; CSDPS226.C15 93.44,350.52 ; CSDPS226.C15 94.25,349.71 ; 93.44,391.16 D228.B15 ; D228.B15 95.06,391.16 ; D228.B15 94.25,391.97 ; D228.B15 94.25,390.35 ; D113.A10 180.61,333.55 ; D113.A10 179.8,332.74 ; D113.A10 181.42,332.74 ; D113.A10 180.61,331.93 ; D111.B10 254.27,369.11 ; D111.B10 255.08,368.3 ; D111.B10 253.46,368.3 ; D111.B10 254.27,367.49 ; 243.3,96.52 D105.A4 ; D105.A4 244.11,95.71 ; D105.A4 244.11,97.33 ; D105.A4 244.92,96.52 ; D111.A1 277.94,375.92 ; D111.A1 276.32,375.92 ; D111.A1 277.13,376.73 ; D111.A1 277.13,375.11 ; 118.84,406.4 D428.A5 ; D428.A5 119.65,407.21 ; D428.A5 119.65,405.59 ; D428.A5 120.46,406.4 ; 256,93.98 D105.A9 ; D105.A9 256.81,93.17 ; D105.A9 256.81,94.79 ; D105.A9 257.62,93.98 ; 106.14,388.62 D228.B10 ; D228.B10 106.95,389.43 ; D228.B10 106.95,387.81 ; D228.B10 107.76,388.62 ; 29.94,391.16 D232.B11 ; D232.B11 31.56,391.16 ; D232.B11 30.75,390.35 ; D232.B11 30.75,391.97 ; 170.45,326.85 D113.B14 ; D113.B14 169.64,327.66 ; D113.B14 171.26,327.66 ; D113.B14 170.45,328.47 ; D118.B16 54.42,81.28 ; D118.B16 52.8,81.28 ; D118.B16 53.61,80.47 ; D118.B16 53.61,82.09 ; 235.68,73.66 D106.A1 ; D106.A1 236.49,72.85 ; D106.A1 236.49,74.47 ; D106.A1 237.3,73.66 ; D113.B9 183.96,330.2 ; D113.B9 182.34,330.2 ; D113.B9 183.15,331.01 ; D113.B9 183.15,329.39 ; 29.94,38.1 D120.B7 ; D120.B7 31.56,38.1 ; D120.B7 30.75,38.91 ; D120.B7 30.75,37.29 ; 48.53,331.93 CSDPS229.B4 ; CSDPS229.B4 48.53,333.55 ; CSDPS229.B4 47.72,332.74 ; CSDPS229.B4 49.34,332.74 ; 200.12,373.38 D115.A2 ; D115.A2 201.74,373.38 ; D115.A2 200.93,374.19 ; D115.A2 200.93,372.57 ; 111.22,388.62 D228.B8 ; D228.B8 112.03,387.81 ; D228.B8 112.84,388.62 ; D228.B8 112.03,389.43 ; D104.A14 196.66,35.56 ; D104.A14 195.85,34.75 ; D104.A14 195.85,36.37 ; D104.A14 195.04,35.56 ; 243.3,368.3 D111.B14 ; D111.B14 244.11,367.49 ; D111.B14 244.11,369.11 ; D111.B14 244.92,368.3 ; D231.B15 21.4,370.84 ; D231.B15 20.59,371.65 ; D231.B15 19.78,370.84 ; D231.B15 20.59,370.03 ; CSDPS425.B14 97.6,342.9 ; CSDPS425.B14 96.79,342.09 ; CSDPS425.B14 95.98,342.9 ; CSDPS425.B14 96.79,343.71 ; D231.A7 40.91,376.73 ; D231.A7 40.1,375.92 ; D231.A7 41.72,375.92 ; D231.A7 40.91,375.11 ; 200.93,387.81 D116.B2 ; D116.B2 200.12,388.62 ; D116.B2 201.74,388.62 ; D116.B2 200.93,389.43 ; 35.83,339.55 CSDPS429.C9 ; CSDPS429.C9 35.83,341.17 ; CSDPS429.C9 35.02,340.36 ; CSDPS429.C9 36.64,340.36 ; 256.81,390.35 D112.B9 ; D112.B9 256,391.16 ; D112.B9 257.62,391.16 ; D112.B9 256.81,391.97 ; 243.3,60.96 D107.B4 ; D107.B4 244.92,60.96 ; D107.B4 244.11,60.15 ; D107.B4 244.11,61.77 ; 99.33,32.21 D124.A5 ; D124.A5 99.33,33.83 ; D124.A5 98.52,33.02 ; D124.A5 100.14,33.02 ; D228.A3 125.54,396.24 ; D228.A3 124.73,397.05 ; D228.A3 124.73,395.43 ; D228.A3 123.92,396.24 ; D111.A9 257.62,375.92 ; D111.A9 256.81,375.11 ; D111.A9 256.81,376.73 ; D111.A9 256,375.92 ; 114.57,18.24 DPS3.C11 ; DPS3.C11 115.38,19.05 ; DPS3.C11 113.76,19.05 ; DPS3.C11 114.57,19.86 ; D104.B4 170.45,41.45 ; D104.B4 170.45,39.83 ; D104.B4 171.26,40.64 ; D104.B4 169.64,40.64 ; D108.A9 257.62,33.02 ; D108.A9 256,33.02 ; D108.A9 256.81,33.83 ; D108.A9 256.81,32.21 ; D110.A5 267.78,355.6 ; D110.A5 266.16,355.6 ; D110.A5 266.97,354.79 ; D110.A5 266.97,356.41 ; 104.41,405.59 D428.A11 ; D428.A11 105.22,406.4 ; D428.A11 104.41,407.21 ; D428.A11 103.6,406.4 ; 122.19,342.09 CSDPS425.B4 ; CSDPS425.B4 123,342.9 ; CSDPS425.B4 121.38,342.9 ; CSDPS425.B4 122.19,343.71 ; 185.69,75.39 D102.A10 ; D102.A10 185.69,77.01 ; D102.A10 184.88,76.2 ; D102.A10 186.5,76.2 ; 122.19,362.41 CSDPS426.B4 ; CSDPS426.B4 123,363.22 ; CSDPS426.B4 121.38,363.22 ; CSDPS426.B4 122.19,364.03 ; D121.B3 95.06,99.06 ; D121.B3 94.25,98.25 ; D121.B3 94.25,99.87 ; D121.B3 93.44,99.06 ; D110.A15 241.57,356.41 ; D110.A15 241.57,354.79 ; D110.A15 242.38,355.6 ; D110.A15 240.76,355.6 ; D428.A9 110.3,406.4 ; D428.A9 109.49,405.59 ; D428.A9 108.68,406.4 ; D428.A9 109.49,407.21 ; 245.84,33.02 D108.A5 ; D108.A5 247.46,33.02 ; D108.A5 246.65,32.21 ; D108.A5 246.65,33.83 ; 249.19,60.15 D107.B6 ; D107.B6 250,60.96 ; D107.B6 249.19,61.77 ; D107.B6 248.38,60.96 ; D122.A12 117.92,76.2 ; D122.A12 117.11,75.39 ; D122.A12 116.3,76.2 ; D122.A12 117.11,77.01 ; D122.B13 119.65,79.55 ; D122.B13 119.65,77.93 ; D122.B13 120.46,78.74 ; D122.B13 118.84,78.74 ; D119.A14 49.34,55.88 ; D119.A14 47.72,55.88 ; D119.A14 48.53,55.07 ; D119.A14 48.53,56.69 ; D118.A15 51.07,74.47 ; D118.A15 50.26,73.66 ; D118.A15 51.07,72.85 ; D118.A15 51.88,73.66 ; 45.18,401.32 D432.B5 ; D432.B5 46.8,401.32 ; D432.B5 45.99,400.51 ; D432.B5 45.99,402.13 ; 101.06,363.22 CSDPS426.B12 ; CSDPS426.B12 102.68,363.22 ; CSDPS426.B12 101.87,362.41 ; CSDPS426.B12 101.87,364.03 ; D124.A10 112.03,36.37 ; D124.A10 112.03,34.75 ; D124.A10 112.84,35.56 ; D124.A10 111.22,35.56 ; 170.45,80.47 D102.B4 ; D102.B4 170.45,82.09 ; D102.B4 171.26,81.28 ; D102.B4 169.64,81.28 ; D228.B7 115.38,391.16 ; D228.B7 113.76,391.16 ; D228.B7 114.57,390.35 ; D228.B7 114.57,391.97 ; CSDPS429.B10 33.29,343.71 ; CSDPS429.B10 34.1,342.9 ; CSDPS429.B10 32.48,342.9 ; CSDPS429.B10 33.29,342.09 ; D428.A12 101.87,404.67 ; D428.A12 102.68,403.86 ; D428.A12 101.87,403.05 ; D428.A12 101.06,403.86 ; D118.B11 41.72,78.74 ; D118.B11 40.91,79.55 ; D118.B11 40.1,78.74 ; D118.B11 40.91,77.93 ; 121.38,332.74 CSDPS225.B4 ; CSDPS225.B4 123,332.74 ; CSDPS225.B4 122.19,331.93 ; CSDPS225.B4 122.19,333.55 ; 274.59,34.75 D108.A16 ; D108.A16 275.4,35.56 ; D108.A16 274.59,36.37 ; D108.A16 273.78,35.56 ; D124.B10 112.84,40.64 ; D124.B10 112.03,39.83 ; D124.B10 111.22,40.64 ; D124.B10 112.03,41.45 ; 241.57,32.21 D108.A3 ; D108.A3 241.57,33.83 ; D108.A3 242.38,33.02 ; D108.A3 240.76,33.02 ; 94.25,32.21 D124.A3 ; D124.A3 94.25,33.83 ; D124.A3 95.06,33.02 ; D124.A3 93.44,33.02 ; 117.11,352.25 CSDPS226.B6 ; CSDPS226.B6 117.92,353.06 ; CSDPS226.B6 117.11,353.87 ; CSDPS226.B6 116.3,353.06 ; 106.14,76.2 D122.A8 ; D122.A8 106.95,77.01 ; D122.A8 106.95,75.39 ; D122.A8 107.76,76.2 ; D107.A3 241.57,54.15 ; D107.A3 242.38,53.34 ; D107.A3 241.57,52.53 ; D107.A3 240.76,53.34 ; D115.B11 178.88,370.84 ; D115.B11 178.07,370.03 ; D115.B11 177.26,370.84 ; D115.B11 178.07,371.65 ; 28.21,382.73 D431.A12 ; D431.A12 28.21,384.35 ; D431.A12 29.02,383.54 ; D431.A12 27.4,383.54 ; D231.B16 18.86,368.3 ; D231.B16 17.24,368.3 ; D231.B16 18.05,367.49 ; D231.B16 18.05,369.11 ; D117.A15 51.88,93.98 ; D117.A15 50.26,93.98 ; D117.A15 51.07,94.79 ; D117.A15 51.07,93.17 ; D108.B8 254.27,41.45 ; D108.B8 253.46,40.64 ; D108.B8 254.27,39.83 ; D108.B8 255.08,40.64 ; 91.71,382.73 D427.A16 ; D427.A16 91.71,384.35 ; D427.A16 92.52,383.54 ; D427.A16 90.9,383.54 ; 272.05,354.79 D110.A3 ; D110.A3 271.24,355.6 ; D110.A3 272.86,355.6 ; D110.A3 272.05,356.41 ; DPS8.C11 31.56,410.21 ; DPS8.C11 30.75,411.02 ; DPS8.C11 29.94,410.21 ; DPS8.C11 30.75,409.4 ; D103.A16 200.93,56.69 ; D103.A16 201.74,55.88 ; D103.A16 200.12,55.88 ; D103.A16 200.93,55.07 ; 244.11,75.39 D106.A4 ; D106.A4 244.92,76.2 ; D106.A4 243.3,76.2 ; D106.A4 244.11,77.01 ; 169.64,96.52 D101.A4 ; D101.A4 171.26,96.52 ; D101.A4 170.45,95.71 ; D101.A4 170.45,97.33 ; 35.02,53.34 D119.A9 ; D119.A9 35.83,54.15 ; D119.A9 35.83,52.53 ; D119.A9 36.64,53.34 ; 13.77,361.95 UHC430.G1_8 ; UHC430.G1_8 14.58,361.14 ; UHC430.G1_8 15.39,361.95 ; UHC430.G1_8 14.58,362.76 ; 269.51,75.39 D106.A14 ; D106.A14 270.32,76.2 ; D106.A14 269.51,77.01 ; D106.A14 268.7,76.2 ; 259.35,95.71 D105.A10 ; D105.A10 260.16,96.52 ; D105.A10 258.54,96.52 ; D105.A10 259.35,97.33 ; 53.61,60.15 D119.B16 ; D119.B16 52.8,60.96 ; D119.B16 54.42,60.96 ; D119.B16 53.61,61.77 ; 112.03,377.65 D427.B8 ; D427.B8 111.22,378.46 ; D427.B8 112.84,378.46 ; D427.B8 112.03,379.27 ; 164.56,388.62 D116.B16 ; D116.B16 165.37,387.81 ; D116.B16 165.37,389.43 ; D116.B16 166.18,388.62 ; D105.B3 242.38,99.06 ; D105.B3 241.57,99.87 ; D105.B3 240.76,99.06 ; D105.B3 241.57,98.25 ; 172.99,52.53 D103.A5 ; D103.A5 172.18,53.34 ; D103.A5 173.8,53.34 ; D103.A5 172.99,54.15 ; 101.87,60.15 D123.B6 ; D123.B6 102.68,60.96 ; D123.B6 101.06,60.96 ; D123.B6 101.87,61.77 ; 238.22,388.62 D112.B16 ; D112.B16 239.03,387.81 ; D112.B16 239.03,389.43 ; D112.B16 239.84,388.62 ; D118.A6 28.21,77.01 ; D118.A6 29.02,76.2 ; D118.A6 28.21,75.39 ; D118.A6 27.4,76.2 ; 38.37,367.49 D231.B8 ; D231.B8 39.18,368.3 ; D231.B8 37.56,368.3 ; D231.B8 38.37,369.11 ; D231.A6 44.26,373.38 ; D231.A6 43.45,372.57 ; D231.A6 42.64,373.38 ; D231.A6 43.45,374.19 ; D114.B13 173.8,350.52 ; D114.B13 172.18,350.52 ; D114.B13 172.99,351.33 ; D114.B13 172.99,349.71 ; 172.99,354.79 D114.A13 ; D114.A13 172.18,355.6 ; D114.A13 172.99,356.41 ; D114.A13 173.8,355.6 ; D113.B16 165.37,328.47 ; D113.B16 165.37,326.85 ; D113.B16 164.56,327.66 ; D113.B16 166.18,327.66 ; 106.14,60.96 D123.B8 ; D123.B8 107.76,60.96 ; D123.B8 106.95,61.77 ; D123.B8 106.95,60.15 ; 198.39,390.35 D116.B3 ; D116.B3 197.58,391.16 ; D116.B3 199.2,391.16 ; D116.B3 198.39,391.97 ; 117.11,342.09 CSDPS425.B6 ; CSDPS425.B6 117.92,342.9 ; CSDPS425.B6 116.3,342.9 ; CSDPS425.B6 117.11,343.71 ; D116.A12 176.34,393.7 ; D116.A12 175.53,394.51 ; D116.A12 175.53,392.89 ; D116.A12 174.72,393.7 ; D108.B16 274.59,41.45 ; D108.B16 275.4,40.64 ; D108.B16 274.59,39.83 ; D108.B16 273.78,40.64 ; D119.B15 51.88,58.42 ; D119.B15 50.26,58.42 ; D119.B15 51.07,57.61 ; D119.B15 51.07,59.23 ; D118.B10 38.37,82.09 ; D118.B10 37.56,81.28 ; D118.B10 39.18,81.28 ; D118.B10 38.37,80.47 ; D228.A6 117.11,394.51 ; D228.A6 116.3,393.7 ; D228.A6 117.11,392.89 ; D228.A6 117.92,393.7 ; 121.38,55.88 D123.A14 ; D123.A14 123,55.88 ; D123.A14 122.19,55.07 ; D123.A14 122.19,56.69 ; 172.18,375.92 D115.A13 ; D115.A13 172.99,376.73 ; D115.A13 172.99,375.11 ; D115.A13 173.8,375.92 ; D119.B5 25.67,59.23 ; D119.B5 25.67,57.61 ; D119.B5 24.86,58.42 ; D119.B5 26.48,58.42 ; 25.67,98.25 D117.B5 ; D117.B5 24.86,99.06 ; D117.B5 26.48,99.06 ; D117.B5 25.67,99.87 ; 178.07,411.94 DPS2.B11 ; DPS2.B11 178.88,412.75 ; DPS2.B11 178.07,413.56 ; DPS2.B11 177.26,412.75 ; 192.5,73.66 D102.A13 ; D102.A13 193.31,72.85 ; D102.A13 193.31,74.47 ; D102.A13 194.12,73.66 ; D227.A15 94.25,376.73 ; D227.A15 94.25,375.11 ; D227.A15 93.44,375.92 ; D227.A15 95.06,375.92 ; 23.13,377.65 D431.B14 ; D431.B14 23.94,378.46 ; D431.B14 22.32,378.46 ; D431.B14 23.13,379.27 ; 261.89,390.35 D112.B7 ; D112.B7 261.08,391.16 ; D112.B7 261.89,391.97 ; D112.B7 262.7,391.16 ; D116.A1 204.28,396.24 ; D116.A1 203.47,395.43 ; D116.A1 203.47,397.05 ; D116.A1 202.66,396.24 ; D232.B6 43.45,389.43 ; D232.B6 42.64,388.62 ; D232.B6 43.45,387.81 ; D232.B6 44.26,388.62 ; UHC430.G1_13 14.58,359.26 ; UHC430.G1_13 13.77,358.45 ; UHC430.G1_13 15.39,358.45 ; UHC430.G1_13 14.58,357.64 ; 266.16,335.28 D109.A5 ; D109.A5 266.97,334.47 ; D109.A5 266.97,336.09 ; D109.A5 267.78,335.28 ; 93.44,370.84 D227.B15 ; D227.B15 95.06,370.84 ; D227.B15 94.25,370.03 ; D227.B15 94.25,371.65 ; 250.92,33.02 D108.A7 ; D108.A7 251.73,32.21 ; D108.A7 252.54,33.02 ; D108.A7 251.73,33.83 ; 114.57,359.87 CSDPS426.C7 ; CSDPS426.C7 114.57,361.49 ; CSDPS426.C7 115.38,360.68 ; CSDPS426.C7 113.76,360.68 ; 274.59,372.57 D111.A2 ; D111.A2 275.4,373.38 ; D111.A2 273.78,373.38 ; D111.A2 274.59,374.19 ; D231.B10 34.1,368.3 ; D231.B10 32.48,368.3 ; D231.B10 33.29,369.11 ; D231.B10 33.29,367.49 ; D115.B3 198.39,371.65 ; D115.B3 198.39,370.03 ; D115.B3 197.58,370.84 ; D115.B3 199.2,370.84 ; D107.B3 242.38,58.42 ; D107.B3 240.76,58.42 ; D107.B3 241.57,59.23 ; D107.B3 241.57,57.61 ; D124.B5 100.14,38.1 ; D124.B5 99.33,37.29 ; D124.B5 98.52,38.1 ; D124.B5 99.33,38.91 ; 56.15,385.27 D431.A1 ; D431.A1 56.15,386.89 ; D431.A1 56.96,386.08 ; D431.A1 55.34,386.08 ; D112.A7 262.7,396.24 ; D112.A7 261.89,395.43 ; D112.A7 261.08,396.24 ; D112.A7 261.89,397.05 ; D119.B2 18.05,61.77 ; D119.B2 18.05,60.15 ; D119.B2 17.24,60.96 ; D119.B2 18.86,60.96 ; 103.6,99.06 D121.B7 ; D121.B7 105.22,99.06 ; D121.B7 104.41,99.87 ; D121.B7 104.41,98.25 ; D431.B1 56.96,381 ; D431.B1 56.15,380.19 ; D431.B1 55.34,381 ; D431.B1 56.15,381.81 ; 240.76,78.74 D106.B3 ; D106.B3 241.57,79.55 ; D106.B3 242.38,78.74 ; D106.B3 241.57,77.93 ; 190.77,392.89 D116.A6 ; D116.A6 189.96,393.7 ; D116.A6 190.77,394.51 ; D116.A6 191.58,393.7 ; 184.88,327.66 D113.B8 ; D113.B8 185.69,326.85 ; D113.B8 185.69,328.47 ; D113.B8 186.5,327.66 ; 235.68,58.42 D107.B1 ; D107.B1 236.49,59.23 ; D107.B1 237.3,58.42 ; D107.B1 236.49,57.61 ; 38.37,39.83 D120.B10 ; D120.B10 38.37,41.45 ; D120.B10 39.18,40.64 ; D120.B10 37.56,40.64 ; 98.52,19.05 DPS3.C05 ; DPS3.C05 100.14,19.05 ; DPS3.C05 99.33,18.24 ; DPS3.C05 99.33,19.86 ; 106.14,398.78 D428.B10 ; D428.B10 107.76,398.78 ; D428.B10 106.95,399.59 ; D428.B10 106.95,397.97 ; 185.69,95.71 D101.A10 ; D101.A10 186.5,96.52 ; D101.A10 185.69,97.33 ; D101.A10 184.88,96.52 ; D113.A9 183.15,336.09 ; D113.A9 182.34,335.28 ; D113.A9 183.15,334.47 ; D113.A9 183.96,335.28 ; D110.A2 274.59,353.87 ; D110.A2 275.4,353.06 ; D110.A2 274.59,352.25 ; D110.A2 273.78,353.06 ; D112.A10 255.08,393.7 ; D112.A10 254.27,394.51 ; D112.A10 254.27,392.89 ; D112.A10 253.46,393.7 ; 88.36,99.06 D121.B1 ; D121.B1 89.17,98.25 ; D121.B1 89.98,99.06 ; D121.B1 89.17,99.87 ; D102.B9 183.15,79.55 ; D102.B9 183.15,77.93 ; D102.B9 183.96,78.74 ; D102.B9 182.34,78.74 ; D108.A4 244.11,36.37 ; D108.A4 244.92,35.56 ; D108.A4 244.11,34.75 ; D108.A4 243.3,35.56 ; D116.B8 186.5,388.62 ; D116.B8 185.69,387.81 ; D116.B8 184.88,388.62 ; D116.B8 185.69,389.43 ; 35.02,370.84 D231.B9 ; D231.B9 36.64,370.84 ; D231.B9 35.83,371.65 ; D231.B9 35.83,370.03 ; D232.A1 56.96,396.24 ; D232.A1 56.15,395.43 ; D232.A1 56.15,397.05 ; D232.A1 55.34,396.24 ; 261.08,33.02 D108.A11 ; D108.A11 261.89,33.83 ; D108.A11 261.89,32.21 ; D108.A11 262.7,33.02 ; D103.A1 163.64,53.34 ; D103.A1 162.83,54.15 ; D103.A1 162.83,52.53 ; D103.A1 162.02,53.34 ; D101.B14 196.66,101.6 ; D101.B14 195.85,100.79 ; D101.B14 195.04,101.6 ; D101.B14 195.85,102.41 ; 118.84,370.84 D227.B5 ; D227.B5 120.46,370.84 ; D227.B5 119.65,370.03 ; D227.B5 119.65,371.65 ; D117.B6 29.02,101.6 ; D117.B6 27.4,101.6 ; D117.B6 28.21,100.79 ; D117.B6 28.21,102.41 ; D124.A14 123,35.56 ; D124.A14 122.19,36.37 ; D124.A14 121.38,35.56 ; D124.A14 122.19,34.75 ; 29.94,53.34 D119.A7 ; D119.A7 31.56,53.34 ; D119.A7 30.75,52.53 ; D119.A7 30.75,54.15 ; D110.B10 254.27,348.79 ; D110.B10 253.46,347.98 ; D110.B10 254.27,347.17 ; D110.B10 255.08,347.98 ; D432.B13 26.48,401.32 ; D432.B13 24.86,401.32 ; D432.B13 25.67,400.51 ; D432.B13 25.67,402.13 ; D108.A1 237.3,33.02 ; D108.A1 235.68,33.02 ; D108.A1 236.49,33.83 ; D108.A1 236.49,32.21 ; 19.78,93.98 D117.A3 ; D117.A3 20.59,94.79 ; D117.A3 20.59,93.17 ; D117.A3 21.4,93.98 ; D432.A15 20.59,407.21 ; D432.A15 21.4,406.4 ; D432.A15 20.59,405.59 ; D432.A15 19.78,406.4 ; D110.B13 246.65,351.33 ; D110.B13 245.84,350.52 ; D110.B13 247.46,350.52 ; D110.B13 246.65,349.71 ; 164.56,81.28 D102.B2 ; D102.B2 165.37,80.47 ; D102.B2 166.18,81.28 ; D102.B2 165.37,82.09 ; 251.73,395.43 D112.A11 ; D112.A11 250.92,396.24 ; D112.A11 251.73,397.05 ; D112.A11 252.54,396.24 ; 94.25,329.39 CSDPS225.C15 ; CSDPS225.C15 95.06,330.2 ; CSDPS225.C15 94.25,331.01 ; CSDPS225.C15 93.44,330.2 ; D432.B12 29.02,398.78 ; D432.B12 27.4,398.78 ; D432.B12 28.21,397.97 ; D432.B12 28.21,399.59 ; D120.A14 48.53,36.37 ; D120.A14 47.72,35.56 ; D120.A14 49.34,35.56 ; D120.A14 48.53,34.75 ; 248.38,327.66 D109.B12 ; D109.B12 249.19,328.47 ; D109.B12 249.19,326.85 ; D109.B12 250,327.66 ; 238.22,332.74 D109.A16 ; D109.A16 239.03,333.55 ; D109.A16 239.84,332.74 ; D109.A16 239.03,331.93 ; 162.02,73.66 D102.A1 ; D102.A1 162.83,74.47 ; D102.A1 163.64,73.66 ; D102.A1 162.83,72.85 ; 126.46,368.3 D227.B2 ; D227.B2 128.08,368.3 ; D227.B2 127.27,369.11 ; D227.B2 127.27,367.49 ; 53.61,55.07 D119.A16 ; D119.A16 53.61,56.69 ; D119.A16 54.42,55.88 ; D119.A16 52.8,55.88 ; 170.45,347.17 D114.B14 ; D114.B14 171.26,347.98 ; D114.B14 169.64,347.98 ; D114.B14 170.45,348.79 ; 19.18,354.48 UHC230.G4_1 ; UHC230.G4_1 19.99,355.29 ; UHC230.G4_1 19.18,356.1 ; UHC230.G4_1 18.37,355.29 ; 20.59,57.61 D119.B3 ; D119.B3 20.59,59.23 ; D119.B3 21.4,58.42 ; D119.B3 19.78,58.42 ; D116.B6 191.58,388.62 ; D116.B6 189.96,388.62 ; D116.B6 190.77,387.81 ; D116.B6 190.77,389.43 ; D103.A10 185.69,56.69 ; D103.A10 184.88,55.88 ; D103.A10 186.5,55.88 ; D103.A10 185.69,55.07 ; 40.91,72.85 D118.A11 ; D118.A11 41.72,73.66 ; D118.A11 40.91,74.47 ; D118.A11 40.1,73.66 ; 178.07,349.71 D114.B11 ; D114.B11 177.26,350.52 ; D114.B11 178.88,350.52 ; D114.B11 178.07,351.33 ; 245.84,335.28 D109.A13 ; D109.A13 247.46,335.28 ; D109.A13 246.65,334.47 ; D109.A13 246.65,336.09 ; 93.44,396.24 D228.A15 ; D228.A15 94.25,395.43 ; D228.A15 94.25,397.05 ; D228.A15 95.06,396.24 ; 179.8,388.62 D116.B10 ; D116.B10 180.61,389.43 ; D116.B10 180.61,387.81 ; D116.B10 181.42,388.62 ; 239.03,347.17 D110.B16 ; D110.B16 239.84,347.98 ; D110.B16 238.22,347.98 ; D110.B16 239.03,348.79 ; D121.A15 124.73,94.79 ; D121.A15 124.73,93.17 ; D121.A15 125.54,93.98 ; D121.A15 123.92,93.98 ; D123.B2 92.52,60.96 ; D123.B2 90.9,60.96 ; D123.B2 91.71,60.15 ; D123.B2 91.71,61.77 ; D121.A16 128.08,96.52 ; D121.A16 127.27,95.71 ; D121.A16 127.27,97.33 ; D121.A16 126.46,96.52 ; 53.36,155.6 KS4.6 ; KS4.6 52.24,156.72 ; KS4.6 54.47,156.72 ; KS4.6 53.36,157.84 ; 23.13,34.75 D120.A4 ; D120.A4 22.32,35.56 ; D120.A4 23.13,36.37 ; D120.A4 23.94,35.56 ; 14.7,93.98 D117.A1 ; D117.A1 15.51,93.17 ; D117.A1 15.51,94.79 ; D117.A1 16.32,93.98 ; 88.36,396.24 D228.A17 ; D228.A17 89.17,397.05 ; D228.A17 89.98,396.24 ; D228.A17 89.17,395.43 ; 180.61,372.57 D115.A10 ; D115.A10 180.61,374.19 ; D115.A10 181.42,373.38 ; D115.A10 179.8,373.38 ; 127.27,100.79 D121.B16 ; D121.B16 126.46,101.6 ; D121.B16 128.08,101.6 ; D121.B16 127.27,102.41 ; CSDPS426.C5 119.65,361.49 ; CSDPS426.C5 119.65,359.87 ; CSDPS426.C5 118.84,360.68 ; CSDPS426.C5 120.46,360.68 ; D104.B11 189.04,38.1 ; D104.B11 187.42,38.1 ; D104.B11 188.23,37.29 ; D104.B11 188.23,38.91 ; 103.6,396.24 D228.A11 ; D228.A11 104.41,395.43 ; D228.A11 105.22,396.24 ; D228.A11 104.41,397.05 ; 45.99,98.25 D117.B13 ; D117.B13 45.18,99.06 ; D117.B13 45.99,99.87 ; D107.A13 267.78,53.34 ; D107.A13 266.97,54.15 ; D107.A13 266.16,53.34 ; D107.A13 266.97,52.53 ; 256,396.24 D112.A9 ; D112.A9 256.81,395.43 ; D112.A9 257.62,396.24 ; D112.A9 256.81,397.05 ; 37.56,378.46 D431.B8 ; D431.B8 38.37,377.65 ; D431.B8 38.37,379.27 ; D431.B8 39.18,378.46 ; D123.B12 117.92,60.96 ; D123.B12 117.11,60.15 ; D123.B12 117.11,61.77 ; D123.B12 116.3,60.96 ; 185.69,352.25 D114.A8 ; D114.A8 184.88,353.06 ; D114.A8 185.69,353.87 ; D114.A8 186.5,353.06 ; 269.51,80.47 D106.B14 ; D106.B14 270.32,81.28 ; D106.B14 268.7,81.28 ; D106.B14 269.51,82.09 ; D111.B15 242.38,370.84 ; D111.B15 240.76,370.84 ; D111.B15 241.57,371.65 ; D111.B15 241.57,370.03 ; D109.A2 274.59,333.55 ; D109.A2 275.4,332.74 ; D109.A2 273.78,332.74 ; D109.A2 274.59,331.93 ; D123.A9 109.49,54.15 ; D123.A9 110.3,53.34 ; D123.A9 109.49,52.53 ; D123.A9 108.68,53.34 ; DPS2.B05 194.12,412.75 ; DPS2.B05 192.5,412.75 ; DPS2.B05 193.31,413.56 ; DPS2.B05 193.31,411.94 ; D104.A13 193.31,33.83 ; D104.A13 192.5,33.02 ; D104.A13 194.12,33.02 ; D104.A13 193.31,32.21 ; D121.A10 112.84,96.52 ; D121.A10 111.22,96.52 ; D121.A10 112.03,97.33 ; D121.A10 112.03,95.71 ; 254.27,372.57 D111.A10 ; D111.A10 254.27,374.19 ; D111.A10 253.46,373.38 ; D111.A10 255.08,373.38 ; 250.92,350.52 D110.B11 ; D110.B11 252.54,350.52 ; D110.B11 251.73,349.71 ; D110.B11 251.73,351.33 ; D115.A14 171.26,373.38 ; D115.A14 170.45,374.19 ; D115.A14 169.64,373.38 ; D115.A14 170.45,372.57 ; D112.B12 250,388.62 ; D112.B12 248.38,388.62 ; D112.B12 249.19,389.43 ; D112.B12 249.19,387.81 ; 272.05,375.11 D111.A3 ; D111.A3 272.86,375.92 ; D111.A3 271.24,375.92 ; D111.A3 272.05,376.73 ; 273.78,368.3 D111.B2 ; D111.B2 274.59,369.11 ; D111.B2 275.4,368.3 ; D111.B2 274.59,367.49 ; 246.65,72.85 D106.A5 ; D106.A5 247.46,73.66 ; D106.A5 246.65,74.47 ; D106.A5 245.84,73.66 ; 124.73,349.71 CSDPS226.C3 ; CSDPS226.C3 125.54,350.52 ; CSDPS226.C3 123.92,350.52 ; CSDPS226.C3 124.73,351.33 ; 113.76,375.92 D227.A7 ; D227.A7 114.57,376.73 ; D227.A7 114.57,375.11 ; D227.A7 115.38,375.92 ; CSDPS425.C13 100.14,340.36 ; CSDPS425.C13 98.52,340.36 ; CSDPS425.C13 99.33,339.55 ; CSDPS425.C13 99.33,341.17 ; CSDPS429.B2 53.61,343.71 ; CSDPS429.B2 54.42,342.9 ; CSDPS429.B2 52.8,342.9 ; CSDPS429.B2 53.61,342.09 ; D232.B4 49.34,388.62 ; D232.B4 48.53,387.81 ; D232.B4 47.72,388.62 ; D232.B4 48.53,389.43 ; 55.34,330.2 CSDPS229.C1 ; CSDPS229.C1 56.15,329.39 ; CSDPS229.C1 56.96,330.2 ; CSDPS229.C1 56.15,331.01 ; D121.B5 100.14,99.06 ; D121.B5 99.33,98.25 ; D121.B5 98.52,99.06 ; D121.B5 99.33,99.87 ; D231.B14 23.13,369.11 ; D231.B14 23.13,367.49 ; D231.B14 22.32,368.3 ; D231.B14 23.94,368.3 ; D117.A14 49.34,96.52 ; D117.A14 47.72,96.52 ; D117.A14 48.53,97.33 ; D117.A14 48.53,95.71 ; 106.95,80.47 D122.B8 ; D122.B8 106.95,82.09 ; D122.B8 107.76,81.28 ; D122.B8 106.14,81.28 ; CSDPS429.C11 31.56,340.36 ; CSDPS429.C11 30.75,339.55 ; CSDPS429.C11 29.94,340.36 ; CSDPS429.C11 30.75,341.17 ; 114.57,52.53 D123.A11 ; D123.A11 115.38,53.34 ; D123.A11 113.76,53.34 ; D123.A11 114.57,54.15 ; D232.A3 51.88,396.24 ; D232.A3 51.07,397.05 ; D232.A3 50.26,396.24 ; D232.A3 51.07,395.43 ; 241.57,37.29 D108.B3 ; D108.B3 242.38,38.1 ; D108.B3 240.76,38.1 ; D108.B3 241.57,38.91 ; CSDPS225.C3 125.54,330.2 ; CSDPS225.C3 124.73,331.01 ; CSDPS225.C3 123.92,330.2 ; CSDPS225.C3 124.73,329.39 ; D110.B15 241.57,351.33 ; D110.B15 242.38,350.52 ; D110.B15 241.57,349.71 ; D110.B15 240.76,350.52 ; D432.B7 41.72,401.32 ; D432.B7 40.1,401.32 ; D432.B7 40.91,400.51 ; D432.B7 40.91,402.13 ; 184.88,60.96 D103.B10 ; D103.B10 185.69,61.77 ; D103.B10 185.69,60.15 ; D103.B10 186.5,60.96 ; D109.A6 264.43,333.55 ; D109.A6 263.62,332.74 ; D109.A6 264.43,331.93 ; D109.A6 265.24,332.74 ; D123.A1 89.98,53.34 ; D123.A1 89.17,52.53 ; D123.A1 88.36,53.34 ; D123.A1 89.17,54.15 ; 88.36,38.1 D124.B1 ; D124.B1 89.17,37.29 ; D124.B1 89.17,38.91 ; D124.B1 89.98,38.1 ; 203.47,411.94 DPS2.B01 ; DPS2.B01 202.66,412.75 ; DPS2.B01 203.47,413.56 ; DPS2.B01 204.28,412.75 ; D111.B12 250,368.3 ; D111.B12 249.19,367.49 ; D111.B12 249.19,369.11 ; D111.B12 248.38,368.3 ; 16.88,350.98 UHC230.G4 ; UHC230.G4 17.69,351.79 ; UHC230.G4 16.88,352.6 ; UHC230.G4 16.07,351.79 ; D120.B3 21.4,38.1 ; D120.B3 19.78,38.1 ; D120.B3 20.59,38.91 ; D120.B3 20.59,37.29 ; 95.98,378.46 D427.B14 ; D427.B14 97.6,378.46 ; D427.B14 96.79,377.65 ; D427.B14 96.79,379.27 ; DPS3.A11 115.38,13.97 ; DPS3.A11 114.57,13.16 ; DPS3.A11 114.57,14.78 ; DPS3.A11 113.76,13.97 ; D124.B15 125.54,38.1 ; D124.B15 123.92,38.1 ; D124.B15 124.73,38.91 ; D124.B15 124.73,37.29 ; D102.B10 185.69,82.09 ; D102.B10 185.69,80.47 ; D102.B10 184.88,81.28 ; D102.B10 186.5,81.28 ; DPS1.A01 236.49,14.78 ; DPS1.A01 237.3,13.97 ; DPS1.A01 236.49,13.16 ; DPS1.A01 235.68,13.97 ; 16.88,364.64 UHC430.G1_2 ; UHC430.G1_2 16.88,366.26 ; UHC430.G1_2 16.07,365.45 ; UHC430.G1_2 17.69,365.45 ; D120.A1 15.51,33.83 ; D120.A1 14.7,33.02 ; D120.A1 16.32,33.02 ; D120.A1 15.51,32.21 ; 95.98,363.22 CSDPS426.B14 ; CSDPS426.B14 96.79,362.41 ; CSDPS426.B14 97.6,363.22 ; CSDPS426.B14 96.79,364.03 ; 19.78,386.08 D431.A15 ; D431.A15 20.59,386.89 ; D431.A15 21.4,386.08 ; D431.A15 20.59,385.27 ; D109.B8 259.35,328.47 ; D109.B8 259.35,326.85 ; D109.B8 258.54,327.66 ; D109.B8 260.16,327.66 ; 52.8,76.2 D118.A16 ; D118.A16 53.61,77.01 ; D118.A16 54.42,76.2 ; D118.A16 53.61,75.39 ; D109.A10 255.08,332.74 ; D109.A10 254.27,331.93 ; D109.A10 254.27,333.55 ; D109.A10 253.46,332.74 ; 197.58,330.2 D113.B3 ; D113.B3 198.39,329.39 ; D113.B3 198.39,331.01 ; D113.B3 199.2,330.2 ; D428.B14 96.79,399.59 ; D428.B14 97.6,398.78 ; D428.B14 96.79,397.97 ; D428.B14 95.98,398.78 ; D121.A11 115.38,93.98 ; D121.A11 114.57,94.79 ; D121.A11 114.57,93.17 ; D121.A11 113.76,93.98 ; 99.33,385.27 D427.A13 ; D427.A13 99.33,386.89 ; D427.A13 100.14,386.08 ; D427.A13 98.52,386.08 ; 14.7,73.66 D118.A1 ; D118.A1 15.51,72.85 ; D118.A1 16.32,73.66 ; D118.A1 15.51,74.47 ; 188.23,98.25 D101.B11 ; D101.B11 189.04,99.06 ; D101.B11 187.42,99.06 ; D101.B11 188.23,99.87 ; 126.46,35.56 D124.A16 ; D124.A16 127.27,36.37 ; D124.A16 127.27,34.75 ; D124.A16 128.08,35.56 ; 172.99,32.21 D104.A5 ; D104.A5 172.18,33.02 ; D104.A5 173.8,33.02 ; D104.A5 172.99,33.83 ; 109.49,380.19 D427.B9 ; D427.B9 110.3,381 ; D427.B9 109.49,381.81 ; D427.B9 108.68,381 ; 195.85,326.85 D113.B4 ; D113.B4 195.04,327.66 ; D113.B4 195.85,328.47 ; D113.B4 196.66,327.66 ; D118.A12 44.26,76.2 ; D118.A12 42.64,76.2 ; D118.A12 43.45,75.39 ; D118.A12 43.45,77.01 ; D114.A5 193.31,356.41 ; D114.A5 194.12,355.6 ; D114.A5 193.31,354.79 ; D114.A5 192.5,355.6 ; D118.B12 43.45,82.09 ; D118.B12 43.45,80.47 ; D118.B12 42.64,81.28 ; D118.B12 44.26,81.28 ; D227.B4 122.19,369.11 ; D227.B4 121.38,368.3 ; D227.B4 122.19,367.49 ; D227.B4 123,368.3 ; 170.45,352.25 D114.A14 ; D114.A14 169.64,353.06 ; D114.A14 171.26,353.06 ; D114.A14 170.45,353.87 ; D105.A3 241.57,94.79 ; D105.A3 242.38,93.98 ; D105.A3 241.57,93.17 ; D105.A3 240.76,93.98 ; D114.B2 200.93,348.79 ; D114.B2 201.74,347.98 ; D114.B2 200.12,347.98 ; D114.B2 200.93,347.17 ; 256,58.42 D107.B9 ; D107.B9 256.81,59.23 ; D107.B9 256.81,57.61 ; D107.B9 257.62,58.42 ; D113.A15 167.91,336.09 ; D113.A15 167.1,335.28 ; D113.A15 167.91,334.47 ; D113.A15 168.72,335.28 ; D105.A7 251.73,94.79 ; D105.A7 250.92,93.98 ; D105.A7 251.73,93.17 ; D105.A7 252.54,93.98 ; D102.A5 172.99,74.47 ; D102.A5 173.8,73.66 ; D102.A5 172.18,73.66 ; D102.A5 172.99,72.85 ; 254.27,95.71 D105.A8 ; D105.A8 254.27,97.33 ; D105.A8 253.46,96.52 ; D105.A8 255.08,96.52 ; D118.A3 20.59,74.47 ; D118.A3 21.4,73.66 ; D118.A3 20.59,72.85 ; D118.A3 19.78,73.66 ; 109.49,329.39 CSDPS225.C9 ; CSDPS225.C9 108.68,330.2 ; CSDPS225.C9 110.3,330.2 ; CSDPS225.C9 109.49,331.01 ; D104.B14 196.66,40.64 ; D104.B14 195.85,41.45 ; D104.B14 195.04,40.64 ; D104.B14 195.85,39.83 ; D107.A12 265.24,55.88 ; D107.A12 263.62,55.88 ; D107.A12 264.43,56.69 ; D107.A12 264.43,55.07 ; 193.31,370.03 D115.B5 ; D115.B5 194.12,370.84 ; D115.B5 192.5,370.84 ; D115.B5 193.31,371.65 ; D103.B8 180.61,61.77 ; D103.B8 181.42,60.96 ; D103.B8 179.8,60.96 ; D103.B8 180.61,60.15 ; 249.19,39.83 D108.B6 ; D108.B6 249.19,41.45 ; D108.B6 248.38,40.64 ; D108.B6 250,40.64 ; D109.A3 272.86,335.28 ; D109.A3 271.24,335.28 ; D109.A3 272.05,336.09 ; D109.A3 272.05,334.47 ; D110.A1 277.94,355.6 ; D110.A1 277.13,354.79 ; D110.A1 276.32,355.6 ; D110.A1 277.13,356.41 ; D120.A8 34.1,35.56 ; D120.A8 32.48,35.56 ; D120.A8 33.29,36.37 ; D120.A8 33.29,34.75 ; D106.A16 274.59,77.01 ; D106.A16 274.59,75.39 ; D106.A16 273.78,76.2 ; D106.A16 275.4,76.2 ; 127.27,403.05 D428.A2 ; D428.A2 127.27,404.67 ; D428.A2 126.46,403.86 ; D428.A2 128.08,403.86 ; 56.15,390.35 D232.B1 ; D232.B1 55.34,391.16 ; D232.B1 56.96,391.16 ; D232.B1 56.15,391.97 ; 261.89,98.25 D105.B11 ; D105.B11 261.89,99.87 ; D105.B11 262.7,99.06 ; D105.B11 261.08,99.06 ; D116.B11 178.07,391.97 ; D116.B11 177.26,391.16 ; D116.B11 178.07,390.35 ; D116.B11 178.88,391.16 ; 235.68,16.51 DPS1.B01 ; DPS1.B01 236.49,17.32 ; DPS1.B01 237.3,16.51 ; DPS1.B01 236.49,15.7 ; D114.B4 196.66,347.98 ; D114.B4 195.85,348.79 ; D114.B4 195.85,347.17 ; D114.B4 195.04,347.98 ; D103.A8 180.61,56.69 ; D103.A8 181.42,55.88 ; D103.A8 179.8,55.88 ; D103.A8 180.61,55.07 ; D118.B14 48.53,82.09 ; D118.B14 47.72,81.28 ; D118.B14 48.53,80.47 ; D118.B14 49.34,81.28 ; 258.54,35.56 D108.A10 ; D108.A10 259.35,36.37 ; D108.A10 259.35,34.75 ; D108.A10 260.16,35.56 ; UHC230.G4_10 15.73,350.85 ; UHC230.G4_10 16.54,350.04 ; UHC230.G4_10 14.92,350.04 ; UHC230.G4_10 15.73,349.23 ; D117.A5 26.48,93.98 ; D117.A5 25.67,93.17 ; D117.A5 24.86,93.98 ; D117.A5 25.67,94.79 ; D111.B1 277.94,370.84 ; D111.B1 276.32,370.84 ; D111.B1 277.13,371.65 ; D111.B1 277.13,370.03 ; 179.8,368.3 D115.B10 ; D115.B10 181.42,368.3 ; D115.B10 180.61,367.49 ; D115.B10 180.61,369.11 ; D112.A14 244.11,394.51 ; D112.A14 244.11,392.89 ; D112.A14 244.92,393.7 ; D112.A14 243.3,393.7 ; CSDPS429.C13 25.67,341.17 ; CSDPS429.C13 24.86,340.36 ; CSDPS429.C13 26.48,340.36 ; CSDPS429.C13 25.67,339.55 ; 51.07,52.53 D119.A15 ; D119.A15 51.07,54.15 ; D119.A15 51.88,53.34 ; D119.A15 50.26,53.34 ; D101.A2 166.18,96.52 ; D101.A2 165.37,95.71 ; D101.A2 165.37,97.33 ; D101.A2 164.56,96.52 ; D109.A14 244.11,333.55 ; D109.A14 243.3,332.74 ; D109.A14 244.11,331.93 ; D109.A14 244.92,332.74 ; D107.A14 270.32,55.88 ; D107.A14 269.51,56.69 ; D107.A14 268.7,55.88 ; D107.A14 269.51,55.07 ; D124.A8 106.95,36.37 ; D124.A8 107.76,35.56 ; D124.A8 106.95,34.75 ; D124.A8 106.14,35.56 ; UHC430.G1_4 18.03,364.51 ; UHC430.G1_4 17.22,363.7 ; UHC430.G1_4 18.84,363.7 ; UHC430.G1_4 18.03,362.89 ; 56.15,339.55 CSDPS429.C1 ; CSDPS429.C1 56.96,340.36 ; CSDPS429.C1 55.34,340.36 ; CSDPS429.C1 56.15,341.17 ; 95.98,373.38 D227.A14 ; D227.A14 96.79,372.57 ; D227.A14 97.6,373.38 ; D227.A14 96.79,374.19 ; 40.1,406.4 D432.A7 ; D432.A7 41.72,406.4 ; D432.A7 40.91,405.59 ; D432.A7 40.91,407.21 ; CSDPS225.B8 112.03,333.55 ; CSDPS225.B8 112.84,332.74 ; CSDPS225.B8 112.03,331.93 ; CSDPS225.B8 111.22,332.74 ; D120.A12 44.26,35.56 ; D120.A12 42.64,35.56 ; D120.A12 43.45,36.37 ; D120.A12 43.45,34.75 ; 53.61,95.71 D117.A16 ; D117.A16 52.8,96.52 ; D117.A16 54.42,96.52 ; D117.A16 53.61,97.33 ; 164.56,35.56 D104.A2 ; D104.A2 165.37,36.37 ; D104.A2 166.18,35.56 ; D104.A2 165.37,34.75 ; D121.B15 124.73,99.87 ; D121.B15 124.73,98.25 ; D121.B15 123.92,99.06 ; D121.B15 125.54,99.06 ; D112.A8 259.35,394.51 ; D112.A8 259.35,392.89 ; D112.A8 260.16,393.7 ; D112.A8 258.54,393.7 ; 19.78,401.32 D432.B15 ; D432.B15 20.59,402.13 ; D432.B15 20.59,400.51 ; D432.B15 21.4,401.32 ; UHC230.G4_4 18.84,353.54 ; UHC230.G4_4 18.03,354.35 ; UHC230.G4_4 17.22,353.54 ; UHC230.G4_4 18.03,352.73 ; 266.16,73.66 D106.A13 ; D106.A13 266.97,74.47 ; D106.A13 267.78,73.66 ; D106.A13 266.97,72.85 ; CSDPS426.C9 110.3,360.68 ; CSDPS426.C9 109.49,359.87 ; CSDPS426.C9 109.49,361.49 ; CSDPS426.C9 108.68,360.68 ; 164.56,101.6 D101.B2 ; D101.B2 165.37,102.41 ; D101.B2 165.37,100.79 ; D101.B2 166.18,101.6 ; D109.A11 252.54,335.28 ; D109.A11 251.73,336.09 ; D109.A11 250.92,335.28 ; D109.A11 251.73,334.47 ; CSDPS229.B2 54.42,332.74 ; CSDPS229.B2 53.61,331.93 ; CSDPS229.B2 53.61,333.55 ; CSDPS229.B2 52.8,332.74 ; 119.65,380.19 D427.B5 ; D427.B5 120.46,381 ; D427.B5 118.84,381 ; D427.B5 119.65,381.81 ; 162.02,78.74 D102.B1 ; D102.B1 163.64,78.74 ; D102.B1 162.83,79.55 ; D102.B1 162.83,77.93 ; D110.B6 264.43,348.79 ; D110.B6 263.62,347.98 ; D110.B6 265.24,347.98 ; D110.B6 264.43,347.17 ; 250.92,78.74 D106.B7 ; D106.B7 251.73,79.55 ; D106.B7 252.54,78.74 ; D106.B7 251.73,77.93 ; UHC230.G3_10 46.34,350.04 ; UHC230.G3_10 44.72,350.04 ; UHC230.G3_10 45.53,349.23 ; UHC230.G3_10 45.53,350.85 ; D102.B12 190.77,82.09 ; D102.B12 190.77,80.47 ; D102.B12 191.58,81.28 ; D102.B12 189.96,81.28 ; D431.B4 49.34,378.46 ; D431.B4 48.53,379.27 ; D431.B4 48.53,377.65 ; D431.B4 47.72,378.46 ; D119.B7 30.75,59.23 ; D119.B7 30.75,57.61 ; D119.B7 29.94,58.42 ; D119.B7 31.56,58.42 ; D232.A13 26.48,396.24 ; D232.A13 24.86,396.24 ; D232.A13 25.67,397.05 ; D232.A13 25.67,395.43 ; 91.71,403.05 D428.A16 ; D428.A16 90.9,403.86 ; D428.A16 92.52,403.86 ; D428.A16 91.71,404.67 ; D106.B10 259.35,82.09 ; D106.B10 258.54,81.28 ; D106.B10 260.16,81.28 ; D106.B10 259.35,80.47 ; 89.17,380.19 D427.B17 ; D427.B17 89.98,381 ; D427.B17 88.36,381 ; D427.B17 89.17,381.81 ; D102.B3 167.91,79.55 ; D102.B3 167.1,78.74 ; D102.B3 167.91,77.93 ; D102.B3 168.72,78.74
  L04_DGND w0.203: D231.A13 26.48,375.92 ; D231.A13 24.86,375.92 ; D231.A13 25.67,375.11 ; D231.A13 25.67,376.73 ; D432.B3 51.07,402.13 ; D432.B3 50.26,401.32 ; D432.B3 51.07,400.51 ; D432.B3 51.88,401.32 ; 184.88,40.64 D104.B10 ; D104.B10 186.5,40.64 ; D104.B10 185.69,41.45 ; D104.B10 185.69,39.83 ; D432.B16 18.86,398.78 ; D432.B16 18.05,397.97 ; D432.B16 18.05,399.59 ; D432.B16 17.24,398.78 ; D102.B10 185.69,82.09 ; D102.B10 186.5,81.28 ; D102.B10 185.69,80.47 ; D102.B10 184.88,81.28 ; 238.22,332.74 D109.A16 ; D109.A16 239.03,331.93 ; D109.A16 239.84,332.74 ; D109.A16 239.03,333.55 ; D427.A10 106.95,384.35 ; D427.A10 106.14,383.54 ; D427.A10 106.95,382.73 ; D427.A10 107.76,383.54 ; D115.A10 181.42,373.38 ; D115.A10 179.8,373.38 ; D115.A10 180.61,374.19 ; D115.A10 180.61,372.57 ; 20.59,409.4 DPS8.C15 ; DPS8.C15 21.4,410.21 ; DPS8.C15 20.59,411.02 ; DPS8.C15 19.78,410.21 ; D427.A13 100.14,386.08 ; D427.A13 99.33,385.27 ; D427.A13 99.33,386.89 ; D427.A13 98.52,386.08 ; 29.94,33.02 D120.A7 ; D120.A7 30.75,33.83 ; D120.A7 31.56,33.02 ; D120.A7 30.75,32.21 ; D103.B5 173.8,58.42 ; D103.B5 172.99,59.23 ; D103.B5 172.99,57.61 ; D103.B5 172.18,58.42 ; 47.72,35.56 D120.A14 ; D120.A14 49.34,35.56 ; D120.A14 48.53,34.75 ; D120.A14 48.53,36.37 ; 263.62,327.66 D109.B6 ; D109.B6 264.43,326.85 ; D109.B6 265.24,327.66 ; D109.B6 264.43,328.47 ; 200.12,347.98 D114.B2 ; D114.B2 200.93,348.79 ; D114.B2 201.74,347.98 ; D114.B2 200.93,347.17 ; 200.12,368.3 D115.B2 ; D115.B2 201.74,368.3 ; D115.B2 200.93,367.49 ; D115.B2 200.93,369.11 ; D428.A5 120.46,406.4 ; D428.A5 118.84,406.4 ; D428.A5 119.65,407.21 ; D428.A5 119.65,405.59 ; 104.41,339.55 CSDPS425.C11 ; CSDPS425.C11 103.6,340.36 ; CSDPS425.C11 105.22,340.36 ; CSDPS425.C11 104.41,341.17 ; D112.A11 251.73,397.05 ; D112.A11 252.54,396.24 ; D112.A11 251.73,395.43 ; D112.A11 250.92,396.24 ; 277.13,329.39 D109.B1 ; D109.B1 277.13,331.01 ; D109.B1 276.32,330.2 ; D109.B1 277.94,330.2 ; UHC230.G4_6 19.99,351.79 ; UHC230.G4_6 18.37,351.79 ; UHC230.G4_6 19.18,350.98 ; UHC230.G4_6 19.18,352.6 ; 266.16,58.42 D107.B13 ; D107.B13 267.78,58.42 ; D107.B13 266.97,57.61 ; D107.B13 266.97,59.23 ; 184.88,60.96 D103.B10 ; D103.B10 185.69,61.77 ; D103.B10 186.5,60.96 ; D103.B10 185.69,60.15 ; 127.27,367.49 D227.B2 ; D227.B2 128.08,368.3 ; D227.B2 127.27,369.11 ; D227.B2 126.46,368.3 ; 15.51,380.19 D431.B17 ; D431.B17 15.51,381.81 ; D431.B17 14.7,381 ; D431.B17 16.32,381 ; 56.15,400.51 D432.B1 ; D432.B1 56.96,401.32 ; D432.B1 55.34,401.32 ; D432.B1 56.15,402.13 ; D121.A11 114.57,94.79 ; D121.A11 115.38,93.98 ; D121.A11 114.57,93.17 ; D121.A11 113.76,93.98 ; 246.65,349.71 D110.B13 ; D110.B13 246.65,351.33 ; D110.B13 247.46,350.52 ; D110.B13 245.84,350.52 ; D431.A3 51.07,386.89 ; D431.A3 51.88,386.08 ; D431.A3 51.07,385.27 ; D431.A3 50.26,386.08 ; D122.A5 100.14,73.66 ; D122.A5 99.33,74.47 ; D122.A5 99.33,72.85 ; D122.A5 98.52,73.66 ; 271.24,73.66 D106.A15 ; D106.A15 272.05,74.47 ; D106.A15 272.86,73.66 ; D106.A15 272.05,72.85 ; 198.39,32.21 D104.A15 ; D104.A15 199.2,33.02 ; D104.A15 198.39,33.83 ; D104.A15 197.58,33.02 ; 33.29,377.65 D431.B10 ; D431.B10 33.29,379.27 ; D431.B10 34.1,378.46 ; D431.B10 32.48,378.46 ; CSDPS229.C1 56.15,331.01 ; CSDPS229.C1 55.34,330.2 ; CSDPS229.C1 56.96,330.2 ; CSDPS229.C1 56.15,329.39 ; D120.A2 18.05,36.37 ; D120.A2 17.24,35.56 ; D120.A2 18.05,34.75 ; D120.A2 18.86,35.56 ; D431.B5 46.8,381 ; D431.B5 45.99,380.19 ; D431.B5 45.99,381.81 ; D431.B5 45.18,381 ; CSDPS226.C5 120.46,350.52 ; CSDPS226.C5 119.65,349.71 ; CSDPS226.C5 119.65,351.33 ; CSDPS226.C5 118.84,350.52 ; D105.A13 266.97,94.79 ; D105.A13 266.16,93.98 ; D105.A13 267.78,93.98 ; D105.A13 266.97,93.17 ; 184.88,353.06 D114.A8 ; D114.A8 185.69,353.87 ; D114.A8 186.5,353.06 ; D114.A8 185.69,352.25 ; DPS1.B05 246.65,17.32 ; DPS1.B05 247.46,16.51 ; DPS1.B05 245.84,16.51 ; DPS1.B05 246.65,15.7 ; 195.04,373.38 D115.A4 ; D115.A4 195.85,372.57 ; D115.A4 196.66,373.38 ; D115.A4 195.85,374.19 ; 109.49,93.17 D121.A9 ; D121.A9 108.68,93.98 ; D121.A9 110.3,93.98 ; D121.A9 109.49,94.79 ; CSDPS425.B14 96.79,343.71 ; CSDPS425.B14 97.6,342.9 ; CSDPS425.B14 96.79,342.09 ; CSDPS425.B14 95.98,342.9 ; D107.B8 254.27,61.77 ; D107.B8 254.27,60.15 ; D107.B8 255.08,60.96 ; D107.B8 253.46,60.96 ; D102.A1 163.64,73.66 ; D102.A1 162.83,74.47 ; D102.A1 162.02,73.66 ; D102.A1 162.83,72.85 ; D123.B10 112.03,61.77 ; D123.B10 112.03,60.15 ; D123.B10 112.84,60.96 ; D123.B10 111.22,60.96 ; D109.B3 272.05,331.01 ; D109.B3 272.05,329.39 ; D109.B3 272.86,330.2 ; D109.B3 271.24,330.2 ; D432.A15 21.4,406.4 ; D432.A15 20.59,407.21 ; D432.A15 19.78,406.4 ; D432.A15 20.59,405.59 ; CSDPS229.B8 39.18,332.74 ; CSDPS229.B8 37.56,332.74 ; CSDPS229.B8 38.37,331.93 ; CSDPS229.B8 38.37,333.55 ; 40.1,340.36 CSDPS429.C7 ; CSDPS429.C7 40.91,341.17 ; CSDPS429.C7 41.72,340.36 ; CSDPS429.C7 40.91,339.55 ; 35.83,385.27 D431.A9 ; D431.A9 35.02,386.08 ; D431.A9 35.83,386.89 ; D431.A9 36.64,386.08 ; 170.45,392.89 D116.A14 ; D116.A14 171.26,393.7 ; D116.A14 170.45,394.51 ; D116.A14 169.64,393.7 ; 38.37,377.65 D431.B8 ; D431.B8 37.56,378.46 ; D431.B8 38.37,379.27 ; D431.B8 39.18,378.46 ; 19.18,361.14 UHC430.G1_6 ; UHC430.G1_6 19.18,362.76 ; UHC430.G1_6 19.99,361.95 ; UHC430.G1_6 18.37,361.95 ; 239.03,75.39 D106.A2 ; D106.A2 239.84,76.2 ; D106.A2 239.03,77.01 ; D106.A2 238.22,76.2 ; 271.24,391.16 D112.B3 ; D112.B3 272.86,391.16 ; D112.B3 272.05,391.97 ; D112.B3 272.05,390.35 ; D119.A1 16.32,53.34 ; D119.A1 15.51,54.15 ; D119.A1 15.51,52.53 ; D119.A1 14.7,53.34 ; 190.77,367.49 D115.B6 ; D115.B6 189.96,368.3 ; D115.B6 190.77,369.11 ; D115.B6 191.58,368.3 ; 266.97,98.25 D105.B13 ; D105.B13 266.97,99.87 ; D105.B13 267.78,99.06 ; D105.B13 266.16,99.06 ; DPS3.B15 125.54,16.51 ; DPS3.B15 123.92,16.51 ; DPS3.B15 124.73,15.7 ; DPS3.B15 124.73,17.32 ; 89.17,98.25 D121.B1 ; D121.B1 88.36,99.06 ; D121.B1 89.17,99.87 ; D121.B1 89.98,99.06 ; D431.B11 30.75,381.81 ; D431.B11 30.75,380.19 ; D431.B11 29.94,381 ; D431.B11 31.56,381 ; D102.A15 199.2,73.66 ; D102.A15 197.58,73.66 ; D102.A15 198.39,74.47 ; D102.A15 198.39,72.85 ; 101.06,96.52 D121.A6 ; D121.A6 101.87,95.71 ; D121.A6 101.87,97.33 ; D121.A6 102.68,96.52 ; D121.A8 106.95,97.33 ; D121.A8 106.95,95.71 ; D121.A8 106.14,96.52 ; D121.A8 107.76,96.52 ; D119.B16 54.42,60.96 ; D119.B16 53.61,61.77 ; D119.B16 53.61,60.15 ; D119.B16 52.8,60.96 ; D427.A16 91.71,384.35 ; D427.A16 91.71,382.73 ; D427.A16 90.9,383.54 ; D427.A16 92.52,383.54 ; D116.B3 198.39,391.97 ; D116.B3 198.39,390.35 ; D116.B3 197.58,391.16 ; D116.B3 199.2,391.16 ; D109.A11 251.73,336.09 ; D109.A11 252.54,335.28 ; D109.A11 250.92,335.28 ; D109.A11 251.73,334.47 ; 266.16,375.92 D111.A5 ; D111.A5 266.97,375.11 ; D111.A5 266.97,376.73 ; D111.A5 267.78,375.92 ; D112.A2 275.4,393.7 ; D112.A2 274.59,392.89 ; D112.A2 274.59,394.51 ; D112.A2 273.78,393.7 ; 274.59,60.15 D107.B16 ; D107.B16 275.4,60.96 ; D107.B16 274.59,61.77 ; D107.B16 273.78,60.96 ; 25.67,72.85 D118.A5 ; D118.A5 25.67,74.47 ; D118.A5 24.86,73.66 ; D118.A5 26.48,73.66 ; 243.3,373.38 D111.A14 ; D111.A14 244.92,373.38 ; D111.A14 244.11,372.57 ; D111.A14 244.11,374.19 ; D124.B5 99.33,38.91 ; D124.B5 98.52,38.1 ; D124.B5 100.14,38.1 ; D124.B5 99.33,37.29 ; D113.B16 165.37,328.47 ; D113.B16 166.18,327.66 ; D113.B16 164.56,327.66 ; D113.B16 165.37,326.85 ; 126.46,40.64 D124.B16 ; D124.B16 128.08,40.64 ; D124.B16 127.27,41.45 ; D124.B16 127.27,39.83 ; 192.5,33.02 D104.A13 ; D104.A13 193.31,32.21 ; D104.A13 194.12,33.02 ; D104.A13 193.31,33.83 ; 167.91,375.11 D115.A15 ; D115.A15 168.72,375.92 ; D115.A15 167.91,376.73 ; D115.A15 167.1,375.92 ; 27.4,388.62 D232.B12 ; D232.B12 28.21,387.81 ; D232.B12 28.21,389.43 ; D232.B12 29.02,388.62 ; D124.A3 95.06,33.02 ; D124.A3 94.25,33.83 ; D124.A3 93.44,33.02 ; D124.A3 94.25,32.21 ; 264.43,34.75 D108.A12 ; D108.A12 264.43,36.37 ; D108.A12 263.62,35.56 ; D108.A12 265.24,35.56 ; D109.A14 244.92,332.74 ; D109.A14 244.11,331.93 ; D109.A14 243.3,332.74 ; D109.A14 244.11,333.55 ; 114.57,15.7 DPS3.B11 ; DPS3.B11 114.57,17.32 ; DPS3.B11 113.76,16.51 ; DPS3.B11 115.38,16.51 ; DPS2.C05 193.31,411.02 ; DPS2.C05 192.5,410.21 ; DPS2.C05 193.31,409.4 ; DPS2.C05 194.12,410.21 ; D227.A1 129.81,376.73 ; D227.A1 129.81,375.11 ; D227.A1 129,375.92 ; D227.A1 130.62,375.92 ; D228.B8 112.03,389.43 ; D228.B8 112.03,387.81 ; D228.B8 111.22,388.62 ; D228.B8 112.84,388.62 ; 18.03,362.89 UHC430.G1_4 ; UHC430.G1_4 18.03,364.51 ; UHC430.G1_4 18.84,363.7 ; UHC430.G1_4 17.22,363.7 ; UHC230.G3 46.68,352.6 ; UHC230.G3 47.49,351.79 ; UHC230.G3 46.68,350.98 ; UHC230.G3 45.87,351.79 ; D110.A13 247.46,355.6 ; D110.A13 246.65,356.41 ; D110.A13 246.65,354.79 ; D110.A13 245.84,355.6 ; D119.B1 15.51,59.23 ; D119.B1 15.51,57.61 ; D119.B1 14.7,58.42 ; D119.B1 16.32,58.42 ; 264.43,372.57 D111.A6 ; D111.A6 265.24,373.38 ; D111.A6 264.43,374.19 ; D111.A6 263.62,373.38 ; D111.B1 277.94,370.84 ; D111.B1 276.32,370.84 ; D111.B1 277.13,370.03 ; D111.B1 277.13,371.65 ; D106.A11 261.89,74.47 ; D106.A11 262.7,73.66 ; D106.A11 261.89,72.85 ; D106.A11 261.08,73.66 ; D124.A5 99.33,33.83 ; D124.A5 98.52,33.02 ; D124.A5 100.14,33.02 ; D124.A5 99.33,32.21 ; D228.B7 115.38,391.16 ; D228.B7 114.57,391.97 ; D228.B7 113.76,391.16 ; D228.B7 114.57,390.35 ; UHC430.G2_6 48.98,362.76 ; UHC430.G2_6 48.17,361.95 ; UHC430.G2_6 49.79,361.95 ; UHC430.G2_6 48.98,361.14 ; D227.B17 89.98,370.84 ; D227.B17 89.17,371.65 ; D227.B17 88.36,370.84 ; D227.B17 89.17,370.03 ; 45.18,53.34 D119.A13 ; D119.A13 46.8,53.34 ; D119.A13 45.99,52.53 ; D119.A13 45.99,54.15 ; D118.A7 30.75,74.47 ; D118.A7 29.94,73.66 ; D118.A7 31.56,73.66 ; D118.A7 30.75,72.85 ; D431.B7 40.91,381.81 ; D431.B7 40.1,381 ; D431.B7 40.91,380.19 ; D431.B7 41.72,381 ; 195.04,347.98 D114.B4 ; D114.B4 196.66,347.98 ; D114.B4 195.85,348.79 ; D114.B4 195.85,347.17 ; CSDPS426.C1 130.62,360.68 ; CSDPS426.C1 129.81,361.49 ; CSDPS426.C1 129.81,359.87 ; CSDPS426.C1 129,360.68 ; 261.08,396.24 D112.A7 ; D112.A7 261.89,395.43 ; D112.A7 262.7,396.24 ; D112.A7 261.89,397.05 ; D119.B11 41.72,58.42 ; D119.B11 40.91,57.61 ; D119.B11 40.91,59.23 ; D119.B11 40.1,58.42 ; D110.A5 266.97,356.41 ; D110.A5 266.16,355.6 ; D110.A5 267.78,355.6 ; D110.A5 266.97,354.79 ; 261.89,98.25 D105.B11 ; D105.B11 261.89,99.87 ; D105.B11 262.7,99.06 ; D105.B11 261.08,99.06 ; D103.A2 166.18,55.88 ; D103.A2 165.37,56.69 ; D103.A2 165.37,55.07 ; D103.A2 164.56,55.88 ; CSDPS426.B6 117.11,364.03 ; CSDPS426.B6 117.11,362.41 ; CSDPS426.B6 116.3,363.22 ; CSDPS426.B6 117.92,363.22 ; D120.B7 30.75,38.91 ; D120.B7 30.75,37.29 ; D120.B7 31.56,38.1 ; D120.B7 29.94,38.1 ; 16.88,361.14 UHC430.G1 ; UHC430.G1 16.88,362.76 ; UHC430.G1 16.07,361.95 ; UHC430.G1 17.69,361.95 ; 277.13,395.43 D112.A1 ; D112.A1 277.13,397.05 ; D112.A1 276.32,396.24 ; D112.A1 277.94,396.24 ; D101.B13 193.31,99.87 ; D101.B13 193.31,98.25 ; D101.B13 192.5,99.06 ; D101.B13 194.12,99.06 ; DPS2.A15 168.72,415.29 ; DPS2.A15 167.91,416.1 ; DPS2.A15 167.1,415.29 ; DPS2.A15 167.91,414.48 ; 103.6,58.42 D123.B7 ; D123.B7 104.41,59.23 ; D123.B7 105.22,58.42 ; D123.B7 104.41,57.61 ; D119.B6 28.21,61.77 ; D119.B6 27.4,60.96 ; D119.B6 29.02,60.96 ; D119.B6 28.21,60.15 ; 123.92,391.16 D228.B3 ; D228.B3 125.54,391.16 ; D228.B3 124.73,390.35 ; D228.B3 124.73,391.97 ; 162.02,78.74 D102.B1 ; D102.B1 163.64,78.74 ; D102.B1 162.83,79.55 ; D102.B1 162.83,77.93 ; D227.A16 92.52,373.38 ; D227.A16 91.71,372.57 ; D227.A16 91.71,374.19 ; D227.A16 90.9,373.38 ; D107.A11 262.7,53.34 ; D107.A11 261.89,52.53 ; D107.A11 261.89,54.15 ; D107.A11 261.08,53.34 ; D103.A10 186.5,55.88 ; D103.A10 185.69,55.07 ; D103.A10 184.88,55.88 ; D103.A10 185.69,56.69 ; D115.A1 203.47,376.73 ; D115.A1 204.28,375.92 ; D115.A1 202.66,375.92 ; D115.A1 203.47,375.11 ; 193.31,77.93 D102.B13 ; D102.B13 193.31,79.55 ; D102.B13 194.12,78.74 ; D102.B13 192.5,78.74 ; D121.B10 112.03,102.41 ; D121.B10 112.03,100.79 ; D121.B10 112.84,101.6 ; D121.B10 111.22,101.6 ; CSDPS229.C9 35.83,331.01 ; CSDPS229.C9 35.83,329.39 ; CSDPS229.C9 36.64,330.2 ; CSDPS229.C9 35.02,330.2 ; D103.B8 181.42,60.96 ; D103.B8 180.61,60.15 ; D103.B8 179.8,60.96 ; D103.B8 180.61,61.77 ; 198.39,375.11 D115.A3 ; D115.A3 197.58,375.92 ; D115.A3 199.2,375.92 ; D115.A3 198.39,376.73 ; 45.53,359.39 UHC430.G2_10 ; UHC430.G2_10 45.53,361.01 ; UHC430.G2_10 46.34,360.2 ; UHC430.G2_10 44.72,360.2 ; 45.99,405.59 D432.A5 ; D432.A5 46.8,406.4 ; D432.A5 45.99,407.21 ; D432.A5 45.18,406.4 ; 167.91,52.53 D103.A3 ; D103.A3 167.91,54.15 ; D103.A3 167.1,53.34 ; D103.A3 168.72,53.34 ; D232.A2 53.61,394.51 ; D232.A2 54.42,393.7 ; D232.A2 53.61,392.89 ; D232.A2 52.8,393.7 ; D121.B11 114.57,99.87 ; D121.B11 114.57,98.25 ; D121.B11 113.76,99.06 ; D121.B11 115.38,99.06 ; D103.B14 195.85,61.77 ; D103.B14 195.04,60.96 ; D103.B14 196.66,60.96 ; D103.B14 195.85,60.15 ; 250.92,330.2 D109.B11 ; D109.B11 252.54,330.2 ; D109.B11 251.73,329.39 ; D109.B11 251.73,331.01 ; D227.B7 114.57,371.65 ; D227.B7 113.76,370.84 ; D227.B7 115.38,370.84 ; D227.B7 114.57,370.03 ; 272.05,15.7 DPS1.B15 ; DPS1.B15 271.24,16.51 ; DPS1.B15 272.05,17.32 ; DPS1.B15 272.86,16.51 ; 29.94,401.32 D432.B11 ; D432.B11 30.75,400.51 ; D432.B11 31.56,401.32 ; D432.B11 30.75,402.13 ; 91.71,362.41 CSDPS426.B16 ; CSDPS426.B16 91.71,364.03 ; CSDPS426.B16 92.52,363.22 ; CSDPS426.B16 90.9,363.22 ; D431.B4 48.53,379.27 ; D431.B4 47.72,378.46 ; D431.B4 49.34,378.46 ; D431.B4 48.53,377.65 ; 119.65,400.51 D428.B5 ; D428.B5 118.84,401.32 ; D428.B5 120.46,401.32 ; D428.B5 119.65,402.13 ; D431.B1 56.96,381 ; D431.B1 55.34,381 ; D431.B1 56.15,381.81 ; D431.B1 56.15,380.19 ; D112.B4 269.51,389.43 ; D112.B4 269.51,387.81 ; D112.B4 270.32,388.62 ; D112.B4 268.7,388.62 ; D101.A1 162.83,94.79 ; D101.A1 162.83,93.17 ; D101.A1 163.64,93.98 ; D101.A1 162.02,93.98 ; 269.51,55.07 D107.A14 ; D107.A14 268.7,55.88 ; D107.A14 270.32,55.88 ; D107.A14 269.51,56.69 ; 174.72,347.98 D114.B12 ; D114.B12 176.34,347.98 ; D114.B12 175.53,347.17 ; D114.B12 175.53,348.79 ; 103.6,93.98 D121.A7 ; D121.A7 104.41,94.79 ; D121.A7 104.41,93.17 ; D121.A7 105.22,93.98 ; 250.92,99.06 D105.B7 ; D105.B7 252.54,99.06 ; D105.B7 251.73,99.87 ; D105.B7 251.73,98.25 ; 33.29,55.07 D119.A8 ; D119.A8 33.29,56.69 ; D119.A8 32.48,55.88 ; D119.A8 34.1,55.88 ; D104.B6 176.34,40.64 ; D104.B6 175.53,41.45 ; D104.B6 174.72,40.64 ; D104.B6 175.53,39.83 ; 30.75,57.61 D119.B7 ; D119.B7 29.94,58.42 ; D119.B7 30.75,59.23 ; D119.B7 31.56,58.42 ; 90.9,353.06 CSDPS226.B16 ; CSDPS226.B16 92.52,353.06 ; CSDPS226.B16 91.71,352.25 ; CSDPS226.B16 91.71,353.87 ; 272.05,13.16 DPS1.A15 ; DPS1.A15 272.05,14.78 ; DPS1.A15 271.24,13.97 ; DPS1.A15 272.86,13.97 ; 42.64,55.88 D119.A12 ; D119.A12 43.45,56.69 ; D119.A12 43.45,55.07 ; D119.A12 44.26,55.88 ; DPS2.B11 178.88,412.75 ; DPS2.B11 177.26,412.75 ; DPS2.B11 178.07,411.94 ; DPS2.B11 178.07,413.56 ; D104.A6 176.34,35.56 ; D104.A6 174.72,35.56 ; D104.A6 175.53,34.75 ; D104.A6 175.53,36.37 ; UHC430.G1_9 18.03,361.01 ; UHC430.G1_9 17.22,360.2 ; UHC430.G1_9 18.03,359.39 ; UHC430.G1_9 18.84,360.2 ; DPS8.C01 56.96,410.21 ; DPS8.C01 56.15,411.02 ; DPS8.C01 56.15,409.4 ; DPS8.C01 55.34,410.21 ; D110.B1 277.13,351.33 ; D110.B1 276.32,350.52 ; D110.B1 277.94,350.52 ; D110.B1 277.13,349.71 ; D123.B11 115.38,58.42 ; D123.B11 114.57,57.61 ; D123.B11 113.76,58.42 ; D123.B11 114.57,59.23 ; 129,330.2 CSDPS225.C1 ; CSDPS225.C1 130.62,330.2 ; CSDPS225.C1 129.81,329.39 ; CSDPS225.C1 129.81,331.01 ; 52.8,373.38 D231.A2 ; D231.A2 54.42,373.38 ; D231.A2 53.61,372.57 ; D231.A2 53.61,374.19 ; 112.03,372.57 D227.A8 ; D227.A8 112.84,373.38 ; D227.A8 111.22,373.38 ; D227.A8 112.03,374.19 ; D111.A1 277.13,376.73 ; D111.A1 277.94,375.92 ; D111.A1 277.13,375.11 ; D111.A1 276.32,375.92 ; D116.A4 196.66,393.7 ; D116.A4 195.85,392.89 ; D116.A4 195.85,394.51 ; D116.A4 195.04,393.7 ; D110.A4 269.51,353.87 ; D110.A4 270.32,353.06 ; D110.A4 268.7,353.06 ; D110.A4 269.51,352.25 ; 112.03,377.65 D427.B8 ; D427.B8 111.22,378.46 ; D427.B8 112.03,379.27 ; D427.B8 112.84,378.46 ; D112.B5 266.97,391.97 ; D112.B5 266.97,390.35 ; D112.B5 266.16,391.16 ; D112.B5 267.78,391.16 ; 238.22,327.66 D109.B16 ; D109.B16 239.03,328.47 ; D109.B16 239.84,327.66 ; D109.B16 239.03,326.85 ; 240.76,93.98 D105.A3 ; D105.A3 241.57,94.79 ; D105.A3 241.57,93.17 ; D105.A3 242.38,93.98 ; CSDPS429.B14 23.13,343.71 ; CSDPS429.B14 23.13,342.09 ; CSDPS429.B14 22.32,342.9 ; CSDPS429.B14 23.94,342.9 ; CSDPS429.C13 26.48,340.36 ; CSDPS429.C13 25.67,339.55 ; CSDPS429.C13 25.67,341.17 ; CSDPS429.C13 24.86,340.36 ; 244.11,387.81 D112.B14 ; D112.B14 244.11,389.43 ; D112.B14 244.92,388.62 ; D112.B14 243.3,388.62 ; D109.B9 257.62,330.2 ; D109.B9 256.81,329.39 ; D109.B9 256,330.2 ; D109.B9 256.81,331.01 ; UHC430.G2_8 45.19,361.95 ; UHC430.G2_8 44.38,361.14 ; UHC430.G2_8 43.57,361.95 ; UHC430.G2_8 44.38,362.76 ; D123.A12 117.92,55.88 ; D123.A12 116.3,55.88 ; D123.A12 117.11,55.07 ; D123.A12 117.11,56.69 ; D228.B1 130.62,391.16 ; D228.B1 129,391.16 ; D228.B1 129.81,391.97 ; D228.B1 129.81,390.35 ; 200.93,55.07 D103.A16 ; D103.A16 201.74,55.88 ; D103.A16 200.93,56.69 ; D103.A16 200.12,55.88 ; 114.57,13.16 DPS3.A11 ; DPS3.A11 115.38,13.97 ; DPS3.A11 113.76,13.97 ; DPS3.A11 114.57,14.78 ; 109.49,98.25 D121.B9 ; D121.B9 108.68,99.06 ; D121.B9 110.3,99.06 ; D121.B9 109.49,99.87 ; 123.92,381 D427.B3 ; D427.B3 125.54,381 ; D427.B3 124.73,381.81 ; D427.B3 124.73,380.19 ; D113.A14 171.26,332.74 ; D113.A14 170.45,333.55 ; D113.A14 170.45,331.93 ; D113.A14 169.64,332.74 ; D232.B5 46.8,391.16 ; D232.B5 45.99,391.97 ; D232.B5 45.18,391.16 ; D232.B5 45.99,390.35 ; D113.A10 181.42,332.74 ; D113.A10 180.61,333.55 ; D113.A10 179.8,332.74 ; D113.A10 180.61,331.93 ; D427.A15 95.06,386.08 ; D427.A15 94.25,385.27 ; D427.A15 94.25,386.89 ; D427.A15 93.44,386.08 ; D106.B3 241.57,79.55 ; D106.B3 241.57,77.93 ; D106.B3 240.76,78.74 ; D106.B3 242.38,78.74 ; D432.B17 16.32,401.32 ; D432.B17 15.51,402.13 ; D432.B17 15.51,400.51 ; D432.B17 14.7,401.32 ; D123.A7 104.41,54.15 ; D123.A7 105.22,53.34 ; D123.A7 104.41,52.53 ; D123.A7 103.6,53.34 ; 93.44,53.34 D123.A3 ; D123.A3 95.06,53.34 ; D123.A3 94.25,52.53 ; D123.A3 94.25,54.15 ; 177.26,73.66 D102.A7 ; D102.A7 178.88,73.66 ; D102.A7 178.07,74.47 ; D102.A7 178.07,72.85 ; D105.A5 247.46,93.98 ; D105.A5 245.84,93.98 ; D105.A5 246.65,93.17 ; D105.A5 246.65,94.79 ; 185.69,75.39 D102.A10 ; D102.A10 184.88,76.2 ; D102.A10 186.5,76.2 ; D102.A10 185.69,77.01 ; D114.B16 166.18,347.98 ; D114.B16 164.56,347.98 ; D114.B16 165.37,348.79 ; D114.B16 165.37,347.17 ; 90.9,398.78 D428.B16 ; D428.B16 92.52,398.78 ; D428.B16 91.71,399.59 ; D428.B16 91.71,397.97 ; 256.81,375.11 D111.A9 ; D111.A9 256.81,376.73 ; D111.A9 257.62,375.92 ; D111.A9 256,375.92 ; D227.B6 117.11,369.11 ; D227.B6 117.11,367.49 ; D227.B6 116.3,368.3 ; D227.B6 117.92,368.3 ; 192.5,396.24 D116.A5 ; D116.A5 193.31,397.05 ; D116.A5 194.12,396.24 ; D116.A5 193.31,395.43 ; 271.24,58.42 D107.B15 ; D107.B15 272.86,58.42 ; D107.B15 272.05,57.61 ; D107.B15 272.05,59.23 ; D124.A12 117.92,35.56 ; D124.A12 117.11,34.75 ; D124.A12 116.3,35.56 ; D124.A12 117.11,36.37 ; 164.56,81.28 D102.B2 ; D102.B2 166.18,81.28 ; D102.B2 165.37,82.09 ; D102.B2 165.37,80.47 ; D232.B15 20.59,391.97 ; D232.B15 21.4,391.16 ; D232.B15 19.78,391.16 ; D232.B15 20.59,390.35 ; D113.B13 173.8,330.2 ; D113.B13 172.99,331.01 ; D113.B13 172.99,329.39 ; D113.B13 172.18,330.2 ; 193.31,93.17 D101.A13 ; D101.A13 194.12,93.98 ; D101.A13 192.5,93.98 ; D101.A13 193.31,94.79 ; 271.24,19.05 DPS1.C15 ; DPS1.C15 272.86,19.05 ; DPS1.C15 272.05,19.86 ; DPS1.C15 272.05,18.24 ; 193.31,57.61 D103.B13 ; D103.B13 192.5,58.42 ; D103.B13 193.31,59.23 ; D103.B13 194.12,58.42 ; 192.5,412.75 DPS2.B05 ; DPS2.B05 194.12,412.75 ; DPS2.B05 193.31,411.94 ; DPS2.B05 193.31,413.56 ; D106.B1 236.49,79.55 ; D106.B1 237.3,78.74 ; D106.B1 235.68,78.74 ; D106.B1 236.49,77.93 ; D231.B15 21.4,370.84 ; D231.B15 20.59,370.03 ; D231.B15 19.78,370.84 ; D231.B15 20.59,371.65 ; UHC230.G3_2 47.49,355.29 ; UHC230.G3_2 46.68,354.48 ; UHC230.G3_2 45.87,355.29 ; UHC230.G3_2 46.68,356.1 ; D228.B9 109.49,391.97 ; D228.B9 108.68,391.16 ; D228.B9 110.3,391.16 ; D228.B9 109.49,390.35 ; 19.78,415.29 DPS8.A15 ; DPS8.A15 20.59,416.1 ; DPS8.A15 20.59,414.48 ; DPS8.A15 21.4,415.29 ; 25.67,390.35 D232.B13 ; D232.B13 26.48,391.16 ; D232.B13 25.67,391.97 ; D232.B13 24.86,391.16 ; 117.11,331.93 CSDPS225.B6 ; CSDPS225.B6 117.11,333.55 ; CSDPS225.B6 117.92,332.74 ; CSDPS225.B6 116.3,332.74 ; 266.16,38.1 D108.B13 ; D108.B13 266.97,37.29 ; D108.B13 266.97,38.91 ; D108.B13 267.78,38.1 ; D104.A1 163.64,33.02 ; D104.A1 162.02,33.02 ; D104.A1 162.83,32.21 ; D104.A1 162.83,33.83 ; D124.A9 110.3,33.02 ; D124.A9 109.49,32.21 ; D124.A9 109.49,33.83 ; D124.A9 108.68,33.02 ; D428.B15 95.06,401.32 ; D428.B15 93.44,401.32 ; D428.B15 94.25,400.51 ; D428.B15 94.25,402.13 ; D113.A11 178.88,335.28 ; D113.A11 177.26,335.28 ; D113.A11 178.07,334.47 ; D113.A11 178.07,336.09 ; D427.B5 119.65,381.81 ; D427.B5 118.84,381 ; D427.B5 119.65,380.19 ; D427.B5 120.46,381 ; 112.03,352.25 CSDPS226.B8 ; CSDPS226.B8 112.84,353.06 ; CSDPS226.B8 111.22,353.06 ; CSDPS226.B8 112.03,353.87 ; CSDPS225.B12 101.87,333.55 ; CSDPS225.B12 101.87,331.93 ; CSDPS225.B12 102.68,332.74 ; CSDPS225.B12 101.06,332.74 ; D110.A7 262.7,355.6 ; D110.A7 261.89,356.41 ; D110.A7 261.08,355.6 ; D110.A7 261.89,354.79 ; 245.84,58.42 D107.B5 ; D107.B5 246.65,59.23 ; D107.B5 246.65,57.61 ; D107.B5 247.46,58.42 ; D103.A15 199.2,53.34 ; D103.A15 197.58,53.34 ; D103.A15 198.39,52.53 ; D103.A15 198.39,54.15 ; 180.61,39.83 D104.B8 ; D104.B8 179.8,40.64 ; D104.B8 180.61,41.45 ; D104.B8 181.42,40.64 ; D120.A12 43.45,36.37 ; D120.A12 44.26,35.56 ; D120.A12 42.64,35.56 ; D120.A12 43.45,34.75 ; 274.59,100.79 D105.B16 ; D105.B16 273.78,101.6 ; D105.B16 274.59,102.41 ; D105.B16 275.4,101.6 ; 188.23,37.29 D104.B11 ; D104.B11 187.42,38.1 ; D104.B11 189.04,38.1 ; D104.B11 188.23,38.91 ; 189.96,40.64 D104.B12 ; D104.B12 191.58,40.64 ; D104.B12 190.77,39.83 ; D104.B12 190.77,41.45 ; DPS3.B01 89.98,16.51 ; DPS3.B01 88.36,16.51 ; DPS3.B01 89.17,15.7 ; DPS3.B01 89.17,17.32 ; D228.B17 89.98,391.16 ; D228.B17 88.36,391.16 ; D228.B17 89.17,390.35 ; D228.B17 89.17,391.97 ; D109.A2 275.4,332.74 ; D109.A2 274.59,331.93 ; D109.A2 274.59,333.55 ; D109.A2 273.78,332.74 ; 269.51,372.57 D111.A4 ; D111.A4 268.7,373.38 ; D111.A4 269.51,374.19 ; D111.A4 270.32,373.38 ; D103.B15 198.39,59.23 ; D103.B15 198.39,57.61 ; D103.B15 197.58,58.42 ; D103.B15 199.2,58.42 ; 37.56,35.56 D120.A10 ; D120.A10 38.37,34.75 ; D120.A10 38.37,36.37 ; D120.A10 39.18,35.56 ; 127.27,382.73 D427.A2 ; D427.A2 128.08,383.54 ; D427.A2 127.27,384.35 ; D427.A2 126.46,383.54 ; 170.45,387.81 D116.B14 ; D116.B14 171.26,388.62 ; D116.B14 169.64,388.62 ; D116.B14 170.45,389.43 ; 268.7,368.3 D111.B4 ; D111.B4 270.32,368.3 ; D111.B4 269.51,367.49 ; D111.B4 269.51,369.11 ; 240.76,350.52 D110.B15 ; D110.B15 241.57,351.33 ; D110.B15 241.57,349.71 ; D110.B15 242.38,350.52 ; D232.A12 28.21,394.51 ; D232.A12 28.21,392.89 ; D232.A12 29.02,393.7 ; D232.A12 27.4,393.7 ; D123.A14 122.19,56.69 ; D123.A14 123,55.88 ; D123.A14 121.38,55.88 ; D123.A14 122.19,55.07 ; 90.9,40.64 D124.B2 ; D124.B2 91.71,41.45 ; D124.B2 92.52,40.64 ; D124.B2 91.71,39.83 ; CSDPS229.C5 45.99,331.01 ; CSDPS229.C5 45.18,330.2 ; CSDPS229.C5 46.8,330.2 ; CSDPS229.C5 45.99,329.39 ; 43.57,358.45 UHC430.G2_13 ; UHC430.G2_13 45.19,358.45 ; UHC430.G2_13 44.38,359.26 ; UHC430.G2_13 44.38,357.64 ; 118.84,73.66 D122.A13 ; D122.A13 119.65,74.47 ; D122.A13 120.46,73.66 ; D122.A13 119.65,72.85 ; 268.7,393.7 D112.A4 ; D112.A4 269.51,394.51 ; D112.A4 270.32,393.7 ; D112.A4 269.51,392.89 ; 103.6,391.16 D228.B11 ; D228.B11 104.41,391.97 ; D228.B11 105.22,391.16 ; D228.B11 104.41,390.35 ; D104.B16 200.93,41.45 ; D104.B16 201.74,40.64 ; D104.B16 200.93,39.83 ; D104.B16 200.12,40.64 ; D108.B2 239.03,41.45 ; D108.B2 238.22,40.64 ; D108.B2 239.84,40.64 ; D108.B2 239.03,39.83 ; 253.46,353.06 D110.A10 ; D110.A10 254.27,352.25 ; D110.A10 255.08,353.06 ; D110.A10 254.27,353.87 ; D113.A2 200.93,333.55 ; D113.A2 200.93,331.93 ; D113.A2 200.12,332.74 ; D113.A2 201.74,332.74 ; D101.A15 198.39,94.79 ; D101.A15 198.39,93.17 ; D101.A15 197.58,93.98 ; D101.A15 199.2,93.98 ; 30.75,414.48 DPS8.A11 ; DPS8.A11 31.56,415.29 ; DPS8.A11 29.94,415.29 ; DPS8.A11 30.75,416.1 ; D114.A7 189.04,355.6 ; D114.A7 187.42,355.6 ; D114.A7 188.23,354.79 ; D114.A7 188.23,356.41 ; D104.A5 173.8,33.02 ; D104.A5 172.99,33.83 ; D104.A5 172.18,33.02 ; D104.A5 172.99,32.21 ; D231.B11 31.56,370.84 ; D231.B11 29.94,370.84 ; D231.B11 30.75,371.65 ; D231.B11 30.75,370.03 ; D114.A10 180.61,353.87 ; D114.A10 181.42,353.06 ; D114.A10 179.8,353.06 ; D114.A10 180.61,352.25 ; 127.27,100.79 D121.B16 ; D121.B16 126.46,101.6 ; D121.B16 128.08,101.6 ; D121.B16 127.27,102.41 ; 32.48,393.7 D232.A10 ; D232.A10 34.1,393.7 ; D232.A10 33.29,394.51 ; D232.A10 33.29,392.89 ; 96.79,362.41 CSDPS426.B14 ; CSDPS426.B14 97.6,363.22 ; CSDPS426.B14 95.98,363.22 ; CSDPS426.B14 96.79,364.03 ; D104.B4 171.26,40.64 ; D104.B4 170.45,41.45 ; D104.B4 169.64,40.64 ; D104.B4 170.45,39.83 ; 14.58,350.98 UHC230.G4_8 ; UHC230.G4_8 15.39,351.79 ; UHC230.G4_8 14.58,352.6 ; UHC230.G4_8 13.77,351.79 ; 167.1,335.28 D113.A15 ; D113.A15 167.91,336.09 ; D113.A15 167.91,334.47 ; D113.A15 168.72,335.28 ; D124.A15 124.73,33.83 ; D124.A15 125.54,33.02 ; D124.A15 123.92,33.02 ; D124.A15 124.73,32.21 ; UHC230.G3_12 46.68,349.1 ; UHC230.G3_12 45.87,348.29 ; UHC230.G3_12 47.49,348.29 ; UHC230.G3_12 46.68,347.48 ; 240.76,99.06 D105.B3 ; D105.B3 241.57,99.87 ; D105.B3 241.57,98.25 ; D105.B3 242.38,99.06 ; D111.B12 249.19,369.11 ; D111.B12 249.19,367.49 ; D111.B12 250,368.3 ; D111.B12 248.38,368.3 ; 40.1,396.24 D232.A7 ; D232.A7 40.91,397.05 ; D232.A7 41.72,396.24 ; D232.A7 40.91,395.43 ; 43.45,331.93 CSDPS229.B6 ; CSDPS229.B6 43.45,333.55 ; CSDPS229.B6 42.64,332.74 ; CSDPS229.B6 44.26,332.74 ; 261.08,16.51 DPS1.B11 ; DPS1.B11 261.89,17.32 ; DPS1.B11 261.89,15.7 ; DPS1.B11 262.7,16.51 ; 35.83,390.35 D232.B9 ; D232.B9 35.83,391.97 ; D232.B9 35.02,391.16 ; D232.B9 36.64,391.16 ; 256,355.6 D110.A9 ; D110.A9 257.62,355.6 ; D110.A9 256.81,354.79 ; D110.A9 256.81,356.41 ; 174.72,332.74 D113.A12 ; D113.A12 175.53,333.55 ; D113.A12 175.53,331.93 ; D113.A12 176.34,332.74 ; 179.8,55.88 D103.A8 ; D103.A8 181.42,55.88 ; D103.A8 180.61,55.07 ; D103.A8 180.61,56.69 ; D427.B15 95.06,381 ; D427.B15 94.25,380.19 ; D427.B15 94.25,381.81 ; D427.B15 93.44,381 ; 274.59,372.57 D111.A2 ; D111.A2 274.59,374.19 ; D111.A2 275.4,373.38 ; D111.A2 273.78,373.38 ; 251.73,390.35 D112.B11 ; D112.B11 252.54,391.16 ; D112.B11 250.92,391.16 ; D112.B11 251.73,391.97 ; 240.76,330.2 D109.B15 ; D109.B15 241.57,329.39 ; D109.B15 241.57,331.01 ; D109.B15 242.38,330.2 ; DPS8.B01 56.15,413.56 ; DPS8.B01 56.15,411.94 ; DPS8.B01 55.34,412.75 ; DPS8.B01 56.96,412.75 ; D112.A3 272.86,396.24 ; D112.A3 272.05,397.05 ; D112.A3 271.24,396.24 ; D112.A3 272.05,395.43 ; D103.A13 193.31,54.15 ; D103.A13 192.5,53.34 ; D103.A13 193.31,52.53 ; D103.A13 194.12,53.34 ; D106.B14 269.51,82.09 ; D106.B14 269.51,80.47 ; D106.B14 268.7,81.28 ; D106.B14 270.32,81.28 ; D432.A9 35.83,407.21 ; D432.A9 35.02,406.4 ; D432.A9 36.64,406.4 ; D432.A9 35.83,405.59 ; 203.47,354.79 D114.A1 ; D114.A1 203.47,356.41 ; D114.A1 204.28,355.6 ; D114.A1 202.66,355.6 ; D114.B13 172.99,351.33 ; D114.B13 172.18,350.52 ; D114.B13 172.99,349.71 ; D114.B13 173.8,350.52 ; 254.27,372.57 D111.A10 ; D111.A10 253.46,373.38 ; D111.A10 254.27,374.19 ; D111.A10 255.08,373.38 ; 185.69,392.89 D116.A8 ; D116.A8 186.5,393.7 ; D116.A8 184.88,393.7 ; D116.A8 185.69,394.51 ; D427.A6 117.11,384.35 ; D427.A6 117.92,383.54 ; D427.A6 116.3,383.54 ; D427.A6 117.11,382.73 ; D227.B15 95.06,370.84 ; D227.B15 93.44,370.84 ; D227.B15 94.25,370.03 ; D227.B15 94.25,371.65 ; 238.22,81.28 D106.B2 ; D106.B2 239.03,82.09 ; D106.B2 239.84,81.28 ; D106.B2 239.03,80.47 ; D102.B9 183.96,78.74 ; D102.B9 183.15,79.55 ; D102.B9 183.15,77.93 ; D102.B9 182.34,78.74 ; D232.A4 48.53,394.51 ; D232.A4 48.53,392.89 ; D232.A4 49.34,393.7 ; D232.A4 47.72,393.7 ; D104.A14 195.85,36.37 ; D104.A14 196.66,35.56 ; D104.A14 195.85,34.75 ; D104.A14 195.04,35.56 ; D432.A3 51.07,407.21 ; D432.A3 51.07,405.59 ; D432.A3 50.26,406.4 ; D432.A3 51.88,406.4 ; 50.26,330.2 CSDPS229.C3 ; CSDPS229.C3 51.07,331.01 ; CSDPS229.C3 51.88,330.2 ; CSDPS229.C3 51.07,329.39 ; 258.54,40.64 D108.B10 ; D108.B10 259.35,41.45 ; D108.B10 259.35,39.83 ; D108.B10 260.16,40.64 ; D113.B6 190.77,328.47 ; D113.B6 189.96,327.66 ; D113.B6 191.58,327.66 ; D113.B6 190.77,326.85 ; 238.22,353.06 D110.A16 ; D110.A16 239.03,353.87 ; D110.A16 239.03,352.25 ; D110.A16 239.84,353.06 ; 122.19,367.49 D227.B4 ; D227.B4 123,368.3 ; D227.B4 122.19,369.11 ; D227.B4 121.38,368.3 ; 203.47,349.71 D114.B1 ; D114.B1 203.47,351.33 ; D114.B1 204.28,350.52 ; D114.B1 202.66,350.52 ; 273.78,347.98 D110.B2 ; D110.B2 275.4,347.98 ; D110.B2 274.59,348.79 ; D110.B2 274.59,347.17 ; D106.B4 244.11,82.09 ; D106.B4 243.3,81.28 ; D106.B4 244.11,80.47 ; D106.B4 244.92,81.28 ; D124.A16 128.08,35.56 ; D124.A16 127.27,36.37 ; D124.A16 127.27,34.75 ; D124.A16 126.46,35.56 ; D428.A6 117.11,404.67 ; D428.A6 117.11,403.05 ; D428.A6 117.92,403.86 ; D428.A6 116.3,403.86 ; D101.A9 183.15,94.79 ; D101.A9 182.34,93.98 ; D101.A9 183.96,93.98 ; D101.A9 183.15,93.17 ; 114.57,52.53 D123.A11 ; D123.A11 113.76,53.34 ; D123.A11 115.38,53.34 ; D123.A11 114.57,54.15 ; 188.23,390.35 D116.B7 ; D116.B7 188.23,391.97 ; D116.B7 189.04,391.16 ; D116.B7 187.42,391.16 ; 203.47,334.47 D113.A1 ; D113.A1 203.47,336.09 ; D113.A1 204.28,335.28 ; D113.A1 202.66,335.28 ; D107.B12 265.24,60.96 ; D107.B12 264.43,60.15 ; D107.B12 264.43,61.77 ; D107.B12 263.62,60.96 ; 47.72,342.9 CSDPS429.B4 ; CSDPS429.B4 48.53,342.09 ; CSDPS429.B4 48.53,343.71 ; CSDPS429.B4 49.34,342.9 ; UHC230.G3_8 44.38,352.6 ; UHC230.G3_8 43.57,351.79 ; UHC230.G3_8 44.38,350.98 ; UHC230.G3_8 45.19,351.79 ; 101.87,100.79 D121.B6 ; D121.B6 102.68,101.6 ; D121.B6 101.87,102.41 ; D121.B6 101.06,101.6 ; D122.A10 112.03,77.01 ; D122.A10 112.03,75.39 ; D122.A10 112.84,76.2 ; D122.A10 111.22,76.2 ; 40.91,72.85 D118.A11 ; D118.A11 40.91,74.47 ; D118.A11 40.1,73.66 ; D118.A11 41.72,73.66 ; D428.B13 99.33,402.13 ; D428.B13 99.33,400.51 ; D428.B13 100.14,401.32 ; D428.B13 98.52,401.32 ; D123.B12 117.11,61.77 ; D123.B12 116.3,60.96 ; D123.B12 117.92,60.96 ; D123.B12 117.11,60.15 ; 93.44,78.74 D122.B3 ; D122.B3 94.25,79.55 ; D122.B3 94.25,77.93 ; D122.B3 95.06,78.74 ; 40.1,391.16 D232.B7 ; D232.B7 40.91,391.97 ; D232.B7 41.72,391.16 ; D232.B7 40.91,390.35 ; 254.27,387.81 D112.B10 ; D112.B10 255.08,388.62 ; D112.B10 253.46,388.62 ; D112.B10 254.27,389.43 ; 172.99,72.85 D102.A5 ; D102.A5 172.18,73.66 ; D102.A5 173.8,73.66 ; D102.A5 172.99,74.47 ; 203.47,370.03 D115.B1 ; D115.B1 202.66,370.84 ; D115.B1 204.28,370.84 ; D115.B1 203.47,371.65 ; D105.B6 249.19,102.41 ; D105.B6 248.38,101.6 ; D105.B6 249.19,100.79 ; D105.B6 250,101.6 ; D106.B7 252.54,78.74 ; D106.B7 250.92,78.74 ; D106.B7 251.73,77.93 ; D106.B7 251.73,79.55 ; D114.B5 193.31,351.33 ; D114.B5 193.31,349.71 ; D114.B5 194.12,350.52 ; D114.B5 192.5,350.52 ; D431.A11 31.56,386.08 ; D431.A11 29.94,386.08 ; D431.A11 30.75,385.27 ; D431.A11 30.75,386.89 ; 101.87,372.57 D227.A12 ; D227.A12 101.87,374.19 ; D227.A12 101.06,373.38 ; D227.A12 102.68,373.38 ; UHC230.G4_2 17.69,355.29 ; UHC230.G4_2 16.07,355.29 ; UHC230.G4_2 16.88,354.48 ; UHC230.G4_2 16.88,356.1 ; 106.95,55.07 D123.A8 ; D123.A8 107.76,55.88 ; D123.A8 106.14,55.88 ; D123.A8 106.95,56.69 ; 14.92,363.7 UHC430.G1_5 ; UHC430.G1_5 15.73,364.51 ; UHC430.G1_5 15.73,362.89 ; UHC430.G1_5 16.54,363.7 ; D432.B9 36.64,401.32 ; D432.B9 35.83,400.51 ; D432.B9 35.83,402.13 ; D432.B9 35.02,401.32 ; 121.38,398.78 D428.B4 ; D428.B4 123,398.78 ; D428.B4 122.19,397.97 ; D428.B4 122.19,399.59 ; 32.48,383.54 D431.A10 ; D431.A10 34.1,383.54 ; D431.A10 33.29,382.73 ; D431.A10 33.29,384.35 ; 238.22,388.62 D112.B16 ; D112.B16 239.03,389.43 ; D112.B16 239.84,388.62 ; D112.B16 239.03,387.81 ; 263.62,347.98 D110.B6 ; D110.B6 265.24,347.98 ; D110.B6 264.43,347.17 ; D110.B6 264.43,348.79 ; D114.A9 183.96,355.6 ; D114.A9 182.34,355.6 ; D114.A9 183.15,356.41 ; D114.A9 183.15,354.79 ; D107.B6 250,60.96 ; D107.B6 249.19,61.77 ; D107.B6 248.38,60.96 ; D107.B6 249.19,60.15 ; D428.A8 112.84,403.86 ; D428.A8 112.03,404.67 ; D428.A8 111.22,403.86 ; D428.A8 112.03,403.05 ; 106.14,81.28 D122.B8 ; D122.B8 107.76,81.28 ; D122.B8 106.95,80.47 ; D122.B8 106.95,82.09 ; 106.95,377.65 D427.B10 ; D427.B10 106.95,379.27 ; D427.B10 106.14,378.46 ; D427.B10 107.76,378.46 ; 50.26,33.02 D120.A15 ; D120.A15 51.88,33.02 ; D120.A15 51.07,33.83 ; D120.A15 51.07,32.21 ; 106.14,403.86 D428.A10 ; D428.A10 106.95,404.67 ; D428.A10 107.76,403.86 ; D428.A10 106.95,403.05 ; 266.97,329.39 D109.B5 ; D109.B5 266.16,330.2 ; D109.B5 267.78,330.2 ; D109.B5 266.97,331.01 ; 179.8,368.3 D115.B10 ; D115.B10 180.61,369.11 ; D115.B10 181.42,368.3 ; D115.B10 180.61,367.49 ; 170.45,347.17 D114.B14 ; D114.B14 171.26,347.98 ; D114.B14 170.45,348.79 ; D114.B14 169.64,347.98 ; D119.A6 29.02,55.88 ; D119.A6 27.4,55.88 ; D119.A6 28.21,55.07 ; D119.A6 28.21,56.69 ; 271.24,99.06 D105.B15 ; D105.B15 272.05,99.87 ; D105.B15 272.86,99.06 ; D105.B15 272.05,98.25 ; 195.04,40.64 D104.B14 ; D104.B14 196.66,40.64 ; D104.B14 195.85,41.45 ; D104.B14 195.85,39.83 ; 246.65,334.47 D109.A13 ; D109.A13 246.65,336.09 ; D109.A13 245.84,335.28 ; D109.A13 247.46,335.28 ; CSDPS425.C9 110.3,340.36 ; CSDPS425.C9 109.49,339.55 ; CSDPS425.C9 108.68,340.36 ; CSDPS425.C9 109.49,341.17 ; 195.85,100.79 D101.B14 ; D101.B14 195.85,102.41 ; D101.B14 196.66,101.6 ; D101.B14 195.04,101.6 ; 22.32,378.46 D431.B14 ; D431.B14 23.94,378.46 ; D431.B14 23.13,379.27 ; D431.B14 23.13,377.65 ; 95.98,378.46 D427.B14 ; D427.B14 96.79,379.27 ; D427.B14 97.6,378.46 ; D427.B14 96.79,377.65 ; 47.72,403.86 D432.A4 ; D432.A4 48.53,403.05 ; D432.A4 48.53,404.67 ; D432.A4 49.34,403.86 ; D113.A7 189.04,335.28 ; D113.A7 188.23,334.47 ; D113.A7 187.42,335.28 ; D113.A7 188.23,336.09 ; D107.A4 244.92,55.88 ; D107.A4 244.11,55.07 ; D107.A4 243.3,55.88 ; D107.A4 244.11,56.69 ; D228.B5 119.65,391.97 ; D228.B5 119.65,390.35 ; D228.B5 120.46,391.16 ; D228.B5 118.84,391.16 ; D102.A12 190.77,77.01 ; D102.A12 189.96,76.2 ; D102.A12 190.77,75.39 ; D102.A12 191.58,76.2 ; D120.A4 23.94,35.56 ; D120.A4 23.13,36.37 ; D120.A4 22.32,35.56 ; D120.A4 23.13,34.75 ; D231.B16 18.86,368.3 ; D231.B16 17.24,368.3 ; D231.B16 18.05,369.11 ; D231.B16 18.05,367.49 ; 184.88,388.62 D116.B8 ; D116.B8 185.69,389.43 ; D116.B8 186.5,388.62 ; D116.B8 185.69,387.81 ; D107.A12 264.43,56.69 ; D107.A12 265.24,55.88 ; D107.A12 264.43,55.07 ; D107.A12 263.62,55.88 ; UHC230.G3_10 46.34,350.04 ; UHC230.G3_10 45.53,350.85 ; UHC230.G3_10 45.53,349.23 ; UHC230.G3_10 44.72,350.04 ; 42.64,40.64 D120.B12 ; D120.B12 44.26,40.64 ; D120.B12 43.45,41.45 ; D120.B12 43.45,39.83 ; 45.87,358.45 UHC430.G2_12 ; UHC430.G2_12 46.68,359.26 ; UHC430.G2_12 46.68,357.64 ; UHC430.G2_12 47.49,358.45 ; D232.B17 15.51,391.97 ; D232.B17 15.51,390.35 ; D232.B17 14.7,391.16 ; D232.B17 16.32,391.16 ; 276.32,391.16 D112.B1 ; D112.B1 277.13,391.97 ; D112.B1 277.13,390.35 ; D112.B1 277.94,391.16 ; 18.05,55.07 D119.A2 ; D119.A2 17.24,55.88 ; D119.A2 18.86,55.88 ; D119.A2 18.05,56.69 ; 170.45,55.07 D103.A4 ; D103.A4 171.26,55.88 ; D103.A4 169.64,55.88 ; D103.A4 170.45,56.69 ; D103.B7 178.07,59.23 ; D103.B7 177.26,58.42 ; D103.B7 178.88,58.42 ; D103.B7 178.07,57.61 ; 28.21,39.83 D120.B6 ; D120.B6 28.21,41.45 ; D120.B6 27.4,40.64 ; D120.B6 29.02,40.64 ; 246.65,18.24 DPS1.C05 ; DPS1.C05 245.84,19.05 ; DPS1.C05 247.46,19.05 ; DPS1.C05 246.65,19.86 ; 13.77,361.95 UHC430.G1_8 ; UHC430.G1_8 15.39,361.95 ; UHC430.G1_8 14.58,362.76 ; UHC430.G1_8 14.58,361.14 ; D232.B8 39.18,388.62 ; D232.B8 38.37,389.43 ; D232.B8 38.37,387.81 ; D232.B8 37.56,388.62 ; UHC230.G4_11 19.18,349.1 ; UHC230.G4_11 19.18,347.48 ; UHC230.G4_11 19.99,348.29 ; UHC230.G4_11 18.37,348.29 ; D122.B4 96.79,82.09 ; D122.B4 97.6,81.28 ; D122.B4 96.79,80.47 ; D122.B4 95.98,81.28 ; D109.A15 242.38,335.28 ; D109.A15 240.76,335.28 ; D109.A15 241.57,334.47 ; D109.A15 241.57,336.09 ; 124.73,400.51 D428.B3 ; D428.B3 125.54,401.32 ; D428.B3 124.73,402.13 ; D428.B3 123.92,401.32 ; D231.A11 30.75,376.73 ; D231.A11 29.94,375.92 ; D231.A11 30.75,375.11 ; D231.A11 31.56,375.92 ; D101.B16 201.74,101.6 ; D101.B16 200.12,101.6 ; D101.B16 200.93,102.41 ; D101.B16 200.93,100.79 ; D115.A7 189.04,375.92 ; D115.A7 188.23,376.73 ; D115.A7 187.42,375.92 ; D115.A7 188.23,375.11 ; 183.15,375.11 D115.A9 ; D115.A9 183.15,376.73 ; D115.A9 183.96,375.92 ; D115.A9 182.34,375.92 ; 178.07,354.79 D114.A11 ; D114.A11 177.26,355.6 ; D114.A11 178.88,355.6 ; D114.A11 178.07,356.41 ; 103.6,360.68 CSDPS426.C11 ; CSDPS426.C11 104.41,359.87 ; CSDPS426.C11 105.22,360.68 ; CSDPS426.C11 104.41,361.49 ; CSDPS225.C11 105.22,330.2 ; CSDPS225.C11 104.41,331.01 ; CSDPS225.C11 103.6,330.2 ; CSDPS225.C11 104.41,329.39 ; D108.B15 272.05,38.91 ; D108.B15 271.24,38.1 ; D108.B15 272.86,38.1 ; D108.B15 272.05,37.29 ; D228.A5 120.46,396.24 ; D228.A5 118.84,396.24 ; D228.A5 119.65,397.05 ; D228.A5 119.65,395.43 ; 236.49,15.7 DPS1.B01 ; DPS1.B01 235.68,16.51 ; DPS1.B01 237.3,16.51 ; DPS1.B01 236.49,17.32 ; CSDPS229.C15 20.59,331.01 ; CSDPS229.C15 19.78,330.2 ; CSDPS229.C15 20.59,329.39 ; CSDPS229.C15 21.4,330.2 ; 240.76,38.1 D108.B3 ; D108.B3 241.57,37.29 ; D108.B3 241.57,38.91 ; D108.B3 242.38,38.1 ; D106.B16 274.59,82.09 ; D106.B16 275.4,81.28 ; D106.B16 274.59,80.47 ; D106.B16 273.78,81.28 ; 259.35,55.07 D107.A10 ; D107.A10 258.54,55.88 ; D107.A10 260.16,55.88 ; D107.A10 259.35,56.69 ; 27.4,403.86 D432.A12 ; D432.A12 28.21,404.67 ; D432.A12 28.21,403.05 ; D432.A12 29.02,403.86 ; 256,78.74 D106.B9 ; D106.B9 256.81,77.93 ; D106.B9 257.62,78.74 ; D106.B9 256.81,79.55 ; 127.27,397.97 D428.B2 ; D428.B2 127.27,399.59 ; D428.B2 128.08,398.78 ; D428.B2 126.46,398.78 ; 90.9,368.3 D227.B16 ; D227.B16 91.71,367.49 ; D227.B16 92.52,368.3 ; D227.B16 91.71,369.11 ; D106.A10 259.35,77.01 ; D106.A10 258.54,76.2 ; D106.A10 259.35,75.39 ; D106.A10 260.16,76.2 ; 256,73.66 D106.A9 ; D106.A9 256.81,74.47 ; D106.A9 257.62,73.66 ; D106.A9 256.81,72.85 ; 178.07,52.53 D103.A7 ; D103.A7 178.88,53.34 ; D103.A7 177.26,53.34 ; D103.A7 178.07,54.15 ; D121.A14 123,96.52 ; D121.A14 121.38,96.52 ; D121.A14 122.19,97.33 ; D121.A14 122.19,95.71 ; D428.B17 89.98,401.32 ; D428.B17 89.17,402.13 ; D428.B17 89.17,400.51 ; D428.B17 88.36,401.32 ; 169.64,35.56 D104.A4 ; D104.A4 171.26,35.56 ; D104.A4 170.45,36.37 ; D104.A4 170.45,34.75 ; D114.A4 196.66,353.06 ; D114.A4 195.85,353.87 ; D114.A4 195.04,353.06 ; D114.A4 195.85,352.25 ; D109.B7 262.7,330.2 ; D109.B7 261.89,329.39 ; D109.B7 261.89,331.01 ; D109.B7 261.08,330.2 ; 248.38,373.38 D111.A12 ; D111.A12 249.19,374.19 ; D111.A12 250,373.38 ; D111.A12 249.19,372.57 ; 103.6,375.92 D227.A11 ; D227.A11 104.41,376.73 ; D227.A11 104.41,375.11 ; D227.A11 105.22,375.92 ; D116.B13 173.8,391.16 ; D116.B13 172.18,391.16 ; D116.B13 172.99,390.35 ; D116.B13 172.99,391.97 ; 277.13,354.79 D110.A1 ; D110.A1 277.13,356.41 ; D110.A1 277.94,355.6 ; D110.A1 276.32,355.6 ; D228.B12 102.68,388.62 ; D228.B12 101.87,387.81 ; D228.B12 101.87,389.43 ; D228.B12 101.06,388.62 ; 89.17,375.11 D227.A17 ; D227.A17 89.98,375.92 ; D227.A17 89.17,376.73 ; D227.A17 88.36,375.92 ; D123.A1 89.17,54.15 ; D123.A1 88.36,53.34 ; D123.A1 89.17,52.53 ; D123.A1 89.98,53.34 ; D114.B10 180.61,348.79 ; D114.B10 181.42,347.98 ; D114.B10 180.61,347.17 ; D114.B10 179.8,347.98 ; D109.A10 255.08,332.74 ; D109.A10 254.27,331.93 ; D109.A10 253.46,332.74 ; D109.A10 254.27,333.55 ; D116.B9 183.96,391.16 ; D116.B9 182.34,391.16 ; D116.B9 183.15,390.35 ; D116.B9 183.15,391.97 ; D106.B5 247.46,78.74 ; D106.B5 246.65,77.93 ; D106.B5 245.84,78.74 ; D106.B5 246.65,79.55 ; 117.11,387.81 D228.B6 ; D228.B6 117.92,388.62 ; D228.B6 117.11,389.43 ; D228.B6 116.3,388.62 ; 98.52,53.34 D123.A5 ; D123.A5 99.33,52.53 ; D123.A5 100.14,53.34 ; D123.A5 99.33,54.15 ; 15.51,395.43 D232.A17 ; D232.A17 15.51,397.05 ; D232.A17 16.32,396.24 ; D232.A17 14.7,396.24 ; 114.57,405.59 D428.A7 ; D428.A7 114.57,407.21 ; D428.A7 115.38,406.4 ; D428.A7 113.76,406.4 ; 104.41,380.19 D427.B11 ; D427.B11 105.22,381 ; D427.B11 104.41,381.81 ; D427.B11 103.6,381 ; D116.B4 196.66,388.62 ; D116.B4 195.85,387.81 ; D116.B4 195.85,389.43 ; D116.B4 195.04,388.62 ; 98.52,19.05 DPS3.C05 ; DPS3.C05 99.33,18.24 ; DPS3.C05 100.14,19.05 ; DPS3.C05 99.33,19.86 ; D109.B13 247.46,330.2 ; D109.B13 246.65,331.01 ; D109.B13 246.65,329.39 ; D109.B13 245.84,330.2 ; CSDPS225.B14 97.6,332.74 ; CSDPS225.B14 96.79,333.55 ; CSDPS225.B14 96.79,331.93 ; CSDPS225.B14 95.98,332.74 ; 124.73,359.87 CSDPS426.C3 ; CSDPS426.C3 123.92,360.68 ; CSDPS426.C3 124.73,361.49 ; CSDPS426.C3 125.54,360.68 ; 45.18,73.66 D118.A13 ; D118.A13 46.8,73.66 ; D118.A13 45.99,74.47 ; D118.A13 45.99,72.85 ; 193.31,334.47 D113.A5 ; D113.A5 194.12,335.28 ; D113.A5 192.5,335.28 ; D113.A5 193.31,336.09 ; D232.A14 23.13,394.51 ; D232.A14 23.94,393.7 ; D232.A14 23.13,392.89 ; D232.A14 22.32,393.7 ; 189.96,373.38 D115.A6 ; D115.A6 191.58,373.38 ; D115.A6 190.77,372.57 ; D115.A6 190.77,374.19 ; D114.B3 198.39,351.33 ; D114.B3 199.2,350.52 ; D114.B3 197.58,350.52 ; D114.B3 198.39,349.71 ; D120.A16 54.42,35.56 ; D120.A16 52.8,35.56 ; D120.A16 53.61,34.75 ; D120.A16 53.61,36.37 ; 43.57,355.29 UHC230.G3_3 ; UHC230.G3_3 44.38,356.1 ; UHC230.G3_3 44.38,354.48 ; UHC230.G3_3 45.19,355.29 ; 271.24,355.6 D110.A3 ; D110.A3 272.05,356.41 ; D110.A3 272.86,355.6 ; D110.A3 272.05,354.79 ; 251.73,370.03 D111.B11 ; D111.B11 252.54,370.84 ; D111.B11 250.92,370.84 ; D111.B11 251.73,371.65 ; D114.A15 167.91,356.41 ; D114.A15 167.91,354.79 ; D114.A15 168.72,355.6 ; D114.A15 167.1,355.6 ; D114.A2 200.93,353.87 ; D114.A2 200.12,353.06 ; D114.A2 201.74,353.06 ; D114.A2 200.93,352.25 ; 89.17,37.29 D124.B1 ; D124.B1 88.36,38.1 ; D124.B1 89.17,38.91 ; D124.B1 89.98,38.1 ; 48.53,331.93 CSDPS229.B4 ; CSDPS229.B4 49.34,332.74 ; CSDPS229.B4 47.72,332.74 ; CSDPS229.B4 48.53,333.55 ; 89.17,32.21 D124.A1 ; D124.A1 89.17,33.83 ; D124.A1 88.36,33.02 ; D124.A1 89.98,33.02 ; 52.8,40.64 D120.B16 ; D120.B16 53.61,41.45 ; D120.B16 53.61,39.83 ; D120.B16 54.42,40.64 ; 200.12,76.2 D102.A16 ; D102.A16 200.93,75.39 ; D102.A16 201.74,76.2 ; D102.A16 200.93,77.01 ; D103.A5 172.99,54.15 ; D103.A5 173.8,53.34 ; D103.A5 172.18,53.34 ; D103.A5 172.99,52.53 ; 98.52,406.4 D428.A13 ; D428.A13 99.33,407.21 ; D428.A13 99.33,405.59 ; D428.A13 100.14,406.4 ; 25.67,380.19 D431.B13 ; D431.B13 24.86,381 ; D431.B13 26.48,381 ; D431.B13 25.67,381.81 ; 172.18,335.28 D113.A13 ; D113.A13 172.99,334.47 ; D113.A13 173.8,335.28 ; D113.A13 172.99,336.09 ; 259.35,95.71 D105.A10 ; D105.A10 259.35,97.33 ; D105.A10 258.54,96.52 ; D105.A10 260.16,96.52 ; 106.95,39.83 D124.B8 ; D124.B8 106.14,40.64 ; D124.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