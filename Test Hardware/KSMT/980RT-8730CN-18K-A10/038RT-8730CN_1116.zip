# Allegro board 038RT-8730CN_1116.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#207  -  []  322.08 231.86 90 top
NOREF#208  -  []  385.78 289.14 90 top
NOREF#209  -  []  395.61 213.47 0 top
NOREF#210  -  []  308.59 228.35 0 top
NOREF#211  -  []  487.71 292.96 0 top
NOREF#212  -  []  232.82 313.44 0 top
NOREF#213  -  []  299.15 302.15 0 top
NOREF#214  -  []  435.16 219.71 0 top
NOREF#215  -  []  205.88 300.49 0 top
NOREF#216  -  []  427.73 298.21 0 top
NOREF#217  -  []  315.22 242.53 0 top
NOREF#218  -  []  425.58 229.16 90 top
NOREF#219  -  []  393.08 302.66 90 top
NOREF#220  -  []  420.48 251.19 0 top
NOREF#221  -  []  275.71 288.59 90 top
NOREF#222  -  []  524.7 230.02 0 top
NOREF#223  -  []  524.2 224.38 0 top
NOREF#224  -  []  302.88 300.86 90 top
NOREF#225  -  []  431.11 305.56 0 top
NOREF#226  -  []  496.6 283.52 0 top
NOREF#227  -  []  328.08 227.86 90 top
NOREF#228  -  []  367.3 162.12 90 top
NOREF#229  -  []  305.15 338.13 90 top
NOREF#230  -  []  428.08 293.38 90 top
NOREF#231  -  []  527.52 228.42 90 top
NOREF#232  -  []  433.21 307.45 90 top
NOREF#233  -  []  388.47 218.61 0 top
NOREF#234  -  []  299.15 304.28 0 top
NOREF#235  -  []  313.51 214.74 0 top
NOREF#236  -  []  348.47 218.61 0 top
NOREF#237  -  []  228.97 277.75 0 top
NOREF#238  -  []  370.08 229.86 90 top
NOREF#239  -  []  430.97 233.86 90 top
NOREF#240  -  []  382.41 247.36 0 top
NOREF#241  -  []  540.2 255.35 0 top
NOREF#242  -  []  394.49 113.39 90 top
NOREF#243  -  []  375.56 336.37 0 top
NOREF#244  -  []  501.69 269.97 90 top
NOREF#245  -  []  347.66 241.41 90 top
NOREF#246  -  []  393.51 214.74 0 top
NOREF#247  -  []  305.68 237.27 90 top
NOREF#248  -  []  232.82 303.45 0 top
NOREF#249  -  []  422.11 307.89 0 top
NOREF#250  -  []  343.58 298.23 0 top
NOREF#251  -  []  496.52 294.36 0 top
NOREF#252  -  []  303.02 219.41 0 top
NOREF#253  -  []  442.13 326.4 90 top
NOREF#254  -  []  408.51 344.31 90 top
NOREF#255  -  []  287.95 300.15 90 top
NOREF#256  -  []  451 273.96 90 top
NOREF#257  -  []  300.33 270.82 0 top
NOREF#258  -  []  507.95 260.07 0 top
NOREF#259  -  []  381.83 297.65 90 top
NOREF#260  -  []  424.48 309.03 0 top
NOREF#261  -  []  389.08 304.86 90 top
NOREF#262  -  []  527.52 235.68 90 top
NOREF#263  -  []  213.31 302 90 top
NOREF#264  -  []  353.28 231.15 90 top
NOREF#265  -  []  345.15 338.13 90 top
NOREF#266  -  []  476.15 420.39 0 top
NOREF#267  -  []  345.72 310.96 90 top
NOREF#268  -  []  527.52 338.55 90 top
NOREF#269  -  []  200.81 267.36 0 top
NOREF#270  -  []  530.15 263.5 0 top
NOREF#271  -  []  383.25 297.84 0 top
NOREF#272  -  []  291.15 332.56 90 top
NOREF#273  -  []  358.47 131.53 0 top
NOREF#274  -  []  332.71 144.68 0 top
NOREF#275  -  []  414.71 309.44 90 top
NOREF#276  -  []  520.85 317.76 90 top
NOREF#277  -  []  478.6 219.23 90 top
NOREF#278  -  []  215.36 279.15 90 top
NOREF#279  -  []  463.34 247.42 90 top
NOREF#280  -  []  393.91 254.79 90 top
NOREF#281  -  []  388.2 236.49 0 top
NOREF#282  -  []  277.65 212.34 0 top
NOREF#283  -  []  486.94 308.86 0 top
NOREF#284  -  []  473.66 260.07 0 top
NOREF#285  -  []  290.08 263.86 0 top
NOREF#286  -  []  512.77 224.38 0 top
NOREF#287  -  []  516.09 288.36 90 top
NOREF#288  -  []  236.5 421.68 90 top
NOREF#289  -  []  381.78 179.81 0 top
NOREF#290  -  []  307.19 302.05 0 top
NOREF#291  -  []  444.92 224.96 0 top
NOREF#292  -  []  428.84 227.46 0 top
NOREF#293  -  []  302.85 311.73 0 top
NOREF#294  -  []  442.68 330.4 90 top
NOREF#295  -  []  434.2 241.74 90 top
NOREF#296  -  []  316.12 304.96 90 top
NOREF#297  -  []  69.58 46.86 0 top
NOREF#298  -  []  270.81 303.1 90 top
NOREF#299  -  []  382.98 236.26 0 top
NOREF#300  -  []  261.25 266.11 90 top
NOREF#301  -  []  376.04 127.81 0 top
NOREF#302  -  []  312.1 238.98 0 top
NOREF#303  -  []  473.66 225.78 0 top
NOREF#304  -  []  339.74 129.19 0 top
NOREF#305  -  []  200.81 341.34 90 top
NOREF#306  -  []  32.37 407.85 0 top
NOREF#307  -  []  380.35 304.3 90 top
NOREF#308  -  []  354.92 305.6 0 top
NOREF#309  -  []  540.2 295.57 90 top
NOREF#310  -  []  373.06 310.84 90 top
NOREF#311  -  []  463.85 299.42 0 top
NOREF#312  -  []  270.81 272.01 90 top
NOREF#313  -  []  491.34 215.27 0 top
NOREF#314  -  []  389.08 244.86 90 top
NOREF#315  -  []  213.31 336.29 90 top
NOREF#316  -  []  409.47 132.6 0 top
NOREF#317  -  []  420.35 240.82 90 top
NOREF#318  -  []  351.9 174.21 90 top
NOREF#319  -  []  392.1 238.98 0 top
NOREF#320  -  []  247.8 127.81 0 top
NOREF#321  -  []  228.44 216.43 90 top
NOREF#322  -  []  303.58 227.38 0 top
NOREF#323  -  []  302.15 238.55 0 top
NOREF#324  -  []  565.58 488.36 0 top
NOREF#325  -  []  458.45 340.72 0 top
NOREF#326  -  []  310.14 327.57 0 top
NOREF#327  -  []  350.32 231.39 90 top
NOREF#328  -  []  513.06 402.82 0 top
NOREF#329  -  []  349.77 234.51 0 top
NOREF#330  -  []  345.68 237.91 90 top
NOREF#331  -  []  423.88 296.58 0 top
NOREF#332  -  []  307.01 337.17 0 top
NOREF#333  -  []  340.33 330.81 0 top
NOREF#334  -  []  345.33 211 90 top
NOREF#335  -  []  228.97 233.47 0 top
NOREF#336  -  []  347.28 251.87 0 top
NOREF#337  -  []  447.6 335.11 0 top
NOREF#338  -  []  346.87 302.35 90 top
NOREF#339  -  []  53.97 433.34 90 top
NOREF#340  -  []  334.1 340.54 90 top
NOREF#341  -  []  308.84 287.46 0 top
NOREF#342  -  []  76.55 43.42 90 top
NOREF#343  -  []  535.43 306.84 90 top
NOREF#344  -  []  305.68 309.03 0 top
NOREF#345  -  []  261.1 216.37 0 top
NOREF#346  -  []  338.25 241.78 0 top
NOREF#347  -  []  359.59 248.7 90 top
NOREF#348  -  []  425.1 297.19 90 top
NOREF#349  -  []  277.93 132.6 0 top
NOREF#350  -  []  47.58 416.9 90 top
NOREF#351  -  []  452.04 390.1 0 top
NOREF#352  -  []  391.5 247.42 0 top
NOREF#353  -  []  336.66 163.97 0 top
NOREF#354  -  []  240.4 302.05 0 top
NOREF#355  -  []  348.09 293.43 90 top
NOREF#356  -  []  251.03 415.7 0 top
NOREF#357  -  []  380.35 240.82 90 top
NOREF#358  -  []  303.88 236.58 0 top
NOREF#359  -  []  259.56 330.24 0 top
NOREF#360  -  []  207.76 279.15 0 top
NOREF#361  -  []  380.58 339.4 0 top
NOREF#362  -  []  316.12 242.21 90 top
NOREF#363  -  []  402.13 326.4 90 top
NOREF#364  -  []  392.71 315.43 0 top
NOREF#365  -  []  270.81 337.39 90 top
NOREF#366  -  []  385.65 235.93 0 top
NOREF#367  -  []  527.52 279.96 90 top
NOREF#368  -  []  512.28 130.92 90 top
NOREF#369  -  []  524.7 252.88 0 top
NOREF#370  -  []  530.15 240.64 0 top
NOREF#371  -  []  346.37 237.89 0 top
NOREF#372  -  []  514.05 280.34 90 top
NOREF#373  -  []  305.91 124.08 90 top
NOREF#374  -  []  507.06 438.26 0 top
NOREF#375  -  []  302.98 296.26 0 top
NOREF#376  -  []  313 238.02 90 top
NOREF#377  -  []  458.45 237.85 0 top
NOREF#378  -  []  310.86 311.87 0 top
NOREF#379  -  []  198.73 298.65 0 top
NOREF#380  -  []  426.95 137.08 90 top
NOREF#381  -  []  266.46 245.89 0 top
NOREF#382  -  []  228.44 293.65 90 top
NOREF#383  -  []  252.62 244.86 90 top
NOREF#384  -  []  341.85 130.48 0 top
NOREF#385  -  []  452.3 268.58 90 top
NOREF#386  -  []  423.31 305.55 90 top
NOREF#387  -  []  228.44 327.94 90 top
NOREF#388  -  []  71.55 48.42 0 top
NOREF#389  -  []  353.51 214.74 0 top
NOREF#390  -  []  270.81 308.5 90 top
NOREF#391  -  []  464.85 207.71 90 top
NOREF#392  -  []  475.85 124.08 90 top
NOREF#393  -  []  299.08 218.86 90 top
NOREF#394  -  []  302.75 300.26 90 top
NOREF#395  -  []  519.22 170.73 90 top
NOREF#396  -  []  281.35 392 0 top
NOREF#397  -  []  343.28 226.82 0 top
NOREF#398  -  []  661.55 43.42 90 top
NOREF#399  -  []  315.58 240.86 90 top
NOREF#400  -  []  315.22 245.28 0 top
NOREF#401  -  []  343.53 319.97 90 top
NOREF#402  -  []  71.55 446.92 0 top
NOREF#403  -  []  486.94 274.57 0 top
NOREF#404  -  []  217.54 336.34 0 top
NOREF#405  -  []  423.58 310.36 0 top
NOREF#406  -  []  46.65 422.87 0 top
NOREF#407  -  []  243.37 285.01 0 top
NOREF#408  -  []  382.15 238.55 0 top
NOREF#409  -  []  458.45 272.14 0 top
NOREF#410  -  []  312.14 231.95 0 top
NOREF#411  -  []  349.92 287.85 90 top
NOREF#412  -  []  231.82 173.52 0 top
NOREF#413  -  []  313.08 310.71 90 top
NOREF#414  -  []  423.25 297.84 0 top
NOREF#415  -  []  489.91 284.56 0 top
NOREF#416  -  []  394.92 245.6 0 top
NOREF#417  -  []  405.46 250.84 0 top
NOREF#418  -  []  193.96 315.73 90 top
NOREF#419  -  []  391.1 309.26 0 top
NOREF#420  -  []  415.03 339.54 90 top
NOREF#421  -  []  301.83 237.65 90 top
NOREF#422  -  []  386.85 295.29 90 top
NOREF#423  -  []  343.58 236.95 90 top
NOREF#424  -  []  311.11 247.77 0 top
NOREF#425  -  []  383.58 179.05 0 top
NOREF#426  -  []  299.12 310.02 90 top
NOREF#427  -  []  337.86 174.37 90 top
NOREF#428  -  []  214.51 300.49 90 top
NOREF#429  -  []  495.94 324.05 90 top
NOREF#430  -  []  299.15 241.46 0 top
NOREF#431  -  []  425.36 289.74 0 top
NOREF#432  -  []  309.68 304.71 90 top
NOREF#433  -  []  300.82 113.44 90 top
NOREF#434  -  []  351.48 147.82 90 top
NOREF#435  -  []  476.15 417.82 0 top
NOREF#436  -  []  250.94 239.67 0 top
NOREF#437  -  []  193.96 212.86 90 top
NOREF#438  -  []  223.58 466.36 90 top
NOREF#439  -  []  539.65 299.98 90 top
NOREF#440  -  []  423.31 307.25 90 top
NOREF#441  -  []  299.58 301.86 0 top
NOREF#442  -  []  215.36 217.83 90 top
NOREF#443  -  []  437.46 124.08 90 top
NOREF#444  -  []  427.23 238.3 0 top
NOREF#445  -  []  305.35 242.35 90 top
NOREF#446  -  []  492.49 129.44 0 top
NOREF#447  -  []  485.39 403.62 90 top
NOREF#448  -  []  362.68 267.2 90 top
NOREF#449  -  []  200.81 278.79 0 top
NOREF#450  -  []  388.09 293.43 90 top
NOREF#451  -  []  378.25 251.94 0 top
NOREF#452  -  []  431.1 309.26 0 top
NOREF#453  -  []  374.19 117.51 90 top
NOREF#454  -  []  425.13 229.66 0 top
NOREF#455  -  []  369.86 250.84 0 top
NOREF#456  -  []  230.62 279.15 0 top
NOREF#457  -  []  345.15 340.7 90 top
NOREF#458  -  []  209.96 210.57 0 top
NOREF#459  -  []  182.93 0 90 top
NOREF#460  -  []  303.53 262.17 90 top
NOREF#461  -  []  308.65 298.59 0 top
NOREF#462  -  []  516.09 338.55 90 top
NOREF#463  -  []  312.01 304.37 0 top
NOREF#464  -  []  303.58 310.36 0 top
NOREF#465  -  []  349.12 292.03 0 top
NOREF#466  -  []  351.1 306.35 0 top
NOREF#467  -  []  74.58 41.86 90 top
NOREF#468  -  []  383.02 219.41 0 top
NOREF#469  -  []  463.34 313.8 90 top
NOREF#470  -  []  324.92 221.76 90 top
NOREF#471  -  []  207.69 150.21 90 top
NOREF#472  -  []  389.4 235.85 90 top
NOREF#473  -  []  385.35 242.35 90 top
NOREF#474  -  []  223.59 252.12 0 top
NOREF#475  -  []  426.87 301.41 90 top
NOREF#476  -  []  469.9 257.77 0 top
NOREF#477  -  []  215.36 244.86 90 top
NOREF#478  -  []  345.1 229.85 90 top
NOREF#479  -  []  41.18 382.48 0 top
NOREF#480  -  []  221.39 295.05 0 top
NOREF#481  -  []  303.58 296.95 90 top
NOREF#482  -  []  524.2 327.25 0 top
NOREF#483  -  []  425.67 302.05 0 top
NOREF#484  -  []  287.95 240.15 90 top
NOREF#485  -  []  301.19 293.6 90 top
NOREF#486  -  []  304.08 243.86 0 top
NOREF#487  -  []  524.2 258.67 0 top
NOREF#488  -  []  540.2 301.07 0 top
NOREF#489  -  []  367.3 192.6 90 top
NOREF#490  -  []  228.77 131.53 90 top
NOREF#491  -  []  433.91 314.79 90 top
NOREF#492  -  []  522.65 298.94 0 top
NOREF#493  -  []  387.45 237.26 90 top
NOREF#494  -  []  298.25 303.15 0 top
NOREF#495  -  []  379.15 304.28 0 top
NOREF#496  -  []  352.12 233.7 0 top
NOREF#497  -  []  236.9 150.21 90 top
NOREF#498  -  []  215.36 329.34 90 top
NOREF#499  -  []  461.65 258.12 0 top
NOREF#500  -  []  351.23 266.4 0 top
NOREF#501  -  []  200.26 243.69 90 top
NOREF#502  -  []  312.7 246.78 90 top
NOREF#503  -  []  298.25 242.47 0 top
NOREF#504  -  []  453.9 267.23 90 top
NOREF#505  -  []  484.51 324.05 90 top
NOREF#506  -  []  41.18 381.28 90 top
NOREF#507  -  []  411.05 243.75 0 top
NOREF#508  -  []  193.96 321.23 0 top
NOREF#509  -  []  346.06 241.41 90 top
NOREF#510  -  []  249.65 295.05 90 top
NOREF#511  -  []  333.06 250.84 90 top
NOREF#512  -  []  442.68 267.2 0 top
NOREF#513  -  []  427.66 301.41 90 top
NOREF#514  -  []  275.71 247.29 90 top
NOREF#515  -  []  379.15 302.15 0 top
NOREF#516  -  []  385.67 242.05 0 top
NOREF#517  -  []  484.74 343.15 0 top
NOREF#518  -  []  422.41 247.36 0 top
NOREF#519  -  []  518.8 267.31 0 top
NOREF#520  -  []  313.91 314.79 90 top
NOREF#521  -  []  345.68 229.23 90 top
NOREF#522  -  []  412.85 302.61 90 top
NOREF#523  -  []  427.06 238.91 90 top
NOREF#524  -  []  304.08 308.86 90 top
NOREF#525  -  []  187.37 173.52 0 top
NOREF#526  -  []  305.68 297.27 90 top
NOREF#527  -  []  307.28 251.87 0 top
NOREF#528  -  []  539.65 208.54 90 top
NOREF#529  -  []  189.36 209.4 0 top
NOREF#530  -  []  375.9 130.92 90 top
NOREF#531  -  []  427.53 251.22 90 top
NOREF#532  -  []  305.02 237.19 0 top
NOREF#533  -  []  349.17 135.43 90 top
NOREF#534  -  []  239.87 243.46 90 top
NOREF#535  -  []  212.11 231.91 0 top
NOREF#536  -  []  428.96 339.4 90 top
NOREF#537  -  []  325.46 310.84 0 top
NOREF#538  -  []  384.69 268.37 0 top
NOREF#539  -  []  300.35 244.3 90 top
NOREF#540  -  []  391.11 304.05 0 top
NOREF#541  -  []  305.15 338.13 90 top
NOREF#542  -  []  303.28 228.64 0 top
NOREF#543  -  []  207.76 329.34 0 top
NOREF#544  -  []  305.35 296.29 90 top
NOREF#545  -  []  189.36 289.41 0 top
NOREF#546  -  []  327.95 242.35 90 top
NOREF#547  -  []  472.54 281.36 0 top
NOREF#548  -  []  433.91 254.79 90 top
NOREF#549  -  []  69.58 506.86 0 top
NOREF#550  -  []  429.74 293.89 90 top
NOREF#551  -  []  380.35 244.3 90 top
NOREF#552  -  []  407.66 250.84 0 top
NOREF#553  -  []  362.08 291.86 90 top
NOREF#554  -  []  429.32 251.23 90 top
NOREF#555  -  []  423.32 254.56 90 top
NOREF#556  -  []  512.77 292.96 0 top
NOREF#557  -  []  342.87 137.08 90 top
NOREF#558  -  []  387.66 293.75 0 top
NOREF#559  -  []  507.37 332.69 90 top
NOREF#560  -  []  278.56 275.44 0 top
NOREF#561  -  []  455.22 268.96 90 top
NOREF#562  -  []  244.25 295.05 0 top
NOREF#563  -  []  469.4 245.17 0 top
NOREF#564  -  []  438.21 329.35 90 top
NOREF#565  -  []  281.35 392 90 top
NOREF#566  -  []  352.01 248.09 0 top
NOREF#567  -  []  313.51 212.15 0 top
NOREF#568  -  []  292.85 302.61 0 top
NOREF#569  -  []  362.68 272.6 90 top
NOREF#570  -  []  380.35 241.51 90 top
NOREF#571  -  []  229.82 424.22 0 top
NOREF#572  -  []  386.85 297.41 0 top
NOREF#573  -  []  343.58 288.32 0 top
NOREF#574  -  []  433.34 259.97 90 top
NOREF#575  -  []  71.55 48.42 0 top
NOREF#576  -  []  353 302.38 0 top
NOREF#577  -  []  300.57 339.4 0 top
NOREF#578  -  []  200.81 324.51 0 top
NOREF#579  -  []  378.25 243.15 0 top
NOREF#580  -  []  337.92 310.66 0 top
NOREF#581  -  []  347.91 233.69 90 top
NOREF#582  -  []  426.16 239.87 0 top
NOREF#583  -  []  393.34 319.97 90 top
NOREF#584  -  []  490.55 401.56 0 top
NOREF#585  -  []  367.14 189.45 90 top
NOREF#586  -  []  302.44 255.5 90 top
NOREF#587  -  []  230.23 131.53 0 top
NOREF#588  -  []  507.37 284.56 0 top
NOREF#589  -  []  481.54 229.82 90 top
NOREF#590  -  []  283.28 339.93 90 top
NOREF#591  -  []  352 306.67 0 top
NOREF#592  -  []  230.62 313.44 0 top
NOREF#593  -  []  389.74 287.14 0 top
NOREF#594  -  []  285.09 268.96 90 top
NOREF#595  -  []  424.9 286.88 0 top
NOREF#596  -  []  385.4 251.86 0 top
NOREF#597  -  []  360.19 212.2 90 top
NOREF#598  -  []  309.85 237.94 90 top
NOREF#599  -  []  293.06 310.84 90 top
NOREF#600  -  []  333.78 406.82 90 top
NOREF#601  -  []  491.34 283.85 0 top
NOREF#602  -  []  362.13 266.4 90 top
NOREF#603  -  []  281.41 209.42 90 top
NOREF#604  -  []  279.08 254.86 0 top
NOREF#605  -  []  392.7 306.78 90 top
NOREF#606  -  []  238.22 234.87 90 top
NOREF#607  -  []  383.9 237.85 0 top
NOREF#608  -  []  346.87 237.85 0 top
NOREF#609  -  []  425.77 229.36 90 top
NOREF#610  -  []  428.96 330.75 0 top
NOREF#611  -  []  357.31 128.8 90 top
NOREF#612  -  []  69.58 506.86 0 top
NOREF#613  -  []  222.92 148.72 0 top
NOREF#614  -  []  428.44 250.97 90 top
NOREF#615  -  []  342.11 246.19 0 top
NOREF#616  -  []  353 238.02 90 top
NOREF#617  -  []  304.48 226.18 90 top
NOREF#618  -  []  520.85 209.81 90 top
NOREF#619  -  []  306.16 299.87 0 top
NOREF#620  -  []  408.08 287.86 90 top
NOREF#621  -  []  242.05 260.76 0 top
NOREF#622  -  []  430.79 340.67 0 top
NOREF#623  -  []  444.22 338.45 0 top
NOREF#624  -  []  311.8 299.51 0 top
NOREF#625  -  []  390.97 293.86 90 top
NOREF#626  -  []  540.2 307 90 top
NOREF#627  -  []  470.69 234.42 0 top
NOREF#628  -  []  312.1 301.21 0 top
NOREF#629  -  []  367.3 160.17 90 top
NOREF#630  -  []  402.68 267.2 90 top
NOREF#631  -  []  533.35 267.34 90 top
NOREF#632  -  []  423.28 288.64 0 top
NOREF#633  -  []  307.08 306.86 0 top
NOREF#634  -  []  305.68 249.03 0 top
NOREF#635  -  []  270.31 329.89 0 top
NOREF#636  -  []  507.95 234.42 0 top
NOREF#637  -  []  536.7 212.38 0 top
NOREF#638  -  []  270.81 342.79 90 top
NOREF#639  -  []  386.16 239.87 0 top
NOREF#640  -  []  342.44 255.5 90 top
NOREF#641  -  []  342.87 141.48 90 top
NOREF#642  -  []  355.61 210.88 0 top
NOREF#643  -  []  305.35 302.35 90 top
NOREF#644  -  []  392.1 298.98 0 top
NOREF#645  -  []  428.65 298.59 0 top
NOREF#646  -  []  230.62 226.47 0 top
NOREF#647  -  []  147.4 429.04 0 top
NOREF#648  -  []  298.25 301.78 0 top
NOREF#649  -  []  423.9 230.5 0 top
NOREF#650  -  []  345.35 297.58 0 top
NOREF#651  -  []  272.51 227.02 0 top
NOREF#652  -  []  294.38 259.56 0 top
NOREF#653  -  []  448.54 271.5 0 top
NOREF#654  -  []  245.02 217.83 0 top
NOREF#655  -  []  524.2 292.96 0 top
NOREF#656  -  []  524.7 275.74 0 top
NOREF#657  -  []  391.11 305.56 0 top
NOREF#658  -  []  303.58 228.32 0 top
NOREF#659  -  []  355.02 301.03 0 top
NOREF#660  -  []  307.08 306.86 0 top
NOREF#661  -  []  350.59 415.7 0 top
NOREF#662  -  []  486.94 335.89 0 top
NOREF#663  -  []  238.87 264.33 90 top
NOREF#664  -  []  250.94 308.25 0 top
NOREF#665  -  []  368.34 194.29 0 top
NOREF#666  -  []  76.55 43.42 90 top
NOREF#667  -  []  275.71 213 90 top
NOREF#668  -  []  306.46 336.37 90 top
NOREF#669  -  []  342.98 296.26 0 top
NOREF#670  -  []  457.12 396.45 0 top
NOREF#671  -  []  485.09 337.29 0 top
NOREF#672  -  []  309.92 227.85 90 top
NOREF#673  -  []  409.86 310.84 0 top
NOREF#674  -  []  346.7 225.88 90 top
NOREF#675  -  []  404.92 221.76 90 top
NOREF#676  -  []  530.15 217.78 0 top
NOREF#677  -  []  381.08 251.06 0 top
NOREF#678  -  []  293.88 243.99 90 top
NOREF#679  -  []  46.35 422.55 90 top
NOREF#680  -  []  522 258.67 0 top
NOREF#681  -  []  442.47 232.94 0 top
NOREF#682  -  []  382.41 306.51 0 top
NOREF#683  -  []  527.52 322.65 90 top
NOREF#684  -  []  378.48 340.67 0 top
NOREF#685  -  []  480.72 419.12 90 top
NOREF#686  -  []  425.68 289.22 90 top
NOREF#687  -  []  345.86 299.55 0 top
NOREF#688  -  []  389.85 297.94 90 top
NOREF#689  -  []  441.62 227.86 45 top
NOREF#690  -  []  261.25 300.4 90 top
NOREF#691  -  []  301.68 251.19 0 top
NOREF#692  -  []  472.54 247.07 0 top
NOREF#693  -  []  382.54 160.17 90 top
NOREF#694  -  []  385.08 308.86 0 top
NOREF#695  -  []  336.8 121.67 0 top
NOREF#696  -  []  391.81 255.75 0 top
NOREF#697  -  []  422.11 247.89 0 top
NOREF#698  -  []  484.51 281.36 90 top
NOREF#699  -  []  228.97 302.05 0 top
NOREF#700  -  []  343.53 262.17 90 top
NOREF#701  -  []  334.25 296.3 90 top
NOREF#702  -  []  74.58 41.86 90 top
NOREF#703  -  []  228.44 225.07 90 top
NOREF#704  -  []  290.08 263.86 0 top
NOREF#705  -  []  285.09 268.07 90 top
NOREF#706  -  []  533.35 303.82 90 top
NOREF#707  -  []  393.51 217.31 0 top
NOREF#708  -  []  433 301.53 0 top
NOREF#709  -  []  294.88 268.37 0 top
NOREF#710  -  []  374.44 125.18 0 top
NOREF#711  -  []  193.96 235.72 90 top
NOREF#712  -  []  424.69 328.37 0 top
NOREF#713  -  []  349.74 233.89 90 top
NOREF#714  -  []  349.74 292.01 0 top
NOREF#715  -  []  413.06 250.84 90 top
NOREF#716  -  []  49.28 401.61 0 top
NOREF#717  -  []  420.33 267.57 0 top
NOREF#718  -  []  524.7 344.32 0 top
NOREF#719  -  []  334.71 249.44 90 top
NOREF#720  -  []  477.22 248.67 90 top
NOREF#721  -  []  52.38 416.76 0 top
NOREF#722  -  []  432.9 339.4 0 top
NOREF#723  -  []  283.01 208.07 90 top
NOREF#724  -  []  277.8 210.77 90 top
NOREF#725  -  []  230.62 260.76 0 top
NOREF#726  -  []  392 309.58 0 top
NOREF#727  -  []  425.72 250.96 90 top
NOREF#728  -  []  307.6 310.97 90 top
NOREF#729  -  []  351.8 298.66 0 top
NOREF#730  -  []  389.74 233.89 90 top
NOREF#731  -  []  309.12 232.03 0 top
NOREF#732  -  []  368.34 159.13 90 top
NOREF#733  -  []  349.08 248.46 90 top
NOREF#734  -  []  426.06 301.41 90 top
NOREF#735  -  []  386.33 311.86 0 top
NOREF#736  -  []  499.14 292.96 0 top
NOREF#737  -  []  249.42 313.44 0 top
NOREF#738  -  []  422.11 246.19 0 top
NOREF#739  -  []  447.77 324.41 0 top
NOREF#740  -  []  219.19 295.05 0 top
NOREF#741  -  []  383.88 295.94 0 top
NOREF#742  -  []  293.84 123.34 90 top
NOREF#743  -  []  422.75 241.46 90 top
NOREF#744  -  []  259.56 295.95 0 top
NOREF#745  -  []  344.76 289.66 0 top
NOREF#746  -  []  346.33 251.86 0 top
NOREF#747  -  []  432.88 125.35 0 top
NOREF#748  -  []  385.01 229.28 0 top
NOREF#749  -  []  341.85 125.35 0 top
NOREF#750  -  []  436.05 219.71 0 top
NOREF#751  -  []  485.39 409.02 90 top
NOREF#752  -  []  434.92 305.6 0 top
NOREF#753  -  []  226.79 244.86 90 top
NOREF#754  -  []  315.02 301.03 0 top
NOREF#755  -  []  383.58 236.95 90 top
NOREF#756  -  []  388.09 233.15 90 top
NOREF#757  -  []  410.32 284.96 0 top
NOREF#758  -  []  270.26 268.01 90 top
NOREF#759  -  []  426.06 241.41 90 top
NOREF#760  -  []  385.08 295.3 90 top
NOREF#761  -  []  392 249.58 0 top
NOREF#762  -  []  536.7 326.68 0 top
NOREF#763  -  []  343.25 297.84 0 top
NOREF#764  -  []  377.6 309.76 90 top
NOREF#765  -  []  305.65 295.93 0 top
NOREF#766  -  []  292.08 221.86 90 top
NOREF#767  -  []  246.19 125.18 0 top
NOREF#768  -  []  344.08 248.86 90 top
NOREF#769  -  []  311.81 255.75 0 top
NOREF#770  -  []  266.46 259.91 0 top
NOREF#771  -  []  270.31 227.02 0 top
NOREF#772  -  []  501.34 292.96 0 top
NOREF#773  -  []  507.95 310.26 0 top
NOREF#774  -  []  288.01 269.34 90 top
NOREF#775  -  []  437.47 338.13 90 top
NOREF#776  -  []  477.22 214.38 90 top
NOREF#777  -  []  466.98 402.82 0 top
NOREF#778  -  []  404.75 305.55 0 top
NOREF#779  -  []  419.99 294.24 0 top
NOREF#780  -  []  350.94 286.5 90 top
NOREF#781  -  []  215.36 260.76 90 top
NOREF#782  -  []  433.28 231.15 90 top
NOREF#783  -  []  299.67 233.34 90 top
NOREF#784  -  []  312 246.67 0 top
NOREF#785  -  []  433 298.87 90 top
NOREF#786  -  []  354.2 300.89 90 top
NOREF#787  -  []  340.01 168.64 90 top
NOREF#788  -  []  299.15 301.46 0 top
NOREF#789  -  []  419.99 234.24 0 top
NOREF#790  -  []  387.66 233.75 0 top
NOREF#791  -  []  388.07 297.2 90 top
NOREF#792  -  []  318.17 337.05 0 top
NOREF#793  -  []  301.34 127.92 0 top
NOREF#794  -  []  287.08 266.86 0 top
NOREF#795  -  []  314.2 241.74 90 top
NOREF#796  -  []  302.15 298.55 0 top
NOREF#797  -  []  418.25 303.15 0 top
NOREF#798  -  []  535.43 272.55 90 top
NOREF#799  -  []  345.36 289.74 0 top
NOREF#800  -  []  484.74 335.89 0 top
NOREF#801  -  []  385.77 229.16 90 top
NOREF#802  -  []  306.87 241.41 90 top
NOREF#803  -  []  379.99 234.24 0 top
NOREF#804  -  []  472.03 218.69 90 top
NOREF#805  -  []  407.95 242.35 90 top
NOREF#806  -  []  425.08 295.3 90 top
NOREF#807  -  []  353.1 163.81 0 top
NOREF#808  -  []  449.58 488.36 0 top
NOREF#809  -  []  471.23 286.16 0 top
NOREF#810  -  []  429.08 308.46 90 top
NOREF#811  -  []  238.22 279.15 90 top
NOREF#812  -  []  303.9 230.5 0 top
NOREF#813  -  []  533.35 280.96 90 top
NOREF#814  -  []  299.23 131.75 0 top
NOREF#815  -  []  303.28 288.64 0 top
NOREF#816  -  []  425.78 229.41 90 top
NOREF#817  -  []  514.63 126.36 90 top
NOREF#818  -  []  463.85 292.41 0 top
NOREF#819  -  []  425.65 295.93 0 top
NOREF#820  -  []  193.96 241.22 0 top
NOREF#821  -  []  389.32 311.23 90 top
NOREF#822  -  []  432.01 304.37 0 top
NOREF#823  -  []  348.09 233.43 90 top
NOREF#824  -  []  306.7 225.88 90 top
NOREF#825  -  []  40.9 419.44 0 top
NOREF#826  -  []  471.23 217.58 0 top
NOREF#827  -  []  209.96 286.41 0 top
NOREF#828  -  []  307.44 293.68 0 top
NOREF#829  -  []  524.7 332.89 0 top
NOREF#830  -  []  283.38 334.94 90 top
NOREF#831  -  []  514.05 211.76 90 top
NOREF#832  -  []  238.22 260.76 90 top
NOREF#833  -  []  378.48 338.08 0 top
NOREF#834  -  []  404.22 338.45 0 top
NOREF#835  -  []  228.97 312.04 0 top
NOREF#836  -  []  238.22 295.05 90 top
NOREF#837  -  []  333.78 403.62 0 top
NOREF#838  -  []  420.35 301.51 90 top
NOREF#839  -  []  69.58 506.86 0 top
NOREF#840  -  []  414.94 244.03 90 top
NOREF#841  -  []  268.11 295.6 0 top
NOREF#842  -  []  309.12 292.03 0 top
NOREF#843  -  []  330.76 123.34 0 top
NOREF#844  -  []  295.78 323.31 90 top
NOREF#845  -  []  352.66 117.24 0 top
NOREF#846  -  []  449.48 209.62 0 top
NOREF#847  -  []  387.72 114.8 0 top
NOREF#848  -  []  355.67 415.7 0 top
NOREF#849  -  []  368.34 174.37 90 top
NOREF#850  -  []  418.98 213.2 90 top
NOREF#851  -  []  385.68 297.91 90 top
NOREF#852  -  []  390.58 243.36 90 top
NOREF#853  -  []  287.08 226.86 90 top
NOREF#854  -  []  335.63 113.92 90 top
NOREF#855  -  []  368.08 287.86 90 top
NOREF#856  -  []  306.85 297.41 0 top
NOREF#857  -  []  386.06 301.41 90 top
NOREF#858  -  []  309.54 237.24 0 top
NOREF#859  -  []  375.93 330.81 0 top
NOREF#860  -  []  229.82 421.66 0 top
NOREF#861  -  []  378.25 305.26 0 top
NOREF#862  -  []  471.27 125.35 0 top
NOREF#863  -  []  351.67 215.41 90 top
NOREF#864  -  []  378.24 126.36 90 top
NOREF#865  -  []  251.3 259.36 90 top
NOREF#866  -  []  228.77 131.53 0 top
NOREF#867  -  []  332.11 303.78 0 top
NOREF#868  -  []  228.44 267.76 90 top
NOREF#869  -  []  510.82 125.18 0 top
NOREF#870  -  []  392.1 301.21 0 top
NOREF#871  -  []  359.08 238.86 90 top
NOREF#872  -  []  200.81 259.12 90 top
NOREF#873  -  []  341.08 117.51 0 top
NOREF#874  -  []  279.3 306.35 0 top
NOREF#875  -  []  200.81 293.41 90 top
NOREF#876  -  []  392.01 305.88 0 top
NOREF#877  -  []  515.27 420.39 0 top
NOREF#878  -  []  340.35 302.19 90 top
NOREF#879  -  []  356.12 304.96 90 top
NOREF#880  -  []  219.19 337.74 0 top
NOREF#881  -  []  440.2 280.06 90 top
NOREF#882  -  []  320.19 212.2 90 top
NOREF#883  -  []  347.31 233.29 0 top
NOREF#884  -  []  173.58 87.36 0 top
NOREF#885  -  []  404.92 284.96 0 top
NOREF#886  -  []  270.81 234.52 90 top
NOREF#887  -  []  336.82 162.77 0 top
NOREF#888  -  []  460.14 250.62 0 top
NOREF#889  -  []  200.26 209.4 90 top
NOREF#890  -  []  343.58 228.32 90 top
NOREF#891  -  []  356.8 211.22 0 top
NOREF#892  -  []  428.09 233.15 90 top
NOREF#893  -  []  458.45 220.63 90 top
NOREF#894  -  []  389.74 227.14 0 top
NOREF#895  -  []  384.86 242.05 0 top
NOREF#896  -  []  292.85 302.61 90 top
NOREF#897  -  []  518.8 339.95 90 top
NOREF#898  -  []  213.31 267.71 90 top
NOREF#899  -  []  382.98 296.26 0 top
NOREF#900  -  []  433.21 303.73 90 top
NOREF#901  -  []  353 298.87 90 top
NOREF#902  -  []  198.73 321.51 0 top
NOREF#903  -  []  368.71 208.35 90 top
NOREF#904  -  []  504.66 219.78 90 top
NOREF#905  -  []  249.65 269.16 90 top
NOREF#906  -  []  535.43 244.31 0 top
NOREF#907  -  []  379.15 301.46 0 top
NOREF#908  -  []  266.46 321.48 0 top
NOREF#909  -  []  217.54 225.07 0 top
NOREF#910  -  []  410.51 343.81 90 top
NOREF#911  -  []  242.05 329.34 0 top
NOREF#912  -  []  325.46 250.84 0 top
NOREF#913  -  []  353.1 159.13 90 top
NOREF#914  -  []  463.85 306.43 0 top
NOREF#915  -  []  385.53 179.05 0 top
NOREF#916  -  []  383.53 319.97 90 top
NOREF#917  -  []  71.55 446.92 0 top
NOREF#918  -  []  380.33 270.82 0 top
NOREF#919  -  []  174.46 249.9 0 top
NOREF#920  -  []  360.19 209.61 90 top
NOREF#921  -  []  385.1 237.2 90 top
NOREF#922  -  []  305.68 289.22 90 top
NOREF#923  -  []  385.08 248.86 0 top
NOREF#924  -  []  484.51 327.25 0 top
NOREF#925  -  []  385.16 335.54 90 top
NOREF#926  -  []  351.16 148.72 0 top
NOREF#927  -  []  379.08 274.86 0 top
NOREF#928  -  []  426.87 242.35 90 top
NOREF#929  -  []  249.65 337.74 90 top
NOREF#930  -  []  340.58 339.4 0 top
NOREF#931  -  []  345.1 289.85 90 top
NOREF#932  -  []  342.13 218.6 0 top
NOREF#933  -  []  427.06 298.91 90 top
NOREF#934  -  []  302.11 247.04 0 top
NOREF#935  -  []  450.32 224.96 0 top
NOREF#936  -  []  306.37 297.89 0 top
NOREF#937  -  []  392.14 231.95 0 top
NOREF#938  -  []  226.79 320.7 90 top
NOREF#939  -  []  198.73 326.89 90 top
NOREF#940  -  []  428.12 251.87 0 top
NOREF#941  -  []  352.1 302.06 0 top
NOREF#942  -  []  367.3 178.01 0 top
NOREF#943  -  []  361.32 117.51 0 top
NOREF#944  -  []  266.46 294.2 0 top
NOREF#945  -  []  473.66 251.67 0 top
NOREF#946  -  []  468.6 216.68 0 top
NOREF#947  -  []  305.78 229.14 90 top
NOREF#948  -  []  300.48 311.19 0 top
NOREF#949  -  []  480.72 416.55 90 top
NOREF#950  -  []  392.12 233.7 0 top
NOREF#951  -  []  387.06 233.68 0 top
NOREF#952  -  []  427.89 293.18 90 top
NOREF#953  -  []  300.35 301.51 90 top
NOREF#954  -  []  217.54 285.01 0 top
NOREF#955  -  []  51.44 432.39 0 top
NOREF#956  -  []  342.88 240.86 90 top
NOREF#957  -  []  312.1 299.83 0 top
NOREF#958  -  []  382.54 190.65 90 top
NOREF#959  -  []  207.76 313.44 0 top
NOREF#960  -  []  232.82 260.76 0 top
NOREF#961  -  []  242.05 337.74 0 top
NOREF#962  -  []  349.92 227.85 90 top
NOREF#963  -  []  393.36 340.38 90 top
NOREF#964  -  []  399.64 318.32 90 top
NOREF#965  -  []  410.08 263.86 0 top
NOREF#966  -  []  404.92 218.6 0 top
NOREF#967  -  []  329.86 250.84 0 top
NOREF#968  -  []  374.38 319.56 0 top
NOREF#969  -  []  282.26 336.37 0 top
NOREF#970  -  []  436.12 306.33 90 top
NOREF#971  -  []  370.08 263.86 0 top
NOREF#972  -  []  340.48 251.19 0 top
NOREF#973  -  []  429.44 292.33 90 top
NOREF#974  -  []  231.04 339.9 0 top
NOREF#975  -  []  528.27 253.23 0 top
NOREF#976  -  []  401.62 227.86 45 top
NOREF#977  -  []  540.2 335.36 0 top
NOREF#978  -  []  309.13 338.13 90 top
NOREF#979  -  []  387.66 293.29 0 top
NOREF#980  -  []  458.45 230.84 0 top
NOREF#981  -  []  381.78 195.05 0 top
NOREF#982  -  []  380.58 341.97 0 top
NOREF#983  -  []  423.59 125.38 90 top
NOREF#984  -  []  436.12 302.21 90 top
NOREF#985  -  []  208.88 231.38 90 top
NOREF#986  -  []  460.14 284.91 0 top
NOREF#987  -  []  458.45 337.52 90 top
NOREF#988  -  []  379.15 244.94 0 top
NOREF#989  -  []  429.44 232.33 90 top
NOREF#990  -  []  320.19 209.61 90 top
NOREF#991  -  []  422.44 315.5 90 top
NOREF#992  -  []  43.4 453.95 90 top
NOREF#993  -  []  501.69 304.26 90 top
NOREF#994  -  []  533.35 315.25 90 top
NOREF#995  -  []  515.27 422.95 0 top
NOREF#996  -  []  536.7 235.24 0 top
NOREF#997  -  []  223.59 295.05 0 top
NOREF#998  -  []  339.67 144.68 0 top
NOREF#999  -  []  516.68 178.35 0 top
NOREF#1000  -  []  221.58 488.36 0 top
NOREF#1001  -  []  230.62 303.45 0 top
NOREF#1002  -  []  383.58 250.36 0 top
NOREF#1003  -  []  217.01 293.65 90 top
NOREF#1004  -  []  290.84 123.86 0 top
NOREF#1005  -  []  418.25 301.78 0 top
NOREF#1006  -  []  536.7 258.1 0 top
NOREF#1007  -  []  339.08 218.86 90 top
NOREF#1008  -  []  367.14 179.21 0 top
NOREF#1009  -  []  364.9 140.92 0 top
NOREF#1010  -  []  303.88 235.94 0 top
NOREF#1011  -  []  279.08 298.86 90 top
NOREF#1012  -  []  294.25 296.3 90 top
NOREF#1013  -  []  200.26 335.13 90 top
NOREF#1014  -  []  424.75 295.61 0 top
NOREF#1015  -  []  336.68 219.4 0 top
NOREF#1016  -  []  430.97 293.86 90 top
NOREF#1017  -  []  230.26 140.81 0 top
NOREF#1018  -  []  200.26 220.83 90 top
NOREF#1019  -  []  385.68 237.27 90 top
NOREF#1020  -  []  308.49 297.58 90 top
NOREF#1021  -  []  262.89 305.38 90 top
NOREF#1022  -  []  525.83 376.82 0 top
NOREF#1023  -  []  379.15 304.94 0 top
NOREF#1024  -  []  530.15 252.07 0 top
NOREF#1025  -  []  525.83 376.82 90 top
NOREF#1026  -  []  207.76 320.7 0 top
NOREF#1027  -  []  69.58 46.86 0 top
NOREF#1028  -  []  325.45 210.89 0 top
NOREF#1029  -  []  309.92 287.85 90 top
NOREF#1030  -  []  348.84 287.46 0 top
NOREF#1031  -  []  507.37 301.6 0 top
NOREF#1032  -  []  342.15 298.55 0 top
NOREF#1033  -  []  347.53 251.22 90 top
NOREF#1034  -  []  389.83 318.32 90 top
NOREF#1035  -  []  354.92 246.97 0 top
NOREF#1036  -  []  301.08 298.36 0 top
NOREF#1037  -  []  353.34 262.17 90 top
NOREF#1038  -  []  382.11 247.89 0 top
NOREF#1039  -  []  527.07 214.89 90 top
NOREF#1040  -  []  461.65 292.41 0 top
NOREF#1041  -  []  345.78 289.41 90 top
NOREF#1042  -  []  326.69 392 0 top
NOREF#1043  -  []  277.36 328.49 90 top
NOREF#1044  -  []  343.53 330.81 90 top
NOREF#1045  -  []  338.47 340.67 0 top
NOREF#1046  -  []  223.59 279.15 0 top
NOREF#1047  -  []  306.85 235.29 90 top
NOREF#1048  -  []  228.44 312.04 90 top
NOREF#1049  -  []  426.95 375.51 0 top
NOREF#1050  -  []  343.35 237.91 90 top
NOREF#1051  -  []  475.85 124.08 90 top
NOREF#1052  -  []  236.5 419.12 90 top
NOREF#1053  -  []  385.86 299.55 0 top
NOREF#1054  -  []  429.4 295.85 90 top
NOREF#1055  -  []  291.05 303.74 0 top
NOREF#1056  -  []  432.01 308.09 0 top
NOREF#1057  -  []  257.39 272.36 0 top
NOREF#1058  -  []  418.25 242.47 0 top
NOREF#1059  -  []  304.08 248.86 90 top
NOREF#1060  -  []  303.58 286.5 0 top
NOREF#1061  -  []  539.65 242.83 90 top
NOREF#1062  -  []  305.35 297.58 0 top
NOREF#1063  -  []  217.01 327.94 90 top
NOREF#1064  -  []  472.91 218.43 90 top
NOREF#1065  -  []  283.38 344.2 90 top
NOREF#1066  -  []  363.25 209.62 0 top
NOREF#1067  -  []  343.58 236.95 90 top
NOREF#1068  -  []  270.31 247.29 0 top
NOREF#1069  -  []  418.3 145.48 0 top
NOREF#1070  -  []  301.7 135.43 90 top
NOREF#1071  -  []  41.87 407.27 90 top
NOREF#1072  -  []  343.26 228.02 0 top
NOREF#1073  -  []  428.65 238.59 0 top
NOREF#1074  -  []  305.1 229.85 90 top
NOREF#1075  -  []  276.6 342.47 0 top
NOREF#1076  -  []  378.13 330.81 0 top
NOREF#1077  -  []  383.58 310.36 0 top
NOREF#1078  -  []  287.95 302.35 90 top
NOREF#1079  -  []  352.06 162.12 90 top
NOREF#1080  -  []  252.62 320.7 90 top
NOREF#1081  -  []  320.19 214.77 90 top
NOREF#1082  -  []  305.77 229.16 90 top
NOREF#1083  -  []  470.69 310.26 0 top
NOREF#1084  -  []  300.48 251.18 0 top
NOREF#1085  -  []  425.67 242.05 0 top
NOREF#1086  -  []  301.34 130.48 0 top
NOREF#1087  -  []  71.55 446.92 0 top
NOREF#1088  -  []  527.52 288.36 90 top
NOREF#1089  -  []  259.73 230.88 90 top
NOREF#1090  -  []  431.1 249.26 0 top
NOREF#1091  -  []  312.08 299.36 90 top
NOREF#1092  -  []  385.16 335.54 90 top
NOREF#1093  -  []  425.35 242.35 90 top
NOREF#1094  -  []  442.68 327.2 90 top
NOREF#1095  -  []  485.09 328.65 0 top
NOREF#1096  -  []  420.35 304.3 90 top
NOREF#1097  -  []  364.92 281.76 90 top
NOREF#1098  -  []  430.78 126.62 0 top
NOREF#1099  -  []  306.6 311.22 90 top
NOREF#1100  -  []  440.62 218.44 90 top
NOREF#1101  -  []  319.08 238.86 90 top
NOREF#1102  -  []  422.41 248.21 0 top
NOREF#1103  -  []  384.13 109.32 90 top
NOREF#1104  -  []  313.2 248.94 90 top
NOREF#1105  -  []  331.5 417.82 0 top
NOREF#1106  -  []  458.45 227.64 90 top
NOREF#1107  -  []  385.6 289.67 90 top
NOREF#1108  -  []  268.11 247.29 0 top
NOREF#1109  -  []  397.97 209.36 90 top
NOREF#1110  -  []  412.08 331.86 0 top
NOREF#1111  -  []  316.12 244.96 90 top
NOREF#1112  -  []  200.81 270.55 90 top
NOREF#1113  -  []  304.9 286.88 0 top
NOREF#1114  -  []  383.58 296.95 90 top
NOREF#1115  -  []  228.97 327.94 0 top
NOREF#1116  -  []  402.68 272.6 90 top
NOREF#1117  -  []  294.94 304.03 90 top
NOREF#1118  -  []  305.58 289.16 90 top
NOREF#1119  -  []  428.84 287.46 0 top
NOREF#1120  -  []  230.62 286.41 0 top
NOREF#1121  -  []  433.34 264.37 90 top
NOREF#1122  -  []  427.6 250.97 90 top
NOREF#1123  -  []  305.18 269.42 90 top
NOREF#1124  -  []  390.32 291.39 90 top
NOREF#1125  -  []  476.15 422.95 0 top
NOREF#1126  -  []  524.51 406.82 90 top
NOREF#1127  -  []  347.06 233.68 0 top
NOREF#1128  -  []  308.54 234.54 0 top
NOREF#1129  -  []  423.58 288.32 0 top
NOREF#1130  -  []  350.14 267.57 0 top
NOREF#1131  -  []  486.94 267.31 0 top
NOREF#1132  -  []  391.16 270.75 0 top
NOREF#1133  -  []  286.75 145.48 0 top
NOREF#1134  -  []  244.25 226.47 0 top
NOREF#1135  -  []  469.16 270.37 90 top
NOREF#1136  -  []  382.75 240.26 90 top
NOREF#1137  -  []  428.44 310.97 90 top
NOREF#1138  -  []  448.59 209.62 0 top
NOREF#1139  -  []  392.1 239.83 0 top
NOREF#1140  -  []  306.33 251.86 0 top
NOREF#1141  -  []  425.07 220.36 90 top
NOREF#1142  -  []  540.2 232.49 0 top
NOREF#1143  -  []  473.94 402.82 0 top
NOREF#1144  -  []  486.94 301.6 0 top
NOREF#1145  -  []  478.6 287.81 90 top
NOREF#1146  -  []  270.26 233.72 90 top
NOREF#1147  -  []  307.66 241.41 90 top
NOREF#1148  -  []  428.12 228.85 0 top
NOREF#1149  -  []  422.41 246.51 0 top
NOREF#1150  -  []  489.91 250.27 0 top
NOREF#1151  -  []  198.73 241.5 0 top
NOREF#1152  -  []  379.67 233.34 90 top
NOREF#1153  -  []  294.71 309.44 90 top
NOREF#1154  -  []  353.21 243.73 90 top
NOREF#1155  -  []  423.31 306.4 90 top
NOREF#1156  -  []  345.65 235.93 0 top
NOREF#1157  -  []  344.48 288 90 top
NOREF#1158  -  []  368.34 163.81 0 top
NOREF#1159  -  []  346.14 302.35 90 top
NOREF#1160  -  []  346.46 302.05 0 top
NOREF#1161  -  []  412.85 242.61 90 top
NOREF#1162  -  []  393.36 337.18 0 top
NOREF#1163  -  []  310.3 236.62 90 top
NOREF#1164  -  []  353.2 308.94 90 top
NOREF#1165  -  []  299.15 311.62 0 top
NOREF#1166  -  []  496.52 225.78 0 top
NOREF#1167  -  []  374.38 294.16 90 top
NOREF#1168  -  []  426.37 297.89 0 top
NOREF#1169  -  []  338.25 301.78 0 top
NOREF#1170  -  []  431.23 266.4 0 top
NOREF#1171  -  []  535.43 329.7 90 top
NOREF#1172  -  []  354.92 242.85 0 top
NOREF#1173  -  []  262.89 271.09 90 top
NOREF#1174  -  []  308.12 311.87 0 top
NOREF#1175  -  []  353.34 322.17 90 top
NOREF#1176  -  []  425.68 297.27 90 top
NOREF#1177  -  []  562.17 425.76 90 top
NOREF#1178  -  []  474.04 421.66 0 top
NOREF#1179  -  []  193.96 247.15 90 top
NOREF#1180  -  []  216.58 159.1 0 top
NOREF#1181  -  []  518.8 221.18 90 top
NOREF#1182  -  []  348.08 293.38 90 top
NOREF#1183  -  []  433.25 135.43 90 top
NOREF#1184  -  []  518.8 233.02 0 top
NOREF#1185  -  []  433.21 247.45 90 top
NOREF#1186  -  []  346.22 296.54 90 top
NOREF#1187  -  []  495.94 250.27 0 top
NOREF#1188  -  []  344.9 286.88 0 top
NOREF#1189  -  []  249.42 210.57 0 top
NOREF#1190  -  []  327.95 300.15 90 top
NOREF#1191  -  []  339.15 301.46 0 top
NOREF#1192  -  []  539.65 334.27 90 top
NOREF#1193  -  []  389.74 292.01 0 top
NOREF#1194  -  []  345.13 229.66 0 top
NOREF#1195  -  []  348.96 330.75 0 top
NOREF#1196  -  []  387.08 306.86 0 top
NOREF#1197  -  []  345.15 338.13 90 top
NOREF#1198  -  []  452.22 168.91 90 top
NOREF#1199  -  []  385.35 237.58 0 top
NOREF#1200  -  []  209.96 313.44 0 top
NOREF#1201  -  []  402.38 178.6 0 top
NOREF#1202  -  []  501.34 327.25 0 top
NOREF#1203  -  []  270.81 237.72 90 top
NOREF#1204  -  []  217.54 233.47 0 top
NOREF#1205  -  []  388.08 293.38 90 top
NOREF#1206  -  []  240.4 225.07 0 top
NOREF#1207  -  []  340.35 301.51 90 top
NOREF#1208  -  []  404.75 245.55 0 top
NOREF#1209  -  []  475.85 129.21 90 top
NOREF#1210  -  []  208.88 265.67 90 top
NOREF#1211  -  []  304.54 242.35 90 top
NOREF#1212  -  []  423.58 227.38 0 top
NOREF#1213  -  []  215.36 210.57 90 top
NOREF#1214  -  []  32.37 412.17 90 top
NOREF#1215  -  []  345.07 280.36 90 top
NOREF#1216  -  []  385.16 338.13 90 top
NOREF#1217  -  []  474.04 424.22 0 top
NOREF#1218  -  []  499.14 250.27 0 top
NOREF#1219  -  []  305.78 289.14 90 top
NOREF#1220  -  []  425.65 235.93 0 top
NOREF#1221  -  []  71.55 48.42 0 top
NOREF#1222  -  []  40.28 380.96 0 top
NOREF#1223  -  []  418.11 207.71 90 top
NOREF#1224  -  []  305.77 289.36 90 top
NOREF#1225  -  []  418.25 245.26 0 top
NOREF#1226  -  []  312.25 234.12 0 top
NOREF#1227  -  []  540.2 261.28 90 top
NOREF#1228  -  []  378.13 270.82 0 top
NOREF#1229  -  []  463.85 230.84 0 top
NOREF#1230  -  []  340.35 240.82 90 top
NOREF#1231  -  []  200.81 210.21 0 top
NOREF#1232  -  []  429.08 304.86 90 top
NOREF#1233  -  []  387.01 342.57 90 top
NOREF#1234  -  []  292.85 242.61 0 top
NOREF#1235  -  []  301.19 233.6 90 top
NOREF#1236  -  []  74.58 41.86 90 top
NOREF#1237  -  []  343.31 306.4 90 top
NOREF#1238  -  []  478.6 322.1 90 top
NOREF#1239  -  []  228.44 285.01 90 top
NOREF#1240  -  []  200.81 313.08 90 top
NOREF#1241  -  []  481.54 308.86 0 top
NOREF#1242  -  []  314.25 135.04 0 top
NOREF#1243  -  []  74.58 41.86 90 top
NOREF#1244  -  []  350.97 293.86 90 top
NOREF#1245  -  []  431.23 326.4 0 top
NOREF#1246  -  []  539.65 322.84 90 top
NOREF#1247  -  []  385.36 229.74 0 top
NOREF#1248  -  []  303.58 288.32 0 top
NOREF#1249  -  []  393.2 246.03 90 top
NOREF#1250  -  []  422.44 255.5 90 top
NOREF#1251  -  []  388.12 311.87 0 top
NOREF#1252  -  []  522.65 196.07 0 top
NOREF#1253  -  []  528.87 196.07 0 top
NOREF#1254  -  []  456.68 145.48 0 top
NOREF#1255  -  []  533.35 340.32 90 top
NOREF#1256  -  []  270.26 302.3 90 top
NOREF#1257  -  []  423.31 246.4 90 top
NOREF#1258  -  []  200.81 304.84 90 top
NOREF#1259  -  []  342.11 307.04 0 top
NOREF#1260  -  []  366.54 164.57 0 top
NOREF#1261  -  []  358.15 139.83 0 top
NOREF#1262  -  []  382.61 111.35 0 top
NOREF#1263  -  []  245.71 214.77 90 top
NOREF#1264  -  []  385.72 310.96 90 top
NOREF#1265  -  []  208.88 334.25 90 top
NOREF#1266  -  []  389.08 248.46 90 top
NOREF#1267  -  []  308.07 297.2 90 top
NOREF#1268  -  []  510.57 215.98 0 top
NOREF#1269  -  []  353.34 319.97 90 top
NOREF#1270  -  []  385.68 249.03 0 top
NOREF#1271  -  []  468.6 285.26 0 top
NOREF#1272  -  []  430.79 343.24 0 top
NOREF#1273  -  []  281.22 342.47 0 top
NOREF#1274  -  []  524.7 287.17 0 top
NOREF#1275  -  []  277.36 211.6 90 top
NOREF#1276  -  []  426.95 141.48 90 top
NOREF#1277  -  []  217.01 277.75 90 top
NOREF#1278  -  []  298.47 338.08 0 top
NOREF#1279  -  []  433.51 212.15 0 top
NOREF#1280  -  []  307.01 342.57 90 top
NOREF#1281  -  []  200.81 210.21 90 top
NOREF#1282  -  []  212.11 334.78 0 top
NOREF#1283  -  []  448.61 170.6 90 top
NOREF#1284  -  []  294.38 259.56 0 top
NOREF#1285  -  []  348.12 311.87 0 top
NOREF#1286  -  []  306.33 311.86 0 top
NOREF#1287  -  []  330.08 289.86 90 top
NOREF#1288  -  []  507.37 281.36 90 top
NOREF#1289  -  []  47.92 403.18 0 top
NOREF#1290  -  []  417.6 249.76 90 top
NOREF#1291  -  []  431.5 247.42 0 top
NOREF#1292  -  []  319.59 308.7 90 top
NOREF#1293  -  []  510.57 240.28 0 top
NOREF#1294  -  []  200.26 277.98 90 top
NOREF#1295  -  []  342.88 300.86 0 top
NOREF#1296  -  []  392.01 304.37 0 top
NOREF#1297  -  []  343.58 289.6 90 top
NOREF#1298  -  []  198.73 230.07 0 top
NOREF#1299  -  []  527.07 312.68 90 top
NOREF#1300  -  []  419.15 244.28 0 top
NOREF#1301  -  []  238.22 217.83 90 top
NOREF#1302  -  []  303.58 296.95 90 top
NOREF#1303  -  []  481.54 305.66 90 top
NOREF#1304  -  []  304.08 303.86 0 top
NOREF#1305  -  []  355.22 306.65 0 top
NOREF#1306  -  []  303.53 330.81 90 top
NOREF#1307  -  []  231.93 422.95 0 top
NOREF#1308  -  []  324.92 224.96 0 top
NOREF#1309  -  []  223.59 226.47 0 top
NOREF#1310  -  []  492.35 424.44 90 top
NOREF#1311  -  []  160.9 429.54 0 top
NOREF#1312  -  []  433 302.38 0 top
NOREF#1313  -  []  458.45 296.22 90 top
NOREF#1314  -  []  366.54 195.05 0 top
NOREF#1315  -  []  387.73 238.21 0 top
NOREF#1316  -  []  425.01 229.28 0 top
NOREF#1317  -  []  309.1 297.26 0 top
NOREF#1318  -  []  302.75 240.26 90 top
NOREF#1319  -  []  302.41 246.51 0 top
NOREF#1320  -  []  354.2 301.74 90 top
NOREF#1321  -  []  189.36 277.98 0 top
NOREF#1322  -  []  349.77 294.51 0 top
NOREF#1323  -  []  351.3 195.05 0 top
NOREF#1324  -  []  422.75 300.26 90 top
NOREF#1325  -  []  356.18 137.96 0 top
NOREF#1326  -  []  432.1 241.21 0 top
NOREF#1327  -  []  367.95 302.35 90 top
NOREF#1328  -  []  308.39 241.41 90 top
NOREF#1329  -  []  304.76 229.66 0 top
NOREF#1330  -  []  390.14 267.57 0 top
NOREF#1331  -  []  71.55 446.92 0 top
NOREF#1332  -  []  362.08 231.86 90 top
NOREF#1333  -  []  379.5 207.71 90 top
NOREF#1334  -  []  471.68 315.65 0 top
NOREF#1335  -  []  300.35 304.3 90 top
NOREF#1336  -  []  71.55 446.92 0 top
NOREF#1337  -  []  495.94 264.11 90 top
NOREF#1338  -  []  275.71 315.87 90 top
NOREF#1339  -  []  337.86 189.61 90 top
NOREF#1340  -  []  533.35 258.1 90 top
NOREF#1341  -  []  252.62 313.44 90 top
NOREF#1342  -  []  350.97 233.86 90 top
NOREF#1343  -  []  223.59 337.74 0 top
NOREF#1344  -  []  426.6 311.22 90 top
NOREF#1345  -  []  344.48 229.88 0 top
NOREF#1346  -  []  344.48 249.03 0 top
NOREF#1347  -  []  432.88 125.35 0 top
NOREF#1348  -  []  392.06 311.23 90 top
NOREF#1349  -  []  366.54 158.37 90 top
NOREF#1350  -  []  500.33 415.7 0 top
NOREF#1351  -  []  518.8 332.69 90 top
NOREF#1352  -  []  312.12 233.7 0 top
NOREF#1353  -  []  308.44 250.97 90 top
NOREF#1354  -  []  208.88 299.96 90 top
NOREF#1355  -  []  382.88 300.86 0 top
NOREF#1356  -  []  423.58 288.32 90 top
NOREF#1357  -  []  234.36 165.9 90 top
NOREF#1358  -  []  352.1 242.06 0 top
NOREF#1359  -  []  424.48 229.88 0 top
NOREF#1360  -  []  424.08 248.86 90 top
NOREF#1361  -  []  495.94 258.67 0 top
NOREF#1362  -  []  217.54 243.46 0 top
NOREF#1363  -  []  309.1 237.26 0 top
NOREF#1364  -  []  351.1 249.26 0 top
NOREF#1365  -  []  338.13 270.82 0 top
NOREF#1366  -  []  212.16 313.44 0 top
NOREF#1367  -  []  501.69 338.55 90 top
NOREF#1368  -  []  328.95 113.41 0 top
NOREF#1369  -  []  471.27 127.92 0 top
NOREF#1370  -  []  228.97 319.3 0 top
NOREF#1371  -  []  388.63 298.15 0 top
NOREF#1372  -  []  311.33 377.33 90 top
NOREF#1373  -  []  352.06 178.01 0 top
NOREF#1374  -  []  228.44 336.34 90 top
NOREF#1375  -  []  200.81 233.07 90 top
NOREF#1376  -  []  429.32 311.23 90 top
NOREF#1377  -  []  383.32 314.56 90 top
NOREF#1378  -  []  308.09 233.43 90 top
NOREF#1379  -  []  342.88 240.86 0 top
NOREF#1380  -  []  307.01 337.17 90 top
NOREF#1381  -  []  356.26 109.32 90 top
NOREF#1382  -  []  484.84 402.82 90 top
NOREF#1383  -  []  422.88 240.86 0 top
NOREF#1384  -  []  303.58 289.6 90 top
NOREF#1385  -  []  386.22 236.54 90 top
NOREF#1386  -  []  207.76 295.05 0 top
NOREF#1387  -  []  381.78 164.57 0 top
NOREF#1388  -  []  427.28 311.87 0 top
NOREF#1389  -  []  239.87 233.47 90 top
NOREF#1390  -  []  334.04 211.52 0 top
NOREF#1391  -  []  76.55 43.42 90 top
NOREF#1392  -  []  394.92 246.97 0 top
NOREF#1393  -  []  71.55 48.42 0 top
NOREF#1394  -  []  307.31 329.35 0 top
NOREF#1395  -  []  311.15 240.26 0 top
NOREF#1396  -  []  292.11 243.78 0 top
NOREF#1397  -  []  305.91 124.08 90 top
NOREF#1398  -  []  485.09 294.36 0 top
NOREF#1399  -  []  422.88 240.86 90 top
NOREF#1400  -  []  424.79 123.86 90 top
NOREF#1401  -  []  69.58 506.86 0 top
NOREF#1402  -  []  424.46 227.38 90 top
NOREF#1403  -  []  350.94 226.5 90 top
NOREF#1404  -  []  507.37 212.78 90 top
NOREF#1405  -  []  277.36 287.19 90 top
NOREF#1406  -  []  341.08 115.31 90 top
NOREF#1407  -  []  74.58 41.86 90 top
NOREF#1408  -  []  499.58 466.36 90 top
NOREF#1409  -  []  249.65 303.45 90 top
NOREF#1410  -  []  402.08 321.86 0 top
NOREF#1411  -  []  249.65 234.87 90 top
NOREF#1412  -  []  478.29 241.36 90 top
NOREF#1413  -  []  200.81 339.13 90 top
NOREF#1414  -  []  385.35 236.29 90 top
NOREF#1415  -  []  392.1 302.06 0 top
NOREF#1416  -  []  309.68 244.71 90 top
NOREF#1417  -  []  512.77 215.98 0 top
NOREF#1418  -  []  510.57 274.57 0 top
NOREF#1419  -  []  290.08 323.86 0 top
NOREF#1420  -  []  463.34 316 90 top
NOREF#1421  -  []  385.77 289.16 90 top
NOREF#1422  -  []  305.08 295.3 90 top
NOREF#1423  -  []  391.8 238.66 0 top
NOREF#1424  -  []  385.68 229.23 90 top
NOREF#1425  -  []  352.1 298.98 0 top
NOREF#1426  -  []  426.85 235.29 90 top
NOREF#1427  -  []  385.73 183.88 90 top
NOREF#1428  -  []  74.58 41.86 90 top
NOREF#1429  -  []  522 335.89 0 top
NOREF#1430  -  []  385.13 289.66 0 top
NOREF#1431  -  []  518.8 335.89 0 top
NOREF#1432  -  []  246.45 303.45 0 top
NOREF#1433  -  []  407.42 338.45 90 top
NOREF#1434  -  []  342.88 240.86 0 top
NOREF#1435  -  []  268.11 329.89 0 top
NOREF#1436  -  []  347.89 233.18 90 top
NOREF#1437  -  []  347.06 293.68 0 top
NOREF#1438  -  []  309.74 233.89 90 top
NOREF#1439  -  []  256.94 270.76 90 top
NOREF#1440  -  []  458.45 306.43 0 top
NOREF#1441  -  []  74.58 41.86 90 top
NOREF#1442  -  []  382.41 307.36 0 top
NOREF#1443  -  []  425.07 280.36 90 top
NOREF#1444  -  []  307.89 233.18 90 top
NOREF#1445  -  []  291.58 466.36 90 top
NOREF#1446  -  []  427.31 329.35 0 top
NOREF#1447  -  []  385.1 289.85 90 top
NOREF#1448  -  []  232.82 286.41 0 top
NOREF#1449  -  []  400.19 212.2 90 top
NOREF#1450  -  []  470.43 282.63 0 top
NOREF#1451  -  []  428.84 234.21 0 top
NOREF#1452  -  []  329.86 310.84 0 top
NOREF#1453  -  []  386.87 237.85 0 top
NOREF#1454  -  []  346.6 311.22 90 top
NOREF#1455  -  []  313.34 322.17 90 top
NOREF#1456  -  []  306.14 302.35 90 top
NOREF#1457  -  []  345.4 251.86 0 top
NOREF#1458  -  []  426.87 237.85 0 top
NOREF#1459  -  []  421.68 251.19 0 top
NOREF#1460  -  []  372.08 331.86 0 top
NOREF#1461  -  []  206.11 225.07 0 top
NOREF#1462  -  []  231.93 417.82 0 top
NOREF#1463  -  []  383.58 228.32 90 top
NOREF#1464  -  []  290.08 263.86 0 top
NOREF#1465  -  []  433.44 233.48 90 top
NOREF#1466  -  []  205.28 334.25 0 top
NOREF#1467  -  []  275.71 220.01 90 top
NOREF#1468  -  []  280.47 268.96 90 top
NOREF#1469  -  []  387.91 233.69 90 top
NOREF#1470  -  []  309.44 232.33 90 top
NOREF#1471  -  []  343.58 226.5 0 top
NOREF#1472  -  []  378.25 241.78 0 top
NOREF#1473  -  []  382.11 246.19 0 top
NOREF#1474  -  []  217.01 259.36 90 top
NOREF#1475  -  []  303.32 254.56 90 top
NOREF#1476  -  []  228.97 243.46 0 top
NOREF#1477  -  []  385.63 119.8 0 top
NOREF#1478  -  []  458.45 292.41 0 top
NOREF#1479  -  []  367.95 237.95 90 top
NOREF#1480  -  []  303.58 229.6 90 top
NOREF#1481  -  []  524.7 298.6 0 top
NOREF#1482  -  []  228.44 277.75 90 top
NOREF#1483  -  []  364.22 338.45 0 top
NOREF#1484  -  []  360.19 209.61 90 top
NOREF#1485  -  []  382.54 175.41 90 top
NOREF#1486  -  []  427.73 238.21 0 top
NOREF#1487  -  []  385.43 118.96 90 top
NOREF#1488  -  []  206.11 312.04 0 top
NOREF#1489  -  []  346.42 124.08 90 top
NOREF#1490  -  []  350.86 251.87 0 top
NOREF#1491  -  []  524.2 335.89 0 top
NOREF#1492  -  []  421.28 122.54 90 top
NOREF#1493  -  []  458.45 303.23 90 top
NOREF#1494  -  []  387.31 269.35 0 top
NOREF#1495  -  []  381.78 188.85 90 top
NOREF#1496  -  []  228.44 259.36 90 top
NOREF#1497  -  []  460.14 216.33 0 top
NOREF#1498  -  []  353.34 324.37 90 top
NOREF#1499  -  []  496.09 140.17 90 top
