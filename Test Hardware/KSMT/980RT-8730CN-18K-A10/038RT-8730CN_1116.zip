# Allegro board 038RT-8730CN_1116.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#2774  -  []  288.08 227.86 90 top
NOREF#2775  -  []  420.33 327.57 0 top
NOREF#2776  -  []  230.62 234.87 0 top
NOREF#2777  -  []  425.77 289.36 90 top
NOREF#2778  -  []  270.81 303.1 0 top
NOREF#2779  -  []  163.9 426.54 90 top
NOREF#2780  -  []  345.1 237.2 90 top
NOREF#2781  -  []  302.98 236.26 0 top
NOREF#2782  -  []  354.2 241.74 90 top
NOREF#2783  -  []  433.36 330.75 0 top
NOREF#2784  -  []  348.63 298.15 0 top
NOREF#2785  -  []  426.25 297.9 0 top
NOREF#2786  -  []  308.49 237.58 90 top
NOREF#2787  -  []  41.87 427.59 90 top
NOREF#2788  -  []  217.54 267.76 0 top
NOREF#2789  -  []  228.97 216.43 0 top
NOREF#2790  -  []  404.92 215.4 90 top
NOREF#2791  -  []  45.3 380.96 0 top
NOREF#2792  -  []  355.25 183.88 90 top
NOREF#2793  -  []  349.68 304.71 90 top
NOREF#2794  -  []  448.12 218.6 0 top
NOREF#2795  -  []  292.08 281.86 90 top
NOREF#2796  -  []  217.54 302.05 0 top
NOREF#2797  -  []  239.87 277.75 90 top
NOREF#2798  -  []  472.03 321.56 90 top
NOREF#2799  -  []  383.58 227.38 0 top
NOREF#2800  -  []  382.88 300.86 90 top
NOREF#2801  -  []  379.15 242.15 0 top
NOREF#2802  -  []  431.1 246.35 0 top
NOREF#2803  -  []  353.08 250.71 90 top
NOREF#2804  -  []  518.8 301.6 0 top
NOREF#2805  -  []  427.44 293.68 0 top
NOREF#2806  -  []  312 306.67 0 top
NOREF#2807  -  []  198.73 212.59 90 top
NOREF#2808  -  []  388.65 238.59 0 top
NOREF#2809  -  []  306.87 242.35 90 top
NOREF#2810  -  []  425.68 237.91 90 top
NOREF#2811  -  []  522 240.28 0 top
NOREF#2812  -  []  384.48 309.03 0 top
NOREF#2813  -  []  349.12 232.03 0 top
NOREF#2814  -  []  530.15 274.93 0 top
NOREF#2815  -  []  345.36 229.74 0 top
NOREF#2816  -  []  310.94 286.5 90 top
NOREF#2817  -  []  499.14 240.28 0 top
NOREF#2818  -  []  414.38 294.16 90 top
NOREF#2819  -  []  535.43 261.12 90 top
NOREF#2820  -  []  69.58 506.86 0 top
NOREF#2821  -  []  309.74 232.01 0 top
NOREF#2822  -  []  345.35 236.29 90 top
NOREF#2823  -  []  266.46 287.19 0 top
NOREF#2824  -  []  484.51 289.76 90 top
NOREF#2825  -  []  342.88 300.86 0 top
NOREF#2826  -  []  463.34 311.6 90 top
NOREF#2827  -  []  387.53 311.22 90 top
NOREF#2828  -  []  472.03 219.33 0 top
NOREF#2829  -  []  74.58 41.86 90 top
NOREF#2830  -  []  434.2 240.89 90 top
NOREF#2831  -  []  198.73 235.45 90 top
NOREF#2832  -  []  399.59 248.7 90 top
NOREF#2833  -  []  433.34 322.17 90 top
NOREF#2834  -  []  410.08 229.86 90 top
NOREF#2835  -  []  315.22 302.53 0 top
NOREF#2836  -  []  436.12 246.33 90 top
NOREF#2837  -  []  425.36 229.74 0 top
NOREF#2838  -  []  444.92 215.4 90 top
NOREF#2839  -  []  299.15 251.62 0 top
NOREF#2840  -  []  307.31 233.29 0 top
NOREF#2841  -  []  322.13 266.4 90 top
NOREF#2842  -  []  69.58 506.86 0 top
NOREF#2843  -  []  312.01 248.09 0 top
NOREF#2844  -  []  305.1 237.2 90 top
NOREF#2845  -  []  384.76 289.66 0 top
NOREF#2846  -  []  425.78 289.14 90 top
NOREF#2847  -  []  471.27 127.92 0 top
NOREF#2848  -  []  245.02 286.41 0 top
NOREF#2849  -  []  434.07 226.36 0 top
NOREF#2850  -  []  219.19 244.86 0 top
NOREF#2851  -  []  436.12 244.96 90 top
NOREF#2852  -  []  455.48 124.98 90 top
NOREF#2853  -  []  438.6 285.59 90 top
NOREF#2854  -  []  516.09 269.97 90 top
NOREF#2855  -  []  303.58 287.38 0 top
NOREF#2856  -  []  499.14 308.86 0 top
NOREF#2857  -  []  378.25 302.47 0 top
NOREF#2858  -  []  428.09 233.43 90 top
NOREF#2859  -  []  174.46 329.91 0 top
NOREF#2860  -  []  383.88 236.58 0 top
NOREF#2861  -  []  434.2 300.89 90 top
NOREF#2862  -  []  207.76 217.83 0 top
NOREF#2863  -  []  524.7 264.31 0 top
NOREF#2864  -  []  426.22 236.54 90 top
NOREF#2865  -  []  309.85 297.94 90 top
NOREF#2866  -  []  336.66 158.97 90 top
NOREF#2867  -  []  348.54 234.54 0 top
NOREF#2868  -  []  275.71 295.6 90 top
NOREF#2869  -  []  313.08 250.71 90 top
NOREF#2870  -  []  424.54 242.35 90 top
NOREF#2871  -  []  256.21 307.92 0 top
NOREF#2872  -  []  418.25 304.6 0 top
NOREF#2873  -  []  272.51 220.01 0 top
NOREF#2874  -  []  343.02 219.41 0 top
NOREF#2875  -  []  367.08 226.86 90 top
NOREF#2876  -  []  373.06 250.84 90 top
NOREF#2877  -  []  200.81 233.07 0 top
NOREF#2878  -  []  209.96 252.12 0 top
NOREF#2879  -  []  400.19 209.61 90 top
NOREF#2880  -  []  230.62 252.12 0 top
NOREF#2881  -  []  346.7 285.88 90 top
NOREF#2882  -  []  385.08 235.94 90 top
NOREF#2883  -  []  420.48 311.19 0 top
NOREF#2884  -  []  200.26 323.7 90 top
NOREF#2885  -  []  345.68 289.22 90 top
NOREF#2886  -  []  387.91 293.69 90 top
NOREF#2887  -  []  340.35 300.82 90 top
NOREF#2888  -  []  463.85 237.85 0 top
NOREF#2889  -  []  49.28 395.61 90 top
NOREF#2890  -  []  221.39 337.74 0 top
NOREF#2891  -  []  392 306.67 0 top
NOREF#2892  -  []  244.25 260.76 0 top
NOREF#2893  -  []  424.46 287.38 90 top
NOREF#2894  -  []  385.07 214 90 top
NOREF#2895  -  []  312 309.58 0 top
NOREF#2896  -  []  308.12 288.85 0 top
NOREF#2897  -  []  282.07 267.61 90 top
NOREF#2898  -  []  344.48 289.87 0 top
NOREF#2899  -  []  348.08 233.38 90 top
NOREF#2900  -  []  432.25 234.12 0 top
NOREF#2901  -  []  203.76 377.07 0 top
NOREF#2902  -  []  309.4 295.85 90 top
NOREF#2903  -  []  338.25 303.15 0 top
NOREF#2904  -  []  498.71 213.67 0 top
NOREF#2905  -  []  436.8 377.4 90 top
NOREF#2906  -  []  349.1 237.26 0 top
NOREF#2907  -  []  386.87 241.41 90 top
NOREF#2908  -  []  395.4 211.22 0 top
NOREF#2909  -  []  315.22 246.65 0 top
NOREF#2910  -  []  495.94 289.76 90 top
NOREF#2911  -  []  492.57 137.96 0 top
NOREF#2912  -  []  414.38 234.16 90 top
NOREF#2913  -  []  311.1 309.26 0 top
NOREF#2914  -  []  314.2 301.74 90 top
NOREF#2915  -  []  311.11 305.56 0 top
NOREF#2916  -  []  463.85 258.12 0 top
NOREF#2917  -  []  221.39 226.47 0 top
NOREF#2918  -  []  426.85 237.41 0 top
NOREF#2919  -  []  189.36 300.84 0 top
NOREF#2920  -  []  480.72 421.68 90 top
NOREF#2921  -  []  395.02 301.03 0 top
NOREF#2922  -  []  289.97 118.04 0 top
NOREF#2923  -  []  382.44 315.5 90 top
NOREF#2924  -  []  391.81 315.75 0 top
NOREF#2925  -  []  359.35 139.19 90 top
NOREF#2926  -  []  307.44 233.68 0 top
NOREF#2927  -  []  324.22 338.45 0 top
NOREF#2928  -  []  348.59 288.35 0 top
NOREF#2929  -  []  246.45 295.05 0 top
NOREF#2930  -  []  356.12 244.96 90 top
NOREF#2931  -  []  173.58 488.36 0 top
NOREF#2932  -  []  370.29 194.29 0 top
NOREF#2933  -  []  507.95 268.71 0 top
NOREF#2934  -  []  429.77 234.51 0 top
NOREF#2935  -  []  310.58 243.36 90 top
NOREF#2936  -  []  503.28 280.98 90 top
NOREF#2937  -  []  395.22 242.53 0 top
NOREF#2938  -  []  426.33 311.86 0 top
NOREF#2939  -  []  526.25 298.94 90 top
NOREF#2940  -  []  395.61 210.88 0 top
NOREF#2941  -  []  235.02 286.41 0 top
NOREF#2942  -  []  380.58 336.81 0 top
NOREF#2943  -  []  367.08 266.86 0 top
NOREF#2944  -  []  332.85 242.61 90 top
NOREF#2945  -  []  516.09 322.65 90 top
NOREF#2946  -  []  273.65 270.45 90 top
NOREF#2947  -  []  303.58 228.32 90 top
NOREF#2948  -  []  387.08 246.86 0 top
NOREF#2949  -  []  347.19 302.05 0 top
NOREF#2950  -  []  313.36 337.18 90 top
NOREF#2951  -  []  431.11 304.05 0 top
NOREF#2952  -  []  380.33 267.57 0 top
NOREF#2953  -  []  345.36 289.28 0 top
NOREF#2954  -  []  345.68 297.27 90 top
NOREF#2955  -  []  387.44 233.68 0 top
NOREF#2956  -  []  533.35 233.05 90 top
NOREF#2957  -  []  193.96 344.09 0 top
NOREF#2958  -  []  337.86 179.05 0 top
NOREF#2959  -  []  355.05 194.29 0 top
NOREF#2960  -  []  206.11 319.3 0 top
NOREF#2961  -  []  432.88 127.92 0 top
NOREF#2962  -  []  485.09 310.26 0 top
NOREF#2963  -  []  485.09 225.78 0 top
NOREF#2964  -  []  207.69 164.63 90 top
NOREF#2965  -  []  212.16 244.86 0 top
NOREF#2966  -  []  313.21 247.45 90 top
NOREF#2967  -  []  424.48 298.55 0 top
NOREF#2968  -  []  388.43 297.66 90 top
NOREF#2969  -  []  303.25 237.85 0 top
NOREF#2970  -  []  212.16 279.15 0 top
NOREF#2971  -  []  382.12 315.2 0 top
NOREF#2972  -  []  388.09 233.43 90 top
NOREF#2973  -  []  383.58 286.5 0 top
NOREF#2974  -  []  342.41 248.21 0 top
NOREF#2975  -  []  228.97 285.01 0 top
NOREF#2976  -  []  290.08 289.86 90 top
NOREF#2977  -  []  425.68 249.03 0 top
NOREF#2978  -  []  432.1 242.06 0 top
NOREF#2979  -  []  380.33 330.81 0 top
NOREF#2980  -  []  316.21 252.13 90 top
NOREF#2981  -  []  305.68 297.91 90 top
NOREF#2982  -  []  393.51 214.74 0 top
NOREF#2983  -  []  427.08 246.86 90 top
NOREF#2984  -  []  304.46 287.38 90 top
NOREF#2985  -  []  424.9 226.88 0 top
NOREF#2986  -  []  426.65 310.96 90 top
NOREF#2987  -  []  344.08 243.86 0 top
NOREF#2988  -  []  279.08 254.86 0 top
NOREF#2989  -  []  353.36 270.75 0 top
NOREF#2990  -  []  510.57 284.56 0 top
NOREF#2991  -  []  428.54 234.54 0 top
NOREF#2992  -  []  429.44 293.61 90 top
NOREF#2993  -  []  430.6 247.1 0 top
NOREF#2994  -  []  516.09 331.29 90 top
NOREF#2995  -  []  209.96 244.86 0 top
NOREF#2996  -  []  378.48 338.08 0 top
NOREF#2997  -  []  424.76 229.66 0 top
NOREF#2998  -  []  386.37 237.89 0 top
NOREF#2999  -  []  533.35 338.11 90 top
NOREF#3000  -  []  387.44 293.68 0 top
NOREF#3001  -  []  495.94 229.82 90 top
NOREF#3002  -  []  305.02 297.19 0 top
NOREF#3003  -  []  305.6 229.67 90 top
NOREF#3004  -  []  430.78 129.19 0 top
NOREF#3005  -  []  313 298.87 90 top
NOREF#3006  -  []  306.25 297.9 0 top
NOREF#3007  -  []  422.75 301.46 90 top
NOREF#3008  -  []  69.58 506.86 0 top
NOREF#3009  -  []  424.48 249.03 0 top
NOREF#3010  -  []  495.25 415.7 0 top
NOREF#3011  -  []  32.37 391.85 90 top
NOREF#3012  -  []  530.15 332.08 0 top
NOREF#3013  -  []  251.3 302.05 90 top
NOREF#3014  -  []  71.55 48.42 0 top
NOREF#3015  -  []  374.71 249.44 90 top
NOREF#3016  -  []  327.95 302.35 90 top
NOREF#3017  -  []  313 242.38 0 top
NOREF#3018  -  []  262.84 438.26 0 top
NOREF#3019  -  []  328.95 119.51 0 top
NOREF#3020  -  []  489.95 424.44 0 top
NOREF#3021  -  []  298.25 302.47 0 top
NOREF#3022  -  []  435.58 300.86 90 top
NOREF#3023  -  []  436.56 330.75 90 top
NOREF#3024  -  []  538.95 288.36 90 top
NOREF#3025  -  []  345.18 269.42 90 top
NOREF#3026  -  []  429.68 244.71 90 top
NOREF#3027  -  []  343.28 286.82 0 top
NOREF#3028  -  []  370.29 179.05 0 top
NOREF#3029  -  []  437.46 126.65 90 top
NOREF#3030  -  []  471.79 234.48 0 top
NOREF#3031  -  []  399.3 246.35 0 top
NOREF#3032  -  []  386.7 225.88 90 top
NOREF#3033  -  []  524.45 287.52 90 top
NOREF#3034  -  []  71.55 446.92 0 top
NOREF#3035  -  []  520.85 312.68 90 top
NOREF#3036  -  []  292.04 125.38 90 top
NOREF#3037  -  []  200.81 307.05 90 top
NOREF#3038  -  []  431.15 240.26 0 top
NOREF#3039  -  []  383.53 322.17 90 top
NOREF#3040  -  []  392.06 251.23 90 top
NOREF#3041  -  []  428.08 233.38 90 top
NOREF#3042  -  []  407.08 266.86 0 top
NOREF#3043  -  []  309.32 251.23 90 top
NOREF#3044  -  []  430.78 126.62 0 top
NOREF#3045  -  []  226.79 210.57 90 top
NOREF#3046  -  []  345.77 229.36 90 top
NOREF#3047  -  []  379.67 293.34 90 top
NOREF#3048  -  []  291.81 115.29 90 top
NOREF#3049  -  []  324.92 281.76 90 top
NOREF#3050  -  []  345.08 295.3 90 top
NOREF#3051  -  []  281.41 208.53 90 top
NOREF#3052  -  []  304.54 302.35 90 top
NOREF#3053  -  []  299.99 294.24 0 top
NOREF#3054  -  []  423.9 297.84 0 top
NOREF#3055  -  []  355.05 163.81 0 top
NOREF#3056  -  []  369.86 310.84 0 top
NOREF#3057  -  []  300.35 302.19 90 top
NOREF#3058  -  []  302.41 307.36 0 top
NOREF#3059  -  []  385.02 237.19 0 top
NOREF#3060  -  []  228.44 243.46 90 top
NOREF#3061  -  []  374.25 296.3 90 top
NOREF#3062  -  []  302.41 308.21 0 top
NOREF#3063  -  []  353.1 179.05 0 top
NOREF#3064  -  []  429.92 287.85 90 top
NOREF#3065  -  []  383.26 228.02 0 top
NOREF#3066  -  []  284.75 245.55 0 top
NOREF#3067  -  []  174.46 295.62 0 top
NOREF#3068  -  []  272.51 322.88 0 top
NOREF#3069  -  []  282.86 179.91 0 top
NOREF#3070  -  []  425.68 309.03 0 top
NOREF#3071  -  []  391.23 326.4 0 top
NOREF#3072  -  []  69.58 506.86 0 top
NOREF#3073  -  []  364.92 224.96 0 top
NOREF#3074  -  []  287.95 237.95 90 top
NOREF#3075  -  []  324.08 229.86 90 top
NOREF#3076  -  []  347.19 242.05 0 top
NOREF#3077  -  []  312.01 245.88 0 top
NOREF#3078  -  []  235.02 313.44 0 top
NOREF#3079  -  []  215.11 299.96 90 top
NOREF#3080  -  []  370.29 163.81 0 top
NOREF#3081  -  []  530.67 253.23 90 top
NOREF#3082  -  []  310.58 243.36 90 top
NOREF#3083  -  []  422.9 332.18 90 top
NOREF#3084  -  []  352.12 293.7 0 top
NOREF#3085  -  []  367.95 297.95 90 top
NOREF#3086  -  []  387.89 293.18 90 top
NOREF#3087  -  []  527.07 249.18 90 top
NOREF#3088  -  []  403.81 309.44 0 top
NOREF#3089  -  []  244.53 415.3 90 top
NOREF#3090  -  []  350.59 339.27 90 top
NOREF#3091  -  []  226.79 217.83 90 top
NOREF#3092  -  []  463.34 245.22 90 top
NOREF#3093  -  []  322.08 321.86 0 top
NOREF#3094  -  []  501.69 262.71 90 top
NOREF#3095  -  []  296.59 392 0 top
NOREF#3096  -  []  309.77 294.51 0 top
NOREF#3097  -  []  301.83 297.65 90 top
NOREF#3098  -  []  390.3 296.62 90 top
NOREF#3099  -  []  352.25 234.12 0 top
NOREF#3100  -  []  213.31 336.29 90 top
NOREF#3101  -  []  360.19 214.77 90 top
NOREF#3102  -  []  256.21 342.21 0 top
NOREF#3103  -  []  306.87 237.85 0 top
NOREF#3104  -  []  470.43 248.34 0 top
NOREF#3105  -  []  329.29 402.82 0 top
NOREF#3106  -  []  351.63 209.35 90 top
NOREF#3107  -  []  277.36 259.91 90 top
NOREF#3108  -  []  532.47 230.36 90 top
NOREF#3109  -  []  348.44 250.97 90 top
NOREF#3110  -  []  422.41 308.21 0 top
NOREF#3111  -  []  496.52 303 0 top
NOREF#3112  -  []  383.28 226.82 0 top
NOREF#3113  -  []  298.25 304.6 0 top
NOREF#3114  -  []  378.48 340.67 0 top
NOREF#3115  -  []  243.37 319.3 0 top
NOREF#3116  -  []  474.04 421.66 0 top
NOREF#3117  -  []  389.12 232.03 0 top
NOREF#3118  -  []  273.65 236.16 90 top
NOREF#3119  -  []  353 298.02 90 top
NOREF#3120  -  []  287.08 226.86 90 top
NOREF#3121  -  []  334.28 329.41 0 top
NOREF#3122  -  []  384.86 302.05 0 top
NOREF#3123  -  []  284.98 330.3 90 top
NOREF#3124  -  []  386.33 251.86 0 top
NOREF#3125  -  []  298.25 244.6 0 top
NOREF#3126  -  []  313.21 307.45 90 top
NOREF#3127  -  []  307.91 293.69 90 top
NOREF#3128  -  []  401.4 208.02 90 top
NOREF#3129  -  []  314.92 305.6 0 top
NOREF#3130  -  []  193.96 332.66 0 top
NOREF#3131  -  []  351.67 211.01 90 top
NOREF#3132  -  []  312.1 241.21 0 top
NOREF#3133  -  []  442.68 332.6 90 top
NOREF#3134  -  []  461.65 299.42 0 top
NOREF#3135  -  []  495.94 267.31 0 top
NOREF#3136  -  []  522 224.38 0 top
NOREF#3137  -  []  381.91 336.38 0 top
NOREF#3138  -  []  424.54 302.35 90 top
NOREF#3139  -  []  346.14 242.35 90 top
NOREF#3140  -  []  303.26 228.02 0 top
NOREF#3141  -  []  76.55 43.42 90 top
NOREF#3142  -  []  383.58 226.5 0 top
NOREF#3143  -  []  384.48 237.91 0 top
NOREF#3144  -  []  388.08 233.18 90 top
NOREF#3145  -  []  193.96 286.94 0 top
NOREF#3146  -  []  393.36 330.75 0 top
NOREF#3147  -  []  303.58 236.95 90 top
NOREF#3148  -  []  291.05 243.75 0 top
NOREF#3149  -  []  386.25 297.9 0 top
NOREF#3150  -  []  339.08 278.86 90 top
NOREF#3151  -  []  69.58 46.86 0 top
NOREF#3152  -  []  311.23 326.4 0 top
NOREF#3153  -  []  69.58 506.86 0 top
NOREF#3154  -  []  516.09 228.42 90 top
NOREF#3155  -  []  303.25 297.84 0 top
NOREF#3156  -  []  396.12 242.21 90 top
NOREF#3157  -  []  547.22 375.13 0 top
NOREF#3158  -  []  386.6 251.22 90 top
NOREF#3159  -  []  364.92 284.96 0 top
NOREF#3160  -  []  259.36 233.72 0 top
NOREF#3161  -  []  349.74 227.14 0 top
NOREF#3162  -  []  501.69 228.42 90 top
NOREF#3163  -  []  322.68 327.2 0 top
NOREF#3164  -  []  343.9 237.85 0 top
NOREF#3165  -  []  343.58 250.36 0 top
NOREF#3166  -  []  344.69 328.37 0 top
NOREF#3167  -  []  174.46 284.19 0 top
NOREF#3168  -  []  370.08 289.86 90 top
NOREF#3169  -  []  356.12 302.21 90 top
NOREF#3170  -  []  307.66 293.29 0 top
NOREF#3171  -  []  338.47 340.67 0 top
NOREF#3172  -  []  463.85 333.71 0 top
NOREF#3173  -  []  410.32 218.6 0 top
NOREF#3174  -  []  470.43 316.92 0 top
NOREF#3175  -  []  344.54 242.35 90 top
NOREF#3176  -  []  206.11 250.72 0 top
NOREF#3177  -  []  347.89 293.18 90 top
NOREF#3178  -  []  484.51 255.47 90 top
NOREF#3179  -  []  407.95 240.15 90 top
NOREF#3180  -  []  367.66 250.84 0 top
NOREF#3181  -  []  533.35 214.59 90 top
NOREF#3182  -  []  427.45 237.26 90 top
NOREF#3183  -  []  433.34 324.37 90 top
NOREF#3184  -  []  303.58 238.23 0 top
NOREF#3185  -  []  187.37 159.1 0 top
NOREF#3186  -  []  395.02 241.03 0 top
NOREF#3187  -  []  355.22 242.53 0 top
NOREF#3188  -  []  539.65 277.12 90 top
NOREF#3189  -  []  297.6 249.76 90 top
NOREF#3190  -  []  410.08 229.86 90 top
NOREF#3191  -  []  450.32 284.96 0 top
NOREF#3192  -  []  478.6 329.11 90 top
NOREF#3193  -  []  313 302.38 0 top
NOREF#3194  -  []  356.41 129.76 0 top
NOREF#3195  -  []  232.26 270.05 0 top
NOREF#3196  -  []  383.9 290.5 0 top
NOREF#3197  -  []  423.58 298.23 0 top
NOREF#3198  -  []  342.21 135.43 90 top
NOREF#3199  -  []  307.23 298.3 0 top
NOREF#3200  -  []  428.07 237.2 90 top
NOREF#3201  -  []  430.14 327.57 0 top
NOREF#3202  -  []  308.09 293.43 90 top
NOREF#3203  -  []  432.9 341.97 0 top
NOREF#3204  -  []  504.66 254.07 90 top
NOREF#3205  -  []  399.64 258.32 90 top
NOREF#3206  -  []  299.23 129.19 0 top
NOREF#3207  -  []  308.39 301.41 90 top
NOREF#3208  -  []  234.21 406.82 90 top
NOREF#3209  -  []  419.15 241.46 0 top
NOREF#3210  -  []  193.96 258.58 90 top
NOREF#3211  -  []  232.26 338.63 0 top
NOREF#3212  -  []  388.39 241.41 90 top
NOREF#3213  -  []  533.35 294.6 90 top
NOREF#3214  -  []  520.85 283.47 90 top
NOREF#3215  -  []  277.72 207.9 90 top
NOREF#3216  -  []  343.28 288.64 0 top
NOREF#3217  -  []  353.21 247.45 90 top
NOREF#3218  -  []  479.98 398.99 90 top
NOREF#3219  -  []  430.14 267.57 0 top
NOREF#3220  -  []  341.08 238.36 0 top
NOREF#3221  -  []  510.57 301.6 0 top
NOREF#3222  -  []  343.25 237.85 0 top
NOREF#3223  -  []  351.9 158.97 90 top
NOREF#3224  -  []  351.18 250.97 90 top
NOREF#3225  -  []  378.4 425.76 90 top
NOREF#3226  -  []  302.11 247.89 0 top
NOREF#3227  -  []  385.77 229.36 90 top
NOREF#3228  -  []  347.73 298.21 0 top
NOREF#3229  -  []  454.69 285.71 0 top
NOREF#3230  -  []  349.74 293.89 90 top
NOREF#3231  -  []  442.13 266.4 90 top
NOREF#3232  -  []  350.3 236.62 90 top
NOREF#3233  -  []  311.48 292.15 0 top
NOREF#3234  -  []  383.28 228.64 0 top
NOREF#3235  -  []  436.8 377.4 0 top
NOREF#3236  -  []  403.81 249.44 0 top
NOREF#3237  -  []  447.37 210.89 0 top
NOREF#3238  -  []  304.45 237.2 90 top
NOREF#3239  -  []  400.19 214.77 90 top
NOREF#3240  -  []  245.02 320.7 0 top
NOREF#3241  -  []  405.56 377.2 0 top
NOREF#3242  -  []  384.13 113.39 0 top
NOREF#3243  -  []  296.59 377.58 0 top
NOREF#3244  -  []  305.08 308.86 0 top
NOREF#3245  -  []  262.89 236.8 90 top
NOREF#3246  -  []  69.58 506.86 0 top
NOREF#3247  -  []  312.12 293.7 0 top
NOREF#3248  -  []  334.22 145.48 0 top
NOREF#3249  -  []  69.58 46.86 0 top
NOREF#3250  -  []  311.81 315.75 0 top
NOREF#3251  -  []  372.08 271.86 0 top
NOREF#3252  -  []  344.48 226.18 90 top
NOREF#3253  -  []  461.65 340.72 0 top
NOREF#3254  -  []  425.35 302.35 90 top
NOREF#3255  -  []  427.66 293.75 0 top
NOREF#3256  -  []  206.11 243.46 0 top
NOREF#3257  -  []  336.07 421.68 90 top
NOREF#3258  -  []  470.69 275.97 0 top
NOREF#3259  -  []  495.94 339.95 90 top
NOREF#3260  -  []  458.45 289.21 90 top
NOREF#3261  -  []  174.46 307.05 0 top
NOREF#3262  -  []  336.66 179.21 0 top
NOREF#3263  -  []  193.96 270.01 90 top
NOREF#3264  -  []  349.4 295.85 90 top
NOREF#3265  -  []  371.69 117.24 90 top
NOREF#3266  -  []  496.52 320.25 0 top
NOREF#3267  -  []  368.12 284.96 0 top
NOREF#3268  -  []  228.44 233.47 90 top
NOREF#3269  -  []  335.93 330.81 0 top
NOREF#3270  -  []  530.15 297.79 0 top
NOREF#3271  -  []  240.4 267.76 0 top
NOREF#3272  -  []  362.68 330.4 90 top
NOREF#3273  -  []  278.84 425.76 90 top
NOREF#3274  -  []  379.08 334.86 0 top
NOREF#3275  -  []  539.65 219.97 90 top
NOREF#3276  -  []  313.36 337.18 0 top
NOREF#3277  -  []  429.1 297.26 0 top
NOREF#3278  -  []  533.35 292.39 90 top
NOREF#3279  -  []  345.33 215.4 90 top
NOREF#3280  -  []  246.45 226.47 0 top
NOREF#3281  -  []  430.58 303.36 90 top
NOREF#3282  -  []  659.58 41.86 90 top
NOREF#3283  -  []  527.52 254.07 90 top
NOREF#3284  -  []  315.58 300.86 90 top
NOREF#3285  -  []  232.82 279.15 0 top
NOREF#3286  -  []  379.12 250.02 90 top
NOREF#3287  -  []  221.58 87.36 0 top
NOREF#3288  -  []  55 408.31 90 top
NOREF#3289  -  []  426.87 297.85 0 top
NOREF#3290  -  []  418.25 241.78 0 top
NOREF#3291  -  []  328.95 116.46 0 top
NOREF#3292  -  []  392.25 234.12 0 top
NOREF#3293  -  []  370.32 284.96 0 top
NOREF#3294  -  []  390.86 251.87 0 top
NOREF#3295  -  []  361.62 227.86 45 top
NOREF#3296  -  []  431.15 300.26 0 top
NOREF#3297  -  []  565.58 87.36 0 top
NOREF#3298  -  []  326.67 209.62 0 top
NOREF#3299  -  []  423.59 125.38 90 top
NOREF#3300  -  []  319.59 248.7 90 top
NOREF#3301  -  []  505.16 284.15 0 top
NOREF#3302  -  []  290.24 123.34 0 top
NOREF#3303  -  []  423.32 314.56 90 top
NOREF#3304  -  []  270.81 337.39 0 top
NOREF#3305  -  []  424.48 237.91 0 top
NOREF#3306  -  []  393.21 243.73 90 top
NOREF#3307  -  []  327.95 297.95 90 top
NOREF#3308  -  []  381.08 298.36 0 top
NOREF#3309  -  []  352.06 162.77 0 top
NOREF#3310  -  []  440.19 209.61 90 top
NOREF#3311  -  []  265.56 302.75 0 top
NOREF#3312  -  []  280.7 270.81 0 top
NOREF#3313  -  []  485.09 320.25 0 top
NOREF#3314  -  []  432.7 306.78 90 top
NOREF#3315  -  []  287.45 271.63 90 top
NOREF#3316  -  []  454.05 208.35 90 top
NOREF#3317  -  []  333.78 403.62 90 top
NOREF#3318  -  []  308.08 233.18 90 top
NOREF#3319  -  []  349.58 335.71 0 top
NOREF#3320  -  []  301.34 125.35 0 top
NOREF#3321  -  []  402.08 291.86 90 top
NOREF#3322  -  []  524.51 403.62 90 top
NOREF#3323  -  []  279.08 238.86 90 top
NOREF#3324  -  []  386.65 310.96 90 top
NOREF#3325  -  []  518.8 258.67 0 top
NOREF#3326  -  []  352.01 245.88 0 top
NOREF#3327  -  []  427.28 251.87 0 top
NOREF#3328  -  []  472.03 287.27 90 top
NOREF#3329  -  []  420.35 310.97 90 top
NOREF#3330  -  []  335.93 270.82 0 top
NOREF#3331  -  []  538.95 219.78 90 top
NOREF#3332  -  []  198.73 264.36 0 top
NOREF#3333  -  []  234.36 151.48 90 top
NOREF#3334  -  []  460.78 123.86 0 top
NOREF#3335  -  []  339.15 302.15 0 top
NOREF#3336  -  []  421.83 297.65 90 top
NOREF#3337  -  []  427.31 269.35 0 top
NOREF#3338  -  []  419.08 278.86 90 top
NOREF#3339  -  []  69.58 506.86 0 top
NOREF#3340  -  []  301.08 238.36 0 top
NOREF#3341  -  []  345.77 289.36 90 top
NOREF#3342  -  []  439.64 258.32 90 top
NOREF#3343  -  []  345.1 297.19 90 top
NOREF#3344  -  []  529.66 401.56 0 top
NOREF#3345  -  []  313 298.02 90 top
NOREF#3346  -  []  535.43 318.27 90 top
NOREF#3347  -  []  337.6 249.76 90 top
NOREF#3348  -  []  385.68 297.27 90 top
NOREF#3349  -  []  385.65 295.93 0 top
NOREF#3350  -  []  428.08 233.18 90 top
NOREF#3351  -  []  510.57 233.02 0 top
NOREF#3352  -  []  221.39 260.76 0 top
NOREF#3353  -  []  447.6 307.83 0 top
NOREF#3354  -  []  235.02 210.57 0 top
NOREF#3355  -  []  280.36 339.55 90 top
NOREF#3356  -  []  318.21 269.35 90 top
NOREF#3357  -  []  351.8 299.51 0 top
NOREF#3358  -  []  390.94 226.5 90 top
NOREF#3359  -  []  459.28 271.25 90 top
NOREF#3360  -  []  277.39 338.15 0 top
NOREF#3361  -  []  364.14 209.62 0 top
NOREF#3362  -  []  351.16 330.75 0 top
NOREF#3363  -  []  370.32 218.6 0 top
NOREF#3364  -  []  387.08 306.86 0 top
NOREF#3365  -  []  315.02 241.03 0 top
NOREF#3366  -  []  271.04 210.44 0 top
NOREF#3367  -  []  313.44 114.38 0 top
NOREF#3368  -  []  302.88 240.86 0 top
NOREF#3369  -  []  427.6 310.97 90 top
NOREF#3370  -  []  358.5 140.81 0 top
NOREF#3371  -  []  489.91 258.67 0 top
NOREF#3372  -  []  469.16 236.08 90 top
NOREF#3373  -  []  346.16 299.87 0 top
NOREF#3374  -  []  249.65 260.76 90 top
NOREF#3375  -  []  448.14 208.02 90 top
NOREF#3376  -  []  368.12 218.6 0 top
NOREF#3377  -  []  465.07 280.36 90 top
NOREF#3378  -  []  484.51 292.96 0 top
NOREF#3379  -  []  339.99 234.24 0 top
NOREF#3380  -  []  496.52 217.38 0 top
NOREF#3381  -  []  345.01 289.28 0 top
NOREF#3382  -  []  349.68 244.71 90 top
NOREF#3383  -  []  389.77 234.51 0 top
NOREF#3384  -  []  334.71 309.44 90 top
NOREF#3385  -  []  266.46 252.9 0 top
NOREF#3386  -  []  251.3 233.47 90 top
NOREF#3387  -  []  301.08 251.06 0 top
NOREF#3388  -  []  345.67 302.05 0 top
NOREF#3389  -  []  385.13 229.66 0 top
NOREF#3390  -  []  239.87 293.65 90 top
NOREF#3391  -  []  412.08 221.86 90 top
NOREF#3392  -  []  352.06 177.36 90 top
NOREF#3393  -  []  261.1 319.24 0 top
NOREF#3394  -  []  312.14 291.95 0 top
NOREF#3395  -  []  383.53 330.81 90 top
NOREF#3396  -  []  478.6 135.43 90 top
NOREF#3397  -  []  236.5 421.68 90 top
NOREF#3398  -  []  394.49 116.12 0 top
NOREF#3399  -  []  388.48 251.23 90 top
NOREF#3400  -  []  303.58 250.36 0 top
NOREF#3401  -  []  394.07 220 0 top
NOREF#3402  -  []  217.54 319.3 0 top
NOREF#3403  -  []  405.46 310.84 0 top
NOREF#3404  -  []  315.19 240.94 0 top
NOREF#3405  -  []  383.88 296.58 0 top
NOREF#3406  -  []  510.57 250.27 0 top
NOREF#3407  -  []  343.26 288.02 0 top
NOREF#3408  -  []  69.58 506.86 0 top
NOREF#3409  -  []  313.21 245.24 90 top
NOREF#3410  -  []  367.3 193.25 0 top
NOREF#3411  -  []  309.74 227.14 0 top
NOREF#3412  -  []  340.58 339.4 0 top
NOREF#3413  -  []  507.37 221.18 90 top
NOREF#3414  -  []  536.7 269.53 0 top
NOREF#3415  -  []  389.77 294.51 0 top
NOREF#3416  -  []  205.88 231.91 0 top
NOREF#3417  -  []  320.19 212.2 90 top
NOREF#3418  -  []  367.14 174.21 90 top
NOREF#3419  -  []  349.32 251.23 90 top
NOREF#3420  -  []  495.94 274.57 0 top
NOREF#3421  -  []  343.58 227.38 0 top
NOREF#3422  -  []  249.42 244.86 0 top
NOREF#3423  -  []  447.6 293.81 0 top
NOREF#3424  -  []  287.08 286.86 90 top
NOREF#3425  -  []  200.81 301.65 90 top
NOREF#3426  -  []  303.26 288.02 0 top
NOREF#3427  -  []  306.25 237.9 0 top
NOREF#3428  -  []  387.31 329.35 0 top
NOREF#3429  -  []  311.5 307.42 0 top
NOREF#3430  -  []  303.9 237.85 0 top
NOREF#3431  -  []  391.1 249.26 0 top
NOREF#3432  -  []  340.33 270.82 0 top
NOREF#3433  -  []  487.55 148.72 0 top
NOREF#3434  -  []  485.39 403.62 0 top
NOREF#3435  -  []  335.78 218.6 0 top
NOREF#3436  -  []  217.01 250.72 90 top
NOREF#3437  -  []  306.85 295.29 90 top
NOREF#3438  -  []  355.22 302.53 0 top
NOREF#3439  -  []  355.58 240.86 90 top
NOREF#3440  -  []  420.35 243.64 90 top
NOREF#3441  -  []  337.92 250.66 0 top
NOREF#3442  -  []  343.58 298.23 0 top
NOREF#3443  -  []  310.32 231.39 90 top
NOREF#3444  -  []  200.81 255.93 90 top
NOREF#3445  -  []  333.06 310.84 90 top
NOREF#3446  -  []  530.15 320.65 0 top
NOREF#3447  -  []  287.9 330.68 90 top
NOREF#3448  -  []  332.08 271.86 0 top
NOREF#3449  -  []  270.26 336.59 90 top
NOREF#3450  -  []  394.2 301.74 90 top
NOREF#3451  -  []  393 242.38 0 top
NOREF#3452  -  []  348.48 251.23 90 top
NOREF#3453  -  []  348.48 311.23 90 top
NOREF#3454  -  []  396.12 246.33 90 top
NOREF#3455  -  []  334.36 123.34 90 top
NOREF#3456  -  []  433.08 242.66 90 top
NOREF#3457  -  []  300.57 341.97 0 top
NOREF#3458  -  []  198.73 344.37 0 top
NOREF#3459  -  []  431.18 250.97 90 top
NOREF#3460  -  []  207.76 286.41 0 top
NOREF#3461  -  []  518.8 289.76 90 top
NOREF#3462  -  []  229.82 421.66 0 top
NOREF#3463  -  []  535.43 335.75 0 top
NOREF#3464  -  []  423.58 229.6 90 top
NOREF#3465  -  []  277.39 347.4 0 top
NOREF#3466  -  []  423.58 296.95 90 top
NOREF#3467  -  []  412.11 243.78 0 top
NOREF#3468  -  []  207.76 260.76 0 top
NOREF#3469  -  []  346.65 310.96 90 top
NOREF#3470  -  []  463.85 326.7 0 top
NOREF#3471  -  []  431.48 232.15 0 top
NOREF#3472  -  []  259.73 265.17 90 top
NOREF#3473  -  []  518.8 305.66 90 top
NOREF#3474  -  []  389.44 293.61 90 top
NOREF#3475  -  []  288.08 287.86 90 top
NOREF#3476  -  []  351.9 194.45 0 top
NOREF#3477  -  []  426.7 285.88 90 top
NOREF#3478  -  []  302.44 315.5 90 top
NOREF#3479  -  []  351.67 213.21 90 top
NOREF#3480  -  []  71.55 48.42 0 top
NOREF#3481  -  []  368.34 189.61 90 top
NOREF#3482  -  []  400.76 343.68 0 top
NOREF#3483  -  []  387.53 251.22 90 top
NOREF#3484  -  []  535.43 347.18 0 top
NOREF#3485  -  []  300.35 241.51 90 top
NOREF#3486  -  []  308.96 270.75 0 top
NOREF#3487  -  []  241.17 403.62 90 top
NOREF#3488  -  []  268.11 261.31 0 top
NOREF#3489  -  []  221.39 320.7 0 top
NOREF#3490  -  []  193.96 224.29 90 top
NOREF#3491  -  []  252.62 217.83 90 top
NOREF#3492  -  []  256.21 273.63 0 top
NOREF#3493  -  []  383.31 306.4 90 top
NOREF#3494  -  []  243.37 216.43 0 top
NOREF#3495  -  []  451.41 217.8 90 top
NOREF#3496  -  []  472.03 287.91 0 top
NOREF#3497  -  []  339.12 250.02 90 top
NOREF#3498  -  []  313.36 340.38 90 top
NOREF#3499  -  []  347.6 250.97 90 top
NOREF#3500  -  []  211.51 334.25 0 top
NOREF#3501  -  []  402.38 164.18 0 top
NOREF#3502  -  []  304.86 302.05 0 top
NOREF#3503  -  []  242.05 295.05 0 top
NOREF#3504  -  []  298.25 243.15 0 top
NOREF#3505  -  []  302.41 247.36 0 top
NOREF#3506  -  []  366.02 119.24 0 top
NOREF#3507  -  []  43.4 498.15 0 top
NOREF#3508  -  []  226.79 313.44 90 top
NOREF#3509  -  []  499.14 301.6 0 top
NOREF#3510  -  []  240.4 336.34 0 top
NOREF#3511  -  []  393 298.02 90 top
NOREF#3512  -  []  431.63 209.35 90 top
NOREF#3513  -  []  384.69 328.37 0 top
NOREF#3514  -  []  484.51 224.38 0 top
NOREF#3515  -  []  300.35 242.19 90 top
NOREF#3516  -  []  238.87 332.91 90 top
NOREF#3517  -  []  217.54 327.94 0 top
NOREF#3518  -  []  347.91 293.69 90 top
NOREF#3519  -  []  471.27 125.35 0 top
NOREF#3520  -  []  430.79 338.08 0 top
NOREF#3521  -  []  258.32 306.65 0 top
NOREF#3522  -  []  313.08 242.66 90 top
NOREF#3523  -  []  305.68 249.58 0 top
NOREF#3524  -  []  272.51 288.59 0 top
NOREF#3525  -  []  308.96 330.75 0 top
NOREF#3526  -  []  383.9 297.84 0 top
NOREF#3527  -  []  535.43 283.98 90 top
NOREF#3528  -  []  442.68 327.2 0 top
NOREF#3529  -  []  477.11 211.51 90 top
NOREF#3530  -  []  247.66 130.92 90 top
NOREF#3531  -  []  517 402.82 90 top
NOREF#3532  -  []  399.08 298.86 90 top
NOREF#3533  -  []  367.14 194.45 0 top
NOREF#3534  -  []  300.33 330.81 0 top
NOREF#3535  -  []  350.32 291.39 90 top
NOREF#3536  -  []  426.85 297.41 0 top
NOREF#3537  -  []  259.73 231.52 0 top
NOREF#3538  -  []  254.27 216.43 90 top
NOREF#3539  -  []  343.58 286.5 0 top
NOREF#3540  -  []  353.21 245.24 90 top
NOREF#3541  -  []  385.86 239.55 0 top
NOREF#3542  -  []  212.97 175.21 0 top
NOREF#3543  -  []  344.48 237.91 0 top
NOREF#3544  -  []  278.13 344.13 0 top
NOREF#3545  -  []  329.39 424.22 0 top
NOREF#3546  -  []  461.65 306.43 0 top
NOREF#3547  -  []  306.87 297.85 0 top
NOREF#3548  -  []  307.01 340.37 90 top
NOREF#3549  -  []  484.74 301.6 0 top
NOREF#3550  -  []  71.55 446.92 0 top
NOREF#3551  -  []  198.73 269.74 90 top
NOREF#3552  -  []  304.75 235.61 0 top
NOREF#3553  -  []  520.85 278.39 90 top
NOREF#3554  -  []  336.06 195.05 0 top
NOREF#3555  -  []  188.18 160.37 0 top
NOREF#3556  -  []  430.32 231.39 90 top
NOREF#3557  -  []  519.84 419.12 90 top
NOREF#3558  -  []  391.67 211.01 90 top
NOREF#3559  -  []  305.91 126.65 90 top
NOREF#3560  -  []  336.66 174.21 90 top
NOREF#3561  -  []  546.17 438.26 0 top
NOREF#3562  -  []  374.19 118.96 0 top
NOREF#3563  -  []  433.21 243.73 90 top
NOREF#3564  -  []  372.11 303.78 0 top
NOREF#3565  -  []  388.84 287.46 0 top
NOREF#3566  -  []  332.85 302.61 90 top
NOREF#3567  -  []  307.53 251.22 90 top
NOREF#3568  -  []  303.28 286.82 0 top
NOREF#3569  -  []  379.15 311.62 0 top
NOREF#3570  -  []  408.35 342.08 0 top
NOREF#3571  -  []  193.96 281.44 90 top
NOREF#3572  -  []  489.91 292.96 0 top
NOREF#3573  -  []  237.97 164.21 90 top
NOREF#3574  -  []  383.58 238.23 0 top
NOREF#3575  -  []  286.89 327.12 0 top
NOREF#3576  -  []  427.06 293.68 0 top
NOREF#3577  -  []  219.19 260.76 0 top
NOREF#3578  -  []  386.22 296.54 90 top
NOREF#3579  -  []  342.11 247.89 0 top
NOREF#3580  -  []  351.37 117.51 0 top
NOREF#3581  -  []  472.91 252.72 90 top
NOREF#3582  -  []  342.15 238.55 0 top
NOREF#3583  -  []  294.28 269.42 0 top
NOREF#3584  -  []  312.7 306.78 90 top
NOREF#3585  -  []  266.46 211.6 0 top
NOREF#3586  -  []  223.58 466.36 90 top
NOREF#3587  -  []  348.09 293.15 90 top
NOREF#3588  -  []  239.87 285.01 90 top
NOREF#3589  -  []  396.12 244.96 90 top
NOREF#3590  -  []  425.26 145.48 0 top
NOREF#3591  -  []  407.66 310.84 0 top
NOREF#3592  -  []  344.1 415.3 90 top
NOREF#3593  -  []  431.67 215.41 90 top
NOREF#3594  -  []  539.65 288.55 90 top
NOREF#3595  -  []  268.11 322.88 0 top
NOREF#3596  -  []  357.97 209.36 90 top
NOREF#3597  -  []  481.54 298.4 90 top
NOREF#3598  -  []  449.58 87.36 0 top
NOREF#3599  -  []  305.18 329.41 90 top
NOREF#3600  -  []  200.81 281.98 90 top
NOREF#3601  -  []  231.46 140.17 90 top
NOREF#3602  -  []  300.57 336.81 0 top
NOREF#3603  -  []  344.48 238.55 0 top
NOREF#3604  -  []  463.34 243.02 90 top
NOREF#3605  -  []  338.98 215.4 90 top
NOREF#3606  -  []  245.71 283.35 90 top
NOREF#3607  -  []  200.81 316.27 90 top
NOREF#3608  -  []  428.39 241.41 90 top
NOREF#3609  -  []  531.46 424.44 90 top
NOREF#3610  -  []  361.62 287.86 45 top
NOREF#3611  -  []  292.08 271.63 90 top
NOREF#3612  -  []  488.75 148.08 90 top
NOREF#3613  -  []  419.15 311.62 0 top
NOREF#3614  -  []  345.08 248.86 0 top
NOREF#3615  -  []  522.05 287.52 0 top
NOREF#3616  -  []  306.06 301.41 90 top
NOREF#3617  -  []  219.19 286.41 0 top
NOREF#3618  -  []  295.67 240.69 0 top
NOREF#3619  -  []  305.4 251.86 0 top
NOREF#3620  -  []  423.58 298.23 0 top
NOREF#3621  -  []  344.75 235.61 0 top
NOREF#3622  -  []  309.77 234.51 0 top
NOREF#3623  -  []  425.58 289.16 90 top
NOREF#3624  -  []  282.08 231.86 90 top
NOREF#3625  -  []  237.72 337.36 90 top
NOREF#3626  -  []  433 238.02 90 top
NOREF#3627  -  []  539.44 415.7 0 top
NOREF#3628  -  []  484.74 267.31 0 top
NOREF#3629  -  []  351.1 309.26 0 top
NOREF#3630  -  []  272.08 365.86 0 top
NOREF#3631  -  []  214.04 160.37 0 top
NOREF#3632  -  []  343.32 314.56 90 top
NOREF#3633  -  []  329.39 421.66 0 top
NOREF#3634  -  []  432.06 251.23 90 top
NOREF#3635  -  []  451.53 336.45 90 top
NOREF#3636  -  []  200.81 267.36 90 top
NOREF#3637  -  []  372.11 243.78 0 top
NOREF#3638  -  []  399.08 238.86 90 top
NOREF#3639  -  []  347.08 306.86 0 top
NOREF#3640  -  []  499.14 274.57 0 top
NOREF#3641  -  []  355.61 210.88 0 top
NOREF#3642  -  []  517.55 403.62 0 top
NOREF#3643  -  []  659.58 41.86 90 top
NOREF#3644  -  []  344.9 226.88 0 top
NOREF#3645  -  []  426.46 242.05 0 top
NOREF#3646  -  []  379.58 241.86 0 top
NOREF#3647  -  []  392.08 299.36 90 top
NOREF#3648  -  []  386.87 302.35 90 top
NOREF#3649  -  []  527.52 304.26 90 top
NOREF#3650  -  []  375.58 87.36 0 top
NOREF#3651  -  []  205.28 299.96 0 top
NOREF#3652  -  []  417.92 310.66 0 top
NOREF#3653  -  []  540.2 323.93 0 top
NOREF#3654  -  []  534.36 415.7 90 top
NOREF#3655  -  []  316.21 252.13 90 top
NOREF#3656  -  []  428.71 221.31 0 top
NOREF#3657  -  []  304.76 289.66 0 top
NOREF#3658  -  []  351.3 158.37 90 top
NOREF#3659  -  []  518.8 343.15 0 top
NOREF#3660  -  []  429.83 258.32 90 top
NOREF#3661  -  []  217.01 225.07 90 top
NOREF#3662  -  []  293.08 320.86 0 top
NOREF#3663  -  []  308.2 296.49 0 top
NOREF#3664  -  []  383.53 259.97 90 top
NOREF#3665  -  []  287.66 310.84 0 top
NOREF#3666  -  []  457.12 409.15 0 top
NOREF#3667  -  []  231.93 420.39 0 top
NOREF#3668  -  []  499.58 65.36 90 top
NOREF#3669  -  []  477.88 402.82 90 top
NOREF#3670  -  []  339.15 304.28 0 top
NOREF#3671  -  []  391.48 232.15 0 top
NOREF#3672  -  []  470.69 303 0 top
NOREF#3673  -  []  474.04 424.22 0 top
NOREF#3674  -  []  340.35 304.3 90 top
NOREF#3675  -  []  538.95 254.07 90 top
NOREF#3676  -  []  353.2 248.94 90 top
NOREF#3677  -  []  200.81 284.19 90 top
NOREF#3678  -  []  487.71 327.25 0 top
NOREF#3679  -  []  307.89 293.18 90 top
NOREF#3680  -  []  338.25 302.47 0 top
NOREF#3681  -  []  389.44 233.61 90 top
NOREF#3682  -  []  351.18 109.32 0 top
NOREF#3683  -  []  353.91 314.79 90 top
NOREF#3684  -  []  200.81 215.61 90 top
NOREF#3685  -  []  496.52 344.55 0 top
NOREF#3686  -  []  433.94 220.98 0 top
NOREF#3687  -  []  501.34 335.89 0 top
NOREF#3688  -  []  530.15 343.51 0 top
NOREF#3689  -  []  200.81 327.7 90 top
NOREF#3690  -  []  364.92 215.4 90 top
NOREF#3691  -  []  535.43 341.13 90 top
NOREF#3692  -  []  535.43 249.69 90 top
NOREF#3693  -  []  352 249.58 0 top
NOREF#3694  -  []  200.81 236.26 90 top
NOREF#3695  -  []  382.54 177.36 90 top
NOREF#3696  -  []  423.58 238.23 0 top
NOREF#3697  -  []  343.88 296.58 0 top
NOREF#3698  -  []  433.2 248.94 90 top
NOREF#3699  -  []  345.28 209.35 90 top
NOREF#3700  -  []  205.28 231.38 0 top
NOREF#3701  -  []  285.46 250.84 0 top
NOREF#3702  -  []  507.37 343.15 0 top
NOREF#3703  -  []  436.8 390.1 0 top
NOREF#3704  -  []  510.57 224.38 0 top
NOREF#3705  -  []  454.45 337.72 90 top
NOREF#3706  -  []  329.39 424.22 0 top
NOREF#3707  -  []  353 238.87 90 top
NOREF#3708  -  []  394.07 286.36 0 top
NOREF#3709  -  []  311.67 211.01 90 top
NOREF#3710  -  []  303.58 238.23 0 top
NOREF#3711  -  []  380.48 251.19 0 top
NOREF#3712  -  []  281.33 271.88 0 top
NOREF#3713  -  []  331.06 118.24 0 top
NOREF#3714  -  []  469.17 126.62 0 top
NOREF#3715  -  []  231.81 343.43 0 top
NOREF#3716  -  []  423.53 330.81 90 top
NOREF#3717  -  []  232.82 244.86 0 top
NOREF#3718  -  []  228.97 225.07 0 top
NOREF#3719  -  []  484.51 258.67 0 top
NOREF#3720  -  []  303.9 297.84 0 top
NOREF#3721  -  []  495.94 308.86 0 top
NOREF#3722  -  []  339.15 302.83 0 top
NOREF#3723  -  []  353.2 246.03 90 top
NOREF#3724  -  []  312.1 298.98 0 top
NOREF#3725  -  []  301.71 178.22 0 top
NOREF#3726  -  []  344.76 229.66 0 top
NOREF#3727  -  []  346.6 251.22 90 top
NOREF#3728  -  []  334.38 259.56 0 top
NOREF#3729  -  []  266.46 328.49 0 top
NOREF#3730  -  []  386.14 302.35 90 top
NOREF#3731  -  []  302.75 301.46 90 top
NOREF#3732  -  []  215.11 265.67 90 top
NOREF#3733  -  []  418.25 251.94 0 top
NOREF#3734  -  []  309.08 308.46 90 top
NOREF#3735  -  []  533.35 301.62 90 top
NOREF#3736  -  []  313.08 242.66 90 top
NOREF#3737  -  []  425.33 211 90 top
NOREF#3738  -  []  223.58 65.36 90 top
NOREF#3739  -  []  291.58 65.36 90 top
NOREF#3740  -  []  305.4 311.86 0 top
NOREF#3741  -  []  518.8 327.25 0 top
NOREF#3742  -  []  382.38 158.97 90 top
NOREF#3743  -  []  504.66 245.67 90 top
NOREF#3744  -  []  520.85 249.18 90 top
NOREF#3745  -  []  387.66 301.41 90 top
NOREF#3746  -  []  425.86 239.55 0 top
NOREF#3747  -  []  347.29 238.22 0 top
NOREF#3748  -  []  219.19 329.34 0 top
NOREF#3749  -  []  339.81 194.29 0 top
NOREF#3750  -  []  229.07 128.8 90 top
NOREF#3751  -  []  393.21 247.45 90 top
NOREF#3752  -  []  246.45 260.76 0 top
NOREF#3753  -  []  217.39 160.37 0 top
NOREF#3754  -  []  419.58 241.86 0 top
NOREF#3755  -  []  393.91 314.79 90 top
NOREF#3756  -  []  65.1 453.95 90 top
NOREF#3757  -  []  392.7 246.78 90 top
NOREF#3758  -  []  301.67 396.63 0 top
NOREF#3759  -  []  492.79 129.76 0 top
NOREF#3760  -  []  226.79 279.15 90 top
NOREF#3761  -  []  428.39 301.41 90 top
NOREF#3762  -  []  342.11 306.19 0 top
NOREF#3763  -  []  333.78 409.02 90 top
NOREF#3764  -  []  345.08 235.94 90 top
NOREF#3765  -  []  353.08 242.66 90 top
NOREF#3766  -  []  217.01 312.04 90 top
NOREF#3767  -  []  306.46 302.05 0 top
NOREF#3768  -  []  481.54 274.57 0 top
NOREF#3769  -  []  507.37 315.65 90 top
NOREF#3770  -  []  223.59 286.41 0 top
NOREF#3771  -  []  279.08 314.86 0 top
NOREF#3772  -  []  374.38 234.16 90 top
NOREF#3773  -  []  308.07 237.2 90 top
NOREF#3774  -  []  430.94 231.37 90 top
NOREF#3775  -  []  395.22 246.65 0 top
NOREF#3776  -  []  305.72 250.96 90 top
NOREF#3777  -  []  309.83 318.32 90 top
NOREF#3778  -  []  368.08 227.86 90 top
NOREF#3779  -  []  499.14 318.85 0 top
NOREF#3780  -  []  313.45 233.48 90 top
NOREF#3781  -  []  463.85 223.83 0 top
NOREF#3782  -  []  230.62 244.86 0 top
NOREF#3783  -  []  390.14 327.57 0 top
NOREF#3784  -  []  435.26 335.55 90 top
NOREF#3785  -  []  503.28 212.4 90 top
NOREF#3786  -  []  238.22 210.57 90 top
NOREF#3787  -  []  387.66 233.29 0 top
NOREF#3788  -  []  305.08 295.94 90 top
NOREF#3789  -  []  400.91 111.1 90 top
NOREF#3790  -  []  429.12 292.03 0 top
NOREF#3791  -  []  355.61 216.04 0 top
NOREF#3792  -  []  407.32 208.35 90 top
NOREF#3793  -  []  431.16 330.75 0 top
NOREF#3794  -  []  389.83 258.32 90 top
NOREF#3795  -  []  403.93 345.58 0 top
NOREF#3796  -  []  477.22 317.25 90 top
NOREF#3797  -  []  418.25 243.15 0 top
NOREF#3798  -  []  348.2 296.49 0 top
NOREF#3799  -  []  540.2 243.92 0 top
NOREF#3800  -  []  425.72 310.96 90 top
NOREF#3801  -  []  496.6 214.94 0 top
NOREF#3802  -  []  240.4 259.36 0 top
NOREF#3803  -  []  295.56 336.37 0 top
NOREF#3804  -  []  348.84 227.46 0 top
NOREF#3805  -  []  431.1 306.35 0 top
NOREF#3806  -  []  385.1 229.85 90 top
NOREF#3807  -  []  429.92 227.85 90 top
NOREF#3808  -  []  301.67 411.05 0 top
NOREF#3809  -  []  208.28 300.49 90 top
NOREF#3810  -  []  385.77 289.36 90 top
NOREF#3811  -  []  307.23 238.3 0 top
NOREF#3812  -  []  305.08 235.3 90 top
NOREF#3813  -  []  484.51 318.85 0 top
NOREF#3814  -  []  351.1 246.35 0 top
NOREF#3815  -  []  387.73 298.21 0 top
NOREF#3816  -  []  362.79 208.02 90 top
NOREF#3817  -  []  265.56 268.46 0 top
NOREF#3818  -  []  349.32 311.23 90 top
NOREF#3819  -  []  430.71 144.68 0 top
NOREF#3820  -  []  305.15 335.54 90 top
NOREF#3821  -  []  238.22 286.41 90 top
NOREF#3822  -  []  425.76 344.8 0 top
NOREF#3823  -  []  293.24 123.86 90 top
NOREF#3824  -  []  487.71 215.98 0 top
NOREF#3825  -  []  316.12 246.33 90 top
NOREF#3826  -  []  9.45 423.13 0 top
NOREF#3827  -  []  233.66 402.82 90 top
NOREF#3828  -  []  536.7 223.81 0 top
NOREF#3829  -  []  430.78 131.75 0 top
NOREF#3830  -  []  433.08 302.66 90 top
NOREF#3831  -  []  254.27 312.04 90 top
NOREF#3832  -  []  343.53 264.37 90 top
NOREF#3833  -  []  205.15 165.9 90 top
NOREF#3834  -  []  535.43 290.03 0 top
NOREF#3835  -  []  423.9 237.85 0 top
NOREF#3836  -  []  461.65 230.84 0 top
NOREF#3837  -  []  427.45 297.26 90 top
NOREF#3838  -  []  328.12 284.96 0 top
NOREF#3839  -  []  458.45 258.12 0 top
NOREF#3840  -  []  378.25 242.47 0 top
NOREF#3841  -  []  292.08 221.86 90 top
NOREF#3842  -  []  221.39 303.45 0 top
NOREF#3843  -  []  359.08 298.86 90 top
NOREF#3844  -  []  485.39 406.82 90 top
NOREF#3845  -  []  424.69 268.37 0 top
NOREF#3846  -  []  378.25 301.78 0 top
NOREF#3847  -  []  418.25 302.47 0 top
NOREF#3848  -  []  540.2 318.43 90 top
NOREF#3849  -  []  390.94 291.37 90 top
NOREF#3850  -  []  389.1 237.26 0 top
NOREF#3851  -  []  392.01 248.09 0 top
NOREF#3852  -  []  207.08 302 90 top
NOREF#3853  -  []  188.18 174.79 0 top
NOREF#3854  -  []  249.65 226.47 90 top
NOREF#3855  -  []  247.22 313.44 0 top
NOREF#3856  -  []  449.93 341.99 90 top
NOREF#3857  -  []  313.51 217.31 0 top
NOREF#3858  -  []  424.86 242.05 0 top
NOREF#3859  -  []  504.66 322.65 90 top
NOREF#3860  -  []  472.3 141.48 90 top
NOREF#3861  -  []  468.6 250.97 0 top
NOREF#3862  -  []  320.19 209.61 90 top
NOREF#3863  -  []  206.11 259.36 0 top
NOREF#3864  -  []  478.29 275.65 90 top
NOREF#3865  -  []  385.58 289.16 90 top
NOREF#3866  -  []  352.08 299.36 90 top
NOREF#3867  -  []  289.86 310.84 0 top
NOREF#3868  -  []  352.36 148.08 90 top
NOREF#3869  -  []  395.58 240.86 90 top
NOREF#3870  -  []  385.36 229.28 0 top
NOREF#3871  -  []  251.3 336.34 90 top
NOREF#3872  -  []  303.31 305.55 90 top
NOREF#3873  -  []  392.1 299.83 0 top
NOREF#3874  -  []  423.58 289.6 90 top
NOREF#3875  -  []  238.22 252.12 90 top
NOREF#3876  -  []  392.12 293.7 0 top
NOREF#3877  -  []  536.7 315.25 0 top
NOREF#3878  -  []  496.52 234.42 0 top
NOREF#3879  -  []  338.98 211 90 top
NOREF#3880  -  []  404.92 281.76 90 top
NOREF#3881  -  []  347.73 238.21 0 top
NOREF#3882  -  []  313.36 342.58 90 top
NOREF#3883  -  []  540.2 226.99 90 top
NOREF#3884  -  []  301.08 238.36 0 top
NOREF#3885  -  []  310.14 267.57 0 top
NOREF#3886  -  []  321.62 287.86 45 top
NOREF#3887  -  []  414.94 304.03 90 top
NOREF#3888  -  []  501.34 343.15 0 top
NOREF#3889  -  []  302.36 141.48 90 top
NOREF#3890  -  []  422.88 240.86 0 top
NOREF#3891  -  []  499.58 65.36 90 top
NOREF#3892  -  []  303.53 270.82 90 top
NOREF#3893  -  []  313.28 231.15 90 top
NOREF#3894  -  []  418.13 270.82 0 top
NOREF#3895  -  []  437.47 338.13 90 top
NOREF#3896  -  []  472.03 252.98 90 top
NOREF#3897  -  []  250.94 342.54 0 top
NOREF#3898  -  []  327.08 286.86 90 top
NOREF#3899  -  []  242.05 234.87 0 top
NOREF#3900  -  []  427.66 241.41 90 top
NOREF#3901  -  []  346.85 297.41 0 top
NOREF#3902  -  []  372.85 302.61 0 top
NOREF#3903  -  []  249.42 320.7 0 top
NOREF#3904  -  []  431.11 307.77 0 top
NOREF#3905  -  []  451.53 321.49 90 top
NOREF#3906  -  []  414.88 328.37 0 top
NOREF#3907  -  []  345.07 220.36 90 top
NOREF#3908  -  []  431.48 292.15 0 top
NOREF#3909  -  []  394.92 306.97 0 top
NOREF#3910  -  []  345.08 235.3 90 top
NOREF#3911  -  []  207.76 252.12 0 top
NOREF#3912  -  []  484.74 308.86 0 top
NOREF#3913  -  []  522.65 230.36 0 top
NOREF#3914  -  []  329.07 337.05 90 top
NOREF#3915  -  []  471.68 212.78 0 top
NOREF#3916  -  []  165.53 90.42 0 top
NOREF#3917  -  []  299.15 242.15 0 top
NOREF#3918  -  []  309.8 244.86 90 top
NOREF#3919  -  []  207.76 210.57 0 top
NOREF#3920  -  []  367.14 163.97 0 top
NOREF#3921  -  []  393.21 307.45 90 top
NOREF#3922  -  []  313.2 308.94 90 top
NOREF#3923  -  []  395.61 213.47 0 top
NOREF#3924  -  []  74.58 41.86 90 top
NOREF#3925  -  []  347.06 298.91 90 top
NOREF#3926  -  []  303.53 264.37 90 top
NOREF#3927  -  []  235.02 260.76 0 top
NOREF#3928  -  []  382.38 163.97 0 top
NOREF#3929  -  []  311.11 304.05 0 top
NOREF#3930  -  []  386.6 311.22 90 top
NOREF#3931  -  []  313.21 303.73 90 top
NOREF#3932  -  []  535.43 324.32 0 top
NOREF#3933  -  []  241.17 403.62 0 top
NOREF#3934  -  []  340.35 250.98 90 top
NOREF#3935  -  []  499.14 233.02 0 top
NOREF#3936  -  []  321.62 227.86 45 top
NOREF#3937  -  []  348.43 297.66 90 top
NOREF#3938  -  []  347.23 298.3 0 top
NOREF#3939  -  []  371.05 303.74 0 top
NOREF#3940  -  []  262.37 284.95 90 top
NOREF#3941  -  []  302.36 137.08 90 top
NOREF#3942  -  []  538.95 269.97 90 top
NOREF#3943  -  []  382.15 298.55 0 top
NOREF#3944  -  []  281.35 377.58 0 top
NOREF#3945  -  []  244.53 420.38 90 top
NOREF#3946  -  []  423.58 250.36 0 top
NOREF#3947  -  []  428.48 251.23 90 top
NOREF#3948  -  []  165.53 463.3 0 top
NOREF#3949  -  []  252.62 210.57 90 top
NOREF#3950  -  []  540.2 284.14 90 top
NOREF#3951  -  []  351.11 305.56 0 top
NOREF#3952  -  []  219.19 303.45 0 top
NOREF#3953  -  []  206.11 209.17 0 top
NOREF#3954  -  []  270.31 254.3 0 top
NOREF#3955  -  []  517.55 403.62 90 top
NOREF#3956  -  []  432.1 298.98 0 top
NOREF#3957  -  []  226.79 295.05 90 top
NOREF#3958  -  []  494.85 138.93 90 top
NOREF#3959  -  []  429.08 248.46 90 top
NOREF#3960  -  []  432.14 231.95 0 top
NOREF#3961  -  []  276.07 270.81 0 top
NOREF#3962  -  []  471.8 223.88 90 top
NOREF#3963  -  []  425.77 289.16 90 top
NOREF#3964  -  []  430.6 307.1 0 top
NOREF#3965  -  []  429.77 294.51 0 top
NOREF#3966  -  []  358.21 329.35 90 top
NOREF#3967  -  []  349.83 318.32 90 top
NOREF#3968  -  []  354.07 226.36 0 top
NOREF#3969  -  []  344.48 228 90 top
NOREF#3970  -  []  340.01 183.88 90 top
NOREF#3971  -  []  352.1 241.21 0 top
NOREF#3972  -  []  379.58 301.86 0 top
NOREF#3973  -  []  313.21 305.24 90 top
NOREF#3974  -  []  495.94 255.47 90 top
NOREF#3975  -  []  303.35 297.91 90 top
NOREF#3976  -  []  428.08 293.18 90 top
NOREF#3977  -  []  473.66 328.65 0 top
NOREF#3978  -  []  303.53 259.97 90 top
NOREF#3979  -  []  347.45 297.26 90 top
NOREF#3980  -  []  205.28 265.67 0 top
NOREF#3981  -  []  507.95 241.68 0 top
NOREF#3982  -  []  200.81 255.93 0 top
NOREF#3983  -  []  235.02 234.87 0 top
NOREF#3984  -  []  496.52 328.65 0 top
NOREF#3985  -  []  226.79 252.12 90 top
NOREF#3986  -  []  308.48 311.23 90 top
NOREF#3987  -  []  209.96 217.83 0 top
NOREF#3988  -  []  518.8 224.38 0 top
NOREF#3989  -  []  385.08 235.3 90 top
NOREF#3990  -  []  385.67 302.05 0 top
NOREF#3991  -  []  243.37 277.75 0 top
NOREF#3992  -  []  425.86 299.55 0 top
NOREF#3993  -  []  423.58 290.2 0 top
NOREF#3994  -  []  427.19 302.05 0 top
NOREF#3995  -  []  332.56 125.38 90 top
NOREF#3996  -  []  415.78 218.6 0 top
NOREF#3997  -  []  423.53 259.97 90 top
NOREF#3998  -  []  364.75 245.55 0 top
NOREF#3999  -  []  270.81 340.59 90 top
NOREF#4000  -  []  348.12 251.87 0 top
NOREF#4001  -  []  528.87 298.94 0 top
NOREF#4002  -  []  228.17 129.76 0 top
NOREF#4003  -  []  249.42 279.15 0 top
NOREF#4004  -  []  425.78 229.14 90 top
NOREF#4005  -  []  245.02 279.15 0 top
NOREF#4006  -  []  338.25 244.6 0 top
NOREF#4007  -  []  349.44 293.61 90 top
NOREF#4008  -  []  300.35 310.97 90 top
NOREF#4009  -  []  342.41 307.36 0 top
NOREF#4010  -  []  302.11 307.89 0 top
NOREF#4011  -  []  659.58 41.86 90 top
NOREF#4012  -  []  383.58 236.95 90 top
NOREF#4013  -  []  429.74 232.01 0 top
NOREF#4014  -  []  319.08 254.86 0 top
NOREF#4015  -  []  507.37 271.37 90 top
NOREF#4016  -  []  507.95 337.29 0 top
NOREF#4017  -  []  528.27 321.81 0 top
NOREF#4018  -  []  237.8 271.65 90 top
NOREF#4019  -  []  440.19 212.2 90 top
NOREF#4020  -  []  349.83 258.32 90 top
NOREF#4021  -  []  338.98 213.2 90 top
NOREF#4022  -  []  357.72 364.64 90 top
NOREF#4023  -  []  352.06 251.23 90 top
NOREF#4024  -  []  428.47 218.61 0 top
NOREF#4025  -  []  246.33 401.56 0 top
NOREF#4026  -  []  367.66 310.84 0 top
NOREF#4027  -  []  352.7 306.78 90 top
NOREF#4028  -  []  214.51 334.78 90 top
NOREF#4029  -  []  359.3 246.35 0 top
NOREF#4030  -  []  305.67 302.05 0 top
NOREF#4031  -  []  425.6 289.67 90 top
NOREF#4032  -  []  471.23 320.45 0 top
NOREF#4033  -  []  428.96 341.6 90 top
NOREF#4034  -  []  359.59 308.7 90 top
NOREF#4035  -  []  499.14 267.31 0 top
NOREF#4036  -  []  374.25 236.3 90 top
NOREF#4037  -  []  229.98 268.14 0 top
NOREF#4038  -  []  524.45 321.81 90 top
NOREF#4039  -  []  322.68 332.6 90 top
NOREF#4040  -  []  347.28 311.87 0 top
NOREF#4041  -  []  174.46 341.34 0 top
NOREF#4042  -  []  535.43 221.45 0 top
NOREF#4043  -  []  211.51 299.96 0 top
NOREF#4044  -  []  441.62 287.86 45 top
NOREF#4045  -  []  429.83 318.32 90 top
NOREF#4046  -  []  270.31 295.6 0 top
