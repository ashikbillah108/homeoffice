# Allegro board 038RT-8730CN_1116.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#1500  -  []  385.68 309.03 0 top
NOREF#1501  -  []  311.16 270.75 0 top
NOREF#1502  -  []  425.1 289.85 90 top
NOREF#1503  -  []  345.36 229.28 0 top
NOREF#1504  -  []  307.66 233.75 0 top
NOREF#1505  -  []  283.39 269.34 90 top
NOREF#1506  -  []  305.77 229.36 90 top
NOREF#1507  -  []  254.27 277.75 90 top
NOREF#1508  -  []  516.09 314.25 90 top
NOREF#1509  -  []  184.83 160.37 0 top
NOREF#1510  -  []  294.94 244.03 90 top
NOREF#1511  -  []  339.08 274.86 0 top
NOREF#1512  -  []  336.06 164.57 0 top
NOREF#1513  -  []  435.22 306.65 0 top
NOREF#1514  -  []  524.51 409.02 90 top
NOREF#1515  -  []  423.53 324.37 90 top
NOREF#1516  -  []  297.6 309.76 90 top
NOREF#1517  -  []  535.43 232.88 0 top
NOREF#1518  -  []  533.35 226.02 90 top
NOREF#1519  -  []  341.85 125.35 0 top
NOREF#1520  -  []  310.97 233.86 90 top
NOREF#1521  -  []  431.81 255.75 0 top
NOREF#1522  -  []  394.2 240.89 90 top
NOREF#1523  -  []  231.11 139.19 90 top
NOREF#1524  -  []  507.95 294.36 0 top
NOREF#1525  -  []  484.74 274.57 0 top
NOREF#1526  -  []  455.96 211.52 0 top
NOREF#1527  -  []  370.49 183.88 90 top
NOREF#1528  -  []  322.68 330.4 90 top
NOREF#1529  -  []  383.31 246.4 90 top
NOREF#1530  -  []  533.35 237.45 90 top
NOREF#1531  -  []  318.21 329.35 90 top
NOREF#1532  -  []  207.08 336.29 90 top
NOREF#1533  -  []  512.77 343.15 0 top
NOREF#1534  -  []  463.85 265.13 0 top
NOREF#1535  -  []  428.84 292.33 0 top
NOREF#1536  -  []  347.08 306.86 0 top
NOREF#1537  -  []  479.98 386.29 90 top
NOREF#1538  -  []  223.59 320.7 0 top
NOREF#1539  -  []  388.84 234.21 0 top
NOREF#1540  -  []  305.68 229.23 90 top
NOREF#1541  -  []  300.98 311.61 0 top
NOREF#1542  -  []  292.85 242.61 90 top
NOREF#1543  -  []  223.59 234.87 0 top
NOREF#1544  -  []  399.84 165.45 0 top
NOREF#1545  -  []  328.08 324.86 0 top
NOREF#1546  -  []  71.55 446.92 0 top
NOREF#1547  -  []  361.74 117.24 90 top
NOREF#1548  -  []  338.25 305.26 0 top
NOREF#1549  -  []  402.68 330.4 90 top
NOREF#1550  -  []  309.08 244.86 90 top
NOREF#1551  -  []  305.91 129.21 90 top
NOREF#1552  -  []  429.68 304.71 90 top
NOREF#1553  -  []  513.16 421.66 0 top
NOREF#1554  -  []  349.85 297.94 90 top
NOREF#1555  -  []  46.35 423.75 0 top
NOREF#1556  -  []  385.18 269.42 90 top
NOREF#1557  -  []  250 126.36 90 top
NOREF#1558  -  []  305.65 235.93 0 top
NOREF#1559  -  []  377.6 249.76 90 top
NOREF#1560  -  []  433 242.38 0 top
NOREF#1561  -  []  347.44 233.68 0 top
NOREF#1562  -  []  249.42 286.41 0 top
NOREF#1563  -  []  474.04 419.09 0 top
NOREF#1564  -  []  238.22 313.44 90 top
NOREF#1565  -  []  497.58 488.36 0 top
NOREF#1566  -  []  395.58 300.86 90 top
NOREF#1567  -  []  496.52 268.71 0 top
NOREF#1568  -  []  535.43 226.83 90 top
NOREF#1569  -  []  433.2 308.94 90 top
NOREF#1570  -  []  378.25 304.6 0 top
NOREF#1571  -  []  336.06 158.37 90 top
NOREF#1572  -  []  289.74 122.54 90 top
NOREF#1573  -  []  372.85 242.61 0 top
NOREF#1574  -  []  292.04 125.38 90 top
NOREF#1575  -  []  396.56 270.75 90 top
NOREF#1576  -  []  247.22 217.83 0 top
NOREF#1577  -  []  484.74 240.28 0 top
NOREF#1578  -  []  339.12 310.02 90 top
NOREF#1579  -  []  342.41 247.36 0 top
NOREF#1580  -  []  342.87 139.28 90 top
NOREF#1581  -  []  245.71 249.06 90 top
NOREF#1582  -  []  472.03 253.62 0 top
NOREF#1583  -  []  249.65 329.34 90 top
NOREF#1584  -  []  471.79 268.77 0 top
NOREF#1585  -  []  206.11 216.43 0 top
NOREF#1586  -  []  189.36 220.83 0 top
NOREF#1587  -  []  433.91 139.28 90 top
NOREF#1588  -  []  420.35 242.19 90 top
NOREF#1589  -  []  496.52 241.68 0 top
NOREF#1590  -  []  367.08 276.86 0 top
NOREF#1591  -  []  351.81 255.75 0 top
NOREF#1592  -  []  404.92 224.96 0 top
NOREF#1593  -  []  213.31 302 90 top
NOREF#1594  -  []  384.46 227.38 90 top
NOREF#1595  -  []  311.1 249.26 0 top
NOREF#1596  -  []  493.69 128.8 90 top
NOREF#1597  -  []  348.44 310.97 90 top
NOREF#1598  -  []  311.18 250.97 90 top
NOREF#1599  -  []  425.35 236.29 90 top
NOREF#1600  -  []  367.3 175.41 90 top
NOREF#1601  -  []  426.16 299.87 0 top
NOREF#1602  -  []  429.12 232.03 0 top
NOREF#1603  -  []  499.14 343.15 0 top
NOREF#1604  -  []  399.3 306.35 0 top
NOREF#1605  -  []  434.07 220 0 top
NOREF#1606  -  []  273.65 304.74 90 top
NOREF#1607  -  []  259.73 300.1 0 top
NOREF#1608  -  []  380.35 300.82 90 top
NOREF#1609  -  []  306.65 310.96 90 top
NOREF#1610  -  []  71.55 48.42 0 top
NOREF#1611  -  []  426.33 251.86 0 top
NOREF#1612  -  []  346.87 301.41 90 top
NOREF#1613  -  []  71.55 109.92 0 top
NOREF#1614  -  []  458.45 254.92 90 top
NOREF#1615  -  []  332.85 302.61 0 top
NOREF#1616  -  []  355.02 241.03 0 top
NOREF#1617  -  []  326.29 113.92 90 top
NOREF#1618  -  []  433.2 246.03 90 top
NOREF#1619  -  []  262.89 339.67 90 top
NOREF#1620  -  []  340.58 336.81 0 top
NOREF#1621  -  []  359.64 258.32 90 top
NOREF#1622  -  []  495.94 221.18 90 top
NOREF#1623  -  []  332.08 221.86 90 top
NOREF#1624  -  []  305.77 289.16 90 top
NOREF#1625  -  []  238.22 226.47 90 top
NOREF#1626  -  []  312.01 308.09 0 top
NOREF#1627  -  []  485.09 303 0 top
NOREF#1628  -  []  313.34 259.97 90 top
NOREF#1629  -  []  382.54 193.25 0 top
NOREF#1630  -  []  74.58 41.86 90 top
NOREF#1631  -  []  524.7 310.03 0 top
NOREF#1632  -  []  340.35 244.3 90 top
NOREF#1633  -  []  384.48 228 90 top
NOREF#1634  -  []  481.54 237.08 90 top
NOREF#1635  -  []  383.31 245.55 90 top
NOREF#1636  -  []  461.65 333.71 0 top
NOREF#1637  -  []  423.58 287.38 0 top
NOREF#1638  -  []  229.82 419.09 0 top
NOREF#1639  -  []  423.02 219.41 0 top
NOREF#1640  -  []  398.21 329.35 90 top
NOREF#1641  -  []  303.31 307.25 90 top
NOREF#1642  -  []  294.38 234.16 90 top
NOREF#1643  -  []  71.55 48.42 0 top
NOREF#1644  -  []  354.92 302.85 0 top
NOREF#1645  -  []  345.35 242.35 90 top
NOREF#1646  -  []  507.95 225.78 0 top
NOREF#1647  -  []  322.08 261.86 0 top
NOREF#1648  -  []  540.2 215.56 90 top
NOREF#1649  -  []  356.56 270.75 90 top
NOREF#1650  -  []  341.08 298.36 0 top
NOREF#1651  -  []  471.8 292.46 90 top
NOREF#1652  -  []  400.64 210.89 0 top
NOREF#1653  -  []  489.91 318.85 0 top
NOREF#1654  -  []  460.14 319.2 0 top
NOREF#1655  -  []  307.66 293.75 0 top
NOREF#1656  -  []  339.15 244.28 0 top
NOREF#1657  -  []  307.28 311.87 0 top
NOREF#1658  -  []  345.18 329.41 90 top
NOREF#1659  -  []  306.87 302.35 90 top
NOREF#1660  -  []  367.08 326.86 0 top
NOREF#1661  -  []  189.36 243.69 0 top
NOREF#1662  -  []  365.45 346.74 0 top
NOREF#1663  -  []  235.02 279.15 0 top
NOREF#1664  -  []  393 301.53 0 top
NOREF#1665  -  []  495.94 318.85 0 top
NOREF#1666  -  []  46.95 407.63 0 top
NOREF#1667  -  []  419.15 251.62 0 top
NOREF#1668  -  []  288.08 264.86 0 top
NOREF#1669  -  []  334.28 269.42 0 top
NOREF#1670  -  []  336.07 416.55 90 top
NOREF#1671  -  []  539.65 265.69 90 top
NOREF#1672  -  []  312.1 242.06 0 top
NOREF#1673  -  []  393.28 291.15 90 top
NOREF#1674  -  []  351.15 300.26 0 top
NOREF#1675  -  []  334.94 244.03 90 top
NOREF#1676  -  []  296.08 317.86 0 top
NOREF#1677  -  []  298.25 311.94 0 top
NOREF#1678  -  []  425.28 209.35 90 top
NOREF#1679  -  []  407.08 226.86 90 top
NOREF#1680  -  []  348.2 236.49 0 top
NOREF#1681  -  []  427.91 293.69 90 top
NOREF#1682  -  []  254.27 250.72 90 top
NOREF#1683  -  []  533.35 283.17 90 top
NOREF#1684  -  []  226.79 286.41 90 top
NOREF#1685  -  []  402.08 261.86 0 top
NOREF#1686  -  []  347.44 293.68 0 top
NOREF#1687  -  []  302.11 307.04 0 top
NOREF#1688  -  []  336.8 121.67 0 top
NOREF#1689  -  []  489.91 327.25 0 top
NOREF#1690  -  []  391.15 300.26 0 top
NOREF#1691  -  []  310.94 226.5 90 top
NOREF#1692  -  []  412.85 242.61 0 top
NOREF#1693  -  []  412.08 271.86 0 top
NOREF#1694  -  []  380.33 327.57 0 top
NOREF#1695  -  []  342.41 246.51 0 top
NOREF#1696  -  []  495.94 233.02 0 top
NOREF#1697  -  []  465.33 141.48 90 top
NOREF#1698  -  []  193.96 252.65 0 top
NOREF#1699  -  []  339.15 304.94 0 top
NOREF#1700  -  []  485.09 344.55 0 top
NOREF#1701  -  []  382.44 255.5 90 top
NOREF#1702  -  []  300.35 303.64 90 top
NOREF#1703  -  []  205.15 151.48 90 top
NOREF#1704  -  []  358.8 141.13 0 top
NOREF#1705  -  []  221.39 313.44 0 top
NOREF#1706  -  []  422.75 240.26 90 top
NOREF#1707  -  []  299.15 244.28 0 top
NOREF#1708  -  []  287.95 242.35 90 top
NOREF#1709  -  []  302.88 240.86 0 top
NOREF#1710  -  []  332.08 331.86 0 top
NOREF#1711  -  []  349.4 235.85 90 top
NOREF#1712  -  []  462.08 187.86 90 top
NOREF#1713  -  []  424.08 243.86 0 top
NOREF#1714  -  []  337.86 194.29 0 top
NOREF#1715  -  []  496.52 275.97 0 top
NOREF#1716  -  []  344.48 297.91 0 top
NOREF#1717  -  []  304.08 243.86 0 top
NOREF#1718  -  []  316.21 252.13 0 top
NOREF#1719  -  []  519.84 421.68 90 top
NOREF#1720  -  []  239.87 327.94 90 top
NOREF#1721  -  []  512.77 318.85 0 top
NOREF#1722  -  []  472.54 212.78 0 top
NOREF#1723  -  []  306.85 237.41 0 top
NOREF#1724  -  []  184.83 174.79 0 top
NOREF#1725  -  []  393.34 259.97 90 top
NOREF#1726  -  []  198.73 252.93 0 top
NOREF#1727  -  []  377.58 65.36 90 top
NOREF#1728  -  []  438.17 337.05 0 top
NOREF#1729  -  []  193.96 327.16 90 top
NOREF#1730  -  []  335.91 141.48 90 top
NOREF#1731  -  []  304.48 238.55 0 top
NOREF#1732  -  []  419.08 334.86 0 top
NOREF#1733  -  []  74.58 41.86 90 top
NOREF#1734  -  []  322.13 326.4 90 top
NOREF#1735  -  []  345.4 311.86 0 top
NOREF#1736  -  []  478.29 309.94 90 top
NOREF#1737  -  []  414.71 249.44 90 top
NOREF#1738  -  []  393.28 231.15 90 top
NOREF#1739  -  []  252.62 279.15 90 top
NOREF#1740  -  []  306.65 250.96 90 top
NOREF#1741  -  []  484.51 212.78 90 top
NOREF#1742  -  []  530.15 229.21 0 top
NOREF#1743  -  []  315.58 240.86 90 top
NOREF#1744  -  []  289.58 87.36 0 top
NOREF#1745  -  []  368.12 224.96 0 top
NOREF#1746  -  []  345.15 335.54 90 top
NOREF#1747  -  []  342.12 255.2 0 top
NOREF#1748  -  []  469.17 129.19 0 top
NOREF#1749  -  []  592.33 126.82 90 top
NOREF#1750  -  []  469.17 129.19 0 top
NOREF#1751  -  []  347.67 338 90 top
NOREF#1752  -  []  495.19 141.13 0 top
NOREF#1753  -  []  331.36 123.86 0 top
NOREF#1754  -  []  200.81 272.76 90 top
NOREF#1755  -  []  315.29 108.63 90 top
NOREF#1756  -  []  435.61 210.88 0 top
NOREF#1757  -  []  264.76 274.26 0 top
NOREF#1758  -  []  442.68 267.2 90 top
NOREF#1759  -  []  212.16 329.34 0 top
NOREF#1760  -  []  424.48 228 90 top
NOREF#1761  -  []  305.68 237.91 90 top
NOREF#1762  -  []  524.45 218.94 90 top
NOREF#1763  -  []  302.41 248.21 0 top
NOREF#1764  -  []  444.92 281.76 90 top
NOREF#1765  -  []  518.8 240.28 0 top
NOREF#1766  -  []  426.87 302.35 90 top
NOREF#1767  -  []  217.54 216.43 0 top
NOREF#1768  -  []  387.23 238.3 0 top
NOREF#1769  -  []  529.06 424.44 0 top
NOREF#1770  -  []  404.51 347.01 0 top
NOREF#1771  -  []  364.75 305.55 0 top
NOREF#1772  -  []  428.2 296.49 0 top
NOREF#1773  -  []  343.58 310.36 0 top
NOREF#1774  -  []  343.9 230.5 0 top
NOREF#1775  -  []  353.2 306.03 90 top
NOREF#1776  -  []  49.87 379.69 90 top
NOREF#1777  -  []  431.67 211.01 90 top
NOREF#1778  -  []  387.34 236.08 0 top
NOREF#1779  -  []  302.36 139.28 90 top
NOREF#1780  -  []  302.75 240.26 90 top
NOREF#1781  -  []  512.77 250.27 0 top
NOREF#1782  -  []  237.8 340.23 90 top
NOREF#1783  -  []  352.71 255.43 0 top
NOREF#1784  -  []  575.83 129.32 0 top
NOREF#1785  -  []  428.59 228.35 0 top
NOREF#1786  -  []  311.11 244.05 0 top
NOREF#1787  -  []  496.52 251.67 0 top
NOREF#1788  -  []  315.22 306.65 0 top
NOREF#1789  -  []  319.61 113.41 0 top
NOREF#1790  -  []  385.07 220.36 90 top
NOREF#1791  -  []  495.94 247.07 90 top
NOREF#1792  -  []  334.94 304.03 90 top
NOREF#1793  -  []  331.05 243.75 0 top
NOREF#1794  -  []  385.02 297.19 0 top
NOREF#1795  -  []  386.46 302.05 0 top
NOREF#1796  -  []  478.6 253.52 90 top
NOREF#1797  -  []  428.07 297.2 90 top
NOREF#1798  -  []  259.36 268.01 0 top
NOREF#1799  -  []  353.08 310.71 90 top
NOREF#1800  -  []  419.15 302.83 0 top
NOREF#1801  -  []  349.85 237.94 90 top
NOREF#1802  -  []  303.31 306.4 90 top
NOREF#1803  -  []  309.83 258.32 90 top
NOREF#1804  -  []  396.12 302.21 90 top
NOREF#1805  -  []  435.22 305.28 0 top
NOREF#1806  -  []  429.74 287.14 0 top
NOREF#1807  -  []  292.08 271.86 0 top
NOREF#1808  -  []  228.44 209.17 90 top
NOREF#1809  -  []  351.11 304.05 0 top
NOREF#1810  -  []  349.08 244.86 90 top
NOREF#1811  -  []  313.51 214.74 0 top
NOREF#1812  -  []  324.92 215.4 90 top
NOREF#1813  -  []  423.53 270.82 90 top
NOREF#1814  -  []  232.82 329.34 0 top
NOREF#1815  -  []  322.68 267.2 0 top
NOREF#1816  -  []  391.67 215.41 90 top
NOREF#1817  -  []  340.33 327.57 0 top
NOREF#1818  -  []  351.11 244.05 0 top
NOREF#1819  -  []  423.28 228.64 0 top
NOREF#1820  -  []  495.94 343.15 0 top
NOREF#1821  -  []  312.01 244.37 0 top
NOREF#1822  -  []  380.35 303.64 90 top
NOREF#1823  -  []  452.04 377.4 0 top
NOREF#1824  -  []  518.8 229.82 90 top
NOREF#1825  -  []  303.31 245.55 90 top
NOREF#1826  -  []  272.51 213 0 top
NOREF#1827  -  []  358.21 269.35 90 top
NOREF#1828  -  []  507.37 258.67 0 top
NOREF#1829  -  []  277.93 132.6 0 top
NOREF#1830  -  []  430.3 296.62 90 top
NOREF#1831  -  []  340.74 403.62 0 top
NOREF#1832  -  []  420.16 156.56 90 top
NOREF#1833  -  []  345.9 401.56 0 top
NOREF#1834  -  []  222.76 402.82 0 top
NOREF#1835  -  []  507.37 255.47 90 top
NOREF#1836  -  []  348.12 228.85 0 top
NOREF#1837  -  []  47.62 404.06 0 top
NOREF#1838  -  []  393.34 322.17 90 top
NOREF#1839  -  []  408.58 347.18 90 top
NOREF#1840  -  []  262.37 216.37 90 top
NOREF#1841  -  []  439.64 318.32 90 top
NOREF#1842  -  []  385.72 250.96 90 top
NOREF#1843  -  []  393.36 342.58 90 top
NOREF#1844  -  []  338.25 304.6 0 top
NOREF#1845  -  []  32.37 432.49 90 top
NOREF#1846  -  []  533.35 278.76 90 top
NOREF#1847  -  []  380.35 302.19 90 top
NOREF#1848  -  []  389.92 287.85 90 top
NOREF#1849  -  []  268.11 220.01 0 top
NOREF#1850  -  []  302.98 236.26 0 top
NOREF#1851  -  []  345.35 302.35 90 top
NOREF#1852  -  []  282.08 261.86 0 top
NOREF#1853  -  []  304.48 298.55 0 top
NOREF#1854  -  []  383.58 230.2 0 top
NOREF#1855  -  []  433.21 305.24 90 top
NOREF#1856  -  []  517.58 488.36 0 top
NOREF#1857  -  []  346.85 237.41 0 top
NOREF#1858  -  []  385.6 229.67 90 top
NOREF#1859  -  []  226.79 303.45 90 top
NOREF#1860  -  []  420.35 250.98 90 top
NOREF#1861  -  []  448.92 231.34 0 top
NOREF#1862  -  []  354.2 240.89 90 top
NOREF#1863  -  []  434.92 302.85 0 top
NOREF#1864  -  []  431.11 244.05 0 top
NOREF#1865  -  []  341.08 311.06 0 top
NOREF#1866  -  []  308.84 234.21 0 top
NOREF#1867  -  []  303.58 236.95 90 top
NOREF#1868  -  []  213.31 233.42 90 top
NOREF#1869  -  []  285.46 310.84 0 top
NOREF#1870  -  []  200.26 312.27 90 top
NOREF#1871  -  []  465.33 139.28 90 top
NOREF#1872  -  []  343.58 228.32 0 top
NOREF#1873  -  []  330.25 122.54 90 top
NOREF#1874  -  []  510.57 267.31 0 top
NOREF#1875  -  []  293.88 303.99 90 top
NOREF#1876  -  []  347.66 293.75 0 top
NOREF#1877  -  []  430.3 236.62 90 top
NOREF#1878  -  []  298.25 251.94 0 top
NOREF#1879  -  []  353.34 259.97 90 top
NOREF#1880  -  []  355.05 179.05 0 top
NOREF#1881  -  []  200.81 238.47 90 top
NOREF#1882  -  []  305.36 289.74 0 top
NOREF#1883  -  []  299.15 244.94 0 top
NOREF#1884  -  []  223.59 217.83 0 top
NOREF#1885  -  []  534.36 415.7 0 top
NOREF#1886  -  []  427.23 298.3 0 top
NOREF#1887  -  []  239.87 216.43 90 top
NOREF#1888  -  []  495.73 139.19 90 top
NOREF#1889  -  []  382.88 240.86 0 top
NOREF#1890  -  []  350.58 303.36 90 top
NOREF#1891  -  []  342.75 240.26 90 top
NOREF#1892  -  []  520.85 244.1 90 top
NOREF#1893  -  []  382.38 179.21 0 top
NOREF#1894  -  []  319.08 298.86 90 top
NOREF#1895  -  []  226.79 329.34 90 top
NOREF#1896  -  []  538.95 262.71 90 top
NOREF#1897  -  []  69.58 506.86 0 top
NOREF#1898  -  []  344.54 302.35 90 top
NOREF#1899  -  []  352.01 308.09 0 top
NOREF#1900  -  []  424.48 289.87 0 top
NOREF#1901  -  []  223.59 303.45 0 top
NOREF#1902  -  []  403.19 179.87 0 top
NOREF#1903  -  []  516.09 304.26 90 top
NOREF#1904  -  []  426.6 251.22 90 top
NOREF#1905  -  []  419.15 302.15 0 top
NOREF#1906  -  []  264.76 342.84 0 top
NOREF#1907  -  []  346.25 237.9 0 top
NOREF#1908  -  []  435.61 213.47 0 top
NOREF#1909  -  []  432.01 305.88 0 top
NOREF#1910  -  []  277.36 314.47 90 top
NOREF#1911  -  []  313.44 112.48 0 top
NOREF#1912  -  []  336.82 192.6 90 top
NOREF#1913  -  []  230.62 329.34 0 top
NOREF#1914  -  []  428.59 288.35 0 top
NOREF#1915  -  []  305.01 229.28 0 top
NOREF#1916  -  []  533.35 269.53 90 top
NOREF#1917  -  []  421.68 311.19 0 top
NOREF#1918  -  []  308.63 298.15 0 top
NOREF#1919  -  []  348.49 297.58 90 top
NOREF#1920  -  []  301.83 297.76 90 top
NOREF#1921  -  []  433 238.87 90 top
NOREF#1922  -  []  415.93 330.81 0 top
NOREF#1923  -  []  71.55 48.42 0 top
NOREF#1924  -  []  428.49 237.58 90 top
NOREF#1925  -  []  426.37 237.89 0 top
NOREF#1926  -  []  414.25 236.3 90 top
NOREF#1927  -  []  395.22 302.53 0 top
NOREF#1928  -  []  431.18 310.97 90 top
NOREF#1929  -  []  434.7 218.11 90 top
NOREF#1930  -  []  507.37 224.38 0 top
NOREF#1931  -  []  497.79 213.67 0 top
NOREF#1932  -  []  275.71 254.3 90 top
NOREF#1933  -  []  301.08 311.06 0 top
NOREF#1934  -  []  305.15 335.54 90 top
NOREF#1935  -  []  200.81 247.69 90 top
NOREF#1936  -  []  313.51 212.15 0 top
NOREF#1937  -  []  454.45 321.87 90 top
NOREF#1938  -  []  429.85 237.94 90 top
NOREF#1939  -  []  516.09 235.68 90 top
NOREF#1940  -  []  243.37 250.72 0 top
NOREF#1941  -  []  427.29 238.22 0 top
NOREF#1942  -  []  247.22 279.15 0 top
NOREF#1943  -  []  393 238.02 90 top
NOREF#1944  -  []  306.06 241.41 90 top
NOREF#1945  -  []  308.08 233.38 90 top
NOREF#1946  -  []  347.23 238.3 0 top
NOREF#1947  -  []  305.67 242.05 0 top
NOREF#1948  -  []  407.08 326.86 0 top
NOREF#1949  -  []  427.66 233.75 0 top
NOREF#1950  -  []  391.11 245.56 0 top
NOREF#1951  -  []  434.07 286.36 0 top
NOREF#1952  -  []  311.5 247.42 0 top
NOREF#1953  -  []  193.96 292.87 90 top
NOREF#1954  -  []  340.35 303.64 90 top
NOREF#1955  -  []  419.15 304.28 0 top
NOREF#1956  -  []  428.43 237.66 90 top
NOREF#1957  -  []  350.6 247.1 0 top
NOREF#1958  -  []  354.07 220 0 top
NOREF#1959  -  []  294.71 249.44 90 top
NOREF#1960  -  []  238.22 303.45 90 top
NOREF#1961  -  []  507.37 237.08 90 top
NOREF#1962  -  []  486.94 233.02 0 top
NOREF#1963  -  []  305.13 289.66 0 top
NOREF#1964  -  []  393 298.87 90 top
NOREF#1965  -  []  327.95 237.95 90 top
NOREF#1966  -  []  341.19 293.6 90 top
NOREF#1967  -  []  419.08 274.86 0 top
NOREF#1968  -  []  425.33 215.4 90 top
NOREF#1969  -  []  275.71 281.58 90 top
NOREF#1970  -  []  370.61 211.52 0 top
NOREF#1971  -  []  307.45 237.26 90 top
NOREF#1972  -  []  351.9 189.45 90 top
NOREF#1973  -  []  269.97 207.26 0 top
NOREF#1974  -  []  299.08 334.86 0 top
NOREF#1975  -  []  484.51 247.07 90 top
NOREF#1976  -  []  305.36 289.28 0 top
NOREF#1977  -  []  351.3 179.81 0 top
NOREF#1978  -  []  52.38 415.56 90 top
NOREF#1979  -  []  388.12 251.87 0 top
NOREF#1980  -  []  469.9 292.06 0 top
NOREF#1981  -  []  347.45 237.26 90 top
NOREF#1982  -  []  308.66 135.43 90 top
NOREF#1983  -  []  391.1 246.35 0 top
NOREF#1984  -  []  223.59 313.44 0 top
NOREF#1985  -  []  413.06 310.84 90 top
NOREF#1986  -  []  356.11 129.44 0 top
NOREF#1987  -  []  294.38 294.16 90 top
NOREF#1988  -  []  388.84 227.46 0 top
NOREF#1989  -  []  270.81 268.81 90 top
NOREF#1990  -  []  314.92 242.85 0 top
NOREF#1991  -  []  356.56 330.75 90 top
NOREF#1992  -  []  256.11 415.7 0 top
NOREF#1993  -  []  284.75 305.55 0 top
NOREF#1994  -  []  422.11 307.04 0 top
NOREF#1995  -  []  428.96 270.75 0 top
NOREF#1996  -  []  484.51 315.65 90 top
NOREF#1997  -  []  421.19 293.6 90 top
NOREF#1998  -  []  228.97 259.36 0 top
NOREF#1999  -  []  346.85 295.29 90 top
NOREF#2000  -  []  409.86 250.84 0 top
NOREF#2001  -  []  495.94 237.08 90 top
NOREF#2002  -  []  304.69 268.37 0 top
NOREF#2003  -  []  343.31 247.25 90 top
NOREF#2004  -  []  532.47 298.94 90 top
NOREF#2005  -  []  374.1 340.54 90 top
NOREF#2006  -  []  427.19 242.05 0 top
NOREF#2007  -  []  522 327.25 0 top
NOREF#2008  -  []  306.46 242.05 0 top
NOREF#2009  -  []  238.22 329.34 90 top
NOREF#2010  -  []  513.16 421.66 0 top
NOREF#2011  -  []  423.88 295.94 0 top
NOREF#2012  -  []  385.78 289.41 90 top
NOREF#2013  -  []  422.98 296.26 0 top
NOREF#2014  -  []  342.75 300.26 90 top
NOREF#2015  -  []  663.76 509.6 0 top
NOREF#2016  -  []  309.08 304.86 90 top
NOREF#2017  -  []  384.54 242.35 90 top
NOREF#2018  -  []  348.65 238.59 0 top
NOREF#2019  -  []  301.34 125.35 0 top
NOREF#2020  -  []  393.44 293.48 90 top
NOREF#2021  -  []  244.25 234.87 0 top
NOREF#2022  -  []  382.88 240.86 90 top
NOREF#2023  -  []  369.07 337.05 90 top
NOREF#2024  -  []  383.58 229.6 90 top
NOREF#2025  -  []  469.16 338.95 90 top
NOREF#2026  -  []  507.37 298.4 90 top
NOREF#2027  -  []  338.47 338.08 0 top
NOREF#2028  -  []  427.31 233.29 0 top
NOREF#2029  -  []  299.99 234.24 0 top
NOREF#2030  -  []  339.15 251.62 0 top
NOREF#2031  -  []  350.6 307.1 0 top
NOREF#2032  -  []  435.61 216.04 0 top
NOREF#2033  -  []  433 241.53 0 top
NOREF#2034  -  []  432.08 299.36 90 top
NOREF#2035  -  []  309.74 292.01 0 top
NOREF#2036  -  []  451.53 320.6 90 top
NOREF#2037  -  []  308.08 293.18 90 top
NOREF#2038  -  []  308.43 297.66 90 top
NOREF#2039  -  []  425.01 289.28 0 top
NOREF#2040  -  []  384.08 303.86 0 top
NOREF#2041  -  []  390.6 247.1 0 top
NOREF#2042  -  []  307.91 233.69 90 top
NOREF#2043  -  []  423.9 290.5 0 top
NOREF#2044  -  []  433.08 310.71 90 top
NOREF#2045  -  []  420.33 270.82 0 top
NOREF#2046  -  []  495.94 240.28 0 top
NOREF#2047  -  []  507.95 328.65 0 top
NOREF#2048  -  []  228.97 250.72 0 top
NOREF#2049  -  []  507.37 335.89 0 top
NOREF#2050  -  []  512.77 335.89 0 top
NOREF#2051  -  []  432.06 311.23 90 top
NOREF#2052  -  []  300.33 327.57 0 top
NOREF#2053  -  []  473.66 285.96 0 top
NOREF#2054  -  []  507.37 327.25 0 top
NOREF#2055  -  []  347.06 238.91 90 top
NOREF#2056  -  []  414.88 268.37 0 top
NOREF#2057  -  []  391.11 244.05 0 top
NOREF#2058  -  []  303.35 237.91 90 top
NOREF#2059  -  []  374.88 268.37 0 top
NOREF#2060  -  []  223.24 147.82 90 top
NOREF#2061  -  []  299.15 242.83 0 top
NOREF#2062  -  []  193.96 229.79 0 top
NOREF#2063  -  []  512.77 267.31 0 top
NOREF#2064  -  []  393 238.87 90 top
NOREF#2065  -  []  339.74 126.62 0 top
NOREF#2066  -  []  354.07 286.36 0 top
NOREF#2067  -  []  256.94 339.34 90 top
NOREF#2068  -  []  463.34 208.73 90 top
NOREF#2069  -  []  284.98 338.66 90 top
NOREF#2070  -  []  217.54 209.17 0 top
NOREF#2071  -  []  312.1 302.06 0 top
NOREF#2072  -  []  319.3 306.35 0 top
NOREF#2073  -  []  303.58 288.32 90 top
NOREF#2074  -  []  302.88 240.86 0 top
NOREF#2075  -  []  386.87 242.35 90 top
NOREF#2076  -  []  348.84 294.21 0 top
NOREF#2077  -  []  386.85 235.29 90 top
NOREF#2078  -  []  535.43 278.6 0 top
NOREF#2079  -  []  343.31 246.4 90 top
NOREF#2080  -  []  388.54 234.54 0 top
NOREF#2081  -  []  370.9 345.94 0 top
NOREF#2082  -  []  433.51 214.74 0 top
NOREF#2083  -  []  298.25 305.26 0 top
NOREF#2084  -  []  381.78 173.61 90 top
NOREF#2085  -  []  540.2 289.64 0 top
NOREF#2086  -  []  76.55 43.42 90 top
NOREF#2087  -  []  458.45 323.5 90 top
NOREF#2088  -  []  228.97 293.65 0 top
NOREF#2089  -  []  270.31 315.87 0 top
NOREF#2090  -  []  351.16 270.75 0 top
NOREF#2091  -  []  501.34 258.67 0 top
NOREF#2092  -  []  450.32 218.6 0 top
NOREF#2093  -  []  239.87 209.17 90 top
NOREF#2094  -  []  230.56 141.13 0 top
NOREF#2095  -  []  447.6 259.52 0 top
NOREF#2096  -  []  208.28 334.78 90 top
NOREF#2097  -  []  328.08 287.86 90 top
NOREF#2098  -  []  393.21 303.73 90 top
NOREF#2099  -  []  321.71 115.19 0 top
NOREF#2100  -  []  364.92 218.6 0 top
NOREF#2101  -  []  217.01 243.46 90 top
NOREF#2102  -  []  429.54 237.24 0 top
NOREF#2103  -  []  71.55 446.92 0 top
NOREF#2104  -  []  463.34 277.31 90 top
NOREF#2105  -  []  429.1 237.26 0 top
NOREF#2106  -  []  305.36 229.74 0 top
NOREF#2107  -  []  419.15 242.83 0 top
NOREF#2108  -  []  340.74 409.02 90 top
NOREF#2109  -  []  340.08 346.74 0 top
NOREF#2110  -  []  481.54 335.89 0 top
NOREF#2111  -  []  393.2 308.94 90 top
NOREF#2112  -  []  278.76 344.2 90 top
NOREF#2113  -  []  239.87 259.36 90 top
NOREF#2114  -  []  320.97 112.04 90 top
NOREF#2115  -  []  463.34 281.71 90 top
NOREF#2116  -  []  325.45 346.74 0 top
NOREF#2117  -  []  282.08 291.86 90 top
NOREF#2118  -  []  522 292.96 0 top
NOREF#2119  -  []  324.53 386.47 90 top
NOREF#2120  -  []  335.63 116.97 90 top
NOREF#2121  -  []  518.8 298.4 90 top
NOREF#2122  -  []  461.65 223.83 0 top
NOREF#2123  -  []  522 301.6 0 top
NOREF#2124  -  []  501.34 250.27 0 top
NOREF#2125  -  []  395.22 306.65 0 top
NOREF#2126  -  []  300.35 300.82 90 top
NOREF#2127  -  []  213.31 267.71 90 top
NOREF#2128  -  []  481.54 339.95 90 top
NOREF#2129  -  []  385.18 329.41 90 top
NOREF#2130  -  []  390.94 231.37 90 top
NOREF#2131  -  []  259.73 299.46 90 top
NOREF#2132  -  []  346.42 126.65 90 top
NOREF#2133  -  []  305.58 229.16 90 top
NOREF#2134  -  []  420.35 302.19 90 top
NOREF#2135  -  []  513.16 424.22 0 top
NOREF#2136  -  []  259.73 334.39 0 top
NOREF#2137  -  []  501.34 308.86 0 top
NOREF#2138  -  []  510.57 327.25 0 top
NOREF#2139  -  []  343.53 270.82 90 top
NOREF#2140  -  []  432.9 336.81 0 top
NOREF#2141  -  []  268.11 254.3 0 top
NOREF#2142  -  []  422.98 296.26 0 top
NOREF#2143  -  []  431.81 315.75 0 top
NOREF#2144  -  []  242.05 226.47 0 top
NOREF#2145  -  []  410.08 323.86 0 top
NOREF#2146  -  []  302.12 315.2 0 top
NOREF#2147  -  []  231.81 274.85 0 top
NOREF#2148  -  []  223.58 65.36 90 top
NOREF#2149  -  []  343.58 296.95 90 top
NOREF#2150  -  []  518.8 255.47 90 top
NOREF#2151  -  []  232.82 320.7 0 top
NOREF#2152  -  []  334.88 328.37 0 top
NOREF#2153  -  []  193.96 309.8 0 top
NOREF#2154  -  []  507.37 274.57 0 top
NOREF#2155  -  []  567.58 466.36 90 top
NOREF#2156  -  []  315.61 213.47 0 top
NOREF#2157  -  []  207.08 336.29 90 top
NOREF#2158  -  []  367.14 158.97 90 top
NOREF#2159  -  []  399.08 314.86 0 top
NOREF#2160  -  []  215.36 252.12 90 top
NOREF#2161  -  []  407.95 302.35 90 top
NOREF#2162  -  []  411.05 303.74 0 top
NOREF#2163  -  []  305.1 289.85 90 top
NOREF#2164  -  []  532.47 264.65 90 top
NOREF#2165  -  []  254.27 319.3 90 top
NOREF#2166  -  []  383.58 238.23 0 top
NOREF#2167  -  []  265.56 234.17 0 top
NOREF#2168  -  []  306.14 242.35 90 top
NOREF#2169  -  []  193.96 264.08 0 top
NOREF#2170  -  []  427.22 179.91 0 top
NOREF#2171  -  []  228.44 302.05 90 top
NOREF#2172  -  []  538.95 304.26 90 top
NOREF#2173  -  []  69.58 46.86 0 top
NOREF#2174  -  []  449.07 337.05 90 top
NOREF#2175  -  []  340.74 403.62 90 top
NOREF#2176  -  []  266.46 314.47 0 top
NOREF#2177  -  []  239.87 225.07 90 top
NOREF#2178  -  []  259.36 336.59 0 top
NOREF#2179  -  []  302.11 246.19 0 top
NOREF#2180  -  []  440.19 214.77 90 top
NOREF#2181  -  []  348.43 237.66 90 top
NOREF#2182  -  []  336.06 188.85 90 top
NOREF#2183  -  []  408.12 224.96 0 top
NOREF#2184  -  []  277.36 245.89 90 top
NOREF#2185  -  []  298.47 340.67 0 top
NOREF#2186  -  []  372.08 221.86 90 top
NOREF#2187  -  []  207.08 267.71 90 top
NOREF#2188  -  []  351.3 188.85 90 top
NOREF#2189  -  []  388.49 237.58 90 top
NOREF#2190  -  []  291.58 65.36 90 top
NOREF#2191  -  []  391.16 330.75 0 top
NOREF#2192  -  []  524.2 267.31 0 top
NOREF#2193  -  []  539.65 231.4 90 top
NOREF#2194  -  []  420.35 244.3 90 top
NOREF#2195  -  []  451.53 337.34 90 top
NOREF#2196  -  []  69.58 506.86 0 top
NOREF#2197  -  []  302.11 306.19 0 top
NOREF#2198  -  []  259.73 265.81 0 top
NOREF#2199  -  []  240.4 233.47 0 top
NOREF#2200  -  []  428.84 294.21 0 top
NOREF#2201  -  []  458.45 330.51 90 top
NOREF#2202  -  []  432 249.58 0 top
NOREF#2203  -  []  458.45 234.65 90 top
NOREF#2204  -  []  392.1 241.21 0 top
NOREF#2205  -  []  358.17 337.05 0 top
NOREF#2206  -  []  423.58 236.95 90 top
NOREF#2207  -  []  284.98 339.55 90 top
NOREF#2208  -  []  266.46 218.61 0 top
NOREF#2209  -  []  71.55 48.42 0 top
NOREF#2210  -  []  436.12 304.96 90 top
NOREF#2211  -  []  540.2 329.86 90 top
NOREF#2212  -  []  200.26 232.26 90 top
NOREF#2213  -  []  419.08 218.86 90 top
NOREF#2214  -  []  518.8 271.37 90 top
NOREF#2215  -  []  262.37 250.66 90 top
NOREF#2216  -  []  342.41 308.21 0 top
NOREF#2217  -  []  394.92 305.6 0 top
NOREF#2218  -  []  370.49 168.64 90 top
NOREF#2219  -  []  419.12 250.02 90 top
NOREF#2220  -  []  346.42 129.21 90 top
NOREF#2221  -  []  353.51 214.74 0 top
NOREF#2222  -  []  310.58 303.36 90 top
NOREF#2223  -  []  392.08 239.36 90 top
NOREF#2224  -  []  393.36 270.75 0 top
NOREF#2225  -  []  343.58 290.2 0 top
NOREF#2226  -  []  510.57 335.89 0 top
NOREF#2227  -  []  428.49 297.58 90 top
NOREF#2228  -  []  432.25 294.12 0 top
NOREF#2229  -  []  539.65 311.41 90 top
NOREF#2230  -  []  421.08 298.36 0 top
NOREF#2231  -  []  308.84 294.21 0 top
NOREF#2232  -  []  533.35 271.74 90 top
NOREF#2233  -  []  426.14 242.35 90 top
NOREF#2234  -  []  333.76 123.86 90 top
NOREF#2235  -  []  382.41 308.21 0 top
NOREF#2236  -  []  227.94 137.96 0 top
NOREF#2237  -  []  535.43 312.89 0 top
NOREF#2238  -  []  395.22 305.28 0 top
NOREF#2239  -  []  309.4 235.85 90 top
NOREF#2240  -  []  384.48 249.03 0 top
NOREF#2241  -  []  0 453.95 0 top
NOREF#2242  -  []  247.22 244.86 0 top
NOREF#2243  -  []  499.14 224.38 0 top
NOREF#2244  -  []  408.12 284.96 0 top
NOREF#2245  -  []  435.02 301.03 0 top
NOREF#2246  -  []  352.14 291.95 0 top
NOREF#2247  -  []  387.34 296.08 0 top
NOREF#2248  -  []  527.52 314.25 90 top
NOREF#2249  -  []  393.08 250.71 90 top
NOREF#2250  -  []  540.2 238.42 90 top
NOREF#2251  -  []  414.38 319.56 0 top
NOREF#2252  -  []  359.7 140.17 90 top
NOREF#2253  -  []  533.35 328.89 90 top
NOREF#2254  -  []  340.48 311.19 0 top
NOREF#2255  -  []  418.98 211 90 top
NOREF#2256  -  []  294.25 236.3 90 top
NOREF#2257  -  []  429.4 235.85 90 top
NOREF#2258  -  []  331.77 411.05 0 top
NOREF#2259  -  []  307.06 238.91 90 top
NOREF#2260  -  []  472.91 287.01 90 top
NOREF#2261  -  []  437.47 335.54 90 top
NOREF#2262  -  []  351.8 238.66 0 top
NOREF#2263  -  []  348.65 298.59 0 top
NOREF#2264  -  []  347.08 306.86 0 top
NOREF#2265  -  []  567.58 65.36 90 top
NOREF#2266  -  []  329.39 421.66 0 top
NOREF#2267  -  []  74.58 41.86 90 top
NOREF#2268  -  []  512.77 240.28 0 top
NOREF#2269  -  []  312.01 305.88 0 top
NOREF#2270  -  []  268.11 288.59 0 top
NOREF#2271  -  []  247.22 252.12 0 top
NOREF#2272  -  []  340.35 310.97 90 top
NOREF#2273  -  []  425.68 229.23 90 top
NOREF#2274  -  []  522.05 321.81 0 top
NOREF#2275  -  []  386.14 242.35 90 top
NOREF#2276  -  []  447.6 266.53 0 top
NOREF#2277  -  []  303.58 250.36 0 top
NOREF#2278  -  []  382.38 194.45 0 top
NOREF#2279  -  []  215.36 320.7 90 top
NOREF#2280  -  []  313.28 291.15 90 top
NOREF#2281  -  []  540.2 266.78 0 top
NOREF#2282  -  []  414.28 269.42 0 top
NOREF#2283  -  []  353.1 194.29 0 top
NOREF#2284  -  []  228.44 319.3 90 top
NOREF#2285  -  []  312.1 239.83 0 top
NOREF#2286  -  []  420.33 330.81 0 top
NOREF#2287  -  []  354.63 400.89 90 top
NOREF#2288  -  []  432.9 336.81 0 top
NOREF#2289  -  []  229.72 402.82 0 top
NOREF#2290  -  []  501.69 235.68 90 top
NOREF#2291  -  []  331.06 112.14 0 top
NOREF#2292  -  []  533.35 306.03 90 top
NOREF#2293  -  []  319.3 246.35 0 top
NOREF#2294  -  []  345.02 237.19 0 top
NOREF#2295  -  []  294.38 342.73 0 top
NOREF#2296  -  []  215.36 295.05 90 top
NOREF#2297  -  []  475.85 126.65 90 top
NOREF#2298  -  []  383.58 288.32 0 top
NOREF#2299  -  []  432.1 299.83 0 top
NOREF#2300  -  []  315.61 210.88 0 top
NOREF#2301  -  []  398.21 269.35 90 top
NOREF#2302  -  []  217.54 293.65 0 top
NOREF#2303  -  []  295.93 270.82 0 top
NOREF#2304  -  []  198.73 332.94 0 top
NOREF#2305  -  []  384.48 226.18 90 top
NOREF#2306  -  []  305.35 236.29 90 top
NOREF#2307  -  []  384.48 238.55 0 top
NOREF#2308  -  []  505.16 215.57 0 top
NOREF#2309  -  []  378.48 343.24 0 top
NOREF#2310  -  []  391.11 247.77 0 top
NOREF#2311  -  []  427.34 296.08 0 top
NOREF#2312  -  []  69.58 506.86 0 top
NOREF#2313  -  []  313.34 324.37 90 top
NOREF#2314  -  []  481.54 332.69 90 top
NOREF#2315  -  []  379.15 251.62 0 top
NOREF#2316  -  []  352.01 244.37 0 top
NOREF#2317  -  []  346.25 297.9 0 top
NOREF#2318  -  []  360.19 212.2 90 top
NOREF#2319  -  []  437.47 340.7 90 top
NOREF#2320  -  []  409.22 211.52 0 top
NOREF#2321  -  []  469.17 131.75 0 top
NOREF#2322  -  []  382.11 306.19 0 top
NOREF#2323  -  []  345.6 229.67 90 top
NOREF#2324  -  []  512.77 284.56 0 top
NOREF#2325  -  []  383.25 237.85 0 top
NOREF#2326  -  []  347.67 338.89 90 top
NOREF#2327  -  []  339.74 129.19 0 top
NOREF#2328  -  []  515.27 422.95 0 top
NOREF#2329  -  []  410.32 224.96 0 top
NOREF#2330  -  []  451.95 364.51 90 top
NOREF#2331  -  []  352.06 311.23 90 top
NOREF#2332  -  []  243.37 312.04 0 top
NOREF#2333  -  []  526.25 196.07 90 top
NOREF#2334  -  []  394.92 302.85 0 top
NOREF#2335  -  []  385.16 338.13 90 top
NOREF#2336  -  []  356.12 306.33 90 top
NOREF#2337  -  []  405.28 135.04 0 top
NOREF#2338  -  []  330.08 323.86 0 top
NOREF#2339  -  []  228.97 209.17 0 top
NOREF#2340  -  []  304.48 286.18 90 top
NOREF#2341  -  []  507.37 318.85 0 top
NOREF#2342  -  []  402.59 350.38 0 top
NOREF#2343  -  []  458.52 324.16 90 top
NOREF#2344  -  []  339.15 242.15 0 top
NOREF#2345  -  []  494.85 131.53 0 top
NOREF#2346  -  []  461.65 326.7 0 top
NOREF#2347  -  []  382.75 301.46 90 top
NOREF#2348  -  []  198.73 338.32 90 top
NOREF#2349  -  []  520.85 214.89 90 top
NOREF#2350  -  []  423.88 236.58 0 top
NOREF#2351  -  []  43.19 382.23 0 top
NOREF#2352  -  []  337.86 163.81 0 top
NOREF#2353  -  []  458.45 223.83 0 top
NOREF#2354  -  []  497.33 280.65 90 top
NOREF#2355  -  []  370.08 323.86 0 top
NOREF#2356  -  []  386.06 241.41 90 top
NOREF#2357  -  []  32.37 448.49 0 top
NOREF#2358  -  []  432.9 339.4 0 top
NOREF#2359  -  []  492.57 132.12 90 top
NOREF#2360  -  []  74.58 41.86 90 top
NOREF#2361  -  []  215.36 313.44 90 top
NOREF#2362  -  []  353 241.53 0 top
NOREF#2363  -  []  346.87 241.41 90 top
NOREF#2364  -  []  165.53 463.3 0 top
NOREF#2365  -  []  478.6 294.82 90 top
NOREF#2366  -  []  212.16 295.05 0 top
NOREF#2367  -  []  219.19 279.15 0 top
NOREF#2368  -  []  420.31 345.6 0 top
NOREF#2369  -  []  424.48 238.55 0 top
NOREF#2370  -  []  209.96 295.05 0 top
NOREF#2371  -  []  312 249.58 0 top
NOREF#2372  -  []  219.19 252.12 0 top
NOREF#2373  -  []  305.1 297.19 90 top
NOREF#2374  -  []  423.53 262.17 90 top
NOREF#2375  -  []  385.08 295.94 90 top
NOREF#2376  -  []  303.88 296.58 0 top
NOREF#2377  -  []  343.9 290.5 0 top
NOREF#2378  -  []  423.88 235.94 0 top
NOREF#2379  -  []  206.11 293.65 0 top
NOREF#2380  -  []  433.34 262.17 90 top
NOREF#2381  -  []  409.07 337.05 90 top
NOREF#2382  -  []  313.36 270.75 0 top
NOREF#2383  -  []  200.81 301.65 0 top
NOREF#2384  -  []  351.11 307.77 0 top
NOREF#2385  -  []  356.12 246.33 90 top
NOREF#2386  -  []  300.82 116.64 0 top
NOREF#2387  -  []  309.68 244.71 90 top
NOREF#2388  -  []  301.68 251.18 0 top
NOREF#2389  -  []  174.46 227.04 0 top
NOREF#2390  -  []  299.15 304.94 0 top
NOREF#2391  -  []  304.48 228 90 top
NOREF#2392  -  []  469.64 275.66 90 top
NOREF#2393  -  []  246.45 337.74 0 top
NOREF#2394  -  []  307.34 296.08 0 top
NOREF#2395  -  []  382.38 174.21 90 top
NOREF#2396  -  []  495.94 224.38 0 top
NOREF#2397  -  []  433.08 250.71 90 top
NOREF#2398  -  []  309.32 311.23 90 top
NOREF#2399  -  []  384.75 235.61 0 top
NOREF#2400  -  []  280.47 268.07 90 top
NOREF#2401  -  []  257.39 306.65 0 top
NOREF#2402  -  []  379.99 294.24 0 top
NOREF#2403  -  []  312.89 111.83 0 top
NOREF#2404  -  []  308.09 293.15 90 top
NOREF#2405  -  []  219.19 269.16 0 top
NOREF#2406  -  []  373.88 243.99 90 top
NOREF#2407  -  []  527.52 331.29 90 top
NOREF#2408  -  []  344.08 303.86 0 top
NOREF#2409  -  []  308.43 237.66 90 top
NOREF#2410  -  []  447.6 342.12 0 top
NOREF#2411  -  []  458.45 265.13 0 top
NOREF#2412  -  []  256.94 236.47 90 top
NOREF#2413  -  []  339.74 126.62 0 top
NOREF#2414  -  []  422.88 300.86 0 top
NOREF#2415  -  []  71.55 109.92 0 top
NOREF#2416  -  []  393 241.53 0 top
NOREF#2417  -  []  425.39 123.34 90 top
NOREF#2418  -  []  328.12 224.96 0 top
NOREF#2419  -  []  240.4 327.94 0 top
NOREF#2420  -  []  337.6 309.76 90 top
NOREF#2421  -  []  313.91 254.79 90 top
NOREF#2422  -  []  313.2 246.03 90 top
NOREF#2423  -  []  302.75 241.46 90 top
NOREF#2424  -  []  270.31 213 0 top
NOREF#2425  -  []  193.96 275.51 0 top
NOREF#2426  -  []  527.52 219.78 90 top
NOREF#2427  -  []  303.58 298.23 0 top
NOREF#2428  -  []  339.58 241.86 0 top
NOREF#2429  -  []  223.59 244.86 0 top
NOREF#2430  -  []  350.3 296.62 90 top
NOREF#2431  -  []  334.25 236.3 90 top
NOREF#2432  -  []  433.36 270.75 0 top
NOREF#2433  -  []  230.23 138.93 90 top
NOREF#2434  -  []  433.21 245.24 90 top
NOREF#2435  -  []  386.25 237.9 0 top
NOREF#2436  -  []  350.86 311.87 0 top
NOREF#2437  -  []  387.66 241.41 90 top
NOREF#2438  -  []  496.52 310.26 0 top
NOREF#2439  -  []  304.69 328.37 0 top
NOREF#2440  -  []  303.58 230.2 0 top
NOREF#2441  -  []  347.31 329.35 0 top
NOREF#2442  -  []  346.06 301.41 90 top
NOREF#2443  -  []  384.48 298.55 0 top
NOREF#2444  -  []  533.35 313.06 90 top
NOREF#2445  -  []  471.63 135.43 90 top
NOREF#2446  -  []  217.54 250.72 0 top
NOREF#2447  -  []  433.91 141.48 90 top
NOREF#2448  -  []  215.11 334.25 90 top
NOREF#2449  -  []  283.81 309.44 0 top
NOREF#2450  -  []  227.87 129.44 0 top
NOREF#2451  -  []  353.51 212.15 0 top
NOREF#2452  -  []  311.1 246.35 0 top
NOREF#2453  -  []  391.18 250.97 90 top
NOREF#2454  -  []  481.54 301.6 0 top
NOREF#2455  -  []  440.21 135.43 90 top
NOREF#2456  -  []  447.14 323.35 0 top
NOREF#2457  -  []  300.57 339.4 0 top
NOREF#2458  -  []  198.73 218.64 0 top
NOREF#2459  -  []  386.85 237.41 0 top
NOREF#2460  -  []  393.34 324.37 90 top
NOREF#2461  -  []  322.08 291.86 90 top
NOREF#2462  -  []  425.33 213.2 90 top
NOREF#2463  -  []  494.89 140.81 0 top
NOREF#2464  -  []  347.53 311.22 90 top
NOREF#2465  -  []  463.34 210.93 90 top
NOREF#2466  -  []  352.14 231.95 0 top
NOREF#2467  -  []  214.51 266.2 90 top
NOREF#2468  -  []  435.22 242.53 0 top
NOREF#2469  -  []  224.12 148.08 90 top
NOREF#2470  -  []  432.71 315.43 0 top
NOREF#2471  -  []  353.57 117.51 90 top
NOREF#2472  -  []  332.85 242.61 0 top
NOREF#2473  -  []  245.02 252.12 0 top
NOREF#2474  -  []  327.08 326.86 0 top
NOREF#2475  -  []  288.39 212.09 90 top
NOREF#2476  -  []  431.8 239.51 0 top
NOREF#2477  -  []  294.88 328.37 0 top
NOREF#2478  -  []  300.48 251.19 0 top
NOREF#2479  -  []  293.06 250.84 90 top
NOREF#2480  -  []  432.1 301.21 0 top
NOREF#2481  -  []  423.25 237.85 0 top
NOREF#2482  -  []  345.15 335.54 90 top
NOREF#2483  -  []  383.53 262.17 90 top
NOREF#2484  -  []  331.05 303.74 0 top
NOREF#2485  -  []  402.68 267.2 0 top
NOREF#2486  -  []  426.65 250.96 90 top
NOREF#2487  -  []  384.76 229.66 0 top
NOREF#2488  -  []  386.65 250.96 90 top
NOREF#2489  -  []  291.81 117.49 0 top
NOREF#2490  -  []  312.08 239.36 90 top
NOREF#2491  -  []  388.39 301.41 90 top
NOREF#2492  -  []  294.38 234.16 90 top
NOREF#2493  -  []  428.48 311.23 90 top
NOREF#2494  -  []  419.67 233.34 90 top
NOREF#2495  -  []  419.15 242.15 0 top
NOREF#2496  -  []  285.55 124.98 90 top
NOREF#2497  -  []  463.65 145.48 0 top
NOREF#2498  -  []  513.16 419.09 0 top
NOREF#2499  -  []  273.15 209.17 0 top
NOREF#2500  -  []  312.81 336.38 90 top
NOREF#2501  -  []  362.68 327.2 0 top
NOREF#2502  -  []  47.62 402.86 90 top
NOREF#2503  -  []  430.94 291.37 90 top
NOREF#2504  -  []  198.73 246.88 90 top
NOREF#2505  -  []  481.54 271.37 90 top
NOREF#2506  -  []  327.66 250.84 0 top
NOREF#2507  -  []  469.16 304.66 90 top
NOREF#2508  -  []  414.28 329.41 0 top
NOREF#2509  -  []  288.08 264.86 0 top
NOREF#2510  -  []  362.08 321.86 0 top
NOREF#2511  -  []  343.35 297.91 90 top
NOREF#2512  -  []  522.65 264.65 0 top
NOREF#2513  -  []  402.68 327.2 90 top
NOREF#2514  -  []  504.66 211.38 90 top
NOREF#2515  -  []  311.11 307.77 0 top
NOREF#2516  -  []  423.53 319.97 90 top
NOREF#2517  -  []  351.5 307.42 0 top
NOREF#2518  -  []  380.35 250.98 90 top
NOREF#2519  -  []  345.78 229.14 90 top
NOREF#2520  -  []  367.3 162.77 0 top
NOREF#2521  -  []  345.01 229.28 0 top
NOREF#2522  -  []  286.69 267.61 90 top
NOREF#2523  -  []  380.4 336.69 90 top
NOREF#2524  -  []  242.05 303.45 0 top
NOREF#2525  -  []  507.37 292.96 0 top
NOREF#2526  -  []  383.31 247.25 90 top
NOREF#2527  -  []  270.31 288.59 0 top
NOREF#2528  -  []  288.08 227.86 90 top
NOREF#2529  -  []  71.55 446.92 0 top
NOREF#2530  -  []  345.65 295.93 0 top
NOREF#2531  -  []  345.33 213.2 90 top
NOREF#2532  -  []  350.59 415.7 90 top
NOREF#2533  -  []  388.08 233.38 90 top
NOREF#2534  -  []  193.96 218.36 0 top
NOREF#2535  -  []  219.19 320.7 0 top
NOREF#2536  -  []  396.56 330.75 90 top
NOREF#2537  -  []  507.37 250.27 0 top
NOREF#2538  -  []  345.08 308.86 0 top
NOREF#2539  -  []  200.81 213.4 90 top
NOREF#2540  -  []  268.11 315.87 0 top
NOREF#2541  -  []  530.67 321.81 90 top
NOREF#2542  -  []  402.13 266.4 90 top
NOREF#2543  -  []  419.15 304.94 0 top
NOREF#2544  -  []  536.7 338.11 0 top
NOREF#2545  -  []  340.58 341.97 0 top
NOREF#2546  -  []  329.39 419.09 0 top
NOREF#2547  -  []  494.15 401.56 90 top
NOREF#2548  -  []  435.61 210.88 0 top
NOREF#2549  -  []  343.32 254.56 90 top
NOREF#2550  -  []  437.46 126.65 90 top
NOREF#2551  -  []  352.06 192.6 90 top
NOREF#2552  -  []  387.29 298.22 0 top
NOREF#2553  -  []  303.9 290.5 0 top
NOREF#2554  -  []  439.59 308.7 90 top
NOREF#2555  -  []  342.75 241.46 90 top
NOREF#2556  -  []  277.36 280.18 90 top
NOREF#2557  -  []  447.6 225.23 0 top
NOREF#2558  -  []  275.71 261.31 90 top
NOREF#2559  -  []  380.58 336.81 0 top
NOREF#2560  -  []  351.5 247.42 0 top
NOREF#2561  -  []  389.32 251.23 90 top
NOREF#2562  -  []  495.94 301.6 0 top
NOREF#2563  -  []  310.86 251.87 0 top
NOREF#2564  -  []  355.22 305.28 0 top
NOREF#2565  -  []  308.84 232.33 0 top
NOREF#2566  -  []  309.74 287.14 0 top
NOREF#2567  -  []  207.76 226.47 0 top
NOREF#2568  -  []  314.92 245.6 0 top
NOREF#2569  -  []  332.72 375.64 0 top
NOREF#2570  -  []  530.15 286.36 0 top
NOREF#2571  -  []  50.38 410.8 90 top
NOREF#2572  -  []  71.55 109.92 0 top
NOREF#2573  -  []  393.51 212.15 0 top
NOREF#2574  -  []  324.75 245.55 0 top
NOREF#2575  -  []  353.51 217.31 0 top
NOREF#2576  -  []  507.37 229.82 90 top
NOREF#2577  -  []  198.73 310.08 0 top
NOREF#2578  -  []  391.8 298.66 0 top
NOREF#2579  -  []  484.74 233.02 0 top
NOREF#2580  -  []  348.07 237.2 90 top
NOREF#2581  -  []  245.02 313.44 0 top
NOREF#2582  -  []  189.36 312.27 0 top
NOREF#2583  -  []  307.73 238.21 0 top
NOREF#2584  -  []  353.08 302.66 90 top
NOREF#2585  -  []  533.35 326.68 90 top
NOREF#2586  -  []  387.23 298.3 0 top
NOREF#2587  -  []  290.08 263.86 0 top
NOREF#2588  -  []  254.27 209.17 90 top
NOREF#2589  -  []  272.51 254.3 0 top
NOREF#2590  -  []  69.58 46.86 0 top
NOREF#2591  -  []  496.52 337.29 0 top
NOREF#2592  -  []  270.31 322.88 0 top
NOREF#2593  -  []  533.35 244.48 90 top
NOREF#2594  -  []  432.88 130.48 0 top
NOREF#2595  -  []  419.58 301.86 0 top
NOREF#2596  -  []  310.6 307.1 0 top
NOREF#2597  -  []  345.68 249.03 0 top
NOREF#2598  -  []  389.54 237.24 0 top
NOREF#2599  -  []  379.08 218.86 90 top
NOREF#2600  -  []  507.37 264.11 90 top
NOREF#2601  -  []  223.59 210.57 0 top
NOREF#2602  -  []  429.74 227.14 0 top
NOREF#2603  -  []  352.01 305.88 0 top
NOREF#2604  -  []  189.36 266.55 0 top
NOREF#2605  -  []  425.4 251.86 0 top
NOREF#2606  -  []  422.12 255.2 0 top
NOREF#2607  -  []  524.45 253.23 90 top
NOREF#2608  -  []  348.39 301.41 90 top
NOREF#2609  -  []  300.35 240.82 90 top
NOREF#2610  -  []  323.81 249.44 0 top
NOREF#2611  -  []  347.29 298.22 0 top
NOREF#2612  -  []  303.58 290.2 0 top
NOREF#2613  -  []  389.74 232.01 0 top
NOREF#2614  -  []  527.86 420.38 90 top
NOREF#2615  -  []  352.1 299.83 0 top
NOREF#2616  -  []  326.22 208.02 90 top
NOREF#2617  -  []  391.5 307.42 0 top
NOREF#2618  -  []  367.95 300.15 90 top
NOREF#2619  -  []  425.68 237.27 90 top
NOREF#2620  -  []  425.6 229.67 90 top
NOREF#2621  -  []  369.9 130.42 90 top
NOREF#2622  -  []  425.08 235.3 90 top
NOREF#2623  -  []  412.85 302.61 0 top
NOREF#2624  -  []  76.55 43.42 90 top
NOREF#2625  -  []  304.48 309.03 0 top
NOREF#2626  -  []  272.76 347.4 0 top
NOREF#2627  -  []  387.6 250.97 90 top
NOREF#2628  -  []  433.34 319.97 90 top
NOREF#2629  -  []  221.39 269.16 0 top
NOREF#2630  -  []  407.95 300.15 90 top
NOREF#2631  -  []  336.07 421.68 90 top
NOREF#2632  -  []  385.68 289.22 90 top
NOREF#2633  -  []  339.58 301.86 0 top
NOREF#2634  -  []  328.12 218.6 0 top
NOREF#2635  -  []  387.19 242.05 0 top
NOREF#2636  -  []  302.88 300.86 0 top
NOREF#2637  -  []  352.71 315.43 0 top
NOREF#2638  -  []  353.91 254.79 90 top
NOREF#2639  -  []  342.75 301.46 90 top
NOREF#2640  -  []  345.68 237.27 90 top
NOREF#2641  -  []  496.52 260.07 0 top
NOREF#2642  -  []  281.35 377.58 90 top
NOREF#2643  -  []  463.85 272.14 0 top
NOREF#2644  -  []  497.33 212.07 90 top
NOREF#2645  -  []  283.19 275.44 0 top
NOREF#2646  -  []  478.43 403.62 0 top
NOREF#2647  -  []  422.41 306.51 0 top
NOREF#2648  -  []  289.86 250.84 0 top
NOREF#2649  -  []  425.36 229.28 0 top
NOREF#2650  -  []  241.58 87.36 0 top
NOREF#2651  -  []  469.4 279.46 0 top
NOREF#2652  -  []  382.75 300.26 90 top
NOREF#2653  -  []  484.51 250.27 0 top
NOREF#2654  -  []  524.7 218.59 0 top
NOREF#2655  -  []  382.54 162.77 0 top
NOREF#2656  -  []  522 274.57 0 top
NOREF#2657  -  []  235.02 320.7 0 top
NOREF#2658  -  []  355.61 213.47 0 top
NOREF#2659  -  []  446.07 178.22 0 top
NOREF#2660  -  []  229.98 336.72 0 top
NOREF#2661  -  []  398.17 337.05 0 top
NOREF#2662  -  []  321.41 117.56 90 top
NOREF#2663  -  []  447.6 300.82 0 top
NOREF#2664  -  []  389.12 292.03 0 top
NOREF#2665  -  []  434.92 306.97 0 top
NOREF#2666  -  []  538.95 228.42 90 top
NOREF#2667  -  []  257.39 238.07 0 top
NOREF#2668  -  []  522 308.86 0 top
NOREF#2669  -  []  522 343.15 0 top
NOREF#2670  -  []  440.2 280.94 90 top
NOREF#2671  -  []  383.58 194.29 0 top
NOREF#2672  -  []  383.58 290.2 0 top
NOREF#2673  -  []  471.8 326.75 90 top
NOREF#2674  -  []  312.71 255.43 0 top
NOREF#2675  -  []  527.07 278.39 90 top
NOREF#2676  -  []  349.54 297.24 0 top
NOREF#2677  -  []  516.09 262.71 90 top
NOREF#2678  -  []  344.86 302.05 0 top
NOREF#2679  -  []  338.25 251.94 0 top
NOREF#2680  -  []  332.13 208.35 90 top
NOREF#2681  -  []  471.8 258.17 90 top
NOREF#2682  -  []  345.72 250.96 90 top
NOREF#2683  -  []  249.42 252.12 0 top
NOREF#2684  -  []  307.06 298.91 90 top
NOREF#2685  -  []  382.54 162.12 90 top
NOREF#2686  -  []  342.93 207.71 90 top
NOREF#2687  -  []  384.9 226.88 0 top
NOREF#2688  -  []  384.08 243.86 0 top
NOREF#2689  -  []  208.28 231.91 90 top
NOREF#2690  -  []  436.56 270.75 90 top
NOREF#2691  -  []  384.45 237.2 90 top
NOREF#2692  -  []  468.6 319.55 0 top
NOREF#2693  -  []  298.25 245.26 0 top
NOREF#2694  -  []  378.25 303.15 0 top
NOREF#2695  -  []  382.88 300.86 0 top
NOREF#2696  -  []  387.06 298.91 90 top
NOREF#2697  -  []  299.23 126.62 0 top
NOREF#2698  -  []  304.45 297.19 90 top
NOREF#2699  -  []  381.78 158.37 90 top
NOREF#2700  -  []  391.8 239.51 0 top
NOREF#2701  -  []  469.64 241.37 90 top
NOREF#2702  -  []  235.02 329.34 0 top
NOREF#2703  -  []  244.25 269.16 0 top
NOREF#2704  -  []  235.02 303.45 0 top
NOREF#2705  -  []  264.76 239.97 0 top
NOREF#2706  -  []  272.51 247.29 0 top
NOREF#2707  -  []  384.45 297.19 90 top
NOREF#2708  -  []  385.73 168.64 90 top
NOREF#2709  -  []  292.2 144.68 0 top
NOREF#2710  -  []  371.05 243.75 0 top
NOREF#2711  -  []  200.81 227.04 90 top
NOREF#2712  -  []  353.21 307.45 90 top
NOREF#2713  -  []  476.15 420.39 0 top
NOREF#2714  -  []  344.48 298.55 0 top
NOREF#2715  -  []  340.58 336.81 0 top
NOREF#2716  -  []  478.43 403.62 90 top
NOREF#2717  -  []  485.09 275.97 0 top
NOREF#2718  -  []  336.66 194.45 0 top
NOREF#2719  -  []  341.19 233.6 90 top
NOREF#2720  -  []  200.81 261.33 90 top
NOREF#2721  -  []  421.79 123.34 0 top
NOREF#2722  -  []  434.2 301.74 90 top
NOREF#2723  -  []  221.39 252.12 0 top
NOREF#2724  -  []  430.94 286.5 90 top
NOREF#2725  -  []  311.8 238.66 0 top
NOREF#2726  -  []  524.2 301.6 0 top
NOREF#2727  -  []  244.25 329.34 0 top
NOREF#2728  -  []  251.3 225.07 90 top
NOREF#2729  -  []  473.66 294.36 0 top
NOREF#2730  -  []  533.26 401.56 90 top
NOREF#2731  -  []  324.92 218.6 0 top
NOREF#2732  -  []  536.7 292.39 0 top
NOREF#2733  -  []  372.51 111.35 0 top
NOREF#2734  -  []  351.9 179.21 0 top
NOREF#2735  -  []  393.08 310.71 90 top
NOREF#2736  -  []  351.3 173.61 90 top
NOREF#2737  -  []  71.55 48.42 0 top
NOREF#2738  -  []  420.35 303.64 90 top
NOREF#2739  -  []  478.6 233.25 90 top
NOREF#2740  -  []  462.13 144.68 0 top
NOREF#2741  -  []  305.13 229.66 0 top
NOREF#2742  -  []  530.15 309.22 0 top
NOREF#2743  -  []  71.55 48.42 0 top
NOREF#2744  -  []  339.15 244.94 0 top
NOREF#2745  -  []  384.48 289.87 0 top
NOREF#2746  -  []  71.55 446.92 0 top
NOREF#2747  -  []  314.07 226.36 0 top
NOREF#2748  -  []  306.7 285.88 90 top
NOREF#2749  -  []  304.48 249.01 0 top
NOREF#2750  -  []  241.17 406.82 90 top
NOREF#2751  -  []  189.36 232.26 0 top
NOREF#2752  -  []  311.18 310.97 90 top
NOREF#2753  -  []  425.4 311.86 0 top
NOREF#2754  -  []  481.54 264.11 90 top
NOREF#2755  -  []  510.57 343.15 0 top
NOREF#2756  -  []  381.68 311.19 0 top
NOREF#2757  -  []  422.88 300.86 90 top
NOREF#2758  -  []  381.19 233.6 90 top
NOREF#2759  -  []  413.88 243.99 90 top
NOREF#2760  -  []  250.94 273.96 0 top
NOREF#2761  -  []  359.64 318.32 90 top
NOREF#2762  -  []  424.48 226.18 90 top
NOREF#2763  -  []  286.89 336.37 0 top
NOREF#2764  -  []  458.45 333.71 0 top
NOREF#2765  -  []  478.6 226.24 90 top
NOREF#2766  -  []  295.67 240.69 90 top
NOREF#2767  -  []  354.92 306.97 0 top
NOREF#2768  -  []  432.12 293.7 0 top
NOREF#2769  -  []  501.34 240.28 0 top
NOREF#2770  -  []  432.14 291.95 0 top
NOREF#2771  -  []  304.48 229.88 0 top
NOREF#2772  -  []  487.71 224.38 0 top
NOREF#2773  -  []  462.33 330.35 90 top
