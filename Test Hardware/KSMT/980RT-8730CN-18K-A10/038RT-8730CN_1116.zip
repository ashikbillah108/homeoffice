# Allegro board 038RT-8730CN_1116.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#4047  -  []  428.09 293.15 90 top
NOREF#4048  -  []  299.58 241.86 0 top
NOREF#4049  -  []  473.66 320.25 0 top
NOREF#4050  -  []  443.94 345.19 0 top
NOREF#4051  -  []  351.23 326.4 0 top
NOREF#4052  -  []  200.81 244.5 0 top
NOREF#4053  -  []  359.3 306.35 0 top
NOREF#4054  -  []  499.14 258.67 0 top
NOREF#4055  -  []  388.12 288.85 0 top
NOREF#4056  -  []  387.6 310.97 90 top
NOREF#4057  -  []  343.53 324.37 90 top
NOREF#4058  -  []  518.8 237.08 90 top
NOREF#4059  -  []  304.48 249.03 0 top
NOREF#4060  -  []  379.15 241.46 0 top
NOREF#4061  -  []  352.1 301.21 0 top
NOREF#4062  -  []  510.57 258.67 0 top
NOREF#4063  -  []  428.54 294.54 0 top
NOREF#4064  -  []  460.18 123.34 0 top
NOREF#4065  -  []  433.91 137.08 90 top
NOREF#4066  -  []  307.34 236.08 0 top
NOREF#4067  -  []  340.19 402.82 90 top
NOREF#4068  -  []  533.35 260.31 90 top
NOREF#4069  -  []  442.14 211.22 0 top
NOREF#4070  -  []  230.62 320.7 0 top
NOREF#4071  -  []  407.95 237.95 90 top
NOREF#4072  -  []  336.82 175.41 90 top
NOREF#4073  -  []  230.62 210.57 0 top
NOREF#4074  -  []  394.92 242.85 0 top
NOREF#4075  -  []  480.72 421.68 90 top
NOREF#4076  -  []  439.59 248.7 90 top
NOREF#4077  -  []  504.66 279.96 90 top
NOREF#4078  -  []  515.27 420.39 0 top
NOREF#4079  -  []  495.94 315.65 90 top
NOREF#4080  -  []  409.47 132.6 0 top
NOREF#4081  -  []  486.94 343.15 0 top
NOREF#4082  -  []  311.33 377.33 0 top
NOREF#4083  -  []  346.87 297.85 0 top
NOREF#4084  -  []  205.88 266.2 0 top
NOREF#4085  -  []  257.39 340.94 0 top
NOREF#4086  -  []  331.5 422.95 0 top
NOREF#4087  -  []  305.08 248.86 0 top
NOREF#4088  -  []  381.19 293.6 90 top
NOREF#4089  -  []  421.08 238.36 0 top
NOREF#4090  -  []  319.08 314.86 0 top
NOREF#4091  -  []  499.58 466.36 90 top
NOREF#4092  -  []  340.4 336.69 90 top
NOREF#4093  -  []  484.51 284.56 0 top
NOREF#4094  -  []  422.39 123.86 0 top
NOREF#4095  -  []  370.32 224.96 0 top
NOREF#4096  -  []  433.51 212.15 0 top
NOREF#4097  -  []  209.96 226.47 0 top
NOREF#4098  -  []  382.75 241.46 90 top
NOREF#4099  -  []  309.44 292.33 90 top
NOREF#4100  -  []  390.86 311.87 0 top
NOREF#4101  -  []  481.54 240.28 0 top
NOREF#4102  -  []  270.31 261.31 0 top
NOREF#4103  -  []  429.74 233.89 90 top
NOREF#4104  -  []  512.77 233.02 0 top
NOREF#4105  -  []  345.58 289.16 90 top
NOREF#4106  -  []  334.38 234.16 90 top
NOREF#4107  -  []  363.58 87.36 0 top
NOREF#4108  -  []  295.4 141.48 90 top
NOREF#4109  -  []  392.01 245.88 0 top
NOREF#4110  -  []  429.74 292.01 0 top
NOREF#4111  -  []  221.39 217.83 0 top
NOREF#4112  -  []  362.03 210.89 0 top
NOREF#4113  -  []  322.02 338.45 0 top
NOREF#4114  -  []  433.2 306.03 90 top
NOREF#4115  -  []  433.28 291.15 90 top
NOREF#4116  -  []  533.35 221.62 90 top
NOREF#4117  -  []  507.37 240.28 0 top
NOREF#4118  -  []  277.36 225.62 90 top
NOREF#4119  -  []  193.96 338.59 90 top
NOREF#4120  -  []  246.45 269.16 0 top
NOREF#4121  -  []  379.08 278.86 90 top
NOREF#4122  -  []  350.58 243.36 90 top
NOREF#4123  -  []  423.58 226.5 0 top
NOREF#4124  -  []  380.35 242.19 90 top
NOREF#4125  -  []  423.35 237.91 90 top
NOREF#4126  -  []  389.85 237.94 90 top
NOREF#4127  -  []  385.35 296.29 90 top
NOREF#4128  -  []  538.95 235.68 90 top
NOREF#4129  -  []  357.01 131.53 0 top
NOREF#4130  -  []  394.07 226.36 0 top
NOREF#4131  -  []  228.44 250.72 90 top
NOREF#4132  -  []  399.59 308.7 90 top
NOREF#4133  -  []  440.19 212.2 90 top
NOREF#4134  -  []  488.75 415.3 90 top
NOREF#4135  -  []  501.69 297 90 top
NOREF#4136  -  []  328.08 264.86 0 top
NOREF#4137  -  []  221.39 279.15 0 top
NOREF#4138  -  []  362.68 332.6 90 top
NOREF#4139  -  []  310.32 291.39 90 top
NOREF#4140  -  []  383.98 118.96 0 top
NOREF#4141  -  []  383.31 307.25 90 top
NOREF#4142  -  []  382.12 255.2 0 top
NOREF#4143  -  []  310.97 293.86 90 top
NOREF#4144  -  []  414.38 259.56 0 top
NOREF#4145  -  []  417.09 124.98 90 top
NOREF#4146  -  []  461.98 125.38 90 top
NOREF#4147  -  []  332.56 125.38 90 top
NOREF#4148  -  []  281.22 333.22 0 top
NOREF#4149  -  []  270.81 268.81 0 top
NOREF#4150  -  []  211.51 265.67 0 top
NOREF#4151  -  []  338.13 330.81 0 top
NOREF#4152  -  []  279.3 246.35 0 top
NOREF#4153  -  []  352 309.58 0 top
NOREF#4154  -  []  493.39 131.53 90 top
NOREF#4155  -  []  528.27 287.52 0 top
NOREF#4156  -  []  453.44 334.16 0 top
NOREF#4157  -  []  538.95 297 90 top
NOREF#4158  -  []  287.53 121.65 0 top
NOREF#4159  -  []  326.06 124.98 90 top
NOREF#4160  -  []  386.46 242.05 0 top
NOREF#4161  -  []  308.44 310.97 90 top
NOREF#4162  -  []  198.73 275.79 0 top
NOREF#4163  -  []  351.11 247.77 0 top
NOREF#4164  -  []  481.54 233.02 0 top
NOREF#4165  -  []  530.67 287.52 90 top
NOREF#4166  -  []  458.45 326.7 0 top
NOREF#4167  -  []  385.07 280.36 90 top
NOREF#4168  -  []  336.66 189.45 90 top
NOREF#4169  -  []  427.08 246.86 0 top
NOREF#4170  -  []  501.34 318.85 0 top
NOREF#4171  -  []  351.9 163.97 0 top
NOREF#4172  -  []  305.91 126.65 90 top
NOREF#4173  -  []  287.9 339.93 90 top
NOREF#4174  -  []  288.98 339.54 90 top
NOREF#4175  -  []  388.09 293.15 90 top
NOREF#4176  -  []  473.66 217.38 0 top
NOREF#4177  -  []  355.25 168.64 90 top
NOREF#4178  -  []  276.71 271.88 0 top
NOREF#4179  -  []  431.8 299.51 0 top
NOREF#4180  -  []  432 246.67 0 top
NOREF#4181  -  []  351.3 164.57 0 top
NOREF#4182  -  []  433.51 217.31 0 top
NOREF#4183  -  []  437.46 129.21 90 top
NOREF#4184  -  []  217.01 319.3 90 top
NOREF#4185  -  []  200.81 313.08 0 top
NOREF#4186  -  []  304.86 242.05 0 top
NOREF#4187  -  []  517.55 409.02 90 top
NOREF#4188  -  []  69.58 46.86 0 top
NOREF#4189  -  []  385.4 311.86 0 top
NOREF#4190  -  []  493.39 131.53 0 top
NOREF#4191  -  []  272.26 209.17 0 top
NOREF#4192  -  []  433.44 293.48 90 top
NOREF#4193  -  []  349.44 232.33 90 top
NOREF#4194  -  []  425.77 229.16 90 top
NOREF#4195  -  []  507.95 303 0 top
NOREF#4196  -  []  363.52 117.51 90 top
NOREF#4197  -  []  299.08 218.86 90 top
NOREF#4198  -  []  388.2 296.49 0 top
NOREF#4199  -  []  344.86 242.05 0 top
NOREF#4200  -  []  524.7 321.46 0 top
NOREF#4201  -  []  342.98 236.26 0 top
NOREF#4202  -  []  351.11 245.56 0 top
NOREF#4203  -  []  245.02 210.57 0 top
NOREF#4204  -  []  382.54 178.01 0 top
NOREF#4205  -  []  351.81 315.75 0 top
NOREF#4206  -  []  299.67 293.34 90 top
NOREF#4207  -  []  533.35 290.19 90 top
NOREF#4208  -  []  308.54 294.54 0 top
NOREF#4209  -  []  507.37 339.95 90 top
NOREF#4210  -  []  383.58 287.38 0 top
NOREF#4211  -  []  375.93 270.82 0 top
NOREF#4212  -  []  422.15 298.55 0 top
NOREF#4213  -  []  434.92 242.85 0 top
NOREF#4214  -  []  307.86 168.91 90 top
NOREF#4215  -  []  383.58 298.23 0 top
NOREF#4216  -  []  383.9 230.5 0 top
NOREF#4217  -  []  385.16 340.7 90 top
NOREF#4218  -  []  58.12 429.85 90 top
NOREF#4219  -  []  316.56 270.75 90 top
NOREF#4220  -  []  336.82 177.36 90 top
NOREF#4221  -  []  423.58 296.95 90 top
NOREF#4222  -  []  410.33 219.4 0 top
NOREF#4223  -  []  435.22 246.65 0 top
NOREF#4224  -  []  302.88 300.86 0 top
NOREF#4225  -  []  277.36 294.2 90 top
NOREF#4226  -  []  418.13 330.81 0 top
NOREF#4227  -  []  223.59 260.76 0 top
NOREF#4228  -  []  313 301.53 0 top
NOREF#4229  -  []  182.93 0 90 top
NOREF#4230  -  []  367.08 286.86 90 top
NOREF#4231  -  []  258.32 272.36 0 top
NOREF#4232  -  []  347.08 246.86 0 top
NOREF#4233  -  []  345.68 297.91 90 top
NOREF#4234  -  []  469.9 223.48 0 top
NOREF#4235  -  []  299.23 129.19 0 top
NOREF#4236  -  []  392.71 255.43 0 top
NOREF#4237  -  []  327.08 266.86 0 top
NOREF#4238  -  []  258.32 238.07 0 top
NOREF#4239  -  []  322.68 272.6 90 top
NOREF#4240  -  []  528.27 218.94 0 top
NOREF#4241  -  []  423.58 228.32 90 top
NOREF#4242  -  []  382.98 236.26 0 top
NOREF#4243  -  []  307.08 306.86 0 top
NOREF#4244  -  []  380.35 310.97 90 top
NOREF#4245  -  []  362.02 338.45 0 top
NOREF#4246  -  []  427.66 233.29 0 top
NOREF#4247  -  []  517.58 87.36 0 top
NOREF#4248  -  []  200.81 290.22 90 top
NOREF#4249  -  []  421.08 311.06 0 top
NOREF#4250  -  []  277.36 218.61 90 top
NOREF#4251  -  []  200.26 289.41 90 top
NOREF#4252  -  []  247.22 286.41 0 top
NOREF#4253  -  []  353.45 293.48 90 top
NOREF#4254  -  []  245.73 424.44 0 top
NOREF#4255  -  []  591.83 113.32 90 top
NOREF#4256  -  []  217.54 277.75 0 top
NOREF#4257  -  []  481.54 343.15 0 top
NOREF#4258  -  []  287.08 326.86 0 top
NOREF#4259  -  []  244.25 337.74 0 top
NOREF#4260  -  []  419.15 301.46 0 top
NOREF#4261  -  []  433 298.02 90 top
NOREF#4262  -  []  217.54 312.04 0 top
NOREF#4263  -  []  309.08 248.46 90 top
NOREF#4264  -  []  226.79 337.74 90 top
NOREF#4265  -  []  334.88 268.37 0 top
NOREF#4266  -  []  284.98 329.41 90 top
NOREF#4267  -  []  346.42 126.65 90 top
NOREF#4268  -  []  303.53 322.17 90 top
NOREF#4269  -  []  425.1 237.2 90 top
NOREF#4270  -  []  524.2 274.57 0 top
NOREF#4271  -  []  526.25 264.65 90 top
NOREF#4272  -  []  336.06 173.61 90 top
NOREF#4273  -  []  504.66 288.36 90 top
NOREF#4274  -  []  354.92 245.6 0 top
NOREF#4275  -  []  447.86 132.6 0 top
NOREF#4276  -  []  324.08 229.86 90 top
NOREF#4277  -  []  418.98 215.4 90 top
NOREF#4278  -  []  219.19 210.57 0 top
NOREF#4279  -  []  289.58 488.36 0 top
NOREF#4280  -  []  432.71 255.43 0 top
NOREF#4281  -  []  343.88 295.94 0 top
NOREF#4282  -  []  429.85 297.94 90 top
NOREF#4283  -  []  430.86 251.87 0 top
NOREF#4284  -  []  174.46 215.61 0 top
NOREF#4285  -  []  256.21 239.34 0 top
NOREF#4286  -  []  394.2 300.89 90 top
NOREF#4287  -  []  287.53 121.65 0 top
NOREF#4288  -  []  290.08 229.86 90 top
NOREF#4289  -  []  487.71 318.85 0 top
NOREF#4290  -  []  538.95 338.55 90 top
NOREF#4291  -  []  432.1 238.98 0 top
NOREF#4292  -  []  400.19 212.2 90 top
NOREF#4293  -  []  383.28 286.82 0 top
NOREF#4294  -  []  302.12 255.2 0 top
NOREF#4295  -  []  299.08 274.86 0 top
NOREF#4296  -  []  426.7 225.88 90 top
NOREF#4297  -  []  308.2 236.49 0 top
NOREF#4298  -  []  200.26 300.84 90 top
NOREF#4299  -  []  427.44 233.68 0 top
NOREF#4300  -  []  501.69 331.29 90 top
NOREF#4301  -  []  423.53 264.37 90 top
NOREF#4302  -  []  424.08 308.86 90 top
NOREF#4303  -  []  381.83 237.65 90 top
NOREF#4304  -  []  539.65 254.26 90 top
NOREF#4305  -  []  396.12 306.33 90 top
NOREF#4306  -  []  392.1 242.06 0 top
NOREF#4307  -  []  367.3 190.65 90 top
NOREF#4308  -  []  311.67 213.21 90 top
NOREF#4309  -  []  522.05 253.23 0 top
NOREF#4310  -  []  374.71 309.44 90 top
NOREF#4311  -  []  388.44 310.97 90 top
NOREF#4312  -  []  447.9 270.43 0 top
NOREF#4313  -  []  200.81 324.51 90 top
NOREF#4314  -  []  383.58 163.81 0 top
NOREF#4315  -  []  258.32 340.94 0 top
NOREF#4316  -  []  533.35 255.91 90 top
NOREF#4317  -  []  377.58 65.36 90 top
NOREF#4318  -  []  304.48 297.91 0 top
NOREF#4319  -  []  241.66 130.42 90 top
NOREF#4320  -  []  300.57 336.81 0 top
NOREF#4321  -  []  342.88 300.86 90 top
NOREF#4322  -  []  527.07 209.81 90 top
NOREF#4323  -  []  527.07 244.1 90 top
NOREF#4324  -  []  270.81 234.52 0 top
NOREF#4325  -  []  302.98 296.26 0 top
NOREF#4326  -  []  391.15 240.26 0 top
NOREF#4327  -  []  421.83 237.65 90 top
NOREF#4328  -  []  527.52 262.71 90 top
NOREF#4329  -  []  217.01 285.01 90 top
NOREF#4330  -  []  200.81 249.9 90 top
NOREF#4331  -  []  212.16 210.57 0 top
NOREF#4332  -  []  391.8 299.51 0 top
NOREF#4333  -  []  506.28 130.42 90 top
NOREF#4334  -  []  309.74 293.89 90 top
NOREF#4335  -  []  385.01 289.28 0 top
NOREF#4336  -  []  495.94 327.25 0 top
NOREF#4337  -  []  283.81 249.44 0 top
NOREF#4338  -  []  44.66 398.1 90 top
NOREF#4339  -  []  380.48 311.19 0 top
NOREF#4340  -  []  358.47 138.93 90 top
NOREF#4341  -  []  270.81 274.21 90 top
NOREF#4342  -  []  305.78 289.41 90 top
NOREF#4343  -  []  261.25 334.69 90 top
NOREF#4344  -  []  198.73 224.02 90 top
NOREF#4345  -  []  312.08 239.36 90 top
NOREF#4346  -  []  221.39 286.41 0 top
NOREF#4347  -  []  353.28 291.15 90 top
NOREF#4348  -  []  393.44 233.48 90 top
NOREF#4349  -  []  589.33 129.82 0 top
NOREF#4350  -  []  395.61 216.04 0 top
NOREF#4351  -  []  540.2 204.13 90 top
NOREF#4352  -  []  200.81 295.62 90 top
NOREF#4353  -  []  339.15 242.83 0 top
NOREF#4354  -  []  324.92 284.96 0 top
NOREF#4355  -  []  392.14 291.95 0 top
NOREF#4356  -  []  425.1 229.85 90 top
NOREF#4357  -  []  226.79 269.16 90 top
NOREF#4358  -  []  386.46 336.37 90 top
NOREF#4359  -  []  308.84 227.46 0 top
NOREF#4360  -  []  430.79 338.08 0 top
NOREF#4361  -  []  524.2 240.28 0 top
NOREF#4362  -  []  432 306.67 0 top
NOREF#4363  -  []  425.18 269.42 90 top
NOREF#4364  -  []  339.74 131.75 0 top
NOREF#4365  -  []  306.22 236.54 90 top
NOREF#4366  -  []  489.91 215.98 0 top
NOREF#4367  -  []  421.19 233.6 90 top
NOREF#4368  -  []  339.15 311.62 0 top
NOREF#4369  -  []  347.31 269.35 0 top
NOREF#4370  -  []  380.35 301.51 90 top
NOREF#4371  -  []  394.49 114.66 90 top
NOREF#4372  -  []  311.45 392 0 top
NOREF#4373  -  []  389.44 292.33 90 top
NOREF#4374  -  []  444.92 218.6 0 top
NOREF#4375  -  []  382.11 307.04 0 top
NOREF#4376  -  []  308.65 238.59 0 top
NOREF#4377  -  []  333.88 303.99 90 top
NOREF#4378  -  []  363.81 309.44 0 top
NOREF#4379  -  []  250.15 364.38 90 top
NOREF#4380  -  []  335.63 110.87 90 top
NOREF#4381  -  []  272.51 295.6 0 top
NOREF#4382  -  []  313.21 243.73 90 top
NOREF#4383  -  []  298.47 340.67 0 top
NOREF#4384  -  []  212.16 260.76 0 top
NOREF#4385  -  []  206.11 277.75 0 top
NOREF#4386  -  []  314.92 302.85 0 top
NOREF#4387  -  []  427.08 306.86 0 top
NOREF#4388  -  []  383.32 254.56 90 top
NOREF#4389  -  []  422.13 218.6 0 top
NOREF#4390  -  []  430.78 129.19 0 top
NOREF#4391  -  []  379.15 302.83 0 top
NOREF#4392  -  []  448.12 224.96 0 top
NOREF#4393  -  []  308.12 251.87 0 top
NOREF#4394  -  []  355.22 245.28 0 top
NOREF#4395  -  []  297.92 310.66 0 top
NOREF#4396  -  []  417.92 250.66 0 top
NOREF#4397  -  []  264.76 308.55 0 top
NOREF#4398  -  []  507.37 308.86 0 top
NOREF#4399  -  []  306.16 239.87 0 top
NOREF#4400  -  []  405.56 377.2 90 top
NOREF#4401  -  []  279.5 215.9 0 top
NOREF#4402  -  []  343.53 259.97 90 top
NOREF#4403  -  []  388.49 297.58 90 top
NOREF#4404  -  []  288.08 324.86 0 top
NOREF#4405  -  []  71.55 446.92 0 top
NOREF#4406  -  []  383.58 298.23 0 top
NOREF#4407  -  []  368.34 179.05 0 top
NOREF#4408  -  []  388.84 292.33 0 top
NOREF#4409  -  []  435.61 213.47 0 top
NOREF#4410  -  []  387.19 302.05 0 top
NOREF#4411  -  []  363.81 249.44 0 top
NOREF#4412  -  []  308.12 228.85 0 top
NOREF#4413  -  []  322.33 402.82 0 top
NOREF#4414  -  []  230.62 217.83 0 top
NOREF#4415  -  []  372.85 242.61 90 top
NOREF#4416  -  []  515.27 417.82 0 top
NOREF#4417  -  []  315.61 216.04 0 top
NOREF#4418  -  []  472.3 137.08 90 top
NOREF#4419  -  []  313.34 262.17 90 top
NOREF#4420  -  []  386.7 285.88 90 top
NOREF#4421  -  []  429.44 233.61 90 top
NOREF#4422  -  []  383.58 159.13 90 top
NOREF#4423  -  []  353 242.38 0 top
NOREF#4424  -  []  338.25 242.47 0 top
NOREF#4425  -  []  359.08 314.86 0 top
NOREF#4426  -  []  321.62 227.86 45 top
NOREF#4427  -  []  343.91 341.81 0 top
NOREF#4428  -  []  432.08 239.36 90 top
NOREF#4429  -  []  496.52 285.96 0 top
NOREF#4430  -  []  349.08 308.46 90 top
NOREF#4431  -  []  538.95 331.29 90 top
NOREF#4432  -  []  266.46 225.62 0 top
NOREF#4433  -  []  442.11 277.77 0 top
NOREF#4434  -  []  516.09 219.78 90 top
NOREF#4435  -  []  243.37 243.46 0 top
NOREF#4436  -  []  355.58 300.86 90 top
NOREF#4437  -  []  232.82 252.12 0 top
NOREF#4438  -  []  390.32 231.39 90 top
NOREF#4439  -  []  367.42 338.45 90 top
NOREF#4440  -  []  523.96 402.82 90 top
NOREF#4441  -  []  336.07 419.12 90 top
NOREF#4442  -  []  465.18 229.43 90 top
NOREF#4443  -  []  426.22 296.54 90 top
NOREF#4444  -  []  346.87 242.35 90 top
NOREF#4445  -  []  200.81 318.48 90 top
NOREF#4446  -  []  353.1 174.37 90 top
NOREF#4447  -  []  295.78 332.56 90 top
NOREF#4448  -  []  245.71 317.64 90 top
NOREF#4449  -  []  456.29 233.24 0 top
NOREF#4450  -  []  423.35 297.91 90 top
NOREF#4451  -  []  412.08 281.86 90 top
NOREF#4452  -  []  275.71 227.02 90 top
NOREF#4453  -  []  387.31 293.29 0 top
NOREF#4454  -  []  432.01 245.88 0 top
NOREF#4455  -  []  305.6 289.67 90 top
NOREF#4456  -  []  236.5 419.12 90 top
NOREF#4457  -  []  383.26 288.02 0 top
NOREF#4458  -  []  516.09 297 90 top
NOREF#4459  -  []  344.45 237.2 90 top
NOREF#4460  -  []  400.91 116.94 0 top
NOREF#4461  -  []  259.56 261.66 0 top
NOREF#4462  -  []  299.12 250.02 90 top
NOREF#4463  -  []  442.02 338.45 0 top
NOREF#4464  -  []  353.21 305.24 90 top
NOREF#4465  -  []  510.57 292.96 0 top
NOREF#4466  -  []  322.68 267.2 90 top
NOREF#4467  -  []  389.68 244.71 90 top
NOREF#4468  -  []  207.08 267.71 90 top
NOREF#4469  -  []  412.11 339.16 90 top
NOREF#4470  -  []  423.58 230.2 0 top
NOREF#4471  -  []  327.66 310.84 0 top
NOREF#4472  -  []  420.35 241.51 90 top
NOREF#4473  -  []  519.84 416.55 90 top
NOREF#4474  -  []  305.86 239.55 0 top
NOREF#4475  -  []  419.15 244.94 0 top
NOREF#4476  -  []  290.08 229.86 90 top
NOREF#4477  -  []  382.54 192.6 90 top
NOREF#4478  -  []  392.01 244.37 0 top
NOREF#4479  -  []  422.98 236.26 0 top
NOREF#4480  -  []  396.12 304.96 90 top
NOREF#4481  -  []  408.12 218.6 0 top
NOREF#4482  -  []  427.89 233.18 90 top
NOREF#4483  -  []  358.47 331.9 90 top
NOREF#4484  -  []  522.83 169.04 90 top
NOREF#4485  -  []  299.23 126.62 0 top
NOREF#4486  -  []  362.68 327.2 90 top
NOREF#4487  -  []  271.8 213.97 0 top
NOREF#4488  -  []  388.43 237.66 90 top
NOREF#4489  -  []  408.08 324.86 0 top
NOREF#4490  -  []  345.67 242.05 0 top
NOREF#4491  -  []  349.44 233.61 90 top
NOREF#4492  -  []  432.7 246.78 90 top
NOREF#4493  -  []  389.54 297.24 0 top
NOREF#4494  -  []  519.84 421.68 90 top
NOREF#4495  -  []  330.08 229.86 90 top
NOREF#4496  -  []  347.31 293.29 0 top
NOREF#4497  -  []  308.59 288.35 0 top
NOREF#4498  -  []  385.53 194.29 0 top
NOREF#4499  -  []  239.87 250.72 90 top
NOREF#4500  -  []  306.37 237.89 0 top
NOREF#4501  -  []  200.81 335.94 90 top
NOREF#4502  -  []  242.05 269.16 0 top
NOREF#4503  -  []  463.34 213.13 90 top
NOREF#4504  -  []  345.86 239.55 0 top
NOREF#4505  -  []  431.67 213.21 90 top
NOREF#4506  -  []  407.08 286.86 90 top
NOREF#4507  -  []  436.44 283.87 0 top
NOREF#4508  -  []  426.46 302.05 0 top
NOREF#4509  -  []  453.13 320.15 90 top
NOREF#4510  -  []  535.43 215.4 90 top
NOREF#4511  -  []  526.25 230.36 90 top
NOREF#4512  -  []  348.12 288.85 0 top
NOREF#4513  -  []  305.72 310.96 90 top
NOREF#4514  -  []  306.22 296.54 90 top
NOREF#4515  -  []  403.19 165.45 0 top
NOREF#4516  -  []  384.75 295.61 0 top
NOREF#4517  -  []  402.68 327.2 0 top
NOREF#4518  -  []  403.05 345.58 0 top
NOREF#4519  -  []  200.81 224.83 90 top
NOREF#4520  -  []  353.1 189.61 90 top
NOREF#4521  -  []  311.8 298.66 0 top
NOREF#4522  -  []  297.92 250.66 0 top
NOREF#4523  -  []  311.11 245.56 0 top
NOREF#4524  -  []  336.82 160.17 90 top
NOREF#4525  -  []  465.33 137.08 90 top
NOREF#4526  -  []  501.34 233.02 0 top
NOREF#4527  -  []  487.71 284.56 0 top
NOREF#4528  -  []  346.85 235.29 90 top
NOREF#4529  -  []  382.11 307.89 0 top
NOREF#4530  -  []  32.37 428.17 0 top
NOREF#4531  -  []  471.27 130.48 0 top
NOREF#4532  -  []  374.1 342.74 90 top
NOREF#4533  -  []  341.83 297.65 90 top
NOREF#4534  -  []  345.58 229.16 90 top
NOREF#4535  -  []  410.08 263.86 0 top
NOREF#4536  -  []  305.35 237.58 0 top
NOREF#4537  -  []  347.66 301.41 90 top
NOREF#4538  -  []  303.58 298.23 0 top
NOREF#4539  -  []  346.16 239.87 0 top
NOREF#4540  -  []  384.08 308.86 90 top
NOREF#4541  -  []  340.35 241.51 90 top
NOREF#4542  -  []  533.35 210.19 90 top
NOREF#4543  -  []  348.08 293.18 90 top
NOREF#4544  -  []  567.58 466.36 90 top
NOREF#4545  -  []  305.08 249.14 0 top
NOREF#4546  -  []  303.53 319.97 90 top
NOREF#4547  -  []  535.43 267.17 0 top
NOREF#4548  -  []  463.34 279.51 90 top
NOREF#4549  -  []  533.35 317.46 90 top
NOREF#4550  -  []  386.87 297.85 0 top
NOREF#4551  -  []  392.01 308.09 0 top
NOREF#4552  -  []  279.08 238.86 90 top
NOREF#4553  -  []  530.67 218.94 90 top
NOREF#4554  -  []  342.11 247.04 0 top
NOREF#4555  -  []  428.2 236.49 0 top
NOREF#4556  -  []  311.15 240.26 0 top
NOREF#4557  -  []  388.07 237.2 90 top
NOREF#4558  -  []  485.09 234.42 0 top
NOREF#4559  -  []  535.43 255.74 0 top
NOREF#4560  -  []  353.34 264.37 90 top
NOREF#4561  -  []  532.47 196.07 90 top
NOREF#4562  -  []  308.09 233.15 90 top
NOREF#4563  -  []  207.08 302 90 top
NOREF#4564  -  []  345.07 214 90 top
NOREF#4565  -  []  427.31 293.29 0 top
NOREF#4566  -  []  229.91 139.83 0 top
NOREF#4567  -  []  259.56 227.37 0 top
NOREF#4568  -  []  309.44 293.61 90 top
NOREF#4569  -  []  200.81 244.5 90 top
NOREF#4570  -  []  373.88 303.99 90 top
NOREF#4571  -  []  423.31 245.55 90 top
NOREF#4572  -  []  254.27 243.46 90 top
NOREF#4573  -  []  341.85 127.92 0 top
NOREF#4574  -  []  383.31 305.55 90 top
NOREF#4575  -  []  288.98 342.73 0 top
NOREF#4576  -  []  69.58 46.86 0 top
NOREF#4577  -  []  223.59 329.34 0 top
NOREF#4578  -  []  387.28 311.87 0 top
NOREF#4579  -  []  212.11 266.2 0 top
NOREF#4580  -  []  235.02 226.47 0 top
NOREF#4581  -  []  251.03 415.7 90 top
NOREF#4582  -  []  378.25 245.26 0 top
NOREF#4583  -  []  512.77 258.67 0 top
NOREF#4584  -  []  461.65 237.85 0 top
NOREF#4585  -  []  318.44 132.6 0 top
NOREF#4586  -  []  348.59 228.35 0 top
NOREF#4587  -  []  336.82 162.12 90 top
NOREF#4588  -  []  437.46 124.08 90 top
NOREF#4589  -  []  387.89 233.18 90 top
NOREF#4590  -  []  425.18 329.41 90 top
NOREF#4591  -  []  367.3 177.36 90 top
NOREF#4592  -  []  518.8 308.86 0 top
NOREF#4593  -  []  454.69 251.42 0 top
NOREF#4594  -  []  174.46 318.48 0 top
NOREF#4595  -  []  284.33 209.8 90 top
NOREF#4596  -  []  308.63 238.15 0 top
NOREF#4597  -  []  76.55 43.42 90 top
NOREF#4598  -  []  324.75 305.55 0 top
NOREF#4599  -  []  469.1 144.68 0 top
NOREF#4600  -  []  252.62 252.12 90 top
NOREF#4601  -  []  343.58 230.2 0 top
NOREF#4602  -  []  310.94 291.37 90 top
NOREF#4603  -  []  423.31 247.25 90 top
NOREF#4604  -  []  420.16 170.98 90 top
NOREF#4605  -  []  402.68 332.6 90 top
NOREF#4606  -  []  572.22 364.13 90 top
NOREF#4607  -  []  383.53 324.37 90 top
NOREF#4608  -  []  512.77 301.6 0 top
NOREF#4609  -  []  362.68 267.2 0 top
NOREF#4610  -  []  365.46 250.84 0 top
NOREF#4611  -  []  301.34 127.92 0 top
NOREF#4612  -  []  345.78 289.14 90 top
NOREF#4613  -  []  386.87 301.41 90 top
NOREF#4614  -  []  495.94 335.89 0 top
NOREF#4615  -  []  428.96 337.2 90 top
NOREF#4616  -  []  74.58 41.86 90 top
NOREF#4617  -  []  426.85 295.29 90 top
NOREF#4618  -  []  345.77 289.16 90 top
NOREF#4619  -  []  461.98 125.38 90 top
NOREF#4620  -  []  207.76 244.86 0 top
NOREF#4621  -  []  306.22 116.64 0 top
NOREF#4622  -  []  487.87 147.82 90 top
NOREF#4623  -  []  382.98 296.26 0 top
NOREF#4624  -  []  387.06 238.91 90 top
NOREF#4625  -  []  447.42 338.45 90 top
NOREF#4626  -  []  374.94 244.03 90 top
NOREF#4627  -  []  388.96 330.75 0 top
NOREF#4628  -  []  422.88 300.86 0 top
NOREF#4629  -  []  471.68 247.07 0 top
NOREF#4630  -  []  69.58 506.86 0 top
NOREF#4631  -  []  536.7 303.82 0 top
NOREF#4632  -  []  374.04 113.39 0 top
NOREF#4633  -  []  342.12 315.2 0 top
NOREF#4634  -  []  299.16 144.68 0 top
NOREF#4635  -  []  382.88 240.86 0 top
NOREF#4636  -  []  434.92 246.97 0 top
NOREF#4637  -  []  198.73 258.31 90 top
NOREF#4638  -  []  331.06 115.19 0 top
NOREF#4639  -  []  469.64 207.08 90 top
NOREF#4640  -  []  339.99 294.24 0 top
NOREF#4641  -  []  528.87 264.65 0 top
NOREF#4642  -  []  527.86 415.3 90 top
NOREF#4643  -  []  262.37 319.24 90 top
NOREF#4644  -  []  442.68 270.4 90 top
NOREF#4645  -  []  401.62 287.86 45 top
NOREF#4646  -  []  385.78 229.14 90 top
NOREF#4647  -  []  383.58 289.6 90 top
NOREF#4648  -  []  44.66 406.99 0 top
NOREF#4649  -  []  217.01 216.43 90 top
NOREF#4650  -  []  268.11 281.58 0 top
NOREF#4651  -  []  443.12 281.33 90 top
NOREF#4652  -  []  348.08 233.18 90 top
NOREF#4653  -  []  244.25 303.45 0 top
NOREF#4654  -  []  308.48 251.23 90 top
NOREF#4655  -  []  292.11 303.78 0 top
NOREF#4656  -  []  432.61 288.79 0 top
NOREF#4657  -  []  193.96 304.3 90 top
NOREF#4658  -  []  417.6 309.76 90 top
NOREF#4659  -  []  314.92 306.97 0 top
NOREF#4660  -  []  344.75 295.61 0 top
NOREF#4661  -  []  332.08 281.86 90 top
NOREF#4662  -  []  343.88 235.94 0 top
NOREF#4663  -  []  261.1 284.95 0 top
NOREF#4664  -  []  174.46 261.33 0 top
NOREF#4665  -  []  431.11 245.56 0 top
NOREF#4666  -  []  348.39 241.41 90 top
NOREF#4667  -  []  312.25 294.12 0 top
NOREF#4668  -  []  390.58 303.36 90 top
NOREF#4669  -  []  287.95 297.95 90 top
NOREF#4670  -  []  365.46 310.84 0 top
NOREF#4671  -  []  330.33 219.4 0 top
NOREF#4672  -  []  425.68 297.91 90 top
NOREF#4673  -  []  313.34 319.97 90 top
NOREF#4674  -  []  305.78 229.41 90 top
NOREF#4675  -  []  426.14 302.35 90 top
NOREF#4676  -  []  336.07 419.12 90 top
NOREF#4677  -  []  387.29 238.22 0 top
NOREF#4678  -  []  424.86 302.05 0 top
NOREF#4679  -  []  522.05 218.94 0 top
NOREF#4680  -  []  495.94 298.4 90 top
NOREF#4681  -  []  507.37 233.02 0 top
NOREF#4682  -  []  463.18 123.86 90 top
NOREF#4683  -  []  391.1 306.35 0 top
NOREF#4684  -  []  425.78 289.41 90 top
NOREF#4685  -  []  200.81 335.94 0 top
NOREF#4686  -  []  362.13 326.4 90 top
NOREF#4687  -  []  382.41 248.21 0 top
NOREF#4688  -  []  353.51 212.15 0 top
NOREF#4689  -  []  298.25 241.78 0 top
NOREF#4690  -  []  383.88 235.94 0 top
NOREF#4691  -  []  374.94 304.03 90 top
NOREF#4692  -  []  295.4 137.08 90 top
NOREF#4693  -  []  246.45 234.87 0 top
NOREF#4694  -  []  533.35 246.67 90 top
NOREF#4695  -  []  463.78 123.34 90 top
NOREF#4696  -  []  512.77 274.57 0 top
NOREF#4697  -  []  519.34 122.62 90 top
NOREF#4698  -  []  338.47 343.24 0 top
NOREF#4699  -  []  374.28 269.42 0 top
NOREF#4700  -  []  510.57 318.85 0 top
NOREF#4701  -  []  437.97 209.36 90 top
NOREF#4702  -  []  495.94 271.37 90 top
NOREF#4703  -  []  425.36 289.28 0 top
NOREF#4704  -  []  343.28 228.64 0 top
NOREF#4705  -  []  232.82 226.47 0 top
NOREF#4706  -  []  533.35 324.49 90 top
NOREF#4707  -  []  382.38 189.45 90 top
NOREF#4708  -  []  386.37 297.89 0 top
NOREF#4709  -  []  193.96 298.37 0 top
NOREF#4710  -  []  339.08 334.86 0 top
NOREF#4711  -  []  402.75 209.62 0 top
NOREF#4712  -  []  424.48 297.91 0 top
NOREF#4713  -  []  486.94 240.28 0 top
NOREF#4714  -  []  497.79 282.25 0 top
NOREF#4715  -  []  387.06 293.68 0 top
NOREF#4716  -  []  342.11 307.89 0 top
NOREF#4717  -  []  535.43 301.46 0 top
NOREF#4718  -  []  336.06 179.81 0 top
NOREF#4719  -  []  495.94 332.69 90 top
NOREF#4720  -  []  225.15 375.38 0 top
NOREF#4721  -  []  349.5 401.56 90 top
NOREF#4722  -  []  256.94 305.05 90 top
NOREF#4723  -  []  308.84 292.33 0 top
NOREF#4724  -  []  333.88 243.99 90 top
NOREF#4725  -  []  533.35 223.81 90 top
NOREF#4726  -  []  393.2 248.94 90 top
NOREF#4727  -  []  399.84 179.87 0 top
NOREF#4728  -  []  302.41 306.51 0 top
NOREF#4729  -  []  348.07 297.2 90 top
NOREF#4730  -  []  351.48 232.15 0 top
NOREF#4731  -  []  349.54 237.24 0 top
NOREF#4732  -  []  307.73 298.21 0 top
NOREF#4733  -  []  516.09 254.07 90 top
NOREF#4734  -  []  448.46 229.74 90 top
NOREF#4735  -  []  352.7 246.78 90 top
NOREF#4736  -  []  235.02 217.83 0 top
NOREF#4737  -  []  299.58 241.86 0 top
NOREF#4738  -  []  427.91 233.69 90 top
NOREF#4739  -  []  391.48 292.15 0 top
NOREF#4740  -  []  384.08 248.86 90 top
NOREF#4741  -  []  438.21 269.35 90 top
NOREF#4742  -  []  206.11 327.94 0 top
NOREF#4743  -  []  374.38 259.56 0 top
NOREF#4744  -  []  567.58 65.36 90 top
NOREF#4745  -  []  351.15 240.26 0 top
NOREF#4746  -  []  200.81 290.22 0 top
NOREF#4747  -  []  501.34 274.57 0 top
NOREF#4748  -  []  292.18 342.73 0 top
NOREF#4749  -  []  308.47 218.61 0 top
NOREF#4750  -  []  341.68 251.19 0 top
NOREF#4751  -  []  315.61 210.88 0 top
NOREF#4752  -  []  425.08 308.86 0 top
NOREF#4753  -  []  71.55 48.42 0 top
NOREF#4754  -  []  299.08 274.86 0 top
NOREF#4755  -  []  338.25 311.94 0 top
NOREF#4756  -  []  352 246.67 0 top
NOREF#4757  -  []  418.25 305.26 0 top
NOREF#4758  -  []  345.68 309.03 0 top
NOREF#4759  -  []  326.29 110.87 90 top
NOREF#4760  -  []  303.53 324.37 90 top
NOREF#4761  -  []  399.82 338.45 0 top
NOREF#4762  -  []  423.75 144.68 0 top
NOREF#4763  -  []  344.45 297.19 90 top
NOREF#4764  -  []  234.21 403.62 90 top
NOREF#4765  -  []  352.1 238.98 0 top
NOREF#4766  -  []  476.15 422.95 0 top
NOREF#4767  -  []  433.51 214.74 0 top
NOREF#4768  -  []  518.8 264.11 90 top
NOREF#4769  -  []  298.47 343.24 0 top
NOREF#4770  -  []  393.08 242.66 90 top
NOREF#4771  -  []  432.1 239.83 0 top
NOREF#4772  -  []  419.12 310.02 90 top
NOREF#4773  -  []  416.68 219.4 0 top
NOREF#4774  -  []  307.31 293.29 0 top
NOREF#4775  -  []  69.58 46.86 0 top
NOREF#4776  -  []  367.95 240.15 90 top
NOREF#4777  -  []  214.51 231.91 90 top
NOREF#4778  -  []  251.3 293.65 90 top
NOREF#4779  -  []  408.08 227.86 90 top
NOREF#4780  -  []  343.31 305.55 90 top
NOREF#4781  -  []  536.7 246.67 0 top
NOREF#4782  -  []  431.8 298.66 0 top
NOREF#4783  -  []  401.83 346.85 0 top
NOREF#4784  -  []  422.7 155.29 90 top
NOREF#4785  -  []  362.08 261.86 0 top
NOREF#4786  -  []  339.67 293.34 90 top
NOREF#4787  -  []  212.11 300.49 0 top
NOREF#4788  -  []  471.79 337.35 0 top
NOREF#4789  -  []  223.59 269.16 0 top
NOREF#4790  -  []  333.23 402.82 90 top
NOREF#4791  -  []  410.08 289.86 90 top
NOREF#4792  -  []  471.79 303.06 0 top
NOREF#4793  -  []  392 246.67 0 top
NOREF#4794  -  []  469.4 313.75 0 top
NOREF#4795  -  []  442.52 221.61 0 top
NOREF#4796  -  []  304.48 237.91 0 top
NOREF#4797  -  []  471.23 251.87 0 top
NOREF#4798  -  []  387.01 337.17 0 top
NOREF#4799  -  []  302.88 240.86 90 top
NOREF#4800  -  []  507.37 289.76 90 top
NOREF#4801  -  []  432.01 248.09 0 top
NOREF#4802  -  []  212.16 286.41 0 top
NOREF#4803  -  []  303.28 226.82 0 top
NOREF#4804  -  []  447.77 340.26 0 top
NOREF#4805  -  []  478.29 207.07 90 top
NOREF#4806  -  []  174.46 238.47 0 top
NOREF#4807  -  []  378.25 244.6 0 top
NOREF#4808  -  []  318.44 132.6 0 top
NOREF#4809  -  []  221.39 329.34 0 top
NOREF#4810  -  []  247.22 210.57 0 top
NOREF#4811  -  []  444.92 221.76 90 top
NOREF#4812  -  []  321.71 112.14 0 top
NOREF#4813  -  []  343.31 307.25 90 top
NOREF#4814  -  []  315.61 213.47 0 top
NOREF#4815  -  []  475.85 126.65 90 top
NOREF#4816  -  []  362.68 270.4 90 top
NOREF#4817  -  []  313.08 250.71 90 top
NOREF#4818  -  []  237.72 268.78 90 top
NOREF#4819  -  []  76.55 43.42 90 top
NOREF#4820  -  []  311.45 392 90 top
NOREF#4821  -  []  295.67 240.69 0 top
NOREF#4822  -  []  50.38 419.69 0 top
NOREF#4823  -  []  389.68 304.71 90 top
NOREF#4824  -  []  427.53 311.22 90 top
NOREF#4825  -  []  335.91 137.08 90 top
NOREF#4826  -  []  313.2 306.03 90 top
NOREF#4827  -  []  377.92 310.66 0 top
NOREF#4828  -  []  319.64 318.32 90 top
NOREF#4829  -  []  327.56 209.62 0 top
NOREF#4830  -  []  388.44 250.97 90 top
NOREF#4831  -  []  519.84 419.12 90 top
NOREF#4832  -  []  423.26 288.02 0 top
NOREF#4833  -  []  219.19 234.87 0 top
NOREF#4834  -  []  346.65 250.96 90 top
NOREF#4835  -  []  387.31 233.29 0 top
NOREF#4836  -  []  231.93 422.95 0 top
NOREF#4837  -  []  311.1 306.35 0 top
NOREF#4838  -  []  385.68 237.91 90 top
NOREF#4839  -  []  512.43 127.81 0 top
NOREF#4840  -  []  350.94 291.37 90 top
NOREF#4841  -  []  510.57 308.86 0 top
NOREF#4842  -  []  362.61 117.24 0 top
NOREF#4843  -  []  427.08 246.86 90 top
NOREF#4844  -  []  343.58 288.32 90 top
NOREF#4845  -  []  527.52 211.38 90 top
NOREF#4846  -  []  200.26 266.55 90 top
NOREF#4847  -  []  387.08 306.86 0 top
NOREF#4848  -  []  497.83 180.04 0 top
NOREF#4849  -  []  536.7 280.96 0 top
NOREF#4850  -  []  44.66 416.52 90 top
NOREF#4851  -  []  439.82 338.45 0 top
NOREF#4852  -  []  345.35 296.29 90 top
NOREF#4853  -  []  425.07 214 90 top
NOREF#4854  -  []  501.28 140.92 0 top
NOREF#4855  -  []  221.39 210.57 0 top
NOREF#4856  -  []  424.48 286.18 90 top
NOREF#4857  -  []  402.02 338.45 0 top
NOREF#4858  -  []  314.2 240.89 90 top
NOREF#4859  -  []  390.6 307.1 0 top
NOREF#4860  -  []  336.82 193.25 0 top
NOREF#4861  -  []  414.01 335.99 0 top
NOREF#4862  -  []  348.84 232.33 0 top
NOREF#4863  -  []  350.14 327.57 0 top
NOREF#4864  -  []  313.34 264.37 90 top
NOREF#4865  -  []  540.2 312.5 0 top
NOREF#4866  -  []  327.26 145.48 0 top
NOREF#4867  -  []  477.22 282.96 90 top
NOREF#4868  -  []  327.95 240.15 90 top
NOREF#4869  -  []  507.37 215.98 0 top
NOREF#4870  -  []  331.5 420.39 0 top
NOREF#4871  -  []  523.06 425.76 90 top
NOREF#4872  -  []  352.25 294.12 0 top
NOREF#4873  -  []  426.87 241.41 90 top
NOREF#4874  -  []  294.38 319.56 0 top
NOREF#4875  -  []  331.5 422.95 0 top
NOREF#4876  -  []  198.73 315.46 90 top
NOREF#4877  -  []  344.46 227.38 90 top
NOREF#4878  -  []  241.17 409.02 90 top
NOREF#4879  -  []  423.58 236.95 90 top
NOREF#4880  -  []  272.51 315.87 0 top
NOREF#4881  -  []  425.02 297.19 0 top
NOREF#4882  -  []  459.67 122.54 90 top
NOREF#4883  -  []  343.31 245.55 90 top
NOREF#4884  -  []  295.93 330.81 0 top
NOREF#4885  -  []  372.08 281.86 90 top
NOREF#4886  -  []  200.81 278.79 90 top
NOREF#4887  -  []  221.39 234.87 0 top
NOREF#4888  -  []  391.18 310.97 90 top
NOREF#4889  -  []  330.32 218.6 0 top
NOREF#4890  -  []  447.7 232.61 0 top
NOREF#4891  -  []  540.2 249.85 90 top
NOREF#4892  -  []  494.53 139.83 0 top
NOREF#4893  -  []  226.79 226.47 90 top
NOREF#4894  -  []  313.45 293.48 90 top
NOREF#4895  -  []  330.08 263.86 0 top
NOREF#4896  -  []  219.19 226.47 0 top
NOREF#4897  -  []  316.56 330.75 90 top
NOREF#4898  -  []  393.2 306.03 90 top
NOREF#4899  -  []  498.71 282.25 0 top
NOREF#4900  -  []  307.08 246.86 0 top
NOREF#4901  -  []  472.03 322.2 0 top
NOREF#4902  -  []  306.87 301.41 90 top
NOREF#4903  -  []  71.55 48.42 0 top
NOREF#4904  -  []  234.21 403.62 0 top
NOREF#4905  -  []  55 414.31 0 top
NOREF#4906  -  []  198.73 304.03 90 top
NOREF#4907  -  []  259.36 302.3 0 top
NOREF#4908  -  []  212.16 217.83 0 top
NOREF#4909  -  []  212.16 252.12 0 top
NOREF#4910  -  []  330.9 345.94 0 top
NOREF#4911  -  []  212.16 226.47 0 top
NOREF#4912  -  []  332.11 243.78 0 top
NOREF#4913  -  []  436.12 242.21 90 top
NOREF#4914  -  []  349.08 304.86 90 top
NOREF#4915  -  []  449.81 231.34 0 top
NOREF#4916  -  []  383.58 174.37 90 top
NOREF#4917  -  []  348.09 233.15 90 top
NOREF#4918  -  []  243.37 209.17 0 top
NOREF#4919  -  []  200.26 255.12 90 top
NOREF#4920  -  []  423.28 226.82 0 top
NOREF#4921  -  []  506.1 402.82 0 top
NOREF#4922  -  []  380.58 339.4 0 top
NOREF#4923  -  []  524.2 233.02 0 top
NOREF#4924  -  []  507.95 344.55 0 top
NOREF#4925  -  []  336.82 178.01 0 top
NOREF#4926  -  []  312.06 311.23 90 top
NOREF#4927  -  []  345.6 289.67 90 top
NOREF#4928  -  []  470.43 214.05 0 top
NOREF#4929  -  []  359.08 254.86 0 top
NOREF#4930  -  []  349.74 287.14 0 top
NOREF#4931  -  []  239.87 302.05 90 top
NOREF#4932  -  []  424.48 288 90 top
NOREF#4933  -  []  251.3 267.76 90 top
NOREF#4934  -  []  432 309.58 0 top
NOREF#4935  -  []  432.12 233.7 0 top
NOREF#4936  -  []  374.88 328.37 0 top
NOREF#4937  -  []  343.58 238.23 0 top
NOREF#4938  -  []  424.45 297.19 90 top
NOREF#4939  -  []  313 238.87 90 top
NOREF#4940  -  []  307.19 242.05 0 top
NOREF#4941  -  []  447.6 232.24 0 top
NOREF#4942  -  []  382.95 122.62 90 top
NOREF#4943  -  []  477.11 280.09 90 top
NOREF#4944  -  []  388.12 228.85 0 top
NOREF#4945  -  []  310.3 296.62 90 top
NOREF#4946  -  []  478.43 409.02 90 top
NOREF#4947  -  []  303.31 247.25 90 top
NOREF#4948  -  []  314.2 300.89 90 top
NOREF#4949  -  []  422.11 306.19 0 top
NOREF#4950  -  []  424.75 235.61 0 top
NOREF#4951  -  []  209.96 320.7 0 top
NOREF#4952  -  []  524.7 241.45 0 top
NOREF#4953  -  []  235.02 295.05 0 top
NOREF#4954  -  []  383.28 288.64 0 top
NOREF#4955  -  []  341.83 237.65 90 top
NOREF#4956  -  []  331.5 420.39 0 top
NOREF#4957  -  []  342.41 306.51 0 top
NOREF#4958  -  []  311.16 330.75 0 top
NOREF#4959  -  []  254.71 122.62 90 top
NOREF#4960  -  []  389.4 295.85 90 top
NOREF#4961  -  []  291.58 466.36 90 top
NOREF#4962  -  []  307.29 298.22 0 top
NOREF#4963  -  []  390.3 236.62 90 top
NOREF#4964  -  []  343.58 296.95 90 top
NOREF#4965  -  []  432.1 302.06 0 top
NOREF#4966  -  []  415.93 270.82 0 top
NOREF#4967  -  []  312.71 315.43 0 top
NOREF#4968  -  []  342.98 296.26 0 top
NOREF#4969  -  []  387.01 340.37 90 top
NOREF#4970  -  []  386.16 299.87 0 top
NOREF#4971  -  []  478.6 336.12 90 top
NOREF#4972  -  []  470.69 268.71 0 top
NOREF#4973  -  []  346.33 311.86 0 top
NOREF#4974  -  []  384.48 286.18 90 top
NOREF#4975  -  []  343.58 229.6 90 top
NOREF#4976  -  []  533.35 335.92 90 top
NOREF#4977  -  []  391.11 307.77 0 top
NOREF#4978  -  []  465.07 214 90 top
NOREF#4979  -  []  478.6 260.53 90 top
NOREF#4980  -  []  393 302.38 0 top
NOREF#4981  -  []  507.37 324.05 90 top
NOREF#4982  -  []  384.48 288 90 top
NOREF#4983  -  []  409.65 339.87 90 top
NOREF#4984  -  []  310.94 231.37 90 top
NOREF#4985  -  []  443.67 135.04 0 top
NOREF#4986  -  []  431.16 270.75 0 top
NOREF#4987  -  []  478.43 406.82 90 top
NOREF#4988  -  []  431.8 238.66 0 top
NOREF#4989  -  []  311.8 239.51 0 top
NOREF#4990  -  []  428.09 293.43 90 top
NOREF#4991  -  []  305.36 229.28 0 top
NOREF#4992  -  []  231.93 420.39 0 top
NOREF#4993  -  []  280.36 338.66 90 top
NOREF#4994  -  []  485.09 260.07 0 top
NOREF#4995  -  []  423.28 286.82 0 top
NOREF#4996  -  []  335.91 139.28 90 top
NOREF#4997  -  []  379.12 310.02 90 top
NOREF#4998  -  []  540.2 221.06 0 top
NOREF#4999  -  []  359.82 338.45 0 top
NOREF#5000  -  []  428.43 297.66 90 top
NOREF#5001  -  []  246.45 329.34 0 top
NOREF#5002  -  []  71.55 109.92 0 top
NOREF#5003  -  []  217.54 259.36 0 top
NOREF#5004  -  []  383.58 296.95 90 top
NOREF#5005  -  []  339.15 241.46 0 top
NOREF#5006  -  []  348.96 270.75 0 top
NOREF#5007  -  []  507.37 267.31 0 top
NOREF#5008  -  []  440.19 209.61 90 top
NOREF#5009  -  []  425.35 296.29 90 top
NOREF#5010  -  []  240.62 402.82 90 top
NOREF#5011  -  []  465.07 220.36 90 top
NOREF#5012  -  []  393.34 264.37 90 top
NOREF#5013  -  []  251.3 327.94 90 top
NOREF#5014  -  []  309.44 233.61 90 top
NOREF#5015  -  []  374.28 329.41 0 top
NOREF#5016  -  []  293.71 145.48 0 top
NOREF#5017  -  []  11.45 390.13 90 top
NOREF#5018  -  []  232.82 217.83 0 top
NOREF#5019  -  []  388.59 288.35 0 top
NOREF#5020  -  []  413.88 303.99 90 top
NOREF#5021  -  []  458.45 268.94 90 top
NOREF#5022  -  []  389.92 227.85 90 top
NOREF#5023  -  []  311.15 300.26 0 top
NOREF#5024  -  []  419.67 293.34 90 top
NOREF#5025  -  []  450.39 275.06 0 top
NOREF#5026  -  []  259.73 333.75 90 top
NOREF#5027  -  []  527.52 297 90 top
NOREF#5028  -  []  383.35 237.91 90 top
NOREF#5029  -  []  232.82 210.57 0 top
NOREF#5030  -  []  310.6 247.1 0 top
NOREF#5031  -  []  307.53 311.22 90 top
NOREF#5032  -  []  163.41 413.04 90 top
NOREF#5033  -  []  339.81 179.05 0 top
NOREF#5034  -  []  436.8 390.1 90 top
NOREF#5035  -  []  497.58 87.36 0 top
NOREF#5036  -  []  362.4 438.26 0 top
NOREF#5037  -  []  352.08 239.36 90 top
NOREF#5038  -  []  383.53 264.37 90 top
NOREF#5039  -  []  435.22 302.53 0 top
NOREF#5040  -  []  435.22 245.28 0 top
NOREF#5041  -  []  337.86 159.13 90 top
NOREF#5042  -  []  383.58 189.61 90 top
NOREF#5043  -  []  241.58 488.36 0 top
NOREF#5044  -  []  540.2 272.71 90 top
NOREF#5045  -  []  215.36 226.47 90 top
NOREF#5046  -  []  54.74 390.13 90 top
NOREF#5047  -  []  316.12 302.21 90 top
NOREF#5048  -  []  346.42 124.08 90 top
NOREF#5049  -  []  495.94 292.96 0 top
NOREF#5050  -  []  472.3 139.28 90 top
NOREF#5051  -  []  513.16 424.22 0 top
NOREF#5052  -  []  522 233.02 0 top
NOREF#5053  -  []  401.86 209.62 0 top
NOREF#5054  -  []  471.68 281.36 0 top
NOREF#5055  -  []  527.52 245.67 90 top
NOREF#5056  -  []  275.71 329.89 90 top
NOREF#5057  -  []  46.95 400.01 0 top
NOREF#5058  -  []  432.88 127.92 0 top
NOREF#5059  -  []  303.31 246.4 90 top
NOREF#5060  -  []  203.76 377.07 90 top
NOREF#5061  -  []  485.09 241.68 0 top
NOREF#5062  -  []  292.08 331.86 0 top
NOREF#5063  -  []  53.55 431.12 0 top
NOREF#5064  -  []  307.66 301.41 90 top
NOREF#5065  -  []  310.65 311.73 0 top
NOREF#5066  -  []  447.6 328.1 0 top
NOREF#5067  -  []  402.68 270.4 90 top
NOREF#5068  -  []  429.08 244.86 90 top
NOREF#5069  -  []  485.09 251.67 0 top
NOREF#5070  -  []  316.12 306.33 90 top
NOREF#5071  -  []  298.13 330.81 0 top
NOREF#5072  -  []  304.48 288 90 top
NOREF#5073  -  []  350.94 231.37 90 top
NOREF#5074  -  []  388.96 270.75 0 top
NOREF#5075  -  []  447.6 239.25 0 top
NOREF#5076  -  []  303.58 226.5 0 top
NOREF#5077  -  []  189.36 323.7 0 top
NOREF#5078  -  []  71.55 109.92 0 top
NOREF#5079  -  []  314.07 220 0 top
NOREF#5080  -  []  470.69 241.68 0 top
NOREF#5081  -  []  304.9 226.88 0 top
NOREF#5082  -  []  270.81 239.92 90 top
NOREF#5083  -  []  364.92 221.76 90 top
NOREF#5084  -  []  345.08 295.94 90 top
NOREF#5085  -  []  484.51 221.18 90 top
NOREF#5086  -  []  69.58 506.86 0 top
NOREF#5087  -  []  378.25 311.94 0 top
NOREF#5088  -  []  381.08 311.06 0 top
NOREF#5089  -  []  387.01 337.17 90 top
NOREF#5090  -  []  393.36 337.18 90 top
NOREF#5091  -  []  429.54 297.24 0 top
NOREF#5092  -  []  387.45 297.26 90 top
NOREF#5093  -  []  426.25 237.9 0 top
NOREF#5094  -  []  217.01 209.17 90 top
NOREF#5095  -  []  303.32 314.56 90 top
NOREF#5096  -  []  352.06 160.17 90 top
NOREF#5097  -  []  212.16 320.7 0 top
NOREF#5098  -  []  239.87 319.3 90 top
NOREF#5099  -  []  318.08 295.86 90 top
NOREF#5100  -  []  434.92 245.6 0 top
NOREF#5101  -  []  388.08 293.18 90 top
NOREF#5102  -  []  435.58 240.86 90 top
NOREF#5103  -  []  480.72 419.12 90 top
NOREF#5104  -  []  236.66 140.92 0 top
NOREF#5105  -  []  430.32 291.39 90 top
NOREF#5106  -  []  254.27 285.01 90 top
NOREF#5107  -  []  427.66 293.29 0 top
NOREF#5108  -  []  349.74 232.01 0 top
NOREF#5109  -  []  344.08 308.86 90 top
NOREF#5110  -  []  390.94 286.5 90 top
NOREF#5111  -  []  340.35 243.64 90 top
NOREF#5112  -  []  315.22 305.28 0 top
NOREF#5113  -  []  422.98 236.26 0 top
NOREF#5114  -  []  422.7 169.71 90 top
NOREF#5115  -  []  422.15 238.55 0 top
NOREF#5116  -  []  298.47 338.08 0 top
NOREF#5117  -  []  380.35 243.64 90 top
NOREF#5118  -  []  314.74 112.48 90 top
NOREF#5119  -  []  344.69 268.37 0 top
NOREF#5120  -  []  524.2 343.15 0 top
NOREF#5121  -  []  351.18 310.97 90 top
NOREF#5122  -  []  343.58 287.38 0 top
NOREF#5123  -  []  425.08 248.86 0 top
NOREF#5124  -  []  487.71 258.67 0 top
NOREF#5125  -  []  352.06 193.25 0 top
NOREF#5126  -  []  422.41 307.36 0 top
NOREF#5127  -  []  200.81 221.64 90 top
NOREF#5128  -  []  345.02 297.19 0 top
NOREF#5129  -  []  343.9 297.84 0 top
NOREF#5130  -  []  400.19 209.61 90 top
NOREF#5131  -  []  308.08 293.38 90 top
NOREF#5132  -  []  227.94 132.12 90 top
NOREF#5133  -  []  428.63 238.15 0 top
NOREF#5134  -  []  230.62 295.05 0 top
NOREF#5135  -  []  353.21 303.73 90 top
NOREF#5136  -  []  304.08 248.86 90 top
NOREF#5137  -  []  273.74 135.04 0 top
NOREF#5138  -  []  487.71 250.27 0 top
NOREF#5139  -  []  270.81 306.3 90 top
NOREF#5140  -  []  423.58 228.32 0 top
NOREF#5141  -  []  435.02 241.03 0 top
NOREF#5142  -  []  501.34 301.6 0 top
NOREF#5143  -  []  268.11 213 0 top
NOREF#5144  -  []  351.48 292.15 0 top
NOREF#5145  -  []  235.02 244.86 0 top
NOREF#5146  -  []  316.21 252.13 0 top
NOREF#5147  -  []  535.43 295.41 90 top
NOREF#5148  -  []  348.49 237.58 90 top
NOREF#5149  -  []  245.02 244.86 0 top
NOREF#5150  -  []  481.54 267.31 0 top
NOREF#5151  -  []  412.11 338.27 90 top
NOREF#5152  -  []  346.22 236.54 90 top
NOREF#5153  -  []  252.62 286.41 90 top
NOREF#5154  -  []  174.46 272.76 0 top
NOREF#5155  -  []  41.87 386.95 90 top
NOREF#5156  -  []  393.21 245.24 90 top
NOREF#5157  -  []  424.76 289.66 0 top
NOREF#5158  -  []  367.08 276.86 90 top
NOREF#5159  -  []  198.73 281.17 90 top
NOREF#5160  -  []  206.11 285.01 0 top
NOREF#5161  -  []  379.15 244.28 0 top
NOREF#5162  -  []  348.54 294.54 0 top
NOREF#5163  -  []  389.44 232.33 90 top
NOREF#5164  -  []  388.54 294.54 0 top
NOREF#5165  -  []  304.25 170.6 90 top
NOREF#5166  -  []  383.58 228.32 0 top
NOREF#5167  -  []  501.34 267.31 0 top
NOREF#5168  -  []  347.6 310.97 90 top
NOREF#5169  -  []  522 267.31 0 top
NOREF#5170  -  []  219.19 217.83 0 top
NOREF#5171  -  []  348.84 292.33 0 top
NOREF#5172  -  []  307.31 269.35 0 top
NOREF#5173  -  []  249.93 401.56 90 top
NOREF#5174  -  []  226.79 234.87 90 top
NOREF#5175  -  []  270.31 281.58 0 top
NOREF#5176  -  []  516.09 245.67 90 top
NOREF#5177  -  []  346.46 242.05 0 top
NOREF#5178  -  []  425.13 289.66 0 top
NOREF#5179  -  []  232.82 234.87 0 top
NOREF#5180  -  []  469.17 126.62 0 top
NOREF#5181  -  []  334.1 342.74 90 top
NOREF#5182  -  []  353 301.53 0 top
NOREF#5183  -  []  219.19 313.44 0 top
NOREF#5184  -  []  512.77 308.86 0 top
NOREF#5185  -  []  311.3 311.08 90 top
NOREF#5186  -  []  309.54 297.24 0 top
NOREF#5187  -  []  345.78 229.41 90 top
NOREF#5188  -  []  357.01 131.53 90 top
NOREF#5189  -  []  407.95 297.95 90 top
NOREF#5190  -  []  478.6 301.83 90 top
NOREF#5191  -  []  388.63 238.15 0 top
NOREF#5192  -  []  348.84 234.21 0 top
NOREF#5193  -  []  339.67 233.34 90 top
NOREF#5194  -  []  344.46 287.38 90 top
NOREF#5195  -  []  299.08 278.86 90 top
NOREF#5196  -  []  504.66 314.25 90 top
NOREF#5197  -  []  428.12 311.87 0 top
NOREF#5198  -  []  221.39 244.86 0 top
NOREF#5199  -  []  198.73 292.6 90 top
NOREF#5200  -  []  422.12 315.2 0 top
NOREF#5201  -  []  507.37 305.66 90 top
NOREF#5202  -  []  342.98 236.26 0 top
NOREF#5203  -  []  427.29 298.22 0 top
NOREF#5204  -  []  307.29 238.22 0 top
NOREF#5205  -  []  383.53 270.82 90 top
NOREF#5206  -  []  294.28 329.41 0 top
NOREF#5207  -  []  431.5 307.42 0 top
NOREF#5208  -  []  52.66 412.71 0 top
NOREF#5209  -  []  346.37 297.89 0 top
NOREF#5210  -  []  231.04 271.32 0 top
NOREF#5211  -  []  527.07 317.76 90 top
NOREF#5212  -  []  307.66 233.29 0 top
NOREF#5213  -  []  454.69 217.13 0 top
NOREF#5214  -  []  277.36 252.9 90 top
NOREF#5215  -  []  452.3 267.69 90 top
NOREF#5216  -  []  249.42 217.83 0 top
NOREF#5217  -  []  345.35 237.58 0 top
NOREF#5218  -  []  261.25 231.82 90 top
NOREF#5219  -  []  300.35 243.64 90 top
NOREF#5220  -  []  428.84 232.33 0 top
NOREF#5221  -  []  53.97 434.54 0 top
NOREF#5222  -  []  428.63 298.15 0 top
NOREF#5223  -  []  322.68 327.2 90 top
NOREF#5224  -  []  458.45 261.93 90 top
NOREF#5225  -  []  301.08 251.06 0 top
NOREF#5226  -  []  226.79 260.76 90 top
NOREF#5227  -  []  384.48 229.88 0 top
NOREF#5228  -  []  458.45 299.42 0 top
NOREF#5229  -  []  302.88 240.86 90 top
NOREF#5230  -  []  319.82 338.45 0 top
NOREF#5231  -  []  423.58 286.5 0 top
NOREF#5232  -  []  420.35 300.82 90 top
NOREF#5233  -  []  418.25 311.94 0 top
NOREF#5234  -  []  469.4 210.88 0 top
NOREF#5235  -  []  392.25 294.12 0 top
NOREF#5236  -  []  495.94 305.66 90 top
NOREF#5237  -  []  501.34 224.38 0 top
NOREF#5238  -  []  427.06 233.68 0 top
NOREF#5239  -  []  307.06 293.68 0 top
NOREF#5240  -  []  495.25 415.7 90 top
NOREF#5241  -  []  198.73 287.22 0 top
NOREF#5242  -  []  418.25 244.6 0 top
NOREF#5243  -  []  311.48 232.15 0 top
NOREF#5244  -  []  339.81 163.81 0 top
NOREF#5245  -  []  205.88 334.78 0 top
NOREF#5246  -  []  277.36 321.48 90 top
NOREF#5247  -  []  454.69 320 0 top
NOREF#5248  -  []  393.21 305.24 90 top
NOREF#5249  -  []  303.88 295.94 0 top
NOREF#5250  -  []  388.48 311.23 90 top
NOREF#5251  -  []  298.13 270.82 0 top
NOREF#5252  -  []  389.74 293.89 90 top
NOREF#5253  -  []  208.28 266.2 90 top
NOREF#5254  -  []  425.02 237.19 0 top
NOREF#5255  -  []  463.85 340.72 0 top
NOREF#5256  -  []  507.95 275.97 0 top
NOREF#5257  -  []  527.52 269.97 90 top
NOREF#5258  -  []  421.08 251.06 0 top
NOREF#5259  -  []  314.07 286.36 0 top
NOREF#5260  -  []  472.91 321.3 90 top
NOREF#5261  -  []  207.08 233.42 90 top
NOREF#5262  -  []  425.08 235.94 90 top
NOREF#5263  -  []  382.11 247.04 0 top
NOREF#5264  -  []  533.35 235.24 90 top
NOREF#5265  -  []  379.15 242.83 0 top
NOREF#5266  -  []  535.43 238.26 90 top
NOREF#5267  -  []  387.28 251.87 0 top
NOREF#5268  -  []  270.31 220.01 0 top
NOREF#5269  -  []  338.25 245.26 0 top
NOREF#5270  -  []  518.8 274.57 0 top
NOREF#5271  -  []  393.51 212.15 0 top
NOREF#5272  -  []  424.45 237.2 90 top
NOREF#5273  -  []  388.84 294.21 0 top
NOREF#5274  -  []  311.67 215.41 90 top
NOREF#5275  -  []  470.69 344.55 0 top
NOREF#5276  -  []  385.36 289.28 0 top
NOREF#5277  -  []  423.53 322.17 90 top
NOREF#5278  -  []  319.64 258.32 90 top
NOREF#5279  -  []  374.04 109.32 90 top
NOREF#5280  -  []  282.08 321.86 0 top
NOREF#5281  -  []  349.1 297.26 0 top
NOREF#5282  -  []  233.15 270.05 0 top
NOREF#5283  -  []  299.15 302.83 0 top
NOREF#5284  -  []  247.22 320.7 0 top
NOREF#5285  -  []  437.47 335.54 90 top
NOREF#5286  -  []  424.08 303.86 0 top
NOREF#5287  -  []  533.35 248.88 90 top
NOREF#5288  -  []  356.12 242.21 90 top
NOREF#5289  -  []  343.88 236.58 0 top
NOREF#5290  -  []  517.55 406.82 90 top
NOREF#5291  -  []  322.68 270.4 90 top
NOREF#5292  -  []  548.69 0 90 top
NOREF#5293  -  []  304.46 227.38 90 top
NOREF#5294  -  []  319.61 116.46 0 top
NOREF#5295  -  []  307.6 250.97 90 top
NOREF#5296  -  []  338.47 338.08 0 top
NOREF#5297  -  []  347.34 296.08 0 top
NOREF#5298  -  []  430.94 226.5 90 top
NOREF#5299  -  []  238.22 320.7 90 top
NOREF#5300  -  []  272.51 281.58 0 top
NOREF#5301  -  []  423.58 238.23 0 top
NOREF#5302  -  []  229.82 424.22 0 top
NOREF#5303  -  []  341.08 251.06 0 top
P1  HIGH-SIDE  [PG_3680_DPS64_HDAV_H_P1]  367.08 276.86 0 top
P2  HIGH-SIDE  [PG_3680_HDRF3_LPC_P2]  367.08 276.86 0 top
P4  HIGH-SIDE  [PG_3680_HDRF3_DPS32_P4]  367.08 276.86 0 top
P5  HIGH-SIDE  [PG_3680_HDRF3_LPC_P5]  367.08 276.86 0 top
P6  HIGH-SIDE  [PG_3680_HDRF3_DPS32_HDAV_H_P6]  367.08 276.86 0 top
P7  LOW-SIDE  [PG_3680_DPS64_HDAV_L_P7]  367.08 276.86 0 top
P8  LOW-SIDE  [PG_3680_HDRF3_LPC_P8]  367.08 276.86 0 top
P9  SYS  [PG_3680_SYS_P9]  367.08 276.86 0 top
P10  LOW-SIDE  [PG_3680_HDRF3_LPC_P10]  367.08 276.86 0 top
P11  LOW-SIDE  [PG_3680_DPS64_HDAV_L_P11]  367.08 276.86 0 top
