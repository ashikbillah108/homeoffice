# Allegro board 038RT-8730CN_1116-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#4048  -  []  414.94 244.03 90 top
NOREF#4049  -  []  418.25 311.94 0 top
NOREF#4050  -  []  252.62 320.7 90 top
NOREF#4051  -  []  217.01 259.36 90 top
NOREF#4052  -  []  428.12 251.87 0 top
NOREF#4053  -  []  390.94 291.37 90 top
NOREF#4054  -  []  515.27 417.82 0 top
NOREF#4055  -  []  314.74 112.48 90 top
NOREF#4056  -  []  380.48 311.19 0 top
NOREF#4057  -  []  385.73 183.88 90 top
NOREF#4058  -  []  424.08 243.86 0 top
NOREF#4059  -  []  346.25 237.9 0 top
NOREF#4060  -  []  302.75 301.46 90 top
NOREF#4061  -  []  240.4 259.36 0 top
NOREF#4062  -  []  392.01 245.88 0 top
NOREF#4063  -  []  507.37 264.11 90 top
NOREF#4064  -  []  346.65 310.96 90 top
NOREF#4065  -  []  492.79 129.76 0 top
NOREF#4066  -  []  333.78 409.02 90 top
NOREF#4067  -  []  299.15 302.83 0 top
NOREF#4068  -  []  433 241.53 0 top
NOREF#4069  -  []  432.88 127.92 0 top
NOREF#4070  -  []  391.67 211.01 90 top
NOREF#4071  -  []  394.2 241.74 90 top
NOREF#4072  -  []  300.48 251.19 0 top
NOREF#4073  -  []  533.35 315.25 90 top
NOREF#4074  -  []  368.12 224.96 0 top
NOREF#4075  -  []  311.11 244.05 0 top
NOREF#4076  -  []  393.34 319.97 90 top
NOREF#4077  -  []  344.9 226.88 0 top
NOREF#4078  -  []  427.19 242.05 0 top
NOREF#4079  -  []  388.65 238.59 0 top
NOREF#4080  -  []  499.14 292.96 0 top
NOREF#4081  -  []  313.91 254.79 90 top
NOREF#4082  -  []  305.68 237.27 90 top
NOREF#4083  -  []  430.6 247.1 0 top
NOREF#4084  -  []  382.41 306.51 0 top
NOREF#4085  -  []  350.97 293.86 90 top
NOREF#4086  -  []  351.48 292.15 0 top
NOREF#4087  -  []  198.73 212.59 90 top
NOREF#4088  -  []  384.76 289.66 0 top
NOREF#4089  -  []  428.08 293.18 90 top
NOREF#4090  -  []  461.65 272.14 0 top
NOREF#4091  -  []  428.12 288.85 0 top
NOREF#4092  -  []  353.08 242.66 90 top
NOREF#4093  -  []  383.58 296.95 90 top
NOREF#4094  -  []  460.14 284.91 0 top
NOREF#4095  -  []  198.73 344.37 0 top
NOREF#4096  -  []  270.26 233.72 90 top
NOREF#4097  -  []  308.84 227.46 0 top
NOREF#4098  -  []  479.98 398.99 90 top
NOREF#4099  -  []  466.98 402.82 0 top
NOREF#4100  -  []  367.3 178.01 0 top
NOREF#4101  -  []  384.48 249.03 0 top
NOREF#4102  -  []  241.17 403.62 0 top
NOREF#4103  -  []  174.46 272.76 0 top
NOREF#4104  -  []  345.36 289.74 0 top
NOREF#4105  -  []  383.28 226.82 0 top
NOREF#4106  -  []  388.54 294.54 0 top
NOREF#4107  -  []  429.12 232.03 0 top
NOREF#4108  -  []  387.28 311.87 0 top
NOREF#4109  -  []  536.7 235.24 0 top
NOREF#4110  -  []  388.2 236.49 0 top
NOREF#4111  -  []  225.15 375.38 0 top
NOREF#4112  -  []  343.58 250.36 0 top
NOREF#4113  -  []  305.13 289.66 0 top
NOREF#4114  -  []  231.82 173.52 0 top
NOREF#4115  -  []  382.88 300.86 0 top
NOREF#4116  -  []  425.77 229.16 90 top
NOREF#4117  -  []  471.23 217.58 0 top
NOREF#4118  -  []  429.08 304.86 90 top
NOREF#4119  -  []  236.5 419.12 90 top
NOREF#4120  -  []  371.69 117.24 90 top
NOREF#4121  -  []  339.81 179.05 0 top
NOREF#4122  -  []  512.77 343.15 0 top
NOREF#4123  -  []  388.43 297.66 90 top
NOREF#4124  -  []  299.15 242.15 0 top
NOREF#4125  -  []  341.83 297.65 90 top
NOREF#4126  -  []  342.88 240.86 90 top
NOREF#4127  -  []  307.31 233.29 0 top
NOREF#4128  -  []  432.1 302.06 0 top
NOREF#4129  -  []  382.75 240.26 90 top
NOREF#4130  -  []  399.3 306.35 0 top
NOREF#4131  -  []  249.65 234.87 90 top
NOREF#4132  -  []  343.58 296.95 90 top
NOREF#4133  -  []  433.2 248.94 90 top
NOREF#4134  -  []  433.2 306.03 90 top
NOREF#4135  -  []  431.11 305.56 0 top
NOREF#4136  -  []  507.37 215.98 0 top
NOREF#4137  -  []  313.91 314.79 90 top
NOREF#4138  -  []  340.4 336.69 90 top
NOREF#4139  -  []  293.06 310.84 90 top
NOREF#4140  -  []  513.16 424.22 0 top
NOREF#4141  -  []  324.22 338.45 0 top
NOREF#4142  -  []  189.36 209.4 0 top
NOREF#4143  -  []  339.15 244.28 0 top
NOREF#4144  -  []  431.15 240.26 0 top
NOREF#4145  -  []  32.37 432.49 90 top
NOREF#4146  -  []  254.27 243.46 90 top
NOREF#4147  -  []  414.38 319.56 0 top
NOREF#4148  -  []  425.58 229.16 90 top
NOREF#4149  -  []  344.08 308.86 90 top
NOREF#4150  -  []  524.2 224.38 0 top
NOREF#4151  -  []  289.58 87.36 0 top
NOREF#4152  -  []  389.1 297.26 0 top
NOREF#4153  -  []  461.65 265.13 0 top
NOREF#4154  -  []  433.34 264.37 90 top
NOREF#4155  -  []  480.72 419.12 90 top
NOREF#4156  -  []  336.06 195.05 0 top
NOREF#4157  -  []  421.08 238.36 0 top
NOREF#4158  -  []  350.59 415.7 90 top
NOREF#4159  -  []  235.02 226.47 0 top
NOREF#4160  -  []  251.3 225.07 90 top
NOREF#4161  -  []  495.94 289.76 90 top
NOREF#4162  -  []  270.31 261.31 0 top
NOREF#4163  -  []  292.11 303.78 0 top
NOREF#4164  -  []  342.41 306.51 0 top
NOREF#4165  -  []  349.85 297.94 90 top
NOREF#4166  -  []  380.33 327.57 0 top
NOREF#4167  -  []  46.35 423.75 0 top
NOREF#4168  -  []  407.95 237.95 90 top
NOREF#4169  -  []  394.07 226.36 0 top
NOREF#4170  -  []  219.19 252.12 0 top
NOREF#4171  -  []  384.48 289.87 0 top
NOREF#4172  -  []  69.58 506.86 0 top
NOREF#4173  -  []  356.12 302.21 90 top
NOREF#4174  -  []  428.08 233.38 90 top
NOREF#4175  -  []  390.58 243.36 90 top
NOREF#4176  -  []  219.19 210.57 0 top
NOREF#4177  -  []  329.39 419.09 0 top
NOREF#4178  -  []  252.62 313.44 90 top
NOREF#4179  -  []  319.59 248.7 90 top
NOREF#4180  -  []  208.88 334.25 90 top
NOREF#4181  -  []  533.35 214.59 90 top
NOREF#4182  -  []  428.08 293.38 90 top
NOREF#4183  -  []  294.28 269.42 0 top
NOREF#4184  -  []  249.42 313.44 0 top
NOREF#4185  -  []  427.06 233.68 0 top
NOREF#4186  -  []  462.08 187.86 90 top
NOREF#4187  -  []  346.87 237.85 0 top
NOREF#4188  -  []  295.78 323.31 90 top
NOREF#4189  -  []  377.58 65.36 90 top
NOREF#4190  -  []  389.08 244.86 90 top
NOREF#4191  -  []  533.35 301.62 90 top
NOREF#4192  -  []  432.01 305.88 0 top
NOREF#4193  -  []  383.31 305.55 90 top
NOREF#4194  -  []  356.8 211.22 0 top
NOREF#4195  -  []  299.15 301.46 0 top
NOREF#4196  -  []  348.12 311.87 0 top
NOREF#4197  -  []  527.52 211.38 90 top
NOREF#4198  -  []  362.08 321.86 0 top
NOREF#4199  -  []  174.46 261.33 0 top
NOREF#4200  -  []  275.71 220.01 90 top
NOREF#4201  -  []  277.36 314.47 90 top
NOREF#4202  -  []  277.36 218.61 90 top
NOREF#4203  -  []  501.34 274.57 0 top
NOREF#4204  -  []  414.88 268.37 0 top
NOREF#4205  -  []  251.3 259.36 90 top
NOREF#4206  -  []  304.48 238.55 0 top
NOREF#4207  -  []  305.6 289.67 90 top
NOREF#4208  -  []  444.92 221.76 90 top
NOREF#4209  -  []  424.9 286.88 0 top
NOREF#4210  -  []  384.48 309.03 0 top
NOREF#4211  -  []  534.36 415.7 0 top
NOREF#4212  -  []  32.37 412.17 90 top
NOREF#4213  -  []  473.66 294.36 0 top
NOREF#4214  -  []  209.96 217.83 0 top
NOREF#4215  -  []  349.74 287.14 0 top
NOREF#4216  -  []  389.12 292.03 0 top
NOREF#4217  -  []  311.11 305.56 0 top
NOREF#4218  -  []  209.96 286.41 0 top
NOREF#4219  -  []  223.58 466.36 90 top
NOREF#4220  -  []  378.25 304.6 0 top
NOREF#4221  -  []  501.28 140.92 0 top
NOREF#4222  -  []  294.38 319.56 0 top
NOREF#4223  -  []  250.94 308.25 0 top
NOREF#4224  -  []  486.94 233.02 0 top
NOREF#4225  -  []  328.08 264.86 0 top
NOREF#4226  -  []  345.36 229.28 0 top
NOREF#4227  -  []  279.08 254.86 0 top
NOREF#4228  -  []  306.87 302.35 90 top
NOREF#4229  -  []  527.52 322.65 90 top
NOREF#4230  -  []  294.38 234.16 90 top
NOREF#4231  -  []  447.6 342.12 0 top
NOREF#4232  -  []  193.96 344.09 0 top
NOREF#4233  -  []  394.49 114.66 90 top
NOREF#4234  -  []  228.77 131.53 0 top
NOREF#4235  -  []  310.3 296.62 90 top
NOREF#4236  -  []  303.31 306.4 90 top
NOREF#4237  -  []  423.58 226.5 0 top
NOREF#4238  -  []  478.29 207.07 90 top
NOREF#4239  -  []  330.76 123.34 0 top
NOREF#4240  -  []  418.25 301.78 0 top
NOREF#4241  -  []  527.86 415.3 90 top
NOREF#4242  -  []  441.62 287.86 45 top
NOREF#4243  -  []  241.17 403.62 90 top
NOREF#4244  -  []  353.91 314.79 90 top
NOREF#4245  -  []  426.06 241.41 90 top
NOREF#4246  -  []  362.08 261.86 0 top
NOREF#4247  -  []  447.6 273.54 0 top
NOREF#4248  -  []  526.25 230.36 90 top
NOREF#4249  -  []  298.47 338.08 0 top
NOREF#4250  -  []  319.3 246.35 0 top
NOREF#4251  -  []  299.15 311.62 0 top
NOREF#4252  -  []  239.87 302.05 90 top
NOREF#4253  -  []  380.35 302.19 90 top
NOREF#4254  -  []  303.26 288.02 0 top
NOREF#4255  -  []  497.58 488.36 0 top
NOREF#4256  -  []  458.45 292.41 0 top
NOREF#4257  -  []  327.95 242.35 90 top
NOREF#4258  -  []  309.83 258.32 90 top
NOREF#4259  -  []  330.25 122.54 90 top
NOREF#4260  -  []  394.07 286.36 0 top
NOREF#4261  -  []  200.81 329.91 90 top
NOREF#4262  -  []  484.51 289.76 90 top
NOREF#4263  -  []  249.42 279.15 0 top
NOREF#4264  -  []  422.44 255.5 90 top
NOREF#4265  -  []  245.02 210.57 0 top
NOREF#4266  -  []  331.5 417.82 0 top
NOREF#4267  -  []  485.09 275.97 0 top
NOREF#4268  -  []  501.34 301.6 0 top
NOREF#4269  -  []  307.31 329.35 0 top
NOREF#4270  -  []  533.35 246.67 90 top
NOREF#4271  -  []  385.18 329.41 90 top
NOREF#4272  -  []  270.81 306.3 90 top
NOREF#4273  -  []  513.16 421.66 0 top
NOREF#4274  -  []  418.25 251.94 0 top
NOREF#4275  -  []  343.58 296.95 90 top
NOREF#4276  -  []  262.37 319.24 90 top
NOREF#4277  -  []  341.08 251.06 0 top
NOREF#4278  -  []  367.08 286.86 90 top
NOREF#4279  -  []  277.36 211.6 90 top
NOREF#4280  -  []  405.46 310.84 0 top
NOREF#4281  -  []  367.3 175.41 90 top
NOREF#4282  -  []  518.8 221.18 90 top
NOREF#4283  -  []  528.27 321.81 0 top
NOREF#4284  -  []  348.63 298.15 0 top
NOREF#4285  -  []  303.53 324.37 90 top
NOREF#4286  -  []  390.6 307.1 0 top
NOREF#4287  -  []  364.92 218.6 0 top
NOREF#4288  -  []  512.77 308.86 0 top
NOREF#4289  -  []  354.92 305.6 0 top
NOREF#4290  -  []  71.55 446.92 0 top
NOREF#4291  -  []  535.43 267.17 0 top
NOREF#4292  -  []  344.48 237.91 0 top
NOREF#4293  -  []  200.81 233.07 0 top
NOREF#4294  -  []  270.81 303.1 0 top
NOREF#4295  -  []  393.36 340.38 90 top
NOREF#4296  -  []  307.01 342.57 90 top
NOREF#4297  -  []  344.48 309.03 0 top
NOREF#4298  -  []  378.25 243.15 0 top
NOREF#4299  -  []  424.76 229.66 0 top
NOREF#4300  -  []  215.36 252.12 90 top
NOREF#4301  -  []  242.05 295.05 0 top
NOREF#4302  -  []  312.01 304.37 0 top
NOREF#4303  -  []  458.45 234.65 90 top
NOREF#4304  -  []  448.12 224.96 0 top
NOREF#4305  -  []  495.94 335.89 0 top
NOREF#4306  -  []  366.54 188.85 90 top
NOREF#4307  -  []  314.07 226.36 0 top
NOREF#4308  -  []  533.35 244.48 90 top
NOREF#4309  -  []  348.44 310.97 90 top
NOREF#4310  -  []  242.05 329.34 0 top
NOREF#4311  -  []  527.52 331.29 90 top
NOREF#4312  -  []  495.94 292.96 0 top
NOREF#4313  -  []  384.69 328.37 0 top
NOREF#4314  -  []  207.76 329.34 0 top
NOREF#4315  -  []  311.48 292.15 0 top
NOREF#4316  -  []  387.08 306.86 0 top
NOREF#4317  -  []  165.53 463.3 0 top
NOREF#4318  -  []  305.78 289.14 90 top
NOREF#4319  -  []  469.17 126.62 0 top
NOREF#4320  -  []  291.58 65.36 90 top
NOREF#4321  -  []  315.22 305.28 0 top
NOREF#4322  -  []  266.46 259.91 0 top
NOREF#4323  -  []  354.92 245.6 0 top
NOREF#4324  -  []  425.6 229.67 90 top
NOREF#4325  -  []  243.37 312.04 0 top
NOREF#4326  -  []  349.92 287.85 90 top
NOREF#4327  -  []  428.07 237.2 90 top
NOREF#4328  -  []  336.8 121.67 0 top
NOREF#4329  -  []  516.68 178.35 0 top
NOREF#4330  -  []  470.69 310.26 0 top
NOREF#4331  -  []  419.67 293.34 90 top
NOREF#4332  -  []  293.08 320.86 0 top
NOREF#4333  -  []  346.33 251.86 0 top
NOREF#4334  -  []  410.08 289.86 90 top
NOREF#4335  -  []  266.46 211.6 0 top
NOREF#4336  -  []  440.19 209.61 90 top
NOREF#4337  -  []  351.8 299.51 0 top
NOREF#4338  -  []  426.7 285.88 90 top
NOREF#4339  -  []  364.75 305.55 0 top
NOREF#4340  -  []  284.98 338.66 90 top
NOREF#4341  -  []  307.28 251.87 0 top
NOREF#4342  -  []  312.81 336.38 90 top
NOREF#4343  -  []  219.19 295.05 0 top
NOREF#4344  -  []  395.58 240.86 90 top
NOREF#4345  -  []  428.48 311.23 90 top
NOREF#4346  -  []  432.12 293.7 0 top
NOREF#4347  -  []  370.49 183.88 90 top
NOREF#4348  -  []  350.86 311.87 0 top
NOREF#4349  -  []  448.92 231.34 0 top
NOREF#4350  -  []  205.88 231.91 0 top
NOREF#4351  -  []  281.35 392 90 top
NOREF#4352  -  []  458.45 223.83 0 top
NOREF#4353  -  []  367.14 158.97 90 top
NOREF#4354  -  []  420.35 301.51 90 top
NOREF#4355  -  []  393.34 264.37 90 top
NOREF#4356  -  []  348.39 301.41 90 top
NOREF#4357  -  []  518.8 267.31 0 top
NOREF#4358  -  []  423.58 310.36 0 top
NOREF#4359  -  []  501.69 235.68 90 top
NOREF#4360  -  []  433.36 330.75 0 top
NOREF#4361  -  []  412.11 303.78 0 top
NOREF#4362  -  []  409.86 250.84 0 top
NOREF#4363  -  []  305.72 310.96 90 top
NOREF#4364  -  []  242.05 234.87 0 top
NOREF#4365  -  []  499.14 250.27 0 top
NOREF#4366  -  []  524.2 240.28 0 top
NOREF#4367  -  []  527.07 209.81 90 top
NOREF#4368  -  []  383.02 219.41 0 top
NOREF#4369  -  []  246.19 125.18 0 top
NOREF#4370  -  []  332.08 331.86 0 top
NOREF#4371  -  []  302.85 311.73 0 top
NOREF#4372  -  []  436.56 330.75 90 top
NOREF#4373  -  []  294.38 342.73 0 top
NOREF#4374  -  []  305.36 229.74 0 top
NOREF#4375  -  []  439.59 248.7 90 top
NOREF#4376  -  []  298.25 302.47 0 top
NOREF#4377  -  []  287.95 297.95 90 top
NOREF#4378  -  []  381.78 179.81 0 top
NOREF#4379  -  []  346.87 301.41 90 top
NOREF#4380  -  []  382.41 307.36 0 top
NOREF#4381  -  []  461.65 258.12 0 top
NOREF#4382  -  []  387.91 293.69 90 top
NOREF#4383  -  []  485.39 409.02 90 top
NOREF#4384  -  []  217.01 216.43 90 top
NOREF#4385  -  []  428.09 293.15 90 top
NOREF#4386  -  []  421.83 297.65 90 top
NOREF#4387  -  []  312.1 239.83 0 top
NOREF#4388  -  []  338.25 243.15 0 top
NOREF#4389  -  []  421.08 311.06 0 top
NOREF#4390  -  []  392 309.58 0 top
NOREF#4391  -  []  535.43 244.31 0 top
NOREF#4392  -  []  387.66 301.41 90 top
NOREF#4393  -  []  481.54 271.37 90 top
NOREF#4394  -  []  329.39 424.22 0 top
NOREF#4395  -  []  527.52 228.42 90 top
NOREF#4396  -  []  294.28 329.41 0 top
NOREF#4397  -  []  380.4 336.69 90 top
NOREF#4398  -  []  427.66 301.41 90 top
NOREF#4399  -  []  484.74 343.15 0 top
NOREF#4400  -  []  313.44 112.48 0 top
NOREF#4401  -  []  425.13 289.66 0 top
NOREF#4402  -  []  352.08 239.36 90 top
NOREF#4403  -  []  198.73 264.36 0 top
NOREF#4404  -  []  272.51 322.88 0 top
NOREF#4405  -  []  478.43 403.62 0 top
NOREF#4406  -  []  422.7 155.29 90 top
NOREF#4407  -  []  463.34 313.8 90 top
NOREF#4408  -  []  301.19 233.6 90 top
NOREF#4409  -  []  408.12 218.6 0 top
NOREF#4410  -  []  367.3 162.77 0 top
NOREF#4411  -  []  440.21 135.43 90 top
NOREF#4412  -  []  432.9 341.97 0 top
NOREF#4413  -  []  355.22 305.28 0 top
NOREF#4414  -  []  391.8 239.51 0 top
NOREF#4415  -  []  307.23 238.3 0 top
NOREF#4416  -  []  489.91 258.67 0 top
NOREF#4417  -  []  454.38 230.07 90 top
NOREF#4418  -  []  231.81 274.85 0 top
NOREF#4419  -  []  198.73 315.46 90 top
NOREF#4420  -  []  69.58 46.86 0 top
NOREF#4421  -  []  346.85 295.29 90 top
NOREF#4422  -  []  295.4 137.08 90 top
NOREF#4423  -  []  524.2 292.96 0 top
NOREF#4424  -  []  309.92 227.85 90 top
NOREF#4425  -  []  244.25 337.74 0 top
NOREF#4426  -  []  452.04 377.4 0 top
NOREF#4427  -  []  240.4 233.47 0 top
NOREF#4428  -  []  427.45 297.26 90 top
NOREF#4429  -  []  434.2 300.89 90 top
NOREF#4430  -  []  419.99 234.24 0 top
NOREF#4431  -  []  58.12 429.85 90 top
NOREF#4432  -  []  356.56 270.75 90 top
NOREF#4433  -  []  540.2 243.92 0 top
NOREF#4434  -  []  383.58 238.23 0 top
NOREF#4435  -  []  425.08 235.94 90 top
NOREF#4436  -  []  433 242.38 0 top
NOREF#4437  -  []  458.45 254.92 90 top
NOREF#4438  -  []  367.66 250.84 0 top
NOREF#4439  -  []  426.95 137.08 90 top
NOREF#4440  -  []  425.4 311.86 0 top
NOREF#4441  -  []  433.91 137.08 90 top
NOREF#4442  -  []  358.17 337.05 0 top
NOREF#4443  -  []  427.06 238.91 90 top
NOREF#4444  -  []  283.28 339.93 90 top
NOREF#4445  -  []  420.33 270.82 0 top
NOREF#4446  -  []  354.92 242.85 0 top
NOREF#4447  -  []  365.46 250.84 0 top
NOREF#4448  -  []  305.08 235.3 90 top
NOREF#4449  -  []  391.11 304.05 0 top
NOREF#4450  -  []  478.6 287.81 90 top
NOREF#4451  -  []  270.81 274.21 90 top
NOREF#4452  -  []  423.88 235.94 0 top
NOREF#4453  -  []  510.57 274.57 0 top
NOREF#4454  -  []  270.81 337.39 0 top
NOREF#4455  -  []  259.36 302.3 0 top
NOREF#4456  -  []  302.41 307.36 0 top
NOREF#4457  -  []  307.19 242.05 0 top
NOREF#4458  -  []  353.51 212.15 0 top
NOREF#4459  -  []  382.11 247.04 0 top
NOREF#4460  -  []  395.22 302.53 0 top
NOREF#4461  -  []  305.1 289.85 90 top
NOREF#4462  -  []  249.42 286.41 0 top
NOREF#4463  -  []  288.98 342.73 0 top
NOREF#4464  -  []  455.22 268.96 90 top
NOREF#4465  -  []  507.37 274.57 0 top
NOREF#4466  -  []  394.92 302.85 0 top
NOREF#4467  -  []  290.08 263.86 0 top
NOREF#4468  -  []  301.08 311.06 0 top
NOREF#4469  -  []  401.62 287.86 45 top
NOREF#4470  -  []  257.39 272.36 0 top
NOREF#4471  -  []  481.54 264.11 90 top
NOREF#4472  -  []  343.28 288.64 0 top
NOREF#4473  -  []  306.65 250.96 90 top
NOREF#4474  -  []  423.35 237.91 90 top
NOREF#4475  -  []  351.8 298.66 0 top
NOREF#4476  -  []  280.47 268.07 90 top
NOREF#4477  -  []  431.23 326.4 0 top
NOREF#4478  -  []  320.19 212.2 90 top
NOREF#4479  -  []  344.48 229.88 0 top
NOREF#4480  -  []  425.01 289.28 0 top
NOREF#4481  -  []  349.17 135.43 90 top
NOREF#4482  -  []  384.9 286.88 0 top
NOREF#4483  -  []  224.12 148.08 90 top
NOREF#4484  -  []  422.98 236.26 0 top
NOREF#4485  -  []  174.46 284.19 0 top
NOREF#4486  -  []  303 241.46 90 top
NOREF#4487  -  []  507.37 233.02 0 top
NOREF#4488  -  []  336.82 177.36 90 top
NOREF#4489  -  []  355.67 415.7 0 top
NOREF#4490  -  []  351.67 211.01 90 top
NOREF#4491  -  []  386.33 251.86 0 top
NOREF#4492  -  []  471.63 135.43 90 top
NOREF#4493  -  []  423.88 296.58 0 top
NOREF#4494  -  []  417.92 250.66 0 top
NOREF#4495  -  []  193.96 252.65 0 top
NOREF#4496  -  []  395.22 305.28 0 top
NOREF#4497  -  []  345.08 235.94 90 top
NOREF#4498  -  []  251.3 293.65 90 top
NOREF#4499  -  []  386.16 299.87 0 top
NOREF#4500  -  []  392.25 294.12 0 top
NOREF#4501  -  []  357.72 364.64 90 top
NOREF#4502  -  []  208.88 231.38 90 top
NOREF#4503  -  []  352.06 162.77 0 top
NOREF#4504  -  []  423.25 297.84 0 top
NOREF#4505  -  []  200.26 323.7 90 top
NOREF#4506  -  []  207.08 302 90 top
NOREF#4507  -  []  501.34 258.67 0 top
NOREF#4508  -  []  291.15 332.56 90 top
NOREF#4509  -  []  239.87 319.3 90 top
NOREF#4510  -  []  383.28 228.64 0 top
NOREF#4511  -  []  288.08 227.86 90 top
NOREF#4512  -  []  293.24 123.86 90 top
NOREF#4513  -  []  395.58 300.86 90 top
NOREF#4514  -  []  512.77 267.31 0 top
NOREF#4515  -  []  69.58 46.86 0 top
NOREF#4516  -  []  294.38 234.16 90 top
NOREF#4517  -  []  46.35 422.55 90 top
NOREF#4518  -  []  306.7 285.88 90 top
NOREF#4519  -  []  386.22 236.54 90 top
NOREF#4520  -  []  495.94 240.28 0 top
NOREF#4521  -  []  451.41 217.8 90 top
NOREF#4522  -  []  418.25 305.26 0 top
NOREF#4523  -  []  533.35 317.46 90 top
NOREF#4524  -  []  449.48 209.62 0 top
NOREF#4525  -  []  433.25 135.43 90 top
NOREF#4526  -  []  426.6 251.22 90 top
NOREF#4527  -  []  310.58 303.36 90 top
NOREF#4528  -  []  427.08 246.86 90 top
NOREF#4529  -  []  533.35 267.34 90 top
NOREF#4530  -  []  295.67 240.69 90 top
NOREF#4531  -  []  510.57 343.15 0 top
NOREF#4532  -  []  254.27 250.72 90 top
NOREF#4533  -  []  448.54 271.5 0 top
NOREF#4534  -  []  309.44 292.33 90 top
NOREF#4535  -  []  11.45 390.13 90 top
NOREF#4536  -  []  270.31 227.02 0 top
NOREF#4537  -  []  423.53 322.17 90 top
NOREF#4538  -  []  303.58 227.38 0 top
NOREF#4539  -  []  533.35 233.05 90 top
NOREF#4540  -  []  431.81 315.75 0 top
NOREF#4541  -  []  304.48 228 90 top
NOREF#4542  -  []  310.58 243.36 90 top
NOREF#4543  -  []  392.1 238.98 0 top
NOREF#4544  -  []  228.44 243.46 90 top
NOREF#4545  -  []  313.36 337.18 90 top
NOREF#4546  -  []  193.96 247.15 90 top
NOREF#4547  -  []  347.66 233.29 0 top
NOREF#4548  -  []  303.58 310.36 0 top
NOREF#4549  -  []  440.19 212.2 90 top
NOREF#4550  -  []  200.81 293.41 90 top
NOREF#4551  -  []  422.41 248.21 0 top
NOREF#4552  -  []  312.01 245.88 0 top
NOREF#4553  -  []  316.21 252.13 0 top
NOREF#4554  -  []  469.9 223.48 0 top
NOREF#4555  -  []  304.08 248.86 90 top
NOREF#4556  -  []  463.34 243.02 90 top
NOREF#4557  -  []  344.86 242.05 0 top
NOREF#4558  -  []  228.44 209.17 90 top
NOREF#4559  -  []  383.31 245.55 90 top
NOREF#4560  -  []  347.91 293.69 90 top
NOREF#4561  -  []  354.92 306.97 0 top
NOREF#4562  -  []  342.87 141.48 90 top
NOREF#4563  -  []  504.66 245.67 90 top
NOREF#4564  -  []  404.22 338.45 0 top
NOREF#4565  -  []  41.18 381.28 90 top
NOREF#4566  -  []  240.62 402.82 90 top
NOREF#4567  -  []  308.48 311.23 90 top
NOREF#4568  -  []  384.45 237.2 90 top
NOREF#4569  -  []  422.11 247.04 0 top
NOREF#4570  -  []  442.68 270.4 90 top
NOREF#4571  -  []  495.94 237.08 90 top
NOREF#4572  -  []  362.68 272.6 90 top
NOREF#4573  -  []  345.01 289.28 0 top
NOREF#4574  -  []  425.72 310.96 90 top
NOREF#4575  -  []  278.13 344.13 0 top
NOREF#4576  -  []  294.94 244.03 90 top
NOREF#4577  -  []  362.08 291.86 90 top
NOREF#4578  -  []  439.64 318.32 90 top
NOREF#4579  -  []  463.85 272.14 0 top
NOREF#4580  -  []  436.12 302.21 90 top
NOREF#4581  -  []  512.77 224.38 0 top
NOREF#4582  -  []  383.58 163.81 0 top
NOREF#4583  -  []  395.61 213.47 0 top
NOREF#4584  -  []  239.87 225.07 90 top
NOREF#4585  -  []  242.05 260.76 0 top
NOREF#4586  -  []  425.78 289.41 90 top
NOREF#4587  -  []  387.23 298.3 0 top
NOREF#4588  -  []  345.13 229.66 0 top
NOREF#4589  -  []  289.86 310.84 0 top
NOREF#4590  -  []  312.1 242.06 0 top
NOREF#4591  -  []  356.56 330.75 90 top
NOREF#4592  -  []  420.35 244.3 90 top
NOREF#4593  -  []  533.35 283.17 90 top
NOREF#4594  -  []  226.79 303.45 90 top
NOREF#4595  -  []  351.11 304.05 0 top
NOREF#4596  -  []  351.63 209.35 90 top
NOREF#4597  -  []  299.23 126.62 0 top
NOREF#4598  -  []  350.3 236.62 90 top
NOREF#4599  -  []  469.17 129.19 0 top
NOREF#4600  -  []  377.6 309.76 90 top
NOREF#4601  -  []  229.82 424.22 0 top
NOREF#4602  -  []  298.25 242.47 0 top
NOREF#4603  -  []  361.74 117.24 90 top
NOREF#4604  -  []  496.52 260.07 0 top
NOREF#4605  -  []  349.12 232.03 0 top
NOREF#4606  -  []  383.58 298.23 0 top
NOREF#4607  -  []  539.65 231.4 90 top
NOREF#4608  -  []  385.73 168.64 90 top
NOREF#4609  -  []  447.37 210.89 0 top
NOREF#4610  -  []  436.12 246.33 90 top
NOREF#4611  -  []  345.15 335.54 90 top
NOREF#4612  -  []  241.17 409.02 90 top
NOREF#4613  -  []  484.51 315.65 90 top
NOREF#4614  -  []  442.47 232.94 0 top
NOREF#4615  -  []  374.04 109.32 90 top
NOREF#4616  -  []  485.39 403.62 90 top
NOREF#4617  -  []  393.34 262.17 90 top
NOREF#4618  -  []  382.98 236.26 0 top
NOREF#4619  -  []  429.77 234.51 0 top
NOREF#4620  -  []  303.58 238.23 0 top
NOREF#4621  -  []  234.21 403.62 0 top
NOREF#4622  -  []  339.58 301.86 0 top
NOREF#4623  -  []  392.12 233.7 0 top
NOREF#4624  -  []  433.08 310.71 90 top
NOREF#4625  -  []  383.31 246.4 90 top
NOREF#4626  -  []  173.58 87.36 0 top
NOREF#4627  -  []  424.48 238.55 0 top
NOREF#4628  -  []  333.88 243.99 90 top
NOREF#4629  -  []  535.43 249.69 90 top
NOREF#4630  -  []  307.89 293.18 90 top
NOREF#4631  -  []  427.89 233.18 90 top
NOREF#4632  -  []  485.39 403.62 0 top
NOREF#4633  -  []  309.08 244.86 90 top
NOREF#4634  -  []  425.08 295.94 90 top
NOREF#4635  -  []  435.58 300.86 90 top
NOREF#4636  -  []  380.35 301.51 90 top
NOREF#4637  -  []  425.6 289.67 90 top
NOREF#4638  -  []  457.12 409.15 0 top
NOREF#4639  -  []  254.27 312.04 90 top
NOREF#4640  -  []  320.19 214.77 90 top
NOREF#4641  -  []  270.31 322.88 0 top
NOREF#4642  -  []  312.25 294.12 0 top
NOREF#4643  -  []  71.55 48.42 0 top
NOREF#4644  -  []  313.45 233.48 90 top
NOREF#4645  -  []  303.53 270.82 90 top
NOREF#4646  -  []  302.36 141.48 90 top
NOREF#4647  -  []  367.3 193.25 0 top
NOREF#4648  -  []  428.84 234.21 0 top
NOREF#4649  -  []  235.02 217.83 0 top
NOREF#4650  -  []  268.11 220.01 0 top
NOREF#4651  -  []  345.9 401.56 0 top
NOREF#4652  -  []  340.35 300.82 90 top
NOREF#4653  -  []  318.08 295.86 90 top
NOREF#4654  -  []  352 246.67 0 top
NOREF#4655  -  []  510.57 233.02 0 top
NOREF#4656  -  []  235.02 260.76 0 top
NOREF#4657  -  []  381.68 311.19 0 top
NOREF#4658  -  []  433.28 291.15 90 top
NOREF#4659  -  []  240.4 327.94 0 top
NOREF#4660  -  []  378.25 311.94 0 top
NOREF#4661  -  []  238.22 234.87 90 top
NOREF#4662  -  []  277.39 347.4 0 top
NOREF#4663  -  []  367.08 276.86 0 top
NOREF#4664  -  []  307.01 337.17 90 top
NOREF#4665  -  []  313.34 322.17 90 top
NOREF#4666  -  []  428.96 330.75 0 top
NOREF#4667  -  []  307.44 293.68 0 top
NOREF#4668  -  []  515.27 422.95 0 top
NOREF#4669  -  []  205.28 265.67 0 top
NOREF#4670  -  []  318.17 337.05 0 top
NOREF#4671  -  []  478.6 294.82 90 top
NOREF#4672  -  []  395.22 306.65 0 top
NOREF#4673  -  []  476.15 422.95 0 top
NOREF#4674  -  []  299.12 250.02 90 top
NOREF#4675  -  []  314.92 302.85 0 top
NOREF#4676  -  []  427.44 233.68 0 top
NOREF#4677  -  []  386.06 301.41 90 top
NOREF#4678  -  []  430.58 303.36 90 top
NOREF#4679  -  []  527.52 288.36 90 top
NOREF#4680  -  []  311.1 249.26 0 top
NOREF#4681  -  []  385.36 229.74 0 top
NOREF#4682  -  []  383.53 319.97 90 top
NOREF#4683  -  []  495.94 224.38 0 top
NOREF#4684  -  []  313.36 340.38 90 top
NOREF#4685  -  []  303.32 254.56 90 top
NOREF#4686  -  []  244.25 303.45 0 top
NOREF#4687  -  []  226.79 295.05 90 top
NOREF#4688  -  []  332.08 281.86 90 top
NOREF#4689  -  []  230.62 313.44 0 top
NOREF#4690  -  []  409.22 211.52 0 top
NOREF#4691  -  []  418.25 302.47 0 top
NOREF#4692  -  []  376.04 127.81 0 top
NOREF#4693  -  []  408.12 284.96 0 top
NOREF#4694  -  []  299.15 244.28 0 top
NOREF#4695  -  []  499.58 466.36 90 top
NOREF#4696  -  []  382.54 160.17 90 top
NOREF#4697  -  []  361.62 287.86 45 top
NOREF#4698  -  []  305.77 229.36 90 top
NOREF#4699  -  []  423.58 289.6 90 top
NOREF#4700  -  []  434.92 245.6 0 top
NOREF#4701  -  []  305.91 126.65 90 top
NOREF#4702  -  []  193.96 315.73 90 top
NOREF#4703  -  []  239.87 259.36 90 top
NOREF#4704  -  []  538.95 331.29 90 top
NOREF#4705  -  []  338.25 245.26 0 top
NOREF#4706  -  []  409.65 339.87 90 top
NOREF#4707  -  []  303.53 322.17 90 top
NOREF#4708  -  []  478.6 301.83 90 top
NOREF#4709  -  []  496.52 320.25 0 top
NOREF#4710  -  []  198.73 326.89 90 top
NOREF#4711  -  []  352.01 308.09 0 top
NOREF#4712  -  []  307.91 293.69 90 top
NOREF#4713  -  []  360.19 212.2 90 top
NOREF#4714  -  []  221.58 87.36 0 top
NOREF#4715  -  []  659.58 41.86 90 top
NOREF#4716  -  []  345.1 237.2 90 top
NOREF#4717  -  []  433.34 319.97 90 top
NOREF#4718  -  []  428.59 228.35 0 top
NOREF#4719  -  []  495.94 332.69 90 top
NOREF#4720  -  []  250.94 342.54 0 top
NOREF#4721  -  []  507.37 332.69 90 top
NOREF#4722  -  []  477.11 245.8 90 top
NOREF#4723  -  []  342.41 248.21 0 top
NOREF#4724  -  []  367.95 302.35 90 top
NOREF#4725  -  []  430.3 296.62 90 top
NOREF#4726  -  []  389.74 293.89 90 top
NOREF#4727  -  []  342.15 298.55 0 top
NOREF#4728  -  []  402.68 327.2 0 top
NOREF#4729  -  []  447.6 259.52 0 top
NOREF#4730  -  []  389.74 287.14 0 top
NOREF#4731  -  []  379.15 302.83 0 top
NOREF#4732  -  []  443.12 281.33 90 top
NOREF#4733  -  []  232.26 338.63 0 top
NOREF#4734  -  []  383.35 237.91 90 top
NOREF#4735  -  []  352 309.58 0 top
NOREF#4736  -  []  471.8 292.46 90 top
NOREF#4737  -  []  232.82 303.45 0 top
NOREF#4738  -  []  423.32 254.56 90 top
NOREF#4739  -  []  387.01 337.17 90 top
NOREF#4740  -  []  396.56 270.75 90 top
NOREF#4741  -  []  437.47 338.13 90 top
NOREF#4742  -  []  394.2 301.74 90 top
NOREF#4743  -  []  237.8 271.65 90 top
NOREF#4744  -  []  419.15 301.46 0 top
NOREF#4745  -  []  368.08 324.86 0 top
NOREF#4746  -  []  428.63 238.15 0 top
NOREF#4747  -  []  379.99 294.24 0 top
NOREF#4748  -  []  353.45 233.48 90 top
NOREF#4749  -  []  343.9 230.5 0 top
NOREF#4750  -  []  349.44 293.61 90 top
NOREF#4751  -  []  403.93 345.58 0 top
NOREF#4752  -  []  343.53 264.37 90 top
NOREF#4753  -  []  430.78 126.62 0 top
NOREF#4754  -  []  458.45 272.14 0 top
NOREF#4755  -  []  389.85 237.94 90 top
NOREF#4756  -  []  69.58 506.86 0 top
NOREF#4757  -  []  472.03 218.69 90 top
NOREF#4758  -  []  442.68 327.2 90 top
NOREF#4759  -  []  309.74 227.14 0 top
NOREF#4760  -  []  363.81 249.44 0 top
NOREF#4761  -  []  221.39 329.34 0 top
NOREF#4762  -  []  266.46 252.9 0 top
NOREF#4763  -  []  350.32 291.39 90 top
NOREF#4764  -  []  387.91 233.69 90 top
NOREF#4765  -  []  390.3 296.62 90 top
NOREF#4766  -  []  279.3 246.35 0 top
NOREF#4767  -  []  349.85 237.94 90 top
NOREF#4768  -  []  311.33 377.33 90 top
NOREF#4769  -  []  250.94 273.96 0 top
NOREF#4770  -  []  396.12 304.96 90 top
NOREF#4771  -  []  207.76 217.83 0 top
NOREF#4772  -  []  346.46 302.05 0 top
NOREF#4773  -  []  217.01 243.46 90 top
NOREF#4774  -  []  454.05 208.35 90 top
NOREF#4775  -  []  423.58 236.95 90 top
NOREF#4776  -  []  382.54 175.41 90 top
NOREF#4777  -  []  426.25 297.9 0 top
NOREF#4778  -  []  354.2 300.89 90 top
NOREF#4779  -  []  500.33 415.7 0 top
NOREF#4780  -  []  290.08 263.86 0 top
NOREF#4781  -  []  381.08 298.36 0 top
NOREF#4782  -  []  516.09 262.71 90 top
NOREF#4783  -  []  427.44 293.68 0 top
NOREF#4784  -  []  219.19 337.74 0 top
NOREF#4785  -  []  332.56 125.38 90 top
NOREF#4786  -  []  358.21 269.35 90 top
NOREF#4787  -  []  387.01 340.37 90 top
NOREF#4788  -  []  310.32 231.39 90 top
NOREF#4789  -  []  481.54 339.95 90 top
NOREF#4790  -  []  430.32 291.39 90 top
NOREF#4791  -  []  422.75 241.46 90 top
NOREF#4792  -  []  71.55 48.42 0 top
NOREF#4793  -  []  383.28 286.82 0 top
NOREF#4794  -  []  440.19 212.2 90 top
NOREF#4795  -  []  245.02 252.12 0 top
NOREF#4796  -  []  352.36 148.08 90 top
NOREF#4797  -  []  442.68 267.2 90 top
NOREF#4798  -  []  374.28 329.41 0 top
NOREF#4799  -  []  242.05 269.16 0 top
NOREF#4800  -  []  198.73 252.93 0 top
NOREF#4801  -  []  343.58 288.32 0 top
NOREF#4802  -  []  433.21 303.73 90 top
NOREF#4803  -  []  353.08 302.66 90 top
NOREF#4804  -  []  200.81 261.33 90 top
NOREF#4805  -  []  389.77 234.51 0 top
NOREF#4806  -  []  401.86 209.62 0 top
NOREF#4807  -  []  9.45 423.13 0 top
NOREF#4808  -  []  259.73 334.39 0 top
NOREF#4809  -  []  207.08 233.42 90 top
NOREF#4810  -  []  413.06 250.84 90 top
NOREF#4811  -  []  485.09 344.55 0 top
NOREF#4812  -  []  259.73 300.1 0 top
NOREF#4813  -  []  487.71 327.25 0 top
NOREF#4814  -  []  268.11 227.02 0 top
NOREF#4815  -  []  429.44 232.33 90 top
NOREF#4816  -  []  387.01 337.17 0 top
NOREF#4817  -  []  232.82 234.87 0 top
NOREF#4818  -  []  244.25 329.34 0 top
NOREF#4819  -  []  345.86 299.55 0 top
NOREF#4820  -  []  362.4 438.26 0 top
NOREF#4821  -  []  468.6 216.68 0 top
NOREF#4822  -  []  463.34 245.22 90 top
NOREF#4823  -  []  518.8 324.05 90 top
NOREF#4824  -  []  469.16 304.66 90 top
NOREF#4825  -  []  336.06 158.37 90 top
NOREF#4826  -  []  423.32 314.56 90 top
NOREF#4827  -  []  436.8 377.4 0 top
NOREF#4828  -  []  313.51 212.15 0 top
NOREF#4829  -  []  363.52 117.51 90 top
NOREF#4830  -  []  247.22 313.44 0 top
NOREF#4831  -  []  518.8 264.11 90 top
NOREF#4832  -  []  206.11 293.65 0 top
NOREF#4833  -  []  460.18 123.34 0 top
NOREF#4834  -  []  504.66 279.96 90 top
NOREF#4835  -  []  378.48 338.08 0 top
NOREF#4836  -  []  341.08 117.51 0 top
NOREF#4837  -  []  270.81 303.1 90 top
NOREF#4838  -  []  348.09 233.43 90 top
NOREF#4839  -  []  499.58 65.36 90 top
NOREF#4840  -  []  389.44 232.33 90 top
NOREF#4841  -  []  414.25 296.3 90 top
NOREF#4842  -  []  313.36 337.18 0 top
NOREF#4843  -  []  469.9 292.06 0 top
NOREF#4844  -  []  661.55 43.42 90 top
NOREF#4845  -  []  386.87 241.41 90 top
NOREF#4846  -  []  452.04 390.1 0 top
NOREF#4847  -  []  331.05 303.74 0 top
NOREF#4848  -  []  402.08 261.86 0 top
NOREF#4849  -  []  430.32 231.39 90 top
NOREF#4850  -  []  478.6 267.54 90 top
NOREF#4851  -  []  429.54 297.24 0 top
NOREF#4852  -  []  432.1 298.98 0 top
NOREF#4853  -  []  373.88 243.99 90 top
NOREF#4854  -  []  370.32 284.96 0 top
NOREF#4855  -  []  306.06 241.41 90 top
NOREF#4856  -  []  402.75 209.62 0 top
NOREF#4857  -  []  381.19 293.6 90 top
NOREF#4858  -  []  522.05 321.81 0 top
NOREF#4859  -  []  431.23 266.4 0 top
NOREF#4860  -  []  495.94 274.57 0 top
NOREF#4861  -  []  501.69 338.55 90 top
NOREF#4862  -  []  519.84 419.12 90 top
NOREF#4863  -  []  424.08 308.86 90 top
NOREF#4864  -  []  518.8 240.28 0 top
NOREF#4865  -  []  305.58 289.16 90 top
NOREF#4866  -  []  425.28 209.35 90 top
NOREF#4867  -  []  393 242.38 0 top
NOREF#4868  -  []  519.84 416.55 90 top
NOREF#4869  -  []  285.46 250.84 0 top
NOREF#4870  -  []  347.31 233.29 0 top
NOREF#4871  -  []  309.44 233.61 90 top
NOREF#4872  -  []  346.6 251.22 90 top
NOREF#4873  -  []  308.07 297.2 90 top
NOREF#4874  -  []  382.88 240.86 90 top
NOREF#4875  -  []  422.44 315.5 90 top
NOREF#4876  -  []  71.55 446.92 0 top
NOREF#4877  -  []  428.96 337.2 90 top
NOREF#4878  -  []  496.52 234.42 0 top
NOREF#4879  -  []  352.1 241.21 0 top
NOREF#4880  -  []  242.05 226.47 0 top
NOREF#4881  -  []  378.13 330.81 0 top
NOREF#4882  -  []  514.05 280.34 90 top
NOREF#4883  -  []  270.81 239.92 90 top
NOREF#4884  -  []  519.84 419.12 90 top
NOREF#4885  -  []  419.15 244.94 0 top
NOREF#4886  -  []  334.36 123.34 90 top
NOREF#4887  -  []  362.68 270.4 90 top
NOREF#4888  -  []  207.08 233.42 90 top
NOREF#4889  -  []  200.81 327.7 90 top
NOREF#4890  -  []  430.86 251.87 0 top
NOREF#4891  -  []  359.59 308.7 90 top
NOREF#4892  -  []  217.01 209.17 90 top
NOREF#4893  -  []  311.3 311.08 90 top
NOREF#4894  -  []  303.25 297.84 0 top
NOREF#4895  -  []  303.02 219.41 0 top
NOREF#4896  -  []  426.95 375.51 0 top
NOREF#4897  -  []  213.31 267.71 90 top
NOREF#4898  -  []  307.73 298.21 0 top
NOREF#4899  -  []  205.28 299.96 0 top
NOREF#4900  -  []  392.14 231.95 0 top
NOREF#4901  -  []  421.68 311.19 0 top
NOREF#4902  -  []  382.88 240.86 0 top
NOREF#4903  -  []  431.63 209.35 90 top
NOREF#4904  -  []  392.1 298.98 0 top
NOREF#4905  -  []  347.44 293.68 0 top
NOREF#4906  -  []  659.58 41.86 90 top
NOREF#4907  -  []  219.19 244.86 0 top
NOREF#4908  -  []  474.04 419.09 0 top
NOREF#4909  -  []  393.2 248.94 90 top
NOREF#4910  -  []  422.98 236.26 0 top
NOREF#4911  -  []  507.37 240.28 0 top
NOREF#4912  -  []  512.77 318.85 0 top
NOREF#4913  -  []  344.48 297.91 0 top
NOREF#4914  -  []  277.65 212.34 0 top
NOREF#4915  -  []  312.89 111.83 0 top
NOREF#4916  -  []  427.66 293.75 0 top
NOREF#4917  -  []  238.22 295.05 90 top
NOREF#4918  -  []  518.8 332.69 90 top
NOREF#4919  -  []  447.77 340.26 0 top
NOREF#4920  -  []  244.53 420.38 90 top
NOREF#4921  -  []  198.73 224.02 90 top
NOREF#4922  -  []  385.08 308.86 0 top
NOREF#4923  -  []  272.51 227.02 0 top
NOREF#4924  -  []  54.74 390.13 90 top
NOREF#4925  -  []  430.94 226.5 90 top
NOREF#4926  -  []  370.32 218.6 0 top
NOREF#4927  -  []  442.52 221.61 0 top
NOREF#4928  -  []  527.52 304.26 90 top
NOREF#4929  -  []  43.19 382.23 0 top
NOREF#4930  -  []  309.77 234.51 0 top
NOREF#4931  -  []  464.85 207.71 90 top
NOREF#4932  -  []  385.01 289.28 0 top
NOREF#4933  -  []  275.71 254.3 90 top
NOREF#4934  -  []  425.68 249.03 0 top
NOREF#4935  -  []  432.71 315.43 0 top
NOREF#4936  -  []  322.68 327.2 90 top
NOREF#4937  -  []  345.68 297.91 90 top
NOREF#4938  -  []  327.08 326.86 0 top
NOREF#4939  -  []  257.39 238.07 0 top
NOREF#4940  -  []  223.59 226.47 0 top
NOREF#4941  -  []  239.87 327.94 90 top
NOREF#4942  -  []  340.35 303.64 90 top
NOREF#4943  -  []  336.82 160.17 90 top
NOREF#4944  -  []  330.32 224.96 0 top
NOREF#4945  -  []  300.57 339.4 0 top
NOREF#4946  -  []  342.12 315.2 0 top
NOREF#4947  -  []  291.81 117.49 0 top
NOREF#4948  -  []  430.94 286.5 90 top
NOREF#4949  -  []  351.16 330.75 0 top
NOREF#4950  -  []  348.12 228.85 0 top
NOREF#4951  -  []  507.37 271.37 90 top
NOREF#4952  -  []  313.28 291.15 90 top
NOREF#4953  -  []  398.21 269.35 90 top
NOREF#4954  -  []  272.51 261.31 0 top
NOREF#4955  -  []  375.56 336.37 0 top
NOREF#4956  -  []  495.94 264.11 90 top
NOREF#4957  -  []  238.22 217.83 90 top
NOREF#4958  -  []  423.31 247.25 90 top
NOREF#4959  -  []  431.8 238.66 0 top
NOREF#4960  -  []  288.08 287.86 90 top
NOREF#4961  -  []  342.11 306.19 0 top
NOREF#4962  -  []  414.28 329.41 0 top
NOREF#4963  -  []  340.35 301.51 90 top
NOREF#4964  -  []  386.85 237.41 0 top
NOREF#4965  -  []  258.32 306.65 0 top
NOREF#4966  -  []  272.51 315.87 0 top
NOREF#4967  -  []  533.35 260.31 90 top
NOREF#4968  -  []  510.57 301.6 0 top
NOREF#4969  -  []  386.25 297.9 0 top
NOREF#4970  -  []  433.2 246.03 90 top
NOREF#4971  -  []  313.08 250.71 90 top
NOREF#4972  -  []  52.68 415.88 0 top
NOREF#4973  -  []  312 249.58 0 top
NOREF#4974  -  []  312.7 306.78 90 top
NOREF#4975  -  []  412.85 302.61 0 top
NOREF#4976  -  []  71.55 109.92 0 top
NOREF#4977  -  []  209.96 210.57 0 top
NOREF#4978  -  []  200.81 247.69 90 top
NOREF#4979  -  []  395.02 301.03 0 top
NOREF#4980  -  []  433.51 217.31 0 top
NOREF#4981  -  []  174.46 295.62 0 top
NOREF#4982  -  []  589.33 129.82 0 top
NOREF#4983  -  []  383.53 270.82 90 top
NOREF#4984  -  []  300.48 311.19 0 top
NOREF#4985  -  []  393.34 259.97 90 top
NOREF#4986  -  []  481.54 237.08 90 top
NOREF#4987  -  []  354.92 302.85 0 top
NOREF#4988  -  []  410.32 224.96 0 top
NOREF#4989  -  []  232.82 226.47 0 top
NOREF#4990  -  []  303.58 226.5 0 top
NOREF#4991  -  []  251.03 415.7 0 top
NOREF#4992  -  []  277.36 321.48 90 top
NOREF#4993  -  []  433.21 245.24 90 top
NOREF#4994  -  []  546.17 438.26 0 top
NOREF#4995  -  []  318.21 329.35 90 top
NOREF#4996  -  []  334.88 328.37 0 top
NOREF#4997  -  []  472.54 212.78 0 top
NOREF#4998  -  []  450.32 218.6 0 top
NOREF#4999  -  []  353.51 214.74 0 top
NOREF#5000  -  []  227.87 129.44 0 top
NOREF#5001  -  []  226.79 320.7 90 top
NOREF#5002  -  []  309.1 237.26 0 top
NOREF#5003  -  []  304.54 242.35 90 top
NOREF#5004  -  []  355.22 242.53 0 top
NOREF#5005  -  []  383.26 288.02 0 top
NOREF#5006  -  []  387.06 233.68 0 top
NOREF#5007  -  []  288.98 339.54 90 top
NOREF#5008  -  []  428.84 227.46 0 top
NOREF#5009  -  []  321.41 117.56 90 top
NOREF#5010  -  []  423.9 237.85 0 top
NOREF#5011  -  []  238.22 329.34 90 top
NOREF#5012  -  []  347.67 338 90 top
NOREF#5013  -  []  387.23 238.3 0 top
NOREF#5014  -  []  423.58 229.6 90 top
NOREF#5015  -  []  524.51 403.62 0 top
NOREF#5016  -  []  480.72 421.68 90 top
NOREF#5017  -  []  346.85 235.29 90 top
NOREF#5018  -  []  418.25 244.6 0 top
NOREF#5019  -  []  343.58 310.36 0 top
NOREF#5020  -  []  425.68 289.22 90 top
NOREF#5021  -  []  383.58 288.32 90 top
NOREF#5022  -  []  496.52 241.68 0 top
NOREF#5023  -  []  507.95 260.07 0 top
NOREF#5024  -  []  304.76 289.66 0 top
NOREF#5025  -  []  388.09 233.15 90 top
NOREF#5026  -  []  315.19 240.94 0 top
NOREF#5027  -  []  367.08 276.86 90 top
NOREF#5028  -  []  380.33 330.81 0 top
NOREF#5029  -  []  437.47 338.13 90 top
NOREF#5030  -  []  245.71 283.35 90 top
NOREF#5031  -  []  430.58 243.36 90 top
NOREF#5032  -  []  349.83 318.32 90 top
NOREF#5033  -  []  484.51 327.25 0 top
NOREF#5034  -  []  290.84 123.86 0 top
NOREF#5035  -  []  381.83 297.65 90 top
NOREF#5036  -  []  477.11 211.51 90 top
NOREF#5037  -  []  404.92 284.96 0 top
NOREF#5038  -  []  163.9 426.54 90 top
NOREF#5039  -  []  71.55 446.92 0 top
NOREF#5040  -  []  302.88 300.86 90 top
NOREF#5041  -  []  347.66 241.41 90 top
NOREF#5042  -  []  528.27 218.94 0 top
NOREF#5043  -  []  499.14 301.6 0 top
NOREF#5044  -  []  207.76 210.57 0 top
NOREF#5045  -  []  369.86 310.84 0 top
NOREF#5046  -  []  380.35 243.64 90 top
NOREF#5047  -  []  351.11 244.05 0 top
NOREF#5048  -  []  291.58 466.36 90 top
NOREF#5049  -  []  448.12 218.6 0 top
NOREF#5050  -  []  304.75 295.61 0 top
NOREF#5051  -  []  200.81 267.36 90 top
NOREF#5052  -  []  313.08 310.71 90 top
NOREF#5053  -  []  517.58 488.36 0 top
NOREF#5054  -  []  429.74 233.89 90 top
NOREF#5055  -  []  268.11 261.31 0 top
NOREF#5056  -  []  307.29 238.22 0 top
NOREF#5057  -  []  385.1 289.85 90 top
NOREF#5058  -  []  484.51 224.38 0 top
NOREF#5059  -  []  396.12 246.33 90 top
NOREF#5060  -  []  393.44 293.48 90 top
NOREF#5061  -  []  309.4 235.85 90 top
NOREF#5062  -  []  365.45 346.74 0 top
NOREF#5063  -  []  385.07 280.36 90 top
NOREF#5064  -  []  215.11 299.96 90 top
NOREF#5065  -  []  188.18 174.79 0 top
NOREF#5066  -  []  367.3 177.36 90 top
NOREF#5067  -  []  383.58 230.2 0 top
NOREF#5068  -  []  429.74 227.14 0 top
NOREF#5069  -  []  207.76 295.05 0 top
NOREF#5070  -  []  226.79 210.57 90 top
NOREF#5071  -  []  311.18 310.97 90 top
NOREF#5072  -  []  203.76 377.07 0 top
NOREF#5073  -  []  389.32 311.23 90 top
NOREF#5074  -  []  306.16 239.87 0 top
NOREF#5075  -  []  305.35 242.35 90 top
NOREF#5076  -  []  536.7 303.82 0 top
NOREF#5077  -  []  345.4 311.86 0 top
NOREF#5078  -  []  219.19 320.7 0 top
NOREF#5079  -  []  472.03 321.56 90 top
NOREF#5080  -  []  346.87 241.41 90 top
NOREF#5081  -  []  279.3 306.35 0 top
NOREF#5082  -  []  268.11 329.89 0 top
NOREF#5083  -  []  418.13 270.82 0 top
NOREF#5084  -  []  434.92 305.6 0 top
NOREF#5085  -  []  382.38 189.45 90 top
NOREF#5086  -  []  425.07 220.36 90 top
NOREF#5087  -  []  275.71 261.31 90 top
NOREF#5088  -  []  343.26 288.02 0 top
NOREF#5089  -  []  352.12 233.7 0 top
NOREF#5090  -  []  423.25 237.85 0 top
NOREF#5091  -  []  219.19 234.87 0 top
NOREF#5092  -  []  351.11 307.77 0 top
NOREF#5093  -  []  228.97 285.01 0 top
NOREF#5094  -  []  341.85 125.35 0 top
NOREF#5095  -  []  193.96 258.58 90 top
NOREF#5096  -  []  305.01 229.28 0 top
NOREF#5097  -  []  310.86 311.87 0 top
NOREF#5098  -  []  458.45 227.64 90 top
NOREF#5099  -  []  350.3 296.62 90 top
NOREF#5100  -  []  295.67 240.69 90 top
NOREF#5101  -  []  383.53 262.17 90 top
NOREF#5102  -  []  232.82 329.34 0 top
NOREF#5103  -  []  456.29 233.24 0 top
NOREF#5104  -  []  364.22 338.45 0 top
NOREF#5105  -  []  292.08 271.86 0 top
NOREF#5106  -  []  344.48 238.55 0 top
NOREF#5107  -  []  432.25 294.12 0 top
NOREF#5108  -  []  422.39 123.86 0 top
NOREF#5109  -  []  462.13 144.68 0 top
NOREF#5110  -  []  272.51 254.3 0 top
NOREF#5111  -  []  235.02 244.86 0 top
NOREF#5112  -  []  319.61 113.41 0 top
NOREF#5113  -  []  305.35 296.29 90 top
NOREF#5114  -  []  76.55 43.42 90 top
NOREF#5115  -  []  236.66 140.92 0 top
NOREF#5116  -  []  240.4 293.65 0 top
NOREF#5117  -  []  349.32 251.23 90 top
NOREF#5118  -  []  343.58 227.38 0 top
NOREF#5119  -  []  380.35 303.64 90 top
NOREF#5120  -  []  229.82 424.22 0 top
NOREF#5121  -  []  540.2 215.56 90 top
NOREF#5122  -  []  332.85 242.61 90 top
NOREF#5123  -  []  387.6 250.97 90 top
NOREF#5124  -  []  339.67 233.34 90 top
NOREF#5125  -  []  344.46 287.38 90 top
NOREF#5126  -  []  385.77 289.36 90 top
NOREF#5127  -  []  520.85 317.76 90 top
NOREF#5128  -  []  436.12 242.21 90 top
NOREF#5129  -  []  394.2 300.89 90 top
NOREF#5130  -  []  203.76 377.07 90 top
NOREF#5131  -  []  237.8 340.23 90 top
NOREF#5132  -  []  454.45 337.72 90 top
NOREF#5133  -  []  313.21 245.24 90 top
NOREF#5134  -  []  303.31 307.25 90 top
NOREF#5135  -  []  343.88 296.58 0 top
NOREF#5136  -  []  71.55 48.42 0 top
NOREF#5137  -  []  529.66 401.56 0 top
NOREF#5138  -  []  425.33 211 90 top
NOREF#5139  -  []  330.08 289.86 90 top
NOREF#5140  -  []  223.59 313.44 0 top
NOREF#5141  -  []  332.13 208.35 90 top
NOREF#5142  -  []  343.28 226.82 0 top
NOREF#5143  -  []  200.81 290.22 90 top
NOREF#5144  -  []  338.13 270.82 0 top
NOREF#5145  -  []  431.18 250.97 90 top
NOREF#5146  -  []  420.16 156.56 90 top
NOREF#5147  -  []  507.95 310.26 0 top
NOREF#5148  -  []  465.07 220.36 90 top
NOREF#5149  -  []  292.18 342.73 0 top
NOREF#5150  -  []  384.75 295.61 0 top
NOREF#5151  -  []  69.58 506.86 0 top
NOREF#5152  -  []  422.88 240.86 0 top
NOREF#5153  -  []  351.5 307.42 0 top
NOREF#5154  -  []  425.77 229.36 90 top
NOREF#5155  -  []  212.16 295.05 0 top
NOREF#5156  -  []  312.12 233.7 0 top
NOREF#5157  -  []  383.35 297.91 90 top
NOREF#5158  -  []  501.69 269.97 90 top
NOREF#5159  -  []  440.19 214.77 90 top
NOREF#5160  -  []  451.53 337.34 90 top
NOREF#5161  -  []  471.27 125.35 0 top
NOREF#5162  -  []  372.85 302.61 90 top
NOREF#5163  -  []  251.03 415.7 90 top
NOREF#5164  -  []  278.76 344.2 90 top
NOREF#5165  -  []  455.48 124.98 90 top
NOREF#5166  -  []  238.22 286.41 90 top
NOREF#5167  -  []  369.86 250.84 0 top
NOREF#5168  -  []  430.79 338.08 0 top
NOREF#5169  -  []  223.59 286.41 0 top
NOREF#5170  -  []  346.22 236.54 90 top
NOREF#5171  -  []  434.07 226.36 0 top
NOREF#5172  -  []  387.44 233.68 0 top
NOREF#5173  -  []  423.53 259.97 90 top
NOREF#5174  -  []  519.34 122.62 90 top
NOREF#5175  -  []  334.1 338.34 90 top
NOREF#5176  -  []  433 298.87 90 top
NOREF#5177  -  []  306.22 116.64 0 top
NOREF#5178  -  []  223.59 260.76 0 top
NOREF#5179  -  []  256.21 342.21 0 top
NOREF#5180  -  []  285.55 124.98 90 top
NOREF#5181  -  []  305.68 309.03 0 top
NOREF#5182  -  []  338.25 311.94 0 top
NOREF#5183  -  []  359.08 254.86 0 top
NOREF#5184  -  []  347.29 238.22 0 top
NOREF#5185  -  []  343.58 229.6 90 top
NOREF#5186  -  []  535.43 306.84 90 top
NOREF#5187  -  []  338.25 302.47 0 top
NOREF#5188  -  []  302.11 306.19 0 top
NOREF#5189  -  []  228.97 302.05 0 top
NOREF#5190  -  []  382.44 255.5 90 top
NOREF#5191  -  []  32.37 428.17 0 top
NOREF#5192  -  []  391.67 215.41 90 top
NOREF#5193  -  []  458.45 230.84 0 top
NOREF#5194  -  []  424.48 297.91 0 top
NOREF#5195  -  []  361.32 117.51 0 top
NOREF#5196  -  []  393.08 242.66 90 top
NOREF#5197  -  []  329.07 337.05 90 top
NOREF#5198  -  []  334.28 329.41 0 top
NOREF#5199  -  []  384.54 302.35 90 top
NOREF#5200  -  []  309.74 293.89 90 top
NOREF#5201  -  []  407.08 326.86 0 top
NOREF#5202  -  []  393.36 342.58 90 top
NOREF#5203  -  []  71.55 446.92 0 top
NOREF#5204  -  []  293.71 145.48 0 top
NOREF#5205  -  []  472.03 322.2 0 top
NOREF#5206  -  []  532.47 264.65 90 top
NOREF#5207  -  []  424.9 226.88 0 top
NOREF#5208  -  []  313.08 242.66 90 top
NOREF#5209  -  []  313.34 324.37 90 top
NOREF#5210  -  []  342.41 247.36 0 top
NOREF#5211  -  []  305.4 251.86 0 top
NOREF#5212  -  []  424.54 242.35 90 top
NOREF#5213  -  []  447.77 324.41 0 top
NOREF#5214  -  []  540.2 323.93 0 top
NOREF#5215  -  []  342.93 207.71 90 top
NOREF#5216  -  []  371.05 303.74 0 top
NOREF#5217  -  []  388.48 311.23 90 top
NOREF#5218  -  []  354.63 400.89 90 top
NOREF#5219  -  []  425.01 229.28 0 top
NOREF#5220  -  []  217.54 225.07 0 top
NOREF#5221  -  []  447.7 232.61 0 top
NOREF#5222  -  []  334.38 234.16 90 top
NOREF#5223  -  []  277.36 280.18 90 top
NOREF#5224  -  []  389.92 227.85 90 top
NOREF#5225  -  []  347.53 251.22 90 top
NOREF#5226  -  []  305.08 295.3 90 top
NOREF#5227  -  []  507.37 250.27 0 top
NOREF#5228  -  []  428.09 233.15 90 top
NOREF#5229  -  []  305.01 289.28 0 top
NOREF#5230  -  []  333.76 123.86 90 top
NOREF#5231  -  []  489.91 327.25 0 top
NOREF#5232  -  []  484.84 402.82 90 top
NOREF#5233  -  []  386.85 235.29 90 top
NOREF#5234  -  []  391.11 247.77 0 top
NOREF#5235  -  []  330.32 218.6 0 top
NOREF#5236  -  []  429.54 237.24 0 top
NOREF#5237  -  []  461.65 292.41 0 top
NOREF#5238  -  []  463.85 299.42 0 top
NOREF#5239  -  []  305.08 249.14 0 top
NOREF#5240  -  []  347.45 297.26 90 top
NOREF#5241  -  []  393 298.02 90 top
NOREF#5242  -  []  484.51 247.07 90 top
NOREF#5243  -  []  337.86 174.37 90 top
NOREF#5244  -  []  461.65 299.42 0 top
NOREF#5245  -  []  452.3 268.58 90 top
NOREF#5246  -  []  507.95 328.65 0 top
NOREF#5247  -  []  387.08 306.86 0 top
NOREF#5248  -  []  355.61 216.04 0 top
NOREF#5249  -  []  460.14 250.62 0 top
NOREF#5250  -  []  383.28 288.64 0 top
NOREF#5251  -  []  338.47 338.08 0 top
NOREF#5252  -  []  493.39 131.53 0 top
NOREF#5253  -  []  343.25 297.84 0 top
NOREF#5254  -  []  300.35 244.3 90 top
NOREF#5255  -  []  193.96 235.72 90 top
NOREF#5256  -  []  387.29 238.22 0 top
NOREF#5257  -  []  308.54 294.54 0 top
NOREF#5258  -  []  348.65 298.59 0 top
NOREF#5259  -  []  345.65 235.93 0 top
NOREF#5260  -  []  470.69 337.29 0 top
NOREF#5261  -  []  380.48 251.19 0 top
NOREF#5262  -  []  345.35 237.58 0 top
NOREF#5263  -  []  374.88 328.37 0 top
NOREF#5264  -  []  487.71 224.38 0 top
NOREF#5265  -  []  388.08 233.18 90 top
NOREF#5266  -  []  316.12 242.21 90 top
NOREF#5267  -  []  429.74 232.01 0 top
NOREF#5268  -  []  486.94 343.15 0 top
NOREF#5269  -  []  424.75 295.61 0 top
NOREF#5270  -  []  259.73 265.81 0 top
NOREF#5271  -  []  217.01 277.75 90 top
NOREF#5272  -  []  346.14 302.35 90 top
NOREF#5273  -  []  299.23 131.75 0 top
NOREF#5274  -  []  393 301.53 0 top
NOREF#5275  -  []  315.22 245.28 0 top
NOREF#5276  -  []  345.02 297.19 0 top
NOREF#5277  -  []  305.65 235.93 0 top
NOREF#5278  -  []  287.08 266.86 0 top
NOREF#5279  -  []  392.1 301.21 0 top
NOREF#5280  -  []  303.28 286.82 0 top
NOREF#5281  -  []  299.15 244.94 0 top
NOREF#5282  -  []  540.2 249.85 90 top
NOREF#5283  -  []  349.54 297.24 0 top
NOREF#5284  -  []  487.71 318.85 0 top
NOREF#5285  -  []  328.08 227.86 90 top
NOREF#5286  -  []  495.94 343.15 0 top
NOREF#5287  -  []  403.81 309.44 0 top
NOREF#5288  -  []  344.54 302.35 90 top
NOREF#5289  -  []  535.43 215.4 90 top
NOREF#5290  -  []  208.88 265.67 90 top
NOREF#5291  -  []  228.44 225.07 90 top
NOREF#5292  -  []  533.35 258.1 90 top
NOREF#5293  -  []  423.9 297.84 0 top
NOREF#5294  -  []  432.1 239.83 0 top
NOREF#5295  -  []  305.58 229.16 90 top
NOREF#5296  -  []  345.08 248.86 0 top
NOREF#5297  -  []  433.08 250.71 90 top
NOREF#5298  -  []  495.73 139.19 90 top
NOREF#5299  -  []  353.34 264.37 90 top
NOREF#5300  -  []  485.09 225.78 0 top
NOREF#5301  -  []  307.6 310.97 90 top
NOREF#5302  -  []  389.54 237.24 0 top
NOREF#5303  -  []  331.5 420.39 0 top
P1  HIGH-SIDE  [PG_3680_DPS64_HDAV_H_P1]  367.08 276.86 0 top
P2  HIGH-SIDE  [PG_3680_HDRF3_LPC_P2]  367.08 276.86 0 top
P4  HIGH-SIDE  [PG_3680_HDRF3_DPS32_P4]  367.08 276.86 0 top
P5  HIGH-SIDE  [PG_3680_HDRF3_LPC_P5]  367.08 276.86 0 top
P6  HIGH-SIDE  [PG_3680_HDRF3_DPS32_HDAV_H_P6]  367.08 276.86 0 top
P7  LOW-SIDE  [PG_3680_DPS64_HDAV_L_P7]  367.08 276.86 0 top
P8  LOW-SIDE  [PG_3680_HDRF3_LPC_P8]  367.08 276.86 0 top
P9  SYS  [PG_3680_SYS_P9]  367.08 276.86 0 top
P10  LOW-SIDE  [PG_3680_HDRF3_LPC_P10]  367.08 276.86 0 top
P11  LOW-SIDE  [PG_3680_DPS64_HDAV_L_P11]  367.08 276.86 0 top
