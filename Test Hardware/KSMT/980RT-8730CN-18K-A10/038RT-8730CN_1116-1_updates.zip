# Allegro board 038RT-8730CN_1116-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PJ07604-1982  REF-CODE-SOCKET  [SOCKET_CODE]  29.37 377.89 90 top
PT1  PT-ULTRAFLEX-TESTER-75X35  [PROTECTOR_75X35MM]  46.95 407.63 270 bottom
QFN100-10X10  REF-CODE-SOCKET  [SOCKET_CODE]  375.33 441.71 0 top
R1  0-5-S2  [R0201]  308.84 237.94 315 top
R2  0-5-S2  [R0201]  307.06 237.2 315 top
R3  0-5-S2  [R0201]  309.44 233.91 270 top
R4  NC/0-5-S2  [R0201]  309.14 234.21 0 top
R5  0-5-S2  [R0201]  305.35 236.59 270 bottom
R6  0-5-S2  [R0201]  303.58 237.25 270 top
R7  0-5-S2  [R0201]  303.58 229.9 270 top
R8  NC/0-5-S2  [R0201]  303.88 230.2 180 top
R9  0-5-S2  [R0201]  303.58 237.25 270 bottom
R10  0-5-S4  [R0402]  262.37 212.7 90 top
R11  0-5-S4  [R0402]  261.1 212.7 90 top
R12  NC/10K-1-S4  [R0402]  258.46 232.12 90 top
R13  0-5-S4  [R0402]  259.73 232.12 90 top
R14  NC/10K-1-S4  [R0402]  259.83 212.7 90 top
R15  0-5-S4  [R0402]  257.19 232.12 90 top
R16  0-5-S4  [R0402]  258.56 212.7 90 top
R17  0-5-S4  [R0402]  255.92 232.12 90 top
R18  NC/10K-1-S4  [R0402]  257.44 212.7 90 top
R19  0-5-S4  [R0402]  215.75 233.42 180 bottom
R20  0-5-S4  [R0402]  215.75 238.5 180 bottom
R21  0-5-S4  [R0402]  215.75 241.04 180 bottom
R22  45.3-1-S4  [R0402]  319.07 272.79 90 bottom
R23  45.3-1-S4  [R0402]  267.21 240.12 90 bottom
R24  0-5-S4  [R0402]  294.64 125.4 180 bottom
R25  45.3-1-S4  [R0402]  319.07 268.8 270 bottom
R26  45.3-1-S4  [R0402]  267.21 236.13 270 bottom
R27  0-5-S4  [R0402]  294.64 130.48 180 bottom
R28  0-5-S4  [R0402]  294.64 133.02 180 bottom
R29  NC/45.3-1-S4  [R0402]  245.33 232.23 90 bottom
R30  0-5-S4  [R0402]  209.52 233.42 180 bottom
R31  0-5-S4  [R0402]  209.52 238.5 180 bottom
R32  0-5-S4  [R0402]  209.52 241.04 180 bottom
R33  NC/45.3-1-S4  [R0402]  244.18 232.23 270 bottom
R34  10K-1-S4  [R0402]  286.47 180.76 270 bottom
R35  10K-1-S4  [R0402]  289.01 180.76 270 bottom
R36  10K-1-S4  [R0402]  291.55 180.76 270 bottom
R37  10K-1-S4  [R0402]  294.09 180.76 270 bottom
R38  0-5-S4  [R0402]  288.88 170.6 0 bottom
R39  10K-1-S4  [R0402]  296.63 180.76 270 bottom
R40  10K-1-S4  [R0402]  299.17 180.76 270 bottom
R41  10K-1-S4  [R0402]  301.71 180.76 270 bottom
R42  0-5-S4  [R0402]  301.84 170.6 180 bottom
R43  12K-1-S4  [R0402]  320.01 247.6 0 bottom
R45  32.4-1-S4  [R0402]  242.78 218.22 90 bottom
R47  32.4-1-S4  [R0402]  242.78 210.96 90 bottom
R48  0-5-S4  [R0402]  282.74 238.45 90 bottom
R49  NC/0-5-S4  [R0402]  289.96 238.45 90 bottom
R50  0-5-S4  [R0402]  322.43 216.24 270 top
R51  NC/0-5-S4  [R0402]  293.58 271.32 270 bottom
R53  0-5-S4  [R0402]  306.61 274.45 90 bottom
R54  NC/0-5-S4  [R0402]  306.61 270.25 270 bottom
R55  0-5-S4  [R0402]  295.43 276.09 180 bottom
R57  NC/10K-1-S4  [R0402]  221.89 232.84 0 bottom
R58  NC/10K-1-S4  [R0402]  221.89 240.1 0 bottom
R59  NC/10K-1-S4  [R0402]  221.89 224.43 0 bottom
R60  NC/10K-1-S4  [R0402]  221.89 231.7 0 bottom
R61  0-5-S4  [R0402]  280.24 124.98 0 bottom
R62  0-5-S4  [R0402]  283.24 124.98 180 bottom
R63  0-5-S4  [R0402]  240.45 210.96 90 bottom
R64  0-5-S4  [R0402]  241.62 210.96 90 bottom
R65  0-5-S4  [R0402]  241.62 213.38 270 bottom
R66  0-5-S4  [R0402]  240.45 213.38 270 bottom
R67  0-5-S4  [R0402]  240.45 218.22 90 bottom
R68  0-5-S4  [R0402]  241.62 218.22 90 bottom
R69  0-5-S4  [R0402]  241.62 220.64 270 bottom
R70  0-5-S4  [R0402]  240.45 220.64 270 bottom
R71  2-5-D-2  [RC02W_27MM]  185.96 238.47 180 bottom
R72  2-5-D-2  [RC02W_27MM]  185.96 227.04 180 bottom
R73  2-5-D-2  [RC02W_27MM]  185.96 215.61 180 bottom
R74  0-5-S4  [R0402]  242.78 213.38 270 bottom
R75  0-5-S4  [R0402]  242.78 220.64 270 bottom
R76  0-5-S4  [R0402]  320.01 243.24 180 bottom
R77  0-5-S4  [R0402]  315.77 252.13 180 bottom
R78  0-5-S4  [R0402]  308.92 257.13 270 bottom
R79  0-5-S4  [R0402]  303.37 257.13 270 bottom
R81  0-5-S4  [R0402]  320.01 245.38 180 bottom
R82  0-5-S4  [R0402]  320.01 248.7 180 bottom
R83  0-5-S4  [R0402]  320.01 246.5 180 bottom
R327  4.7K-0.1-S4-YA  [R0402]  342.97 195.26 90 top
R338  4.7K-0.1-S4-YA  [R0402]  357.71 195.76 0 bottom
R342  4.7K-0.1-S4-YA  [R0402]  342.47 195.76 0 bottom
R346  4.7K-0.1-S4-YA  [R0402]  358.21 195.26 90 top
R347  4.7K-0.1-S4-YA  [R0402]  373.45 195.26 90 top
R348  4.7K-0.1-S4-YA  [R0402]  388.69 195.26 90 top
R349  4.7K-0.1-S4-YA  [R0402]  342.47 180.52 0 bottom
R350  4.7K-0.1-S4-YA  [R0402]  357.71 180.52 0 bottom
R351  4.7K-0.1-S4-YA  [R0402]  388.19 180.52 0 bottom
R352  4.7K-0.1-S4-YA  [R0402]  373.45 180.02 90 top
R353  4.7K-0.1-S4-YA  [R0402]  372.95 180.52 0 bottom
R354  4.7K-0.1-S4-YA  [R0402]  388.69 180.02 90 top
R355  4.7K-0.1-S4-YA  [R0402]  358.21 180.02 90 top
R356  4.7K-0.1-S4-YA  [R0402]  342.97 180.02 90 top
R357  4.7K-0.1-S4-YA  [R0402]  388.19 165.28 0 bottom
R358  4.7K-0.1-S4-YA  [R0402]  372.95 165.28 0 bottom
R359  4.7K-0.1-S4-YA  [R0402]  342.47 165.28 0 bottom
R360  4.7K-0.1-S4-YA  [R0402]  358.21 164.78 90 top
R361  4.7K-0.1-S4-YA  [R0402]  357.71 165.28 0 bottom
R362  4.7K-0.1-S4-YA  [R0402]  342.97 164.78 90 top
R363  4.7K-0.1-S4-YA  [R0402]  373.45 164.78 90 top
R364  4.7K-0.1-S4-YA  [R0402]  388.69 164.78 90 top
R365  4.7K-0.1-S4-YA  [R0402]  372.95 195.76 0 bottom
R366  4.7K-0.1-S4-YA  [R0402]  388.19 195.76 0 bottom
RB8  0-5-S4  [R0402]  359.48 111.27 90 bottom
RB205  10K-1-S4  [R0402]  402.42 113.39 180 bottom
RB595  13K-1-S4  [R0402]  230.86 127.16 270 bottom
RB596  100K-0.1-S4  [R0402]  227.05 137.96 270 bottom
RB597  0-5-S4  [R0402]  228.96 141.13 0 bottom
RB598  NC/10-1-S6  [R0603]  234.67 137.96 270 bottom
RB599  200K-10-D-Regulate  [VRD_3296W_BOURNS_SKPIN]  239.12 125.89 270 top
RB600  20K-1-S4  [R0402]  234.67 132.88 90 bottom
RB601  200-1-S4  [R0402]  249.28 127.16 270 bottom
RB603  100K-0.1-S4  [R0402]  355.29 137.96 270 bottom
RB604  0-5-S4  [R0402]  357.2 141.13 0 bottom
RB605  NC/10-1-S6  [R0603]  362.91 137.96 270 bottom
RB606  200K-10-D-Regulate  [VRD_3296W_BOURNS_SKPIN]  367.36 125.89 270 top
RB607  20K-1-S4  [R0402]  362.91 132.88 90 bottom
RB608  200-1-S4  [R0402]  377.52 127.16 270 bottom
RB617  100K-0.1-S4  [R0402]  491.68 137.96 270 bottom
RB618  0-5-S4  [R0402]  493.58 141.13 0 bottom
RB619  NC/10-1-S6  [R0603]  499.3 137.96 270 bottom
RB620  200K-10-D-Regulate  [VRD_3296W_BOURNS_SKPIN]  503.74 125.89 270 top
RB621  20K-1-S4  [R0402]  499.3 132.88 90 bottom
RB622  200-1-S4  [R0402]  513.9 127.16 270 bottom
RB623  7.15K-1-S4  [R0402]  357.83 127.16 270 bottom
RB624  NC/9.1K-1-S4  [R0402]  359.1 127.16 270 bottom
RB627  7.15K-1-S4  [R0402]  494.22 127.16 270 bottom
RB628  NC/9.1K-1-S4  [R0402]  495.49 127.16 270 bottom
RT1  1K-1-S4  [R0402]  314.74 116.14 270 bottom
RTL8730EAH  REF-CODE-CHIP  [CHIP_CODE]  59.21 509.04 0 top
S0_1V3  TP03-D  [TP_060_040]  321.85 218.6 270 top
S0_GND1  TP03-D  [TP_060_040]  290.24 268.35 0 top
S0_GND2  TP03-D  [TP_060_040]  197.46 210.21 0 top
S0_GND3  TP03-D  [TP_060_040]  197.46 234.12 0 top
S0_GND4  TP03-D  [TP_060_040]  268.11 210.07 0 top
S0_VD33_ALL1  TP03-D  [TP_060_040]  315.61 208.27 0 top
S0_VDD09  TP03-D  [TP_060_040]  197.46 231.4 0 top
S0_VDD18_A  TP03-D  [TP_060_040]  291.9 274.01 0 top
S0_VDD18_D  TP03-D  [TP_060_040]  252.65 238.07 0 top
S1_1V3  TP03-D  [TP_060_040]  372.52 212.27 270 top
S1_GND1  TP03-D  [TP_060_040]  330.24 268.35 0 top
S1_GND2  TP03-D  [TP_060_040]  197.46 244.5 0 top
S1_GND3  TP03-D  [TP_060_040]  197.46 268.41 0 top
S1_GND4  TP03-D  [TP_060_040]  268.11 244.36 0 top
S1_VD33_ALL1  TP03-D  [TP_060_040]  356.5 208.27 0 top
S1_VDD09  TP03-D  [TP_060_040]  197.46 265.69 0 top
S1_VDD18_A  TP03-D  [TP_060_040]  331.9 274.01 0 top
S1_VDD18_D  TP03-D  [TP_060_040]  252.65 272.36 0 top
S2_1V3  TP03-D  [TP_060_040]  412.52 212.52 270 top
S2_GND1  TP03-D  [TP_060_040]  370.24 268.35 0 top
S2_GND2  TP03-D  [TP_060_040]  536.7 274.93 180 top
S2_GND3  TP03-D  [TP_060_040]  536.7 251.02 180 top
S2_GND4  TP03-D  [TP_060_040]  466.05 275.07 180 top
S2_VD33_ALL1  TP03-D  [TP_060_040]  395.61 208.27 0 top
S2_VDD09  TP03-D  [TP_060_040]  536.7 253.74 180 top
S2_VDD18_A  TP03-D  [TP_060_040]  371.9 274.01 0 top
S2_VDD18_D  TP03-D  [TP_060_040]  481.51 247.07 180 top
S3_1V3  TP03-D  [TP_060_040]  444.9 212.55 270 top
S3_GND1  TP03-D  [TP_060_040]  410.24 268.35 0 top
S3_GND2  TP03-D  [TP_060_040]  536.7 240.64 180 top
S3_GND3  TP03-D  [TP_060_040]  536.7 216.73 180 top
S3_GND4  TP03-D  [TP_060_040]  466.05 240.78 180 top
S3_VD33_ALL1  TP03-D  [TP_060_040]  435.61 208.27 0 top
S3_VDD09  TP03-D  [TP_060_040]  536.7 219.45 180 top
S3_VDD18_A  TP03-D  [TP_060_040]  411.9 274.01 0 top
S3_VDD18_D  TP03-D  [TP_060_040]  481.51 212.78 180 top
S4_1V3  TP03-D  [TP_060_040]  319.44 344.78 90 top
S4_GND1  TP03-D  [TP_060_040]  290.24 328.35 0 top
S4_GND2  TP03-D  [TP_060_040]  197.46 278.79 0 top
S4_GND3  TP03-D  [TP_060_040]  197.46 302.7 0 top
S4_GND4  TP03-D  [TP_060_040]  268.11 278.65 0 top
S4_VD33_ALL1  TP03-D  [TP_060_040]  300.57 344.61 0 top
S4_VDD09  TP03-D  [TP_060_040]  197.46 299.98 0 top
S4_VDD18_A  TP03-D  [TP_060_040]  291.9 334.01 0 top
S4_VDD18_D  TP03-D  [TP_060_040]  252.65 306.65 0 top
S5_1V3  TP03-D  [TP_060_040]  359.44 344.78 90 top
S5_GND1  TP03-D  [TP_060_040]  330.24 328.35 0 top
S5_GND2  TP03-D  [TP_060_040]  197.46 313.08 0 top
S5_GND3  TP03-D  [TP_060_040]  197.46 336.99 0 top
S5_GND4  TP03-D  [TP_060_040]  268.11 312.94 0 top
S5_VD33_ALL1  TP03-D  [TP_060_040]  340.58 344.61 0 top
S5_VDD09  TP03-D  [TP_060_040]  197.46 334.27 0 top
S5_VDD18_A  TP03-D  [TP_060_040]  331.9 334.01 0 top
S5_VDD18_D  TP03-D  [TP_060_040]  252.65 340.94 0 top
S6_1V3  TP03-D  [TP_060_040]  399.25 344.76 90 top
S6_GND1  TP03-D  [TP_060_040]  370.24 328.35 0 top
S6_GND2  TP03-D  [TP_060_040]  536.7 343.51 180 top
S6_GND3  TP03-D  [TP_060_040]  536.7 319.6 180 top
S6_GND4  TP03-D  [TP_060_040]  466.05 343.65 180 top
S6_VD33_ALL1  TP03-D  [TP_060_040]  380.58 344.61 0 top
S6_VDD09  TP03-D  [TP_060_040]  536.7 322.32 180 top
S6_VDD18_A  TP03-D  [TP_060_040]  371.9 334.01 0 top
S6_VDD18_D  TP03-D  [TP_060_040]  481.51 315.65 180 top
S7_1V3  TP03-D  [TP_060_040]  439.44 344.78 90 top
S7_GND1  TP03-D  [TP_060_040]  410.24 328.35 0 top
S7_GND2  TP03-D  [TP_060_040]  536.7 309.22 180 top
S7_GND3  TP03-D  [TP_060_040]  536.7 285.31 180 top
S7_GND4  TP03-D  [TP_060_040]  466.05 309.36 180 top
S7_VD33_ALL1  TP03-D  [TP_060_040]  432.9 344.61 0 top
S7_VDD09  TP03-D  [TP_060_040]  536.7 288.03 180 top
S7_VDD18_A  TP03-D  [TP_060_040]  411.9 334.01 0 top
S7_VDD18_D  TP03-D  [TP_060_040]  481.51 281.36 180 top
SCREW3  CHROMA3680-OUTLINE-RF-TYPE2  [PG_3680_FT_RF_OUTLINE_CHROMA_V2]  367.08 276.86 0 top
SITE0  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  307.08 246.86 0 top
SITE1  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  347.08 246.86 0 top
SITE2  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  387.08 246.86 0 top
SITE3  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  427.08 246.86 0 top
SITE4  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  307.08 306.86 0 top
SITE5  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  347.08 306.86 0 top
SITE6  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  387.08 306.86 0 top
SITE7  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  427.08 306.86 0 top
SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  314.76 229.13 210 top
SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  309.44 224.03 180 top
SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  303.58 223.07 180 top
ST1  SHORT  [DEFAULT_SHORT_SMALL]  316.96 114.38 180 top
ST2  SHORT  [DEFAULT_SHORT_SMALL]  317.02 115.27 180 top
ST3  SHORT  [DEFAULT_SHORT_SMALL]  286.2 246.89 0 top
ST4  SHORT  [DEFAULT_SHORT_SMALL]  314.32 220.59 0 top
ST5  SHORT  [DEFAULT_SHORT_SMALL]  314.32 219.83 0 top
ST8  SHORT  [DEFAULT_SHORT_SMALL]  332.41 204.68 45 bottom
ST11  SHORT  [DEFAULT_SHORT_SMALL]  314.83 265.91 270 top
ST12  SHORT  [DEFAULT_SHORT_SMALL]  305.03 270.76 270 bottom
ST13  SHORT  [DEFAULT_SHORT_SMALL]  282.74 240.69 270 bottom
ST14  SHORT  [DEFAULT_SHORT_SMALL]  296.63 277.12 0 bottom
ST15  SHORT  [DEFAULT_SHORT_SMALL]  321.74 244.4 270 bottom
ST16  SHORT  [DEFAULT_SHORT_SMALL]  286.28 248.01 0 top
ST17  SHORT  [DEFAULT_SHORT_SMALL]  305.74 270.74 270 bottom
ST18  SHORT  [DEFAULT_SHORT_SMALL]  333.16 204.19 45 bottom
ST19  SHORT  [DEFAULT_SHORT_SMALL]  316.02 265.94 270 top
SW1  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  225.47 155.29 0 top
SW2  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  196.26 169.71 0 top
SW3  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  196.26 155.29 0 top
SW4  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  411.27 174.79 0 top
SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  295.36 174.41 0 top
SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  281.74 128.79 0 top
SW7  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  411.27 160.37 0 top
SWB1  SW-SLIDE-1-D4.7  [SW_5P_UTP0030B]  47.98 482.35 270 top
TEMP_MEASUREMENT  TP03-D  [TP_060_040]  314.74 110.09 0 top
TP_VN15  TP03-D  [TP_060_040]  388.2 111.35 0 top
TP_VP5A  TP03-D  [TP_060_040]  359.88 114.93 0 top
TP_VP5B  TP03-D  [TP_060_040]  345.87 111.03 0 top
TP_VP12  TP03-D  [TP_060_040]  296.9 111.73 180 top
TP_VP15  TP03-D  [TP_060_040]  378.1 111.35 0 top
TP_VP24  TP03-D  [TP_060_040]  349.65 111.35 0 top
U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  307.66 233.75 270 top
U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  305.36 229.74 270 top
U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  260.46 221.67 180 bottom
U5  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  354.4 191.95 180 bottom
U6  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  369.64 191.95 180 bottom
U7  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  339.16 191.95 180 bottom
U8  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  384.88 191.95 180 bottom
U9  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  369.64 176.71 180 bottom
U10  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  354.4 176.71 180 bottom
U11  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  384.88 176.71 180 bottom
U12  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  339.16 176.71 180 bottom
U13  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  339.16 161.47 180 bottom
U14  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  354.4 161.47 180 bottom
U15  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  369.64 161.47 180 bottom
U16  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  384.88 161.47 180 bottom
UB5  25LC256-SOIC8  [SO8_206X127MM]  397.1 114.02 180 bottom
UB70  RT8293A-SOP8  [SO8_206X127MM_G]  230.86 134.15 270 bottom
UB71  RT8293A-SOP8  [SO8_206X127MM_G]  359.1 134.15 270 bottom
UB73  RT8293A-SOP8  [SO8_206X127MM_G]  495.49 134.15 270 bottom
UT1  TMP235A2DCKR-SC70  [SC70_5P]  314.09 113.43 0 bottom
VDD12_ATX  HDR-2X2-M  [CONN_2X2_2P54MM_PH]  52.03 417.79 270 top
Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  293 243.89 45 top

## Library data of the parts
1BD1-1BD3 1BD5 1BD7 1BD9 1BD11-1BD13 1BD15-1BD23 1BD27-1BD37 2BD1-2BD3 2BD5 2BD7 2BD9 2BD11-2BD13 2BD15-2BD23 2BD27-2BD37 3BD1-3BD3 3BD5 3BD7 3BD9 3BD11-3BD13 3BD15-3BD23 3BD27-3BD37 4BD1-4BD3 4BD5 4BD7 4BD9 4BD11-4BD13 4BD15-4BD23 4BD27-4BD37 5BD1-5BD3 5BD5 5BD7 5BD9 5BD11-5BD13 5BD15-5BD23 5BD27-5BD37 6BD1-6BD3 6BD5 6BD7 6BD9 6BD11-6BD13 6BD15-6BD23 6BD27-6BD37 7BD1-7BD3 7BD5 7BD7 7BD9 7BD11-7BD13 7BD15-7BD23 7BD27-7BD37 BD1-BD3 BD5 BD7 BD9 BD11-BD13 BD15-BD23 BD27-BD37 = BD120-1.5A-S4-MU
1C1 1C4 1C9 1C11 1C16 2C1 2C4 2C9 2C11 2C16 3C1 3C4 3C9 3C11 3C16 4C1 4C4 4C9 4C11 4C16 5C1 5C4 5C9 5C11 5C16 6C1 6C4 6C9 6C11 6C16 7C1 7C4 7C9 7C11 7C16 C1 C4 C9 C11 C16 = 1P-25-N-S2-WA
1C2 1C6 1C7 1C13 1C14 2C2 2C6 2C7 2C13 2C14 3C2 3C6 3C7 3C13 3C14 4C2 4C6 4C7 4C13 4C14 5C2 5C6 5C7 5C13 5C14 6C2 6C6 6C7 6C13 6C14 7C2 7C6 7C7 7C13 7C14 C2 C6 C7 C13 C14 = 10P-50-N-S2-MU
1C3 1C5 1C10 1C12 1C19 2C3 2C5 2C10 2C12 2C19 3C3 3C5 3C10 3C12 3C19 4C3 4C5 4C10 4C12 4C19 5C3 5C5 5C10 5C12 5C19 6C3 6C5 6C10 6C12 6C19 7C3 7C5 7C10 7C12 7C19 C3 C5 C10 C12 C19 = 1.2P-50-N-S2-MU
1C8 1C15 2C8 2C15 3C8 3C15 4C8 4C15 5C8 5C15 6C8 6C15 7C8 7C15 C8 C15 CB652 CB660 CB667 CB675 CB697 CB705 = CNC-S4
1C17 1C18 1C20 1C21 1C44-1C49 1C52 1C54 1C56 1C58 1C59 1C61 1C64 1C74 1C75 1C77-1C79 1C84 1C85 1C88 1C91 1C98 1C100 1C102 1C105 1C107 1C112 1C119 1C124 1C126 1C128 1C152 1C153 2C17 2C18 2C20 2C21 2C44-2C49 2C52 2C54 2C56 2C58 2C59 2C61 2C64 2C74 2C75 2C77-2C79 2C84 2C85 2C88 2C91 2C98 2C100 2C102 2C105 2C107 2C112 2C119 2C124 2C126 2C128 2C152 2C153 3C17 3C18 3C20 3C21 3C44-3C49 3C52 3C54 3C56 3C58 3C59 3C61 3C64 3C74 3C75 3C77-3C79 3C84 3C85 3C88 3C91 3C98 3C100 3C102 3C105 3C107 3C112 3C119 3C124 3C126 3C128 3C152 3C153 4C17 4C18 4C20 4C21 4C44-4C49 4C52 4C54 4C56 4C58 4C59 4C61 4C64 4C74 4C75 4C77-4C79 4C84 4C85 4C88 4C91 4C98 4C100 4C102 4C105 4C107 4C112 4C119 4C124 4C126 4C128 4C152 4C153 5C17 5C18 5C20 5C21 5C44-5C49 5C52 5C54 5C56 5C58 5C59 5C61 5C64 5C74 5C75 5C77-5C79 5C84 5C85 5C88 5C91 5C98 5C100 5C102 5C105 5C107 5C112 5C119 5C124 5C126 5C128 5C152 5C153 6C17 6C18 6C20 6C21 6C44-6C49 6C52 6C54 6C56 6C58 6C59 6C61 6C64 6C74 6C75 6C77-6C79 6C84 6C85 6C88 6C91 6C98 6C100 6C102 6C105 6C107 6C112 6C119 6C124 6C126 6C128 6C152 6C153 7C17 7C18 7C20 7C21 7C44-7C49 7C52 7C54 7C56 7C58 7C59 7C61 7C64 7C74 7C75 7C77-7C79 7C84 7C85 7C88 7C91 7C98 7C100 7C102 7C105 7C107 7C112 7C119 7C124 7C126 7C128 7C152 7C153 C17 C18 C20 C21 C44-C49 C52 C54 C56 C58 C59 C61 C64 C74 C75 C77-C79 C84 C85 C88 C91 C98 C100 C102 C105 C107 C112 C119 C124 C126 C128 C152 C153 = 0.1U-35-X-S2-MU
1C22 2C22 3C22 4C22 5C22 6C22 7C22 C22 CB662 CB677 CB707 = 0.1U-16-X-S4
1C23 1C25 1C38 1C40 2C23 2C25 2C38 2C40 3C23 3C25 3C38 3C40 4C23 4C25 4C38 4C40 5C23 5C25 5C38 5C40 6C23 6C25 6C38 6C40 7C23 7C25 7C38 7C40 C23 C25 C38 C40 = 10P-50-N-S4-MU-1
1C24 1C55 1C108 1C130 1C137 2C24 2C55 2C108 2C130 2C137 3C24 3C55 3C108 3C130 3C137 4C24 4C55 4C108 4C130 4C137 5C24 5C55 5C108 5C130 5C137 6C24 6C55 6C108 6C130 6C137 7C24 7C55 7C108 7C130 7C137 C24 C55 C108 C130 C137 = 0.1U-25-X-S4-TY
1C39 1C41 2C39 2C41 3C39 3C41 4C39 4C41 5C39 5C41 6C39 6C41 7C39 7C41 C39 C41 = 33P-50-N-S4-WA
1C53 1C57 1C60 1C67 1C73 1C76 1C83 1C89 1C90 1C96 1C97 1C99 1C101 1C106 1C109-1C111 1C118 1C122 1C123 1C125 1C127 1C129 1C136 1C138 2C53 2C57 2C60 2C67 2C73 2C76 2C83 2C89 2C90 2C96 2C97 2C99 2C101 2C106 2C109-2C111 2C118 2C122 2C123 2C125 2C127 2C129 2C136 2C138 3C53 3C57 3C60 3C67 3C73 3C76 3C83 3C89 3C90 3C96 3C97 3C99 3C101 3C106 3C109-3C111 3C118 3C122 3C123 3C125 3C127 3C129 3C136 3C138 4C53 4C57 4C60 4C67 4C73 4C76 4C83 4C89 4C90 4C96 4C97 4C99 4C101 4C106 4C109-4C111 4C118 4C122 4C123 4C125 4C127 4C129 4C136 4C138 5C53 5C57 5C60 5C67 5C73 5C76 5C83 5C89 5C90 5C96 5C97 5C99 5C101 5C106 5C109-5C111 5C118 5C122 5C123 5C125 5C127 5C129 5C136 5C138 6C53 6C57 6C60 6C67 6C73 6C76 6C83 6C89 6C90 6C96 6C97 6C99 6C101 6C106 6C109-6C111 6C118 6C122 6C123 6C125 6C127 6C129 6C136 6C138 7C53 7C57 7C60 7C67 7C73 7C76 7C83 7C89 7C90 7C96 7C97 7C99 7C101 7C106 7C109-7C111 7C118 7C122 7C123 7C125 7C127 7C129 7C136 7C138 C53 C57 C60 C67 C73 C76 C83 C89 C90 C96 C97 C99 C101 C106 C109-C111 C118 C122 C123 C125 C127 C129 C136 C138 = 10U-10-X-S4-SS
1C62 1C63 1C92 1C93 1C116 1C117 1C139 1C142 2C62 2C63 2C92 2C93 2C116 2C117 2C139 2C142 3C62 3C63 3C92 3C93 3C116 3C117 3C139 3C142 4C62 4C63 4C92 4C93 4C116 4C117 4C139 4C142 5C62 5C63 5C92 5C93 5C116 5C117 5C139 5C142 6C62 6C63 6C92 6C93 6C116 6C117 6C139 6C142 7C62 7C63 7C92 7C93 7C116 7C117 7C139 7C142 C62 C63 C92 C93 C116 C117 C139 C142 = 22U-25-X-S8-MU
1C65 1C94 1C120 1C140 2C65 2C94 2C120 2C140 3C65 3C94 3C120 3C140 4C65 4C94 4C120 4C140 5C65 5C94 5C120 5C140 6C65 6C94 6C120 6C140 7C65 7C94 7C120 7C140 C65 C94 C120 C140 = 47U-16-T-SC
1C66 1C95 1C121 1C141 2C66 2C95 2C121 2C141 3C66 3C95 3C121 3C141 4C66 4C95 4C121 4C141 5C66 5C95 5C121 5C141 6C66 6C95 6C121 6C141 7C66 7C95 7C121 7C141 C66 C95 C121 C141 = 10U-16-T-SA
1C68-1C72 1C131-1C135 2C68-2C72 2C131-2C135 3C68-3C72 3C131-3C135 4C68-4C72 4C131-4C135 5C68-5C72 5C131-5C135 6C68-6C72 6C131-6C135 7C68-7C72 7C131-7C135 C68-C72 C131-C135 CT17-CT21 = 22U-10-T-SA
1C113 2C113 3C113 4C113 5C113 6C113 7C113 C113 = 10U-25-X-S6-MU
1C143-1C150 2C143-2C150 3C143-3C150 4C143-4C150 5C143-5C150 6C143-6C150 7C143-7C150 C143-C150 = 10P-50-N-S4-WA
1D1-1D3 2D1-2D3 3D1-3D3 4D1-4D3 5D1-5D3 6D1-6D3 7D1-7D3 D1-D3 = RCLAMP3321P-SLP1006P2
1J1-1J3 2J1-2J3 3J1-3J3 4J1-4J3 5J1-5J3 6J1-6J3 7J1-7J3 J1-J3 = HDR-4X1-F-1
1J4 2J4 3J4 4J4 5J4 6J4 7J4 J4 = HDR-8X1-M
1J5 2J5 3J5 4J5 5J5 6J5 7J5 J5 = HDR-1X1-M
1J6-1J9 2J6-2J9 3J6-3J9 4J6-4J9 5J6-5J9 6J6-6J9 7J6-7J9 J6-J9 = HDR-2X1-M
1K1-1K16 1K18-1K23 1K25 1K26 1K28-1K32 1K34-1K36 1K39 2K1-2K16 2K18-2K23 2K25 2K26 2K28-2K39 3K1-3K16 3K18-3K23 3K25 3K26 3K28-3K32 3K34-3K36 3K39 4K1-4K16 4K18-4K23 4K25 4K26 4K28-4K39 5K1-5K16 5K18-5K23 5K25 5K26 5K28-5K32 5K34-5K36 5K39 6K1-6K16 6K18-6K23 6K25 6K26 6K28-6K39 7K1-7K16 7K18-7K23 7K25 7K26 7K28-7K32 7K34-7K36 7K39 K1-K16 K18-K23 K25 K26 K28-K39 KT1 = CU/UA2-12NJ-A-V2
1L1 1L3 1L4 2L1 2L3 2L4 3L1 3L3 3L4 4L1 4L3 4L4 5L1 5L3 5L4 6L1 6L3 6L4 7L1 7L3 7L4 L1 L3 L4 = CU/L2.2U-1.5A-S2.0X1.6-TDK
1R1-1R9 2R1-2R9 3R1-3R9 4R1-4R9 5R1-5R9 6R1-6R9 7R1-7R9 R1-R9 = 0-5-S2
1R10 1R11 1R13 1R15-1R17 1R19-1R21 1R24 1R27 1R28 1R30-1R32 1R38 1R42 1R48-1R51 1R53-1R55 1R61-1R70 1R74-1R79 1R81-1R83 2R10 2R11 2R13 2R15-2R17 2R19-2R21 2R24 2R27 2R28 2R30-2R32 2R38 2R42 2R48-2R51 2R53-2R55 2R61-2R70 2R74-2R79 2R81-2R83 3R10 3R11 3R13 3R15-3R17 3R19-3R21 3R24 3R27 3R28 3R30-3R32 3R38 3R42 3R48-3R51 3R53-3R55 3R61-3R70 3R74-3R79 3R81-3R83 4R10 4R11 4R13 4R15-4R17 4R19-4R21 4R24 4R27 4R28 4R30-4R32 4R38 4R42 4R48-4R51 4R53-4R55 4R61-4R70 4R74-4R79 4R81-4R83 5R10 5R11 5R13 5R15-5R17 5R19-5R21 5R24 5R27 5R28 5R30-5R32 5R38 5R42 5R48-5R51 5R53-5R55 5R61-5R70 5R74-5R79 5R81-5R83 6R10 6R11 6R13 6R15-6R17 6R19-6R21 6R24 6R27 6R28 6R30-6R32 6R38 6R42 6R48-6R51 6R53-6R55 6R61-6R70 6R74-6R79 6R81-6R83 7R10 7R11 7R13 7R15-7R17 7R19-7R21 7R24 7R27 7R28 7R30-7R32 7R38 7R42 7R48-7R51 7R53-7R55 7R61-7R70 7R74-7R79 7R81-7R83 R10 R11 R13 R15-R17 R19-R21 R24 R27 R28 R30-R32 R38 R42 R48-R51 R53-R55 R61-R70 R74-R79 R81-R83 RB8 RB597 RB604 RB618 = 0-5-S4
1R12 1R14 1R18 1R34-1R37 1R39-1R41 1R57-1R60 2R12 2R14 2R18 2R34-2R37 2R39-2R41 2R57-2R60 3R12 3R14 3R18 3R34-3R37 3R39-3R41 3R57-3R60 4R12 4R14 4R18 4R34-4R37 4R39-4R41 4R57-4R60 5R12 5R14 5R18 5R34-5R37 5R39-5R41 5R57-5R60 6R12 6R14 6R18 6R34-6R37 6R39-6R41 6R57-6R60 7R12 7R14 7R18 7R34-7R37 7R39-7R41 7R57-7R60 R12 R14 R18 R34-R37 R39-R41 R57-R60 RB205 = 10K-1-S4
1R22 1R23 1R25 1R26 1R29 1R33 2R22 2R23 2R25 2R26 2R29 2R33 3R22 3R23 3R25 3R26 3R29 3R33 4R22 4R23 4R25 4R26 4R29 4R33 5R22 5R23 5R25 5R26 5R29 5R33 6R22 6R23 6R25 6R26 6R29 6R33 7R22 7R23 7R25 7R26 7R29 7R33 R22 R23 R25 R26 R29 R33 = 45.3-1-S4
1R43 2R43 3R43 4R43 5R43 6R43 7R43 R43 = 12K-1-S4
1R45 1R47 2R45 2R47 3R45 3R47 4R45 4R47 5R45 5R47 6R45 6R47 7R45 7R47 R45 R47 = 32.4-1-S4
1R71-1R73 2R71-2R73 3R71-3R73 4R71-4R73 5R71-5R73 6R71-6R73 7R71-7R73 R71-R73 = 2-5-D-2
1SMP1-1SMP3 2SMP1-2SMP3 3SMP1-3SMP3 4SMP1-4SMP3 5SMP1-5SMP3 6SMP1-6SMP3 7SMP1-7SMP3 SMP1-SMP3 = MINI-SMP-18S107-40ML5-V2
1ST3-1ST5 1ST8 1ST11-1ST19 2ST3-2ST5 2ST8 2ST11-2ST19 3ST3-3ST5 3ST8 3ST11-3ST19 4ST3-4ST5 4ST8 4ST11-4ST19 5ST3-5ST5 5ST8 5ST11-5ST19 6ST3-6ST5 6ST8 6ST11-6ST19 7ST3-7ST5 7ST8 7ST11-7ST19 ST1-ST5 ST8 ST11-ST19 = SHORT
1SW5 2SW5 3SW5 4SW5 5SW5 6SW5 7SW5 SW5 = SW-SLIDE-8-D2.54-TRI-ECE
1SW6 2SW6 3SW6 4SW6 5SW6 6SW6 7SW6 SW6 = SW-SLIDE-4-D2.54-TRI-ECE
1U1 1U2 2U1 2U2 3U1 3U2 4U1 4U2 5U1 5U2 6U1 6U2 7U1 7U2 U1 U2 = RFASWA358ATF0G
1U3 2U3 3U3 4U3 5U3 6U3 7U3 U3 = MX25R6435FM2IL0-SOP8
1Y1 2Y1 3Y1 4Y1 5Y1 6Y1 7Y1 Y1 = XTAL40M-S2016-TAI-12P
4SW1-4SW4 4SW7 SW1-SW4 SW7 = SW-SLIDE-8-D2.54-ECE
038RT-8730CN16Q-A100 = REF-CODE-PCB
980RT-8730CN-18K- RTL8730EAH = REF-CODE-CHIP
ATX_VD0V9 ATX_VD1V8 ATX_VD33 = HDR-8X2-M
BD42-BD44 BD48 BD50-BD52 BD56-BD72 = BD120-3A-S8
BDB74-BDB77 BDB80-BDB83 BDB86 BDB87 = BD100-3A-SA
C524 C525 C528 C539 C548-C555 = 0.1U-50-X7R-S4-YA
C540-C547 = 0.1U-50-X-S6
CB631 CB632 CB635 CB643 CB654 CB661 CB664 CB669 CB676 CB679 CB699 CB706 CB709 = 220U-10-T-SD
CB633 CB636 CB642 = 10U-10-T-SA-AVX
CB634 CB637 CB638 CB641 CB647 CB650 CB653 CB657 CB665 CB668 CB672 CB695 CB698 CB702 = 0.1U-10-X-S4-MU
CB639 CB648 = 10U-35-T-SC
CB640 CB649 = 47U-25-T-SD-AVX
CB651 CB666 CB696 = 3300P-50-X-S4
CB655 CB663 CB670 CB678 CB700 CB708 = 10U-10-X-S4
CB656 CB671 CB701 = 100P-50-N-S4
CB658 CB673 CB703 = 0.1U-16-X-S4-MU
CB659 CB674 CB704 = 100P-50-N-S4-MU
CT1 CT15 = 680P-50-X-S4
CT2 CT4 CT6 = 10U-25-X7R-SA
CT3 CT5 CT7 = 4.7U-25-X7R-S8-TY
CT8 CT10 CT12 = 10U-50-X-SB-MU
CT9 CT11 CT13 = 4.7U-50-X-S8-MU
CT14 = 0.1U-16-X-S4-MU-1
CT16 = 0.1U-25-X-S6
FD1-FD16 = TP01
FUSEB1-FUSEB3 = MF-R185-40A-D
H1-H4 = M3-HOLE
HOLE_CABLE3 HOLE_CABLE4 = DEBUGHOLE-15X15MM
JB1 = ATX-10X2-MR
LB1 LB2 LB4 = L10U-3.6A-S10X10
LDB1-LDB6 = LDG-2-S8
LDB19 LDB20 LDB22 = LDR-2-S8
LOGO1 = LOGO_RT_Realtek
LOGO2 = LOGO_KT_KSMT
LRB1 LRB2 = 330-1-S6
LRB3 = 1K-1-S6
LRB4 = 2K-1-S6
LRB5 LRB6 = 1.5K-1-S6
P1 P2 P4-P6 = HIGH-SIDE
P7 P8 P10 P11 = LOW-SIDE
P9 = SYS
PJ07604-1982 QFN100-10X10 = REF-CODE-SOCKET
PT1 = PT-ULTRAFLEX-TESTER-75X35
R327 R338 R342 R346-R366 = 4.7K-0.1-S4-YA
RB595 = 13K-1-S4
RB596 RB603 RB617 = 100K-0.1-S4
RB598 RB605 RB619 = 10-1-S6
RB599 RB606 RB620 = 200K-10-D-Regulate
RB600 RB607 RB621 = 20K-1-S4
RB601 RB608 RB622 = 200-1-S4
RB623 RB627 = 7.15K-1-S4
RB624 RB628 = 9.1K-1-S4
RT1 = 1K-1-S4
S0_1V3 S0_GND1-S0_GND4 S0_VD33_ALL1 S0_VDD09 S0_VDD18_A S0_VDD18_D S1_1V3 S1_GND1-S1_GND4 S1_VD33_ALL1 S1_VDD09 S1_VDD18_A S1_VDD18_D S2_1V3 S2_GND1-S2_GND4 S2_VD33_ALL1 S2_VDD09 S2_VDD18_A S2_VDD18_D S3_1V3 S3_GND1-S3_GND4 S3_VD33_ALL1 S3_VDD09 S3_VDD18_A S3_VDD18_D S4_1V3 S4_GND1-S4_GND4 S4_VD33_ALL1 S4_VDD09 S4_VDD18_A S4_VDD18_D S5_1V3 S5_GND1-S5_GND4 S5_VD33_ALL1 S5_VDD09 S5_VDD18_A S5_VDD18_D S6_1V3 S6_GND1-S6_GND4 S6_VD33_ALL1 S6_VDD09 S6_VDD18_A S6_VDD18_D S7_1V3 S7_GND1-S7_GND4 S7_VD33_ALL1 S7_VDD09 S7_VDD18_A S7_VDD18_D TEMP_MEASUREMENT TP_VN15 TP_VP5A TP_VP5B TP_VP12 TP_VP15 TP_VP24 = TP03-D
SCREW3 = CHROMA3680-OUTLINE-RF-TYPE2
SITE0-SITE7 = RTL8730A-QFN100
SWB1 = SW-SLIDE-1-D4.7
U5-U16 = MAX4896ETP+-TQFN-EP-20
UB5 = 25LC256-SOIC8
UB70 UB71 UB73 = RT8293A-SOP8
UT1 = TMP235_0
VDD12_ATX = HDR-2X2-M

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
C0402#2
  custom 0.15x0.15 smd: 1(-0.5,0) 2(0.5,0)
C0402#3
  custom 0.15x0.15 smd: 1(-0.5,0)
LOGO_KT_KSMT
  round 0.051 smd: 1(-0.711,-0.711)
LOGO_RT_REALTEK
  round 0.051 smd: 1(-0.711,-0.711)
PROTECTOR_75X35MM
  round 0.508 hole 3.2 unplated: (-33.02,-12.42) (-33.02,12.42) (33.02,-6.32) (33.02,12.42)
RL_NECUA2_12V_V2#2
  rect 1.626x1.626 hole 1.041: 1(3.6,1.6)
  round 1.626 hole 1.041: 2(0.4,1.6) 8(3.6,-1.6)
RL_NECUA2_12V_V2#3
  rect 1.626x1.626 hole 1.041: 1(3.6,1.6)
  round 1.626 hole 1.041: 8(3.6,-1.6)

## Nets
S0_1_VDD09: C60.1
S0_PB23_SICK: K4.2
S0_PB25_I2C_SCL: K8.2

Pads without a net: C22 1 2; C24 1 2; C38 1 2; C39 1 2; C40 1 2; C41 1 2; C53 1 2; C55 1 2; C57 1 2; C60 2; C67 1 2; C76 1 2; C83 1 2; C89 1 2; C90 1 2; C96 1 2; C97 1 2; C99 1 2; C101 1 2; C106 1 2; C108 1 2; C109 1 2; C110 1 2; C111 1 2; C118 1 2; C122 1 2; C123 1 2; C125 1 2; C127 1 2; C129 1 2; C130 1 2; C136 1 2; C137 1 2; C138 1 2; C148 1 2; C149 1; K4 1 8; K6 1 2 8; K8 1 8; K9 1 2 8; K19 1 8; K20 1 2 8; K21 1 2 8; K22 1 2 8; K23 1 2 8; K25 1 2 8; K26 1 2 8; K28 1 2 8; K29 1 2 8; LOGO1 1; LOGO2 1
