# Allegro board 038RT-8730CN_1116-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
6R49  NC/0-5-S4  [R0402]  369.96 298.45 90 bottom
6R50  0-5-S4  [R0402]  405.32 343.76 180 top
6R51  NC/0-5-S4  [R0402]  373.58 331.32 270 bottom
6R53  0-5-S4  [R0402]  386.61 334.45 90 bottom
6R54  NC/0-5-S4  [R0402]  386.61 330.25 270 bottom
6R55  0-5-S4  [R0402]  375.43 336.09 180 bottom
6R57  NC/10K-1-S4  [R0402]  512.27 320.88 180 bottom
6R58  NC/10K-1-S4  [R0402]  512.27 313.62 180 bottom
6R59  NC/10K-1-S4  [R0402]  512.27 329.29 180 bottom
6R60  NC/10K-1-S4  [R0402]  512.27 322.02 180 bottom
6R61  0-5-S4  [R0402]  500.56 423.32 180 bottom
6R62  0-5-S4  [R0402]  497.56 423.32 0 bottom
6R63  0-5-S4  [R0402]  493.7 342.76 270 bottom
6R64  0-5-S4  [R0402]  492.54 342.76 270 bottom
6R65  0-5-S4  [R0402]  492.54 340.34 90 bottom
6R66  0-5-S4  [R0402]  493.7 340.34 90 bottom
6R67  0-5-S4  [R0402]  493.7 335.5 270 bottom
6R68  0-5-S4  [R0402]  492.54 335.5 270 bottom
6R69  0-5-S4  [R0402]  492.54 333.08 90 bottom
6R70  0-5-S4  [R0402]  493.7 333.08 90 bottom
6R71  2-5-D-2  [RC02W_27MM]  548.2 315.25 0 bottom
6R72  2-5-D-2  [RC02W_27MM]  548.2 326.68 0 bottom
6R73  2-5-D-2  [RC02W_27MM]  548.2 338.11 0 bottom
6R74  0-5-S4  [R0402]  491.38 340.34 90 bottom
6R75  0-5-S4  [R0402]  491.38 333.08 90 bottom
6R76  0-5-S4  [R0402]  400.01 303.24 180 bottom
6R77  0-5-S4  [R0402]  395.77 312.13 180 bottom
6R78  0-5-S4  [R0402]  388.92 317.13 270 bottom
6R79  0-5-S4  [R0402]  383.37 317.13 270 bottom
6R81  0-5-S4  [R0402]  400.01 305.38 180 bottom
6R82  0-5-S4  [R0402]  400.01 308.7 180 bottom
6R83  0-5-S4  [R0402]  400.01 306.5 180 bottom
6SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  394.76 289.13 210 top
6SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  389.44 284.03 180 top
6SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  383.58 283.07 180 top
6ST3  SHORT  [DEFAULT_SHORT_SMALL]  365.86 320.29 270 top
6ST4  SHORT  [DEFAULT_SHORT_SMALL]  369.34 343.87 270 top
6ST5  SHORT  [DEFAULT_SHORT_SMALL]  368.58 343.87 270 top
6ST8  SHORT  [DEFAULT_SHORT_SMALL]  400.15 350.27 270 bottom
6ST11  SHORT  [DEFAULT_SHORT_SMALL]  385.49 318.82 0 top
6ST12  SHORT  [DEFAULT_SHORT_SMALL]  378.13 327.56 270 bottom
6ST13  SHORT  [DEFAULT_SHORT_SMALL]  362.74 300.69 270 bottom
6ST14  SHORT  [DEFAULT_SHORT_SMALL]  376.63 337.12 0 bottom
6ST15  SHORT  [DEFAULT_SHORT_SMALL]  401.74 304.4 270 bottom
6ST16  SHORT  [DEFAULT_SHORT_SMALL]  365.05 320.27 270 top
6ST17  SHORT  [DEFAULT_SHORT_SMALL]  376.86 327.66 270 bottom
6ST18  SHORT  [DEFAULT_SHORT_SMALL]  399.08 350.62 270 bottom
6ST19  SHORT  [DEFAULT_SHORT_SMALL]  383.54 318.19 0 top
6SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  414.45 381.01 180 top
6SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  499.06 419.51 180 top
6U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  387.66 293.75 270 top
6U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  385.36 289.74 270 top
6U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  473.7 332.05 0 bottom
6Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  373 303.89 45 top
7BD1  BD120-1.5A-S4-MU  [FB0402]  419.97 317.1 270 bottom
7BD2  BD120-1.5A-S4-MU  [FB0402]  435.74 314.24 180 bottom
7BD3  BD120-1.5A-S4-MU  [FB0402]  418.93 317.1 270 bottom
7BD5  BD120-1.5A-S4-MU  [FB0402]  416.11 307.53 0 bottom
7BD7  BD120-1.5A-S4-MU  [FB0402]  421.01 317.1 270 bottom
7BD9  BD120-1.5A-S4-MU  [FB0402]  439.98 304.31 180 bottom
7BD11  BD120-1.5A-S4-MU  [FB0402]  435.74 313.2 180 bottom
7BD12  BD120-1.5A-S4-MU  [FB0402]  427.85 317.1 270 bottom
7BD13  BD120-1.5A-S4-MU  [FB0402]  416.14 300.68 0 bottom
7BD15  BD120-1.5A-S4-MU  [FB0402]  419.26 296.89 0 bottom
7BD16  BD120-1.5A-S4-MU  [FB0402]  422.57 303.52 180 bottom
7BD17  BD120-1.5A-S4-MU  [FB0402]  422.57 302.48 180 bottom
7BD18  BD120-1.5A-S4-MU  [FB0402]  434.49 299.43 180 bottom
7BD19  BD120-1.5A-S4-MU  [FB0402]  434.49 298.23 180 bottom
7BD20  BD120-1.5A-S4-MU  [FB0402]  414.56 307.48 270 bottom
7BD21  BD120-1.5A-S4-MU  [FB0402]  434.49 296.09 180 bottom
7BD22  BD120-1.5A-S4-MU  [FB0402]  421.08 293.24 180 bottom
7BD23  BD120-1.5A-S4-MU  [FB0402]  421.08 295.3 0 bottom
7BD27  NC/BD120-1.5A-S4-MU  [FB0402]  491.65 287.7 0 bottom
7BD28  BD120-1.5A-S4-MU  [FB0402]  415.59 310.31 270 bottom
7BD29  BD120-1.5A-S4-MU  [FB0402]  425.59 317.1 270 bottom
7BD30  BD120-1.5A-S4-MU  [FB0402]  415.74 313.12 225 bottom
7BD31  BD120-1.5A-S4-MU  [FB0402]  432.63 316.63 180 bottom
7BD32  BD120-1.5A-S4-MU  [FB0402]  469.1 287.28 90 top
7BD33  BD120-1.5A-S4-MU  [FB0402]  521.37 420.41 90 bottom
7BD34  BD120-1.5A-S4-MU  [FB0402]  422.26 291.51 0 bottom
7BD35  BD120-1.5A-S4-MU  [FB0402]  432.4 296.09 180 bottom
7BD36  BD120-1.5A-S4-MU  [FB0402]  414.09 300.69 0 bottom
7BD37  BD120-1.5A-S4-MU  [FB0402]  429.98 317.1 270 bottom
7C1  NC/1P-25-N-S2-WA  [C0201]  427.94 298.42 45 top
7C2  10P-50-N-S2-MU  [C0201]  432.27 293.44 300 top
7C3  NC/1.2P-50-N-S2-MU  [C0201]  429.75 297.46 45 top
7C4  NC/1P-25-N-S2-WA  [C0201]  426.58 298.11 225 top
7C5  NC/1.2P-50-N-S2-MU  [C0201]  427.55 296.29 225 top
7C6  10P-50-N-S2-MU  [C0201]  429.44 292.63 90 top
7C7  NC/10P-50-N-S2-MU  [C0201]  429.14 292.33 180 top
7C8  CNC-S2  [C0201]  429.14 287.46 180 top
7C9  NC/1P-25-N-S2-WA  [C0201]  425.65 297.58 180 bottom
7C10  NC/1.2P-50-N-S2-MU  [C0201]  425.05 295.61 180 bottom
7C11  NC/1P-25-N-S2-WA  [C0201]  423.88 298.23 180 top
7C12  NC/1.2P-50-N-S2-MU  [C0201]  423.28 296.26 180 top
7C13  10P-50-N-S2-MU  [C0201]  423.58 288.62 90 top
7C14  NC/10P-50-N-S2-MU  [C0201]  423.88 288.32 0 top
7C15  CNC-S2  [C0201]  423.88 286.5 0 top
7C16  NC/1P-25-N-S2-WA  [C0201]  423.88 298.23 180 bottom
7C17  NC/0.1U-35-X-S2-MU  [C0201]  432.4 302.06 180 bottom
7C18  NC/0.1U-35-X-S2-MU  [C0201]  432.4 301.21 180 bottom
7C19  NC/1.2P-50-N-S2-MU  [C0201]  423.28 296.26 180 bottom
7C20  0.1U-35-X-S2-MU  [C0201]  432.4 298.98 0 bottom
7C21  0.1U-35-X-S2-MU  [C0201]  432.4 299.83 0 bottom
7C22  0.1U-16-X-S4-MU  [C0402]  471.64 287.31 270 top
7C23  0.9P-50-N-S4-MU  [C0402]  415.37 305.27 270 top
7C24  0.1U-25-X-S4-TY  [C0402]  491.61 286.62 180 bottom
7C25  0.9P-50-N-S4-MU  [C0402]  415.37 302.5 90 top
7C38  1P-50-N-S4-WA  [C0402]  499.64 295 180 bottom
7C39  22P-50-N-S4-AVX  [C0402]  503.04 295 180 bottom
7C40  1P-50-N-S4-WA  [C0402]  499.64 287.73 180 bottom
7C41  22P-50-N-S4-AVX  [C0402]  503.04 287.73 180 bottom
7C44  0.1U-35-X-S2-MU  [C0201]  422.71 307.36 0 bottom
7C45  0.1U-35-X-S2-MU  [C0201]  431.18 311.27 270 bottom
7C46  0.1U-35-X-S2-MU  [C0201]  422.71 306.51 0 bottom
7C47  0.1U-35-X-S2-MU  [C0201]  431.41 304.05 180 bottom
7C48  0.1U-35-X-S2-MU  [C0201]  418.55 304.6 180 top
7C49  0.1U-35-X-S2-MU  [C0201]  431.41 307.77 180 bottom
7C52  0.1U-35-X-S2-MU  [C0201]  422.71 308.21 0 bottom
7C53  10U-10-X-S4-SS  [C0402]  406.53 308.35 90 bottom
7C54  0.1U-35-X-S2-MU  [C0201]  427.6 311.27 270 bottom
7C55  0.1U-25-X-S4-TY  [C0402]  408.8 308.35 90 bottom
7C56  0.1U-35-X-S2-MU  [C0201]  435.52 305.28 0 top
7C57  NC/10U-10-X-S4-SS  [C0402]  407.66 308.35 90 bottom
7C58  0.1U-35-X-S2-MU  [C0201]  422.44 315.8 90 top
7C59  0.1U-35-X-S2-MU  [C0201]  431.4 309.26 180 bottom
7C60  10U-10-X-S4-SS  [C0402]  437.88 314.29 0 bottom
7C61  0.1U-35-X-S2-MU  [C0201]  426.65 311.26 270 bottom
7C62  22U-25-X-S8-MU  [C0805]  406.41 316.59 0 bottom
7C63  22U-25-X-S8-MU  [C0805]  406.41 318.62 0 bottom
7C64  0.1U-35-X-S2-MU  [C0201]  418.55 302.47 180 top
7C65  47U-16-T-SC  [CODE_C]  474.22 281.36 0 bottom
7C66  10U-16-T-SA  [CODE_A]  474.19 281.36 0 top
7C67  10U-10-X-S4-SS  [C0402]  437.88 313.17 0 bottom
7C68  22U-10-T-SA  [CODE_A]  434.55 336.81 0 bottom
7C69  22U-10-T-SA  [CODE_A]  434.55 339.4 0 bottom
7C70  22U-10-T-SA  [CODE_A]  434.55 341.97 0 bottom
7C71  22U-10-T-SA  [CODE_A]  434.55 339.4 0 top
7C72  22U-10-T-SA  [CODE_A]  434.55 336.81 0 top
7C73  10U-10-X-S4-SS  [C0402]  414.06 299.62 180 bottom
7C74  0.1U-35-X-S2-MU  [C0201]  425.35 302.65 90 bottom
7C75  0.1U-35-X-S2-MU  [C0201]  435.52 302.53 0 top
7C76  10U-10-X-S4-SS  [C0402]  419.23 297.96 180 bottom
7C77  0.1U-35-X-S2-MU  [C0201]  424.54 302.65 90 bottom
7C78  0.1U-35-X-S2-MU  [C0201]  418.55 303.15 180 top
7C79  0.1U-35-X-S2-MU  [C0201]  418.55 301.78 180 top
7C83  10U-10-X-S4-SS  [C0402]  434.52 300.52 0 bottom
7C84  0.1U-35-X-S2-MU  [C0201]  426.87 302.65 90 bottom
7C85  0.1U-35-X-S2-MU  [C0201]  426.14 302.65 90 bottom
7C88  0.1U-35-X-S2-MU  [C0201]  418.55 305.26 180 top
7C89  10U-10-X-S4-SS  [C0402]  413.03 308.85 180 bottom
7C90  10U-10-X-S4-SS  [C0402]  434.52 297.15 0 bottom
7C91  0.1U-35-X-S2-MU  [C0201]  426.46 299.87 0 bottom
7C92  22U-25-X-S8-MU  [C0805]  500.3 217.09 180 bottom
7C93  22U-25-X-S8-MU  [C0805]  500.3 217.09 180 top
7C94  47U-16-T-SC  [CODE_C]  500.33 213.67 180 bottom
7C95  10U-16-T-SA  [CODE_A]  500.36 213.67 180 top
7C96  10U-10-X-S4-SS  [C0402]  436.6 300.52 0 bottom
7C97  10U-10-X-S4-SS  [C0402]  420.61 292.74 270 top
7C98  0.1U-35-X-S2-MU  [C0201]  419.67 293.64 270 top
7C99  10U-10-X-S4-SS  [C0402]  421.55 294.8 270 top
7C100  0.1U-35-X-S2-MU  [C0201]  421.83 297.95 270 top
7C101  10U-10-X-S4-SS  [C0402]  413.03 307.01 180 bottom
7C102  0.1U-35-X-S2-MU  [C0201]  431.41 305.56 180 bottom
7C105  0.1U-35-X-S2-MU  [C0201]  431.4 306.35 180 bottom
7C106  10U-10-X-S4-SS  [C0402]  436.43 327.74 90 bottom
7C107  0.1U-35-X-S2-MU  [C0201]  435.52 306.65 0 top
7C108  0.1U-25-X-S4-TY  [C0402]  435.31 327.74 90 bottom
7C109  NC/10U-10-X-S4-SS  [C0402]  437.55 327.74 90 bottom
7C110  1U-10-X-S4-MU  [C0402]  437.14 302.53 180 top
7C111  10U-10-X-S4-SS  [C0402]  415.59 309.34 270 top
7C112  0.1U-35-X-S2-MU  [C0201]  417.6 310.06 270 top
7C113  10U-25-X-S6-MU  [C0603]  441.74 307.85 90 bottom
7C116  22U-25-X-S8-MU  [C0805]  426.8 319.97 180 bottom
7C117  22U-25-X-S8-MU  [C0805]  426.8 322.13 180 bottom
7C118  10U-10-X-S4-SS  [C0402]  424.5 317.13 90 bottom
7C119  0.1U-35-X-S2-MU  [C0201]  425.72 311.26 270 bottom
7C120  47U-16-T-SC  [CODE_C]  451.53 338.99 90 bottom
7C121  10U-16-T-SA  [CODE_A]  451.53 338.99 90 top
7C122  10U-10-X-S4-SS  [C0402]  436.6 299.41 0 bottom
7C123  10U-10-X-S4-SS  [C0402]  415.05 313.14 135 top
7C124  0.1U-35-X-S2-MU  [C0201]  418.55 311.94 180 top
7C125  10U-10-X-S4-SS  [C0402]  432.16 317.13 90 top
7C126  0.1U-35-X-S2-MU  [C0201]  432.11 315.75 180 top
7C127  10U-10-X-S4-SS  [C0402]  470.37 287.31 270 top
7C128  0.1U-35-X-S2-MU  [C0201]  472.91 287.31 270 top
7C129  10U-10-X-S4-SS  [C0402]  412.04 300.68 180 bottom
7C130  0.1U-25-X-S4-TY  [C0402]  522.46 420.38 270 bottom
7C131  22U-10-T-SA  [CODE_A]  516.92 417.82 180 bottom
7C132  22U-10-T-SA  [CODE_A]  516.92 422.95 180 top
7C133  22U-10-T-SA  [CODE_A]  516.92 420.39 180 top
7C134  22U-10-T-SA  [CODE_A]  516.92 420.39 180 bottom
7C135  22U-10-T-SA  [CODE_A]  516.92 422.95 180 bottom
7C136  10U-10-X-S4-SS  [C0402]  426.61 327.74 90 bottom
7C137  0.1U-25-X-S4-TY  [C0402]  425.5 327.74 90 bottom
7C138  NC/10U-10-X-S4-SS  [C0402]  427.73 327.74 90 bottom
7C139  22U-25-X-S8-MU  [C0805]  415.27 327.42 270 bottom
7C140  47U-16-T-SC  [CODE_C]  451.53 323.14 270 bottom
7C141  10U-16-T-SA  [CODE_A]  451.53 323.14 270 top
7C142  22U-25-X-S8-MU  [C0805]  417.56 327.42 270 bottom
7C143  NC/10P-50-N-S4-WA  [C0402]  435.78 310.66 180 bottom
7C144  NC/10P-50-N-S4-WA  [C0402]  435.78 309.49 180 bottom
7C145  NC/10P-50-N-S4-WA  [C0402]  528.27 302.37 270 top
7C146  NC/10P-50-N-S4-WA  [C0402]  528.27 299.17 270 top
7C147  NC/10P-50-N-S4-WA  [C0402]  528.27 309.64 270 top
7C148  NC/10P-50-N-S4-WA  [C0402]  528.27 306.44 270 top
7C149  NC/10P-50-N-S4-WA  [C0402]  528.27 293.74 270 top
7C150  NC/10P-50-N-S4-WA  [C0402]  528.27 290.54 270 top
7C152  0.1U-35-X-S2-MU  [C0201]  428.44 311.27 270 bottom
7C153  CNC-S2  [C0201]  430.9 307.1 180 bottom
7D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  432.51 292.17 30 top
7D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  429.02 288.35 0 top
7D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  424 287.38 180 top
7J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  520.85 286.01 90 top
7J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  527.86 422.92 90 top
7J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  527.07 286.01 90 top
7J4  HDR-8X1-M  [JP_8P_100]  543.61 371.74 90 top
7J5  HDR-1X1-M  [JP_1P_RD070_040]  512.94 415.04 270 top
7J6  HDR-2X1-M  [JP_2P_100]  515.85 415.04 270 top
7J7  HDR-2X1-M  [JP_2P_100]  520.85 157.26 0 top
7J8  HDR-2X1-M  [JP_2P_100]  524.66 157.26 0 top
7J9  HDR-2X1-M  [JP_2P_100]  517.04 157.26 0 top
7K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  462.05 290.81 180 bottom
7K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  462.05 297.82 180 bottom
7K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  462.05 304.83 180 bottom
7K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  510.97 282.96 180 bottom
7K5  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  444.28 330.8 270 bottom
7K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  519.15 407.22 270 bottom
7K7  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  461.74 281.31 90 bottom
7K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  510.97 291.36 180 bottom
7K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  448.52 283.36 180 bottom
7K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  485.14 300 180 bottom
7K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  510.97 307.26 180 bottom
7K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  499.54 300 180 bottom
7K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  510.97 300 180 bottom
7K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  485.14 307.26 180 bottom
7K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  499.54 307.26 180 bottom
7K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  488.11 282.96 180 bottom
7K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  488.11 291.36 180 bottom
7K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  499.54 291.36 180 bottom
7K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  421.93 323.97 90 bottom
7K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  409.46 312.44 0 bottom
7K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  406.35 301.95 90 bottom
7K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  427.36 341.2 90 bottom
7K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  419.93 332.41 0 bottom
7K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.82 340.05 0 bottom
7K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  432.96 332.35 0 bottom
7K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  431.74 323.97 90 bottom
7K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  531.75 282.76 90 bottom
7K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  531.75 294.19 90 bottom
7K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  531.75 305.62 90 bottom
7K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  522.4 300 180 bottom
7K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  522.4 307.26 180 bottom
7K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  522.4 291.36 180 bottom
7K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  526.11 407.22 270 bottom
7L1  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  410.75 307.9 270 bottom
7L3  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  436.06 325.2 90 bottom
7L4  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  426.25 325.2 90 bottom
7R1  0-5-S2  [R0201]  428.84 297.94 315 top
7R2  0-5-S2  [R0201]  427.06 297.2 315 top
7R3  0-5-S2  [R0201]  429.44 293.91 270 top
7R4  NC/0-5-S2  [R0201]  429.14 294.21 0 top
7R5  0-5-S2  [R0201]  425.35 296.59 270 bottom
7R6  0-5-S2  [R0201]  423.58 297.25 270 top
7R7  0-5-S2  [R0201]  423.58 289.9 270 top
7R8  NC/0-5-S2  [R0201]  423.88 290.2 180 top
7R9  0-5-S2  [R0201]  423.58 297.25 270 bottom
7R10  0-5-S4  [R0402]  471.79 306.73 270 top
7R11  0-5-S4  [R0402]  473.06 306.73 270 top
7R12  NC/10K-1-S4  [R0402]  475.7 287.31 270 top
7R13  0-5-S4  [R0402]  474.43 287.31 270 top
7R14  NC/10K-1-S4  [R0402]  474.33 306.73 270 top
7R15  0-5-S4  [R0402]  476.97 287.31 270 top
7R16  0-5-S4  [R0402]  475.6 306.73 270 top
7R17  0-5-S4  [R0402]  478.24 287.31 270 top
7R18  NC/10K-1-S4  [R0402]  476.71 306.73 270 top
7R19  0-5-S4  [R0402]  518.41 286.01 0 bottom
7R20  0-5-S4  [R0402]  518.41 280.93 0 bottom
7R21  0-5-S4  [R0402]  518.41 278.39 0 bottom
7R22  45.3-1-S4  [R0402]  439.07 332.79 90 bottom
7R23  45.3-1-S4  [R0402]  466.95 279.31 270 bottom
7R24  0-5-S4  [R0402]  525.27 422.9 0 bottom
7R25  45.3-1-S4  [R0402]  439.07 328.8 270 bottom
7R26  45.3-1-S4  [R0402]  466.95 283.3 90 bottom
7R27  0-5-S4  [R0402]  525.27 417.82 0 bottom
7R28  0-5-S4  [R0402]  525.27 415.28 0 bottom
7R29  NC/45.3-1-S4  [R0402]  488.83 287.2 270 bottom
7R30  0-5-S4  [R0402]  524.63 286.01 0 bottom
7R31  0-5-S4  [R0402]  524.63 280.93 0 bottom
7R32  0-5-S4  [R0402]  524.63 278.39 0 bottom
7R33  NC/45.3-1-S4  [R0402]  489.97 287.2 90 bottom
7R34  10K-1-S4  [R0402]  543.61 374.28 90 bottom
7R35  10K-1-S4  [R0402]  541.07 374.28 90 bottom
7R36  10K-1-S4  [R0402]  538.53 374.28 90 bottom
7R37  10K-1-S4  [R0402]  535.99 374.28 90 bottom
7R38  0-5-S4  [R0402]  541.2 384.44 180 bottom
7R39  10K-1-S4  [R0402]  533.45 374.28 90 bottom
7R40  10K-1-S4  [R0402]  530.91 374.28 90 bottom
7R41  10K-1-S4  [R0402]  528.37 374.28 90 bottom
7R42  0-5-S4  [R0402]  528.24 384.44 0 bottom
7R43  12K-1-S4  [R0402]  440.01 307.6 0 bottom
7R45  32.4-1-S4  [R0402]  491.38 301.21 270 bottom
7R47  32.4-1-S4  [R0402]  491.38 308.47 270 bottom
7R48  0-5-S4  [R0402]  402.74 298.45 90 bottom
7R49  NC/0-5-S4  [R0402]  409.96 298.45 90 bottom
7R50  0-5-S4  [R0402]  445.32 343.76 180 top
7R51  NC/0-5-S4  [R0402]  413.58 331.32 270 bottom
7R53  0-5-S4  [R0402]  426.61 334.45 90 bottom
7R54  NC/0-5-S4  [R0402]  426.61 330.25 270 bottom
7R55  0-5-S4  [R0402]  415.43 336.09 180 bottom
7R57  NC/10K-1-S4  [R0402]  512.27 286.59 180 bottom
7R58  NC/10K-1-S4  [R0402]  512.27 279.33 180 bottom
7R59  NC/10K-1-S4  [R0402]  512.27 295 180 bottom
7R60  NC/10K-1-S4  [R0402]  512.27 287.73 180 bottom
7R61  0-5-S4  [R0402]  539.67 423.32 180 bottom
7R62  0-5-S4  [R0402]  536.67 423.32 0 bottom
7R63  0-5-S4  [R0402]  493.7 308.47 270 bottom
7R64  0-5-S4  [R0402]  492.54 308.47 270 bottom
7R65  0-5-S4  [R0402]  492.54 306.05 90 bottom
7R66  0-5-S4  [R0402]  493.7 306.05 90 bottom
7R67  0-5-S4  [R0402]  493.7 301.21 270 bottom
7R68  0-5-S4  [R0402]  492.54 301.21 270 bottom
7R69  0-5-S4  [R0402]  492.54 298.79 90 bottom
7R70  0-5-S4  [R0402]  493.7 298.79 90 bottom
7R71  2-5-D-2  [RC02W_27MM]  548.2 280.96 0 bottom
7R72  2-5-D-2  [RC02W_27MM]  548.2 292.39 0 bottom
7R73  2-5-D-2  [RC02W_27MM]  548.2 303.82 0 bottom
7R74  0-5-S4  [R0402]  491.38 306.05 90 bottom
7R75  0-5-S4  [R0402]  491.38 298.79 90 bottom
7R76  0-5-S4  [R0402]  440.01 303.24 180 bottom
7R77  0-5-S4  [R0402]  435.77 312.13 180 bottom
7R78  0-5-S4  [R0402]  428.92 317.13 270 bottom
7R79  0-5-S4  [R0402]  423.37 317.13 270 bottom
7R81  0-5-S4  [R0402]  440.01 305.38 180 bottom
7R82  0-5-S4  [R0402]  440.01 308.7 180 bottom
7R83  0-5-S4  [R0402]  440.01 306.5 180 bottom
7SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  434.76 289.13 210 top
7SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  429.44 284.03 180 top
7SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  423.58 283.07 180 top
7ST3  SHORT  [DEFAULT_SHORT_SMALL]  419.99 314.68 180 top
7ST4  SHORT  [DEFAULT_SHORT_SMALL]  426.64 332.76 0 top
7ST5  SHORT  [DEFAULT_SHORT_SMALL]  426.64 332 0 top
7ST8  SHORT  [DEFAULT_SHORT_SMALL]  445.89 347.83 180 bottom
7ST11  SHORT  [DEFAULT_SHORT_SMALL]  425.68 318.9 0 top
7ST12  SHORT  [DEFAULT_SHORT_SMALL]  427.51 320.68 180 bottom
7ST13  SHORT  [DEFAULT_SHORT_SMALL]  402.74 300.69 270 bottom
7ST14  SHORT  [DEFAULT_SHORT_SMALL]  416.63 337.12 0 bottom
7ST15  SHORT  [DEFAULT_SHORT_SMALL]  441.74 304.4 270 bottom
7ST16  SHORT  [DEFAULT_SHORT_SMALL]  419.83 313.79 180 top
7ST17  SHORT  [DEFAULT_SHORT_SMALL]  427.53 319.25 180 bottom
7ST18  SHORT  [DEFAULT_SHORT_SMALL]  445.95 348.84 180 bottom
7ST19  SHORT  [DEFAULT_SHORT_SMALL]  423.62 318.21 0 top
7SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  534.72 380.63 180 top
7SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  538.17 419.51 180 top
7U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  427.66 293.75 270 top
7U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  425.36 289.74 270 top
7U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  473.7 297.76 0 bottom
7Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  413 303.89 45 top
038RT-8730CN16Q-A100  REF-CODE-PCB  [PCB_CODE]  45.97 505.36 0 top
980RT-8730CN-18K-  REF-CODE-CHIP  [CHIP_CODE]  37.18 509.02 0 top
ATX_VD0V9  HDR-8X2-M  [CONN_8X2_2P54MM_PH]  527.24 143.04 90 top
ATX_VD1V8  HDR-8X2-M  [CONN_8X2_2P54MM_PH]  390.85 143.04 90 top
ATX_VD33  HDR-8X2-M  [CONN_8X2_2P54MM_PH]  262.61 143.04 90 top
BD1  BD120-1.5A-S4-MU  [FB0402]  299.97 257.1 270 bottom
BD2  BD120-1.5A-S4-MU  [FB0402]  315.74 254.24 180 bottom
BD3  BD120-1.5A-S4-MU  [FB0402]  298.93 257.1 270 bottom
BD5  BD120-1.5A-S4-MU  [FB0402]  296.11 247.53 0 bottom
BD7  BD120-1.5A-S4-MU  [FB0402]  301.01 257.1 270 bottom
BD9  BD120-1.5A-S4-MU  [FB0402]  319.98 244.31 180 bottom
BD11  BD120-1.5A-S4-MU  [FB0402]  315.74 253.2 180 bottom
BD12  BD120-1.5A-S4-MU  [FB0402]  307.85 257.1 270 bottom
BD13  BD120-1.5A-S4-MU  [FB0402]  296.14 240.68 0 bottom
BD15  BD120-1.5A-S4-MU  [FB0402]  299.26 236.89 0 bottom
BD16  BD120-1.5A-S4-MU  [FB0402]  302.57 243.52 180 bottom
BD17  BD120-1.5A-S4-MU  [FB0402]  302.57 242.48 180 bottom
BD18  BD120-1.5A-S4-MU  [FB0402]  314.49 239.43 180 bottom
BD19  BD120-1.5A-S4-MU  [FB0402]  314.49 238.23 180 bottom
BD20  BD120-1.5A-S4-MU  [FB0402]  294.56 247.48 270 bottom
BD21  BD120-1.5A-S4-MU  [FB0402]  314.49 236.09 180 bottom
BD22  BD120-1.5A-S4-MU  [FB0402]  301.08 233.24 180 bottom
BD23  BD120-1.5A-S4-MU  [FB0402]  301.08 235.3 0 bottom
BD27  NC/BD120-1.5A-S4-MU  [FB0402]  242.51 231.73 180 bottom
BD28  BD120-1.5A-S4-MU  [FB0402]  295.59 250.31 270 bottom
BD29  BD120-1.5A-S4-MU  [FB0402]  305.59 257.1 270 bottom
BD30  BD120-1.5A-S4-MU  [FB0402]  295.74 253.12 225 bottom
BD31  BD120-1.5A-S4-MU  [FB0402]  312.63 256.63 180 bottom
BD32  BD120-1.5A-S4-MU  [FB0402]  265.06 232.15 270 top
BD33  BD120-1.5A-S4-MU  [FB0402]  298.54 127.89 270 bottom
BD34  BD120-1.5A-S4-MU  [FB0402]  302.26 231.51 0 bottom
BD35  BD120-1.5A-S4-MU  [FB0402]  312.41 236.09 180 bottom
BD36  BD120-1.5A-S4-MU  [FB0402]  294.09 240.69 0 bottom
BD37  BD120-1.5A-S4-MU  [FB0402]  309.98 257.1 270 bottom
BD42  NC/BD120-3A-S8  [FB0805]  280.82 114.96 270 bottom
BD43  NC/BD120-3A-S8  [FB0805]  408.2 114.81 270 bottom
BD44  NC/BD120-3A-S8  [FB0805]  338.15 111.76 270 bottom
BD48  NC/BD120-3A-S8  [FB0805]  369.11 111.86 90 bottom
BD50  NC/BD120-3A-S8  [FB0805]  395.58 167 0 bottom
BD51  NC/BD120-3A-S8  [FB0805]  395.58 173.96 0 bottom
BD52  NC/BD120-3A-S8  [FB0805]  395.58 180.7 0 bottom
BD56  NC/BD120-3A-S8  [FB0805]  395.58 188.62 0 bottom
BD57  NC/BD120-3A-S8  [FB0805]  176.35 112.52 270 bottom
BD58  NC/BD120-3A-S8  [FB0805]  186.51 112.52 270 bottom
BD59  NC/BD120-3A-S8  [FB0805]  555.65 112.52 270 bottom
BD60  NC/BD120-3A-S8  [FB0805]  565.81 112.52 270 bottom
BD61  NC/BD120-3A-S8  [FB0805]  183.84 436.02 90 bottom
BD62  NC/BD120-3A-S8  [FB0805]  173.68 436.02 90 bottom
BD63  NC/BD120-3A-S8  [FB0805]  565.55 436.02 90 bottom
BD64  NC/BD120-3A-S8  [FB0805]  555.39 436.02 90 bottom
BD65  NC/BD120-3A-S8  [FB0805]  421.51 436.02 90 bottom
BD66  NC/BD120-3A-S8  [FB0805]  411.35 436.02 90 bottom
BD67  NC/BD120-3A-S8  [FB0805]  401.19 436.02 90 bottom
BD68  NC/BD120-3A-S8  [FB0805]  391.03 436.02 90 bottom
BD69  NC/BD120-3A-S8  [FB0805]  316.79 188.42 180 bottom
BD70  NC/BD120-3A-S8  [FB0805]  316.79 181.46 180 bottom
BD71  NC/BD120-3A-S8  [FB0805]  316.79 174.73 180 bottom
BD72  NC/BD120-3A-S8  [FB0805]  316.79 166.8 180 bottom
BDB74  BD100-3A-SA  [FB1206]  47.58 405.72 0 bottom
BDB75  BD100-3A-SA  [FB1206]  47.58 408.9 0 bottom
BDB76  BD100-3A-SA  [FB1206]  47.58 424.77 0 bottom
BDB77  BD100-3A-SA  [FB1206]  47.58 427.95 0 bottom
BDB80  BD100-3A-SA  [FB1206]  223.88 144.94 270 bottom
BDB81  BD100-3A-SA  [FB1206]  253.72 127.8 0 bottom
BDB82  BD100-3A-SA  [FB1206]  352.12 144.94 270 bottom
BDB83  BD100-3A-SA  [FB1206]  381.96 127.8 0 bottom
BDB86  BD100-3A-SA  [FB1206]  488.5 144.94 270 bottom
BDB87  BD100-3A-SA  [FB1206]  518.35 127.8 0 bottom
C1  NC/1P-25-N-S2-WA  [C0201]  307.94 238.42 45 top
C2  10P-50-N-S2-MU  [C0201]  312.27 233.44 300 top
C3  NC/1.2P-50-N-S2-MU  [C0201]  309.75 237.46 45 top
C4  NC/1P-25-N-S2-WA  [C0201]  306.58 238.11 225 top
C5  NC/1.2P-50-N-S2-MU  [C0201]  307.55 236.29 225 top
C6  10P-50-N-S2-MU  [C0201]  309.44 232.63 90 top
C7  NC/10P-50-N-S2-MU  [C0201]  309.14 232.33 180 top
C8  CNC-S2  [C0201]  309.14 227.46 180 top
C9  NC/1P-25-N-S2-WA  [C0201]  305.65 237.58 180 bottom
C10  NC/1.2P-50-N-S2-MU  [C0201]  305.05 235.61 180 bottom
C11  NC/1P-25-N-S2-WA  [C0201]  303.88 238.23 180 top
C12  NC/1.2P-50-N-S2-MU  [C0201]  303.28 236.26 180 top
C13  10P-50-N-S2-MU  [C0201]  303.58 228.62 90 top
C14  NC/10P-50-N-S2-MU  [C0201]  303.88 228.32 0 top
C15  CNC-S2  [C0201]  303.88 226.5 0 top
C16  NC/1P-25-N-S2-WA  [C0201]  303.88 238.23 180 bottom
C17  NC/0.1U-35-X-S2-MU  [C0201]  312.4 242.06 180 bottom
C18  NC/0.1U-35-X-S2-MU  [C0201]  312.4 241.21 180 bottom
C19  NC/1.2P-50-N-S2-MU  [C0201]  303.28 236.26 180 bottom
C20  0.1U-35-X-S2-MU  [C0201]  312.4 238.98 0 bottom
C21  0.1U-35-X-S2-MU  [C0201]  312.4 239.83 0 bottom
C22  0.1U-16-X-S4-MU  [C0402#2]  262.52 232.12 90 top
C23  0.9P-50-N-S4-MU  [C0402]  295.37 245.27 270 top
C24  0.1U-25-X-S4-TY  [C0402#2]  242.54 232.81 0 bottom
C25  0.9P-50-N-S4-MU  [C0402]  295.37 242.5 90 top
C38  1P-50-N-S4-WA  [C0402#2]  234.52 224.43 0 bottom
C39  22P-50-N-S4-AVX  [C0402#2]  231.12 224.43 0 bottom
C40  1P-50-N-S4-WA  [C0402#2]  234.52 231.7 0 bottom
C41  22P-50-N-S4-AVX  [C0402#2]  231.12 231.7 0 bottom
C44  0.1U-35-X-S2-MU  [C0201]  302.71 247.36 0 bottom
C45  0.1U-35-X-S2-MU  [C0201]  311.18 251.27 270 bottom
C46  0.1U-35-X-S2-MU  [C0201]  302.71 246.51 0 bottom
C47  0.1U-35-X-S2-MU  [C0201]  311.41 244.05 180 bottom
C48  0.1U-35-X-S2-MU  [C0201]  298.55 244.6 180 top
C49  0.1U-35-X-S2-MU  [C0201]  311.41 247.77 180 bottom
C52  0.1U-35-X-S2-MU  [C0201]  302.71 248.21 0 bottom
C53  10U-10-X-S4-SS  [C0402#2]  286.53 248.35 90 bottom
C54  0.1U-35-X-S2-MU  [C0201]  307.6 251.27 270 bottom
C55  0.1U-25-X-S4-TY  [C0402#2]  288.8 248.35 90 bottom
C56  0.1U-35-X-S2-MU  [C0201]  315.52 245.28 0 top
C57  NC/10U-10-X-S4-SS  [C0402#2]  287.66 248.35 90 bottom
C58  0.1U-35-X-S2-MU  [C0201]  302.44 255.8 90 top
C59  0.1U-35-X-S2-MU  [C0201]  311.4 249.26 180 bottom
C60  10U-10-X-S4-SS  [C0402#2]  317.88 254.29 0 bottom
C61  0.1U-35-X-S2-MU  [C0201]  306.65 251.26 270 bottom
C62  22U-25-X-S8-MU  [C0805]  286.41 256.59 0 bottom
C63  22U-25-X-S8-MU  [C0805]  286.41 258.62 0 bottom
C64  0.1U-35-X-S2-MU  [C0201]  298.55 242.47 180 top
C65  47U-16-T-SC  [CODE_C]  259.93 238.07 180 bottom
C66  10U-16-T-SA  [CODE_A]  259.97 238.07 180 top
C67  10U-10-X-S4-SS  [C0402#2]  317.88 253.17 0 bottom
C68  22U-10-T-SA  [CODE_A]  317.27 210.88 0 bottom
C69  22U-10-T-SA  [CODE_A]  317.27 213.47 0 bottom
C70  22U-10-T-SA  [CODE_A]  317.27 216.04 0 bottom
C71  22U-10-T-SA  [CODE_A]  317.27 213.47 0 top
C72  22U-10-T-SA  [CODE_A]  317.27 210.88 0 top
C73  10U-10-X-S4-SS  [C0402]  294.06 239.62 180 bottom
C74  0.1U-35-X-S2-MU  [C0201]  305.35 242.65 90 bottom
C75  0.1U-35-X-S2-MU  [C0201]  315.52 242.53 0 top
C76  10U-10-X-S4-SS  [C0402#2]  299.23 237.96 180 bottom
C77  0.1U-35-X-S2-MU  [C0201]  304.54 242.65 90 bottom
C78  0.1U-35-X-S2-MU  [C0201]  298.55 243.15 180 top
C79  0.1U-35-X-S2-MU  [C0201]  298.55 241.78 180 top
C83  10U-10-X-S4-SS  [C0402#2]  314.52 240.52 0 bottom
C84  0.1U-35-X-S2-MU  [C0201]  306.87 242.65 90 bottom
C85  0.1U-35-X-S2-MU  [C0201]  306.14 242.65 90 bottom
C88  0.1U-35-X-S2-MU  [C0201]  298.55 245.26 180 top
C89  10U-10-X-S4-SS  [C0402#2]  293.03 248.85 180 bottom
C90  10U-10-X-S4-SS  [C0402#2]  314.52 237.15 0 bottom
C91  0.1U-35-X-S2-MU  [C0201]  306.46 239.87 0 bottom
C92  22U-25-X-S8-MU  [C0805]  329.28 212.93 180 bottom
C93  22U-25-X-S8-MU  [C0805]  329.28 212.93 180 top
C94  47U-16-T-SC  [CODE_C]  329.21 209.62 180 bottom
C95  10U-16-T-SA  [CODE_A]  329.21 209.62 180 top
C96  10U-10-X-S4-SS  [C0402#2]  316.6 240.52 0 bottom
C97  10U-10-X-S4-SS  [C0402#2]  300.61 232.74 270 top
C98  0.1U-35-X-S2-MU  [C0201]  299.67 233.64 270 top
C99  10U-10-X-S4-SS  [C0402#2]  301.55 234.8 270 top
C100  0.1U-35-X-S2-MU  [C0201]  301.83 237.95 270 top
C101  10U-10-X-S4-SS  [C0402#2]  293.03 247.01 180 bottom
C102  0.1U-35-X-S2-MU  [C0201]  311.41 245.56 180 bottom
C105  0.1U-35-X-S2-MU  [C0201]  311.4 246.35 180 bottom
C106  10U-10-X-S4-SS  [C0402#2]  316.43 267.74 90 bottom
C107  0.1U-35-X-S2-MU  [C0201]  315.52 246.65 0 top
C108  0.1U-25-X-S4-TY  [C0402#2]  315.31 267.74 90 bottom
C109  NC/10U-10-X-S4-SS  [C0402#2]  317.55 267.74 90 bottom
C110  1U-10-X-S4-MU  [C0402#2]  317.14 242.53 180 top
C111  10U-10-X-S4-SS  [C0402#2]  295.59 249.34 270 top
C112  0.1U-35-X-S2-MU  [C0201]  297.6 250.06 270 top
C113  10U-25-X-S6-MU  [C0603]  321.74 247.85 90 bottom
C116  22U-25-X-S8-MU  [C0805]  306.8 259.97 180 bottom
C117  22U-25-X-S8-MU  [C0805]  306.8 262.13 180 bottom
C118  10U-10-X-S4-SS  [C0402#2]  304.5 257.13 90 bottom
C119  0.1U-35-X-S2-MU  [C0201]  305.72 251.26 270 bottom
C120  47U-16-T-SC  [CODE_C]  274.8 209.17 0 bottom
C121  10U-16-T-SA  [CODE_A]  274.8 209.17 0 top
C122  10U-10-X-S4-SS  [C0402#2]  316.6 239.41 0 bottom
C123  10U-10-X-S4-SS  [C0402#2]  295.05 253.14 135 top
C124  0.1U-35-X-S2-MU  [C0201]  298.55 251.94 180 top
C125  10U-10-X-S4-SS  [C0402#2]  312.16 257.13 90 top
C126  0.1U-35-X-S2-MU  [C0201]  312.11 255.75 180 top
C127  10U-10-X-S4-SS  [C0402#2]  263.79 232.12 90 top
C128  0.1U-35-X-S2-MU  [C0201]  261.25 232.12 90 top
C129  10U-10-X-S4-SS  [C0402#2]  292.04 240.68 180 bottom
C130  0.1U-25-X-S4-TY  [C0402#2]  297.45 127.92 90 bottom
C131  22U-10-T-SA  [CODE_A]  302.99 130.48 0 bottom
C132  22U-10-T-SA  [CODE_A]  302.99 125.35 0 top
C133  22U-10-T-SA  [CODE_A]  302.99 127.92 0 top
C134  22U-10-T-SA  [CODE_A]  302.99 127.92 0 bottom
C135  22U-10-T-SA  [CODE_A]  302.99 125.35 0 bottom
C136  10U-10-X-S4-SS  [C0402#2]  306.61 267.74 90 bottom
C137  0.1U-25-X-S4-TY  [C0402#2]  305.5 267.74 90 bottom
C138  NC/10U-10-X-S4-SS  [C0402#2]  307.73 267.74 90 bottom
C139  22U-25-X-S8-MU  [C0805]  295.27 267.42 270 bottom
C140  47U-16-T-SC  [CODE_C]  281.41 211.07 270 bottom
C141  10U-16-T-SA  [CODE_A]  281.41 211.07 270 top
C142  22U-25-X-S8-MU  [C0805]  297.56 267.42 270 bottom
C143  NC/10P-50-N-S4-WA  [C0402]  315.78 250.66 180 bottom
C144  NC/10P-50-N-S4-WA  [C0402]  315.78 249.49 180 bottom
C145  NC/10P-50-N-S4-WA  [C0402]  205.88 217.06 90 top
C146  NC/10P-50-N-S4-WA  [C0402]  205.88 220.26 90 top
C147  NC/10P-50-N-S4-WA  [C0402]  205.88 209.79 90 top
C148  NC/10P-50-N-S4-WA  [C0402#2]  205.88 212.99 90 top
C149  NC/10P-50-N-S4-WA  [C0402#3]  205.88 225.69 90 top
C150  NC/10P-50-N-S4-WA  [C0402]  205.88 228.89 90 top
C152  0.1U-35-X-S2-MU  [C0201]  308.44 251.27 270 bottom
C153  CNC-S2  [C0201]  310.9 247.1 180 bottom
C524  0.1U-50-X7R-S4-YA  [C0402]  356.31 188.14 180 bottom
C525  0.1U-50-X7R-S4-YA  [C0402]  386.79 188.14 180 bottom
C528  0.1U-50-X7R-S4-YA  [C0402]  371.55 188.14 180 bottom
C539  0.1U-50-X7R-S4-YA  [C0402]  341.07 188.14 180 bottom
C540  10U-10-X-S6-MU  [C0603]  384.88 184.33 180 bottom
C541  10U-10-X-S6-MU  [C0603]  384.88 169.09 180 bottom
C542  10U-10-X-S6-MU  [C0603]  369.64 184.33 180 bottom
C543  10U-10-X-S6-MU  [C0603]  369.64 169.09 180 bottom
C544  10U-10-X-S6-MU  [C0603]  354.4 184.33 180 bottom
C545  10U-10-X-S6-MU  [C0603]  354.4 169.09 180 bottom
C546  10U-10-X-S6-MU  [C0603]  339.16 184.33 180 bottom
C547  10U-10-X-S6-MU  [C0603]  339.16 169.09 180 bottom
C548  0.1U-50-X7R-S4-YA  [C0402]  386.79 172.9 180 bottom
C549  0.1U-50-X7R-S4-YA  [C0402]  371.55 172.9 180 bottom
C550  0.1U-50-X7R-S4-YA  [C0402]  341.07 172.9 180 bottom
C551  0.1U-50-X7R-S4-YA  [C0402]  356.31 172.9 180 bottom
C552  0.1U-50-X7R-S4-YA  [C0402]  341.07 157.66 180 bottom
C553  0.1U-50-X7R-S4-YA  [C0402]  356.31 157.66 180 bottom
C554  0.1U-50-X7R-S4-YA  [C0402]  386.79 157.66 180 bottom
C555  0.1U-50-X7R-S4-YA  [C0402]  371.55 157.66 180 bottom
CB631  220U-10-T-SD  [CODE_D]  49.49 393.66 0 bottom
CB632  220U-10-T-SD  [CODE_D]  49.49 386.04 0 bottom
CB633  10U-10-T-SA-AVX  [CODE_A]  46.95 380.96 0 bottom
CB634  0.1U-16-X5R-S2-WA  [C0201]  40.58 380.96 180 bottom
CB635  220U-10-T-SD  [CODE_D]  36.79 420.33 180 bottom
CB636  10U-10-T-SA-AVX  [CODE_A]  44.66 418.17 270 bottom
CB637  0.1U-16-X5R-S2-WA  [C0201]  46.95 422.87 0 bottom
CB638  0.1U-16-X5R-S2-WA  [C0201]  48.22 403.18 0 bottom
CB639  10U-35-T-SC  [CODE_C]  49.49 400.01 0 bottom
CB640  47U-25-T-SD-AVX  [CODE_D]  36.79 400.01 180 bottom
CB641  0.1U-16-X5R-S2-WA  [C0201]  54.57 433.66 0 bottom
CB642  10U-10-T-SA-AVX  [CODE_A]  55.2 431.12 0 bottom
CB643  220U-10-T-SD  [CODE_D]  56.47 426.04 0 bottom
CB647  0.1U-16-X5R-S2-WA  [C0201]  52.98 415.88 0 bottom
CB648  10U-35-T-SC  [CODE_C]  55.2 412.71 0 bottom
CB649  47U-25-T-SD-AVX  [CODE_D]  56.47 406.99 0 bottom
CB650  0.1U-16-X5R-S2-WA  [C0201]  228.47 129.76 0 bottom
CB651  3300P-50-X7R-S4-HS  [C0402]  231.5 129.07 180 bottom
CB652  CNC-S4  [C0402]  232.13 127.16 270 bottom
CB653  0.1U-16-X5R-S2-WA  [C0201]  230.23 139.23 270 bottom
CB654  220U-10-T-SD  [CODE_D]  223.88 136.05 270 bottom
CB655  10U-10-X-S4-SS  [C0402]  228.96 139.23 90 bottom
CB656  100P-50-N-S4-YA  [C0402]  224.51 148.12 90 bottom
CB657  0.1U-16-X5R-S2-WA  [C0201]  223.24 148.12 270 bottom
CB658  0.1U-16-X5R-S2-WA  [C0201]  230.86 141.13 0 bottom
CB659  NC/100P-50-N-S4-MU  [C0402]  234.67 135.42 270 bottom
CB660  CNC-S4  [C0402]  235.31 130.97 180 bottom
CB661  220U-10-T-SD  [CODE_D]  250.55 136.05 90 bottom
CB662  0.1U-16-X-S4-MU  [C0402]  245.47 127.16 270 bottom
CB663  10U-10-X-S4-SS  [C0402]  247.37 127.16 270 bottom
CB664  220U-10-T-SD  [CODE_D]  256.26 136.05 90 bottom
CB665  0.1U-16-X5R-S2-WA  [C0201]  356.71 129.76 0 bottom
CB666  3300P-50-X7R-S4-HS  [C0402]  359.74 129.07 180 bottom
CB667  CNC-S4  [C0402]  360.37 127.16 270 bottom
CB668  0.1U-16-X5R-S2-WA  [C0201]  358.47 139.23 270 bottom
CB669  220U-10-T-SD  [CODE_D]  352.12 136.05 270 bottom
CB670  10U-10-X-S4-SS  [C0402]  357.2 139.23 90 bottom
CB671  100P-50-N-S4-YA  [C0402]  352.75 148.12 90 bottom
CB672  0.1U-16-X5R-S2-WA  [C0201]  351.48 148.12 270 bottom
CB673  0.1U-16-X5R-S2-WA  [C0201]  359.1 141.13 0 bottom
CB674  NC/100P-50-N-S4-MU  [C0402]  362.91 135.42 270 bottom
CB675  CNC-S4  [C0402]  363.55 130.97 180 bottom
CB676  220U-10-T-SD  [CODE_D]  378.79 136.05 90 bottom
CB677  0.1U-16-X-S4-MU  [C0402]  373.71 127.16 270 bottom
CB678  10U-10-X-S4-SS  [C0402]  375.61 127.16 270 bottom
CB679  220U-10-T-SD  [CODE_D]  384.5 136.05 90 bottom
CB695  0.1U-16-X5R-S2-WA  [C0201]  493.09 129.76 0 bottom
CB696  3300P-50-X7R-S4-HS  [C0402]  496.12 129.07 180 bottom
CB697  CNC-S4  [C0402]  496.76 127.16 270 bottom
CB698  0.1U-16-X5R-S2-WA  [C0201]  494.85 139.23 270 bottom
CB699  220U-10-T-SD  [CODE_D]  488.5 136.05 270 bottom
CB700  10U-10-X-S4-SS  [C0402]  493.58 139.23 90 bottom
CB701  100P-50-N-S4-YA  [C0402]  489.14 148.12 90 bottom
CB702  0.1U-16-X5R-S2-WA  [C0201]  487.87 148.12 270 bottom
CB703  0.1U-16-X5R-S2-WA  [C0201]  495.49 141.13 0 bottom
CB704  NC/100P-50-N-S4-MU  [C0402]  499.3 135.42 270 bottom
CB705  CNC-S4  [C0402]  499.93 130.97 180 bottom
CB706  220U-10-T-SD  [CODE_D]  515.17 136.05 90 bottom
CB707  0.1U-16-X-S4-MU  [C0402]  510.09 127.16 270 bottom
CB708  10U-10-X-S4-SS  [C0402]  512 127.16 270 bottom
CB709  220U-10-T-SD  [CODE_D]  520.89 136.05 90 bottom
CT1  680P-50-X7R-S4-HS  [C0402]  311.14 117.14 90 bottom
CT2  10U-25-X7R-SA  [C1206]  342.38 114.93 180 bottom
CT3  4.7U-25-X7R-S8-TY  [C0805]  342.38 111.03 180 bottom
CT4  10U-25-X7R-SA  [C1206]  363.67 114.93 0 bottom
CT5  4.7U-25-X7R-S8-TY  [C0805]  363.67 112.32 0 bottom
CT6  10U-25-X7R-SA  [C1206]  293.11 111.73 180 bottom
CT7  4.7U-25-X7R-S8-TY  [C0805]  293.11 115.09 180 bottom
CT8  10U-50-X-SB-MU  [C1210]  353.72 111.35 0 bottom
CT9  4.7U-50-X-S8-MU  [C0805]  353.72 115.32 0 bottom
CT10  10U-50-X-SB-MU  [C1210]  374.04 111.35 180 bottom
CT11  4.7U-50-X-S8-MU  [C0805]  374.04 115.32 180 bottom
CT12  10U-50-X-SB-MU  [C1210]  384.13 111.35 180 bottom
CT13  4.7U-50-X-S8-MU  [C0805]  384.13 115.32 180 bottom
CT14  0.1U-16-X-S4-MU-1  [C0402]  391.78 116.12 180 bottom
CT15  680P-50-N-S8  [C0805]  312.77 117.59 90 bottom
CT16  0.1U-25-X-S6  [C0603]  323.96 118.01 180 bottom
CT17  22U-10-T-SA  [CODE_A]  323.37 115.19 180 bottom
CT18  22U-10-T-SA  [CODE_A]  323.37 112.14 180 bottom
CT19  22U-10-T-SA  [CODE_A]  332.71 118.24 0 bottom
CT20  22U-10-T-SA  [CODE_A]  332.71 112.14 0 bottom
CT21  22U-10-T-SA  [CODE_A]  332.71 115.19 0 bottom
D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  312.51 232.17 30 top
D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  309.02 228.35 0 top
D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  304 227.38 180 top
FD1  -  [FD_040_V2]  170.64 207.68 0 top
FD2  -  [FD_040_V2]  568.59 207.68 0 top
FD3  -  [FD_040_V2]  568.59 349.92 0 top
FD4  -  [FD_040_V2]  170.64 349.92 0 top
FD5  -  [FD_040_V2]  568.59 207.68 180 bottom
FD6  -  [FD_040_V2]  568.59 349.92 180 bottom
FD7  -  [FD_040_V2]  170.64 349.92 180 bottom
FD8  -  [FD_040_V2]  170.64 207.68 180 bottom
FD9  -  [FD_040_V2]  160.48 116.24 0 top
FD10  -  [FD_040_V2]  568.59 121.32 0 top
FD11  -  [FD_040_V2]  568.59 431.2 0 top
FD12  -  [FD_040_V2]  170.64 431.2 0 top
FD13  -  [FD_040_V2]  160.48 116.24 180 bottom
FD14  -  [FD_040_V2]  568.59 121.32 180 bottom
FD15  -  [FD_040_V2]  568.59 431.2 180 bottom
FD16  -  [FD_040_V2]  170.64 431.2 180 bottom
FUSEB1  MF-R185-40A-D  [FUSE_12X9P2MM]  41.87 389.85 270 bottom
FUSEB2  MF-R185-40A-D  [FUSE_12X9P2MM]  41.87 430.49 270 bottom
FUSEB3  MF-R185-40A-D  [FUSE_12X9P2MM]  41.87 410.17 270 bottom
H1  M3-HOLE  [M3_NPTH169]  145.24 278.8 0 top
H2  M3-HOLE  [M3_NPTH169]  416.19 116.24 0 top
H3  M3-HOLE  [M3_NPTH169]  375.55 436.28 0 top
H4  M3-HOLE  [M3_NPTH169]  588.91 278.8 0 top
HOLE_CABLE3  DEBUGHOLE-15X15MM  [SLOT_NPTH_SQ15X15MM]  155.4 421.04 0 top
HOLE_CABLE4  DEBUGHOLE-15X15MM  [SLOT_NPTH_SQ15X15MM]  583.83 121.32 0 top
J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  213.31 233.42 270 top
J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  292.04 125.38 270 top
J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  207.08 233.42 270 top
J4  HDR-8X1-M  [JP_8P_100]  286.47 183.3 270 top
J5  HDR-1X1-M  [JP_1P_RD070_040]  306.97 133.26 90 top
J6  HDR-2X1-M  [JP_2P_100]  304.06 133.26 90 top
J7  HDR-2X1-M  [JP_2P_100]  431.7 157.26 0 top
J8  HDR-2X1-M  [JP_2P_100]  435.51 157.26 0 top
J9  HDR-2X1-M  [JP_2P_100]  427.89 157.26 0 top
JB1  ATX-10X2-MR  [CONN_PWR10X2_4P2MM_ML]  38.35 476.05 90 bottom
K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 228.62 0 bottom
K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 221.61 0 bottom
K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 214.6 0 bottom
K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  223.19 236.47 0 bottom
K5  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  324.28 270.8 270 bottom
K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  300.76 141.08 90 bottom
K7  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.41 238.12 270 bottom
K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  223.19 228.07 0 bottom
K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  328.52 223.36 180 bottom
K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  249.02 219.43 0 bottom
K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 212.17 0 bottom
K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 219.43 0 bottom
K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 219.43 0 bottom
K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  249.02 212.17 0 bottom
K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 212.17 0 bottom
K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  246.05 236.47 0 bottom
K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  246.05 228.07 0 bottom
K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#3]  234.62 228.07 0 bottom
K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  301.93 263.97 90 bottom
K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  289.46 252.44 0 bottom
K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  286.35 241.95 90 bottom
K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  310.07 215.01 90 bottom
K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  299.93 272.42 0 bottom
K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  328.52 217 180 bottom
K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  312.96 272.35 0 bottom
K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2#2]  311.74 263.97 90 bottom
K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 236.67 270 bottom
K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 225.24 270 bottom
K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 213.81 270 bottom
K33  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  343.73 215 90 bottom
K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 219.43 0 bottom
K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 212.17 0 bottom
K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 228.07 0 bottom
K37  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 236.47 0 bottom
K38  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  337.38 215 90 bottom
K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  293.8 141.08 90 bottom
KT1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  304.42 115.04 180 bottom
L1  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  290.75 247.9 270 bottom
L3  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  316.06 265.2 90 bottom
L4  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  306.25 265.2 90 bottom
LB1  L10U-3.8A-S10.2X10-GO  [IND_GSSR2104]  241.66 135.42 270 bottom
LB2  L10U-3.8A-S10.2X10-GO  [IND_GSSR2104]  369.9 135.42 270 bottom
LB4  L10U-3.8A-S10.2X10-GO  [IND_GSSR2104]  506.28 135.42 270 bottom
LDB1  LDG-2-S8  [LED_0805]  341.43 118.24 0 top
LDB2  LDG-2-S8  [LED_0805]  364.62 118.24 180 top
LDB3  LDG-2-S8  [LED_0805]  292.16 118.21 0 top
LDB4  LDG-2-S8  [LED_0805]  354.67 118.24 180 top
LDB5  LDG-2-S8  [LED_0805]  373.09 118.24 0 top
LDB6  LDG-2-S8  [LED_0805]  385.08 118.24 180 top
LDB19  LDR-2-S8  [LED_0805]  249.28 125.26 90 top
LDB20  LDR-2-S8  [LED_0805]  377.52 125.26 90 top
LDB22  LDR-2-S8  [LED_0805]  513.9 125.26 90 top
LOGO1  LOGO_RT_Realtek  [LOGO_RT_REALTEK]  336.9 467.84 0 top
LOGO2  -  [LOGO_KT_KSMT]  456.86 176.86 0 top
LRB1  330-1-S6  [R0603]  343.23 118.24 180 bottom
LRB2  330-1-S6  [R0603]  362.82 118.24 0 bottom
LRB3  1K-1-S6  [R0603]  293.96 118.21 0 bottom
LRB4  2K-1-S6  [R0603]  352.87 118.24 180 bottom
LRB5  1.5K-1-S6  [R0603]  374.89 118.24 0 bottom
LRB6  1.5K-1-S6  [R0603]  383.28 118.24 180 bottom
NOREF  -  []  322.68 267.2 0 top
NOREF#2  -  []  71.55 446.92 0 top
NOREF#3  -  []  312.01 244.37 0 top
NOREF#4  -  []  527.52 279.96 90 top
NOREF#5  -  []  427.06 293.68 0 top
NOREF#6  -  []  527.07 214.89 90 top
NOREF#7  -  []  344.1 415.3 90 top
NOREF#8  -  []  308.12 288.85 0 top
NOREF#9  -  []  385.16 338.13 90 top
NOREF#10  -  []  303.58 228.32 0 top
NOREF#11  -  []  187.37 173.52 0 top
NOREF#12  -  []  40.28 380.96 0 top
NOREF#13  -  []  458.45 237.85 0 top
NOREF#14  -  []  427.34 236.08 0 top
NOREF#15  -  []  428.96 339.4 90 top
NOREF#16  -  []  209.96 226.47 0 top
NOREF#17  -  []  313.51 217.31 0 top
NOREF#18  -  []  426.46 302.05 0 top
NOREF#19  -  []  287.08 226.86 90 top
NOREF#20  -  []  426.65 310.96 90 top
NOREF#21  -  []  382.88 300.86 90 top
NOREF#22  -  []  419.15 302.15 0 top
NOREF#23  -  []  352.1 298.98 0 top
NOREF#24  -  []  389.54 297.24 0 top
NOREF#25  -  []  200.81 318.48 90 top
NOREF#26  -  []  200.81 267.36 0 top
NOREF#27  -  []  355.25 168.64 90 top
NOREF#28  -  []  272.51 295.6 0 top
NOREF#29  -  []  426.87 301.41 90 top
NOREF#30  -  []  238.22 210.57 90 top
NOREF#31  -  []  410.08 229.86 90 top
NOREF#32  -  []  223.59 303.45 0 top
NOREF#33  -  []  300.33 330.81 0 top
NOREF#34  -  []  504.66 314.25 90 top
NOREF#35  -  []  348.12 288.85 0 top
NOREF#36  -  []  481.54 233.02 0 top
NOREF#37  -  []  519.84 421.68 90 top
NOREF#38  -  []  336.82 162.12 90 top
NOREF#39  -  []  304.48 286.18 90 top
NOREF#40  -  []  409.07 337.05 90 top
NOREF#41  -  []  425.08 248.86 0 top
NOREF#42  -  []  425.78 289.14 90 top
NOREF#43  -  []  485.09 260.07 0 top
NOREF#44  -  []  362.68 267.2 90 top
NOREF#45  -  []  425.36 289.28 0 top
NOREF#46  -  []  345.68 297.27 90 top
NOREF#47  -  []  384.48 226.18 90 top
NOREF#48  -  []  303.35 297.91 90 top
NOREF#49  -  []  69.58 46.86 0 top
NOREF#50  -  []  414.88 328.37 0 top
NOREF#51  -  []  247.22 244.86 0 top
NOREF#52  -  []  347.31 293.29 0 top
NOREF#53  -  []  307.23 298.3 0 top
NOREF#54  -  []  444.22 338.45 0 top
NOREF#55  -  []  270.81 234.52 90 top
NOREF#56  -  []  348.44 250.97 90 top
NOREF#57  -  []  353.51 214.74 0 top
NOREF#58  -  []  378.4 425.76 90 top
NOREF#59  -  []  463.78 123.34 90 top
NOREF#60  -  []  74.58 41.86 90 top
NOREF#61  -  []  243.37 216.43 0 top
NOREF#62  -  []  310.65 311.73 0 top
NOREF#63  -  []  288.01 269.34 90 top
NOREF#64  -  []  306.46 242.05 0 top
NOREF#65  -  []  431.67 213.21 90 top
NOREF#66  -  []  478.29 241.36 90 top
NOREF#67  -  []  449.63 327.97 0 top
NOREF#68  -  []  410.32 218.6 0 top
NOREF#69  -  []  447.6 266.53 0 top
NOREF#70  -  []  310.97 233.86 90 top
NOREF#71  -  []  425.67 242.05 0 top
NOREF#72  -  []  308.12 311.87 0 top
NOREF#73  -  []  495.25 415.7 0 top
NOREF#74  -  []  217.01 285.01 90 top
NOREF#75  -  []  385.08 295.3 90 top
NOREF#76  -  []  307.06 293.68 0 top
NOREF#77  -  []  291.58 65.36 90 top
NOREF#78  -  []  342.88 300.86 0 top
NOREF#79  -  []  309.68 244.71 90 top
NOREF#80  -  []  247.66 130.92 90 top
NOREF#81  -  []  251.3 327.94 90 top
NOREF#82  -  []  313.36 270.75 0 top
NOREF#83  -  []  246.45 295.05 0 top
NOREF#84  -  []  303.58 228.32 90 top
NOREF#85  -  []  448.12 284.96 0 top
NOREF#86  -  []  336.66 194.45 0 top
NOREF#87  -  []  518.8 255.47 90 top
NOREF#88  -  []  423.26 228.02 0 top
NOREF#89  -  []  205.88 266.2 0 top
NOREF#90  -  []  428.12 311.87 0 top
NOREF#91  -  []  420.31 345.6 0 top
NOREF#92  -  []  392.1 242.06 0 top
NOREF#93  -  []  334.94 244.03 90 top
NOREF#94  -  []  306.87 242.35 90 top
NOREF#95  -  []  304.45 297.19 90 top
NOREF#96  -  []  193.96 338.59 90 top
NOREF#97  -  []  270.81 337.39 90 top
NOREF#98  -  []  370.32 224.96 0 top
NOREF#99  -  []  471.79 337.35 0 top
NOREF#100  -  []  343.32 314.56 90 top
NOREF#101  -  []  308.84 232.33 0 top
NOREF#102  -  []  436.12 304.96 90 top
NOREF#103  -  []  512.77 335.89 0 top
NOREF#104  -  []  524.51 409.02 90 top
NOREF#105  -  []  198.73 304.03 90 top
NOREF#106  -  []  226.79 279.15 90 top
NOREF#107  -  []  272.76 347.4 0 top
NOREF#108  -  []  408.08 287.86 90 top
NOREF#109  -  []  380.35 244.3 90 top
NOREF#110  -  []  340.58 339.4 0 top
NOREF#111  -  []  307.66 233.29 0 top
NOREF#112  -  []  538.95 338.55 90 top
NOREF#113  -  []  165.53 463.3 0 top
NOREF#114  -  []  306.85 295.29 90 top
NOREF#115  -  []  367.14 163.97 0 top
NOREF#116  -  []  332.71 144.68 0 top
NOREF#117  -  []  347.06 298.91 90 top
NOREF#118  -  []  425.1 229.85 90 top
NOREF#119  -  []  344.9 286.88 0 top
NOREF#120  -  []  308.49 237.58 90 top
NOREF#121  -  []  395.4 211.22 0 top
NOREF#122  -  []  347.91 233.69 90 top
NOREF#123  -  []  345.18 269.42 90 top
NOREF#124  -  []  419.08 334.86 0 top
NOREF#125  -  []  230.62 286.41 0 top
NOREF#126  -  []  256.11 415.7 0 top
NOREF#127  -  []  74.58 41.86 90 top
NOREF#128  -  []  382.88 300.86 0 top
NOREF#129  -  []  383.58 179.05 0 top
NOREF#130  -  []  403.05 345.58 0 top
NOREF#131  -  []  348.84 234.21 0 top
NOREF#132  -  []  359.35 139.19 90 top
NOREF#133  -  []  387.06 298.91 90 top
NOREF#134  -  []  540.2 238.42 90 top
NOREF#135  -  []  304.54 302.35 90 top
NOREF#136  -  []  392.7 246.78 90 top
NOREF#137  -  []  341.08 238.36 0 top
NOREF#138  -  []  374.1 342.74 90 top
NOREF#139  -  []  302.15 238.55 0 top
NOREF#140  -  []  451.95 364.51 90 top
NOREF#141  -  []  322.68 332.6 90 top
NOREF#142  -  []  249.42 252.12 0 top
NOREF#143  -  []  343.58 298.23 0 top
NOREF#144  -  []  404.92 215.4 90 top
NOREF#145  -  []  325.46 310.84 0 top
NOREF#146  -  []  308.54 234.54 0 top
NOREF#147  -  []  391.1 246.35 0 top
NOREF#148  -  []  524.2 233.02 0 top
NOREF#149  -  []  270.31 220.01 0 top
NOREF#150  -  []  383.53 330.81 90 top
NOREF#151  -  []  458.45 333.71 0 top
NOREF#152  -  []  388.39 301.41 90 top
NOREF#153  -  []  382.75 241.46 90 top
NOREF#154  -  []  383.58 228.32 90 top
NOREF#155  -  []  402.13 326.4 90 top
NOREF#156  -  []  374.38 234.16 90 top
NOREF#157  -  []  302.98 296.26 0 top
NOREF#158  -  []  442.68 330.4 90 top
NOREF#159  -  []  420.48 311.19 0 top
NOREF#160  -  []  465.18 229.43 90 top
NOREF#161  -  []  347.06 238.91 90 top
NOREF#162  -  []  228.44 336.34 90 top
NOREF#163  -  []  386.14 302.35 90 top
NOREF#164  -  []  317.97 209.36 90 top
NOREF#165  -  []  374.71 309.44 90 top
NOREF#166  -  []  298.47 343.24 0 top
NOREF#167  -  []  352.1 242.06 0 top
NOREF#168  -  []  256.94 270.76 90 top
NOREF#169  -  []  346.25 297.9 0 top
NOREF#170  -  []  419.08 218.86 90 top
NOREF#171  -  []  345.08 235.3 90 top
NOREF#172  -  []  470.69 241.68 0 top
NOREF#173  -  []  50.38 410.8 90 top
NOREF#174  -  []  535.43 290.03 0 top
NOREF#175  -  []  422.11 307.89 0 top
NOREF#176  -  []  348.84 227.46 0 top
NOREF#177  -  []  388.84 232.33 0 top
NOREF#178  -  []  315.61 216.04 0 top
NOREF#179  -  []  300.35 302.19 90 top
NOREF#180  -  []  404.75 305.55 0 top
NOREF#181  -  []  322.13 266.4 90 top
NOREF#182  -  []  425.68 237.27 90 top
NOREF#183  -  []  427.6 250.97 90 top
NOREF#184  -  []  393.51 212.15 0 top
NOREF#185  -  []  314.2 300.89 90 top
NOREF#186  -  []  193.96 321.23 0 top
NOREF#187  -  []  258.32 272.36 0 top
NOREF#188  -  []  402.08 231.86 90 top
NOREF#189  -  []  339.15 244.94 0 top
NOREF#190  -  []  328.08 324.86 0 top
NOREF#191  -  []  277.93 132.6 0 top
NOREF#192  -  []  311.5 247.42 0 top
NOREF#193  -  []  345.18 329.41 90 top
NOREF#194  -  []  307.73 238.21 0 top
NOREF#195  -  []  471.68 212.78 0 top
NOREF#196  -  []  388.96 270.75 0 top
NOREF#197  -  []  345.68 237.91 90 top
NOREF#198  -  []  313.08 302.66 90 top
NOREF#199  -  []  232.82 313.44 0 top
NOREF#200  -  []  302.88 240.86 90 top
NOREF#201  -  []  469.16 338.95 90 top
NOREF#202  -  []  353.2 246.03 90 top
NOREF#203  -  []  288.08 264.86 0 top
NOREF#204  -  []  209.96 244.86 0 top
NOREF#205  -  []  357.97 209.36 90 top
NOREF#206  -  []  419.15 304.94 0 top
