# Allegro board 038RT-8730CN_1116-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#2774  -  []  407.95 300.15 90 top
NOREF#2775  -  []  347.66 293.29 0 top
NOREF#2776  -  []  200.81 295.62 90 top
NOREF#2777  -  []  339.08 278.86 90 top
NOREF#2778  -  []  433 301.53 0 top
NOREF#2779  -  []  395.22 242.53 0 top
NOREF#2780  -  []  383.9 297.84 0 top
NOREF#2781  -  []  539.65 219.97 90 top
NOREF#2782  -  []  490.55 401.56 0 top
NOREF#2783  -  []  394.92 305.6 0 top
NOREF#2784  -  []  340.35 243.64 90 top
NOREF#2785  -  []  342.44 315.5 90 top
NOREF#2786  -  []  320.19 209.61 90 top
NOREF#2787  -  []  382.11 306.19 0 top
NOREF#2788  -  []  385.53 163.81 0 top
NOREF#2789  -  []  270.31 329.89 0 top
NOREF#2790  -  []  540.2 266.78 0 top
NOREF#2791  -  []  241.66 130.42 90 top
NOREF#2792  -  []  412.85 242.61 0 top
NOREF#2793  -  []  312.1 301.21 0 top
NOREF#2794  -  []  379.15 242.15 0 top
NOREF#2795  -  []  461.65 326.7 0 top
NOREF#2796  -  []  386.46 242.05 0 top
NOREF#2797  -  []  496.52 225.78 0 top
NOREF#2798  -  []  302.11 307.04 0 top
NOREF#2799  -  []  339.74 126.62 0 top
NOREF#2800  -  []  522 335.89 0 top
NOREF#2801  -  []  516.09 254.07 90 top
NOREF#2802  -  []  268.11 213 0 top
NOREF#2803  -  []  489.91 292.96 0 top
NOREF#2804  -  []  345.3 424.44 0 top
NOREF#2805  -  []  300.57 339.4 0 top
NOREF#2806  -  []  338.47 338.08 0 top
NOREF#2807  -  []  438.21 329.35 90 top
NOREF#2808  -  []  430.97 233.86 90 top
NOREF#2809  -  []  471.27 130.48 0 top
NOREF#2810  -  []  200.81 270.55 90 top
NOREF#2811  -  []  254.27 209.17 90 top
NOREF#2812  -  []  305.67 302.05 0 top
NOREF#2813  -  []  495.94 271.37 90 top
NOREF#2814  -  []  436.12 244.96 90 top
NOREF#2815  -  []  386.87 297.85 0 top
NOREF#2816  -  []  259.56 330.24 0 top
NOREF#2817  -  []  232.82 286.41 0 top
NOREF#2818  -  []  306.6 311.22 90 top
NOREF#2819  -  []  308.43 297.66 90 top
NOREF#2820  -  []  423.28 286.82 0 top
NOREF#2821  -  []  402.38 164.18 0 top
NOREF#2822  -  []  345.36 289.28 0 top
NOREF#2823  -  []  335.91 137.08 90 top
NOREF#2824  -  []  322.68 330.4 90 top
NOREF#2825  -  []  424.46 227.38 90 top
NOREF#2826  -  []  382.54 193.25 0 top
NOREF#2827  -  []  538.95 228.42 90 top
NOREF#2828  -  []  420.35 304.3 90 top
NOREF#2829  -  []  229.98 268.14 0 top
NOREF#2830  -  []  303.58 298.23 0 top
NOREF#2831  -  []  297.92 250.66 0 top
NOREF#2832  -  []  292.11 243.78 0 top
NOREF#2833  -  []  351.1 246.35 0 top
NOREF#2834  -  []  518.8 292.96 0 top
NOREF#2835  -  []  300.33 327.57 0 top
NOREF#2836  -  []  353 298.87 90 top
NOREF#2837  -  []  387.34 236.08 0 top
NOREF#2838  -  []  237.97 164.21 90 top
NOREF#2839  -  []  71.55 48.42 0 top
NOREF#2840  -  []  351.18 310.97 90 top
NOREF#2841  -  []  311.16 330.75 0 top
NOREF#2842  -  []  299.15 302.15 0 top
NOREF#2843  -  []  533.35 313.06 90 top
NOREF#2844  -  []  343.28 228.64 0 top
NOREF#2845  -  []  330.08 229.86 90 top
NOREF#2846  -  []  340.33 330.81 0 top
NOREF#2847  -  []  52.38 416.76 0 top
NOREF#2848  -  []  273.65 236.16 90 top
NOREF#2849  -  []  314.2 240.89 90 top
NOREF#2850  -  []  247.22 320.7 0 top
NOREF#2851  -  []  516.09 314.25 90 top
NOREF#2852  -  []  421.83 237.65 90 top
NOREF#2853  -  []  427.22 179.91 0 top
NOREF#2854  -  []  461.65 333.71 0 top
NOREF#2855  -  []  288.08 227.86 90 top
NOREF#2856  -  []  174.46 341.34 0 top
NOREF#2857  -  []  465.33 139.28 90 top
NOREF#2858  -  []  367.3 192.6 90 top
NOREF#2859  -  []  400.91 116.94 0 top
NOREF#2860  -  []  339.74 131.75 0 top
NOREF#2861  -  []  373.06 250.84 90 top
NOREF#2862  -  []  444.92 284.96 0 top
NOREF#2863  -  []  425.35 242.35 90 top
NOREF#2864  -  []  428.65 298.59 0 top
NOREF#2865  -  []  383.58 227.38 0 top
NOREF#2866  -  []  339.67 144.68 0 top
NOREF#2867  -  []  388.59 288.35 0 top
NOREF#2868  -  []  345.35 236.29 90 top
NOREF#2869  -  []  393.51 214.74 0 top
NOREF#2870  -  []  308.59 228.35 0 top
NOREF#2871  -  []  76.55 43.42 90 top
NOREF#2872  -  []  350.94 291.37 90 top
NOREF#2873  -  []  427.91 233.69 90 top
NOREF#2874  -  []  391.8 298.66 0 top
NOREF#2875  -  []  392.71 315.43 0 top
NOREF#2876  -  []  420.35 303.64 90 top
NOREF#2877  -  []  239.87 285.01 90 top
NOREF#2878  -  []  355.25 183.88 90 top
NOREF#2879  -  []  442.68 267.2 0 top
NOREF#2880  -  []  346.07 343.54 90 top
NOREF#2881  -  []  272.51 213 0 top
NOREF#2882  -  []  228.97 225.07 0 top
NOREF#2883  -  []  324.92 221.76 90 top
NOREF#2884  -  []  188.18 160.37 0 top
NOREF#2885  -  []  367.95 297.95 90 top
NOREF#2886  -  []  458.45 265.13 0 top
NOREF#2887  -  []  425.35 296.29 90 top
NOREF#2888  -  []  287.66 310.84 0 top
NOREF#2889  -  []  383.58 288.32 0 top
NOREF#2890  -  []  423.31 245.55 90 top
NOREF#2891  -  []  480.72 419.12 90 top
NOREF#2892  -  []  71.55 446.92 0 top
NOREF#2893  -  []  333.78 403.62 90 top
NOREF#2894  -  []  420.35 243.64 90 top
NOREF#2895  -  []  381.78 195.05 0 top
NOREF#2896  -  []  312.01 308.09 0 top
NOREF#2897  -  []  437.47 340.7 90 top
NOREF#2898  -  []  305.36 289.74 0 top
NOREF#2899  -  []  342.88 300.86 90 top
NOREF#2900  -  []  478.6 260.53 90 top
NOREF#2901  -  []  343.58 236.95 90 top
NOREF#2902  -  []  501.69 331.29 90 top
NOREF#2903  -  []  347.23 298.3 0 top
NOREF#2904  -  []  334.25 296.3 90 top
NOREF#2905  -  []  471.68 247.07 0 top
NOREF#2906  -  []  372.85 302.61 0 top
NOREF#2907  -  []  69.58 506.86 0 top
NOREF#2908  -  []  69.58 506.86 0 top
NOREF#2909  -  []  433 238.02 90 top
NOREF#2910  -  []  345.1 297.19 90 top
NOREF#2911  -  []  425.39 123.34 90 top
NOREF#2912  -  []  303.31 305.55 90 top
NOREF#2913  -  []  343.58 236.95 90 top
NOREF#2914  -  []  392.06 311.23 90 top
NOREF#2915  -  []  386.7 225.88 90 top
NOREF#2916  -  []  387.72 114.8 0 top
NOREF#2917  -  []  383.31 307.25 90 top
NOREF#2918  -  []  71.55 446.92 0 top
NOREF#2919  -  []  529.06 424.44 0 top
NOREF#2920  -  []  310.14 327.57 0 top
NOREF#2921  -  []  367.14 174.21 90 top
NOREF#2922  -  []  217.54 209.17 0 top
NOREF#2923  -  []  272.26 209.17 0 top
NOREF#2924  -  []  375.9 130.92 90 top
NOREF#2925  -  []  193.96 264.08 0 top
NOREF#2926  -  []  47.58 416.9 90 top
NOREF#2927  -  []  442.68 327.2 0 top
NOREF#2928  -  []  364.92 281.76 90 top
NOREF#2929  -  []  238.22 313.44 90 top
NOREF#2930  -  []  484.51 284.56 0 top
NOREF#2931  -  []  301.08 238.36 0 top
NOREF#2932  -  []  326.06 124.98 90 top
NOREF#2933  -  []  308.09 293.43 90 top
NOREF#2934  -  []  275.71 288.59 90 top
NOREF#2935  -  []  287.08 286.86 90 top
NOREF#2936  -  []  342.12 255.2 0 top
NOREF#2937  -  []  349.77 294.51 0 top
NOREF#2938  -  []  495.94 327.25 0 top
NOREF#2939  -  []  393.51 212.15 0 top
NOREF#2940  -  []  388.63 238.15 0 top
NOREF#2941  -  []  472.03 287.27 90 top
NOREF#2942  -  []  357.01 131.53 90 top
NOREF#2943  -  []  313.21 303.73 90 top
NOREF#2944  -  []  230.62 217.83 0 top
NOREF#2945  -  []  294.38 294.16 90 top
NOREF#2946  -  []  209.96 320.7 0 top
NOREF#2947  -  []  488.75 420.38 90 top
NOREF#2948  -  []  74.58 41.86 90 top
NOREF#2949  -  []  309.74 292.01 0 top
NOREF#2950  -  []  345.65 295.93 0 top
NOREF#2951  -  []  340.35 241.51 90 top
NOREF#2952  -  []  247.22 252.12 0 top
NOREF#2953  -  []  215.36 295.05 90 top
NOREF#2954  -  []  516.09 338.55 90 top
NOREF#2955  -  []  663.76 509.6 0 top
NOREF#2956  -  []  393.91 254.79 90 top
NOREF#2957  -  []  312.1 238.98 0 top
NOREF#2958  -  []  348.08 293.38 90 top
NOREF#2959  -  []  343.31 306.4 90 top
NOREF#2960  -  []  463.34 247.42 90 top
NOREF#2961  -  []  230.62 279.15 0 top
NOREF#2962  -  []  393 241.53 0 top
NOREF#2963  -  []  219.19 303.45 0 top
NOREF#2964  -  []  404.92 218.6 0 top
NOREF#2965  -  []  533.35 248.88 90 top
NOREF#2966  -  []  327.95 302.35 90 top
NOREF#2967  -  []  342.15 238.55 0 top
NOREF#2968  -  []  496.6 214.94 0 top
NOREF#2969  -  []  223.59 279.15 0 top
NOREF#2970  -  []  355.22 246.65 0 top
NOREF#2971  -  []  478.6 329.11 90 top
NOREF#2972  -  []  425.68 309.03 0 top
NOREF#2973  -  []  307.53 251.22 90 top
NOREF#2974  -  []  294.88 268.37 0 top
NOREF#2975  -  []  311.67 213.21 90 top
NOREF#2976  -  []  305.86 299.55 0 top
NOREF#2977  -  []  305.86 239.55 0 top
NOREF#2978  -  []  395.22 246.65 0 top
NOREF#2979  -  []  385.16 335.54 90 top
NOREF#2980  -  []  277.36 287.19 90 top
NOREF#2981  -  []  353.28 291.15 90 top
NOREF#2982  -  []  287.08 226.86 90 top
NOREF#2983  -  []  349.92 227.85 90 top
NOREF#2984  -  []  507.37 298.4 90 top
NOREF#2985  -  []  422.15 238.55 0 top
NOREF#2986  -  []  259.56 295.95 0 top
NOREF#2987  -  []  241.58 488.36 0 top
NOREF#2988  -  []  472.03 219.33 0 top
NOREF#2989  -  []  410.51 343.81 90 top
NOREF#2990  -  []  592.33 126.82 90 top
NOREF#2991  -  []  535.43 347.18 0 top
NOREF#2992  -  []  495.94 250.27 0 top
NOREF#2993  -  []  198.73 269.74 90 top
NOREF#2994  -  []  303.58 230.2 0 top
NOREF#2995  -  []  382.41 247.36 0 top
NOREF#2996  -  []  308.2 296.49 0 top
NOREF#2997  -  []  207.08 267.71 90 top
NOREF#2998  -  []  407.32 208.35 90 top
NOREF#2999  -  []  219.19 217.83 0 top
NOREF#3000  -  []  388.84 234.21 0 top
NOREF#3001  -  []  535.43 255.74 0 top
NOREF#3002  -  []  489.91 284.56 0 top
NOREF#3003  -  []  223.59 320.7 0 top
NOREF#3004  -  []  207.08 267.71 90 top
NOREF#3005  -  []  447.6 239.25 0 top
NOREF#3006  -  []  383.32 254.56 90 top
NOREF#3007  -  []  366.54 179.81 0 top
NOREF#3008  -  []  234.21 403.62 90 top
NOREF#3009  -  []  368.34 194.29 0 top
NOREF#3010  -  []  307.34 236.08 0 top
NOREF#3011  -  []  518.8 229.82 90 top
NOREF#3012  -  []  366.54 158.37 90 top
NOREF#3013  -  []  349.4 235.85 90 top
NOREF#3014  -  []  211.51 334.25 0 top
NOREF#3015  -  []  272.51 288.59 0 top
NOREF#3016  -  []  292.04 125.38 90 top
NOREF#3017  -  []  307.29 298.22 0 top
NOREF#3018  -  []  428.09 293.43 90 top
NOREF#3019  -  []  389.77 294.51 0 top
NOREF#3020  -  []  536.7 292.39 0 top
NOREF#3021  -  []  400.91 111.1 90 top
NOREF#3022  -  []  383.58 298.23 0 top
NOREF#3023  -  []  429.44 292.33 90 top
NOREF#3024  -  []  347.66 301.41 90 top
NOREF#3025  -  []  278.84 425.76 90 top
NOREF#3026  -  []  182.93 0 90 top
NOREF#3027  -  []  303.58 286.5 0 top
NOREF#3028  -  []  221.39 226.47 0 top
NOREF#3029  -  []  394.92 306.97 0 top
NOREF#3030  -  []  391.1 249.26 0 top
NOREF#3031  -  []  533.35 278.76 90 top
NOREF#3032  -  []  401.62 227.86 45 top
NOREF#3033  -  []  285.09 268.07 90 top
NOREF#3034  -  []  306.22 296.54 90 top
NOREF#3035  -  []  313.21 243.73 90 top
NOREF#3036  -  []  228.44 319.3 90 top
NOREF#3037  -  []  52.38 415.56 90 top
NOREF#3038  -  []  345.15 338.13 90 top
NOREF#3039  -  []  228.44 250.72 90 top
NOREF#3040  -  []  294.38 259.56 0 top
NOREF#3041  -  []  308.44 250.97 90 top
NOREF#3042  -  []  407.66 250.84 0 top
NOREF#3043  -  []  366.54 164.57 0 top
NOREF#3044  -  []  353.1 174.37 90 top
NOREF#3045  -  []  223.59 234.87 0 top
NOREF#3046  -  []  334.04 211.52 0 top
NOREF#3047  -  []  353.28 231.15 90 top
NOREF#3048  -  []  339.74 129.19 0 top
NOREF#3049  -  []  251.3 267.76 90 top
NOREF#3050  -  []  347.44 233.68 0 top
NOREF#3051  -  []  382.12 255.2 0 top
NOREF#3052  -  []  353.21 243.73 90 top
NOREF#3053  -  []  486.94 301.6 0 top
NOREF#3054  -  []  470.69 268.71 0 top
NOREF#3055  -  []  386.87 302.35 90 top
NOREF#3056  -  []  283.81 249.44 0 top
NOREF#3057  -  []  402.08 291.86 90 top
NOREF#3058  -  []  522 308.86 0 top
NOREF#3059  -  []  309.08 248.46 90 top
NOREF#3060  -  []  343.91 341.81 0 top
NOREF#3061  -  []  391.5 307.42 0 top
NOREF#3062  -  []  372.08 331.86 0 top
NOREF#3063  -  []  315.61 213.47 0 top
NOREF#3064  -  []  405.56 377.2 0 top
NOREF#3065  -  []  221.39 320.7 0 top
NOREF#3066  -  []  355.61 213.47 0 top
NOREF#3067  -  []  472.03 252.98 90 top
NOREF#3068  -  []  55 414.31 0 top
NOREF#3069  -  []  427.31 233.29 0 top
NOREF#3070  -  []  301.83 237.65 90 top
NOREF#3071  -  []  385.53 194.29 0 top
NOREF#3072  -  []  311.8 299.51 0 top
NOREF#3073  -  []  340.33 327.57 0 top
NOREF#3074  -  []  379.08 334.86 0 top
NOREF#3075  -  []  334.25 236.3 90 top
NOREF#3076  -  []  301.08 251.06 0 top
NOREF#3077  -  []  494.89 140.81 0 top
NOREF#3078  -  []  265.56 234.17 0 top
NOREF#3079  -  []  309.68 244.71 90 top
NOREF#3080  -  []  412.08 271.86 0 top
NOREF#3081  -  []  354.2 301.74 90 top
NOREF#3082  -  []  522 274.57 0 top
NOREF#3083  -  []  310.3 236.62 90 top
NOREF#3084  -  []  231.93 420.39 0 top
NOREF#3085  -  []  427.66 233.29 0 top
NOREF#3086  -  []  265.56 337.04 0 top
NOREF#3087  -  []  495.94 315.65 90 top
NOREF#3088  -  []  304.08 308.86 90 top
NOREF#3089  -  []  345.6 289.67 90 top
NOREF#3090  -  []  257.39 340.94 0 top
NOREF#3091  -  []  322.68 270.4 90 top
NOREF#3092  -  []  322.08 261.86 0 top
NOREF#3093  -  []  423.58 290.2 0 top
NOREF#3094  -  []  343.58 298.23 0 top
NOREF#3095  -  []  453.44 334.16 0 top
NOREF#3096  -  []  311.1 309.26 0 top
NOREF#3097  -  []  309.83 318.32 90 top
NOREF#3098  -  []  335.93 270.82 0 top
NOREF#3099  -  []  300.35 242.19 90 top
NOREF#3100  -  []  315.58 300.86 90 top
NOREF#3101  -  []  424.48 237.91 0 top
NOREF#3102  -  []  353.21 245.24 90 top
NOREF#3103  -  []  219.19 260.76 0 top
NOREF#3104  -  []  408.12 224.96 0 top
NOREF#3105  -  []  217.54 216.43 0 top
NOREF#3106  -  []  350.86 251.87 0 top
NOREF#3107  -  []  243.37 250.72 0 top
NOREF#3108  -  []  312.1 241.21 0 top
NOREF#3109  -  []  303.28 228.64 0 top
NOREF#3110  -  []  304.86 242.05 0 top
NOREF#3111  -  []  382.38 194.45 0 top
NOREF#3112  -  []  200.81 244.5 90 top
NOREF#3113  -  []  367.95 237.95 90 top
NOREF#3114  -  []  413.88 303.99 90 top
NOREF#3115  -  []  249.42 210.57 0 top
NOREF#3116  -  []  338.47 343.24 0 top
NOREF#3117  -  []  374.1 338.34 90 top
NOREF#3118  -  []  430.86 311.87 0 top
NOREF#3119  -  []  463.34 213.13 90 top
NOREF#3120  -  []  536.7 315.25 0 top
NOREF#3121  -  []  385.08 248.86 0 top
NOREF#3122  -  []  385.08 235.94 90 top
NOREF#3123  -  []  308.84 287.46 0 top
NOREF#3124  -  []  410.08 263.86 0 top
NOREF#3125  -  []  385.68 309.03 0 top
NOREF#3126  -  []  389.44 233.61 90 top
NOREF#3127  -  []  353.21 305.24 90 top
NOREF#3128  -  []  501.34 267.31 0 top
NOREF#3129  -  []  351.9 158.97 90 top
NOREF#3130  -  []  471.79 268.77 0 top
NOREF#3131  -  []  212.16 320.7 0 top
NOREF#3132  -  []  538.95 262.71 90 top
NOREF#3133  -  []  322.68 272.6 90 top
NOREF#3134  -  []  242.05 303.45 0 top
NOREF#3135  -  []  390.6 247.1 0 top
NOREF#3136  -  []  338.47 340.67 0 top
NOREF#3137  -  []  289.74 122.54 90 top
NOREF#3138  -  []  310.97 293.86 90 top
NOREF#3139  -  []  319.59 308.7 90 top
NOREF#3140  -  []  480.72 421.68 90 top
NOREF#3141  -  []  341.85 125.35 0 top
NOREF#3142  -  []  350.14 327.57 0 top
NOREF#3143  -  []  313.36 330.75 0 top
NOREF#3144  -  []  245.02 286.41 0 top
NOREF#3145  -  []  320.22 211.22 0 top
NOREF#3146  -  []  428.47 218.61 0 top
NOREF#3147  -  []  292.85 302.61 90 top
NOREF#3148  -  []  507.37 292.96 0 top
NOREF#3149  -  []  336.66 189.45 90 top
NOREF#3150  -  []  450.32 224.96 0 top
NOREF#3151  -  []  389.32 251.23 90 top
NOREF#3152  -  []  353.36 330.75 0 top
NOREF#3153  -  []  305.35 236.29 90 top
NOREF#3154  -  []  336.66 163.97 0 top
NOREF#3155  -  []  385.35 302.35 90 top
NOREF#3156  -  []  461.98 125.38 90 top
NOREF#3157  -  []  338.25 303.15 0 top
NOREF#3158  -  []  539.65 322.84 90 top
NOREF#3159  -  []  431.16 270.75 0 top
NOREF#3160  -  []  355.02 241.03 0 top
NOREF#3161  -  []  342.98 236.26 0 top
NOREF#3162  -  []  345.4 251.86 0 top
NOREF#3163  -  []  76.55 43.42 90 top
NOREF#3164  -  []  295.78 332.56 90 top
NOREF#3165  -  []  434.07 286.36 0 top
NOREF#3166  -  []  385.68 249.03 0 top
NOREF#3167  -  []  423.53 330.81 90 top
NOREF#3168  -  []  340.74 406.82 90 top
NOREF#3169  -  []  520.85 214.89 90 top
NOREF#3170  -  []  512.77 292.96 0 top
NOREF#3171  -  []  342.41 308.21 0 top
NOREF#3172  -  []  341.83 237.65 90 top
NOREF#3173  -  []  384.69 268.37 0 top
NOREF#3174  -  []  417.6 309.76 90 top
NOREF#3175  -  []  440.19 209.61 90 top
NOREF#3176  -  []  246.45 303.45 0 top
NOREF#3177  -  []  259.36 268.01 0 top
NOREF#3178  -  []  419.12 310.02 90 top
NOREF#3179  -  []  266.46 245.89 0 top
NOREF#3180  -  []  262.37 216.37 90 top
NOREF#3181  -  []  277.36 294.2 90 top
NOREF#3182  -  []  432.08 239.36 90 top
NOREF#3183  -  []  244.53 415.3 90 top
NOREF#3184  -  []  385.6 289.67 90 top
NOREF#3185  -  []  431.67 211.01 90 top
NOREF#3186  -  []  345.15 340.7 90 top
NOREF#3187  -  []  346.7 225.88 90 top
NOREF#3188  -  []  403.19 179.87 0 top
NOREF#3189  -  []  522.65 298.94 0 top
NOREF#3190  -  []  572.22 364.13 90 top
NOREF#3191  -  []  228.97 312.04 0 top
NOREF#3192  -  []  270.26 336.59 90 top
NOREF#3193  -  []  426.95 141.48 90 top
NOREF#3194  -  []  209.96 329.34 0 top
NOREF#3195  -  []  303.58 229.6 90 top
NOREF#3196  -  []  367.08 226.86 90 top
NOREF#3197  -  []  298.47 340.67 0 top
NOREF#3198  -  []  332.08 221.86 90 top
NOREF#3199  -  []  362.68 327.2 0 top
NOREF#3200  -  []  346.14 242.35 90 top
NOREF#3201  -  []  200.81 255.93 90 top
NOREF#3202  -  []  298.25 304.6 0 top
NOREF#3203  -  []  343.31 305.55 90 top
NOREF#3204  -  []  347.66 233.75 0 top
NOREF#3205  -  []  309.12 292.03 0 top
NOREF#3206  -  []  530.15 320.65 0 top
NOREF#3207  -  []  384.45 297.19 90 top
NOREF#3208  -  []  437.46 124.08 90 top
NOREF#3209  -  []  71.55 446.92 0 top
NOREF#3210  -  []  322.02 338.45 0 top
NOREF#3211  -  []  428.2 296.49 0 top
NOREF#3212  -  []  524.2 274.57 0 top
NOREF#3213  -  []  433.34 324.37 90 top
NOREF#3214  -  []  223.58 65.36 90 top
NOREF#3215  -  []  432.88 127.92 0 top
NOREF#3216  -  []  238.22 244.86 90 top
NOREF#3217  -  []  303.58 238.23 0 top
NOREF#3218  -  []  516.09 304.26 90 top
NOREF#3219  -  []  200.26 312.27 90 top
NOREF#3220  -  []  375.93 330.81 0 top
NOREF#3221  -  []  379.15 244.94 0 top
NOREF#3222  -  []  245.02 217.83 0 top
NOREF#3223  -  []  402.59 350.38 0 top
NOREF#3224  -  []  424.75 235.61 0 top
NOREF#3225  -  []  387.19 242.05 0 top
NOREF#3226  -  []  432.9 339.4 0 top
NOREF#3227  -  []  228.97 277.75 0 top
NOREF#3228  -  []  418.98 211 90 top
NOREF#3229  -  []  46.65 422.87 0 top
NOREF#3230  -  []  535.43 318.27 90 top
NOREF#3231  -  []  341.68 311.19 0 top
NOREF#3232  -  []  431.8 299.51 0 top
NOREF#3233  -  []  399.3 246.35 0 top
NOREF#3234  -  []  76.55 43.42 90 top
NOREF#3235  -  []  395.02 241.03 0 top
NOREF#3236  -  []  346.42 124.08 90 top
NOREF#3237  -  []  193.96 327.16 90 top
NOREF#3238  -  []  507.37 229.82 90 top
NOREF#3239  -  []  200.26 277.98 90 top
NOREF#3240  -  []  280.36 339.55 90 top
NOREF#3241  -  []  507.37 335.89 0 top
NOREF#3242  -  []  393.28 231.15 90 top
NOREF#3243  -  []  423.9 290.5 0 top
NOREF#3244  -  []  382.38 158.97 90 top
NOREF#3245  -  []  399.82 338.45 0 top
NOREF#3246  -  []  71.55 446.92 0 top
NOREF#3247  -  []  312.08 299.36 90 top
NOREF#3248  -  []  431.5 247.42 0 top
NOREF#3249  -  []  396.12 306.33 90 top
NOREF#3250  -  []  380.58 339.4 0 top
NOREF#3251  -  []  386.46 302.05 0 top
NOREF#3252  -  []  528.27 287.52 0 top
NOREF#3253  -  []  298.25 311.94 0 top
NOREF#3254  -  []  339.15 301.46 0 top
NOREF#3255  -  []  385.58 289.16 90 top
NOREF#3256  -  []  392.14 291.95 0 top
NOREF#3257  -  []  487.71 292.96 0 top
NOREF#3258  -  []  229.91 139.83 0 top
NOREF#3259  -  []  296.59 377.58 0 top
NOREF#3260  -  []  235.02 320.7 0 top
NOREF#3261  -  []  351.3 195.05 0 top
NOREF#3262  -  []  381.91 336.38 0 top
NOREF#3263  -  []  495.25 415.7 90 top
NOREF#3264  -  []  525.83 376.82 90 top
NOREF#3265  -  []  461.65 340.72 0 top
NOREF#3266  -  []  385.02 237.19 0 top
NOREF#3267  -  []  327.66 310.84 0 top
NOREF#3268  -  []  228.44 233.47 90 top
NOREF#3269  -  []  433.51 214.74 0 top
NOREF#3270  -  []  305.36 289.28 0 top
NOREF#3271  -  []  346.06 241.41 90 top
NOREF#3272  -  []  423.58 230.2 0 top
NOREF#3273  -  []  447.6 300.82 0 top
NOREF#3274  -  []  433.51 212.15 0 top
NOREF#3275  -  []  395.61 210.88 0 top
NOREF#3276  -  []  336.66 174.21 90 top
NOREF#3277  -  []  46.95 407.63 0 top
NOREF#3278  -  []  334.71 309.44 90 top
NOREF#3279  -  []  346.6 311.22 90 top
NOREF#3280  -  []  507.95 241.68 0 top
NOREF#3281  -  []  219.19 269.16 0 top
NOREF#3282  -  []  391.18 250.97 90 top
NOREF#3283  -  []  459.28 271.25 90 top
NOREF#3284  -  []  228.44 327.94 90 top
NOREF#3285  -  []  41.87 386.95 90 top
NOREF#3286  -  []  306.87 301.41 90 top
NOREF#3287  -  []  408.08 324.86 0 top
NOREF#3288  -  []  471.79 303.06 0 top
NOREF#3289  -  []  147.4 429.04 0 top
NOREF#3290  -  []  344.45 237.2 90 top
NOREF#3291  -  []  392 246.67 0 top
NOREF#3292  -  []  485.09 241.68 0 top
NOREF#3293  -  []  527.52 338.55 90 top
NOREF#3294  -  []  422.75 301.46 90 top
NOREF#3295  -  []  287.08 326.86 0 top
NOREF#3296  -  []  402.68 332.6 90 top
NOREF#3297  -  []  348.49 297.58 90 top
NOREF#3298  -  []  303.53 259.97 90 top
NOREF#3299  -  []  232.26 270.05 0 top
NOREF#3300  -  []  344.08 248.86 90 top
NOREF#3301  -  []  535.43 341.13 90 top
NOREF#3302  -  []  385.36 289.28 0 top
NOREF#3303  -  []  348.48 311.23 90 top
NOREF#3304  -  []  374.44 125.18 0 top
NOREF#3305  -  []  277.36 245.89 90 top
NOREF#3306  -  []  221.58 488.36 0 top
NOREF#3307  -  []  345.68 237.27 90 top
NOREF#3308  -  []  432.08 299.36 90 top
NOREF#3309  -  []  352.25 234.12 0 top
NOREF#3310  -  []  232.82 244.86 0 top
NOREF#3311  -  []  379.15 241.46 0 top
NOREF#3312  -  []  433.2 308.94 90 top
NOREF#3313  -  []  425.4 251.86 0 top
NOREF#3314  -  []  312.01 248.09 0 top
NOREF#3315  -  []  300.35 250.98 90 top
NOREF#3316  -  []  53.97 434.54 0 top
NOREF#3317  -  []  311.8 238.66 0 top
NOREF#3318  -  []  510.57 318.85 0 top
NOREF#3319  -  []  359.7 140.17 90 top
NOREF#3320  -  []  539.65 334.27 90 top
NOREF#3321  -  []  200.81 339.13 90 top
NOREF#3322  -  []  305.18 329.41 90 top
NOREF#3323  -  []  329.29 402.82 0 top
NOREF#3324  -  []  276.07 270.81 0 top
NOREF#3325  -  []  200.81 227.04 90 top
NOREF#3326  -  []  425.86 239.55 0 top
NOREF#3327  -  []  478.6 135.43 90 top
NOREF#3328  -  []  43.4 498.15 0 top
NOREF#3329  -  []  311.11 247.77 0 top
NOREF#3330  -  []  215.36 286.41 90 top
NOREF#3331  -  []  383.53 322.17 90 top
NOREF#3332  -  []  213.31 233.42 90 top
NOREF#3333  -  []  305.35 302.35 90 top
NOREF#3334  -  []  362.68 267.2 0 top
NOREF#3335  -  []  360.19 214.77 90 top
NOREF#3336  -  []  308.49 297.58 90 top
NOREF#3337  -  []  422.88 240.86 0 top
NOREF#3338  -  []  310.94 291.37 90 top
NOREF#3339  -  []  215.36 320.7 90 top
NOREF#3340  -  []  429.08 308.46 90 top
NOREF#3341  -  []  243.37 209.17 0 top
NOREF#3342  -  []  264.76 308.55 0 top
NOREF#3343  -  []  428.39 301.41 90 top
NOREF#3344  -  []  313.2 308.94 90 top
NOREF#3345  -  []  345.78 289.14 90 top
NOREF#3346  -  []  393.36 330.75 0 top
NOREF#3347  -  []  506.28 130.42 90 top
NOREF#3348  -  []  44.66 416.52 90 top
NOREF#3349  -  []  422.88 300.86 90 top
NOREF#3350  -  []  239.87 250.72 90 top
NOREF#3351  -  []  339.74 126.62 0 top
NOREF#3352  -  []  343.32 254.56 90 top
NOREF#3353  -  []  297.6 249.76 90 top
NOREF#3354  -  []  402.68 272.6 90 top
NOREF#3355  -  []  533.35 223.81 90 top
NOREF#3356  -  []  309.44 232.33 90 top
NOREF#3357  -  []  515.27 420.39 0 top
NOREF#3358  -  []  434.07 220 0 top
NOREF#3359  -  []  229.98 336.72 0 top
NOREF#3360  -  []  310.32 291.39 90 top
NOREF#3361  -  []  432.88 125.35 0 top
NOREF#3362  -  []  473.66 320.25 0 top
NOREF#3363  -  []  309.54 297.24 0 top
NOREF#3364  -  []  383.53 259.97 90 top
NOREF#3365  -  []  305.35 297.58 0 top
NOREF#3366  -  []  523.06 425.76 90 top
NOREF#3367  -  []  230.62 210.57 0 top
NOREF#3368  -  []  259.73 231.52 0 top
NOREF#3369  -  []  272.51 220.01 0 top
NOREF#3370  -  []  342.11 307.89 0 top
NOREF#3371  -  []  230.23 138.93 90 top
NOREF#3372  -  []  530.67 253.23 90 top
NOREF#3373  -  []  200.81 210.21 90 top
NOREF#3374  -  []  385.4 251.86 0 top
NOREF#3375  -  []  383.88 295.94 0 top
NOREF#3376  -  []  339.81 163.81 0 top
NOREF#3377  -  []  331.36 123.86 0 top
NOREF#3378  -  []  334.38 319.56 0 top
NOREF#3379  -  []  214.51 231.91 90 top
NOREF#3380  -  []  316.12 304.96 90 top
NOREF#3381  -  []  488.75 148.08 90 top
NOREF#3382  -  []  385.1 229.85 90 top
NOREF#3383  -  []  303.58 288.32 90 top
NOREF#3384  -  []  69.58 506.86 0 top
NOREF#3385  -  []  303.9 237.85 0 top
NOREF#3386  -  []  418.25 243.15 0 top
NOREF#3387  -  []  298.13 270.82 0 top
NOREF#3388  -  []  249.42 244.86 0 top
NOREF#3389  -  []  451.53 320.6 90 top
NOREF#3390  -  []  434.2 301.74 90 top
NOREF#3391  -  []  249.65 329.34 90 top
NOREF#3392  -  []  501.34 327.25 0 top
NOREF#3393  -  []  367.95 240.15 90 top
NOREF#3394  -  []  215.36 226.47 90 top
NOREF#3395  -  []  232.82 217.83 0 top
NOREF#3396  -  []  215.36 244.86 90 top
NOREF#3397  -  []  450.32 284.96 0 top
NOREF#3398  -  []  428.96 270.75 0 top
NOREF#3399  -  []  481.54 343.15 0 top
NOREF#3400  -  []  351.16 270.75 0 top
NOREF#3401  -  []  308.2 236.49 0 top
NOREF#3402  -  []  430.94 231.37 90 top
NOREF#3403  -  []  302.98 236.26 0 top
NOREF#3404  -  []  471.8 223.88 90 top
NOREF#3405  -  []  530.15 274.93 0 top
NOREF#3406  -  []  343.88 235.94 0 top
NOREF#3407  -  []  319.3 306.35 0 top
NOREF#3408  -  []  434.92 246.97 0 top
NOREF#3409  -  []  299.16 144.68 0 top
NOREF#3410  -  []  474.04 421.66 0 top
NOREF#3411  -  []  353.1 189.61 90 top
NOREF#3412  -  []  287.66 250.84 0 top
NOREF#3413  -  []  71.55 446.92 0 top
NOREF#3414  -  []  385.78 229.41 90 top
NOREF#3415  -  []  306.7 225.88 90 top
NOREF#3416  -  []  290.24 123.34 0 top
NOREF#3417  -  []  340.48 251.19 0 top
NOREF#3418  -  []  353 241.53 0 top
NOREF#3419  -  []  245.02 320.7 0 top
NOREF#3420  -  []  207.76 279.15 0 top
NOREF#3421  -  []  353.34 259.97 90 top
NOREF#3422  -  []  223.58 65.36 90 top
NOREF#3423  -  []  312.14 231.95 0 top
NOREF#3424  -  []  336.82 193.25 0 top
NOREF#3425  -  []  423.58 238.23 0 top
NOREF#3426  -  []  383.58 228.32 0 top
NOREF#3427  -  []  305.72 250.96 90 top
NOREF#3428  -  []  399.64 258.32 90 top
NOREF#3429  -  []  339.15 242.83 0 top
NOREF#3430  -  []  303.53 262.17 90 top
NOREF#3431  -  []  387.06 238.91 90 top
NOREF#3432  -  []  235.02 252.12 0 top
NOREF#3433  -  []  407.95 242.35 90 top
NOREF#3434  -  []  348.09 293.43 90 top
NOREF#3435  -  []  340.74 403.62 90 top
NOREF#3436  -  []  291.05 243.75 0 top
NOREF#3437  -  []  384.75 235.61 0 top
NOREF#3438  -  []  367.3 162.12 90 top
NOREF#3439  -  []  280.36 338.66 90 top
NOREF#3440  -  []  44.66 398.1 90 top
NOREF#3441  -  []  230.62 234.87 0 top
NOREF#3442  -  []  300.33 270.82 0 top
NOREF#3443  -  []  527.07 278.39 90 top
NOREF#3444  -  []  344.48 228 90 top
NOREF#3445  -  []  319.61 116.46 0 top
NOREF#3446  -  []  485.09 320.25 0 top
NOREF#3447  -  []  304.48 249.03 0 top
NOREF#3448  -  []  322.33 402.82 0 top
NOREF#3449  -  []  305.78 229.41 90 top
NOREF#3450  -  []  387.45 297.26 90 top
NOREF#3451  -  []  273.65 304.74 90 top
NOREF#3452  -  []  387.34 296.08 0 top
NOREF#3453  -  []  419.08 278.86 90 top
NOREF#3454  -  []  415.03 339.54 90 top
NOREF#3455  -  []  518.8 308.86 0 top
NOREF#3456  -  []  71.55 48.42 0 top
NOREF#3457  -  []  380.35 310.97 90 top
NOREF#3458  -  []  69.58 46.86 0 top
NOREF#3459  -  []  447.14 323.35 0 top
NOREF#3460  -  []  433.91 254.79 90 top
NOREF#3461  -  []  207.76 313.44 0 top
NOREF#3462  -  []  352.1 238.98 0 top
NOREF#3463  -  []  261.1 250.66 0 top
NOREF#3464  -  []  435.22 246.65 0 top
NOREF#3465  -  []  215.36 329.34 90 top
NOREF#3466  -  []  217.54 250.72 0 top
NOREF#3467  -  []  499.14 335.89 0 top
NOREF#3468  -  []  358.47 131.53 0 top
NOREF#3469  -  []  469.9 257.77 0 top
NOREF#3470  -  []  305.91 124.08 90 top
NOREF#3471  -  []  540.2 301.07 0 top
NOREF#3472  -  []  424.79 123.86 90 top
NOREF#3473  -  []  353.57 117.51 90 top
NOREF#3474  -  []  379.58 241.86 0 top
NOREF#3475  -  []  432.1 299.83 0 top
NOREF#3476  -  []  250.94 239.67 0 top
NOREF#3477  -  []  484.74 267.31 0 top
NOREF#3478  -  []  394.49 113.39 90 top
NOREF#3479  -  []  299.08 274.86 0 top
NOREF#3480  -  []  352.06 178.01 0 top
NOREF#3481  -  []  245.02 279.15 0 top
NOREF#3482  -  []  432.7 246.78 90 top
NOREF#3483  -  []  229.82 419.09 0 top
NOREF#3484  -  []  517.58 87.36 0 top
NOREF#3485  -  []  311.18 250.97 90 top
NOREF#3486  -  []  348.08 233.18 90 top
NOREF#3487  -  []  374.88 268.37 0 top
NOREF#3488  -  []  536.7 338.11 0 top
NOREF#3489  -  []  283.81 309.44 0 top
NOREF#3490  -  []  423.58 298.23 0 top
NOREF#3491  -  []  230.23 131.53 0 top
NOREF#3492  -  []  287.08 266.86 0 top
NOREF#3493  -  []  281.35 392 0 top
NOREF#3494  -  []  355.05 179.05 0 top
NOREF#3495  -  []  344.69 268.37 0 top
NOREF#3496  -  []  207.08 336.29 90 top
NOREF#3497  -  []  535.43 324.32 0 top
NOREF#3498  -  []  389.44 293.61 90 top
NOREF#3499  -  []  484.51 215.98 0 top
NOREF#3500  -  []  259.56 261.66 0 top
NOREF#3501  -  []  383.58 238.23 0 top
NOREF#3502  -  []  481.54 308.86 0 top
NOREF#3503  -  []  221.39 244.86 0 top
NOREF#3504  -  []  423.28 228.64 0 top
NOREF#3505  -  []  473.66 251.67 0 top
NOREF#3506  -  []  198.73 246.88 90 top
NOREF#3507  -  []  311.67 211.01 90 top
NOREF#3508  -  []  379.15 301.46 0 top
NOREF#3509  -  []  305.68 249.58 0 top
NOREF#3510  -  []  424.48 226.18 90 top
NOREF#3511  -  []  540.2 318.43 90 top
NOREF#3512  -  []  379.67 293.34 90 top
NOREF#3513  -  []  503.28 280.98 90 top
NOREF#3514  -  []  463.85 292.41 0 top
NOREF#3515  -  []  316.12 244.96 90 top
NOREF#3516  -  []  303.58 289.6 90 top
NOREF#3517  -  []  495.19 141.13 0 top
NOREF#3518  -  []  228.44 216.43 90 top
NOREF#3519  -  []  497.79 213.67 0 top
NOREF#3520  -  []  538.95 304.26 90 top
NOREF#3521  -  []  370.9 345.94 0 top
NOREF#3522  -  []  370.29 179.05 0 top
NOREF#3523  -  []  507.37 247.07 90 top
NOREF#3524  -  []  385.6 229.67 90 top
NOREF#3525  -  []  306.6 251.22 90 top
NOREF#3526  -  []  265.56 268.46 0 top
NOREF#3527  -  []  435.61 213.47 0 top
NOREF#3528  -  []  389.1 237.26 0 top
NOREF#3529  -  []  160.9 429.54 0 top
NOREF#3530  -  []  386.46 336.37 90 top
NOREF#3531  -  []  433 302.38 0 top
NOREF#3532  -  []  385.13 229.66 0 top
NOREF#3533  -  []  433.08 302.66 90 top
NOREF#3534  -  []  460.14 319.2 0 top
NOREF#3535  -  []  497.58 87.36 0 top
NOREF#3536  -  []  290.08 229.86 90 top
NOREF#3537  -  []  71.55 48.42 0 top
NOREF#3538  -  []  200.81 221.64 90 top
NOREF#3539  -  []  303.58 296.95 90 top
NOREF#3540  -  []  524.7 264.31 0 top
NOREF#3541  -  []  420.35 310.97 90 top
NOREF#3542  -  []  320.97 112.04 90 top
NOREF#3543  -  []  76.55 43.42 90 top
NOREF#3544  -  []  426.37 237.89 0 top
NOREF#3545  -  []  342.41 307.36 0 top
NOREF#3546  -  []  380.58 339.4 0 top
NOREF#3547  -  []  304.48 226.18 90 top
NOREF#3548  -  []  47.62 402.86 90 top
NOREF#3549  -  []  347.08 306.86 0 top
NOREF#3550  -  []  305.08 308.86 0 top
NOREF#3551  -  []  307.66 233.75 0 top
NOREF#3552  -  []  340.58 336.81 0 top
NOREF#3553  -  []  335.63 116.97 90 top
NOREF#3554  -  []  302.11 307.89 0 top
NOREF#3555  -  []  432.14 291.95 0 top
NOREF#3556  -  []  382.98 296.26 0 top
NOREF#3557  -  []  388.12 228.85 0 top
NOREF#3558  -  []  287.95 302.35 90 top
NOREF#3559  -  []  217.54 233.47 0 top
NOREF#3560  -  []  457.12 396.45 0 top
NOREF#3561  -  []  385.68 237.91 90 top
NOREF#3562  -  []  383.58 159.13 90 top
NOREF#3563  -  []  254.27 285.01 90 top
NOREF#3564  -  []  228.44 285.01 90 top
NOREF#3565  -  []  257.39 306.65 0 top
NOREF#3566  -  []  355.58 300.86 90 top
NOREF#3567  -  []  340.35 242.19 90 top
NOREF#3568  -  []  277.8 210.77 90 top
NOREF#3569  -  []  448.14 208.02 90 top
NOREF#3570  -  []  386.85 297.41 0 top
NOREF#3571  -  []  420.48 251.19 0 top
NOREF#3572  -  []  345.13 289.66 0 top
NOREF#3573  -  []  245.71 214.77 90 top
NOREF#3574  -  []  207.69 164.63 90 top
NOREF#3575  -  []  336.07 419.12 90 top
NOREF#3576  -  []  463.34 208.73 90 top
NOREF#3577  -  []  352.01 245.88 0 top
NOREF#3578  -  []  343.31 245.55 90 top
NOREF#3579  -  []  378.25 302.47 0 top
NOREF#3580  -  []  245.73 424.44 0 top
NOREF#3581  -  []  231.81 343.43 0 top
NOREF#3582  -  []  392.08 239.36 90 top
NOREF#3583  -  []  384.48 286.18 90 top
NOREF#3584  -  []  212.16 286.41 0 top
NOREF#3585  -  []  327.08 286.86 90 top
NOREF#3586  -  []  324.92 224.96 0 top
NOREF#3587  -  []  230.62 244.86 0 top
NOREF#3588  -  []  307.06 298.91 90 top
NOREF#3589  -  []  391.81 255.75 0 top
NOREF#3590  -  []  229.72 402.82 0 top
NOREF#3591  -  []  230.62 226.47 0 top
NOREF#3592  -  []  484.51 292.96 0 top
NOREF#3593  -  []  223.58 466.36 90 top
NOREF#3594  -  []  353 298.02 90 top
NOREF#3595  -  []  327.42 338.45 90 top
NOREF#3596  -  []  246.45 269.16 0 top
NOREF#3597  -  []  234.36 165.9 90 top
NOREF#3598  -  []  391.11 245.56 0 top
NOREF#3599  -  []  347.08 246.86 0 top
NOREF#3600  -  []  217.54 336.34 0 top
NOREF#3601  -  []  311.15 240.26 0 top
NOREF#3602  -  []  372.08 221.86 90 top
NOREF#3603  -  []  407.95 297.95 90 top
NOREF#3604  -  []  214.04 160.37 0 top
NOREF#3605  -  []  229.82 421.66 0 top
NOREF#3606  -  []  307.08 246.86 0 top
NOREF#3607  -  []  507.37 221.18 90 top
NOREF#3608  -  []  251.3 233.47 90 top
NOREF#3609  -  []  353.34 262.17 90 top
NOREF#3610  -  []  489.91 318.85 0 top
NOREF#3611  -  []  522 292.96 0 top
NOREF#3612  -  []  418.25 242.47 0 top
NOREF#3613  -  []  429.85 237.94 90 top
NOREF#3614  -  []  309.08 308.46 90 top
NOREF#3615  -  []  302.98 296.26 0 top
NOREF#3616  -  []  472.3 141.48 90 top
NOREF#3617  -  []  403.19 165.45 0 top
NOREF#3618  -  []  391.8 299.51 0 top
NOREF#3619  -  []  422.41 307.36 0 top
NOREF#3620  -  []  69.58 46.86 0 top
NOREF#3621  -  []  337.86 194.29 0 top
NOREF#3622  -  []  346.46 242.05 0 top
NOREF#3623  -  []  461.65 223.83 0 top
NOREF#3624  -  []  481.54 267.31 0 top
NOREF#3625  -  []  395.61 213.47 0 top
NOREF#3626  -  []  344.76 289.66 0 top
NOREF#3627  -  []  305.68 229.23 90 top
NOREF#3628  -  []  367.66 310.84 0 top
NOREF#3629  -  []  522.65 264.65 0 top
NOREF#3630  -  []  533.35 290.19 90 top
NOREF#3631  -  []  427.53 311.22 90 top
NOREF#3632  -  []  215.36 313.44 90 top
NOREF#3633  -  []  355.22 245.28 0 top
NOREF#3634  -  []  268.11 295.6 0 top
NOREF#3635  -  []  470.69 344.55 0 top
NOREF#3636  -  []  425.07 280.36 90 top
NOREF#3637  -  []  200.81 259.12 90 top
NOREF#3638  -  []  319.08 298.86 90 top
NOREF#3639  -  []  425.18 329.41 90 top
NOREF#3640  -  []  228.44 259.36 90 top
NOREF#3641  -  []  374.38 319.56 0 top
NOREF#3642  -  []  282.07 267.61 90 top
NOREF#3643  -  []  463.34 316 90 top
NOREF#3644  -  []  227.94 132.12 90 top
NOREF#3645  -  []  385.78 229.14 90 top
NOREF#3646  -  []  393.36 270.75 0 top
NOREF#3647  -  []  205.15 151.48 90 top
NOREF#3648  -  []  309.08 304.86 90 top
NOREF#3649  -  []  356.12 244.96 90 top
NOREF#3650  -  []  308.09 293.15 90 top
NOREF#3651  -  []  308.39 301.41 90 top
NOREF#3652  -  []  303.35 237.91 90 top
NOREF#3653  -  []  301.68 251.19 0 top
NOREF#3654  -  []  423.58 288.32 0 top
NOREF#3655  -  []  481.54 305.66 90 top
NOREF#3656  -  []  336.07 416.55 90 top
NOREF#3657  -  []  414.71 249.44 90 top
NOREF#3658  -  []  399.59 308.7 90 top
NOREF#3659  -  []  174.46 227.04 0 top
NOREF#3660  -  []  364.92 224.96 0 top
NOREF#3661  -  []  312.1 298.98 0 top
NOREF#3662  -  []  303.58 296.95 90 top
NOREF#3663  -  []  231.11 139.19 90 top
NOREF#3664  -  []  390.32 231.39 90 top
NOREF#3665  -  []  431.81 255.75 0 top
NOREF#3666  -  []  311.23 326.4 0 top
NOREF#3667  -  []  385.53 179.05 0 top
NOREF#3668  -  []  392.01 248.09 0 top
NOREF#3669  -  []  305.65 295.93 0 top
NOREF#3670  -  []  431.8 298.66 0 top
NOREF#3671  -  []  422.88 240.86 90 top
NOREF#3672  -  []  387.29 298.22 0 top
NOREF#3673  -  []  392.06 251.23 90 top
NOREF#3674  -  []  413.06 310.84 90 top
NOREF#3675  -  []  308.09 233.43 90 top
NOREF#3676  -  []  485.09 268.71 0 top
NOREF#3677  -  []  399.08 314.86 0 top
NOREF#3678  -  []  426.14 302.35 90 top
NOREF#3679  -  []  306.25 297.9 0 top
NOREF#3680  -  []  539.65 254.26 90 top
NOREF#3681  -  []  372.51 111.35 0 top
NOREF#3682  -  []  370.08 263.86 0 top
NOREF#3683  -  []  387.44 293.68 0 top
NOREF#3684  -  []  211.51 299.96 0 top
NOREF#3685  -  []  432 246.67 0 top
NOREF#3686  -  []  408.35 342.08 0 top
NOREF#3687  -  []  256.21 239.34 0 top
NOREF#3688  -  []  273.65 339.03 90 top
NOREF#3689  -  []  217.01 327.94 90 top
NOREF#3690  -  []  359.08 314.86 0 top
NOREF#3691  -  []  412.85 302.61 90 top
NOREF#3692  -  []  384.48 238.55 0 top
NOREF#3693  -  []  348.07 237.2 90 top
NOREF#3694  -  []  351.3 179.81 0 top
NOREF#3695  -  []  270.81 308.5 90 top
NOREF#3696  -  []  463.85 306.43 0 top
NOREF#3697  -  []  392.1 302.06 0 top
NOREF#3698  -  []  374.25 296.3 90 top
NOREF#3699  -  []  430.78 126.62 0 top
NOREF#3700  -  []  239.87 243.46 90 top
NOREF#3701  -  []  247.22 279.15 0 top
NOREF#3702  -  []  46.95 400.01 0 top
NOREF#3703  -  []  501.34 308.86 0 top
NOREF#3704  -  []  322.68 267.2 90 top
NOREF#3705  -  []  524.7 230.02 0 top
NOREF#3706  -  []  189.36 312.27 0 top
NOREF#3707  -  []  346.42 129.21 90 top
NOREF#3708  -  []  388.39 241.41 90 top
NOREF#3709  -  []  475.85 126.65 90 top
NOREF#3710  -  []  349.74 293.89 90 top
NOREF#3711  -  []  219.19 286.41 0 top
NOREF#3712  -  []  69.58 46.86 0 top
NOREF#3713  -  []  379.12 310.02 90 top
NOREF#3714  -  []  353.34 324.37 90 top
NOREF#3715  -  []  353.21 247.45 90 top
NOREF#3716  -  []  485.09 251.67 0 top
NOREF#3717  -  []  308.07 237.2 90 top
NOREF#3718  -  []  374.25 236.3 90 top
NOREF#3719  -  []  474.04 424.22 0 top
NOREF#3720  -  []  302.88 240.86 0 top
NOREF#3721  -  []  527.52 314.25 90 top
NOREF#3722  -  []  226.79 217.83 90 top
NOREF#3723  -  []  516.09 235.68 90 top
NOREF#3724  -  []  387.45 237.26 90 top
NOREF#3725  -  []  382.41 308.21 0 top
NOREF#3726  -  []  340.33 270.82 0 top
NOREF#3727  -  []  315.61 210.88 0 top
NOREF#3728  -  []  427.29 238.22 0 top
NOREF#3729  -  []  499.14 327.25 0 top
NOREF#3730  -  []  499.14 240.28 0 top
NOREF#3731  -  []  523.96 402.82 90 top
NOREF#3732  -  []  432 249.58 0 top
NOREF#3733  -  []  347.7 424.44 90 top
NOREF#3734  -  []  381.68 251.19 0 top
NOREF#3735  -  []  477.22 317.25 90 top
NOREF#3736  -  []  389.92 287.85 90 top
NOREF#3737  -  []  440.2 280.94 90 top
NOREF#3738  -  []  261.1 216.37 0 top
NOREF#3739  -  []  206.11 277.75 0 top
NOREF#3740  -  []  238.22 279.15 90 top
NOREF#3741  -  []  386.85 295.29 90 top
NOREF#3742  -  []  473.66 217.38 0 top
NOREF#3743  -  []  294.94 304.03 90 top
NOREF#3744  -  []  491.34 215.27 0 top
NOREF#3745  -  []  391.23 266.4 0 top
NOREF#3746  -  []  279.08 254.86 0 top
NOREF#3747  -  []  394.92 246.97 0 top
NOREF#3748  -  []  382.38 179.21 0 top
NOREF#3749  -  []  407.95 302.35 90 top
NOREF#3750  -  []  414.38 259.56 0 top
NOREF#3751  -  []  313.2 306.03 90 top
NOREF#3752  -  []  385.65 295.93 0 top
NOREF#3753  -  []  341.08 298.36 0 top
NOREF#3754  -  []  284.75 305.55 0 top
NOREF#3755  -  []  427.29 298.22 0 top
NOREF#3756  -  []  231.93 420.39 0 top
NOREF#3757  -  []  524.45 321.81 90 top
NOREF#3758  -  []  384.9 226.88 0 top
NOREF#3759  -  []  212.16 210.57 0 top
NOREF#3760  -  []  215.36 260.76 90 top
NOREF#3761  -  []  344.08 243.86 0 top
NOREF#3762  -  []  351.48 232.15 0 top
NOREF#3763  -  []  385.68 237.27 90 top
NOREF#3764  -  []  304.08 303.86 0 top
NOREF#3765  -  []  345.36 229.74 0 top
NOREF#3766  -  []  206.11 209.17 0 top
NOREF#3767  -  []  380.33 267.57 0 top
NOREF#3768  -  []  309.74 232.01 0 top
NOREF#3769  -  []  207.76 260.76 0 top
NOREF#3770  -  []  206.11 243.46 0 top
NOREF#3771  -  []  524.7 321.46 0 top
NOREF#3772  -  []  535.43 226.83 90 top
NOREF#3773  -  []  438.17 337.05 0 top
NOREF#3774  -  []  313.21 247.45 90 top
NOREF#3775  -  []  223.24 147.82 90 top
NOREF#3776  -  []  231.93 422.95 0 top
NOREF#3777  -  []  174.46 238.47 0 top
NOREF#3778  -  []  264.76 342.84 0 top
NOREF#3779  -  []  524.2 308.86 0 top
NOREF#3780  -  []  458.45 306.43 0 top
NOREF#3781  -  []  465.33 137.08 90 top
NOREF#3782  -  []  392 249.58 0 top
NOREF#3783  -  []  308.84 234.21 0 top
NOREF#3784  -  []  498.71 282.25 0 top
NOREF#3785  -  []  382.98 236.26 0 top
NOREF#3786  -  []  353 238.02 90 top
NOREF#3787  -  []  345.35 296.29 90 top
NOREF#3788  -  []  275.71 247.29 90 top
NOREF#3789  -  []  305.91 129.21 90 top
NOREF#3790  -  []  281.22 333.22 0 top
NOREF#3791  -  []  345.77 229.36 90 top
NOREF#3792  -  []  429.74 293.89 90 top
NOREF#3793  -  []  393 302.38 0 top
NOREF#3794  -  []  485.09 303 0 top
NOREF#3795  -  []  425.86 299.55 0 top
NOREF#3796  -  []  331.77 411.05 0 top
NOREF#3797  -  []  198.73 321.51 0 top
NOREF#3798  -  []  303.53 330.81 90 top
NOREF#3799  -  []  507.37 284.56 0 top
NOREF#3800  -  []  433.91 314.79 90 top
NOREF#3801  -  []  536.7 212.38 0 top
NOREF#3802  -  []  200.81 213.4 90 top
NOREF#3803  -  []  422.75 240.26 90 top
NOREF#3804  -  []  352.06 190.65 90 top
NOREF#3805  -  []  540.2 329.86 90 top
NOREF#3806  -  []  200.26 300.84 90 top
NOREF#3807  -  []  412.08 331.86 0 top
NOREF#3808  -  []  425.77 289.36 90 top
NOREF#3809  -  []  425.13 229.66 0 top
NOREF#3810  -  []  249.42 217.83 0 top
NOREF#3811  -  []  350.32 231.39 90 top
NOREF#3812  -  []  439.59 308.7 90 top
NOREF#3813  -  []  379.15 242.83 0 top
NOREF#3814  -  []  200.81 290.22 0 top
NOREF#3815  -  []  393.2 306.03 90 top
NOREF#3816  -  []  405.56 377.2 90 top
NOREF#3817  -  []  238.87 332.91 90 top
NOREF#3818  -  []  53.55 431.12 0 top
NOREF#3819  -  []  337.86 163.81 0 top
NOREF#3820  -  []  290.08 263.86 0 top
NOREF#3821  -  []  292.08 271.63 90 top
NOREF#3822  -  []  270.31 247.29 0 top
NOREF#3823  -  []  270.81 342.79 90 top
NOREF#3824  -  []  262.89 339.67 90 top
NOREF#3825  -  []  304.08 248.86 90 top
NOREF#3826  -  []  230.62 295.05 0 top
NOREF#3827  -  []  477.88 402.82 90 top
NOREF#3828  -  []  304.48 309.03 0 top
NOREF#3829  -  []  424.86 242.05 0 top
NOREF#3830  -  []  388.08 293.18 90 top
NOREF#3831  -  []  342.21 135.43 90 top
NOREF#3832  -  []  351.11 245.56 0 top
NOREF#3833  -  []  431.15 300.26 0 top
NOREF#3834  -  []  473.94 402.82 0 top
NOREF#3835  -  []  427.66 233.75 0 top
NOREF#3836  -  []  223.59 252.12 0 top
NOREF#3837  -  []  344.45 297.19 90 top
NOREF#3838  -  []  354.07 226.36 0 top
NOREF#3839  -  []  429.68 304.71 90 top
NOREF#3840  -  []  383.58 287.38 0 top
NOREF#3841  -  []  427.53 251.22 90 top
NOREF#3842  -  []  301.34 125.35 0 top
NOREF#3843  -  []  252.62 244.86 90 top
NOREF#3844  -  []  165.53 90.42 0 top
NOREF#3845  -  []  281.41 208.53 90 top
NOREF#3846  -  []  388.08 233.38 90 top
NOREF#3847  -  []  391.81 315.75 0 top
NOREF#3848  -  []  387.53 311.22 90 top
NOREF#3849  -  []  383.31 306.4 90 top
NOREF#3850  -  []  385.86 239.55 0 top
NOREF#3851  -  []  366.54 195.05 0 top
NOREF#3852  -  []  440.62 218.44 90 top
NOREF#3853  -  []  351.9 174.21 90 top
NOREF#3854  -  []  301.67 396.63 0 top
NOREF#3855  -  []  496.52 251.67 0 top
NOREF#3856  -  []  425.08 308.86 0 top
NOREF#3857  -  []  427.34 296.08 0 top
NOREF#3858  -  []  348.84 232.33 0 top
NOREF#3859  -  []  275.71 322.88 90 top
NOREF#3860  -  []  223.59 244.86 0 top
NOREF#3861  -  []  347.23 238.3 0 top
NOREF#3862  -  []  339.58 241.86 0 top
NOREF#3863  -  []  69.58 506.86 0 top
NOREF#3864  -  []  310.94 286.5 90 top
NOREF#3865  -  []  349.58 335.71 0 top
NOREF#3866  -  []  387.66 293.75 0 top
NOREF#3867  -  []  505.16 284.15 0 top
NOREF#3868  -  []  389.12 232.03 0 top
NOREF#3869  -  []  533.35 326.68 90 top
NOREF#3870  -  []  362.68 327.2 90 top
NOREF#3871  -  []  343.58 230.2 0 top
NOREF#3872  -  []  522 224.38 0 top
NOREF#3873  -  []  495.94 267.31 0 top
NOREF#3874  -  []  303.88 236.58 0 top
NOREF#3875  -  []  299.15 251.62 0 top
NOREF#3876  -  []  348.84 294.21 0 top
NOREF#3877  -  []  298.47 338.08 0 top
NOREF#3878  -  []  409.86 310.84 0 top
NOREF#3879  -  []  418.98 213.2 90 top
NOREF#3880  -  []  385.07 220.36 90 top
NOREF#3881  -  []  513.16 419.09 0 top
NOREF#3882  -  []  307.31 293.29 0 top
NOREF#3883  -  []  426.87 302.35 90 top
NOREF#3884  -  []  329.86 310.84 0 top
NOREF#3885  -  []  387.73 298.21 0 top
NOREF#3886  -  []  223.59 337.74 0 top
NOREF#3887  -  []  382.54 177.36 90 top
NOREF#3888  -  []  455.96 211.52 0 top
NOREF#3889  -  []  442.11 277.77 0 top
NOREF#3890  -  []  49.87 379.69 90 top
NOREF#3891  -  []  429.4 295.85 90 top
NOREF#3892  -  []  310.58 243.36 90 top
NOREF#3893  -  []  565.58 488.36 0 top
NOREF#3894  -  []  284.75 245.55 0 top
NOREF#3895  -  []  473.66 260.07 0 top
NOREF#3896  -  []  304.9 286.88 0 top
NOREF#3897  -  []  305.18 269.42 90 top
NOREF#3898  -  []  524.7 310.03 0 top
NOREF#3899  -  []  258.32 238.07 0 top
NOREF#3900  -  []  410.08 263.86 0 top
NOREF#3901  -  []  530.15 286.36 0 top
NOREF#3902  -  []  193.96 275.51 0 top
NOREF#3903  -  []  233.66 402.82 90 top
NOREF#3904  -  []  420.35 241.51 90 top
NOREF#3905  -  []  430.97 293.86 90 top
NOREF#3906  -  []  327.95 297.95 90 top
NOREF#3907  -  []  524.45 253.23 90 top
NOREF#3908  -  []  299.08 334.86 0 top
NOREF#3909  -  []  300.35 300.82 90 top
NOREF#3910  -  []  49.28 401.61 0 top
NOREF#3911  -  []  473.66 225.78 0 top
NOREF#3912  -  []  292.2 144.68 0 top
NOREF#3913  -  []  429.74 287.14 0 top
NOREF#3914  -  []  200.81 341.34 90 top
NOREF#3915  -  []  374.28 269.42 0 top
NOREF#3916  -  []  344.08 303.86 0 top
NOREF#3917  -  []  659.58 41.86 90 top
NOREF#3918  -  []  373.06 310.84 90 top
NOREF#3919  -  []  436.44 283.87 0 top
NOREF#3920  -  []  444.92 281.76 90 top
NOREF#3921  -  []  527.52 254.07 90 top
NOREF#3922  -  []  444.92 218.6 0 top
NOREF#3923  -  []  304.46 227.38 90 top
NOREF#3924  -  []  504.66 288.36 90 top
NOREF#3925  -  []  347.28 311.87 0 top
NOREF#3926  -  []  299.08 274.86 0 top
NOREF#3927  -  []  387.31 233.29 0 top
NOREF#3928  -  []  519.22 170.73 90 top
NOREF#3929  -  []  427.66 293.29 0 top
NOREF#3930  -  []  261.1 319.24 0 top
NOREF#3931  -  []  391.11 305.56 0 top
NOREF#3932  -  []  341.08 311.06 0 top
NOREF#3933  -  []  418.25 245.26 0 top
NOREF#3934  -  []  458.45 299.42 0 top
NOREF#3935  -  []  315.22 306.65 0 top
NOREF#3936  -  []  377.92 310.66 0 top
NOREF#3937  -  []  307.06 238.91 90 top
NOREF#3938  -  []  305.77 229.16 90 top
NOREF#3939  -  []  432.1 241.21 0 top
NOREF#3940  -  []  420.35 240.82 90 top
NOREF#3941  -  []  32.37 448.49 0 top
NOREF#3942  -  []  71.55 48.42 0 top
NOREF#3943  -  []  428.59 288.35 0 top
NOREF#3944  -  []  337.6 249.76 90 top
NOREF#3945  -  []  387.31 293.29 0 top
NOREF#3946  -  []  423.58 238.23 0 top
NOREF#3947  -  []  209.96 313.44 0 top
NOREF#3948  -  []  426.25 237.9 0 top
NOREF#3949  -  []  363.81 309.44 0 top
NOREF#3950  -  []  294.25 296.3 90 top
NOREF#3951  -  []  459.67 122.54 90 top
NOREF#3952  -  []  347.19 302.05 0 top
NOREF#3953  -  []  322.68 327.2 0 top
NOREF#3954  -  []  374.94 244.03 90 top
NOREF#3955  -  []  449.58 87.36 0 top
NOREF#3956  -  []  301.08 238.36 0 top
NOREF#3957  -  []  331.06 115.19 0 top
NOREF#3958  -  []  217.54 327.94 0 top
NOREF#3959  -  []  358.21 329.35 90 top
NOREF#3960  -  []  433.34 259.97 90 top
NOREF#3961  -  []  424.48 229.88 0 top
NOREF#3962  -  []  321.71 112.14 0 top
NOREF#3963  -  []  507.37 339.95 90 top
NOREF#3964  -  []  259.73 265.17 90 top
NOREF#3965  -  []  383.9 290.5 0 top
NOREF#3966  -  []  347.45 237.26 90 top
NOREF#3967  -  []  339.15 241.46 0 top
NOREF#3968  -  []  318.44 132.6 0 top
NOREF#3969  -  []  307.66 293.75 0 top
NOREF#3970  -  []  306.25 237.9 0 top
NOREF#3971  -  []  401.4 208.02 90 top
NOREF#3972  -  []  71.55 446.92 0 top
NOREF#3973  -  []  328.12 218.6 0 top
NOREF#3974  -  []  540.2 232.49 0 top
NOREF#3975  -  []  278.86 203.45 90 top
NOREF#3976  -  []  236.5 419.12 90 top
NOREF#3977  -  []  282.08 231.86 90 top
NOREF#3978  -  []  350.14 267.57 0 top
NOREF#3979  -  []  539.65 288.55 90 top
NOREF#3980  -  []  533.35 271.74 90 top
NOREF#3981  -  []  198.73 281.17 90 top
NOREF#3982  -  []  174.46 307.05 0 top
NOREF#3983  -  []  343.58 238.23 0 top
NOREF#3984  -  []  301.91 336.38 0 top
NOREF#3985  -  []  539.65 242.83 90 top
NOREF#3986  -  []  54.27 433.66 0 top
NOREF#3987  -  []  423.31 305.55 90 top
NOREF#3988  -  []  305.1 237.2 90 top
NOREF#3989  -  []  381.78 173.61 90 top
NOREF#3990  -  []  321.62 227.86 45 top
NOREF#3991  -  []  387.19 302.05 0 top
NOREF#3992  -  []  394.92 245.6 0 top
NOREF#3993  -  []  440.2 280.06 90 top
NOREF#3994  -  []  471.79 234.48 0 top
NOREF#3995  -  []  304.76 229.66 0 top
NOREF#3996  -  []  461.98 125.38 90 top
NOREF#3997  -  []  303.25 237.85 0 top
NOREF#3998  -  []  423.53 324.37 90 top
NOREF#3999  -  []  370.29 163.81 0 top
NOREF#4000  -  []  345.68 309.03 0 top
NOREF#4001  -  []  497.33 280.65 90 top
NOREF#4002  -  []  386.6 311.22 90 top
NOREF#4003  -  []  494.53 139.83 0 top
NOREF#4004  -  []  304.48 237.91 0 top
NOREF#4005  -  []  659.58 41.86 90 top
NOREF#4006  -  []  259.73 299.46 90 top
NOREF#4007  -  []  32.37 391.85 90 top
NOREF#4008  -  []  286.69 267.61 90 top
NOREF#4009  -  []  351.11 305.56 0 top
NOREF#4010  -  []  350.94 231.37 90 top
NOREF#4011  -  []  489.91 250.27 0 top
NOREF#4012  -  []  251.3 336.34 90 top
NOREF#4013  -  []  385.35 242.35 90 top
NOREF#4014  -  []  300.35 301.51 90 top
NOREF#4015  -  []  324.92 281.76 90 top
NOREF#4016  -  []  393.44 233.48 90 top
NOREF#4017  -  []  382.54 192.6 90 top
NOREF#4018  -  []  69.58 506.86 0 top
NOREF#4019  -  []  65.1 453.95 90 top
NOREF#4020  -  []  290.08 263.86 0 top
NOREF#4021  -  []  472.54 281.36 0 top
NOREF#4022  -  []  385.65 235.93 0 top
NOREF#4023  -  []  379.15 304.28 0 top
NOREF#4024  -  []  426.37 297.89 0 top
NOREF#4025  -  []  189.36 335.13 0 top
NOREF#4026  -  []  348.09 233.15 90 top
NOREF#4027  -  []  74.58 41.86 90 top
NOREF#4028  -  []  425.35 297.58 0 top
NOREF#4029  -  []  221.39 269.16 0 top
NOREF#4030  -  []  433 298.02 90 top
NOREF#4031  -  []  538.95 219.78 90 top
NOREF#4032  -  []  319.64 258.32 90 top
NOREF#4033  -  []  422.41 306.51 0 top
NOREF#4034  -  []  430.79 343.24 0 top
NOREF#4035  -  []  324.08 229.86 90 top
NOREF#4036  -  []  71.55 109.92 0 top
NOREF#4037  -  []  533.35 294.6 90 top
NOREF#4038  -  []  487.71 284.56 0 top
NOREF#4039  -  []  469.16 270.37 90 top
NOREF#4040  -  []  259.36 336.59 0 top
NOREF#4041  -  []  305.77 289.16 90 top
NOREF#4042  -  []  340.58 339.4 0 top
NOREF#4043  -  []  405.46 250.84 0 top
NOREF#4044  -  []  382.11 246.19 0 top
NOREF#4045  -  []  458.52 324.16 90 top
NOREF#4046  -  []  386.16 239.87 0 top
NOREF#4047  -  []  303.88 235.94 0 top
