# Allegro board 038RT-8730CN_1116-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#207  -  []  486.94 240.28 0 top
NOREF#208  -  []  388.54 234.54 0 top
NOREF#209  -  []  477.22 282.96 90 top
NOREF#210  -  []  469.4 279.46 0 top
NOREF#211  -  []  284.33 209.8 90 top
NOREF#212  -  []  383.88 235.94 0 top
NOREF#213  -  []  344.75 235.61 0 top
NOREF#214  -  []  223.59 295.05 0 top
NOREF#215  -  []  367.42 338.45 90 top
NOREF#216  -  []  306.33 311.86 0 top
NOREF#217  -  []  347.34 296.08 0 top
NOREF#218  -  []  484.74 233.02 0 top
NOREF#219  -  []  307.19 302.05 0 top
NOREF#220  -  []  524.2 343.15 0 top
NOREF#221  -  []  232.82 279.15 0 top
NOREF#222  -  []  415.93 270.82 0 top
NOREF#223  -  []  209.96 260.76 0 top
NOREF#224  -  []  507.37 281.36 90 top
NOREF#225  -  []  299.15 304.94 0 top
NOREF#226  -  []  485.09 310.26 0 top
NOREF#227  -  []  378.48 340.67 0 top
NOREF#228  -  []  287.95 242.35 90 top
NOREF#229  -  []  463.65 145.48 0 top
NOREF#230  -  []  463.85 223.83 0 top
NOREF#231  -  []  217.54 293.65 0 top
NOREF#232  -  []  384.86 242.05 0 top
NOREF#233  -  []  379.08 218.86 90 top
NOREF#234  -  []  378.48 338.08 0 top
NOREF#235  -  []  433.51 212.15 0 top
NOREF#236  -  []  279.08 238.86 90 top
NOREF#237  -  []  71.55 48.42 0 top
NOREF#238  -  []  337.86 189.61 90 top
NOREF#239  -  []  240.4 302.05 0 top
NOREF#240  -  []  362.61 117.24 0 top
NOREF#241  -  []  469.17 129.19 0 top
NOREF#242  -  []  315.58 240.86 90 top
NOREF#243  -  []  383.9 237.85 0 top
NOREF#244  -  []  71.55 48.42 0 top
NOREF#245  -  []  530.15 240.64 0 top
NOREF#246  -  []  346.87 297.85 0 top
NOREF#247  -  []  383.25 297.84 0 top
NOREF#248  -  []  374.19 118.96 0 top
NOREF#249  -  []  501.69 262.71 90 top
NOREF#250  -  []  292.85 302.61 0 top
NOREF#251  -  []  372.11 243.78 0 top
NOREF#252  -  []  343.58 290.2 0 top
NOREF#253  -  []  351.37 117.51 0 top
NOREF#254  -  []  426.95 139.28 90 top
NOREF#255  -  []  216.58 159.1 0 top
NOREF#256  -  []  343.9 290.5 0 top
NOREF#257  -  []  49.28 395.61 90 top
NOREF#258  -  []  352.7 246.78 90 top
NOREF#259  -  []  383.58 229.6 90 top
NOREF#260  -  []  265.56 302.75 0 top
NOREF#261  -  []  514.05 211.76 90 top
NOREF#262  -  []  421.08 251.06 0 top
NOREF#263  -  []  200.81 244.5 0 top
NOREF#264  -  []  487.71 250.27 0 top
NOREF#265  -  []  540.2 209.63 0 top
NOREF#266  -  []  328.95 119.51 0 top
NOREF#267  -  []  514.63 126.36 90 top
NOREF#268  -  []  499.14 308.86 0 top
NOREF#269  -  []  435.02 301.03 0 top
NOREF#270  -  []  334.94 304.03 90 top
NOREF#271  -  []  313 242.38 0 top
NOREF#272  -  []  305.1 297.19 90 top
NOREF#273  -  []  429.32 251.23 90 top
NOREF#274  -  []  292.08 281.86 90 top
NOREF#275  -  []  389.85 297.94 90 top
NOREF#276  -  []  346.16 239.87 0 top
NOREF#277  -  []  379.15 304.94 0 top
NOREF#278  -  []  342.11 307.04 0 top
NOREF#279  -  []  393.34 322.17 90 top
NOREF#280  -  []  208.28 300.49 90 top
NOREF#281  -  []  478.43 403.62 90 top
NOREF#282  -  []  349.54 237.24 0 top
NOREF#283  -  []  427.06 298.91 90 top
NOREF#284  -  []  431.11 304.05 0 top
NOREF#285  -  []  347.06 293.68 0 top
NOREF#286  -  []  338.98 213.2 90 top
NOREF#287  -  []  307.45 297.26 90 top
NOREF#288  -  []  309.77 294.51 0 top
NOREF#289  -  []  428.09 233.43 90 top
NOREF#290  -  []  279.5 215.9 0 top
NOREF#291  -  []  324.75 245.55 0 top
NOREF#292  -  []  228.44 267.76 90 top
NOREF#293  -  []  427.6 310.97 90 top
NOREF#294  -  []  492.49 129.44 0 top
NOREF#295  -  []  311.45 392 90 top
NOREF#296  -  []  74.58 41.86 90 top
NOREF#297  -  []  527.07 317.76 90 top
NOREF#298  -  []  309.8 244.86 90 top
NOREF#299  -  []  352.7 306.78 90 top
NOREF#300  -  []  311.48 232.15 0 top
NOREF#301  -  []  420.33 327.57 0 top
NOREF#302  -  []  429.85 297.94 90 top
NOREF#303  -  []  420.33 267.57 0 top
NOREF#304  -  []  470.69 275.97 0 top
NOREF#305  -  []  418.11 207.71 90 top
NOREF#306  -  []  428.44 250.97 90 top
NOREF#307  -  []  383.53 324.37 90 top
NOREF#308  -  []  314.92 242.85 0 top
NOREF#309  -  []  286.75 145.48 0 top
NOREF#310  -  []  71.55 48.42 0 top
NOREF#311  -  []  391.8 238.66 0 top
NOREF#312  -  []  410.08 323.86 0 top
NOREF#313  -  []  465.07 280.36 90 top
NOREF#314  -  []  305.36 229.28 0 top
NOREF#315  -  []  326.67 209.62 0 top
NOREF#316  -  []  206.11 250.72 0 top
NOREF#317  -  []  535.43 312.89 0 top
NOREF#318  -  []  212.16 217.83 0 top
NOREF#319  -  []  304.48 297.91 0 top
NOREF#320  -  []  471.68 315.65 0 top
NOREF#321  -  []  316.21 252.13 90 top
NOREF#322  -  []  507.95 225.78 0 top
NOREF#323  -  []  481.54 229.82 90 top
NOREF#324  -  []  382.44 315.5 90 top
NOREF#325  -  []  414.25 236.3 90 top
NOREF#326  -  []  535.43 301.46 0 top
NOREF#327  -  []  200.26 232.26 90 top
NOREF#328  -  []  540.2 226.99 90 top
NOREF#329  -  []  287.53 121.65 0 top
NOREF#330  -  []  392.71 255.43 0 top
NOREF#331  -  []  547.22 375.13 0 top
NOREF#332  -  []  309.85 237.94 90 top
NOREF#333  -  []  198.73 230.07 0 top
NOREF#334  -  []  308.44 310.97 90 top
NOREF#335  -  []  346.87 242.35 90 top
NOREF#336  -  []  389.08 248.46 90 top
NOREF#337  -  []  347.67 338.89 90 top
NOREF#338  -  []  423.26 288.02 0 top
NOREF#339  -  []  383.88 236.58 0 top
NOREF#340  -  []  436.8 390.1 0 top
NOREF#341  -  []  270.81 272.01 90 top
NOREF#342  -  []  189.36 323.7 0 top
NOREF#343  -  []  442.68 332.6 90 top
NOREF#344  -  []  283.38 344.2 90 top
NOREF#345  -  []  303.88 295.94 0 top
NOREF#346  -  []  217.01 250.72 90 top
NOREF#347  -  []  282.08 261.86 0 top
NOREF#348  -  []  383.58 290.2 0 top
NOREF#349  -  []  507.37 289.76 90 top
NOREF#350  -  []  432.01 248.09 0 top
NOREF#351  -  []  394.2 240.89 90 top
NOREF#352  -  []  307.28 311.87 0 top
NOREF#353  -  []  314.92 305.6 0 top
NOREF#354  -  []  299.08 278.86 90 top
NOREF#355  -  []  279.08 314.86 0 top
NOREF#356  -  []  345.58 229.16 90 top
NOREF#357  -  []  356.18 132.12 90 top
NOREF#358  -  []  302.36 139.28 90 top
NOREF#359  -  []  324.92 284.96 0 top
NOREF#360  -  []  407.95 240.15 90 top
NOREF#361  -  []  451 273.96 90 top
NOREF#362  -  []  391.16 270.75 0 top
NOREF#363  -  []  200.26 220.83 90 top
NOREF#364  -  []  334.1 342.74 90 top
NOREF#365  -  []  335.91 139.28 90 top
NOREF#366  -  []  339.15 304.28 0 top
NOREF#367  -  []  392.01 305.88 0 top
NOREF#368  -  []  309.32 251.23 90 top
NOREF#369  -  []  359.08 298.86 90 top
NOREF#370  -  []  533.35 280.96 90 top
NOREF#371  -  []  337.6 309.76 90 top
NOREF#372  -  []  425.67 302.05 0 top
NOREF#373  -  []  422.75 300.26 90 top
NOREF#374  -  []  362.03 210.89 0 top
NOREF#375  -  []  496.52 285.96 0 top
NOREF#376  -  []  256.21 273.63 0 top
NOREF#377  -  []  246.45 260.76 0 top
NOREF#378  -  []  487.55 148.72 0 top
NOREF#379  -  []  518.8 301.6 0 top
NOREF#380  -  []  322.08 291.86 90 top
NOREF#381  -  []  355.22 302.53 0 top
NOREF#382  -  []  366.54 173.61 90 top
NOREF#383  -  []  200.81 236.26 90 top
NOREF#384  -  []  351.3 188.85 90 top
NOREF#385  -  []  262.37 284.95 90 top
NOREF#386  -  []  377.92 250.66 0 top
NOREF#387  -  []  304.75 235.61 0 top
NOREF#388  -  []  374.94 304.03 90 top
NOREF#389  -  []  499.14 267.31 0 top
NOREF#390  -  []  364.75 245.55 0 top
NOREF#391  -  []  518.8 271.37 90 top
NOREF#392  -  []  409.47 132.6 0 top
NOREF#393  -  []  331.05 243.75 0 top
NOREF#394  -  []  536.7 326.68 0 top
NOREF#395  -  []  389.83 258.32 90 top
NOREF#396  -  []  235.02 234.87 0 top
NOREF#397  -  []  423.53 319.97 90 top
NOREF#398  -  []  501.69 304.26 90 top
NOREF#399  -  []  437.46 129.21 90 top
NOREF#400  -  []  342.88 240.86 0 top
NOREF#401  -  []  367.95 242.35 90 top
NOREF#402  -  []  343.53 324.37 90 top
NOREF#403  -  []  198.73 235.45 90 top
NOREF#404  -  []  319.64 318.32 90 top
NOREF#405  -  []  301.71 178.22 0 top
NOREF#406  -  []  539.65 265.69 90 top
NOREF#407  -  []  510.57 308.86 0 top
NOREF#408  -  []  345.35 297.58 0 top
NOREF#409  -  []  567.58 466.36 90 top
NOREF#410  -  []  528.87 196.07 0 top
NOREF#411  -  []  533.26 401.56 90 top
NOREF#412  -  []  474.04 421.66 0 top
NOREF#413  -  []  454.69 251.42 0 top
NOREF#414  -  []  229.82 421.66 0 top
NOREF#415  -  []  463.85 340.72 0 top
NOREF#416  -  []  364.92 215.4 90 top
NOREF#417  -  []  351.16 148.72 0 top
NOREF#418  -  []  217.54 312.04 0 top
NOREF#419  -  []  492.35 424.44 90 top
NOREF#420  -  []  368.34 159.13 90 top
NOREF#421  -  []  355.61 210.88 0 top
NOREF#422  -  []  428.71 221.31 0 top
NOREF#423  -  []  231.93 422.95 0 top
NOREF#424  -  []  530.15 229.21 0 top
NOREF#425  -  []  303.31 247.25 90 top
NOREF#426  -  []  276.71 271.88 0 top
NOREF#427  -  []  312.06 311.23 90 top
NOREF#428  -  []  235.02 279.15 0 top
NOREF#429  -  []  384.48 229.88 0 top
NOREF#430  -  []  510.57 284.56 0 top
NOREF#431  -  []  524.2 267.31 0 top
NOREF#432  -  []  432.06 251.23 90 top
NOREF#433  -  []  485.09 234.42 0 top
NOREF#434  -  []  71.55 446.92 0 top
NOREF#435  -  []  305.4 311.86 0 top
NOREF#436  -  []  348.09 293.15 90 top
NOREF#437  -  []  228.97 259.36 0 top
NOREF#438  -  []  469.64 241.37 90 top
NOREF#439  -  []  200.81 278.79 90 top
NOREF#440  -  []  351.8 238.66 0 top
NOREF#441  -  []  429.68 244.71 90 top
NOREF#442  -  []  516.09 245.67 90 top
NOREF#443  -  []  435.22 302.53 0 top
NOREF#444  -  []  493.39 131.53 90 top
NOREF#445  -  []  349.74 233.89 90 top
NOREF#446  -  []  353.21 307.45 90 top
NOREF#447  -  []  527.52 297 90 top
NOREF#448  -  []  345.78 229.14 90 top
NOREF#449  -  []  423.75 144.68 0 top
NOREF#450  -  []  381.08 311.06 0 top
NOREF#451  -  []  336.8 121.67 0 top
NOREF#452  -  []  423.58 228.32 0 top
NOREF#453  -  []  234.36 151.48 90 top
NOREF#454  -  []  458.45 296.22 90 top
NOREF#455  -  []  494.85 131.53 0 top
NOREF#456  -  []  380.35 304.3 90 top
NOREF#457  -  []  310.6 307.1 0 top
NOREF#458  -  []  352.25 294.12 0 top
NOREF#459  -  []  303.28 226.82 0 top
NOREF#460  -  []  212.16 244.86 0 top
NOREF#461  -  []  303.53 264.37 90 top
NOREF#462  -  []  342.87 137.08 90 top
NOREF#463  -  []  487.71 258.67 0 top
NOREF#464  -  []  364.92 284.96 0 top
NOREF#465  -  []  530.15 263.5 0 top
NOREF#466  -  []  302.88 240.86 0 top
NOREF#467  -  []  496.52 303 0 top
NOREF#468  -  []  431.1 246.35 0 top
NOREF#469  -  []  345.28 209.35 90 top
NOREF#470  -  []  311.1 246.35 0 top
NOREF#471  -  []  433.51 214.74 0 top
NOREF#472  -  []  300.33 267.57 0 top
NOREF#473  -  []  427.08 246.86 0 top
NOREF#474  -  []  478.6 336.12 90 top
NOREF#475  -  []  391.15 300.26 0 top
NOREF#476  -  []  384.08 303.86 0 top
NOREF#477  -  []  302.88 300.86 0 top
NOREF#478  -  []  353 238.87 90 top
NOREF#479  -  []  532.47 196.07 90 top
NOREF#480  -  []  343.58 288.32 90 top
NOREF#481  -  []  370.08 229.86 90 top
NOREF#482  -  []  430.78 131.75 0 top
NOREF#483  -  []  489.91 215.98 0 top
NOREF#484  -  []  469.64 207.08 90 top
NOREF#485  -  []  307.08 306.86 0 top
NOREF#486  -  []  351.1 306.35 0 top
NOREF#487  -  []  447.9 270.43 0 top
NOREF#488  -  []  213.31 233.42 90 top
NOREF#489  -  []  306.14 302.35 90 top
NOREF#490  -  []  207.08 336.29 90 top
NOREF#491  -  []  424.45 297.19 90 top
NOREF#492  -  []  217.39 160.37 0 top
NOREF#493  -  []  200.81 233.07 90 top
NOREF#494  -  []  423.28 288.64 0 top
NOREF#495  -  []  353.91 254.79 90 top
NOREF#496  -  []  425.78 229.14 90 top
NOREF#497  -  []  477.22 214.38 90 top
NOREF#498  -  []  392.08 299.36 90 top
NOREF#499  -  []  246.45 329.34 0 top
NOREF#500  -  []  432 306.67 0 top
NOREF#501  -  []  432.9 336.81 0 top
NOREF#502  -  []  302.41 247.36 0 top
NOREF#503  -  []  345.78 229.41 90 top
NOREF#504  -  []  393 238.87 90 top
NOREF#505  -  []  419.15 311.62 0 top
NOREF#506  -  []  495.94 305.66 90 top
NOREF#507  -  []  353.08 310.71 90 top
NOREF#508  -  []  270.31 288.59 0 top
NOREF#509  -  []  501.34 250.27 0 top
NOREF#510  -  []  393.28 291.15 90 top
NOREF#511  -  []  389.83 318.32 90 top
NOREF#512  -  []  232.82 210.57 0 top
NOREF#513  -  []  352.12 293.7 0 top
NOREF#514  -  []  340.35 304.3 90 top
NOREF#515  -  []  379.67 233.34 90 top
NOREF#516  -  []  410.33 219.4 0 top
NOREF#517  -  []  442.13 326.4 90 top
NOREF#518  -  []  355.02 301.03 0 top
NOREF#519  -  []  343.31 246.4 90 top
NOREF#520  -  []  221.39 295.05 0 top
NOREF#521  -  []  496.52 294.36 0 top
NOREF#522  -  []  281.35 377.58 90 top
NOREF#523  -  []  294.88 328.37 0 top
NOREF#524  -  []  348.07 297.2 90 top
NOREF#525  -  []  399.08 254.86 0 top
NOREF#526  -  []  469.17 131.75 0 top
NOREF#527  -  []  295.4 141.48 90 top
NOREF#528  -  []  351.1 309.26 0 top
NOREF#529  -  []  383.88 296.58 0 top
NOREF#530  -  []  342.98 296.26 0 top
NOREF#531  -  []  427.28 251.87 0 top
NOREF#532  -  []  233.15 270.05 0 top
NOREF#533  -  []  417.92 310.66 0 top
NOREF#534  -  []  205.28 231.38 0 top
NOREF#535  -  []  422.88 300.86 0 top
NOREF#536  -  []  231.93 417.82 0 top
NOREF#537  -  []  343.9 237.85 0 top
NOREF#538  -  []  187.37 159.1 0 top
NOREF#539  -  []  337.92 310.66 0 top
NOREF#540  -  []  378.25 301.78 0 top
NOREF#541  -  []  435.61 216.04 0 top
NOREF#542  -  []  383.26 228.02 0 top
NOREF#543  -  []  200.81 284.19 90 top
NOREF#544  -  []  213.31 302 90 top
NOREF#545  -  []  315.58 240.86 90 top
NOREF#546  -  []  386.22 296.54 90 top
NOREF#547  -  []  533.35 335.92 90 top
NOREF#548  -  []  398.17 337.05 0 top
NOREF#549  -  []  322.08 321.86 0 top
NOREF#550  -  []  524.51 406.82 90 top
NOREF#551  -  []  243.37 243.46 0 top
NOREF#552  -  []  347.53 311.22 90 top
NOREF#553  -  []  342.87 139.28 90 top
NOREF#554  -  []  303.9 290.5 0 top
NOREF#555  -  []  313.08 250.71 90 top
NOREF#556  -  []  41.87 427.59 90 top
NOREF#557  -  []  316.12 302.21 90 top
NOREF#558  -  []  427.23 298.3 0 top
NOREF#559  -  []  193.96 304.3 90 top
NOREF#560  -  []  270.31 254.3 0 top
NOREF#561  -  []  424.08 248.86 90 top
NOREF#562  -  []  308.09 233.15 90 top
NOREF#563  -  []  312.08 239.36 90 top
NOREF#564  -  []  342.75 240.26 90 top
NOREF#565  -  []  306.85 235.29 90 top
NOREF#566  -  []  387.31 329.35 0 top
NOREF#567  -  []  348.2 296.49 0 top
NOREF#568  -  []  345.68 249.03 0 top
NOREF#569  -  []  304.48 289.87 0 top
NOREF#570  -  []  469.4 313.75 0 top
NOREF#571  -  []  378.13 270.82 0 top
NOREF#572  -  []  527.52 269.97 90 top
NOREF#573  -  []  424.48 228 90 top
NOREF#574  -  []  423.58 298.23 0 top
NOREF#575  -  []  527.86 420.38 90 top
NOREF#576  -  []  302.88 240.86 0 top
NOREF#577  -  []  301.67 411.05 0 top
NOREF#578  -  []  396.12 242.21 90 top
NOREF#579  -  []  428.54 294.54 0 top
NOREF#580  -  []  425.35 302.35 90 top
NOREF#581  -  []  351.15 300.26 0 top
NOREF#582  -  []  387.01 342.57 90 top
NOREF#583  -  []  226.79 234.87 90 top
NOREF#584  -  []  312.25 234.12 0 top
NOREF#585  -  []  313 241.53 0 top
NOREF#586  -  []  352.1 301.21 0 top
NOREF#587  -  []  305.35 237.58 0 top
NOREF#588  -  []  230.62 329.34 0 top
NOREF#589  -  []  304.08 243.86 0 top
NOREF#590  -  []  403.81 249.44 0 top
NOREF#591  -  []  232.82 295.05 0 top
NOREF#592  -  []  288.08 264.86 0 top
NOREF#593  -  []  304.86 302.05 0 top
NOREF#594  -  []  372.08 281.86 90 top
NOREF#595  -  []  428.84 294.21 0 top
NOREF#596  -  []  501.69 297 90 top
NOREF#597  -  []  236.9 150.21 90 top
NOREF#598  -  []  507.37 327.25 0 top
NOREF#599  -  []  374.1 340.54 90 top
NOREF#600  -  []  200.81 255.93 0 top
NOREF#601  -  []  303.58 250.36 0 top
NOREF#602  -  []  501.34 318.85 0 top
NOREF#603  -  []  472.91 218.43 90 top
NOREF#604  -  []  380.35 240.82 90 top
NOREF#605  -  []  347.28 251.87 0 top
NOREF#606  -  []  423.88 295.94 0 top
NOREF#607  -  []  540.2 261.28 90 top
NOREF#608  -  []  313.34 262.17 90 top
NOREF#609  -  []  497.79 282.25 0 top
NOREF#610  -  []  434.7 218.11 90 top
NOREF#611  -  []  458.45 330.51 90 top
NOREF#612  -  []  372.85 242.61 90 top
NOREF#613  -  []  424.48 289.87 0 top
NOREF#614  -  []  284.98 330.3 90 top
NOREF#615  -  []  471.23 320.45 0 top
NOREF#616  -  []  299.08 218.86 90 top
NOREF#617  -  []  404.75 245.55 0 top
NOREF#618  -  []  472.54 315.65 0 top
NOREF#619  -  []  352.01 244.37 0 top
NOREF#620  -  []  463.34 210.93 90 top
NOREF#621  -  []  510.57 224.38 0 top
NOREF#622  -  []  327.95 300.15 90 top
NOREF#623  -  []  232.82 320.7 0 top
NOREF#624  -  []  495.94 258.67 0 top
NOREF#625  -  []  311.11 245.56 0 top
NOREF#626  -  []  429.12 292.03 0 top
NOREF#627  -  []  360.19 209.61 90 top
NOREF#628  -  []  382.15 238.55 0 top
NOREF#629  -  []  348.43 237.66 90 top
NOREF#630  -  []  518.8 233.02 0 top
NOREF#631  -  []  338.25 304.6 0 top
NOREF#632  -  []  528.87 230.36 0 top
NOREF#633  -  []  299.08 218.86 90 top
NOREF#634  -  []  266.46 328.49 0 top
NOREF#635  -  []  412.11 339.16 90 top
NOREF#636  -  []  332.11 303.78 0 top
NOREF#637  -  []  331.06 112.14 0 top
NOREF#638  -  []  512.77 233.02 0 top
NOREF#639  -  []  476.15 422.95 0 top
NOREF#640  -  []  272.51 247.29 0 top
NOREF#641  -  []  300.35 310.97 90 top
NOREF#642  -  []  351.8 239.51 0 top
NOREF#643  -  []  302.41 306.51 0 top
NOREF#644  -  []  492.57 132.12 90 top
NOREF#645  -  []  349.74 292.01 0 top
NOREF#646  -  []  420.35 250.98 90 top
NOREF#647  -  []  527.07 283.47 90 top
NOREF#648  -  []  336.07 421.68 90 top
NOREF#649  -  []  240.4 225.07 0 top
NOREF#650  -  []  367.14 189.45 90 top
NOREF#651  -  []  391.16 330.75 0 top
NOREF#652  -  []  513.06 402.82 0 top
NOREF#653  -  []  516.09 288.36 90 top
NOREF#654  -  []  311.11 304.05 0 top
NOREF#655  -  []  340.58 341.97 0 top
NOREF#656  -  []  230.62 320.7 0 top
NOREF#657  -  []  368.34 179.05 0 top
NOREF#658  -  []  306.46 336.37 90 top
NOREF#659  -  []  427.73 238.21 0 top
NOREF#660  -  []  515.27 420.39 0 top
NOREF#661  -  []  421.28 122.54 90 top
NOREF#662  -  []  306.37 237.89 0 top
NOREF#663  -  []  423.58 296.95 90 top
NOREF#664  -  []  372.85 242.61 0 top
NOREF#665  -  []  335.63 110.87 90 top
NOREF#666  -  []  524.2 301.6 0 top
NOREF#667  -  []  292.08 221.86 90 top
NOREF#668  -  []  432.71 255.43 0 top
NOREF#669  -  []  425.36 229.74 0 top
NOREF#670  -  []  388.2 296.49 0 top
NOREF#671  -  []  375.58 87.36 0 top
NOREF#672  -  []  383.58 289.6 90 top
NOREF#673  -  []  348.59 228.35 0 top
NOREF#674  -  []  311.16 270.75 0 top
NOREF#675  -  []  472.03 287.91 0 top
NOREF#676  -  []  312.12 293.7 0 top
NOREF#677  -  []  516.09 297 90 top
NOREF#678  -  []  390.94 226.5 90 top
NOREF#679  -  []  424.54 302.35 90 top
NOREF#680  -  []  451.53 321.49 90 top
NOREF#681  -  []  348.65 238.59 0 top
NOREF#682  -  []  300.57 336.81 0 top
NOREF#683  -  []  298.25 244.6 0 top
NOREF#684  -  []  345.01 229.28 0 top
NOREF#685  -  []  213.31 302 90 top
NOREF#686  -  []  311.81 255.75 0 top
NOREF#687  -  []  481.54 335.89 0 top
NOREF#688  -  []  345.33 213.2 90 top
NOREF#689  -  []  331.06 118.24 0 top
NOREF#690  -  []  517.55 409.02 90 top
NOREF#691  -  []  221.39 252.12 0 top
NOREF#692  -  []  228.97 243.46 0 top
NOREF#693  -  []  430.79 340.67 0 top
NOREF#694  -  []  399.08 238.86 90 top
NOREF#695  -  []  226.79 337.74 90 top
NOREF#696  -  []  342.11 247.04 0 top
NOREF#697  -  []  228.97 327.94 0 top
NOREF#698  -  []  302.36 137.08 90 top
NOREF#699  -  []  422.88 300.86 0 top
NOREF#700  -  []  536.7 269.53 0 top
NOREF#701  -  []  358.5 140.81 0 top
NOREF#702  -  []  223.59 210.57 0 top
NOREF#703  -  []  231.04 339.9 0 top
NOREF#704  -  []  430.79 338.08 0 top
NOREF#705  -  []  298.25 305.26 0 top
NOREF#706  -  []  533.35 255.91 90 top
NOREF#707  -  []  305.91 124.08 90 top
NOREF#708  -  []  360.19 212.2 90 top
NOREF#709  -  []  314.2 301.74 90 top
NOREF#710  -  []  452.22 168.91 90 top
NOREF#711  -  []  301.68 311.19 0 top
NOREF#712  -  []  429.74 292.01 0 top
NOREF#713  -  []  458.45 220.63 90 top
NOREF#714  -  []  458.45 323.5 90 top
NOREF#715  -  []  540.2 312.5 0 top
NOREF#716  -  []  389.74 227.14 0 top
NOREF#717  -  []  486.94 274.57 0 top
NOREF#718  -  []  316.56 270.75 90 top
NOREF#719  -  []  538.95 297 90 top
NOREF#720  -  []  434.92 306.97 0 top
NOREF#721  -  []  349.74 232.01 0 top
NOREF#722  -  []  390.3 236.62 90 top
NOREF#723  -  []  507.95 344.55 0 top
NOREF#724  -  []  348.84 292.33 0 top
NOREF#725  -  []  530.67 287.52 90 top
NOREF#726  -  []  471.8 326.75 90 top
NOREF#727  -  []  71.55 48.42 0 top
NOREF#728  -  []  252.62 286.41 90 top
NOREF#729  -  []  356.12 306.33 90 top
NOREF#730  -  []  388.65 298.59 0 top
NOREF#731  -  []  432.1 242.06 0 top
NOREF#732  -  []  268.11 281.58 0 top
NOREF#733  -  []  313.21 305.24 90 top
NOREF#734  -  []  434.2 240.89 90 top
NOREF#735  -  []  310.94 226.5 90 top
NOREF#736  -  []  520.85 244.1 90 top
NOREF#737  -  []  193.96 309.8 0 top
NOREF#738  -  []  437.46 126.65 90 top
NOREF#739  -  []  507.95 275.97 0 top
NOREF#740  -  []  419.15 302.83 0 top
NOREF#741  -  []  540.2 284.14 90 top
NOREF#742  -  []  496.52 344.55 0 top
NOREF#743  -  []  420.16 170.98 90 top
NOREF#744  -  []  368.08 287.86 90 top
NOREF#745  -  []  343.35 237.91 90 top
NOREF#746  -  []  345.68 289.22 90 top
NOREF#747  -  []  315.61 210.88 0 top
NOREF#748  -  []  431.11 247.77 0 top
NOREF#749  -  []  256.94 305.05 90 top
NOREF#750  -  []  517.55 403.62 90 top
NOREF#751  -  []  478.6 233.25 90 top
NOREF#752  -  []  418.25 303.15 0 top
NOREF#753  -  []  435.61 210.88 0 top
NOREF#754  -  []  312.71 315.43 0 top
NOREF#755  -  []  309.12 232.03 0 top
NOREF#756  -  []  388.12 251.87 0 top
NOREF#757  -  []  433.44 293.48 90 top
NOREF#758  -  []  447.6 293.81 0 top
NOREF#759  -  []  379.08 274.86 0 top
NOREF#760  -  []  397.97 209.36 90 top
NOREF#761  -  []  384.48 237.91 0 top
NOREF#762  -  []  249.65 303.45 90 top
NOREF#763  -  []  283.39 269.34 90 top
NOREF#764  -  []  407.08 226.86 90 top
NOREF#765  -  []  277.36 259.91 90 top
NOREF#766  -  []  238.22 260.76 90 top
NOREF#767  -  []  379.99 234.24 0 top
NOREF#768  -  []  510.82 125.18 0 top
NOREF#769  -  []  382.98 296.26 0 top
NOREF#770  -  []  315.61 213.47 0 top
NOREF#771  -  []  388.84 292.33 0 top
NOREF#772  -  []  538.95 235.68 90 top
NOREF#773  -  []  527.07 249.18 90 top
NOREF#774  -  []  473.66 285.96 0 top
NOREF#775  -  []  338.98 211 90 top
NOREF#776  -  []  402.08 321.86 0 top
NOREF#777  -  []  425.68 297.27 90 top
NOREF#778  -  []  184.83 160.37 0 top
NOREF#779  -  []  499.14 318.85 0 top
NOREF#780  -  []  375.93 270.82 0 top
NOREF#781  -  []  326.29 113.92 90 top
NOREF#782  -  []  230.62 303.45 0 top
NOREF#783  -  []  468.6 285.26 0 top
NOREF#784  -  []  293.88 303.99 90 top
NOREF#785  -  []  76.55 43.42 90 top
NOREF#786  -  []  383.58 194.29 0 top
NOREF#787  -  []  425.68 297.91 90 top
NOREF#788  -  []  346.42 124.08 90 top
NOREF#789  -  []  510.57 215.98 0 top
NOREF#790  -  []  415.93 330.81 0 top
NOREF#791  -  []  303.58 250.36 0 top
NOREF#792  -  []  362.08 231.86 90 top
NOREF#793  -  []  391.1 306.35 0 top
NOREF#794  -  []  316.21 252.13 90 top
NOREF#795  -  []  302.44 315.5 90 top
NOREF#796  -  []  510.57 240.28 0 top
NOREF#797  -  []  291.05 303.74 0 top
NOREF#798  -  []  393.2 308.94 90 top
NOREF#799  -  []  345.77 229.16 90 top
NOREF#800  -  []  388.12 288.85 0 top
NOREF#801  -  []  388.63 298.15 0 top
NOREF#802  -  []  302.75 240.26 90 top
NOREF#803  -  []  361.62 227.86 45 top
NOREF#804  -  []  315.02 301.03 0 top
NOREF#805  -  []  525.83 376.82 0 top
NOREF#806  -  []  524.7 287.17 0 top
NOREF#807  -  []  295.56 336.37 0 top
NOREF#808  -  []  283.19 275.44 0 top
NOREF#809  -  []  215.11 231.38 90 top
NOREF#810  -  []  432.9 339.4 0 top
NOREF#811  -  []  522 258.67 0 top
NOREF#812  -  []  291.81 115.29 90 top
NOREF#813  -  []  503.28 212.4 90 top
NOREF#814  -  []  392.81 336.38 90 top
NOREF#815  -  []  478.43 406.82 90 top
NOREF#816  -  []  247.22 210.57 0 top
NOREF#817  -  []  463.34 277.31 90 top
NOREF#818  -  []  516.09 219.78 90 top
NOREF#819  -  []  369.9 130.42 90 top
NOREF#820  -  []  356.41 129.76 0 top
NOREF#821  -  []  430.14 327.57 0 top
NOREF#822  -  []  302.11 247.04 0 top
NOREF#823  -  []  356.12 242.21 90 top
NOREF#824  -  []  193.96 212.86 90 top
NOREF#825  -  []  428.39 241.41 90 top
NOREF#826  -  []  217.54 267.76 0 top
NOREF#827  -  []  333.06 310.84 90 top
NOREF#828  -  []  232.82 260.76 0 top
NOREF#829  -  []  200.81 238.47 90 top
NOREF#830  -  []  222.92 148.72 0 top
NOREF#831  -  []  424.86 302.05 0 top
NOREF#832  -  []  429.44 233.61 90 top
NOREF#833  -  []  540.2 272.71 90 top
NOREF#834  -  []  382.54 190.65 90 top
NOREF#835  -  []  200.26 243.69 90 top
NOREF#836  -  []  351.23 266.4 0 top
NOREF#837  -  []  517.55 406.82 90 top
NOREF#838  -  []  268.11 288.59 0 top
NOREF#839  -  []  419.15 244.28 0 top
NOREF#840  -  []  385.13 289.66 0 top
NOREF#841  -  []  340.08 346.74 0 top
NOREF#842  -  []  447.6 232.24 0 top
NOREF#843  -  []  402.68 267.2 90 top
NOREF#844  -  []  463.34 281.71 90 top
NOREF#845  -  []  342.88 300.86 0 top
NOREF#846  -  []  383.58 236.95 90 top
NOREF#847  -  []  193.96 270.01 90 top
NOREF#848  -  []  507.95 268.71 0 top
NOREF#849  -  []  212.16 260.76 0 top
NOREF#850  -  []  405.28 135.04 0 top
NOREF#851  -  []  221.39 337.74 0 top
NOREF#852  -  []  478.6 322.1 90 top
NOREF#853  -  []  344.75 295.61 0 top
NOREF#854  -  []  308.43 237.66 90 top
NOREF#855  -  []  313.34 259.97 90 top
NOREF#856  -  []  308.12 251.87 0 top
NOREF#857  -  []  340.74 409.02 90 top
NOREF#858  -  []  435.22 306.65 0 top
NOREF#859  -  []  271.8 213.97 0 top
NOREF#860  -  []  422.11 307.04 0 top
NOREF#861  -  []  417.6 249.76 90 top
NOREF#862  -  []  432.1 238.98 0 top
NOREF#863  -  []  437.46 124.08 90 top
NOREF#864  -  []  349.5 401.56 90 top
NOREF#865  -  []  351.81 315.75 0 top
NOREF#866  -  []  393.51 217.31 0 top
NOREF#867  -  []  478.29 309.94 90 top
NOREF#868  -  []  475.85 126.65 90 top
NOREF#869  -  []  293.06 250.84 90 top
NOREF#870  -  []  351.67 213.21 90 top
NOREF#871  -  []  424.45 237.2 90 top
NOREF#872  -  []  343.88 236.58 0 top
NOREF#873  -  []  430.94 291.37 90 top
NOREF#874  -  []  522 233.02 0 top
NOREF#875  -  []  198.73 258.31 90 top
NOREF#876  -  []  370.08 323.86 0 top
NOREF#877  -  []  392.1 241.21 0 top
NOREF#878  -  []  385.1 237.2 90 top
NOREF#879  -  []  351.15 240.26 0 top
NOREF#880  -  []  384.86 302.05 0 top
NOREF#881  -  []  486.94 335.89 0 top
NOREF#882  -  []  431.11 245.56 0 top
NOREF#883  -  []  538.95 288.36 90 top
NOREF#884  -  []  414.38 294.16 90 top
NOREF#885  -  []  423.31 307.25 90 top
NOREF#886  -  []  47.62 404.06 0 top
NOREF#887  -  []  383.25 237.85 0 top
NOREF#888  -  []  333.88 303.99 90 top
NOREF#889  -  []  382.11 247.89 0 top
NOREF#890  -  []  371.05 243.75 0 top
NOREF#891  -  []  300.48 251.18 0 top
NOREF#892  -  []  244.25 295.05 0 top
NOREF#893  -  []  518.8 298.4 90 top
NOREF#894  -  []  301.08 251.06 0 top
NOREF#895  -  []  387.89 233.18 90 top
NOREF#896  -  []  432.01 245.88 0 top
NOREF#897  -  []  367.14 179.21 0 top
NOREF#898  -  []  198.73 338.32 90 top
NOREF#899  -  []  345.02 237.19 0 top
NOREF#900  -  []  287.9 330.68 90 top
NOREF#901  -  []  400.64 210.89 0 top
NOREF#902  -  []  470.43 316.92 0 top
NOREF#903  -  []  308.08 293.18 90 top
NOREF#904  -  []  433.21 243.73 90 top
NOREF#905  -  []  311.33 377.33 0 top
NOREF#906  -  []  200.81 313.08 90 top
NOREF#907  -  []  393.08 250.71 90 top
NOREF#908  -  []  254.27 216.43 90 top
NOREF#909  -  []  340.35 310.97 90 top
NOREF#910  -  []  540.2 255.35 0 top
NOREF#911  -  []  249.65 269.16 90 top
NOREF#912  -  []  311.5 307.42 0 top
NOREF#913  -  []  268.11 322.88 0 top
NOREF#914  -  []  189.36 232.26 0 top
NOREF#915  -  []  458.45 303.23 90 top
NOREF#916  -  []  300.35 303.64 90 top
NOREF#917  -  []  362.13 326.4 90 top
NOREF#918  -  []  356.12 304.96 90 top
NOREF#919  -  []  385.16 338.13 90 top
NOREF#920  -  []  426.87 297.85 0 top
NOREF#921  -  []  499.14 258.67 0 top
NOREF#922  -  []  354.07 286.36 0 top
NOREF#923  -  []  507.37 318.85 0 top
NOREF#924  -  []  435.22 305.28 0 top
NOREF#925  -  []  40.9 419.44 0 top
NOREF#926  -  []  300.35 243.64 90 top
NOREF#927  -  []  344.48 289.87 0 top
NOREF#928  -  []  293.84 123.34 90 top
NOREF#929  -  []  32.37 407.85 0 top
NOREF#930  -  []  414.71 309.44 90 top
NOREF#931  -  []  305.15 338.13 90 top
NOREF#932  -  []  343.53 330.81 90 top
NOREF#933  -  []  346.7 285.88 90 top
NOREF#934  -  []  428.63 298.15 0 top
NOREF#935  -  []  345.08 295.3 90 top
NOREF#936  -  []  304.69 268.37 0 top
NOREF#937  -  []  346.22 296.54 90 top
NOREF#938  -  []  369.07 337.05 90 top
NOREF#939  -  []  387.08 246.86 0 top
NOREF#940  -  []  382.11 307.04 0 top
NOREF#941  -  []  390.14 327.57 0 top
NOREF#942  -  []  497.33 212.07 90 top
NOREF#943  -  []  429.83 258.32 90 top
NOREF#944  -  []  347.89 293.18 90 top
NOREF#945  -  []  336.06 179.81 0 top
NOREF#946  -  []  340.01 168.64 90 top
NOREF#947  -  []  368.71 208.35 90 top
NOREF#948  -  []  382.95 122.62 90 top
NOREF#949  -  []  283.38 334.94 90 top
NOREF#950  -  []  207.76 226.47 0 top
NOREF#951  -  []  463.85 265.13 0 top
NOREF#952  -  []  351.9 163.97 0 top
NOREF#953  -  []  388.47 218.61 0 top
NOREF#954  -  []  222.76 402.82 0 top
NOREF#955  -  []  384.48 298.55 0 top
NOREF#956  -  []  246.33 401.56 0 top
NOREF#957  -  []  421.19 233.6 90 top
NOREF#958  -  []  348.2 236.49 0 top
NOREF#959  -  []  313.2 246.03 90 top
NOREF#960  -  []  378.25 251.94 0 top
NOREF#961  -  []  501.34 233.02 0 top
NOREF#962  -  []  454.45 321.87 90 top
NOREF#963  -  []  348.96 330.75 0 top
NOREF#964  -  []  389.4 235.85 90 top
NOREF#965  -  []  69.58 506.86 0 top
NOREF#966  -  []  286.89 336.37 0 top
NOREF#967  -  []  303.26 228.02 0 top
NOREF#968  -  []  228.97 233.47 0 top
NOREF#969  -  []  384.76 229.66 0 top
NOREF#970  -  []  349.32 311.23 90 top
NOREF#971  -  []  393.21 307.45 90 top
NOREF#972  -  []  323.81 309.44 0 top
NOREF#973  -  []  305.68 289.22 90 top
NOREF#974  -  []  495.94 324.05 90 top
NOREF#975  -  []  423.28 226.82 0 top
NOREF#976  -  []  460.78 123.86 0 top
NOREF#977  -  []  399.84 165.45 0 top
NOREF#978  -  []  390.58 303.36 90 top
NOREF#979  -  []  382.54 178.01 0 top
NOREF#980  -  []  402.68 267.2 0 top
NOREF#981  -  []  272.08 365.86 0 top
NOREF#982  -  []  383.58 174.37 90 top
NOREF#983  -  []  387.31 269.35 0 top
NOREF#984  -  []  349.74 227.14 0 top
NOREF#985  -  []  261.25 334.69 90 top
NOREF#986  -  []  300.35 241.51 90 top
NOREF#987  -  []  321.62 287.86 45 top
NOREF#988  -  []  303.9 297.84 0 top
NOREF#989  -  []  505.16 215.57 0 top
NOREF#990  -  []  391.18 310.97 90 top
NOREF#991  -  []  426.87 241.41 90 top
NOREF#992  -  []  69.58 506.86 0 top
NOREF#993  -  []  306.37 297.89 0 top
NOREF#994  -  []  245.71 249.06 90 top
NOREF#995  -  []  282.08 291.86 90 top
NOREF#996  -  []  217.54 285.01 0 top
NOREF#997  -  []  212.11 231.91 0 top
NOREF#998  -  []  524.7 252.88 0 top
NOREF#999  -  []  302.41 246.51 0 top
NOREF#1000  -  []  296.08 317.86 0 top
NOREF#1001  -  []  533.35 303.82 90 top
NOREF#1002  -  []  212.16 313.44 0 top
NOREF#1003  -  []  412.11 338.27 90 top
NOREF#1004  -  []  344.46 227.38 90 top
NOREF#1005  -  []  388.43 237.66 90 top
NOREF#1006  -  []  533.35 221.62 90 top
NOREF#1007  -  []  535.43 272.55 90 top
NOREF#1008  -  []  336.07 419.12 90 top
NOREF#1009  -  []  448.61 170.6 90 top
NOREF#1010  -  []  520.85 278.39 90 top
NOREF#1011  -  []  507.37 315.65 90 top
NOREF#1012  -  []  305.08 248.86 0 top
NOREF#1013  -  []  378.25 241.78 0 top
NOREF#1014  -  []  496.09 140.17 90 top
NOREF#1015  -  []  282.08 321.86 0 top
NOREF#1016  -  []  304.48 249.01 0 top
NOREF#1017  -  []  308.84 292.33 0 top
NOREF#1018  -  []  379.12 250.02 90 top
NOREF#1019  -  []  330.08 323.86 0 top
NOREF#1020  -  []  339.99 294.24 0 top
NOREF#1021  -  []  396.12 302.21 90 top
NOREF#1022  -  []  206.11 259.36 0 top
NOREF#1023  -  []  294.71 249.44 90 top
NOREF#1024  -  []  383.9 230.5 0 top
NOREF#1025  -  []  189.36 243.69 0 top
NOREF#1026  -  []  287.9 339.93 90 top
NOREF#1027  -  []  423.53 270.82 90 top
NOREF#1028  -  []  349.1 237.26 0 top
NOREF#1029  -  []  299.23 129.19 0 top
NOREF#1030  -  []  327.56 209.62 0 top
NOREF#1031  -  []  352.66 117.24 0 top
NOREF#1032  -  []  388.84 227.46 0 top
NOREF#1033  -  []  359.08 238.86 90 top
NOREF#1034  -  []  338.25 241.78 0 top
NOREF#1035  -  []  471.27 125.35 0 top
NOREF#1036  -  []  431.67 215.41 90 top
NOREF#1037  -  []  282.26 336.37 0 top
NOREF#1038  -  []  535.43 278.6 0 top
NOREF#1039  -  []  219.19 313.44 0 top
NOREF#1040  -  []  510.57 292.96 0 top
NOREF#1041  -  []  200.81 278.79 0 top
NOREF#1042  -  []  228.44 312.04 90 top
NOREF#1043  -  []  345.1 229.85 90 top
NOREF#1044  -  []  328.95 116.46 0 top
NOREF#1045  -  []  351.11 247.77 0 top
NOREF#1046  -  []  539.65 277.12 90 top
NOREF#1047  -  []  386.37 297.89 0 top
NOREF#1048  -  []  391.67 213.21 90 top
NOREF#1049  -  []  463.85 326.7 0 top
NOREF#1050  -  []  518.8 335.89 0 top
NOREF#1051  -  []  308.08 293.38 90 top
NOREF#1052  -  []  408.08 227.86 90 top
NOREF#1053  -  []  351.9 179.21 0 top
NOREF#1054  -  []  297.92 310.66 0 top
NOREF#1055  -  []  472.54 247.07 0 top
NOREF#1056  -  []  362.13 266.4 90 top
NOREF#1057  -  []  360.19 209.61 90 top
NOREF#1058  -  []  378.48 340.67 0 top
NOREF#1059  -  []  516.09 228.42 90 top
NOREF#1060  -  []  309.1 297.26 0 top
NOREF#1061  -  []  318.21 269.35 90 top
NOREF#1062  -  []  341.19 293.6 90 top
NOREF#1063  -  []  389.08 304.86 90 top
NOREF#1064  -  []  301.19 293.6 90 top
NOREF#1065  -  []  385.63 119.8 0 top
NOREF#1066  -  []  387.66 233.75 0 top
NOREF#1067  -  []  540.2 221.06 0 top
NOREF#1068  -  []  346.42 126.65 90 top
NOREF#1069  -  []  534.36 415.7 90 top
NOREF#1070  -  []  341.85 127.92 0 top
NOREF#1071  -  []  382.12 315.2 0 top
NOREF#1072  -  []  341.68 251.19 0 top
NOREF#1073  -  []  306.33 251.86 0 top
NOREF#1074  -  []  240.4 336.34 0 top
NOREF#1075  -  []  268.11 315.87 0 top
NOREF#1076  -  []  431.5 307.42 0 top
NOREF#1077  -  []  507.95 294.36 0 top
NOREF#1078  -  []  289.86 250.84 0 top
NOREF#1079  -  []  200.26 209.4 90 top
NOREF#1080  -  []  236.5 421.68 90 top
NOREF#1081  -  []  302.11 247.89 0 top
NOREF#1082  -  []  308.39 241.41 90 top
NOREF#1083  -  []  343.58 287.38 0 top
NOREF#1084  -  []  174.46 249.9 0 top
NOREF#1085  -  []  298.25 303.15 0 top
NOREF#1086  -  []  198.73 298.65 0 top
NOREF#1087  -  []  297.6 309.76 90 top
NOREF#1088  -  []  428.96 341.6 90 top
NOREF#1089  -  []  273.74 135.04 0 top
NOREF#1090  -  []  524.7 218.59 0 top
NOREF#1091  -  []  270.31 213 0 top
NOREF#1092  -  []  290.08 289.86 90 top
NOREF#1093  -  []  432.9 336.81 0 top
NOREF#1094  -  []  351.9 189.45 90 top
NOREF#1095  -  []  530.67 218.94 90 top
NOREF#1096  -  []  389.4 295.85 90 top
NOREF#1097  -  []  420.35 302.19 90 top
NOREF#1098  -  []  535.43 283.98 90 top
NOREF#1099  -  []  302.44 255.5 90 top
NOREF#1100  -  []  69.58 506.86 0 top
NOREF#1101  -  []  344.48 286.18 90 top
NOREF#1102  -  []  548.69 0 90 top
NOREF#1103  -  []  239.87 216.43 90 top
NOREF#1104  -  []  356.26 109.32 90 top
NOREF#1105  -  []  496.52 337.29 0 top
NOREF#1106  -  []  520.85 283.47 90 top
NOREF#1107  -  []  427.08 246.86 90 top
NOREF#1108  -  []  198.73 218.64 0 top
NOREF#1109  -  []  189.36 220.83 0 top
NOREF#1110  -  []  475.85 124.08 90 top
NOREF#1111  -  []  385.01 229.28 0 top
NOREF#1112  -  []  226.79 244.86 90 top
NOREF#1113  -  []  344.76 229.66 0 top
NOREF#1114  -  []  275.71 295.6 90 top
NOREF#1115  -  []  484.51 255.47 90 top
NOREF#1116  -  []  336.82 190.65 90 top
NOREF#1117  -  []  421.19 293.6 90 top
NOREF#1118  -  []  352.06 162.12 90 top
NOREF#1119  -  []  305.77 289.36 90 top
NOREF#1120  -  []  299.58 241.86 0 top
NOREF#1121  -  []  235.02 329.34 0 top
NOREF#1122  -  []  427.19 302.05 0 top
NOREF#1123  -  []  76.55 43.42 90 top
NOREF#1124  -  []  426.85 295.29 90 top
NOREF#1125  -  []  282.86 179.91 0 top
NOREF#1126  -  []  507.37 308.86 0 top
NOREF#1127  -  []  332.85 242.61 0 top
NOREF#1128  -  []  456.68 145.48 0 top
NOREF#1129  -  []  463.85 333.71 0 top
NOREF#1130  -  []  315.29 108.63 90 top
NOREF#1131  -  []  306.85 237.41 0 top
NOREF#1132  -  []  388.59 228.35 0 top
NOREF#1133  -  []  353.51 212.15 0 top
NOREF#1134  -  []  382.15 298.55 0 top
NOREF#1135  -  []  388.96 330.75 0 top
NOREF#1136  -  []  319.08 238.86 90 top
NOREF#1137  -  []  266.46 321.48 0 top
NOREF#1138  -  []  307.34 296.08 0 top
NOREF#1139  -  []  327.26 145.48 0 top
NOREF#1140  -  []  239.87 293.65 90 top
NOREF#1141  -  []  295.93 270.82 0 top
NOREF#1142  -  []  76.55 43.42 90 top
NOREF#1143  -  []  211.51 231.38 0 top
NOREF#1144  -  []  262.89 236.8 90 top
NOREF#1145  -  []  273.65 270.45 90 top
NOREF#1146  -  []  385.35 297.58 0 top
NOREF#1147  -  []  390.94 286.5 90 top
NOREF#1148  -  []  385.4 311.86 0 top
NOREF#1149  -  []  367.3 190.65 90 top
NOREF#1150  -  []  239.87 209.17 90 top
NOREF#1151  -  []  381.78 164.57 0 top
NOREF#1152  -  []  306.06 301.41 90 top
NOREF#1153  -  []  423.9 230.5 0 top
NOREF#1154  -  []  248.13 424.44 90 top
NOREF#1155  -  []  189.36 300.84 0 top
NOREF#1156  -  []  533.35 328.89 90 top
NOREF#1157  -  []  193.96 298.37 0 top
NOREF#1158  -  []  205.28 334.25 0 top
NOREF#1159  -  []  383.31 247.25 90 top
NOREF#1160  -  []  313.51 212.15 0 top
NOREF#1161  -  []  343.58 289.6 90 top
NOREF#1162  -  []  414.28 269.42 0 top
NOREF#1163  -  []  527.07 312.68 90 top
NOREF#1164  -  []  477.22 248.67 90 top
NOREF#1165  -  []  425.35 237.58 0 top
NOREF#1166  -  []  306.87 297.85 0 top
NOREF#1167  -  []  299.67 233.34 90 top
NOREF#1168  -  []  353.36 270.75 0 top
NOREF#1169  -  []  244.25 269.16 0 top
NOREF#1170  -  []  200.26 289.41 90 top
NOREF#1171  -  []  217.54 319.3 0 top
NOREF#1172  -  []  307.53 311.22 90 top
NOREF#1173  -  []  399.64 318.32 90 top
NOREF#1174  -  []  388.49 237.58 90 top
NOREF#1175  -  []  339.08 218.86 90 top
NOREF#1176  -  []  433.94 220.98 0 top
NOREF#1177  -  []  302.41 308.21 0 top
NOREF#1178  -  []  496.52 268.71 0 top
NOREF#1179  -  []  380.58 341.97 0 top
NOREF#1180  -  []  519.84 421.68 90 top
NOREF#1181  -  []  305.15 338.13 90 top
NOREF#1182  -  []  226.79 260.76 90 top
NOREF#1183  -  []  536.7 223.81 0 top
NOREF#1184  -  []  417.09 124.98 90 top
NOREF#1185  -  []  258.32 340.94 0 top
NOREF#1186  -  []  349.08 308.46 90 top
NOREF#1187  -  []  433.21 307.45 90 top
NOREF#1188  -  []  350.6 247.1 0 top
NOREF#1189  -  []  306.87 237.85 0 top
NOREF#1190  -  []  426.85 297.41 0 top
NOREF#1191  -  []  507.37 258.67 0 top
NOREF#1192  -  []  74.58 41.86 90 top
NOREF#1193  -  []  207.76 244.86 0 top
NOREF#1194  -  []  540.2 295.57 90 top
NOREF#1195  -  []  368.12 218.6 0 top
NOREF#1196  -  []  393.21 303.73 90 top
NOREF#1197  -  []  236.5 416.55 90 top
NOREF#1198  -  []  327.66 250.84 0 top
NOREF#1199  -  []  474.04 424.22 0 top
NOREF#1200  -  []  426.16 239.87 0 top
NOREF#1201  -  []  200.81 281.98 90 top
NOREF#1202  -  []  392 306.67 0 top
NOREF#1203  -  []  342.88 240.86 0 top
NOREF#1204  -  []  535.43 329.7 90 top
NOREF#1205  -  []  518.8 274.57 0 top
NOREF#1206  -  []  310.14 267.57 0 top
NOREF#1207  -  []  344.48 226.18 90 top
NOREF#1208  -  []  495.94 301.6 0 top
NOREF#1209  -  []  432.88 125.35 0 top
NOREF#1210  -  []  208.28 334.78 90 top
NOREF#1211  -  []  430.71 144.68 0 top
NOREF#1212  -  []  74.58 41.86 90 top
NOREF#1213  -  []  353 242.38 0 top
NOREF#1214  -  []  249.42 320.7 0 top
NOREF#1215  -  []  435.61 210.88 0 top
NOREF#1216  -  []  212.16 226.47 0 top
NOREF#1217  -  []  389.74 292.01 0 top
NOREF#1218  -  []  485.09 328.65 0 top
NOREF#1219  -  []  315.22 302.53 0 top
NOREF#1220  -  []  272.51 329.89 0 top
NOREF#1221  -  []  355.05 194.29 0 top
NOREF#1222  -  []  246.45 337.74 0 top
NOREF#1223  -  []  336.06 164.57 0 top
NOREF#1224  -  []  307.66 293.29 0 top
NOREF#1225  -  []  368.12 284.96 0 top
NOREF#1226  -  []  348.43 297.66 90 top
NOREF#1227  -  []  294.71 309.44 90 top
NOREF#1228  -  []  368.08 264.86 0 top
NOREF#1229  -  []  300.35 304.3 90 top
NOREF#1230  -  []  247.8 127.81 0 top
NOREF#1231  -  []  302.88 240.86 90 top
NOREF#1232  -  []  352.01 304.37 0 top
NOREF#1233  -  []  313 238.87 90 top
NOREF#1234  -  []  481.54 274.57 0 top
NOREF#1235  -  []  302.88 240.86 0 top
NOREF#1236  -  []  382.41 248.21 0 top
NOREF#1237  -  []  347.73 298.21 0 top
NOREF#1238  -  []  353 301.53 0 top
NOREF#1239  -  []  246.45 226.47 0 top
NOREF#1240  -  []  354.92 246.97 0 top
NOREF#1241  -  []  333.78 406.82 90 top
NOREF#1242  -  []  310.65 301.98 90 top
NOREF#1243  -  []  431.48 292.15 0 top
NOREF#1244  -  []  343.58 228.32 0 top
NOREF#1245  -  []  71.55 109.92 0 top
NOREF#1246  -  []  390.32 291.39 90 top
NOREF#1247  -  []  338.25 244.6 0 top
NOREF#1248  -  []  287.53 121.65 0 top
NOREF#1249  -  []  393.21 243.73 90 top
NOREF#1250  -  []  200.81 313.08 0 top
NOREF#1251  -  []  69.58 506.86 0 top
NOREF#1252  -  []  504.66 219.78 90 top
NOREF#1253  -  []  442.14 211.22 0 top
NOREF#1254  -  []  200.26 266.55 90 top
NOREF#1255  -  []  499.14 343.15 0 top
NOREF#1256  -  []  388.49 297.58 90 top
NOREF#1257  -  []  350.97 233.86 90 top
NOREF#1258  -  []  200.81 316.27 90 top
NOREF#1259  -  []  429.92 287.85 90 top
NOREF#1260  -  []  390.86 251.87 0 top
NOREF#1261  -  []  345.08 295.94 90 top
NOREF#1262  -  []  345.15 335.54 90 top
NOREF#1263  -  []  344.54 242.35 90 top
NOREF#1264  -  []  422.98 296.26 0 top
NOREF#1265  -  []  309.85 297.94 90 top
NOREF#1266  -  []  352.19 111.35 0 top
NOREF#1267  -  []  252.62 252.12 90 top
NOREF#1268  -  []  349.83 258.32 90 top
NOREF#1269  -  []  279.08 298.86 90 top
NOREF#1270  -  []  517 402.82 90 top
NOREF#1271  -  []  388.09 293.43 90 top
NOREF#1272  -  []  428.07 297.2 90 top
NOREF#1273  -  []  232.82 252.12 0 top
NOREF#1274  -  []  387.28 251.87 0 top
NOREF#1275  -  []  363.58 87.36 0 top
NOREF#1276  -  []  428.49 237.58 90 top
NOREF#1277  -  []  355.61 210.88 0 top
NOREF#1278  -  []  430.79 340.67 0 top
NOREF#1279  -  []  324.75 305.55 0 top
NOREF#1280  -  []  393.2 246.03 90 top
NOREF#1281  -  []  424.48 249.03 0 top
NOREF#1282  -  []  393.21 247.45 90 top
NOREF#1283  -  []  463.85 237.85 0 top
NOREF#1284  -  []  200.81 221.64 0 top
NOREF#1285  -  []  338.25 305.26 0 top
NOREF#1286  -  []  74.58 41.86 90 top
NOREF#1287  -  []  384.48 288 90 top
NOREF#1288  -  []  307.44 233.68 0 top
NOREF#1289  -  []  428.84 287.46 0 top
NOREF#1290  -  []  426.87 237.85 0 top
NOREF#1291  -  []  310.94 231.37 90 top
NOREF#1292  -  []  301.7 135.43 90 top
NOREF#1293  -  []  392.25 234.12 0 top
NOREF#1294  -  []  507.06 438.26 0 top
NOREF#1295  -  []  533.35 292.39 90 top
NOREF#1296  -  []  399.59 248.7 90 top
NOREF#1297  -  []  423.58 250.36 0 top
NOREF#1298  -  []  352.71 255.43 0 top
NOREF#1299  -  []  358.47 331.9 90 top
NOREF#1300  -  []  528.87 298.94 0 top
NOREF#1301  -  []  311.67 215.41 90 top
NOREF#1302  -  []  379.15 302.15 0 top
NOREF#1303  -  []  384.13 109.32 90 top
NOREF#1304  -  []  428.43 237.66 90 top
NOREF#1305  -  []  299.99 294.24 0 top
NOREF#1306  -  []  339.15 242.15 0 top
NOREF#1307  -  []  212.11 334.78 0 top
NOREF#1308  -  []  345.68 229.23 90 top
NOREF#1309  -  []  460.14 216.33 0 top
NOREF#1310  -  []  391.48 292.15 0 top
NOREF#1311  -  []  234.21 406.82 90 top
NOREF#1312  -  []  431.11 307.77 0 top
NOREF#1313  -  []  353.21 303.73 90 top
NOREF#1314  -  []  383.98 118.96 0 top
NOREF#1315  -  []  507.37 212.78 90 top
NOREF#1316  -  []  299.15 304.28 0 top
NOREF#1317  -  []  71.55 109.92 0 top
NOREF#1318  -  []  481.54 298.4 90 top
NOREF#1319  -  []  432.12 233.7 0 top
NOREF#1320  -  []  388.44 250.97 90 top
NOREF#1321  -  []  163.41 413.04 90 top
NOREF#1322  -  []  528.87 264.65 0 top
NOREF#1323  -  []  336.68 219.4 0 top
NOREF#1324  -  []  71.55 446.92 0 top
NOREF#1325  -  []  477.11 280.09 90 top
NOREF#1326  -  []  518.8 289.76 90 top
NOREF#1327  -  []  308.96 330.75 0 top
NOREF#1328  -  []  348.63 238.15 0 top
NOREF#1329  -  []  422.7 169.71 90 top
NOREF#1330  -  []  423.02 219.41 0 top
NOREF#1331  -  []  504.66 322.65 90 top
NOREF#1332  -  []  303.58 236.95 90 top
NOREF#1333  -  []  429.77 294.51 0 top
NOREF#1334  -  []  272.51 281.58 0 top
NOREF#1335  -  []  423.53 262.17 90 top
NOREF#1336  -  []  536.7 246.67 0 top
NOREF#1337  -  []  301.34 130.48 0 top
NOREF#1338  -  []  518.8 327.25 0 top
NOREF#1339  -  []  332.72 375.64 0 top
NOREF#1340  -  []  424.48 298.55 0 top
NOREF#1341  -  []  348.47 218.61 0 top
NOREF#1342  -  []  484.51 221.18 90 top
NOREF#1343  -  []  298.25 243.15 0 top
NOREF#1344  -  []  235.02 313.44 0 top
NOREF#1345  -  []  292.85 242.61 0 top
NOREF#1346  -  []  284.98 339.55 90 top
NOREF#1347  -  []  381.78 158.37 90 top
NOREF#1348  -  []  69.58 46.86 0 top
NOREF#1349  -  []  485.39 406.82 90 top
NOREF#1350  -  []  228.97 293.65 0 top
NOREF#1351  -  []  380.35 242.19 90 top
NOREF#1352  -  []  353 302.38 0 top
NOREF#1353  -  []  226.79 313.44 90 top
NOREF#1354  -  []  374.38 294.16 90 top
NOREF#1355  -  []  425.08 235.3 90 top
NOREF#1356  -  []  247.22 286.41 0 top
NOREF#1357  -  []  208.28 231.91 90 top
NOREF#1358  -  []  422.9 332.18 90 top
NOREF#1359  -  []  359.82 338.45 0 top
NOREF#1360  -  []  422.41 246.51 0 top
NOREF#1361  -  []  367.14 194.45 0 top
NOREF#1362  -  []  334.88 268.37 0 top
NOREF#1363  -  []  200.81 249.9 90 top
NOREF#1364  -  []  193.96 218.36 0 top
NOREF#1365  -  []  382.38 174.21 90 top
NOREF#1366  -  []  261.25 231.82 90 top
NOREF#1367  -  []  283.01 208.07 90 top
NOREF#1368  -  []  351.3 158.37 90 top
NOREF#1369  -  []  524.7 241.45 0 top
NOREF#1370  -  []  422.41 308.21 0 top
NOREF#1371  -  []  538.95 254.07 90 top
NOREF#1372  -  []  346.37 297.89 0 top
NOREF#1373  -  []  200.81 301.65 90 top
NOREF#1374  -  []  471.8 258.17 90 top
NOREF#1375  -  []  247.22 217.83 0 top
NOREF#1376  -  []  447.86 132.6 0 top
NOREF#1377  -  []  385.08 235.3 90 top
NOREF#1378  -  []  395.22 245.28 0 top
NOREF#1379  -  []  478.6 226.24 90 top
NOREF#1380  -  []  312.7 246.78 90 top
NOREF#1381  -  []  346.87 302.35 90 top
NOREF#1382  -  []  350.94 226.5 90 top
NOREF#1383  -  []  418.13 330.81 0 top
NOREF#1384  -  []  425.78 229.41 90 top
NOREF#1385  -  []  484.74 335.89 0 top
NOREF#1386  -  []  422.13 218.6 0 top
NOREF#1387  -  []  300.82 116.64 0 top
NOREF#1388  -  []  400.19 209.61 90 top
NOREF#1389  -  []  339.15 251.62 0 top
NOREF#1390  -  []  238.22 320.7 90 top
NOREF#1391  -  []  431.16 330.75 0 top
NOREF#1392  -  []  507.37 305.66 90 top
NOREF#1393  -  []  238.22 226.47 90 top
NOREF#1394  -  []  331.5 420.39 0 top
NOREF#1395  -  []  387.08 306.86 0 top
NOREF#1396  -  []  315.02 241.03 0 top
NOREF#1397  -  []  305.68 237.91 90 top
NOREF#1398  -  []  428.84 232.33 0 top
NOREF#1399  -  []  385.68 297.91 90 top
NOREF#1400  -  []  353.2 306.03 90 top
NOREF#1401  -  []  385.78 289.14 90 top
NOREF#1402  -  []  390.86 311.87 0 top
NOREF#1403  -  []  312.08 239.36 90 top
NOREF#1404  -  []  69.58 46.86 0 top
NOREF#1405  -  []  454.69 320 0 top
NOREF#1406  -  []  313 302.38 0 top
NOREF#1407  -  []  249.65 295.05 90 top
NOREF#1408  -  []  359.64 258.32 90 top
NOREF#1409  -  []  533.35 212.38 90 top
NOREF#1410  -  []  422.11 306.19 0 top
NOREF#1411  -  []  533.35 226.02 90 top
NOREF#1412  -  []  308.84 294.21 0 top
NOREF#1413  -  []  463.85 258.12 0 top
NOREF#1414  -  []  495.94 229.82 90 top
NOREF#1415  -  []  0 453.95 0 top
NOREF#1416  -  []  324.92 218.6 0 top
NOREF#1417  -  []  343.35 297.91 90 top
NOREF#1418  -  []  214.51 334.78 90 top
NOREF#1419  -  []  379.15 311.62 0 top
NOREF#1420  -  []  475.85 129.21 90 top
NOREF#1421  -  []  363.25 209.62 0 top
NOREF#1422  -  []  462.33 330.35 90 top
NOREF#1423  -  []  313 301.53 0 top
NOREF#1424  -  []  448.59 209.62 0 top
NOREF#1425  -  []  504.66 254.07 90 top
NOREF#1426  -  []  300.35 240.82 90 top
NOREF#1427  -  []  349.68 304.71 90 top
NOREF#1428  -  []  55 408.31 90 top
NOREF#1429  -  []  300.57 341.97 0 top
NOREF#1430  -  []  243.37 319.3 0 top
NOREF#1431  -  []  515.27 422.95 0 top
NOREF#1432  -  []  479.98 386.29 90 top
NOREF#1433  -  []  279.08 238.86 90 top
NOREF#1434  -  []  332.56 125.38 90 top
NOREF#1435  -  []  343.58 228.32 90 top
NOREF#1436  -  []  311.1 306.35 0 top
NOREF#1437  -  []  305.02 237.19 0 top
NOREF#1438  -  []  298.25 241.78 0 top
NOREF#1439  -  []  69.58 506.86 0 top
NOREF#1440  -  []  425.18 269.42 90 top
NOREF#1441  -  []  426.87 242.35 90 top
NOREF#1442  -  []  356.12 246.33 90 top
NOREF#1443  -  []  281.41 209.42 90 top
NOREF#1444  -  []  344.48 298.55 0 top
NOREF#1445  -  []  507.37 301.6 0 top
NOREF#1446  -  []  451.53 336.45 90 top
NOREF#1447  -  []  310.6 247.1 0 top
NOREF#1448  -  []  339.15 304.94 0 top
NOREF#1449  -  []  346.85 297.41 0 top
NOREF#1450  -  []  335.63 113.92 90 top
NOREF#1451  -  []  374.04 113.39 0 top
NOREF#1452  -  []  340.19 402.82 90 top
NOREF#1453  -  []  442.02 338.45 0 top
NOREF#1454  -  []  423.31 246.4 90 top
NOREF#1455  -  []  334.38 294.16 90 top
NOREF#1456  -  []  284.98 329.41 90 top
NOREF#1457  -  []  262.89 305.38 90 top
NOREF#1458  -  []  463.18 123.86 90 top
NOREF#1459  -  []  299.58 241.86 0 top
NOREF#1460  -  []  530.67 321.81 90 top
NOREF#1461  -  []  429.4 235.85 90 top
NOREF#1462  -  []  404.92 221.76 90 top
NOREF#1463  -  []  386.65 250.96 90 top
NOREF#1464  -  []  431.48 232.15 0 top
NOREF#1465  -  []  447.42 338.45 90 top
NOREF#1466  -  []  422.15 298.55 0 top
NOREF#1467  -  []  266.46 218.61 0 top
NOREF#1468  -  []  501.69 228.42 90 top
NOREF#1469  -  []  528.27 253.23 0 top
NOREF#1470  -  []  343.02 219.41 0 top
NOREF#1471  -  []  298.25 245.26 0 top
NOREF#1472  -  []  71.55 48.42 0 top
NOREF#1473  -  []  373.88 303.99 90 top
NOREF#1474  -  []  391.5 247.42 0 top
NOREF#1475  -  []  400.19 212.2 90 top
NOREF#1476  -  []  340.35 302.19 90 top
NOREF#1477  -  []  424.76 289.66 0 top
NOREF#1478  -  []  329.39 421.66 0 top
NOREF#1479  -  []  486.94 308.86 0 top
NOREF#1480  -  []  264.76 239.97 0 top
NOREF#1481  -  []  271.04 210.44 0 top
NOREF#1482  -  []  50.38 419.69 0 top
NOREF#1483  -  []  200.81 224.83 90 top
NOREF#1484  -  []  226.79 226.47 90 top
NOREF#1485  -  []  382.54 162.77 0 top
NOREF#1486  -  []  356.11 129.44 0 top
NOREF#1487  -  []  305.68 297.91 90 top
NOREF#1488  -  []  424.46 287.38 90 top
NOREF#1489  -  []  259.73 230.88 90 top
NOREF#1490  -  []  349.44 232.33 90 top
NOREF#1491  -  []  393.91 314.79 90 top
NOREF#1492  -  []  41.18 382.48 0 top
NOREF#1493  -  []  591.83 113.32 90 top
NOREF#1494  -  []  311.15 240.26 0 top
NOREF#1495  -  []  436.12 306.33 90 top
NOREF#1496  -  []  351.3 164.57 0 top
NOREF#1497  -  []  378.25 242.47 0 top
NOREF#1498  -  []  385.67 242.05 0 top
NOREF#1499  -  []  495.94 298.4 90 top
NOREF#1500  -  []  353.1 159.13 90 top
