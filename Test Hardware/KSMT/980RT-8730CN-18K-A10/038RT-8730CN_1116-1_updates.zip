# Allegro board 038RT-8730CN_1116-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
3SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  429.44 224.03 180 top
3SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  423.58 223.07 180 top
3ST3  SHORT  [DEFAULT_SHORT_SMALL]  419.48 254.46 180 top
3ST4  SHORT  [DEFAULT_SHORT_SMALL]  440.13 218.08 180 top
3ST5  SHORT  [DEFAULT_SHORT_SMALL]  440.13 217.32 180 top
3ST8  SHORT  [DEFAULT_SHORT_SMALL]  455.88 205.33 90 bottom
3ST11  SHORT  [DEFAULT_SHORT_SMALL]  437.94 265.61 180 top
3ST12  SHORT  [DEFAULT_SHORT_SMALL]  426.82 261.25 180 bottom
3ST13  SHORT  [DEFAULT_SHORT_SMALL]  402.74 240.69 270 bottom
3ST14  SHORT  [DEFAULT_SHORT_SMALL]  416.63 277.12 0 bottom
3ST15  SHORT  [DEFAULT_SHORT_SMALL]  441.74 244.4 270 bottom
3ST16  SHORT  [DEFAULT_SHORT_SMALL]  419.45 253.37 180 top
3ST17  SHORT  [DEFAULT_SHORT_SMALL]  426.82 260.54 180 bottom
3ST18  SHORT  [DEFAULT_SHORT_SMALL]  456.82 205.26 90 bottom
3ST19  SHORT  [DEFAULT_SHORT_SMALL]  437.84 264.8 180 top
3SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  439.72 174.41 0 top
3SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  451.67 128.79 0 top
3U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  427.66 233.75 270 top
3U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  425.36 229.74 270 top
3U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  473.7 229.18 0 bottom
3Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  413 243.89 45 top
4BD1  BD120-1.5A-S4-MU  [FB0402]  299.97 317.1 270 bottom
4BD2  BD120-1.5A-S4-MU  [FB0402]  315.74 314.24 180 bottom
4BD3  BD120-1.5A-S4-MU  [FB0402]  298.93 317.1 270 bottom
4BD5  BD120-1.5A-S4-MU  [FB0402]  296.11 307.53 0 bottom
4BD7  BD120-1.5A-S4-MU  [FB0402]  301.01 317.1 270 bottom
4BD9  BD120-1.5A-S4-MU  [FB0402]  319.98 304.31 180 bottom
4BD11  BD120-1.5A-S4-MU  [FB0402]  315.74 313.2 180 bottom
4BD12  BD120-1.5A-S4-MU  [FB0402]  307.85 317.1 270 bottom
4BD13  BD120-1.5A-S4-MU  [FB0402]  296.14 300.68 0 bottom
4BD15  BD120-1.5A-S4-MU  [FB0402]  299.26 296.89 0 bottom
4BD16  BD120-1.5A-S4-MU  [FB0402]  302.57 303.52 180 bottom
4BD17  BD120-1.5A-S4-MU  [FB0402]  302.57 302.48 180 bottom
4BD18  BD120-1.5A-S4-MU  [FB0402]  314.49 299.43 180 bottom
4BD19  BD120-1.5A-S4-MU  [FB0402]  314.49 298.23 180 bottom
4BD20  BD120-1.5A-S4-MU  [FB0402]  294.56 307.48 270 bottom
4BD21  BD120-1.5A-S4-MU  [FB0402]  314.49 296.09 180 bottom
4BD22  BD120-1.5A-S4-MU  [FB0402]  301.08 293.24 180 bottom
4BD23  BD120-1.5A-S4-MU  [FB0402]  301.08 295.3 0 bottom
4BD27  NC/BD120-1.5A-S4-MU  [FB0402]  242.51 300.31 180 bottom
4BD28  BD120-1.5A-S4-MU  [FB0402]  295.59 310.31 270 bottom
4BD29  BD120-1.5A-S4-MU  [FB0402]  305.59 317.1 270 bottom
4BD30  BD120-1.5A-S4-MU  [FB0402]  295.74 313.12 225 bottom
4BD31  BD120-1.5A-S4-MU  [FB0402]  312.63 316.63 180 bottom
4BD32  BD120-1.5A-S4-MU  [FB0402]  265.06 300.73 270 top
4BD33  BD120-1.5A-S4-MU  [FB0402]  238.03 420.41 90 bottom
4BD34  BD120-1.5A-S4-MU  [FB0402]  302.26 291.51 0 bottom
4BD35  BD120-1.5A-S4-MU  [FB0402]  312.41 296.09 180 bottom
4BD36  BD120-1.5A-S4-MU  [FB0402]  294.09 300.69 0 bottom
4BD37  BD120-1.5A-S4-MU  [FB0402]  309.98 317.1 270 bottom
4C1  NC/1P-25-N-S2-WA  [C0201]  307.94 298.42 45 top
4C2  10P-50-N-S2-MU  [C0201]  312.27 293.44 300 top
4C3  NC/1.2P-50-N-S2-MU  [C0201]  309.75 297.46 45 top
4C4  NC/1P-25-N-S2-WA  [C0201]  306.58 298.11 225 top
4C5  NC/1.2P-50-N-S2-MU  [C0201]  307.55 296.29 225 top
4C6  10P-50-N-S2-MU  [C0201]  309.44 292.63 90 top
4C7  NC/10P-50-N-S2-MU  [C0201]  309.14 292.33 180 top
4C8  CNC-S2  [C0201]  309.14 287.46 180 top
4C9  NC/1P-25-N-S2-WA  [C0201]  305.65 297.58 180 bottom
4C10  NC/1.2P-50-N-S2-MU  [C0201]  305.05 295.61 180 bottom
4C11  NC/1P-25-N-S2-WA  [C0201]  303.88 298.23 180 top
4C12  NC/1.2P-50-N-S2-MU  [C0201]  303.28 296.26 180 top
4C13  10P-50-N-S2-MU  [C0201]  303.58 288.62 90 top
4C14  NC/10P-50-N-S2-MU  [C0201]  303.88 288.32 0 top
4C15  CNC-S2  [C0201]  303.88 286.5 0 top
4C16  NC/1P-25-N-S2-WA  [C0201]  303.88 298.23 180 bottom
4C17  NC/0.1U-35-X-S2-MU  [C0201]  312.4 302.06 180 bottom
4C18  NC/0.1U-35-X-S2-MU  [C0201]  312.4 301.21 180 bottom
4C19  NC/1.2P-50-N-S2-MU  [C0201]  303.28 296.26 180 bottom
4C20  0.1U-35-X-S2-MU  [C0201]  312.4 298.98 0 bottom
4C21  0.1U-35-X-S2-MU  [C0201]  312.4 299.83 0 bottom
4C22  0.1U-16-X-S4-MU  [C0402]  262.52 300.7 90 top
4C23  0.9P-50-N-S4-MU  [C0402]  295.37 305.27 270 top
4C24  0.1U-25-X-S4-TY  [C0402]  242.54 301.39 0 bottom
4C25  0.9P-50-N-S4-MU  [C0402]  295.37 302.5 90 top
4C38  1P-50-N-S4-WA  [C0402]  234.52 293.01 0 bottom
4C39  22P-50-N-S4-AVX  [C0402]  231.12 293.01 0 bottom
4C40  1P-50-N-S4-WA  [C0402]  234.52 300.28 0 bottom
4C41  22P-50-N-S4-AVX  [C0402]  231.12 300.28 0 bottom
4C44  0.1U-35-X-S2-MU  [C0201]  302.71 307.36 0 bottom
4C45  0.1U-35-X-S2-MU  [C0201]  311.18 311.27 270 bottom
4C46  0.1U-35-X-S2-MU  [C0201]  302.71 306.51 0 bottom
4C47  0.1U-35-X-S2-MU  [C0201]  311.41 304.05 180 bottom
4C48  0.1U-35-X-S2-MU  [C0201]  298.55 304.6 180 top
4C49  0.1U-35-X-S2-MU  [C0201]  311.41 307.77 180 bottom
4C52  0.1U-35-X-S2-MU  [C0201]  302.71 308.21 0 bottom
4C53  10U-10-X-S4-SS  [C0402]  286.53 308.35 90 bottom
4C54  0.1U-35-X-S2-MU  [C0201]  307.6 311.27 270 bottom
4C55  0.1U-25-X-S4-TY  [C0402]  288.8 308.35 90 bottom
4C56  0.1U-35-X-S2-MU  [C0201]  315.52 305.28 0 top
4C57  NC/10U-10-X-S4-SS  [C0402]  287.66 308.35 90 bottom
4C58  0.1U-35-X-S2-MU  [C0201]  302.44 315.8 90 top
4C59  0.1U-35-X-S2-MU  [C0201]  311.4 309.26 180 bottom
4C60  10U-10-X-S4-SS  [C0402]  317.88 314.29 0 bottom
4C61  0.1U-35-X-S2-MU  [C0201]  306.65 311.26 270 bottom
4C62  22U-25-X-S8-MU  [C0805]  286.41 316.59 0 bottom
4C63  22U-25-X-S8-MU  [C0805]  286.41 318.62 0 bottom
4C64  0.1U-35-X-S2-MU  [C0201]  298.55 302.47 180 top
4C65  47U-16-T-SC  [CODE_C]  259.93 306.65 180 bottom
4C66  10U-16-T-SA  [CODE_A]  259.97 306.65 180 top
4C67  10U-10-X-S4-SS  [C0402]  317.88 313.17 0 bottom
4C68  22U-10-T-SA  [CODE_A]  302.22 336.81 0 bottom
4C69  22U-10-T-SA  [CODE_A]  302.22 339.4 0 bottom
4C70  22U-10-T-SA  [CODE_A]  302.22 341.97 0 bottom
4C71  22U-10-T-SA  [CODE_A]  302.22 339.4 0 top
4C72  22U-10-T-SA  [CODE_A]  302.22 336.81 0 top
4C73  10U-10-X-S4-SS  [C0402]  294.06 299.62 180 bottom
4C74  0.1U-35-X-S2-MU  [C0201]  305.35 302.65 90 bottom
4C75  0.1U-35-X-S2-MU  [C0201]  315.52 302.53 0 top
4C76  10U-10-X-S4-SS  [C0402]  299.23 297.96 180 bottom
4C77  0.1U-35-X-S2-MU  [C0201]  304.54 302.65 90 bottom
4C78  0.1U-35-X-S2-MU  [C0201]  298.55 303.15 180 top
4C79  0.1U-35-X-S2-MU  [C0201]  298.55 301.78 180 top
4C83  10U-10-X-S4-SS  [C0402]  314.52 300.52 0 bottom
4C84  0.1U-35-X-S2-MU  [C0201]  306.87 302.65 90 bottom
4C85  0.1U-35-X-S2-MU  [C0201]  306.14 302.65 90 bottom
4C88  0.1U-35-X-S2-MU  [C0201]  298.55 305.26 180 top
4C89  10U-10-X-S4-SS  [C0402]  293.03 308.85 180 bottom
4C90  10U-10-X-S4-SS  [C0402]  314.52 297.15 0 bottom
4C91  0.1U-35-X-S2-MU  [C0201]  306.46 299.87 0 bottom
4C92  22U-25-X-S8-MU  [C0805]  234.74 273.47 0 bottom
4C93  22U-25-X-S8-MU  [C0805]  234.74 273.47 0 top
4C94  47U-16-T-SC  [CODE_C]  234.8 270.05 0 bottom
4C95  10U-16-T-SA  [CODE_A]  234.8 270.05 0 top
4C96  10U-10-X-S4-SS  [C0402]  316.6 300.52 0 bottom
4C97  10U-10-X-S4-SS  [C0402]  300.61 292.74 270 top
4C98  0.1U-35-X-S2-MU  [C0201]  299.67 293.64 270 top
4C99  10U-10-X-S4-SS  [C0402]  301.55 294.8 270 top
4C100  0.1U-35-X-S2-MU  [C0201]  301.83 297.95 270 top
4C101  10U-10-X-S4-SS  [C0402]  293.03 307.01 180 bottom
4C102  0.1U-35-X-S2-MU  [C0201]  311.41 305.56 180 bottom
4C105  0.1U-35-X-S2-MU  [C0201]  311.4 306.35 180 bottom
4C106  10U-10-X-S4-SS  [C0402]  316.43 327.74 90 bottom
4C107  0.1U-35-X-S2-MU  [C0201]  315.52 306.65 0 top
4C108  0.1U-25-X-S4-TY  [C0402]  315.31 327.74 90 bottom
4C109  NC/10U-10-X-S4-SS  [C0402]  317.55 327.74 90 bottom
4C110  1U-10-X-S4-MU  [C0402]  317.14 302.53 180 top
4C111  10U-10-X-S4-SS  [C0402]  295.59 309.34 270 top
4C112  0.1U-35-X-S2-MU  [C0201]  297.6 310.06 270 top
4C113  10U-25-X-S6-MU  [C0603]  321.74 307.85 90 bottom
4C116  22U-25-X-S8-MU  [C0805]  306.8 319.97 180 bottom
4C117  22U-25-X-S8-MU  [C0805]  306.8 322.13 180 bottom
4C118  10U-10-X-S4-SS  [C0402]  304.5 317.13 90 bottom
4C119  0.1U-35-X-S2-MU  [C0201]  305.72 311.26 270 bottom
4C120  47U-16-T-SC  [CODE_C]  284.98 341.2 90 bottom
4C121  10U-16-T-SA  [CODE_A]  284.98 341.2 90 top
4C122  10U-10-X-S4-SS  [C0402]  316.6 299.41 0 bottom
4C123  10U-10-X-S4-SS  [C0402]  295.05 313.14 135 top
4C124  0.1U-35-X-S2-MU  [C0201]  298.55 311.94 180 top
4C125  10U-10-X-S4-SS  [C0402]  312.16 317.13 90 top
4C126  0.1U-35-X-S2-MU  [C0201]  312.11 315.75 180 top
4C127  10U-10-X-S4-SS  [C0402]  263.79 300.7 90 top
4C128  0.1U-35-X-S2-MU  [C0201]  261.25 300.7 90 top
4C129  10U-10-X-S4-SS  [C0402]  292.04 300.68 180 bottom
4C130  0.1U-25-X-S4-TY  [C0402]  239.12 420.38 270 bottom
4C131  22U-10-T-SA  [CODE_A]  233.58 417.82 180 bottom
4C132  22U-10-T-SA  [CODE_A]  233.58 422.95 180 top
4C133  22U-10-T-SA  [CODE_A]  233.58 420.39 180 top
4C134  22U-10-T-SA  [CODE_A]  233.58 420.39 180 bottom
4C135  22U-10-T-SA  [CODE_A]  233.58 422.95 180 bottom
4C136  10U-10-X-S4-SS  [C0402]  306.61 327.74 90 bottom
4C137  0.1U-25-X-S4-TY  [C0402]  305.5 327.74 90 bottom
4C138  NC/10U-10-X-S4-SS  [C0402]  307.73 327.74 90 bottom
4C139  22U-25-X-S8-MU  [C0805]  295.27 327.42 270 bottom
4C140  47U-16-T-SC  [CODE_C]  284.98 331.95 90 bottom
4C141  10U-16-T-SA  [CODE_A]  284.98 331.95 90 top
4C142  22U-25-X-S8-MU  [C0805]  297.56 327.42 270 bottom
4C143  NC/10P-50-N-S4-WA  [C0402]  315.78 310.66 180 bottom
4C144  NC/10P-50-N-S4-WA  [C0402]  315.78 309.49 180 bottom
4C145  NC/10P-50-N-S4-WA  [C0402]  205.88 285.64 90 top
4C146  NC/10P-50-N-S4-WA  [C0402]  205.88 288.84 90 top
4C147  NC/10P-50-N-S4-WA  [C0402]  205.88 278.37 90 top
4C148  NC/10P-50-N-S4-WA  [C0402]  205.88 281.57 90 top
4C149  NC/10P-50-N-S4-WA  [C0402]  205.88 294.27 90 top
4C150  NC/10P-50-N-S4-WA  [C0402]  205.88 297.47 90 top
4C152  0.1U-35-X-S2-MU  [C0201]  308.44 311.27 270 bottom
4C153  CNC-S2  [C0201]  310.9 307.1 180 bottom
4D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  312.51 292.17 30 top
4D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  309.02 288.35 0 top
4D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  304 287.38 180 top
4J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  213.31 302 270 top
4J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  244.53 422.92 90 top
4J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  207.08 302 270 top
4J4  HDR-8X1-M  [JP_8P_100]  221.54 371.99 90 top
4J5  HDR-1X1-M  [JP_1P_RD070_040]  229.6 415.04 270 top
4J6  HDR-2X1-M  [JP_2P_100]  232.52 415.04 270 top
4J7  HDR-2X1-M  [JP_2P_100]  305.59 157.26 0 top
4J8  HDR-2X1-M  [JP_2P_100]  309.4 157.26 0 top
4J9  HDR-2X1-M  [JP_2P_100]  301.78 157.26 0 top
4K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 297.2 0 bottom
4K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 290.19 0 bottom
4K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 283.18 0 bottom
4K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 305.05 0 bottom
4K5  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  324.28 330.8 270 bottom
4K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  235.81 407.22 270 bottom
4K7  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.41 306.7 270 bottom
4K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 296.65 0 bottom
4K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  328.52 283.36 180 bottom
4K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  249.02 288.01 0 bottom
4K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 280.75 0 bottom
4K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 288.01 0 bottom
4K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 288.01 0 bottom
4K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  249.02 280.75 0 bottom
4K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 280.75 0 bottom
4K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  246.05 305.05 0 bottom
4K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  246.05 296.65 0 bottom
4K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 296.65 0 bottom
4K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  301.93 323.97 90 bottom
4K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  289.46 312.44 0 bottom
4K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  286.35 301.95 90 bottom
4K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  292.58 341.13 180 bottom
4K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  299.93 332.41 0 bottom
4K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  323.82 340.05 0 bottom
4K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  312.96 332.35 0 bottom
4K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  311.74 323.97 90 bottom
4K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 305.25 270 bottom
4K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 293.82 270 bottom
4K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 282.39 270 bottom
4K33  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  308.61 340.77 270 bottom
4K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 288.01 0 bottom
4K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 280.75 0 bottom
4K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 296.65 0 bottom
4K37  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 305.05 0 bottom
4K38  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  314.96 340.78 270 bottom
4K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  242.77 407.22 270 bottom
4L1  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  290.75 307.9 270 bottom
4L3  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  316.06 325.2 90 bottom
4L4  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  306.25 325.2 90 bottom
4R1  0-5-S2  [R0201]  308.84 297.94 315 top
4R2  0-5-S2  [R0201]  307.06 297.2 315 top
4R3  0-5-S2  [R0201]  309.44 293.91 270 top
4R4  NC/0-5-S2  [R0201]  309.14 294.21 0 top
4R5  0-5-S2  [R0201]  305.35 296.59 270 bottom
4R6  0-5-S2  [R0201]  303.58 297.25 270 top
4R7  0-5-S2  [R0201]  303.58 289.9 270 top
4R8  NC/0-5-S2  [R0201]  303.88 290.2 180 top
4R9  0-5-S2  [R0201]  303.58 297.25 270 bottom
4R10  0-5-S4  [R0402]  262.37 281.28 90 top
4R11  0-5-S4  [R0402]  261.1 281.28 90 top
4R12  NC/10K-1-S4  [R0402]  258.46 300.7 90 top
4R13  0-5-S4  [R0402]  259.73 300.7 90 top
4R14  NC/10K-1-S4  [R0402]  259.83 281.28 90 top
4R15  0-5-S4  [R0402]  257.19 300.7 90 top
4R16  0-5-S4  [R0402]  258.56 281.28 90 top
4R17  0-5-S4  [R0402]  255.92 300.7 90 top
4R18  NC/10K-1-S4  [R0402]  257.44 281.28 90 top
4R19  0-5-S4  [R0402]  215.75 302 180 bottom
4R20  0-5-S4  [R0402]  215.75 307.08 180 bottom
4R21  0-5-S4  [R0402]  215.75 309.62 180 bottom
4R22  45.3-1-S4  [R0402]  319.07 332.79 90 bottom
4R23  45.3-1-S4  [R0402]  267.21 308.7 90 bottom
4R24  0-5-S4  [R0402]  241.93 422.9 0 bottom
4R25  45.3-1-S4  [R0402]  319.07 328.8 270 bottom
4R26  45.3-1-S4  [R0402]  267.21 304.71 270 bottom
4R27  0-5-S4  [R0402]  241.93 417.82 0 bottom
4R28  0-5-S4  [R0402]  241.93 415.28 0 bottom
4R29  NC/45.3-1-S4  [R0402]  245.33 300.81 90 bottom
4R30  0-5-S4  [R0402]  209.52 302 180 bottom
4R31  0-5-S4  [R0402]  209.52 307.08 180 bottom
4R32  0-5-S4  [R0402]  209.52 309.62 180 bottom
4R33  NC/45.3-1-S4  [R0402]  244.18 300.81 270 bottom
4R34  10K-1-S4  [R0402]  221.54 374.53 90 bottom
4R35  10K-1-S4  [R0402]  219 374.53 90 bottom
4R36  10K-1-S4  [R0402]  216.46 374.53 90 bottom
4R37  10K-1-S4  [R0402]  213.92 374.53 90 bottom
4R38  0-5-S4  [R0402]  219.12 384.69 180 bottom
4R39  10K-1-S4  [R0402]  211.38 374.53 90 bottom
4R40  10K-1-S4  [R0402]  208.84 374.53 90 bottom
4R41  10K-1-S4  [R0402]  206.3 374.53 90 bottom
4R42  0-5-S4  [R0402]  206.17 384.69 0 bottom
4R43  12K-1-S4  [R0402]  320.01 307.6 0 bottom
4R45  32.4-1-S4  [R0402]  242.78 286.8 90 bottom
4R47  32.4-1-S4  [R0402]  242.78 279.54 90 bottom
4R48  0-5-S4  [R0402]  282.74 298.45 90 bottom
4R49  NC/0-5-S4  [R0402]  289.96 298.45 90 bottom
4R50  0-5-S4  [R0402]  325.32 343.76 180 top
4R51  NC/0-5-S4  [R0402]  293.58 331.32 270 bottom
4R53  0-5-S4  [R0402]  306.61 334.45 90 bottom
4R54  NC/0-5-S4  [R0402]  306.61 330.25 270 bottom
4R55  0-5-S4  [R0402]  295.43 336.09 180 bottom
4R57  NC/10K-1-S4  [R0402]  221.89 301.42 0 bottom
4R58  NC/10K-1-S4  [R0402]  221.89 308.68 0 bottom
4R59  NC/10K-1-S4  [R0402]  221.89 293.01 0 bottom
4R60  NC/10K-1-S4  [R0402]  221.89 300.28 0 bottom
4R61  0-5-S4  [R0402]  256.34 423.32 180 bottom
4R62  0-5-S4  [R0402]  253.34 423.32 0 bottom
4R63  0-5-S4  [R0402]  240.45 279.54 90 bottom
4R64  0-5-S4  [R0402]  241.62 279.54 90 bottom
4R65  0-5-S4  [R0402]  241.62 281.96 270 bottom
4R66  0-5-S4  [R0402]  240.45 281.96 270 bottom
4R67  0-5-S4  [R0402]  240.45 286.8 90 bottom
4R68  0-5-S4  [R0402]  241.62 286.8 90 bottom
4R69  0-5-S4  [R0402]  241.62 289.22 270 bottom
4R70  0-5-S4  [R0402]  240.45 289.22 270 bottom
4R71  2-5-D-2  [RC02W_27MM]  185.96 307.05 180 bottom
4R72  2-5-D-2  [RC02W_27MM]  185.96 295.62 180 bottom
4R73  2-5-D-2  [RC02W_27MM]  185.96 284.19 180 bottom
4R74  0-5-S4  [R0402]  242.78 281.96 270 bottom
4R75  0-5-S4  [R0402]  242.78 289.22 270 bottom
4R76  0-5-S4  [R0402]  320.01 303.24 180 bottom
4R77  0-5-S4  [R0402]  315.77 312.13 180 bottom
4R78  0-5-S4  [R0402]  308.92 317.13 270 bottom
4R79  0-5-S4  [R0402]  303.37 317.13 270 bottom
4R81  0-5-S4  [R0402]  320.01 305.38 180 bottom
4R82  0-5-S4  [R0402]  320.01 308.7 180 bottom
4R83  0-5-S4  [R0402]  320.01 306.5 180 bottom
4SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  314.76 289.13 210 top
4SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  309.44 284.03 180 top
4SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  303.58 283.07 180 top
4ST3  SHORT  [DEFAULT_SHORT_SMALL]  290.68 307.57 90 top
4ST4  SHORT  [DEFAULT_SHORT_SMALL]  314.99 332 180 top
4ST5  SHORT  [DEFAULT_SHORT_SMALL]  314.99 332.77 180 top
4ST8  SHORT  [DEFAULT_SHORT_SMALL]  318.16 350.01 0 bottom
4ST11  SHORT  [DEFAULT_SHORT_SMALL]  304.8 332.77 270 top
4ST12  SHORT  [DEFAULT_SHORT_SMALL]  295.09 324.92 0 bottom
4ST13  SHORT  [DEFAULT_SHORT_SMALL]  282.74 300.69 270 bottom
4ST14  SHORT  [DEFAULT_SHORT_SMALL]  296.63 337.12 0 bottom
4ST15  SHORT  [DEFAULT_SHORT_SMALL]  321.74 304.4 270 bottom
4ST16  SHORT  [DEFAULT_SHORT_SMALL]  291.64 307.77 90 top
4ST17  SHORT  [DEFAULT_SHORT_SMALL]  295.09 324.18 0 bottom
4ST18  SHORT  [DEFAULT_SHORT_SMALL]  318.16 351 0 bottom
4ST19  SHORT  [DEFAULT_SHORT_SMALL]  306.09 332.77 270 top
4SW1  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  290.24 381.39 180 top
4SW2  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  445.69 381.21 180 top
4SW3  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  320.34 395.81 180 top
4SW4  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  445.69 393.91 180 top
4SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  212.65 380.88 180 top
4SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  254.84 419.51 180 top
4SW7  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  290.24 395.81 180 top
4U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  307.66 293.75 270 top
4U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  305.36 289.74 270 top
4U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  260.46 290.25 180 bottom
4Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  293 303.89 45 top
5BD1  BD120-1.5A-S4-MU  [FB0402]  339.97 317.1 270 bottom
5BD2  BD120-1.5A-S4-MU  [FB0402]  355.74 314.24 180 bottom
5BD3  BD120-1.5A-S4-MU  [FB0402]  338.93 317.1 270 bottom
5BD5  BD120-1.5A-S4-MU  [FB0402]  336.11 307.53 0 bottom
5BD7  BD120-1.5A-S4-MU  [FB0402]  341.01 317.1 270 bottom
5BD9  BD120-1.5A-S4-MU  [FB0402]  359.98 304.31 180 bottom
5BD11  BD120-1.5A-S4-MU  [FB0402]  355.74 313.2 180 bottom
5BD12  BD120-1.5A-S4-MU  [FB0402]  347.85 317.1 270 bottom
5BD13  BD120-1.5A-S4-MU  [FB0402]  336.14 300.68 0 bottom
5BD15  BD120-1.5A-S4-MU  [FB0402]  339.26 296.89 0 bottom
5BD16  BD120-1.5A-S4-MU  [FB0402]  342.57 303.52 180 bottom
5BD17  BD120-1.5A-S4-MU  [FB0402]  342.57 302.48 180 bottom
5BD18  BD120-1.5A-S4-MU  [FB0402]  354.49 299.43 180 bottom
5BD19  BD120-1.5A-S4-MU  [FB0402]  354.49 298.23 180 bottom
5BD20  BD120-1.5A-S4-MU  [FB0402]  334.56 307.48 270 bottom
5BD21  BD120-1.5A-S4-MU  [FB0402]  354.49 296.09 180 bottom
5BD22  BD120-1.5A-S4-MU  [FB0402]  341.08 293.24 180 bottom
5BD23  BD120-1.5A-S4-MU  [FB0402]  341.08 295.3 0 bottom
5BD27  NC/BD120-1.5A-S4-MU  [FB0402]  242.51 334.6 180 bottom
5BD28  BD120-1.5A-S4-MU  [FB0402]  335.59 310.31 270 bottom
5BD29  BD120-1.5A-S4-MU  [FB0402]  345.59 317.1 270 bottom
5BD30  BD120-1.5A-S4-MU  [FB0402]  335.74 313.12 225 bottom
5BD31  BD120-1.5A-S4-MU  [FB0402]  352.63 316.63 180 bottom
5BD32  BD120-1.5A-S4-MU  [FB0402]  265.06 335.02 270 top
5BD33  BD120-1.5A-S4-MU  [FB0402]  337.6 420.41 90 bottom
5BD34  BD120-1.5A-S4-MU  [FB0402]  342.26 291.51 0 bottom
5BD35  BD120-1.5A-S4-MU  [FB0402]  352.4 296.09 180 bottom
5BD36  BD120-1.5A-S4-MU  [FB0402]  334.09 300.69 0 bottom
5BD37  BD120-1.5A-S4-MU  [FB0402]  349.98 317.1 270 bottom
5C1  NC/1P-25-N-S2-WA  [C0201]  347.94 298.42 45 top
5C2  10P-50-N-S2-MU  [C0201]  352.27 293.44 300 top
5C3  NC/1.2P-50-N-S2-MU  [C0201]  349.75 297.46 45 top
5C4  NC/1P-25-N-S2-WA  [C0201]  346.58 298.11 225 top
5C5  NC/1.2P-50-N-S2-MU  [C0201]  347.55 296.29 225 top
5C6  10P-50-N-S2-MU  [C0201]  349.44 292.63 90 top
5C7  NC/10P-50-N-S2-MU  [C0201]  349.14 292.33 180 top
5C8  CNC-S2  [C0201]  349.14 287.46 180 top
5C9  NC/1P-25-N-S2-WA  [C0201]  345.65 297.58 180 bottom
5C10  NC/1.2P-50-N-S2-MU  [C0201]  345.05 295.61 180 bottom
5C11  NC/1P-25-N-S2-WA  [C0201]  343.88 298.23 180 top
5C12  NC/1.2P-50-N-S2-MU  [C0201]  343.28 296.26 180 top
5C13  10P-50-N-S2-MU  [C0201]  343.58 288.62 90 top
5C14  NC/10P-50-N-S2-MU  [C0201]  343.88 288.32 0 top
5C15  CNC-S2  [C0201]  343.88 286.5 0 top
5C16  NC/1P-25-N-S2-WA  [C0201]  343.88 298.23 180 bottom
5C17  NC/0.1U-35-X-S2-MU  [C0201]  352.4 302.06 180 bottom
5C18  NC/0.1U-35-X-S2-MU  [C0201]  352.4 301.21 180 bottom
5C19  NC/1.2P-50-N-S2-MU  [C0201]  343.28 296.26 180 bottom
5C20  0.1U-35-X-S2-MU  [C0201]  352.4 298.98 0 bottom
5C21  0.1U-35-X-S2-MU  [C0201]  352.4 299.83 0 bottom
5C22  0.1U-16-X-S4-MU  [C0402]  262.52 334.99 90 top
5C23  0.9P-50-N-S4-MU  [C0402]  335.37 305.27 270 top
5C24  0.1U-25-X-S4-TY  [C0402]  242.54 335.68 0 bottom
5C25  0.9P-50-N-S4-MU  [C0402]  335.37 302.5 90 top
5C38  1P-50-N-S4-WA  [C0402]  234.52 327.3 0 bottom
5C39  22P-50-N-S4-AVX  [C0402]  231.12 327.3 0 bottom
5C40  1P-50-N-S4-WA  [C0402]  234.52 334.57 0 bottom
5C41  22P-50-N-S4-AVX  [C0402]  231.12 334.57 0 bottom
5C44  0.1U-35-X-S2-MU  [C0201]  342.71 307.36 0 bottom
5C45  0.1U-35-X-S2-MU  [C0201]  351.18 311.27 270 bottom
5C46  0.1U-35-X-S2-MU  [C0201]  342.71 306.51 0 bottom
5C47  0.1U-35-X-S2-MU  [C0201]  351.41 304.05 180 bottom
5C48  0.1U-35-X-S2-MU  [C0201]  338.55 304.6 180 top
5C49  0.1U-35-X-S2-MU  [C0201]  351.41 307.77 180 bottom
5C52  0.1U-35-X-S2-MU  [C0201]  342.71 308.21 0 bottom
5C53  10U-10-X-S4-SS  [C0402]  326.53 308.35 90 bottom
5C54  0.1U-35-X-S2-MU  [C0201]  347.6 311.27 270 bottom
5C55  0.1U-25-X-S4-TY  [C0402]  328.8 308.35 90 bottom
5C56  0.1U-35-X-S2-MU  [C0201]  355.52 305.28 0 top
5C57  NC/10U-10-X-S4-SS  [C0402]  327.66 308.35 90 bottom
5C58  0.1U-35-X-S2-MU  [C0201]  342.44 315.8 90 top
5C59  0.1U-35-X-S2-MU  [C0201]  351.4 309.26 180 bottom
5C60  10U-10-X-S4-SS  [C0402]  357.88 314.29 0 bottom
5C61  0.1U-35-X-S2-MU  [C0201]  346.65 311.26 270 bottom
5C62  22U-25-X-S8-MU  [C0805]  326.41 316.59 0 bottom
5C63  22U-25-X-S8-MU  [C0805]  326.41 318.62 0 bottom
5C64  0.1U-35-X-S2-MU  [C0201]  338.55 302.47 180 top
5C65  47U-16-T-SC  [CODE_C]  259.93 340.94 180 bottom
5C66  10U-16-T-SA  [CODE_A]  259.97 340.94 180 top
5C67  10U-10-X-S4-SS  [C0402]  357.88 313.17 0 bottom
5C68  22U-10-T-SA  [CODE_A]  342.23 336.81 0 bottom
5C69  22U-10-T-SA  [CODE_A]  342.23 339.4 0 bottom
5C70  22U-10-T-SA  [CODE_A]  342.23 341.97 0 bottom
5C71  22U-10-T-SA  [CODE_A]  342.23 339.4 0 top
5C72  22U-10-T-SA  [CODE_A]  342.23 336.81 0 top
5C73  10U-10-X-S4-SS  [C0402]  334.06 299.62 180 bottom
5C74  0.1U-35-X-S2-MU  [C0201]  345.35 302.65 90 bottom
5C75  0.1U-35-X-S2-MU  [C0201]  355.52 302.53 0 top
5C76  10U-10-X-S4-SS  [C0402]  339.23 297.96 180 bottom
5C77  0.1U-35-X-S2-MU  [C0201]  344.54 302.65 90 bottom
5C78  0.1U-35-X-S2-MU  [C0201]  338.55 303.15 180 top
5C79  0.1U-35-X-S2-MU  [C0201]  338.55 301.78 180 top
5C83  10U-10-X-S4-SS  [C0402]  354.52 300.52 0 bottom
5C84  0.1U-35-X-S2-MU  [C0201]  346.87 302.65 90 bottom
5C85  0.1U-35-X-S2-MU  [C0201]  346.14 302.65 90 bottom
5C88  0.1U-35-X-S2-MU  [C0201]  338.55 305.26 180 top
5C89  10U-10-X-S4-SS  [C0402]  333.03 308.85 180 bottom
5C90  10U-10-X-S4-SS  [C0402]  354.52 297.15 0 bottom
5C91  0.1U-35-X-S2-MU  [C0201]  346.46 299.87 0 bottom
5C92  22U-25-X-S8-MU  [C0805]  234.74 342.05 0 bottom
5C93  22U-25-X-S8-MU  [C0805]  234.74 342.05 0 top
5C94  47U-16-T-SC  [CODE_C]  234.8 338.63 0 bottom
5C95  10U-16-T-SA  [CODE_A]  234.8 338.63 0 top
5C96  10U-10-X-S4-SS  [C0402]  356.6 300.52 0 bottom
5C97  10U-10-X-S4-SS  [C0402]  340.61 292.74 270 top
5C98  0.1U-35-X-S2-MU  [C0201]  339.67 293.64 270 top
5C99  10U-10-X-S4-SS  [C0402]  341.55 294.8 270 top
5C100  0.1U-35-X-S2-MU  [C0201]  341.83 297.95 270 top
5C101  10U-10-X-S4-SS  [C0402]  333.03 307.01 180 bottom
5C102  0.1U-35-X-S2-MU  [C0201]  351.41 305.56 180 bottom
5C105  0.1U-35-X-S2-MU  [C0201]  351.4 306.35 180 bottom
5C106  10U-10-X-S4-SS  [C0402]  356.43 327.74 90 bottom
5C107  0.1U-35-X-S2-MU  [C0201]  355.52 306.65 0 top
5C108  0.1U-25-X-S4-TY  [C0402]  355.31 327.74 90 bottom
5C109  NC/10U-10-X-S4-SS  [C0402]  357.55 327.74 90 bottom
5C110  1U-10-X-S4-MU  [C0402]  357.14 302.53 180 top
5C111  10U-10-X-S4-SS  [C0402]  335.59 309.34 270 top
5C112  0.1U-35-X-S2-MU  [C0201]  337.6 310.06 270 top
5C113  10U-25-X-S6-MU  [C0603]  361.74 307.85 90 bottom
5C116  22U-25-X-S8-MU  [C0805]  346.8 319.97 180 bottom
5C117  22U-25-X-S8-MU  [C0805]  346.8 322.13 180 bottom
5C118  10U-10-X-S4-SS  [C0402]  344.5 317.13 90 bottom
5C119  0.1U-35-X-S2-MU  [C0201]  345.72 311.26 270 bottom
5C120  47U-16-T-SC  [CODE_C]  347.67 340.54 90 bottom
5C121  10U-16-T-SA  [CODE_A]  347.67 340.54 90 top
5C122  10U-10-X-S4-SS  [C0402]  356.6 299.41 0 bottom
5C123  10U-10-X-S4-SS  [C0402]  335.05 313.14 135 top
5C124  0.1U-35-X-S2-MU  [C0201]  338.55 311.94 180 top
5C125  10U-10-X-S4-SS  [C0402]  352.16 317.13 90 top
5C126  0.1U-35-X-S2-MU  [C0201]  352.11 315.75 180 top
5C127  10U-10-X-S4-SS  [C0402]  263.79 334.99 90 top
5C128  0.1U-35-X-S2-MU  [C0201]  261.25 334.99 90 top
5C129  10U-10-X-S4-SS  [C0402]  332.04 300.68 180 bottom
5C130  0.1U-25-X-S4-TY  [C0402]  338.69 420.38 270 bottom
5C131  22U-10-T-SA  [CODE_A]  333.15 417.82 180 bottom
5C132  22U-10-T-SA  [CODE_A]  333.15 422.95 180 top
5C133  22U-10-T-SA  [CODE_A]  333.15 420.39 180 top
5C134  22U-10-T-SA  [CODE_A]  333.15 420.39 180 bottom
5C135  22U-10-T-SA  [CODE_A]  333.15 422.95 180 bottom
5C136  10U-10-X-S4-SS  [C0402]  346.61 327.74 90 bottom
5C137  0.1U-25-X-S4-TY  [C0402]  345.5 327.74 90 bottom
5C138  NC/10U-10-X-S4-SS  [C0402]  347.73 327.74 90 bottom
5C139  22U-25-X-S8-MU  [C0805]  335.27 327.42 270 bottom
5C140  47U-16-T-SC  [CODE_C]  280.36 341.2 90 bottom
5C141  10U-16-T-SA  [CODE_A]  280.36 341.2 90 top
5C142  22U-25-X-S8-MU  [C0805]  337.56 327.42 270 bottom
5C143  NC/10P-50-N-S4-WA  [C0402]  355.78 310.66 180 bottom
5C144  NC/10P-50-N-S4-WA  [C0402]  355.78 309.49 180 bottom
5C145  NC/10P-50-N-S4-WA  [C0402]  205.88 319.93 90 top
5C146  NC/10P-50-N-S4-WA  [C0402]  205.88 323.13 90 top
5C147  NC/10P-50-N-S4-WA  [C0402]  205.88 312.66 90 top
5C148  NC/10P-50-N-S4-WA  [C0402]  205.88 315.86 90 top
5C149  NC/10P-50-N-S4-WA  [C0402]  205.88 328.56 90 top
5C150  NC/10P-50-N-S4-WA  [C0402]  205.88 331.76 90 top
5C152  0.1U-35-X-S2-MU  [C0201]  348.44 311.27 270 bottom
5C153  CNC-S2  [C0201]  350.9 307.1 180 bottom
5D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  352.51 292.17 30 top
5D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  349.02 288.35 0 top
5D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  344 287.38 180 top
5J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  213.31 336.29 270 top
5J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  344.1 422.92 90 top
5J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  207.08 336.29 270 top
5J4  HDR-8X1-M  [JP_8P_100]  329.11 372.25 90 top
5J5  HDR-1X1-M  [JP_1P_RD070_040]  329.17 415.04 270 top
5J6  HDR-2X1-M  [JP_2P_100]  332.08 415.04 270 top
5J7  HDR-2X1-M  [JP_2P_100]  289.71 157.26 0 top
5J8  HDR-2X1-M  [JP_2P_100]  293.52 157.26 0 top
5J9  HDR-2X1-M  [JP_2P_100]  285.9 157.26 0 top
5K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 331.49 0 bottom
5K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 324.48 0 bottom
5K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.11 317.47 0 bottom
5K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 339.34 0 bottom
5K5  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  364.28 330.8 270 bottom
5K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  335.38 407.22 270 bottom
5K7  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  272.41 340.99 270 bottom
5K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 330.94 0 bottom
5K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  368.52 283.36 180 bottom
5K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  249.02 322.3 0 bottom
5K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 315.04 0 bottom
5K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 322.3 0 bottom
5K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.19 322.3 0 bottom
5K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  249.02 315.04 0 bottom
5K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 315.04 0 bottom
5K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  246.05 339.34 0 bottom
5K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  246.05 330.94 0 bottom
5K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  234.62 330.94 0 bottom
5K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  341.93 323.97 90 bottom
5K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  329.46 312.44 0 bottom
5K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  326.35 301.95 90 bottom
5K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  332.5 342.34 90 bottom
5K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  339.93 332.41 0 bottom
5K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  363.82 340.05 0 bottom
5K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  352.96 332.35 0 bottom
5K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  351.74 323.97 90 bottom
5K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 339.54 270 bottom
5K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 328.11 270 bottom
5K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  202.41 316.68 270 bottom
5K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 322.3 0 bottom
5K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 315.04 0 bottom
5K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  211.76 330.94 0 bottom
5K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  342.34 407.22 270 bottom
5L1  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  330.75 307.9 270 bottom
5L3  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  356.06 325.2 90 bottom
5L4  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  346.25 325.2 90 bottom
5R1  0-5-S2  [R0201]  348.84 297.94 315 top
5R2  0-5-S2  [R0201]  347.06 297.2 315 top
5R3  0-5-S2  [R0201]  349.44 293.91 270 top
5R4  NC/0-5-S2  [R0201]  349.14 294.21 0 top
5R5  0-5-S2  [R0201]  345.35 296.59 270 bottom
5R6  0-5-S2  [R0201]  343.58 297.25 270 top
5R7  0-5-S2  [R0201]  343.58 289.9 270 top
5R8  NC/0-5-S2  [R0201]  343.88 290.2 180 top
5R9  0-5-S2  [R0201]  343.58 297.25 270 bottom
5R10  0-5-S4  [R0402]  262.37 315.57 90 top
5R11  0-5-S4  [R0402]  261.1 315.57 90 top
5R12  NC/10K-1-S4  [R0402]  258.46 334.99 90 top
5R13  0-5-S4  [R0402]  259.73 334.99 90 top
5R14  NC/10K-1-S4  [R0402]  259.83 315.57 90 top
5R15  0-5-S4  [R0402]  257.19 334.99 90 top
5R16  0-5-S4  [R0402]  258.56 315.57 90 top
5R17  0-5-S4  [R0402]  255.92 334.99 90 top
5R18  NC/10K-1-S4  [R0402]  257.44 315.57 90 top
5R19  0-5-S4  [R0402]  215.75 336.29 180 bottom
5R20  0-5-S4  [R0402]  215.75 341.37 180 bottom
5R21  0-5-S4  [R0402]  215.75 343.91 180 bottom
5R22  45.3-1-S4  [R0402]  359.07 332.79 90 bottom
5R23  45.3-1-S4  [R0402]  267.21 342.99 90 bottom
5R24  0-5-S4  [R0402]  341.5 422.9 0 bottom
5R25  45.3-1-S4  [R0402]  359.07 328.8 270 bottom
5R26  45.3-1-S4  [R0402]  267.21 339 270 bottom
5R27  0-5-S4  [R0402]  341.5 417.82 0 bottom
5R28  0-5-S4  [R0402]  341.5 415.28 0 bottom
5R29  NC/45.3-1-S4  [R0402]  245.33 335.1 90 bottom
5R30  0-5-S4  [R0402]  209.52 336.29 180 bottom
5R31  0-5-S4  [R0402]  209.52 341.37 180 bottom
5R32  0-5-S4  [R0402]  209.52 343.91 180 bottom
5R33  NC/45.3-1-S4  [R0402]  244.18 335.1 270 bottom
5R34  10K-1-S4  [R0402]  329.11 374.79 90 bottom
5R35  10K-1-S4  [R0402]  326.57 374.79 90 bottom
5R36  10K-1-S4  [R0402]  324.03 374.79 90 bottom
5R37  10K-1-S4  [R0402]  321.49 374.79 90 bottom
5R38  0-5-S4  [R0402]  326.69 384.95 180 bottom
5R39  10K-1-S4  [R0402]  318.95 374.79 90 bottom
5R40  10K-1-S4  [R0402]  316.41 374.79 90 bottom
5R41  10K-1-S4  [R0402]  313.87 374.79 90 bottom
5R42  0-5-S4  [R0402]  313.74 384.95 0 bottom
5R43  12K-1-S4  [R0402]  360.01 307.6 0 bottom
5R45  32.4-1-S4  [R0402]  242.78 321.09 90 bottom
5R47  32.4-1-S4  [R0402]  242.78 313.83 90 bottom
5R48  0-5-S4  [R0402]  322.74 298.45 90 bottom
5R49  NC/0-5-S4  [R0402]  329.96 298.45 90 bottom
5R50  0-5-S4  [R0402]  365.32 343.76 180 top
5R51  NC/0-5-S4  [R0402]  333.58 331.32 270 bottom
5R53  0-5-S4  [R0402]  346.61 334.45 90 bottom
5R54  NC/0-5-S4  [R0402]  346.61 330.25 270 bottom
5R55  0-5-S4  [R0402]  335.43 336.09 180 bottom
5R57  NC/10K-1-S4  [R0402]  221.89 335.71 0 bottom
5R58  NC/10K-1-S4  [R0402]  221.89 342.97 0 bottom
5R59  NC/10K-1-S4  [R0402]  221.89 327.3 0 bottom
5R60  NC/10K-1-S4  [R0402]  221.89 334.57 0 bottom
5R61  0-5-S4  [R0402]  355.9 423.32 180 bottom
5R62  0-5-S4  [R0402]  352.9 423.32 0 bottom
5R63  0-5-S4  [R0402]  240.45 313.83 90 bottom
5R64  0-5-S4  [R0402]  241.62 313.83 90 bottom
5R65  0-5-S4  [R0402]  241.62 316.25 270 bottom
5R66  0-5-S4  [R0402]  240.45 316.25 270 bottom
5R67  0-5-S4  [R0402]  240.45 321.09 90 bottom
5R68  0-5-S4  [R0402]  241.62 321.09 90 bottom
5R69  0-5-S4  [R0402]  241.62 323.51 270 bottom
5R70  0-5-S4  [R0402]  240.45 323.51 270 bottom
5R71  2-5-D-2  [RC02W_27MM]  185.96 341.34 180 bottom
5R72  2-5-D-2  [RC02W_27MM]  185.96 329.91 180 bottom
5R73  2-5-D-2  [RC02W_27MM]  185.96 318.48 180 bottom
5R74  0-5-S4  [R0402]  242.78 316.25 270 bottom
5R75  0-5-S4  [R0402]  242.78 323.51 270 bottom
5R76  0-5-S4  [R0402]  360.01 303.24 180 bottom
5R77  0-5-S4  [R0402]  355.77 312.13 180 bottom
5R78  0-5-S4  [R0402]  348.92 317.13 270 bottom
5R79  0-5-S4  [R0402]  343.37 317.13 270 bottom
5R81  0-5-S4  [R0402]  360.01 305.38 180 bottom
5R82  0-5-S4  [R0402]  360.01 308.7 180 bottom
5R83  0-5-S4  [R0402]  360.01 306.5 180 bottom
5SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  354.76 289.13 210 top
5SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  349.44 284.03 180 top
5SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  343.58 283.07 180 top
5ST3  SHORT  [DEFAULT_SHORT_SMALL]  339.56 314.73 225 top
5ST4  SHORT  [DEFAULT_SHORT_SMALL]  354.99 332 180 top
5ST5  SHORT  [DEFAULT_SHORT_SMALL]  354.99 332.77 180 top
5ST8  SHORT  [DEFAULT_SHORT_SMALL]  361.97 347.4 315 bottom
5ST11  SHORT  [DEFAULT_SHORT_SMALL]  353.39 341.66 270 top
5ST12  SHORT  [DEFAULT_SHORT_SMALL]  335.38 324.51 0 bottom
5ST13  SHORT  [DEFAULT_SHORT_SMALL]  322.74 300.69 270 bottom
5ST14  SHORT  [DEFAULT_SHORT_SMALL]  336.63 337.12 0 bottom
5ST15  SHORT  [DEFAULT_SHORT_SMALL]  361.74 304.4 270 bottom
5ST16  SHORT  [DEFAULT_SHORT_SMALL]  340.23 313.89 225 top
5ST17  SHORT  [DEFAULT_SHORT_SMALL]  335.33 325.65 0 bottom
5ST18  SHORT  [DEFAULT_SHORT_SMALL]  362.59 348 315 bottom
5ST19  SHORT  [DEFAULT_SHORT_SMALL]  354.35 341.68 270 top
5SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  320.22 381.14 180 top
5SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  354.4 419.51 180 top
5U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  347.66 293.75 270 top
5U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  345.36 289.74 270 top
5U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  260.46 324.54 180 bottom
5Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  333 303.89 45 top
6BD1  BD120-1.5A-S4-MU  [FB0402]  379.97 317.1 270 bottom
6BD2  BD120-1.5A-S4-MU  [FB0402]  395.74 314.24 180 bottom
6BD3  BD120-1.5A-S4-MU  [FB0402]  378.93 317.1 270 bottom
6BD5  BD120-1.5A-S4-MU  [FB0402]  376.11 307.53 0 bottom
6BD7  BD120-1.5A-S4-MU  [FB0402]  381.01 317.1 270 bottom
6BD9  BD120-1.5A-S4-MU  [FB0402]  399.98 304.31 180 bottom
6BD11  BD120-1.5A-S4-MU  [FB0402]  395.74 313.2 180 bottom
6BD12  BD120-1.5A-S4-MU  [FB0402]  387.85 317.1 270 bottom
6BD13  BD120-1.5A-S4-MU  [FB0402]  376.14 300.68 0 bottom
6BD15  BD120-1.5A-S4-MU  [FB0402]  379.26 296.89 0 bottom
6BD16  BD120-1.5A-S4-MU  [FB0402]  382.57 303.52 180 bottom
6BD17  BD120-1.5A-S4-MU  [FB0402]  382.57 302.48 180 bottom
6BD18  BD120-1.5A-S4-MU  [FB0402]  394.49 299.43 180 bottom
6BD19  BD120-1.5A-S4-MU  [FB0402]  394.49 298.23 180 bottom
6BD20  BD120-1.5A-S4-MU  [FB0402]  374.56 307.48 270 bottom
6BD21  BD120-1.5A-S4-MU  [FB0402]  394.49 296.09 180 bottom
6BD22  BD120-1.5A-S4-MU  [FB0402]  381.08 293.24 180 bottom
6BD23  BD120-1.5A-S4-MU  [FB0402]  381.08 295.3 0 bottom
6BD27  NC/BD120-1.5A-S4-MU  [FB0402]  491.65 321.99 0 bottom
6BD28  BD120-1.5A-S4-MU  [FB0402]  375.59 310.31 270 bottom
6BD29  BD120-1.5A-S4-MU  [FB0402]  385.59 317.1 270 bottom
6BD30  BD120-1.5A-S4-MU  [FB0402]  375.74 313.12 225 bottom
6BD31  BD120-1.5A-S4-MU  [FB0402]  392.63 316.63 180 bottom
6BD32  BD120-1.5A-S4-MU  [FB0402]  469.1 321.57 90 top
6BD33  BD120-1.5A-S4-MU  [FB0402]  482.25 420.41 90 bottom
6BD34  BD120-1.5A-S4-MU  [FB0402]  382.26 291.51 0 bottom
6BD35  BD120-1.5A-S4-MU  [FB0402]  392.4 296.09 180 bottom
6BD36  BD120-1.5A-S4-MU  [FB0402]  374.09 300.69 0 bottom
6BD37  BD120-1.5A-S4-MU  [FB0402]  389.98 317.1 270 bottom
6C1  NC/1P-25-N-S2-WA  [C0201]  387.94 298.42 45 top
6C2  10P-50-N-S2-MU  [C0201]  392.27 293.44 300 top
6C3  NC/1.2P-50-N-S2-MU  [C0201]  389.75 297.46 45 top
6C4  NC/1P-25-N-S2-WA  [C0201]  386.58 298.11 225 top
6C5  NC/1.2P-50-N-S2-MU  [C0201]  387.55 296.29 225 top
6C6  10P-50-N-S2-MU  [C0201]  389.44 292.63 90 top
6C7  NC/10P-50-N-S2-MU  [C0201]  389.14 292.33 180 top
6C8  CNC-S2  [C0201]  389.14 287.46 180 top
6C9  NC/1P-25-N-S2-WA  [C0201]  385.65 297.58 180 bottom
6C10  NC/1.2P-50-N-S2-MU  [C0201]  385.05 295.61 180 bottom
6C11  NC/1P-25-N-S2-WA  [C0201]  383.88 298.23 180 top
6C12  NC/1.2P-50-N-S2-MU  [C0201]  383.28 296.26 180 top
6C13  10P-50-N-S2-MU  [C0201]  383.58 288.62 90 top
6C14  NC/10P-50-N-S2-MU  [C0201]  383.88 288.32 0 top
6C15  CNC-S2  [C0201]  383.88 286.5 0 top
6C16  NC/1P-25-N-S2-WA  [C0201]  383.88 298.23 180 bottom
6C17  NC/0.1U-35-X-S2-MU  [C0201]  392.4 302.06 180 bottom
6C18  NC/0.1U-35-X-S2-MU  [C0201]  392.4 301.21 180 bottom
6C19  NC/1.2P-50-N-S2-MU  [C0201]  383.28 296.26 180 bottom
6C20  0.1U-35-X-S2-MU  [C0201]  392.4 298.98 0 bottom
6C21  0.1U-35-X-S2-MU  [C0201]  392.4 299.83 0 bottom
6C22  0.1U-16-X-S4-MU  [C0402]  471.64 321.6 270 top
6C23  0.9P-50-N-S4-MU  [C0402]  375.37 305.27 270 top
6C24  0.1U-25-X-S4-TY  [C0402]  491.61 320.91 180 bottom
6C25  0.9P-50-N-S4-MU  [C0402]  375.37 302.5 90 top
6C38  1P-50-N-S4-WA  [C0402]  499.64 329.29 180 bottom
6C39  22P-50-N-S4-AVX  [C0402]  503.04 329.29 180 bottom
6C40  1P-50-N-S4-WA  [C0402]  499.64 322.02 180 bottom
6C41  22P-50-N-S4-AVX  [C0402]  503.04 322.02 180 bottom
6C44  0.1U-35-X-S2-MU  [C0201]  382.71 307.36 0 bottom
6C45  0.1U-35-X-S2-MU  [C0201]  391.18 311.27 270 bottom
6C46  0.1U-35-X-S2-MU  [C0201]  382.71 306.51 0 bottom
6C47  0.1U-35-X-S2-MU  [C0201]  391.41 304.05 180 bottom
6C48  0.1U-35-X-S2-MU  [C0201]  378.55 304.6 180 top
6C49  0.1U-35-X-S2-MU  [C0201]  391.41 307.77 180 bottom
6C52  0.1U-35-X-S2-MU  [C0201]  382.71 308.21 0 bottom
6C53  10U-10-X-S4-SS  [C0402]  366.53 308.35 90 bottom
6C54  0.1U-35-X-S2-MU  [C0201]  387.6 311.27 270 bottom
6C55  0.1U-25-X-S4-TY  [C0402]  368.8 308.35 90 bottom
6C56  0.1U-35-X-S2-MU  [C0201]  395.52 305.28 0 top
6C57  NC/10U-10-X-S4-SS  [C0402]  367.66 308.35 90 bottom
6C58  0.1U-35-X-S2-MU  [C0201]  382.44 315.8 90 top
6C59  0.1U-35-X-S2-MU  [C0201]  391.4 309.26 180 bottom
6C60  10U-10-X-S4-SS  [C0402]  397.88 314.29 0 bottom
6C61  0.1U-35-X-S2-MU  [C0201]  386.65 311.26 270 bottom
6C62  22U-25-X-S8-MU  [C0805]  366.41 316.59 0 bottom
6C63  22U-25-X-S8-MU  [C0805]  366.41 318.62 0 bottom
6C64  0.1U-35-X-S2-MU  [C0201]  378.55 302.47 180 top
6C65  47U-16-T-SC  [CODE_C]  474.22 315.65 0 bottom
6C66  10U-16-T-SA  [CODE_A]  474.19 315.65 0 top
6C67  10U-10-X-S4-SS  [C0402]  397.88 313.17 0 bottom
6C68  22U-10-T-SA  [CODE_A]  382.23 336.81 0 bottom
6C69  22U-10-T-SA  [CODE_A]  382.23 339.4 0 bottom
6C70  22U-10-T-SA  [CODE_A]  382.23 341.97 0 bottom
6C71  22U-10-T-SA  [CODE_A]  382.23 339.4 0 top
6C72  22U-10-T-SA  [CODE_A]  382.23 336.81 0 top
6C73  10U-10-X-S4-SS  [C0402]  374.06 299.62 180 bottom
6C74  0.1U-35-X-S2-MU  [C0201]  385.35 302.65 90 bottom
6C75  0.1U-35-X-S2-MU  [C0201]  395.52 302.53 0 top
6C76  10U-10-X-S4-SS  [C0402]  379.23 297.96 180 bottom
6C77  0.1U-35-X-S2-MU  [C0201]  384.54 302.65 90 bottom
6C78  0.1U-35-X-S2-MU  [C0201]  378.55 303.15 180 top
6C79  0.1U-35-X-S2-MU  [C0201]  378.55 301.78 180 top
6C83  10U-10-X-S4-SS  [C0402]  394.52 300.52 0 bottom
6C84  0.1U-35-X-S2-MU  [C0201]  386.87 302.65 90 bottom
6C85  0.1U-35-X-S2-MU  [C0201]  386.14 302.65 90 bottom
6C88  0.1U-35-X-S2-MU  [C0201]  378.55 305.26 180 top
6C89  10U-10-X-S4-SS  [C0402]  373.03 308.85 180 bottom
6C90  10U-10-X-S4-SS  [C0402]  394.52 297.15 0 bottom
6C91  0.1U-35-X-S2-MU  [C0201]  386.46 299.87 0 bottom
6C92  22U-25-X-S8-MU  [C0805]  500.3 285.67 180 bottom
6C93  22U-25-X-S8-MU  [C0805]  500.3 285.67 180 top
6C94  47U-16-T-SC  [CODE_C]  500.33 282.25 180 bottom
6C95  10U-16-T-SA  [CODE_A]  500.36 282.25 180 top
6C96  10U-10-X-S4-SS  [C0402]  396.6 300.52 0 bottom
6C97  10U-10-X-S4-SS  [C0402]  380.61 292.74 270 top
6C98  0.1U-35-X-S2-MU  [C0201]  379.67 293.64 270 top
6C99  10U-10-X-S4-SS  [C0402]  381.55 294.8 270 top
6C100  0.1U-35-X-S2-MU  [C0201]  381.83 297.95 270 top
6C101  10U-10-X-S4-SS  [C0402]  373.03 307.01 180 bottom
6C102  0.1U-35-X-S2-MU  [C0201]  391.41 305.56 180 bottom
6C105  0.1U-35-X-S2-MU  [C0201]  391.4 306.35 180 bottom
6C106  10U-10-X-S4-SS  [C0402]  396.43 327.74 90 bottom
6C107  0.1U-35-X-S2-MU  [C0201]  395.52 306.65 0 top
6C108  0.1U-25-X-S4-TY  [C0402]  395.31 327.74 90 bottom
6C109  NC/10U-10-X-S4-SS  [C0402]  397.55 327.74 90 bottom
6C110  1U-10-X-S4-MU  [C0402]  397.14 302.53 180 top
6C111  10U-10-X-S4-SS  [C0402]  375.59 309.34 270 top
6C112  0.1U-35-X-S2-MU  [C0201]  377.6 310.06 270 top
6C113  10U-25-X-S6-MU  [C0603]  401.74 307.85 90 bottom
6C116  22U-25-X-S8-MU  [C0805]  386.8 319.97 180 bottom
6C117  22U-25-X-S8-MU  [C0805]  386.8 322.13 180 bottom
6C118  10U-10-X-S4-SS  [C0402]  384.5 317.13 90 bottom
6C119  0.1U-35-X-S2-MU  [C0201]  385.72 311.26 270 bottom
6C120  47U-16-T-SC  [CODE_C]  405.59 345.58 0 bottom
6C121  10U-16-T-SA  [CODE_A]  405.59 345.58 0 top
6C122  10U-10-X-S4-SS  [C0402]  396.6 299.41 0 bottom
6C123  10U-10-X-S4-SS  [C0402]  375.05 313.14 135 top
6C124  0.1U-35-X-S2-MU  [C0201]  378.55 311.94 180 top
6C125  10U-10-X-S4-SS  [C0402]  392.16 317.13 90 top
6C126  0.1U-35-X-S2-MU  [C0201]  392.11 315.75 180 top
6C127  10U-10-X-S4-SS  [C0402]  470.37 321.6 270 top
6C128  0.1U-35-X-S2-MU  [C0201]  472.91 321.6 270 top
6C129  10U-10-X-S4-SS  [C0402]  372.04 300.68 180 bottom
6C130  0.1U-25-X-S4-TY  [C0402]  483.35 420.38 270 bottom
6C131  22U-10-T-SA  [CODE_A]  477.8 417.82 180 bottom
6C132  22U-10-T-SA  [CODE_A]  477.8 422.95 180 top
6C133  22U-10-T-SA  [CODE_A]  477.8 420.39 180 top
6C134  22U-10-T-SA  [CODE_A]  477.8 420.39 180 bottom
6C135  22U-10-T-SA  [CODE_A]  477.8 422.95 180 bottom
6C136  10U-10-X-S4-SS  [C0402]  386.61 327.74 90 bottom
6C137  0.1U-25-X-S4-TY  [C0402]  385.5 327.74 90 bottom
6C138  NC/10U-10-X-S4-SS  [C0402]  387.73 327.74 90 bottom
6C139  22U-25-X-S8-MU  [C0805]  375.27 327.42 270 bottom
6C140  47U-16-T-SC  [CODE_C]  412.11 340.81 90 bottom
6C141  10U-16-T-SA  [CODE_A]  412.11 340.81 90 top
6C142  22U-25-X-S8-MU  [C0805]  377.56 327.42 270 bottom
6C143  NC/10P-50-N-S4-WA  [C0402]  395.78 310.66 180 bottom
6C144  NC/10P-50-N-S4-WA  [C0402]  395.78 309.49 180 bottom
6C145  NC/10P-50-N-S4-WA  [C0402]  528.27 336.66 270 top
6C146  NC/10P-50-N-S4-WA  [C0402]  528.27 333.46 270 top
6C147  NC/10P-50-N-S4-WA  [C0402]  528.27 343.93 270 top
6C148  NC/10P-50-N-S4-WA  [C0402]  528.27 340.73 270 top
6C149  NC/10P-50-N-S4-WA  [C0402]  528.27 328.03 270 top
6C150  NC/10P-50-N-S4-WA  [C0402]  528.27 324.83 270 top
6C152  0.1U-35-X-S2-MU  [C0201]  388.44 311.27 270 bottom
6C153  CNC-S2  [C0201]  390.9 307.1 180 bottom
6D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  392.51 292.17 30 top
6D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  389.02 288.35 0 top
6D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  384 287.38 180 top
6J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  520.85 320.3 90 top
6J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  488.75 422.92 90 top
6J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  527.07 320.3 90 top
6J4  HDR-8X1-M  [JP_8P_100]  423.34 372.12 90 top
6J5  HDR-1X1-M  [JP_1P_RD070_040]  473.82 415.04 270 top
6J6  HDR-2X1-M  [JP_2P_100]  476.74 415.04 270 top
6J7  HDR-2X1-M  [JP_2P_100]  538 157.26 0 top
6J8  HDR-2X1-M  [JP_2P_100]  541.81 157.26 0 top
6J9  HDR-2X1-M  [JP_2P_100]  534.19 157.26 0 top
6K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  462.05 325.1 180 bottom
6K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  462.05 332.11 180 bottom
6K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  462.05 339.12 180 bottom
6K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  510.97 317.25 180 bottom
6K5  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  404.28 330.8 270 bottom
6K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.03 407.22 270 bottom
6K7  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  461.74 315.6 90 bottom
6K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  510.97 325.65 180 bottom
6K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  408.52 283.36 180 bottom
6K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  485.14 334.29 180 bottom
6K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  510.97 341.55 180 bottom
6K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  499.54 334.29 180 bottom
6K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  510.97 334.29 180 bottom
6K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  485.14 341.55 180 bottom
6K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  499.54 341.55 180 bottom
6K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  488.11 317.25 180 bottom
6K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  488.11 325.65 180 bottom
6K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  499.54 325.65 180 bottom
6K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  381.93 323.97 90 bottom
6K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  369.46 312.44 0 bottom
6K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  366.35 301.95 90 bottom
6K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  372.5 342.34 90 bottom
6K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  379.93 332.41 0 bottom
6K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  403.82 340.05 0 bottom
6K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  392.96 332.35 0 bottom
6K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  391.74 323.97 90 bottom
6K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  531.75 317.05 90 bottom
6K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  531.75 328.48 90 bottom
6K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  531.75 339.91 90 bottom
6K33  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  388.61 340.77 270 bottom
6K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  522.4 334.29 180 bottom
6K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  522.4 341.55 180 bottom
6K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  522.4 325.65 180 bottom
6K37  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  499.54 317.25 180 bottom
6K38  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  394.96 340.78 270 bottom
6K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  486.99 407.22 270 bottom
6L1  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  370.75 307.9 270 bottom
6L3  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  396.06 325.2 90 bottom
6L4  L2.2U-1.15A-S2.0X1.6-CT  [IND_201610]  386.25 325.2 90 bottom
6R1  0-5-S2  [R0201]  388.84 297.94 315 top
6R2  0-5-S2  [R0201]  387.06 297.2 315 top
6R3  0-5-S2  [R0201]  389.44 293.91 270 top
6R4  NC/0-5-S2  [R0201]  389.14 294.21 0 top
6R5  0-5-S2  [R0201]  385.35 296.59 270 bottom
6R6  0-5-S2  [R0201]  383.58 297.25 270 top
6R7  0-5-S2  [R0201]  383.58 289.9 270 top
6R8  NC/0-5-S2  [R0201]  383.88 290.2 180 top
6R9  0-5-S2  [R0201]  383.58 297.25 270 bottom
6R10  0-5-S4  [R0402]  471.79 341.02 270 top
6R11  0-5-S4  [R0402]  473.06 341.02 270 top
6R12  NC/10K-1-S4  [R0402]  475.7 321.6 270 top
6R13  0-5-S4  [R0402]  474.43 321.6 270 top
6R14  NC/10K-1-S4  [R0402]  474.33 341.02 270 top
6R15  0-5-S4  [R0402]  476.97 321.6 270 top
6R16  0-5-S4  [R0402]  475.6 341.02 270 top
6R17  0-5-S4  [R0402]  478.24 321.6 270 top
6R18  NC/10K-1-S4  [R0402]  476.71 341.02 270 top
6R19  0-5-S4  [R0402]  518.41 320.3 0 bottom
6R20  0-5-S4  [R0402]  518.41 315.22 0 bottom
6R21  0-5-S4  [R0402]  518.41 312.68 0 bottom
6R22  45.3-1-S4  [R0402]  399.07 332.79 90 bottom
6R23  45.3-1-S4  [R0402]  466.95 313.6 270 bottom
6R24  0-5-S4  [R0402]  486.15 422.9 0 bottom
6R25  45.3-1-S4  [R0402]  399.07 328.8 270 bottom
6R26  45.3-1-S4  [R0402]  466.95 317.59 90 bottom
6R27  0-5-S4  [R0402]  486.15 417.82 0 bottom
6R28  0-5-S4  [R0402]  486.15 415.28 0 bottom
6R29  NC/45.3-1-S4  [R0402]  488.83 321.49 270 bottom
6R30  0-5-S4  [R0402]  524.63 320.3 0 bottom
6R31  0-5-S4  [R0402]  524.63 315.22 0 bottom
6R32  0-5-S4  [R0402]  524.63 312.68 0 bottom
6R33  NC/45.3-1-S4  [R0402]  489.97 321.49 90 bottom
6R34  10K-1-S4  [R0402]  423.34 374.66 90 bottom
6R35  10K-1-S4  [R0402]  420.8 374.66 90 bottom
6R36  10K-1-S4  [R0402]  418.26 374.66 90 bottom
6R37  10K-1-S4  [R0402]  415.72 374.66 90 bottom
6R38  0-5-S4  [R0402]  420.93 384.82 180 bottom
6R39  10K-1-S4  [R0402]  413.18 374.66 90 bottom
6R40  10K-1-S4  [R0402]  410.64 374.66 90 bottom
6R41  10K-1-S4  [R0402]  408.1 374.66 90 bottom
6R42  0-5-S4  [R0402]  407.97 384.82 0 bottom
6R43  12K-1-S4  [R0402]  400.01 307.6 0 bottom
6R45  32.4-1-S4  [R0402]  491.38 335.5 270 bottom
6R47  32.4-1-S4  [R0402]  491.38 342.76 270 bottom
6R48  0-5-S4  [R0402]  362.74 298.45 90 bottom
