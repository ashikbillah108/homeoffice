# Allegro board 038RT-8730CN_1116-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#1501  -  []  342.98 236.26 0 top
NOREF#1502  -  []  347.08 306.86 0 top
NOREF#1503  -  []  315.22 242.53 0 top
NOREF#1504  -  []  217.54 302.05 0 top
NOREF#1505  -  []  213.31 336.29 90 top
NOREF#1506  -  []  390.94 231.37 90 top
NOREF#1507  -  []  298.47 340.67 0 top
NOREF#1508  -  []  454.69 217.13 0 top
NOREF#1509  -  []  189.36 277.98 0 top
NOREF#1510  -  []  256.21 307.92 0 top
NOREF#1511  -  []  393.36 337.18 0 top
NOREF#1512  -  []  395.61 210.88 0 top
NOREF#1513  -  []  387.66 233.29 0 top
NOREF#1514  -  []  307.66 301.41 90 top
NOREF#1515  -  []  329.39 424.22 0 top
NOREF#1516  -  []  381.08 238.36 0 top
NOREF#1517  -  []  299.23 126.62 0 top
NOREF#1518  -  []  321.62 227.86 45 top
NOREF#1519  -  []  249.65 260.76 90 top
NOREF#1520  -  []  200.81 324.51 0 top
NOREF#1521  -  []  426.22 296.54 90 top
NOREF#1522  -  []  484.51 250.27 0 top
NOREF#1523  -  []  335.78 218.6 0 top
NOREF#1524  -  []  501.34 335.89 0 top
NOREF#1525  -  []  221.39 313.44 0 top
NOREF#1526  -  []  399.84 179.87 0 top
NOREF#1527  -  []  379.58 301.86 0 top
NOREF#1528  -  []  349.77 234.51 0 top
NOREF#1529  -  []  477.11 314.38 90 top
NOREF#1530  -  []  206.11 216.43 0 top
NOREF#1531  -  []  425.35 236.29 90 top
NOREF#1532  -  []  243.37 285.01 0 top
NOREF#1533  -  []  343.31 307.25 90 top
NOREF#1534  -  []  388.09 233.43 90 top
NOREF#1535  -  []  299.58 301.86 0 top
NOREF#1536  -  []  394.49 116.12 0 top
NOREF#1537  -  []  353.51 217.31 0 top
NOREF#1538  -  []  385.35 296.29 90 top
NOREF#1539  -  []  309.4 295.85 90 top
NOREF#1540  -  []  527.52 235.68 90 top
NOREF#1541  -  []  281.22 342.47 0 top
NOREF#1542  -  []  468.6 319.55 0 top
NOREF#1543  -  []  304.45 237.2 90 top
NOREF#1544  -  []  235.02 210.57 0 top
NOREF#1545  -  []  303.58 290.2 0 top
NOREF#1546  -  []  266.46 287.19 0 top
NOREF#1547  -  []  404.92 224.96 0 top
NOREF#1548  -  []  354.07 220 0 top
NOREF#1549  -  []  512.77 301.6 0 top
NOREF#1550  -  []  343.58 238.23 0 top
NOREF#1551  -  []  378.25 305.26 0 top
NOREF#1552  -  []  540.2 335.36 0 top
NOREF#1553  -  []  432.25 234.12 0 top
NOREF#1554  -  []  324.53 386.47 90 top
NOREF#1555  -  []  447.6 307.83 0 top
NOREF#1556  -  []  344.69 328.37 0 top
NOREF#1557  -  []  389.08 308.46 90 top
NOREF#1558  -  []  507.95 234.42 0 top
NOREF#1559  -  []  472.91 287.01 90 top
NOREF#1560  -  []  423.53 264.37 90 top
NOREF#1561  -  []  235.02 286.41 0 top
NOREF#1562  -  []  359.59 248.7 90 top
NOREF#1563  -  []  261.25 300.4 90 top
NOREF#1564  -  []  259.73 333.75 90 top
NOREF#1565  -  []  342.44 255.5 90 top
NOREF#1566  -  []  340.01 183.88 90 top
NOREF#1567  -  []  437.97 209.36 90 top
NOREF#1568  -  []  173.58 488.36 0 top
NOREF#1569  -  []  377.6 249.76 90 top
NOREF#1570  -  []  495.94 318.85 0 top
NOREF#1571  -  []  522.65 230.36 0 top
NOREF#1572  -  []  359.3 306.35 0 top
NOREF#1573  -  []  386.87 242.35 90 top
NOREF#1574  -  []  398.21 329.35 90 top
NOREF#1575  -  []  305.78 229.14 90 top
NOREF#1576  -  []  306.65 310.96 90 top
NOREF#1577  -  []  428.65 238.59 0 top
NOREF#1578  -  []  512.43 127.81 0 top
NOREF#1579  -  []  495.94 233.02 0 top
NOREF#1580  -  []  189.36 266.55 0 top
NOREF#1581  -  []  217.54 277.75 0 top
NOREF#1582  -  []  343.58 286.5 0 top
NOREF#1583  -  []  517.55 403.62 0 top
NOREF#1584  -  []  425.07 214 90 top
NOREF#1585  -  []  425.33 215.4 90 top
NOREF#1586  -  []  393.51 214.74 0 top
NOREF#1587  -  []  306.22 236.54 90 top
NOREF#1588  -  []  215.36 279.15 90 top
NOREF#1589  -  []  302.15 298.55 0 top
NOREF#1590  -  []  388.08 293.38 90 top
NOREF#1591  -  []  304.25 170.6 90 top
NOREF#1592  -  []  221.39 260.76 0 top
NOREF#1593  -  []  423.58 287.38 0 top
NOREF#1594  -  []  239.87 277.75 90 top
NOREF#1595  -  []  539.65 311.41 90 top
NOREF#1596  -  []  341.19 233.6 90 top
NOREF#1597  -  []  364.14 209.62 0 top
NOREF#1598  -  []  489.91 224.38 0 top
NOREF#1599  -  []  295.67 240.69 0 top
NOREF#1600  -  []  307.45 237.26 90 top
NOREF#1601  -  []  314.25 135.04 0 top
NOREF#1602  -  []  207.08 302 90 top
NOREF#1603  -  []  268.11 254.3 0 top
NOREF#1604  -  []  432 309.58 0 top
NOREF#1605  -  []  277.39 338.15 0 top
NOREF#1606  -  []  300.57 336.81 0 top
NOREF#1607  -  []  425.65 295.93 0 top
NOREF#1608  -  []  198.73 332.94 0 top
NOREF#1609  -  []  309.74 287.14 0 top
NOREF#1610  -  []  345.07 220.36 90 top
NOREF#1611  -  []  322.08 231.86 90 top
NOREF#1612  -  []  463.34 311.6 90 top
NOREF#1613  -  []  359.64 318.32 90 top
NOREF#1614  -  []  391.15 240.26 0 top
NOREF#1615  -  []  378.24 126.36 90 top
NOREF#1616  -  []  484.74 308.86 0 top
NOREF#1617  -  []  346.65 250.96 90 top
NOREF#1618  -  []  426.14 242.35 90 top
NOREF#1619  -  []  228.97 209.17 0 top
NOREF#1620  -  []  510.57 250.27 0 top
NOREF#1621  -  []  344.86 302.05 0 top
NOREF#1622  -  []  226.79 286.41 90 top
NOREF#1623  -  []  432.14 231.95 0 top
NOREF#1624  -  []  309.13 338.13 90 top
NOREF#1625  -  []  270.81 268.81 0 top
NOREF#1626  -  []  76.55 43.42 90 top
NOREF#1627  -  []  469.4 245.17 0 top
NOREF#1628  -  []  303.88 296.58 0 top
NOREF#1629  -  []  215.36 217.83 90 top
NOREF#1630  -  []  524.7 332.89 0 top
NOREF#1631  -  []  292.08 331.86 0 top
NOREF#1632  -  []  393.08 310.71 90 top
NOREF#1633  -  []  74.58 41.86 90 top
NOREF#1634  -  []  425.58 289.16 90 top
NOREF#1635  -  []  244.25 234.87 0 top
NOREF#1636  -  []  326.69 392 0 top
NOREF#1637  -  []  241.17 406.82 90 top
NOREF#1638  -  []  352.06 193.25 0 top
NOREF#1639  -  []  346.42 126.65 90 top
NOREF#1640  -  []  520.85 312.68 90 top
NOREF#1641  -  []  208.28 266.2 90 top
NOREF#1642  -  []  428.48 251.23 90 top
NOREF#1643  -  []  393 238.02 90 top
NOREF#1644  -  []  311.45 392 0 top
NOREF#1645  -  []  449.93 341.99 90 top
NOREF#1646  -  []  305.13 229.66 0 top
NOREF#1647  -  []  355.61 213.47 0 top
NOREF#1648  -  []  352 249.58 0 top
NOREF#1649  -  []  223.59 217.83 0 top
NOREF#1650  -  []  323.81 249.44 0 top
NOREF#1651  -  []  241.58 87.36 0 top
NOREF#1652  -  []  412.08 281.86 90 top
NOREF#1653  -  []  388.09 293.15 90 top
NOREF#1654  -  []  533.35 237.45 90 top
NOREF#1655  -  []  362.79 208.02 90 top
NOREF#1656  -  []  461.65 306.43 0 top
NOREF#1657  -  []  428.54 234.54 0 top
NOREF#1658  -  []  426.06 301.41 90 top
NOREF#1659  -  []  319.08 314.86 0 top
NOREF#1660  -  []  382.88 240.86 0 top
NOREF#1661  -  []  353.34 319.97 90 top
NOREF#1662  -  []  381.83 237.65 90 top
NOREF#1663  -  []  385.16 335.54 90 top
NOREF#1664  -  []  392.01 308.09 0 top
NOREF#1665  -  []  383.58 310.36 0 top
NOREF#1666  -  []  533.35 324.49 90 top
NOREF#1667  -  []  303.32 314.56 90 top
NOREF#1668  -  []  382.75 300.26 90 top
NOREF#1669  -  []  463.34 279.51 90 top
NOREF#1670  -  []  362.02 338.45 0 top
NOREF#1671  -  []  281.35 377.58 0 top
NOREF#1672  -  []  292.08 221.86 90 top
NOREF#1673  -  []  407.08 266.86 0 top
NOREF#1674  -  []  303.53 319.97 90 top
NOREF#1675  -  []  184.83 174.79 0 top
NOREF#1676  -  []  345.33 211 90 top
NOREF#1677  -  []  306.87 241.41 90 top
NOREF#1678  -  []  211.51 265.67 0 top
NOREF#1679  -  []  332.11 243.78 0 top
NOREF#1680  -  []  342.11 247.89 0 top
NOREF#1681  -  []  522 327.25 0 top
NOREF#1682  -  []  282.08 231.86 90 top
NOREF#1683  -  []  242.05 337.74 0 top
NOREF#1684  -  []  470.69 234.42 0 top
NOREF#1685  -  []  396.56 330.75 90 top
NOREF#1686  -  []  433.91 139.28 90 top
NOREF#1687  -  []  209.96 252.12 0 top
NOREF#1688  -  []  217.54 243.46 0 top
NOREF#1689  -  []  306.46 302.05 0 top
NOREF#1690  -  []  245.02 244.86 0 top
NOREF#1691  -  []  223.59 269.16 0 top
NOREF#1692  -  []  321.08 292.86 90 top
NOREF#1693  -  []  439.64 258.32 90 top
NOREF#1694  -  []  383.53 264.37 90 top
NOREF#1695  -  []  345.86 239.55 0 top
NOREF#1696  -  []  347.6 250.97 90 top
NOREF#1697  -  []  268.11 247.29 0 top
NOREF#1698  -  []  345.08 308.86 0 top
NOREF#1699  -  []  394.92 242.85 0 top
NOREF#1700  -  []  285.09 268.96 90 top
NOREF#1701  -  []  385.43 118.96 90 top
NOREF#1702  -  []  246.45 234.87 0 top
NOREF#1703  -  []  303.58 287.38 0 top
NOREF#1704  -  []  423.35 297.91 90 top
NOREF#1705  -  []  230.26 140.81 0 top
NOREF#1706  -  []  402.68 327.2 90 top
NOREF#1707  -  []  193.96 281.44 90 top
NOREF#1708  -  []  385.68 229.23 90 top
NOREF#1709  -  []  318.44 132.6 0 top
NOREF#1710  -  []  330.9 345.94 0 top
NOREF#1711  -  []  275.71 213 90 top
NOREF#1712  -  []  350.59 415.7 0 top
NOREF#1713  -  []  465.33 141.48 90 top
NOREF#1714  -  []  418.25 241.78 0 top
NOREF#1715  -  []  305.67 242.05 0 top
NOREF#1716  -  []  339.74 129.19 0 top
NOREF#1717  -  []  425.77 289.16 90 top
NOREF#1718  -  []  433.28 231.15 90 top
NOREF#1719  -  []  367.08 326.86 0 top
NOREF#1720  -  []  414.01 335.99 0 top
NOREF#1721  -  []  332.85 302.61 0 top
NOREF#1722  -  []  343.53 319.97 90 top
NOREF#1723  -  []  249.93 401.56 90 top
NOREF#1724  -  []  215.36 210.57 90 top
NOREF#1725  -  []  493.69 128.8 90 top
NOREF#1726  -  []  335.93 330.81 0 top
NOREF#1727  -  []  313 298.02 90 top
NOREF#1728  -  []  238.22 252.12 90 top
NOREF#1729  -  []  450.39 275.06 0 top
NOREF#1730  -  []  507.95 337.29 0 top
NOREF#1731  -  []  524.2 327.25 0 top
NOREF#1732  -  []  379.15 244.28 0 top
NOREF#1733  -  []  516.09 331.29 90 top
NOREF#1734  -  []  226.79 252.12 90 top
NOREF#1735  -  []  431.1 306.35 0 top
NOREF#1736  -  []  442.13 266.4 90 top
NOREF#1737  -  []  235.02 303.45 0 top
NOREF#1738  -  []  200.26 255.12 90 top
NOREF#1739  -  []  531.46 424.44 90 top
NOREF#1740  -  []  304.46 287.38 90 top
NOREF#1741  -  []  208.88 299.96 90 top
NOREF#1742  -  []  324.53 400.89 90 top
NOREF#1743  -  []  207.69 150.21 90 top
NOREF#1744  -  []  302.88 300.86 0 top
NOREF#1745  -  []  349.44 233.61 90 top
NOREF#1746  -  []  435.61 213.47 0 top
NOREF#1747  -  []  411.05 303.74 0 top
NOREF#1748  -  []  217.01 225.07 90 top
NOREF#1749  -  []  395.61 216.04 0 top
NOREF#1750  -  []  392.7 306.78 90 top
NOREF#1751  -  []  412.85 242.61 90 top
NOREF#1752  -  []  385.36 289.74 0 top
NOREF#1753  -  []  379.5 207.71 90 top
NOREF#1754  -  []  385.35 236.29 90 top
NOREF#1755  -  []  458.45 289.21 90 top
NOREF#1756  -  []  492.57 137.96 0 top
NOREF#1757  -  []  419.58 241.86 0 top
NOREF#1758  -  []  256.94 339.34 90 top
NOREF#1759  -  []  347.19 242.05 0 top
NOREF#1760  -  []  280.47 268.96 90 top
NOREF#1761  -  []  331.5 422.95 0 top
NOREF#1762  -  []  353.1 163.81 0 top
NOREF#1763  -  []  228.44 302.05 90 top
NOREF#1764  -  []  400.19 209.61 90 top
NOREF#1765  -  []  305.08 235.94 90 top
NOREF#1766  -  []  339.81 194.29 0 top
NOREF#1767  -  []  383.58 296.95 90 top
NOREF#1768  -  []  266.46 294.2 0 top
NOREF#1769  -  []  358.8 141.13 0 top
NOREF#1770  -  []  311.81 315.75 0 top
NOREF#1771  -  []  330.08 263.86 0 top
NOREF#1772  -  []  484.51 324.05 90 top
NOREF#1773  -  []  350.6 307.1 0 top
NOREF#1774  -  []  353.1 179.05 0 top
NOREF#1775  -  []  435.22 242.53 0 top
NOREF#1776  -  []  387.6 310.97 90 top
NOREF#1777  -  []  193.96 229.79 0 top
NOREF#1778  -  []  391.48 232.15 0 top
NOREF#1779  -  []  401.83 346.85 0 top
NOREF#1780  -  []  414.94 304.03 90 top
NOREF#1781  -  []  478.43 409.02 90 top
NOREF#1782  -  []  353.2 248.94 90 top
NOREF#1783  -  []  366.02 117.24 90 top
NOREF#1784  -  []  386.37 237.89 0 top
NOREF#1785  -  []  419.67 233.34 90 top
NOREF#1786  -  []  422.98 296.26 0 top
NOREF#1787  -  []  385.08 295.94 90 top
NOREF#1788  -  []  345.77 289.36 90 top
NOREF#1789  -  []  287.95 240.15 90 top
NOREF#1790  -  []  313.2 248.94 90 top
NOREF#1791  -  []  329.39 421.66 0 top
NOREF#1792  -  []  200.81 335.94 90 top
NOREF#1793  -  []  327.08 226.86 90 top
NOREF#1794  -  []  432.7 306.78 90 top
NOREF#1795  -  []  518.8 237.08 90 top
NOREF#1796  -  []  512.28 130.92 90 top
NOREF#1797  -  []  428.12 228.85 0 top
NOREF#1798  -  []  428.08 233.18 90 top
NOREF#1799  -  []  461.65 237.85 0 top
NOREF#1800  -  []  422.11 247.89 0 top
NOREF#1801  -  []  334.28 269.42 0 top
NOREF#1802  -  []  491.34 283.85 0 top
NOREF#1803  -  []  526.25 196.07 90 top
NOREF#1804  -  []  355.22 306.65 0 top
NOREF#1805  -  []  522.05 218.94 0 top
NOREF#1806  -  []  306.14 242.35 90 top
NOREF#1807  -  []  200.81 304.84 90 top
NOREF#1808  -  []  336.66 158.97 90 top
NOREF#1809  -  []  518.8 224.38 0 top
NOREF#1810  -  []  352.06 177.36 90 top
NOREF#1811  -  []  476.15 420.39 0 top
NOREF#1812  -  []  352.71 315.43 0 top
NOREF#1813  -  []  329.86 250.84 0 top
NOREF#1814  -  []  458.45 261.93 90 top
NOREF#1815  -  []  415.78 218.6 0 top
NOREF#1816  -  []  334.38 259.56 0 top
NOREF#1817  -  []  337.86 159.13 90 top
NOREF#1818  -  []  198.73 241.5 0 top
NOREF#1819  -  []  385.58 229.16 90 top
NOREF#1820  -  []  487.71 215.98 0 top
NOREF#1821  -  []  481.54 332.69 90 top
NOREF#1822  -  []  348.59 288.35 0 top
NOREF#1823  -  []  206.11 319.3 0 top
NOREF#1824  -  []  423.59 125.38 90 top
NOREF#1825  -  []  496.52 217.38 0 top
NOREF#1826  -  []  333.78 403.62 0 top
NOREF#1827  -  []  510.57 258.67 0 top
NOREF#1828  -  []  308.47 218.61 0 top
NOREF#1829  -  []  435.16 219.71 0 top
NOREF#1830  -  []  436.05 219.71 0 top
NOREF#1831  -  []  444.92 215.4 90 top
NOREF#1832  -  []  303.58 298.23 0 top
NOREF#1833  -  []  520.85 249.18 90 top
NOREF#1834  -  []  238.22 303.45 90 top
NOREF#1835  -  []  565.58 87.36 0 top
NOREF#1836  -  []  237.72 337.36 90 top
NOREF#1837  -  []  342.11 246.19 0 top
NOREF#1838  -  []  425.26 145.48 0 top
NOREF#1839  -  []  385.86 299.55 0 top
NOREF#1840  -  []  540.2 289.64 0 top
NOREF#1841  -  []  407.08 286.86 90 top
NOREF#1842  -  []  314.07 286.36 0 top
NOREF#1843  -  []  432.01 244.37 0 top
NOREF#1844  -  []  343.25 237.85 0 top
NOREF#1845  -  []  484.51 258.67 0 top
NOREF#1846  -  []  221.39 286.41 0 top
NOREF#1847  -  []  384.08 308.86 90 top
NOREF#1848  -  []  385.67 302.05 0 top
NOREF#1849  -  []  316.21 252.13 0 top
NOREF#1850  -  []  427.23 238.3 0 top
NOREF#1851  -  []  270.81 268.81 90 top
NOREF#1852  -  []  336.07 421.68 90 top
NOREF#1853  -  []  407.66 310.84 0 top
NOREF#1854  -  []  425.33 213.2 90 top
NOREF#1855  -  []  346.06 301.41 90 top
NOREF#1856  -  []  312 246.67 0 top
NOREF#1857  -  []  410.32 284.96 0 top
NOREF#1858  -  []  270.31 295.6 0 top
NOREF#1859  -  []  249.65 337.74 90 top
NOREF#1860  -  []  575.83 129.32 0 top
NOREF#1861  -  []  432.01 308.09 0 top
NOREF#1862  -  []  343.9 297.84 0 top
NOREF#1863  -  []  342.98 296.26 0 top
NOREF#1864  -  []  355.58 240.86 90 top
NOREF#1865  -  []  391.11 307.77 0 top
NOREF#1866  -  []  385.77 289.16 90 top
NOREF#1867  -  []  458.45 258.12 0 top
NOREF#1868  -  []  392.12 293.7 0 top
NOREF#1869  -  []  507.37 343.15 0 top
NOREF#1870  -  []  520.85 209.81 90 top
NOREF#1871  -  []  394.07 220 0 top
NOREF#1872  -  []  393.36 337.18 90 top
NOREF#1873  -  []  497.83 180.04 0 top
NOREF#1874  -  []  351.5 247.42 0 top
NOREF#1875  -  []  306.16 299.87 0 top
NOREF#1876  -  []  437.47 335.54 90 top
NOREF#1877  -  []  431.1 249.26 0 top
NOREF#1878  -  []  480.72 416.55 90 top
NOREF#1879  -  []  347.66 293.75 0 top
NOREF#1880  -  []  423.58 288.32 90 top
NOREF#1881  -  []  347.6 310.97 90 top
NOREF#1882  -  []  423.58 286.5 0 top
NOREF#1883  -  []  200.81 210.21 0 top
NOREF#1884  -  []  408.51 344.31 90 top
NOREF#1885  -  []  219.19 279.15 0 top
NOREF#1886  -  []  438.21 269.35 90 top
NOREF#1887  -  []  422.12 315.2 0 top
NOREF#1888  -  []  252.62 279.15 90 top
NOREF#1889  -  []  345.67 242.05 0 top
NOREF#1890  -  []  501.34 224.38 0 top
NOREF#1891  -  []  495.94 255.47 90 top
NOREF#1892  -  []  419.15 304.28 0 top
NOREF#1893  -  []  215.11 334.25 90 top
NOREF#1894  -  []  327.95 240.15 90 top
NOREF#1895  -  []  390.97 233.86 90 top
NOREF#1896  -  []  346.85 237.41 0 top
NOREF#1897  -  []  327.08 266.86 0 top
NOREF#1898  -  []  419.15 251.62 0 top
NOREF#1899  -  []  447.6 335.11 0 top
NOREF#1900  -  []  301.34 125.35 0 top
NOREF#1901  -  []  382.54 162.12 90 top
NOREF#1902  -  []  522.83 169.04 90 top
NOREF#1903  -  []  463.85 230.84 0 top
NOREF#1904  -  []  69.58 46.86 0 top
NOREF#1905  -  []  425.02 237.19 0 top
NOREF#1906  -  []  228.77 131.53 90 top
NOREF#1907  -  []  352.14 291.95 0 top
NOREF#1908  -  []  524.45 287.52 90 top
NOREF#1909  -  []  522 343.15 0 top
NOREF#1910  -  []  419.99 294.24 0 top
NOREF#1911  -  []  481.54 240.28 0 top
NOREF#1912  -  []  302.12 315.2 0 top
NOREF#1913  -  []  434.92 302.85 0 top
NOREF#1914  -  []  419.12 250.02 90 top
NOREF#1915  -  []  311.8 239.51 0 top
NOREF#1916  -  []  386.87 237.85 0 top
NOREF#1917  -  []  308.59 288.35 0 top
NOREF#1918  -  []  387.66 241.41 90 top
NOREF#1919  -  []  421.08 298.36 0 top
NOREF#1920  -  []  507.95 303 0 top
NOREF#1921  -  []  425.68 237.91 90 top
NOREF#1922  -  []  469.9 326.35 0 top
NOREF#1923  -  []  236.5 421.68 90 top
NOREF#1924  -  []  350.58 243.36 90 top
NOREF#1925  -  []  484.51 281.36 90 top
NOREF#1926  -  []  524.7 344.32 0 top
NOREF#1927  -  []  346.16 299.87 0 top
NOREF#1928  -  []  219.19 329.34 0 top
NOREF#1929  -  []  381.78 188.85 90 top
NOREF#1930  -  []  472.3 139.28 90 top
NOREF#1931  -  []  427.73 298.21 0 top
NOREF#1932  -  []  307.31 269.35 0 top
NOREF#1933  -  []  386.25 237.9 0 top
NOREF#1934  -  []  314.92 306.97 0 top
NOREF#1935  -  []  43.4 453.95 90 top
NOREF#1936  -  []  471.27 127.92 0 top
NOREF#1937  -  []  347.31 329.35 0 top
NOREF#1938  -  []  429.1 297.26 0 top
NOREF#1939  -  []  352.14 231.95 0 top
NOREF#1940  -  []  200.81 215.61 90 top
NOREF#1941  -  []  293.88 243.99 90 top
NOREF#1942  -  []  217.01 319.3 90 top
NOREF#1943  -  []  295.67 240.69 0 top
NOREF#1944  -  []  227.94 137.96 0 top
NOREF#1945  -  []  476.15 420.39 0 top
NOREF#1946  -  []  352.1 299.83 0 top
NOREF#1947  -  []  424.69 268.37 0 top
NOREF#1948  -  []  339.12 310.02 90 top
NOREF#1949  -  []  385.36 229.28 0 top
NOREF#1950  -  []  367.3 160.17 90 top
NOREF#1951  -  []  250.15 364.38 90 top
NOREF#1952  -  []  338.25 242.47 0 top
NOREF#1953  -  []  277.36 225.62 90 top
NOREF#1954  -  []  366.02 119.24 0 top
NOREF#1955  -  []  535.43 335.75 0 top
NOREF#1956  -  []  312.01 305.88 0 top
NOREF#1957  -  []  426.16 299.87 0 top
NOREF#1958  -  []  325.45 346.74 0 top
NOREF#1959  -  []  410.08 229.86 90 top
NOREF#1960  -  []  388.48 251.23 90 top
NOREF#1961  -  []  336.06 173.61 90 top
NOREF#1962  -  []  292.04 125.38 90 top
NOREF#1963  -  []  303.31 245.55 90 top
NOREF#1964  -  []  230.62 260.76 0 top
NOREF#1965  -  []  530.15 297.79 0 top
NOREF#1966  -  []  228.17 129.76 0 top
NOREF#1967  -  []  458.45 326.7 0 top
NOREF#1968  -  []  338.98 215.4 90 top
NOREF#1969  -  []  325.46 250.84 0 top
NOREF#1970  -  []  339.99 234.24 0 top
NOREF#1971  -  []  428.43 297.66 90 top
NOREF#1972  -  []  433.36 270.75 0 top
NOREF#1973  -  []  364.92 221.76 90 top
NOREF#1974  -  []  374.19 117.51 90 top
NOREF#1975  -  []  347.31 269.35 0 top
NOREF#1976  -  []  206.11 225.07 0 top
NOREF#1977  -  []  301.83 297.65 90 top
NOREF#1978  -  []  200.81 335.94 0 top
NOREF#1979  -  []  524.7 275.74 0 top
NOREF#1980  -  []  412.11 243.78 0 top
NOREF#1981  -  []  270.31 315.87 0 top
NOREF#1982  -  []  496.6 283.52 0 top
NOREF#1983  -  []  426.46 242.05 0 top
NOREF#1984  -  []  385.77 229.36 90 top
NOREF#1985  -  []  507.37 324.05 90 top
NOREF#1986  -  []  533.35 235.24 90 top
NOREF#1987  -  []  384.46 227.38 90 top
NOREF#1988  -  []  349.44 292.33 90 top
NOREF#1989  -  []  341.85 127.92 0 top
NOREF#1990  -  []  287.95 237.95 90 top
NOREF#1991  -  []  352.01 305.88 0 top
NOREF#1992  -  []  532.47 298.94 90 top
NOREF#1993  -  []  381.08 251.06 0 top
NOREF#1994  -  []  354.2 240.89 90 top
NOREF#1995  -  []  351.48 147.82 90 top
NOREF#1996  -  []  348.84 287.46 0 top
NOREF#1997  -  []  69.58 46.86 0 top
NOREF#1998  -  []  299.67 293.34 90 top
NOREF#1999  -  []  348.08 293.18 90 top
NOREF#2000  -  []  425.1 237.2 90 top
NOREF#2001  -  []  513.16 421.66 0 top
NOREF#2002  -  []  433.91 141.48 90 top
NOREF#2003  -  []  385.02 297.19 0 top
NOREF#2004  -  []  328.12 224.96 0 top
NOREF#2005  -  []  419.15 241.46 0 top
NOREF#2006  -  []  47.92 403.18 0 top
NOREF#2007  -  []  484.51 318.85 0 top
NOREF#2008  -  []  233.15 338.63 0 top
NOREF#2009  -  []  326.22 208.02 90 top
NOREF#2010  -  []  473.66 328.65 0 top
NOREF#2011  -  []  431.18 310.97 90 top
NOREF#2012  -  []  311.11 307.77 0 top
NOREF#2013  -  []  342.75 301.46 90 top
NOREF#2014  -  []  303.31 246.4 90 top
NOREF#2015  -  []  344.48 249.03 0 top
NOREF#2016  -  []  430.14 267.57 0 top
NOREF#2017  -  []  427.45 237.26 90 top
NOREF#2018  -  []  539.65 299.98 90 top
NOREF#2019  -  []  380.35 250.98 90 top
NOREF#2020  -  []  449.07 337.05 90 top
NOREF#2021  -  []  383.58 236.95 90 top
NOREF#2022  -  []  429.1 237.26 0 top
NOREF#2023  -  []  426.7 225.88 90 top
NOREF#2024  -  []  304.02 116.64 0 top
NOREF#2025  -  []  442.68 272.6 90 top
NOREF#2026  -  []  244.25 260.76 0 top
NOREF#2027  -  []  567.58 65.36 90 top
NOREF#2028  -  []  392.01 304.37 0 top
NOREF#2029  -  []  275.71 315.87 90 top
NOREF#2030  -  []  300.98 311.61 0 top
NOREF#2031  -  []  421.68 251.19 0 top
NOREF#2032  -  []  510.57 335.89 0 top
NOREF#2033  -  []  313.08 242.66 90 top
NOREF#2034  -  []  539.44 415.7 0 top
NOREF#2035  -  []  384.46 287.38 90 top
NOREF#2036  -  []  214.51 300.49 90 top
NOREF#2037  -  []  340.35 244.3 90 top
NOREF#2038  -  []  345.07 214 90 top
NOREF#2039  -  []  345.67 302.05 0 top
NOREF#2040  -  []  52.66 412.71 0 top
NOREF#2041  -  []  341.08 115.31 90 top
NOREF#2042  -  []  303.28 288.64 0 top
NOREF#2043  -  []  427.31 329.35 0 top
NOREF#2044  -  []  426.22 236.54 90 top
NOREF#2045  -  []  481.54 301.6 0 top
NOREF#2046  -  []  298.13 330.81 0 top
NOREF#2047  -  []  659.58 41.86 90 top
NOREF#2048  -  []  307.91 233.69 90 top
NOREF#2049  -  []  349.08 304.86 90 top
NOREF#2050  -  []  352.08 299.36 90 top
NOREF#2051  -  []  400.19 212.2 90 top
NOREF#2052  -  []  343.28 286.82 0 top
NOREF#2053  -  []  385.72 250.96 90 top
NOREF#2054  -  []  423.58 296.95 90 top
NOREF#2055  -  []  303.58 236.95 90 top
NOREF#2056  -  []  530.15 252.07 0 top
NOREF#2057  -  []  512.77 258.67 0 top
NOREF#2058  -  []  471.23 286.16 0 top
NOREF#2059  -  []  378.48 343.24 0 top
NOREF#2060  -  []  378.25 245.26 0 top
NOREF#2061  -  []  189.36 255.12 0 top
NOREF#2062  -  []  308.66 135.43 90 top
NOREF#2063  -  []  343.88 295.94 0 top
NOREF#2064  -  []  478.6 219.23 90 top
NOREF#2065  -  []  345.35 242.35 90 top
NOREF#2066  -  []  385.35 237.58 0 top
NOREF#2067  -  []  311.23 266.4 0 top
NOREF#2068  -  []  340.33 267.57 0 top
NOREF#2069  -  []  334.1 340.54 90 top
NOREF#2070  -  []  430.6 307.1 0 top
NOREF#2071  -  []  524.2 258.67 0 top
NOREF#2072  -  []  424.08 303.86 0 top
NOREF#2073  -  []  538.95 269.97 90 top
NOREF#2074  -  []  336.06 188.85 90 top
NOREF#2075  -  []  357.31 128.8 90 top
NOREF#2076  -  []  343.31 247.25 90 top
NOREF#2077  -  []  495.94 221.18 90 top
NOREF#2078  -  []  381.19 233.6 90 top
NOREF#2079  -  []  69.58 506.86 0 top
NOREF#2080  -  []  385.1 297.19 90 top
NOREF#2081  -  []  423.58 236.95 90 top
NOREF#2082  -  []  434.92 242.85 0 top
NOREF#2083  -  []  423.59 125.38 90 top
NOREF#2084  -  []  365.46 310.84 0 top
NOREF#2085  -  []  228.97 319.3 0 top
NOREF#2086  -  []  386.14 242.35 90 top
NOREF#2087  -  []  189.36 289.41 0 top
NOREF#2088  -  []  252.62 217.83 90 top
NOREF#2089  -  []  261.25 266.11 90 top
NOREF#2090  -  []  217.01 312.04 90 top
NOREF#2091  -  []  314.07 220 0 top
NOREF#2092  -  []  423.88 236.58 0 top
NOREF#2093  -  []  302.41 248.21 0 top
NOREF#2094  -  []  302.75 241.46 90 top
NOREF#2095  -  []  300.82 113.44 90 top
NOREF#2096  -  []  198.73 275.79 0 top
NOREF#2097  -  []  399.08 298.86 90 top
NOREF#2098  -  []  348.96 270.75 0 top
NOREF#2099  -  []  336.82 162.77 0 top
NOREF#2100  -  []  217.01 293.65 90 top
NOREF#2101  -  []  301.34 127.92 0 top
NOREF#2102  -  []  294.25 236.3 90 top
NOREF#2103  -  []  302.11 246.19 0 top
NOREF#2104  -  []  409.47 132.6 0 top
NOREF#2105  -  []  270.31 281.58 0 top
NOREF#2106  -  []  533.35 269.53 90 top
NOREF#2107  -  []  345.35 302.35 90 top
NOREF#2108  -  []  530.15 309.22 0 top
NOREF#2109  -  []  386.7 285.88 90 top
NOREF#2110  -  []  382.38 163.97 0 top
NOREF#2111  -  []  484.74 301.6 0 top
NOREF#2112  -  []  349.08 248.46 90 top
NOREF#2113  -  []  340.74 403.62 0 top
NOREF#2114  -  []  353.08 250.71 90 top
NOREF#2115  -  []  305.78 289.41 90 top
NOREF#2116  -  []  324.08 229.86 90 top
NOREF#2117  -  []  385.18 269.42 90 top
NOREF#2118  -  []  429.08 248.46 90 top
NOREF#2119  -  []  345.07 280.36 90 top
NOREF#2120  -  []  431.8 239.51 0 top
NOREF#2121  -  []  69.58 506.86 0 top
NOREF#2122  -  []  351.81 255.75 0 top
NOREF#2123  -  []  432.01 304.37 0 top
NOREF#2124  -  []  433.34 322.17 90 top
NOREF#2125  -  []  427.31 269.35 0 top
NOREF#2126  -  []  343.53 270.82 90 top
NOREF#2127  -  []  382.61 111.35 0 top
NOREF#2128  -  []  275.71 281.58 90 top
NOREF#2129  -  []  367.08 266.86 0 top
NOREF#2130  -  []  408.58 347.18 90 top
NOREF#2131  -  []  418.25 304.6 0 top
NOREF#2132  -  []  352.06 251.23 90 top
NOREF#2133  -  []  350.94 286.5 90 top
NOREF#2134  -  []  396.12 244.96 90 top
NOREF#2135  -  []  314.2 241.74 90 top
NOREF#2136  -  []  340.35 250.98 90 top
NOREF#2137  -  []  429.83 318.32 90 top
NOREF#2138  -  []  429.08 244.86 90 top
NOREF#2139  -  []  372.11 303.78 0 top
NOREF#2140  -  []  212.16 252.12 0 top
NOREF#2141  -  []  349.08 244.86 90 top
NOREF#2142  -  []  461.65 230.84 0 top
NOREF#2143  -  []  74.58 41.86 90 top
NOREF#2144  -  []  435.02 241.03 0 top
NOREF#2145  -  []  478.29 275.65 90 top
NOREF#2146  -  []  393.08 302.66 90 top
NOREF#2147  -  []  307.01 340.37 90 top
NOREF#2148  -  []  174.46 329.91 0 top
NOREF#2149  -  []  540.2 204.13 90 top
NOREF#2150  -  []  433 238.87 90 top
NOREF#2151  -  []  370.49 168.64 90 top
NOREF#2152  -  []  304.48 298.55 0 top
NOREF#2153  -  []  342.41 246.51 0 top
NOREF#2154  -  []  338.25 301.78 0 top
NOREF#2155  -  []  330.32 284.96 0 top
NOREF#2156  -  []  567.58 65.36 90 top
NOREF#2157  -  []  522.05 287.52 0 top
NOREF#2158  -  []  341.85 130.48 0 top
NOREF#2159  -  []  316.12 306.33 90 top
NOREF#2160  -  []  344.1 420.38 90 top
NOREF#2161  -  []  322.13 326.4 90 top
NOREF#2162  -  []  251.3 302.05 90 top
NOREF#2163  -  []  380.35 241.51 90 top
NOREF#2164  -  []  347.06 233.68 0 top
NOREF#2165  -  []  402.38 178.6 0 top
NOREF#2166  -  []  384.48 228 90 top
NOREF#2167  -  []  423.58 228.32 90 top
NOREF#2168  -  []  449.58 488.36 0 top
NOREF#2169  -  []  383.58 250.36 0 top
NOREF#2170  -  []  238.87 264.33 90 top
NOREF#2171  -  []  213.31 267.71 90 top
NOREF#2172  -  []  301.68 251.18 0 top
NOREF#2173  -  []  384.08 248.86 90 top
NOREF#2174  -  []  348.39 241.41 90 top
NOREF#2175  -  []  285.46 310.84 0 top
NOREF#2176  -  []  308.08 233.18 90 top
NOREF#2177  -  []  540.2 307 90 top
NOREF#2178  -  []  380.33 270.82 0 top
NOREF#2179  -  []  393.21 305.24 90 top
NOREF#2180  -  []  339.15 302.83 0 top
NOREF#2181  -  []  326.29 110.87 90 top
NOREF#2182  -  []  378.25 303.15 0 top
NOREF#2183  -  []  402.68 330.4 90 top
NOREF#2184  -  []  392.1 299.83 0 top
NOREF#2185  -  []  418.98 215.4 90 top
NOREF#2186  -  []  312 306.67 0 top
NOREF#2187  -  []  277.36 328.49 90 top
NOREF#2188  -  []  510.57 327.25 0 top
NOREF#2189  -  []  516.09 269.97 90 top
NOREF#2190  -  []  469.64 309.95 90 top
NOREF#2191  -  []  393.21 245.24 90 top
NOREF#2192  -  []  391.1 309.26 0 top
NOREF#2193  -  []  426.33 311.86 0 top
NOREF#2194  -  []  254.27 319.3 90 top
NOREF#2195  -  []  448.46 229.74 90 top
NOREF#2196  -  []  313 298.87 90 top
NOREF#2197  -  []  362.68 330.4 90 top
NOREF#2198  -  []  290.08 229.86 90 top
NOREF#2199  -  []  419.08 274.86 0 top
NOREF#2200  -  []  206.11 327.94 0 top
NOREF#2201  -  []  349.12 292.03 0 top
NOREF#2202  -  []  429.44 293.61 90 top
NOREF#2203  -  []  332.85 302.61 90 top
NOREF#2204  -  []  226.79 329.34 90 top
NOREF#2205  -  []  526.25 264.65 90 top
NOREF#2206  -  []  352.1 239.83 0 top
NOREF#2207  -  []  312.1 299.83 0 top
NOREF#2208  -  []  340.48 311.19 0 top
NOREF#2209  -  []  245.02 313.44 0 top
NOREF#2210  -  []  527.52 219.78 90 top
NOREF#2211  -  []  437.47 335.54 90 top
NOREF#2212  -  []  533.35 340.32 90 top
NOREF#2213  -  []  313.44 114.38 0 top
NOREF#2214  -  []  336.82 178.01 0 top
NOREF#2215  -  []  228.97 250.72 0 top
NOREF#2216  -  []  305.6 229.67 90 top
NOREF#2217  -  []  458.45 268.94 90 top
NOREF#2218  -  []  386.65 310.96 90 top
NOREF#2219  -  []  305.68 297.27 90 top
NOREF#2220  -  []  430.78 129.19 0 top
NOREF#2221  -  []  256.94 236.47 90 top
NOREF#2222  -  []  472.91 321.3 90 top
NOREF#2223  -  []  383.58 226.5 0 top
NOREF#2224  -  []  275.71 329.89 90 top
NOREF#2225  -  []  231.04 271.32 0 top
NOREF#2226  -  []  193.96 286.94 0 top
NOREF#2227  -  []  336.66 179.21 0 top
NOREF#2228  -  []  44.66 406.99 0 top
NOREF#2229  -  []  390.97 293.86 90 top
NOREF#2230  -  []  453.13 320.15 90 top
NOREF#2231  -  []  433.21 305.24 90 top
NOREF#2232  -  []  266.46 225.62 0 top
NOREF#2233  -  []  425.02 297.19 0 top
NOREF#2234  -  []  383.58 286.5 0 top
NOREF#2235  -  []  325.45 210.89 0 top
NOREF#2236  -  []  427.08 306.86 0 top
NOREF#2237  -  []  472.03 253.62 0 top
NOREF#2238  -  []  214.51 266.2 90 top
NOREF#2239  -  []  443.94 345.19 0 top
NOREF#2240  -  []  337.86 179.05 0 top
NOREF#2241  -  []  352.1 302.06 0 top
NOREF#2242  -  []  269.97 207.26 0 top
NOREF#2243  -  []  370.61 211.52 0 top
NOREF#2244  -  []  536.7 258.1 0 top
NOREF#2245  -  []  535.43 221.45 0 top
NOREF#2246  -  []  71.55 109.92 0 top
NOREF#2247  -  []  299.99 234.24 0 top
NOREF#2248  -  []  245.71 317.64 90 top
NOREF#2249  -  []  433.08 242.66 90 top
NOREF#2250  -  []  345.15 338.13 90 top
NOREF#2251  -  []  250 126.36 90 top
NOREF#2252  -  []  485.09 294.36 0 top
NOREF#2253  -  []  385.68 289.22 90 top
NOREF#2254  -  []  291.58 466.36 90 top
NOREF#2255  -  []  280.7 270.81 0 top
NOREF#2256  -  []  408.08 264.86 0 top
NOREF#2257  -  []  205.88 334.78 0 top
NOREF#2258  -  []  421.79 123.34 0 top
NOREF#2259  -  []  422.11 246.19 0 top
NOREF#2260  -  []  404.51 347.01 0 top
NOREF#2261  -  []  309.44 293.61 90 top
NOREF#2262  -  []  436.8 377.4 90 top
NOREF#2263  -  []  346.33 311.86 0 top
NOREF#2264  -  []  438.6 285.59 90 top
NOREF#2265  -  []  524.2 335.89 0 top
NOREF#2266  -  []  200.26 335.13 90 top
NOREF#2267  -  []  389.74 233.89 90 top
NOREF#2268  -  []  420.35 300.82 90 top
NOREF#2269  -  []  316.56 330.75 90 top
NOREF#2270  -  []  351.18 250.97 90 top
NOREF#2271  -  []  501.34 240.28 0 top
NOREF#2272  -  []  475.85 124.08 90 top
NOREF#2273  -  []  372.08 271.86 0 top
NOREF#2274  -  []  41.87 407.27 90 top
NOREF#2275  -  []  487.87 147.82 90 top
NOREF#2276  -  []  307.08 306.86 0 top
NOREF#2277  -  []  433.21 247.45 90 top
NOREF#2278  -  []  382.75 301.46 90 top
NOREF#2279  -  []  402.02 338.45 0 top
NOREF#2280  -  []  429.32 311.23 90 top
NOREF#2281  -  []  413.88 243.99 90 top
NOREF#2282  -  []  200.81 301.65 0 top
NOREF#2283  -  []  512.77 327.25 0 top
NOREF#2284  -  []  311.8 298.66 0 top
NOREF#2285  -  []  535.43 238.26 90 top
NOREF#2286  -  []  74.58 41.86 90 top
NOREF#2287  -  []  348.12 251.87 0 top
NOREF#2288  -  []  430.78 129.19 0 top
NOREF#2289  -  []  439.82 338.45 0 top
NOREF#2290  -  []  427.66 241.41 90 top
NOREF#2291  -  []  469.64 275.66 90 top
NOREF#2292  -  []  243.37 277.75 0 top
NOREF#2293  -  []  308.65 298.59 0 top
NOREF#2294  -  []  527.52 262.71 90 top
NOREF#2295  -  []  407.42 338.45 90 top
NOREF#2296  -  []  349.4 295.85 90 top
NOREF#2297  -  []  333.06 250.84 90 top
NOREF#2298  -  []  499.14 274.57 0 top
NOREF#2299  -  []  426.6 311.22 90 top
NOREF#2300  -  []  470.69 303 0 top
NOREF#2301  -  []  469.17 126.62 0 top
NOREF#2302  -  []  295.93 330.81 0 top
NOREF#2303  -  []  230.56 141.13 0 top
NOREF#2304  -  []  213.31 336.29 90 top
NOREF#2305  -  []  385.72 310.96 90 top
NOREF#2306  -  []  337.92 250.66 0 top
NOREF#2307  -  []  308.63 298.15 0 top
NOREF#2308  -  []  535.43 232.88 0 top
NOREF#2309  -  []  348.08 233.38 90 top
NOREF#2310  -  []  303.9 230.5 0 top
NOREF#2311  -  []  348.54 294.54 0 top
NOREF#2312  -  []  522 240.28 0 top
NOREF#2313  -  []  562.17 425.76 90 top
NOREF#2314  -  []  430.3 236.62 90 top
NOREF#2315  -  []  458.45 337.52 90 top
NOREF#2316  -  []  45.3 380.96 0 top
NOREF#2317  -  []  444.92 224.96 0 top
NOREF#2318  -  []  307.08 306.86 0 top
NOREF#2319  -  []  309.54 237.24 0 top
NOREF#2320  -  []  301.34 127.92 0 top
NOREF#2321  -  []  382.11 307.89 0 top
NOREF#2322  -  []  429.92 227.85 90 top
NOREF#2323  -  []  174.46 215.61 0 top
NOREF#2324  -  []  402.13 266.4 90 top
NOREF#2325  -  []  347.89 233.18 90 top
NOREF#2326  -  []  205.15 165.9 90 top
NOREF#2327  -  []  443.67 135.04 0 top
NOREF#2328  -  []  244.25 226.47 0 top
NOREF#2329  -  []  313.51 214.74 0 top
NOREF#2330  -  []  336.82 192.6 90 top
NOREF#2331  -  []  312.14 291.95 0 top
NOREF#2332  -  []  343.53 322.17 90 top
NOREF#2333  -  []  387.66 293.29 0 top
NOREF#2334  -  []  223.59 329.34 0 top
NOREF#2335  -  []  383.32 314.56 90 top
NOREF#2336  -  []  533.35 306.03 90 top
NOREF#2337  -  []  425.36 289.74 0 top
NOREF#2338  -  []  212.16 329.34 0 top
NOREF#2339  -  []  476.15 417.82 0 top
NOREF#2340  -  []  298.25 301.78 0 top
NOREF#2341  -  []  282.08 261.86 0 top
NOREF#2342  -  []  425.72 250.96 90 top
NOREF#2343  -  []  425.1 297.19 90 top
NOREF#2344  -  []  518.8 305.66 90 top
NOREF#2345  -  []  198.73 310.08 0 top
NOREF#2346  -  []  516.09 322.65 90 top
NOREF#2347  -  []  384.54 242.35 90 top
NOREF#2348  -  []  422.12 255.2 0 top
NOREF#2349  -  []  348.48 251.23 90 top
NOREF#2350  -  []  518.8 343.15 0 top
NOREF#2351  -  []  504.66 211.38 90 top
NOREF#2352  -  []  356.18 137.96 0 top
NOREF#2353  -  []  304.48 288 90 top
NOREF#2354  -  []  228.97 216.43 0 top
NOREF#2355  -  []  254.27 277.75 90 top
NOREF#2356  -  []  377.58 65.36 90 top
NOREF#2357  -  []  387.53 251.22 90 top
NOREF#2358  -  []  234.21 409.02 90 top
NOREF#2359  -  []  231.46 140.17 90 top
NOREF#2360  -  []  288.39 212.09 90 top
NOREF#2361  -  []  535.43 295.41 90 top
NOREF#2362  -  []  309.32 311.23 90 top
NOREF#2363  -  []  339.15 302.15 0 top
NOREF#2364  -  []  206.11 312.04 0 top
NOREF#2365  -  []  296.59 392 0 top
NOREF#2366  -  []  388.84 294.21 0 top
NOREF#2367  -  []  345.72 310.96 90 top
NOREF#2368  -  []  499.14 233.02 0 top
NOREF#2369  -  []  411.05 243.75 0 top
NOREF#2370  -  []  221.39 303.45 0 top
NOREF#2371  -  []  74.58 41.86 90 top
NOREF#2372  -  []  432.61 288.79 0 top
NOREF#2373  -  []  470.43 282.63 0 top
NOREF#2374  -  []  404.92 281.76 90 top
NOREF#2375  -  []  428.49 297.58 90 top
NOREF#2376  -  []  76.55 43.42 90 top
NOREF#2377  -  []  352.06 192.6 90 top
NOREF#2378  -  []  499.58 466.36 90 top
NOREF#2379  -  []  469.16 236.08 90 top
NOREF#2380  -  []  427.28 311.87 0 top
NOREF#2381  -  []  302.12 255.2 0 top
NOREF#2382  -  []  304.9 226.88 0 top
NOREF#2383  -  []  524.51 403.62 90 top
NOREF#2384  -  []  354.2 241.74 90 top
NOREF#2385  -  []  472.3 137.08 90 top
NOREF#2386  -  []  382.41 246.51 0 top
NOREF#2387  -  []  308.08 233.38 90 top
NOREF#2388  -  []  281.33 271.88 0 top
NOREF#2389  -  []  294.38 259.56 0 top
NOREF#2390  -  []  427.91 293.69 90 top
NOREF#2391  -  []  229.07 128.8 90 top
NOREF#2392  -  []  512.77 274.57 0 top
NOREF#2393  -  []  526.25 298.94 90 top
NOREF#2394  -  []  333.23 402.82 90 top
NOREF#2395  -  []  470.43 248.34 0 top
NOREF#2396  -  []  315.22 246.65 0 top
NOREF#2397  -  []  533.35 210.19 90 top
NOREF#2398  -  []  320.19 209.61 90 top
NOREF#2399  -  []  452.3 267.69 90 top
NOREF#2400  -  []  427.31 293.29 0 top
NOREF#2401  -  []  532.47 230.36 90 top
NOREF#2402  -  []  431.11 244.05 0 top
NOREF#2403  -  []  426.85 235.29 90 top
NOREF#2404  -  []  346.37 237.89 0 top
NOREF#2405  -  []  353.34 322.17 90 top
NOREF#2406  -  []  266.46 280.18 0 top
NOREF#2407  -  []  345.72 250.96 90 top
NOREF#2408  -  []  507.37 237.08 90 top
NOREF#2409  -  []  209.96 279.15 0 top
NOREF#2410  -  []  368.34 174.37 90 top
NOREF#2411  -  []  453.9 267.23 90 top
NOREF#2412  -  []  447.86 132.6 0 top
NOREF#2413  -  []  386.6 251.22 90 top
NOREF#2414  -  []  221.39 210.57 0 top
NOREF#2415  -  []  374.71 249.44 90 top
NOREF#2416  -  []  501.34 292.96 0 top
NOREF#2417  -  []  535.43 261.12 90 top
NOREF#2418  -  []  446.07 178.22 0 top
NOREF#2419  -  []  313 238.02 90 top
NOREF#2420  -  []  383.58 189.61 90 top
NOREF#2421  -  []  277.72 207.9 90 top
NOREF#2422  -  []  393.34 324.37 90 top
NOREF#2423  -  []  495.94 339.95 90 top
NOREF#2424  -  []  489.95 424.44 0 top
NOREF#2425  -  []  368.34 189.61 90 top
NOREF#2426  -  []  311.15 300.26 0 top
NOREF#2427  -  []  447.6 225.23 0 top
NOREF#2428  -  []  370.08 289.86 90 top
NOREF#2429  -  []  313.51 214.74 0 top
NOREF#2430  -  []  431.1 309.26 0 top
NOREF#2431  -  []  305.08 295.94 90 top
NOREF#2432  -  []  484.74 240.28 0 top
NOREF#2433  -  []  349.1 297.26 0 top
NOREF#2434  -  []  217.54 259.36 0 top
NOREF#2435  -  []  287.95 300.15 90 top
NOREF#2436  -  []  347.34 236.08 0 top
NOREF#2437  -  []  312.1 302.06 0 top
NOREF#2438  -  []  513.16 424.22 0 top
NOREF#2439  -  []  314.92 245.6 0 top
NOREF#2440  -  []  193.96 332.66 0 top
NOREF#2441  -  []  69.58 506.86 0 top
NOREF#2442  -  []  436.56 270.75 90 top
NOREF#2443  -  []  567.58 466.36 90 top
NOREF#2444  -  []  215.11 265.67 90 top
NOREF#2445  -  []  449.81 231.34 0 top
NOREF#2446  -  []  308.63 238.15 0 top
NOREF#2447  -  []  338.25 251.94 0 top
NOREF#2448  -  []  51.44 432.39 0 top
NOREF#2449  -  []  328.08 287.86 90 top
NOREF#2450  -  []  522 267.31 0 top
NOREF#2451  -  []  426.33 251.86 0 top
NOREF#2452  -  []  338.47 340.67 0 top
NOREF#2453  -  []  228.44 277.75 90 top
NOREF#2454  -  []  287.45 271.63 90 top
NOREF#2455  -  []  309.92 287.85 90 top
NOREF#2456  -  []  319.82 338.45 0 top
NOREF#2457  -  []  299.23 129.19 0 top
NOREF#2458  -  []  412.08 221.86 90 top
NOREF#2459  -  []  219.19 226.47 0 top
NOREF#2460  -  []  338.13 330.81 0 top
NOREF#2461  -  []  385.16 340.7 90 top
NOREF#2462  -  []  240.4 267.76 0 top
NOREF#2463  -  []  237.72 268.78 90 top
NOREF#2464  -  []  266.46 314.47 0 top
NOREF#2465  -  []  350.59 339.27 90 top
NOREF#2466  -  []  435.26 335.55 90 top
NOREF#2467  -  []  501.34 343.15 0 top
NOREF#2468  -  []  538.95 322.65 90 top
NOREF#2469  -  []  436.8 390.1 90 top
NOREF#2470  -  []  388.84 287.46 0 top
NOREF#2471  -  []  402.68 270.4 90 top
NOREF#2472  -  []  53.97 433.34 90 top
NOREF#2473  -  []  327.95 237.95 90 top
NOREF#2474  -  []  471.27 127.92 0 top
NOREF#2475  -  []  425.65 235.93 0 top
NOREF#2476  -  []  367.95 300.15 90 top
NOREF#2477  -  []  212.16 279.15 0 top
NOREF#2478  -  []  425.76 344.8 0 top
NOREF#2479  -  []  387.89 293.18 90 top
NOREF#2480  -  []  348.54 234.54 0 top
NOREF#2481  -  []  343.53 262.17 90 top
NOREF#2482  -  []  339.15 311.62 0 top
NOREF#2483  -  []  389.68 244.71 90 top
NOREF#2484  -  []  200.81 307.05 90 top
NOREF#2485  -  []  388.07 237.2 90 top
NOREF#2486  -  []  262.84 438.26 0 top
NOREF#2487  -  []  235.02 295.05 0 top
NOREF#2488  -  []  198.73 292.6 90 top
NOREF#2489  -  []  306.85 297.41 0 top
NOREF#2490  -  []  419.15 242.83 0 top
NOREF#2491  -  []  400.76 343.68 0 top
NOREF#2492  -  []  207.76 252.12 0 top
NOREF#2493  -  []  419.15 242.15 0 top
NOREF#2494  -  []  388.12 311.87 0 top
NOREF#2495  -  []  174.46 318.48 0 top
NOREF#2496  -  []  496.52 275.97 0 top
NOREF#2497  -  []  428.2 236.49 0 top
NOREF#2498  -  []  319.08 254.86 0 top
NOREF#2499  -  []  334.71 249.44 90 top
NOREF#2500  -  []  510.57 267.31 0 top
NOREF#2501  -  []  385.07 214 90 top
NOREF#2502  -  []  472.91 252.72 90 top
NOREF#2503  -  []  499.58 65.36 90 top
NOREF#2504  -  []  496.52 328.65 0 top
NOREF#2505  -  []  307.01 337.17 0 top
NOREF#2506  -  []  312 309.58 0 top
NOREF#2507  -  []  434.2 241.74 90 top
NOREF#2508  -  []  387.06 293.68 0 top
NOREF#2509  -  []  307.86 168.91 90 top
NOREF#2510  -  []  485.09 337.29 0 top
NOREF#2511  -  []  314.92 246.97 0 top
NOREF#2512  -  []  469.1 144.68 0 top
NOREF#2513  -  []  312.71 255.43 0 top
NOREF#2514  -  []  277.36 252.9 90 top
NOREF#2515  -  []  340.58 336.81 0 top
NOREF#2516  -  []  539.65 208.54 90 top
NOREF#2517  -  []  471.68 281.36 0 top
NOREF#2518  -  []  368.34 163.81 0 top
NOREF#2519  -  []  221.39 217.83 0 top
NOREF#2520  -  []  330.33 219.4 0 top
NOREF#2521  -  []  351.9 194.45 0 top
NOREF#2522  -  []  71.55 48.42 0 top
NOREF#2523  -  []  353.45 293.48 90 top
NOREF#2524  -  []  310.86 251.87 0 top
NOREF#2525  -  []  209.96 295.05 0 top
NOREF#2526  -  []  357.01 131.53 0 top
NOREF#2527  -  []  303.58 288.32 0 top
NOREF#2528  -  []  321.71 115.19 0 top
NOREF#2529  -  []  304.08 243.86 0 top
NOREF#2530  -  []  454.69 285.71 0 top
NOREF#2531  -  []  512.77 240.28 0 top
NOREF#2532  -  []  437.46 126.65 90 top
NOREF#2533  -  []  352.06 311.23 90 top
NOREF#2534  -  []  252.62 210.57 90 top
NOREF#2535  -  []  426.65 250.96 90 top
NOREF#2536  -  []  313.21 307.45 90 top
NOREF#2537  -  []  270.26 268.01 90 top
NOREF#2538  -  []  512.77 215.98 0 top
NOREF#2539  -  []  270.81 234.52 0 top
NOREF#2540  -  []  207.76 320.7 0 top
NOREF#2541  -  []  228.44 293.65 90 top
NOREF#2542  -  []  418.3 145.48 0 top
NOREF#2543  -  []  359.3 246.35 0 top
NOREF#2544  -  []  302.98 236.26 0 top
NOREF#2545  -  []  351.1 249.26 0 top
NOREF#2546  -  []  309.74 233.89 90 top
NOREF#2547  -  []  391.11 244.05 0 top
NOREF#2548  -  []  512.77 250.27 0 top
NOREF#2549  -  []  347.73 238.21 0 top
NOREF#2550  -  []  277.01 211.27 0 top
NOREF#2551  -  []  345.6 229.67 90 top
NOREF#2552  -  []  342.75 241.46 90 top
NOREF#2553  -  []  389.44 292.33 90 top
NOREF#2554  -  []  299.12 310.02 90 top
NOREF#2555  -  []  307.06 233.68 0 top
NOREF#2556  -  []  393 298.87 90 top
NOREF#2557  -  []  424.48 288 90 top
NOREF#2558  -  []  313.34 319.97 90 top
NOREF#2559  -  []  419.58 301.86 0 top
NOREF#2560  -  []  441.62 227.86 45 top
NOREF#2561  -  []  205.88 300.49 0 top
NOREF#2562  -  []  305.68 249.03 0 top
NOREF#2563  -  []  507.37 255.47 90 top
NOREF#2564  -  []  290.08 323.86 0 top
NOREF#2565  -  []  328.95 113.41 0 top
NOREF#2566  -  []  425.1 289.85 90 top
NOREF#2567  -  []  324.92 215.4 90 top
NOREF#2568  -  []  422.41 247.36 0 top
NOREF#2569  -  []  388.44 310.97 90 top
NOREF#2570  -  []  343.58 226.5 0 top
NOREF#2571  -  []  432.06 311.23 90 top
NOREF#2572  -  []  308.96 270.75 0 top
NOREF#2573  -  []  298.25 251.94 0 top
NOREF#2574  -  []  270.26 302.3 90 top
NOREF#2575  -  []  249.65 226.47 90 top
NOREF#2576  -  []  221.39 234.87 0 top
NOREF#2577  -  []  349.68 244.71 90 top
NOREF#2578  -  []  358.47 138.93 90 top
NOREF#2579  -  []  200.81 324.51 90 top
NOREF#2580  -  []  530.15 217.78 0 top
NOREF#2581  -  []  530.15 343.51 0 top
NOREF#2582  -  []  302.75 240.26 90 top
NOREF#2583  -  []  320.19 212.2 90 top
NOREF#2584  -  []  447.6 328.1 0 top
NOREF#2585  -  []  339.08 334.86 0 top
NOREF#2586  -  []  313.28 231.15 90 top
NOREF#2587  -  []  305.1 229.85 90 top
NOREF#2588  -  []  507.37 224.38 0 top
NOREF#2589  -  []  386.87 301.41 90 top
NOREF#2590  -  []  262.89 271.09 90 top
NOREF#2591  -  []  458.45 340.72 0 top
NOREF#2592  -  []  387.73 238.21 0 top
NOREF#2593  -  []  379.08 278.86 90 top
NOREF#2594  -  []  426.85 237.41 0 top
NOREF#2595  -  []  226.79 269.16 90 top
NOREF#2596  -  []  239.87 312.04 90 top
NOREF#2597  -  []  424.69 328.37 0 top
NOREF#2598  -  []  484.51 212.78 90 top
NOREF#2599  -  []  425.08 295.3 90 top
NOREF#2600  -  []  261.1 284.95 0 top
NOREF#2601  -  []  512.77 284.56 0 top
NOREF#2602  -  []  432.88 130.48 0 top
NOREF#2603  -  []  221.39 279.15 0 top
NOREF#2604  -  []  425.36 229.28 0 top
NOREF#2605  -  []  332.08 271.86 0 top
NOREF#2606  -  []  368.08 227.86 90 top
NOREF#2607  -  []  389.74 232.01 0 top
NOREF#2608  -  []  301.83 297.76 90 top
NOREF#2609  -  []  494.85 138.93 90 top
NOREF#2610  -  []  352.01 248.09 0 top
NOREF#2611  -  []  345.78 289.41 90 top
NOREF#2612  -  []  433.44 233.48 90 top
NOREF#2613  -  []  370.29 194.29 0 top
NOREF#2614  -  []  424.48 309.03 0 top
NOREF#2615  -  []  286.89 327.12 0 top
NOREF#2616  -  []  198.73 287.22 0 top
NOREF#2617  -  []  390.14 267.57 0 top
NOREF#2618  -  []  351.23 326.4 0 top
NOREF#2619  -  []  289.97 118.04 0 top
NOREF#2620  -  []  340.35 240.82 90 top
NOREF#2621  -  []  305.91 126.65 90 top
NOREF#2622  -  []  335.91 141.48 90 top
NOREF#2623  -  []  74.58 41.86 90 top
NOREF#2624  -  []  428.84 292.33 0 top
NOREF#2625  -  []  465.07 214 90 top
NOREF#2626  -  []  239.87 233.47 90 top
NOREF#2627  -  []  351.3 173.61 90 top
NOREF#2628  -  []  316.12 246.33 90 top
NOREF#2629  -  []  424.48 286.18 90 top
NOREF#2630  -  []  305.15 335.54 90 top
NOREF#2631  -  []  275.71 227.02 90 top
NOREF#2632  -  []  435.58 240.86 90 top
NOREF#2633  -  []  343.53 259.97 90 top
NOREF#2634  -  []  386.33 311.86 0 top
NOREF#2635  -  []  362.68 332.6 90 top
NOREF#2636  -  []  276.6 342.47 0 top
NOREF#2637  -  []  469.4 210.88 0 top
NOREF#2638  -  []  74.58 41.86 90 top
NOREF#2639  -  []  301.08 298.36 0 top
NOREF#2640  -  []  400.19 214.77 90 top
NOREF#2641  -  []  496.52 310.26 0 top
NOREF#2642  -  []  352 306.67 0 top
NOREF#2643  -  []  471.23 251.87 0 top
NOREF#2644  -  []  264.76 274.26 0 top
NOREF#2645  -  []  416.68 219.4 0 top
NOREF#2646  -  []  530.15 332.08 0 top
NOREF#2647  -  []  506.1 402.82 0 top
NOREF#2648  -  []  388.07 297.2 90 top
NOREF#2649  -  []  304.48 229.88 0 top
NOREF#2650  -  []  71.55 48.42 0 top
NOREF#2651  -  []  498.71 213.67 0 top
NOREF#2652  -  []  288.08 324.86 0 top
NOREF#2653  -  []  358.15 139.83 0 top
NOREF#2654  -  []  206.11 285.01 0 top
NOREF#2655  -  []  428.44 310.97 90 top
NOREF#2656  -  []  392.1 239.83 0 top
NOREF#2657  -  []  259.36 233.72 0 top
NOREF#2658  -  []  313.36 342.58 90 top
NOREF#2659  -  []  527.07 244.1 90 top
NOREF#2660  -  []  182.93 0 90 top
NOREF#2661  -  []  494.15 401.56 90 top
NOREF#2662  -  []  193.96 224.29 90 top
NOREF#2663  -  []  522 301.6 0 top
NOREF#2664  -  []  378.25 244.6 0 top
NOREF#2665  -  []  351.67 215.41 90 top
NOREF#2666  -  []  352.06 160.17 90 top
NOREF#2667  -  []  352.06 175.41 90 top
NOREF#2668  -  []  328.12 284.96 0 top
NOREF#2669  -  []  299.15 242.83 0 top
NOREF#2670  -  []  364.9 140.92 0 top
NOREF#2671  -  []  299.15 241.46 0 top
NOREF#2672  -  []  386.06 241.41 90 top
NOREF#2673  -  []  305.15 340.7 90 top
NOREF#2674  -  []  308.12 228.85 0 top
NOREF#2675  -  []  278.56 275.44 0 top
NOREF#2676  -  []  309.68 304.71 90 top
NOREF#2677  -  []  308.48 251.23 90 top
NOREF#2678  -  []  495.94 247.07 90 top
NOREF#2679  -  []  345.1 289.85 90 top
NOREF#2680  -  []  384.13 113.39 0 top
NOREF#2681  -  []  433.34 262.17 90 top
NOREF#2682  -  []  230.62 252.12 0 top
NOREF#2683  -  []  380.35 300.82 90 top
NOREF#2684  -  []  392.01 244.37 0 top
NOREF#2685  -  []  305.15 335.54 90 top
NOREF#2686  -  []  353.2 308.94 90 top
NOREF#2687  -  []  254.71 122.62 90 top
NOREF#2688  -  []  307.66 241.41 90 top
NOREF#2689  -  []  495.94 308.86 0 top
NOREF#2690  -  []  420.35 242.19 90 top
NOREF#2691  -  []  518.8 258.67 0 top
NOREF#2692  -  []  499.14 224.38 0 top
NOREF#2693  -  []  435.22 245.28 0 top
NOREF#2694  -  []  350.58 303.36 90 top
NOREF#2695  -  []  355.05 163.81 0 top
NOREF#2696  -  []  484.74 274.57 0 top
NOREF#2697  -  []  307.89 233.18 90 top
NOREF#2698  -  []  302.75 300.26 90 top
NOREF#2699  -  []  380.58 336.81 0 top
NOREF#2700  -  []  524.7 298.6 0 top
NOREF#2701  -  []  518.8 339.95 90 top
NOREF#2702  -  []  536.7 280.96 0 top
NOREF#2703  -  []  414.38 234.16 90 top
NOREF#2704  -  []  486.94 267.31 0 top
NOREF#2705  -  []  345.77 289.16 90 top
NOREF#2706  -  []  339.12 250.02 90 top
NOREF#2707  -  []  212.97 175.21 0 top
NOREF#2708  -  []  344.48 288 90 top
NOREF#2709  -  []  488.75 415.3 90 top
NOREF#2710  -  []  540.2 278.21 0 top
NOREF#2711  -  []  468.6 250.97 0 top
NOREF#2712  -  []  313.45 293.48 90 top
NOREF#2713  -  []  353.1 194.29 0 top
NOREF#2714  -  []  524.45 218.94 90 top
NOREF#2715  -  []  270.81 340.59 90 top
NOREF#2716  -  []  374.38 259.56 0 top
NOREF#2717  -  []  259.56 227.37 0 top
NOREF#2718  -  []  423.58 227.38 0 top
NOREF#2719  -  []  527.52 245.67 90 top
NOREF#2720  -  []  69.58 506.86 0 top
NOREF#2721  -  []  478.6 253.52 90 top
NOREF#2722  -  []  522.05 253.23 0 top
NOREF#2723  -  []  277.93 132.6 0 top
NOREF#2724  -  []  342.13 218.6 0 top
NOREF#2725  -  []  289.58 488.36 0 top
NOREF#2726  -  []  391.23 326.4 0 top
NOREF#2727  -  []  420.33 330.81 0 top
NOREF#2728  -  []  522.65 196.07 0 top
NOREF#2729  -  []  507.37 267.31 0 top
NOREF#2730  -  []  339.08 274.86 0 top
NOREF#2731  -  []  470.43 214.05 0 top
NOREF#2732  -  []  389.68 304.71 90 top
NOREF#2733  -  []  385.78 289.41 90 top
NOREF#2734  -  []  351.18 109.32 0 top
NOREF#2735  -  []  342.75 300.26 90 top
NOREF#2736  -  []  384.48 297.91 0 top
NOREF#2737  -  []  533.35 338.11 90 top
NOREF#2738  -  []  200.81 272.76 90 top
NOREF#2739  -  []  345.33 215.4 90 top
NOREF#2740  -  []  347.08 306.86 0 top
NOREF#2741  -  []  336.82 175.41 90 top
NOREF#2742  -  []  385.68 297.27 90 top
NOREF#2743  -  []  292.85 242.61 90 top
NOREF#2744  -  []  295.4 139.28 90 top
NOREF#2745  -  []  304.69 328.37 0 top
NOREF#2746  -  []  308.65 238.59 0 top
NOREF#2747  -  []  331.5 422.95 0 top
NOREF#2748  -  []  313.34 264.37 90 top
NOREF#2749  -  []  305.02 297.19 0 top
NOREF#2750  -  []  425.68 229.23 90 top
NOREF#2751  -  []  207.76 286.41 0 top
NOREF#2752  -  []  312.06 251.23 90 top
NOREF#2753  -  []  385.77 229.16 90 top
NOREF#2754  -  []  343.26 228.02 0 top
NOREF#2755  -  []  423.31 306.4 90 top
NOREF#2756  -  []  193.96 241.22 0 top
NOREF#2757  -  []  307.6 250.97 90 top
NOREF#2758  -  []  212.11 300.49 0 top
NOREF#2759  -  []  262.37 250.66 90 top
NOREF#2760  -  []  193.96 292.87 90 top
NOREF#2761  -  []  345.58 289.16 90 top
NOREF#2762  -  []  380.58 336.81 0 top
NOREF#2763  -  []  348.49 237.58 90 top
NOREF#2764  -  []  432.1 301.21 0 top
NOREF#2765  -  []  270.81 237.72 90 top
NOREF#2766  -  []  347.29 298.22 0 top
NOREF#2767  -  []  427.89 293.18 90 top
NOREF#2768  -  []  379.15 251.62 0 top
NOREF#2769  -  []  339.67 293.34 90 top
NOREF#2770  -  []  384.08 243.86 0 top
NOREF#2771  -  []  212.11 266.2 0 top
NOREF#2772  -  []  334.22 145.48 0 top
NOREF#2773  -  []  273.15 209.17 0 top
