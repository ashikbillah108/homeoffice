# Allegro board 980K2-260817_261120-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL17_VI100_23_A_HS:
  vias: v1(234.07,193.35) v2(229.8,205.39)
SL17_VI100_23_B_HF: length 10.4
  TOP w0.305: SITE7.31_F 228.3,210.29 228.29,210.3 228.29,210.82 228.07,211.04
  TOP w0.635: v1(229.84,219.54) 229.08,218.78 229.08,213.58 228.07,212.57 228.07,211.04
SL17_VI100_23_B_HS: length 15.2
  BOTTOM w0.203: v1(229.84,224.11) 229.05,223.33 229.05,212.6 228.3,211.84 v2(228.3,209.59)
SL17_VI100_24_B_HF: length 5.7
  TOP w0.305: 235.04,206.93 234.73,207.24 SITE7.20_F
  TOP w0.635: v1(236.03,205.94) 235.04,206.93
  BOTTOM w0.635: v1(236.03,205.94) UNK7C61.2
SL17_VI100_24_B_HS: length 17.5
  BOTTOM w0.203: v1(248.42,205.58) 246.93,207.06 234.7,207.06 234.53,207.24 v2(231.65,207.24)
SL17_VI100_25_B_HF: length 7.6
  TOP w0.305: 234.28,207.99 234.03,207.74 SITE7.21_F
  TOP w0.635: 234.28,207.99 238.64,207.99 v1(239.27,208.62)
SL17_VI100_25_B_HS: length 13.3
  BOTTOM w0.203: v1(243.84,208.62) 242.97,209.49 236.34,209.49 234.58,207.74 v2(231.65,207.74)
SL17_VI100_26_A_HF: length 9.6
  TOP w0.305: 231.98,204.74 231.55,204.74 SITE7.16_F
  TOP w0.635: 231.98,204.74 236.72,200.01 236.72,198.83 v1(237.37,198.18)
SL17_VI100_26_A_HS: length 15.2
  BOTTOM w0.203: v2(231.3,205.39) 231.3,205.13 235.83,200.6 235.83,194.51 236.08,194.25 237.17,194.25 237.37,194.05 v1(237.37,193.35)
SL17_VI100_26_B_HF: length 0.4
  TOP w0.305: SITE7.25_F v2(231.3,210.39)
SL17_VI100_26_B_HS: length 5.7
  BOTTOM w0.203: v1(235.17,212.18) 235.17,210.87 233.95,209.65 231.36,209.65 v2(231.3,209.59)
SL17_VI100_27_A_HF: length 7.2
  TOP w0.305: 233.62,205.67 233.05,206.24 SITE7.18_F
  TOP w0.635: v1(237.73,202.67) 236.62,202.67 233.62,205.67
SL17_VI100_27_A_HS: length 18.6
  BOTTOM w0.203: v1(248.42,201.77) 246.28,203.91 234.3,203.91 231.97,206.24 v2(231.65,206.24)
SL17_VI100_27_B_HF: length 0.4
  TOP w0.305: SITE7.26_F v2(230.8,210.39)
SL17_VI100_27_B_HS: length 10.5
  BOTTOM w0.203: v2(230.8,209.59) 230.8,209.67 231.16,210.03 231.57,210.03 231.7,210.16 233.88,210.16 234.43,210.7 234.43,216 v1(235.17,216.75)
SL17_VI100_28_A_HF: length 8.2
  TOP w0.305: SITE7.19_F 233.59,206.74 234.13,206.19 234.3,206.19
  TOP w0.635: 234.3,206.19 235.57,204.92 238.62,204.92 v1(239.27,205.58)
SL17_VI100_28_A_HS: length 12.7
  BOTTOM w0.203: v1(243.84,205.58) 242.84,206.58 234.43,206.58 234.27,206.74 v2(231.65,206.74)
SL17_VI100_28_B_HF: length 1.1
  TOP w0.305: v2(229.8,210.79) 230,210.79 230.3,210.49 SITE7.27_F
SL17_VI100_28_B_HS: length 15.4
  BOTTOM w0.152: v2(230.3,209.59) 230.44,209.73 230.44,210.53 230.71,210.8
  BOTTOM w0.203: 230.71,210.8 233.5,210.8 234.03,211.32 234.03,216.17 234.05,216.2 234.05,220.2 v1(235.17,221.32)
SL17_VI100_29_A_HF: length 8.4
  TOP w0.305: 233.66,208.65 233.26,208.25 232.44,208.25 232.44,208.24 SITE7.22_F
  TOP w0.635: 233.66,208.65 233.99,208.98 237.62,208.98 v1(237.73,208.86)
  BOTTOM w0.635: UNK7C64.2 236.03,208.22 236.67,208.86 v1(237.73,208.86)
SL17_VI100_29_A_HS: length 18.1
  BOTTOM w0.203: v2(231.65,208.24) 234.45,208.24 236.21,210 247.04,210 v1(248.42,208.62)
SL17_VI100_29_B_HF: length 0.4
  TOP w0.305: SITE7.32_F v2(227.8,210.39)
  vias: v1(227.43,224.11)
SL17_VI100_29_B_HS: length 9.9
  BOTTOM w0.203: v2(227.8,209.59) 227.8,209.86 227.33,210.33 227.33,211.45 228.59,212.71 228.59,215.84 227.43,217.01 v1(227.43,218.27)
SL17_VI100_30_A_HF: length 8.4
  TOP w0.305: SITE7.23_F 232.52,208.74 232.97,209.19
  TOP w0.635: v1(239.27,211.67) 237.57,209.97 233.75,209.97 232.97,209.19
SL17_VI100_30_A_HS: length 14.9
  BOTTOM w0.203: v2(231.65,208.74) 234.31,208.74 236.27,210.7 236.59,210.7 237.12,211.23 237.12,212.36 237.43,212.67 242.85,212.67 v1(243.84,211.67)
SL17_VI100_30_B_HS: length 9.2
  BOTTOM w0.203: v2(229.3,205.39) 229.3,204.72 234.07,199.95 v1(234.07,198.18)
SL17_VI100_31_A_HF: length 10
  TOP w0.305: SITE7.24_F 232.05,209.58 232.28,209.81
  TOP w0.635: 232.28,209.81 233.39,210.92 235.98,210.92 236.98,211.92 236.98,212.77 237.62,213.41 238.47,213.41 v1(239.27,214.21)
SL17_VI100_31_A_HS: length 17.3
  BOTTOM w0.203: v2(231.65,209.24) 234.18,209.24 236.08,211.15 236.46,211.15 236.72,211.4 236.72,215.08 236.97,215.34 242.72,215.34 v1(243.84,214.21)
SL17_VI100_31_B_HS: length 13.9
  BOTTOM w0.203: v1(231.91,193.35) 231.91,193.85 231.51,194.25 230.57,194.25 230.36,194.46 230.36,200.61 228.8,202.17 v2(228.8,205.39)
SL17_VI100_32_A_HF: length 0.4
  TOP w0.305: SITE7.28_F v2(229.8,210.39)
SL17_VI100_32_A_HS: length 4.1
  BOTTOM w0.152: 230.25,210.97 230.14,210.86 230.14,210.08 229.8,209.74 v2(229.8,209.59)
  BOTTOM w0.203: v1(232.25,212.18) 231.28,211.2 230.49,211.2 230.25,210.97
SL17_VI100_32_B_HS: length 7.8
  BOTTOM w0.203: v1(229.12,198.18) 229.12,200.08 227.8,201.39 v2(227.8,205.39)
SL18_VI100_2_A_HF: length 11.5
  TOP w0.305: SITE6.2_F 186.18,208.74
  TOP w0.635: 186.18,208.74 180.98,208.74 v1(180.83,208.59)
  BOTTOM w0.635: UNK6C49.2 176.82,207.59 179.83,207.59 v1(180.83,208.59)
SL18_VI100_2_A_HS: length 29.3
  L26_VI w0.254: SLOT18.C33 319.81,50.69 320.07,50.96 320.68,50.96 321.33,51.6 321.68,51.6 322.32,50.96 322.93,50.96 323.58,51.6 323.93,51.6 324.57,50.96 325.61,50.96 326.93,49.63 326.93,48.99 327.6,48.32 328.08,48.32
  L26_VI w0.635: 338.1,48.32 335.83,48.32 328.08,48.32
  BOTTOM w0.203: v1(180.83,205.79) 181.97,205.79 184.92,208.74 v2(187.45,208.74)
SL18_VI100_2_B_HF: length 36.2
  TOP w0.305: 189.94,211.84 189.31,211.21 189.31,211.02 189.29,211 189.29,210.58 189.31,210.56 189.31,210.3 189.3,210.29 SITE6.29_F
  TOP w0.635: 189.94,211.84 191.49,213.39 191.49,217.25 v1(192.25,218.02)
  L26_VI w0.254: 328.08,47.18 327.6,47.18 327.29,47.49 327.29,47.87 326.93,48.22 326.93,48.49 326.58,48.85 326.58,49.32 325.46,50.43 324.57,50.43 324.1,49.96 323.45,49.96 323.16,50.25 322.98,50.43 322.28,50.43 321.81,49.96 321.2,49.96 320.57,50.59 320.23,50.59 319.7,50.06 319.66,50.06 319.56,49.96 318.95,49.96 317.95,50.96 317.82,50.96 317.35,51.43 316.7,51.43 315.96,50.69 SLOT18.E33
  L26_VI w0.635: 337.62,47.18 335.36,47.18 328.08,47.18
SL18_VI100_2_B_HS: length 342.5
  L26_VI w0.254: SLOT18.C58 320.64,75.96 321.81,75.96 322.21,76.35 322.25,76.35 322.5,76.6 322.8,76.6 323.45,75.96 324.06,75.96 325.06,76.96 325.18,76.96 325.22,76.99 326.13,76.99 327.57,75.55 328.05,75.55
  L26_VI w0.635: 328.05,75.55 331.68,75.55 346.9,90.77 346.9,195.93 308.13,234.69 263.83,234.69 261.72,236.8 261.72,238.24 261.28,238.68 260.66,238.68 259.48,237.5 243.85,237.5 237.3,230.95 236.27,230.95 236.24,230.99 236.24,231.61 235.8,232.05 235.18,232.05 234.08,230.95 232.4,230.95 231.84,231.51 231.26,231.51 230.72,232.05 230.1,232.05 229.66,231.61 229.66,230.89 229.36,230.59 228.95,230.59 228.92,230.56 225.99,230.56 220.58,235.96 216.28,235.96 212.96,232.65 212.96,232.54 212.22,231.8 203.24,231.8 200.15,228.71 200.15,227.17 198.13,225.15 196.47,225.15 196.39,225.23 195.76,225.23 195.33,224.79 195.33,223.97 194.69,223.34 192.84,223.34 192.4,222.9 192.4,222.74 v1(192.25,222.59)
  BOTTOM w0.203: v2(189.3,209.59) 189.21,209.68 189.21,210.84 191.38,213.02 191.38,221.72 v1(192.25,222.59)
SL18_VI100_3_A_HF: length 40
  TOP w0.305: SITE6.5_F 185.45,207.24
  TOP w0.635: v1(180.83,201.22) 183.13,203.52 183.13,204.92 185.45,207.24
  L26_VI w0.254: SLOT18.D31 317.26,48.69 317.53,48.96 318.43,48.96 318.97,49.49 319.54,49.49 320.07,48.96 320.68,48.96 321.22,49.49 321.26,49.49 321.37,49.6 321.68,49.6 322.32,48.96 322.93,48.96 323.43,49.45 323.78,49.45 323.81,49.43 324.1,49.43 324.57,48.96 325.96,48.96 326.58,48.34 326.58,48.08 326.93,47.72 326.93,46.71 327.6,46.04 328.08,46.04
  L26_VI w0.635: 328.08,46.04 334.88,46.04 337.15,46.04
  BOTTOM w0.635: v1(180.83,201.22) 180.83,200.93 180.19,200.3 175.75,200.3 175.11,200.93 v1(175.11,201.22)
SL18_VI100_3_A_HS: length 34.4
  L26_VI w0.254: SLOT18.C31 319.83,48.69 319.93,48.6 320.55,48.6 321.2,47.96 321.81,47.96 322.45,48.6 322.76,48.6 322.89,48.48 322.93,48.48 323.45,47.96 324.06,47.96 324.12,48.02 324.16,48.02 324.57,48.43 325.99,48.43 326.22,48.19 326.22,47.93 326.58,47.57 326.58,46.56 326.93,46.2 326.93,45.56 327.6,44.89 328.08,44.89
  L26_VI w0.635: 328.08,44.89 334.41,44.89 336.68,44.89
  BOTTOM w0.203: v2(187.45,207.24) 186.97,207.24 182.62,202.89 177.13,202.89 v1(176.26,203.76)
SL18_VI100_3_B_HS: length 13
  BOTTOM w0.203: v2(188.3,205.39) 188.3,201.78 189.86,200.22 189.86,194.09 v1(189.12,193.35)
SL18_VI100_4_A_HS: length 28.4
  L26_VI w0.254: 328.08,43.75 327.6,43.75 326.93,44.42 326.93,45.06 326.58,45.42 326.58,46.06 326.22,46.41 326.22,46.7 325.97,46.96 324.57,46.96 324.1,47.43 323.45,47.43 322.98,46.96 322.32,46.96 321.85,47.43 321.2,47.43 320.73,46.96 319.52,46.96 SLOT18.C29
  L26_VI w0.635: 336.2,43.75 333.94,43.75 328.08,43.75
  BOTTOM w0.203: v1(180.83,203.76) 181.84,203.76 185.82,207.74 v2(187.45,207.74)
SL18_VI100_4_B_HS: length 424.8
  L26_VI w0.254: 328.08,70.16 327.6,70.16 327.6,70.17 325.45,70.17 325.18,70.43 324.57,70.43 324.31,70.17 324.27,70.17 324.06,69.96 323.45,69.96 323.24,70.17 323.2,70.17 322.93,70.43 322.32,70.43 322.06,70.17 322.02,70.17 321.81,69.96 321.2,69.96 320.77,70.39 320.77,71.31 SLOT18.C54
  L26_VI w0.635: 328.08,70.16 329.02,70.16 329.12,70.26 332.25,70.26 332.44,70.45 332.58,70.45 350.56,88.43 350.56,197.12 304.6,243.07 289.93,243.07 283.46,249.54 277.16,249.54 276.74,249.12 269.95,249.12 269.53,249.54 268.91,249.54 268.49,249.12 268.23,249.12 266.81,250.54 266.81,251.91 266.12,252.6 265.75,252.6 265.31,253.04 265.31,255.64 260.85,260.1 240.39,260.1 237.22,256.93 237.22,254.26 237.06,254.1 236.16,254.1 233.92,251.86 233.92,249.88 233.46,249.42 229.65,249.42 229.53,249.54 228.91,249.54 228.78,249.42 224.7,249.42 224.57,249.54 223.95,249.54 223.83,249.42 213.95,249.42 213.92,249.37 213.67,249.12 213.38,248.93 213.06,248.8 212.72,248.73 206.38,248.73 206.04,248.8 205.72,248.93 205.43,249.12 205.01,249.54 197.16,249.54 197.04,249.42 195.16,249.42 193.05,247.3 193.05,241.8 193.83,241.02 193.83,240.48 193.05,239.7 193.05,238.14 192.51,237.6 191.19,237.6 184.67,231.08 184.67,205.96 187.03,203.6 202.01,203.6 v1(203.84,201.77)
  BOTTOM w0.203: v1(203.84,201.77) 202.19,203.42 193.97,203.42 v2(191.65,205.74)
SL18_VI100_5_A_HF: length 47.1
  TOP w0.305: SITE6.6_F 186.47,206.74 186.18,206.45
  TOP w0.635: 186.18,206.45 184.16,204.43 v1(184.16,198.18)
  L26_VI w0.254: SLOT18.D27 318.21,44.69 318.84,44.07 318.95,43.96 319.56,43.96 320.56,44.96 320.68,44.96 321.33,45.6 321.68,45.6 322.32,44.96 322.93,44.96 323.58,45.6 323.93,45.6 324.57,44.96 325.4,44.96 325.87,44.49 325.87,43.2 327.6,41.47 328.08,41.47
  L26_VI w0.635: 337,41.47 328.08,41.47
  BOTTOM w0.508: 184.38,193.35 UNK6K12.4
  BOTTOM w0.635: 184.21,187.38 184.45,187.38 185.18,188.1 185.18,193.35 ; 185.18,193.35 185.18,197.54 184.54,198.18 v1(184.16,198.18) ; 185.18,193.35 184.38,193.35
SL18_VI100_5_A_HS: length 19.2
  L26_VI w0.254: 328.08,42.61 327.6,42.61 326.22,43.99 326.22,45.54 325.16,46.6 324.7,46.6 324.06,45.96 323.45,45.96 322.8,46.6 322.45,46.6 321.81,45.96 321.2,45.96 320.55,46.6 320.25,46.6 319.25,45.61 SLOT18.C27
  L26_VI w0.635: 333.46,42.61 328.08,42.61
  vias: v2(187.45,206.74)
SL18_VI100_6_A_HF: length 23.7
  L26_VI w0.254: SLOT18.D25 318.21,42.69 319.12,41.79 319.43,41.79 320.25,42.6 320.55,42.6 321.2,41.96 321.81,41.96 322.24,42.39 322.24,42.5 322.39,42.64 322.76,42.64 323.45,41.96 324.06,41.96 324.7,42.6 325.01,42.6 325.62,42 325.62,41.52 326.93,40.2 326.93,39.85 327.6,39.18 328.08,39.18
  L26_VI w0.635: 328.08,39.18 329.02,39.18 329.08,39.12 333.51,39.12 333.58,39.05 333.88,39.05 334.23,38.7 336.16,38.7 336.26,38.8 336.68,38.8
  vias: v2(187.05,206.24)
SL18_VI100_6_A_HS: length 23
  L26_VI w0.254: 328.08,40.32 327.6,40.32 326.93,40.99 326.93,41.63 325.61,42.96 324.57,42.96 323.57,43.96 323.45,43.96 322.8,44.6 322.45,44.6 321.81,43.96 321.68,43.96 320.68,42.96 319.52,42.96 SLOT18.C25
  L26_VI w0.635: 339.18,39.94 336.44,39.94 336.12,40.26 329.56,40.26 329.5,40.32 328.08,40.32
  vias: v1(186.96,193.35) v2(187.45,206.24)
SL18_VI100_6_B_HF: length 122
  TOP w0.305: SITE6.30_F v2(188.8,211.66)
  L24_VI w0.254: 309.9,46.88 311.23,46.88 312.16,45.96 312.81,45.96 313.1,46.25 313.28,46.43 313.93,46.43 314.37,46 314.37,45.39 314.02,45.04 314.02,44.39 314.75,43.65 SLOT18.E25 ; 276.97,81.02 278.33,79.66 278.33,76.18 278.32,76.16 278.32,75.39 279.19,74.52 279.19,72.67 279.46,72.4
  L24_VI w0.635: 309.9,46.88 304.97,46.88 279.46,72.4 ; 269.72,138.66 269.72,88.27 276.97,81.02
SL18_VI100_6_B_HS: length 367.1
  L26_VI w0.254: SLOT18.C50 321.55,67.69 322.24,67 322.24,66.39 321.81,65.96 321.68,65.96 320.68,64.96 320.07,64.96 319.07,65.96 318.95,65.96 318.52,66.39 318.52,67.04 318.87,67.39 318.87,68.04 318.52,68.39 318.52,69 318.95,69.43 318.95,69.96 318.52,70.39 318.52,71.04 318.87,71.39 318.87,72.04 318.52,72.39 318.52,73 319.48,73.96 319.6,73.96 320.07,74.43 320.68,74.43 321.16,73.96 321.81,73.96 322.46,74.6 322.76,74.6 323,74.36 323.04,74.36 323.45,73.96 324.06,73.96 324.46,74.36 324.51,74.36 324.57,74.43 325.18,74.43 325.25,74.36 327,74.36 328.05,73.31
  L26_VI w0.635: 328.05,73.31 331.62,73.31 348.27,89.96 348.27,196.17 306.84,237.6 271.19,237.6 270.94,237.36 264.22,237.36 261.75,239.83 260.19,239.83 259.85,239.49 258.4,239.49 257.41,240.48 256.3,240.48 255.52,239.7 254.99,239.7 254.21,240.48 253.1,240.48 252.32,239.7 243.97,239.7 243.19,240.48 241.76,240.48 240.77,239.49 240.77,238.6 239.99,237.82 238.88,237.82 238.56,238.14 235.25,238.14 234.93,237.82 233.83,237.82 233.05,238.6 232.51,238.6 231.73,237.82 228.23,237.82 227.47,238.58 227.47,239.2 227.17,239.49 219.08,239.49 217.41,237.82 203.65,237.82 198.8,232.97 198.8,231.1 198.17,230.47 196.12,230.47 191.91,226.26 191.91,225.58 191.19,224.86 189.53,224.86 189.09,224.42 189.09,223.8 189.99,222.9 189.99,220.98 190.19,220.78 190.19,220.25 190.59,219.85 190.59,217.82 190.19,217.42 190.19,217.37 189.99,217.17 189.99,215.14 190.19,214.94 190.19,214.21 189.99,214.01 189.99,213.85 UNK6K46.4
  BOTTOM w0.203: v2(188.8,209.59) 188.8,211.01 189.84,212.05 UNK6K46.4
SL18_VI100_7_A_HF: length 21.7
  L26_VI w0.254: 328.08,36.89 327.6,36.89 326.58,37.92 326.58,39.2 325.82,39.96 325.66,39.96 325.18,40.43 324.57,40.43 324.1,39.96 323.45,39.96 322.8,40.6 322.45,40.6 321.81,39.96 321.2,39.96 320.55,40.6 320.2,40.6 319.56,39.96 318.95,39.96 318.21,40.69 SLOT18.D23
  L26_VI w0.635: 328.08,36.89 328.14,36.83 332.56,36.83 332.63,36.76 332.94,36.76 333.29,36.42 334.7,36.42
  vias: v2(189.8,204.99)
SL18_VI100_7_A_HS: length 18.6
  L26_VI w0.254: SLOT18.C23 319.52,40.96 320.68,40.96 321.1,41.37 321.14,41.37 321.2,41.43 321.85,41.43 322.32,40.96 322.98,40.96 323.45,41.43 324.1,41.43 324.28,41.25 324.29,41.25 324.57,40.96 325.32,40.96 326.93,39.35 326.93,38.71 327.6,38.04 328.08,38.04
  L26_VI w0.635: 335.17,37.56 333.76,37.56 333.41,37.91 333.1,37.91 333.04,37.98 328.61,37.98 328.55,38.04 328.08,38.04
  vias: v1(194.07,193.35) v2(189.8,205.39)
SL18_VI100_7_B_HF: length 147.7
  TOP w0.305: SITE6.31_F 188.3,210.29 188.29,210.3 188.29,210.82 188.07,211.04
  TOP w0.635: v1(189.84,219.54) 189.08,218.78 189.08,213.58 188.07,212.57 188.07,211.04
  L24_VI w0.254: 264.67,81.02 264.67,80.84 264.47,80.64 264.47,80.55 263.76,79.85 263.76,79.26 263.51,79 263.51,78.39 263.94,77.96 264.19,77.96 264.63,77.51 264.63,77.39 265.06,76.96 265.67,76.96 266.32,77.6 266.79,77.6 266.88,77.51 266.88,77.39 267.31,76.96 267.44,76.96 268.44,75.96 269.05,75.96 269.52,76.43 270.17,76.43 270.65,75.96 271.3,75.96 271.77,76.43 272.42,76.43 272.9,75.96 273.55,75.96 274.02,76.43 274.67,76.43 275.19,75.92 275.19,75.43 274.76,75 274.76,74.39 275.19,73.96 275.19,73.43 274.76,73 274.76,72.39 275.19,71.96 275.19,71.43 274.76,71 274.76,70.39 275.19,69.96 275.31,69.96 276.31,68.96 277.6,68.96 278.05,68.51 278.05,65.98 279.46,64.56 ; SLOT18.E23 313.55,40.69 312.81,39.96 312.16,39.96 311.16,40.96 311.07,40.96 310.37,41.66 309.9,41.66
  L24_VI w0.635: 309.9,41.66 302.36,41.66 279.46,64.56 ; 264.67,139.81 264.67,81.02
SL18_VI100_7_B_HS: length 166.3
  L26_VI w0.254: 327.44,63.34 326.93,63.85 326.93,64.33 326.3,64.96 324.53,64.96 323.53,65.96 323.45,65.96 322.9,66.51 322.36,66.51 321.81,65.96 321.2,65.96 321,66.16 320.85,66.16 SLOT18.C48
  L26_VI w0.635: 352.22,190.45 352.22,80.39 350.79,78.97 350.79,78.79 335.47,63.47 327.57,63.47 327.44,63.34
  BOTTOM w0.203: v1(189.84,224.11) 189.05,223.33 189.05,212.6 188.3,211.84 v2(188.3,209.59)
SL18_VI100_8_A_HF: length 22.9
  L26_VI w0.254: SLOT18.D21 317.1,38.6 318.3,38.6 319.34,37.56 319.47,37.56 320.07,36.96 320.68,36.96 321.29,37.56 321.72,37.56 322.32,36.96 322.45,36.96 323.45,35.96 324.06,35.96 324.7,36.6 325.02,36.6 326.93,34.69 326.93,34.07 327.6,33.4 328.08,33.4
  L26_VI w0.635: 328.08,33.4 331.14,33.4 331.21,33.34 331.52,33.34 334.9,29.96
SL18_VI100_8_A_HS: length 23.6
  L26_VI w0.254: SLOT18.C21 319.35,38.6 320.55,38.6 321.2,37.96 321.81,37.96 322.45,38.6 322.81,38.6 323.45,37.96 323.57,37.96 324.57,36.96 325.17,36.96 327.58,34.55 328.08,34.55
  L26_VI w0.635: 338.05,28.42 331.99,34.48 331.68,34.48 331.62,34.55 328.08,34.55
SL18_VI100_8_B_HF: length 33.9
  TOP w0.305: SITE6.20_F 194.73,207.24 195.04,206.93
  TOP w0.635: v1(196.03,205.94) 195.04,206.93
  L26_VI w0.254: SLOT18.E21 315.92,38.69 317,39.78 317.82,38.96 318.43,38.96 319.08,39.6 319.43,39.6 320.07,38.96 320.68,38.96 321.33,39.6 321.68,39.6 322.32,38.96 322.93,38.96 323.58,39.6 323.93,39.6 324.57,38.96 324.97,38.96 326.93,37 326.93,36.42 327.66,35.69 328.08,35.69
  L26_VI w0.635: 337.02,31.07 332.46,35.62 332.16,35.62 332.09,35.69 328.08,35.69
  BOTTOM w0.635: v1(196.03,205.94) UNK6C61.2
SL18_VI100_8_B_HS: length 169.7
  L26_VI w0.254: SLOT18.C46 321.55,63.69 322.28,64.43 322.98,64.43 323.45,63.96 324.1,63.96 324.57,64.43 325.45,64.43 326.93,62.95 326.93,62.71 327.44,62.2
  L26_VI w0.635: 327.44,62.2 327.57,62.32 335.94,62.32 353.36,79.74 353.36,189.98
  BOTTOM w0.203: v2(191.65,207.24) 194.53,207.24 194.7,207.06 206.93,207.06 v1(208.42,205.58)
SL18_VI100_9_A_HF: length 27.4
  L26_VI w0.254: SLOT18.D39 317.53,56.16 317.53,56.14 317.39,56 317.39,55.39 317.82,54.96 318.43,54.96 319.08,55.6 319.43,55.6 320.07,54.96 320.68,54.96 321.16,55.43 321.85,55.43 322.32,54.96 322.76,54.96 323.02,54.7 323.02,54.39 323.45,53.96 324.06,53.96 324.7,54.6 325.01,54.6 326.93,52.68 326.93,52.42 327.6,51.75 328.08,51.75
  L26_VI w0.635: 339.92,51.75 337.25,51.75 328.08,51.75
SL18_VI100_9_A_HS: length 22.4
  L26_VI w0.254: SLOT18.C39 319.72,57.16 319.87,57.16 320.07,56.96 320.68,56.96 321.32,57.6 321.65,57.6 321.81,57.43 321.85,57.43 322.32,56.96 322.93,56.96 323.58,57.6 323.93,57.6 324.57,56.96 324.99,56.96 326.93,55.01 326.93,54.71 327.6,54.04 328.08,54.04
  L26_VI w0.635: 338.97,54.04 338.2,54.04 328.08,54.04
SL18_VI100_9_B_HF: length 37.4
  TOP w0.305: SITE6.21_F 194.03,207.74 194.28,207.99
  TOP w0.635: 194.28,207.99 198.64,207.99 v1(199.27,208.62)
  L26_VI w0.254: 328.08,50.61 327.6,50.61 326.93,51.28 326.93,51.45 325.43,52.96 324.57,52.96 323.93,53.6 323.58,53.6 322.93,52.96 322.32,52.96 321.32,53.96 321.2,53.96 320.73,54.43 320.03,54.43 319.56,53.96 318.95,53.96 318.3,54.6 317.95,54.6 317.31,53.96 316.7,53.96 316.27,54.39 316.27,55.04 316.62,55.39 316.62,56 316.27,56.35 316.27,56.44 316.01,56.69 SLOT18.E39
  L26_VI w0.635: 328.08,50.61 336.78,50.61 339.04,50.61
SL18_VI100_9_B_HS: length 43.8
  L26_VI w0.254: 328.08,49.47 327.6,49.47 326.93,50.14 326.93,50.78 326.58,51.13 326.58,51.2 325.35,52.43 324.53,52.43 324.06,51.96 323.45,51.96 322.8,52.6 322.45,52.6 321.81,51.96 321.2,51.96 320.77,52.39 320.77,52.7 320.51,52.96 320.07,52.96 319.6,53.43 318.95,53.43 318.48,52.96 317.82,52.96 317.35,53.43 316.7,53.43 316.23,52.96 315.57,52.96 314.57,53.96 314.45,53.96 313.71,54.69 SLOT18.F37
  L26_VI w0.635: 338.57,49.47 336.31,49.47 336.3,49.47 328.08,49.47
  BOTTOM w0.203: v2(191.65,207.74) 194.58,207.74 196.34,209.49 202.97,209.49 v1(203.84,208.62)
SL18_VI100_10_A_HF: length 31.9
  TOP w0.305: 191.98,204.74 191.55,204.74 SITE6.16_F
  TOP w0.635: 191.98,204.74 196.72,200.01 196.72,198.83 v1(197.37,198.18)
  L26_VI w0.254: SLOT18.D17 317,33.78 317.82,32.96 317.95,32.96 318.99,31.91 319.12,31.91 320.07,30.96 320.2,30.96 321.2,29.96 321.81,29.96 322.45,30.6 322.8,30.6 323.45,29.96 324.06,29.96 324.7,30.6 325.33,30.6 326.93,29 326.93,28.36 327.67,27.62 328.08,27.62
  L26_VI w0.635: 332.89,23.88 329.15,27.62 328.08,27.62
SL18_VI100_10_A_HS: length 35.3
  L26_VI w0.254: SLOT18.C17 319.25,33.78 320.07,32.96 320.68,32.96 321.33,33.6 321.8,33.6 321.89,33.51 321.89,33.39 322.32,32.96 322.45,32.96 323.45,31.96 324.06,31.96 324.7,32.6 325.62,32.6 326.93,31.28 326.93,30.64 327.6,29.98 328.08,29.98
  L26_VI w0.635: 328.08,29.98 329.72,29.98 329.79,29.91 330.1,29.91 333.78,26.22
  BOTTOM w0.203: v1(197.37,193.35) 197.37,194.05 197.17,194.25 196.08,194.25 195.83,194.51 195.83,200.6 191.3,205.13 v2(191.3,205.39)
SL18_VI100_10_B_HF: length 38.5
  TOP w0.305: SITE6.25_F v2(191.3,210.39)
  L26_VI w0.254: SLOT18.E17 314.75,35.65 315.95,36.85 316.12,36.85 316.7,37.43 317.31,37.43 317.89,36.85 318.06,36.85 318.95,35.96 319.6,35.96 320.07,36.43 320.68,36.43 321.12,36 321.12,35.99 321.15,35.96 321.15,35.38 320.77,35 320.77,34.39 321.2,33.96 321.81,33.96 322.45,34.6 322.8,34.6 323.45,33.96 323.57,33.96 324.57,32.96 326.4,32.96 326.93,32.43 326.93,31.79 327.6,31.12 328.08,31.12
  L26_VI w0.635: 328.08,31.12 330.19,31.12 330.26,31.05 330.57,31.05 341.31,20.31
SL18_VI100_10_B_HS: length 163.8
  L26_VI w0.254: 327.44,58.77 326.93,59.28 326.93,59.42 325.4,60.96 324.57,60.96 323.84,61.69 323.67,61.69 322.93,62.43 322.32,62.43 321.59,61.69 SLOT18.C44
  L26_VI w0.635: 356.79,189.98 356.79,78.32 337.36,58.89 327.57,58.89 327.44,58.77
  BOTTOM w0.203: v2(191.3,209.59) 191.36,209.65 193.95,209.65 195.17,210.87 v1(195.17,212.18)
SL18_VI100_11_A_HF: length 30.5
  TOP w0.305: SITE6.18_F 193.05,206.24 193.62,205.67
  TOP w0.635: 193.62,205.67 196.62,202.67 v1(197.73,202.67)
  L26_VI w0.254: SLOT18.D15 317,31.74 318.31,30.43 318.43,30.43 318.87,30 318.87,29.87 318.9,29.84 318.9,29.38 318.52,29 318.52,28.39 318.95,27.96 319.07,27.96 320.07,26.96 320.68,26.96 321.33,27.6 321.68,27.6 322.32,26.96 322.93,26.96 323.45,27.47 324.06,27.47 324.57,26.96 326.13,26.96 326.58,26.51 326.58,25.92 326.93,25.57 326.93,24.87 328.08,23.73 328.08,23.61
  L26_VI w0.635: 328.08,23.61 328.79,22.9 329.02,22.9 331.47,20.45
SL18_VI100_11_A_HS: length 36.6
  L26_VI w0.254: SLOT18.C15 319.38,32.82 319.71,32.82 319.93,32.6 320.55,32.6 321.2,31.96 321.64,31.96 321.89,31.7 321.89,31.39 322.32,30.96 322.93,30.96 323.58,31.6 323.93,31.6 324.57,30.96 325.48,30.96 327.6,28.83 328.08,28.83
  L26_VI w0.635: 328.08,28.83 329.25,28.83 329.32,28.76 329.62,28.76 333.31,25.08
  BOTTOM w0.203: v1(208.42,201.77) 206.28,203.91 194.3,203.91 191.97,206.24 v2(191.65,206.24)
SL18_VI100_11_B_HF: length 164.7
  TOP w0.305: SITE6.26_F v2(190.8,210.39)
  L24_VI w0.254: 261.29,53.34 261.76,53.34 262.38,52.72 262.38,51.39 262.81,50.96 262.94,50.96 263.94,49.96 264.06,49.96 265.06,48.96 265.19,48.96 266.19,47.96 266.27,47.96 267.8,46.43 267.92,46.43 268.92,45.43 269.05,45.43 270.05,44.43 270.17,44.43 271.17,43.43 271.3,43.43 271.77,42.96 272.42,42.96 272.9,43.43 273.55,43.43 274.02,42.96 274.19,42.96 275.19,41.96 275.31,41.96 276.31,40.96 276.46,40.96 277.71,39.71 277.8,39.71 279.46,38.05 ; SLOT18.E15 314.75,32.16 314.37,31.77 314.37,31.39 313.93,30.96 313.79,30.96 313.24,30.4 313.24,30.39 312.91,30.06 312.91,30.02 312.89,30 312.89,29.35 313.24,29 313.24,28.39 312.89,28.04 312.89,27.35 313.24,27 313.24,26.39 312.89,26.04 312.89,25.35 313.24,25 313.24,24.39 312.89,24.04 312.89,23.35 313.24,23 313.24,22.35 312.89,22 312.89,21.35 313.81,20.43 313.93,20.43 314.57,19.79 314.93,19.79 315.57,20.43 316.18,20.43 316.82,19.79 317.18,19.79 317.82,20.43 318.43,20.43 318.59,20.27 318.64,20.27 318.95,19.96 319.56,19.96 319.87,20.27 319.91,20.27 320.07,20.43 320.68,20.43 320.84,20.27 320.89,20.27 321.2,19.96 321.28,19.96 322.24,19 322.24,17.57 322.46,17.36 322.46,17.32 322.7,17.07 322.7,16.96
  L24_VI w0.635: 242.93,101.38 242.93,71.23 260.81,53.34 261.29,53.34 ; 279.46,38.05 280.13,37.37 281.54,37.37 305.15,13.77 320.74,13.77 322.7,15.73 322.7,16.96
SL18_VI100_11_B_HS: length 170.9
  L26_VI w0.254: 327.44,57.63 325.62,59.45 325.62,60 325.18,60.43 325.01,60.43 324.99,60.45 324.56,60.45 324.06,59.96 323.45,59.96 322.82,60.58 322.44,60.58 321.81,59.96 320.64,59.96 SLOT18.C42
  L26_VI w0.635: 327.44,57.63 327.57,57.75 337.84,57.75 357.93,77.85 357.93,189.98
  BOTTOM w0.203: v1(195.17,216.75) 194.43,216 194.43,210.7 193.88,210.16 191.7,210.16 191.57,210.03 191.16,210.03 190.8,209.67 v2(190.8,209.59)
SL18_VI100_12_A_HF: length 161
  TOP w0.305: 194.3,206.19 194.13,206.19 193.59,206.74 SITE6.19_F
  TOP w0.635: 194.3,206.19 195.57,204.92 198.62,204.92 v1(199.27,205.58)
  L24_VI w0.254: 261.29,74.66 262.38,73.57 262.38,73.39 262.81,72.96 262.94,72.96 263.94,71.96 264.55,71.96 264.58,71.99 265.02,72.43 265.67,72.43 266.25,71.86 266.74,71.86 267.31,72.43 267.92,72.43 268.5,71.86 268.99,71.86 269.56,72.43 270.17,72.43 270.61,72 270.61,71.35 270.26,71 270.26,70.39 270.69,69.96 270.69,69.43 270.26,69 270.26,68.39 270.69,67.96 270.69,67.43 270.26,67 270.26,66.39 270.69,65.96 270.81,65.96 271.81,64.96 272.42,64.96 273.07,65.6 273.38,65.6 273.98,65 273.98,64.39 273.56,63.97 273.56,63.46 274.06,62.96 274.72,62.96 275.19,63.43 275.8,63.43 276.27,62.96 276.84,62.96 277.69,62.11 277.69,61.9 277.96,61.63 277.96,59.86 278.32,59.5 278.32,58.39 279.46,57.25 ; 309.9,34.43 311.73,34.43 312.2,33.96 312.81,33.96 313.28,34.43 313.98,34.43 314.45,33.96 315.06,33.96 315.53,34.43 316.18,34.43 316.62,34 316.62,33.39 316.27,33.04 316.27,32.39 316.65,32.01 316.65,31.05 SLOT18.D13
  L24_VI w0.635: 279.46,57.25 281.23,55.48 302.04,34.67 309.66,34.67 309.9,34.43 ; 259.89,139.81 259.89,75.76 260.81,74.84 261.11,74.84 261.29,74.66
SL18_VI100_12_A_HS: length 30.8
  L26_VI w0.254: SLOT18.C13 319.25,29.78 320.07,28.96 320.68,28.96 321.16,29.43 321.85,29.43 322.32,28.96 322.98,28.96 323.45,29.43 324.1,29.43 324.57,28.96 325.83,28.96 326.58,28.21 326.58,27.57 327.67,26.48 328.08,26.48
  L26_VI w0.635: 328.08,26.48 328.55,26.48 329.84,25.18 329.97,25.18 332.42,22.73
  BOTTOM w0.203: v2(191.65,206.74) 194.27,206.74 194.43,206.58 202.84,206.58 v1(203.84,205.58)
SL18_VI100_12_B_HF: length 175.9
  TOP w0.305: SITE6.27_F 190.3,210.49 190,210.79 v2(189.8,210.79)
  L24_VI w0.254: 279.46,34.24 278.51,35.19 278.51,36.91 276.82,38.6 276.44,38.6 275.8,37.96 275.19,37.96 274.54,38.6 274.19,38.6 273.55,37.96 272.94,37.96 271.94,38.96 271.81,38.96 270.81,39.96 270.69,39.96 269.69,40.96 269.56,40.96 268.56,41.96 268.44,41.96 267.44,42.96 267.31,42.96 266.31,43.96 266.19,43.96 265.19,44.96 265.06,44.96 264.06,45.96 263.94,45.96 262.94,46.96 262.81,46.96 261.29,48.48 ; 325.79,16.96 325.79,17.47 324.49,18.76 324.49,19 324.06,19.43 324.06,19.96 324.49,20.39 324.49,21 324.06,21.43 323.45,21.43 322.97,20.95 322.29,20.95 321.81,21.43 321.2,21.43 320.73,20.96 320.07,20.96 319.6,21.43 318.95,21.43 318.3,20.79 317.95,20.79 317.31,21.43 316.7,21.43 316.05,20.79 315.62,20.79 315.49,20.92 315.49,21 315.06,21.43 314.93,21.43 314.02,22.35 314.02,23.04 314.37,23.39 314.37,24 314.02,24.35 314.02,25.04 314.37,25.39 314.37,26 314.02,26.35 314.02,27.04 314.37,27.39 314.37,28 314.02,28.35 314.02,29 314.75,29.74 SLOT18.E13
  L24_VI w0.635: 325.79,16.96 325.79,15.68 324.99,14.87 324.99,14.78 321.48,11.28 303.67,11.28 280.71,34.24 279.46,34.24 ; 240.64,102.18 240.64,69.13 261.29,48.48
SL18_VI100_12_B_HS: length 327.2
  L26_VI w0.254: SLOT18.B59 321.77,76.96 322.93,76.96 323.93,77.96 324.06,77.96 324.27,78.16 324.31,78.16 324.57,78.43 325.18,78.43 325.28,78.33 326.41,78.33 328.05,76.69
  L26_VI w0.635: v1(195.17,221.32) 195.17,221.48 195.76,222.07 197.06,222.07 203.61,228.62 217.49,228.62 217.83,228.28 219.03,228.28 219.37,228.62 220.69,228.62 221.03,228.28 228.25,228.28 229.42,229.45 229.83,229.45 230.75,230.37 231.37,230.37 231.93,229.81 243,229.81 243.61,229.19 244.23,229.19 244.85,229.81 248.2,229.81 250.5,232.1 252.53,232.1 255.24,234.82 255.24,235.29 256.17,236.22 256.64,236.22 256.71,236.29 260.61,236.29 265.4,231.51 269.56,231.51 270.1,232.05 273.62,232.05 275.12,230.55 275.8,230.55 276.14,230.89 310.32,230.89 345.55,195.65 345.55,91.46 330.78,76.69 328.05,76.69
  BOTTOM w0.152: 190.71,210.8 190.44,210.53 190.44,209.73 v2(190.3,209.59)
  BOTTOM w0.203: v1(195.17,221.32) 194.05,220.2 194.05,216.2 194.03,216.17 194.03,211.32 193.5,210.8 190.71,210.8
SL18_VI100_13_A_HF: length 163.4
  TOP w0.305: SITE6.22_F 192.44,208.24 192.44,208.25 193.26,208.25 193.66,208.65
  TOP w0.635: v1(197.73,208.86) 197.62,208.98 193.99,208.98 193.66,208.65
  L24_VI w0.254: 309.9,32.96 311.68,32.96 312.16,33.43 312.85,33.43 313.32,32.96 313.93,32.96 314.41,33.43 315.06,33.43 315.49,33 315.49,32.39 315.14,32.04 315.14,31.39 315.57,30.96 315.7,30.96 317,29.65 SLOT18.D11 ; 279.46,55.63 279.15,55.94 279.15,56.21 278.51,56.85 278.51,57.7 277.96,58.24 277.96,59.36 277.61,59.71 277.61,60.55 277.19,60.96 276.93,60.96 276.92,60.96 276.31,60.96 275.31,61.96 275.19,61.96 274.72,62.43 274.02,62.43 273.55,61.96 272.94,61.96 272.51,62.39 272.51,63 272.94,63.43 272.94,63.96 272.29,64.6 271.94,64.6 271.3,63.96 270.69,63.96 269.69,64.96 269.56,64.96 269.13,65.39 269.13,66 269.56,66.43 269.56,66.96 269.13,67.39 269.13,68 269.56,68.43 269.56,68.96 269.13,69.39 269.13,70 269.48,70.35 269.48,71 269.05,71.43 268.44,71.43 267.88,70.87 267.36,70.87 266.8,71.43 266.19,71.43 265.72,70.96 265.02,70.96 264.55,71.43 263.94,71.43 263.47,70.96 262.81,70.96 261.29,72.48
  L24_VI w0.635: 258.75,139.81 258.75,75.29 258.96,75.08 258.96,74.81 261.29,72.48 ; 279.46,55.63 280.91,54.19 301.56,33.53 304.58,33.53 305.15,32.96 309.9,32.96
  BOTTOM w0.635: v1(197.73,208.86) 196.67,208.86 196.03,208.22 UNK6C64.2
SL18_VI100_13_A_HS: length 35.1
  L26_VI w0.254: SLOT18.C11 319.35,28.6 320.55,28.6 321.2,27.96 321.81,27.96 322.45,28.6 322.8,28.6 323.45,27.96 324.06,27.96 324.7,28.6 325.36,28.6 326.22,27.74 326.22,27.42 326.93,26.71 326.93,26.48 328.08,25.33
  L26_VI w0.635: 328.08,25.33 329.37,24.04 329.5,24.04 331.95,21.59
  BOTTOM w0.203: v2(191.65,208.24) 194.45,208.24 196.21,210 207.04,210 v1(208.42,208.62)
SL18_VI100_13_B_HF: length 32.4
  TOP w0.305: SITE6.32_F v2(187.8,210.39)
  L26_VI w0.254: SLOT18.E11 314.75,27.74 315.49,27 315.49,26.39 315.06,25.96 315.06,25.43 315.49,25 315.49,24.39 315.06,23.96 315.06,23.43 316.06,22.43 316.18,22.43 316.83,21.79 317.18,21.79 317.82,22.43 318.43,22.43 319.08,21.79 319.43,21.79 320.07,22.43 320.68,22.43 321.33,21.79 321.68,21.79 322.32,22.43 322.93,22.43 323.58,21.79 323.93,21.79 324.57,22.43 325.18,22.43 325.62,22 325.62,18.81 326.93,17.49 326.93,16.96
  L26_VI w0.635: 326.93,16.96 326.93,16.42 329.65,13.71 332.3,13.71
  vias: v1(187.43,224.11)
SL18_VI100_13_B_HS: length 370.5
  L26_VI w0.254: 328.05,72.17 327.57,72.17 327.25,72.49 320.24,72.49 320.19,72.43 320.07,72.43 319.64,72 319.64,71.39 319.7,71.33 319.7,71.29 319.99,71 319.99,70.39 319.7,70.1 319.7,70.06 319.64,70 319.64,69.39 319.7,69.33 319.7,69.29 319.99,69 319.99,68.39 319.7,68.1 319.7,68.06 319.64,68 319.64,67.39 320.34,66.69 SLOT18.B49
  L26_VI w0.635: 328.05,72.17 332.09,72.17 332.17,72.24 332.76,72.24 349.41,88.9 349.41,196.64 304.9,241.16 283.33,241.16 283.19,241.02 278.88,241.02 278.74,241.16 275.07,241.16 274.93,241.02 270.63,241.02 268.96,242.69 268.96,243.65 268.52,244.09 267.56,244.09 265.01,246.63 263.85,246.63 262.4,248.08 242.08,248.08 240.77,246.77 240.77,241.8 239.99,241.02 238.88,241.02 238.6,241.3 235.21,241.3 234.93,241.02 230.63,241.02 230.49,241.16 217.55,241.16 217.41,241.02 202.69,241.02 202.16,240.48 202.08,240.48 201.3,239.7 201.3,239.63 200.77,239.1 200.77,238.6 199.78,237.6 196.25,237.6 194.18,235.53 194.18,235.13 193.75,234.69 193.35,234.69 193.09,234.44 191.09,234.44 190.65,234 190.65,232.6 189.66,231.61 189.66,231.01 186.29,227.64 186.29,219.41 v1(187.43,218.27)
  BOTTOM w0.203: v1(187.43,218.27) 187.43,217.01 188.59,215.84 188.59,212.71 187.33,211.45 187.33,210.33 187.8,209.86 v2(187.8,209.59)
SL18_VI100_14_A_HF: length 8.4
  TOP w0.305: 192.97,209.19 192.52,208.74 SITE6.23_F
  TOP w0.635: 192.97,209.19 193.75,209.97 197.57,209.97 v1(199.27,211.67)
SL18_VI100_14_A_HS: length 14.9
  BOTTOM w0.203: v2(191.65,208.74) 194.31,208.74 196.27,210.7 196.59,210.7 197.12,211.23 197.12,212.36 197.43,212.67 202.85,212.67 v1(203.84,211.67)
SL18_VI100_14_B_HS: length 161.7
  L26_VI w0.254: 327.44,61.05 327.37,61.13 327.34,61.13 325.51,62.96 324.57,62.96 324.1,63.43 323.45,63.43 323.31,63.29 323.27,63.29 322.93,62.96 321.77,62.96 SLOT18.B45
  L26_VI w0.635: 354.5,189.98 354.5,79.27 336.42,61.18 327.57,61.18 327.44,61.05
  BOTTOM w0.203: v1(194.07,198.18) 194.07,199.95 189.3,204.72 v2(189.3,205.39)
SL18_VI100_15_A_HF: length 33.7
  TOP w0.305: 192.28,209.81 192.05,209.58 SITE6.24_F
  TOP w0.635: v1(199.27,214.21) 198.47,213.41 197.62,213.41 196.98,212.77 196.98,211.92 195.98,210.92 193.39,210.92 192.28,209.81
  L26_VI w0.254: 328.08,21.77 327.92,21.77 326.93,22.75 326.93,24.11 325.62,25.43 325.62,26 325.18,26.43 324.57,26.43 324.1,25.96 323.45,25.96 322.98,26.43 322.32,26.43 321.85,25.96 321.16,25.96 320.68,26.43 320.07,26.43 319.07,25.43 318.95,25.43 318.21,24.69 SLOT18.D7
  L26_VI w0.635: 328.08,21.77 328.09,21.75 328.55,21.75 331.88,18.42 334.8,18.42 334.8,18.42
SL18_VI100_15_A_HS: length 37.8
  L26_VI w0.254: SLOT18.C7 319.35,24.79 320.55,24.79 321.2,25.43 321.81,25.43 322.45,24.79 322.8,24.79 323.45,25.43 324.06,25.43 324.7,24.79 325.33,24.79 325.97,24.15 325.97,23.15 326.68,22.44 326.68,21.48 327.56,20.61 328.08,20.61
  L26_VI w0.635: 328.08,20.61 331.41,17.28 334.33,17.28
  BOTTOM w0.203: v2(191.65,209.24) 194.18,209.24 196.08,211.15 196.46,211.15 196.72,211.4 196.72,215.08 196.97,215.34 202.72,215.34 v1(203.84,214.21)
SL18_VI100_15_B_HS: length 31.5
  L26_VI w0.254: SLOT18.B19 321.5,35.78 322.32,34.96 322.93,34.96 323.58,35.6 323.93,35.6 325.15,34.38 325.48,34.38 327.6,32.26 328.08,32.26
  L26_VI w0.635: 328.08,32.26 330.67,32.26 330.74,32.19 331.04,32.19 334.66,28.57
  BOTTOM w0.203: v2(188.8,205.39) 188.8,202.17 190.36,200.61 190.36,194.46 190.57,194.25 191.51,194.25 191.91,193.85 v1(191.91,193.35)
SL18_VI100_16_A_HF: length 25
  TOP w0.305: SITE6.28_F v2(189.8,210.39)
  L26_VI w0.254: SLOT18.D5 317.1,22.79 318.3,22.79 318.95,23.43 319.07,23.43 320.07,24.43 320.68,24.43 321.33,23.79 321.68,23.79 322.32,24.43 322.93,24.43 323.58,23.79 323.93,23.79 324.57,24.43 325.18,24.43 325.62,24 325.62,23.01 326.33,22.29 326.33,20.86 326.93,20.25 326.93,20.14 326.93,19.95 327.41,19.47 327.6,19.47 328.08,19
  L26_VI w0.635: 334.73,16.14 330.94,16.14 328.08,19
SL18_VI100_16_A_HS: length 23.7
  L26_VI w0.254: 328.08,17.38 327.13,18.33 326.89,18.33 325.97,19.24 325.97,22.15 325.33,22.79 324.7,22.79 324.06,23.43 323.45,23.43 322.8,22.79 322.45,22.79 321.81,23.43 321.2,23.43 320.55,22.79 319.35,22.79 SLOT18.C5
  L26_VI w0.635: 328.08,17.38 330.61,14.85 332.77,14.85
  BOTTOM w0.152: v2(189.8,209.59) 189.8,209.74 190.14,210.08 190.14,210.86 190.25,210.97
  BOTTOM w0.203: v1(192.25,212.18) 191.28,211.2 190.49,211.2 190.25,210.97
SL18_VI100_16_B_HS: length 141.7
  L24_VI w0.254: 279.46,39.91 276.75,42.62 276.61,42.62 275.8,43.43 275.67,43.43 274.67,44.43 274.55,44.43 273.55,45.43 273.42,45.43 272.42,46.43 272.3,46.43 271.3,47.43 271.17,47.43 270.17,48.43 270.05,48.43 269.05,49.43 268.92,49.43 267.92,50.43 267.27,50.43 266.8,49.96 266.19,49.96 265.19,50.96 265.06,50.96 264.06,51.96 263.94,51.96 262.94,52.96 262.81,52.96 261.29,54.48 ; 321.5,16.96 SLOT18.B1
  L24_VI w0.635: 279.46,39.91 280.76,38.61 281.93,38.61 297.3,23.24 305.63,14.92 320.15,14.92 321.5,16.27 321.5,16.96 ; 261.29,54.48 260.74,55.03 260.74,57.49 244.07,74.16 244.07,101.36
  BOTTOM w0.203: v2(187.8,205.39) 187.8,201.39 189.12,200.08 v1(189.12,198.18)
SL18_VI100_18_A_HF: length 11.5
  TOP w0.305: SITE8.2_F 266.18,208.74
  TOP w0.635: 266.18,208.74 260.98,208.74 v1(260.83,208.59)
  BOTTOM w0.635: v1(260.83,208.59) 259.83,207.59 256.82,207.59 UNK8C49.2
SL18_VI100_18_A_HS: length 284.2
  L24_VI w0.254: SLOT18.E58 314.67,75.69 313.93,74.96 313.81,74.96 312.81,73.96 312.68,73.96 311.68,72.96 310.74,72.96 310.38,73.32 309.9,73.32
  L24_VI w0.635: 309.9,73.32 307.82,75.4 307.82,167.98 301.9,173.89 287.34,173.89 279.27,165.82 262.11,165.82 248.44,179.49 248.44,182.83 243.19,188.08 241.58,188.08 237.06,192.6 236.16,192.6 235.51,193.25 235.51,199.06 240.27,203.83 240.27,214.4 236.85,217.82 236.85,222.34 242.71,228.2 249.06,228.2 252.53,231.67 253.09,231.67 255.24,233.83 255.24,235.29 256.56,236.6 260.93,236.6 264.7,232.83 276.08,232.83 277.58,231.34
  BOTTOM w0.203: v1(260.83,205.79) 261.97,205.79 264.92,208.74 v2(267.45,208.74)
SL18_VI100_18_B_HF: length 242.7
  TOP w0.305: 269.94,211.84 269.31,211.21 269.31,211.02 269.29,211 269.29,210.58 269.31,210.56 269.31,210.3 269.3,210.29 SITE8.29_F
  TOP w0.635: v1(272.25,218.02) 271.49,217.25 271.49,213.39 269.94,211.84
  L24_VI w0.254: SLOT18.F57 312.24,74.96 311.07,74.96 310.54,75.49 310.54,81.74 310.35,81.93
  L24_VI w0.635: 310.35,81.93 310.35,171.23 305.31,176.27 286.49,176.27 283.16,172.94 276.17,172.94 275.57,173.55 273.55,173.55 272.95,172.94 268,172.94 259.92,181.02 256.3,181.02 254.99,182.33 254.99,187.3 254.21,188.08 251.72,188.08 250.95,188.86 250.95,189.77 250.86,189.98 250.79,190.32 250.79,190.66 250.86,191 250.95,191.21 250.95,206.03 262.15,217.23 262.15,222.94 265.45,226.24 265.73,226.24 267.43,227.95 267.94,227.95 268.02,228.02 268.64,228.02 268.71,227.95 270.04,227.95 270.17,228.07 271.27,228.07 271.4,227.95 272.11,227.95 273.91,226.15 273.91,219.46 272.46,218.02 v1(272.25,218.02)
SL18_VI100_18_B_HS: length 218.3
  L24_VI w0.254: SLOT18.G58 311.79,76.1 311.79,76.37 311.77,76.39 311.77,77 311.79,77.02 311.79,77.06 312.12,77.39 312.12,78 311.79,78.33 311.79,78.37 311.77,78.39 311.77,79 311.79,79.02 311.79,81.64 311.49,81.93
  L24_VI w0.635: 311.49,81.93 311.49,173.52 306.59,178.42 287.02,178.42 283.3,174.69 267.86,174.69 265.97,176.59 265.97,185.21 264.55,186.63 263.85,186.63 262.51,187.97 262.51,192.09 261.36,193.24 261.36,193.89 261.39,194.01 261.39,196.84 261.36,196.87 261.36,197.49 261.39,197.51 261.39,198.64 262.61,199.86 262.61,200.53 262.99,200.91 262.99,207.34 263.55,207.89 263.55,213.3 263.29,213.55 263.29,216.81 265.5,219.02 268.69,219.02 269.09,219.43 269.09,219.85 269.78,220.54 271.05,220.54 272.25,221.74 v1(272.25,222.59)
  BOTTOM w0.203: v2(269.3,209.59) 269.21,209.68 269.21,210.84 271.38,213.02 271.38,221.72 v1(272.25,222.59)
SL18_VI100_19_A_HF: length 129.5
  TOP w0.305: SITE8.5_F 265.45,207.24
  TOP w0.635: 265.45,207.24 263.13,204.92 263.13,203.52 v1(260.83,201.22)
  L24_VI w0.254: 278.67,81.02 279.46,80.23 279.46,75.69 ; SLOT18.F31 309.9,48.69
  L24_VI w0.635: 278.67,81.02 270.9,88.8 270.9,140.4 ; 279.46,75.69 282.6,72.55 282.6,71.36 305.27,48.69 309.9,48.69
  BOTTOM w0.635: v1(255.11,201.22) 255.11,200.93 255.75,200.3 260.19,200.3 260.83,200.93 v1(260.83,201.22)
SL18_VI100_19_A_HS: length 156
  L26_VI w0.254: SLOT18.E56 314.67,73.69 313.93,72.96 313.81,72.96 312.81,71.96 312.68,71.96 311.68,70.96 311.07,70.96 311,71.03 309.9,71.03
  L26_VI w0.635: 302.01,203.31 309.27,196.06 309.27,71.67 309.9,71.03
  BOTTOM w0.203: v2(267.45,207.24) 266.97,207.24 262.62,202.89 257.13,202.89 v1(256.26,203.76)
SL18_VI100_19_B_HS: length 303.8
  L24_VI w0.254: SLOT18.G56 311.14,73.69 309.9,74.93
  L24_VI w0.635: 309.9,74.93 308.96,75.88 308.96,170.19 304.03,175.13 286.96,175.13 282.38,170.55 275.18,170.55 274.03,171.7 273.31,171.7 272.2,170.58 270.75,170.58 270.72,170.55 267.93,170.55 261.71,176.77 254.15,176.77 249.8,181.12 249.8,189.54 249.76,189.64 249.65,190.2 249.65,190.78 249.76,191.34 249.76,196.05 245.7,200.12 245.28,200.12 244.76,200.64 244.76,207.44 244.84,207.53 244.84,208.03 245.28,208.47 245.79,208.47 250.71,213.4 250.71,214.08 250.77,214.14 250.77,214.76 250.71,214.81 250.71,228.22 252.01,229.51 255.3,229.51 256.17,228.64 260.69,228.64 262.41,230.37 273.69,230.37 276.85,227.2 276.85,210.29 277.54,209.61 278.64,209.61 278.8,209.77 279.74,209.77 280.41,209.1 280.41,208.18 280.27,208.03 280.27,208.01 279.23,206.97 276,206.97 270.13,201.1 270.13,194.37 v1(269.12,193.35)
  BOTTOM w0.203: v2(268.3,205.39) 268.3,201.78 269.86,200.22 269.86,194.09 v1(269.12,193.35)
SL18_VI100_20_A_HS: length 152.3
  L26_VI w0.254: 309.9,69.89 310.38,69.89 310.81,70.32 310.97,70.32 311.07,70.43 311.68,70.43 312.16,69.96 312.81,69.96 313.81,70.96 313.93,70.96 314.67,71.69 SLOT18.E54
  L26_VI w0.635: 301.21,202.51 308.12,195.59 308.12,70.52 308.76,69.89 309.9,69.89
  BOTTOM w0.203: v2(267.45,207.74) 265.82,207.74 261.84,203.76 v1(260.83,203.76)
SL18_VI100_20_B_HS: length 195.7
  L26_VI w0.254: 310.16,62.82 311.55,62.82 312.68,63.96 312.85,63.96 313.52,64.62 313.52,64.76 312.89,65.39 312.89,66 313.32,66.43 313.45,66.43 314.97,67.96 315.06,67.96 316.06,68.96 316.18,68.96 316.62,69.39 316.62,70 316.27,70.35 316.27,71 316.62,71.35 316.62,72 316.27,72.35 316.27,73 316.62,73.35 316.62,74 316.18,74.43 316.06,74.43 315.06,75.43 314.45,75.43 313.45,74.43 313.32,74.43 312.32,73.43 312.2,73.43 311.38,72.61 SLOT18.G54
  L26_VI w0.635: 310.16,62.82 305.21,62.82 301.27,66.77 301.27,192.75 296.43,197.58 287.82,197.58 284.59,200.81 284.59,201.18 284,201.77 v1(283.84,201.77)
  BOTTOM w0.203: v2(271.65,205.74) 273.97,203.42 282.19,203.42 v1(283.84,201.77)
SL18_VI100_21_A_HF: length 145.8
  TOP w0.305: SITE8.6_F 266.47,206.74 266.18,206.45
  TOP w0.635: 266.18,206.45 264.16,204.43 v1(264.16,198.18)
  L24_VI w0.254: 279.46,70.29 279.21,70.54 279.15,70.54 277.96,71.73 277.96,78.06 276.59,79.43 275.19,79.43 274.55,78.8 274.19,78.8 273.55,79.43 272.94,79.43 272.3,78.8 271.93,78.8 270.4,80.33 270.18,80.38 270.13,80.39 268.73,80.39 268.1,81.02 ; SLOT18.F27 312.14,45.06 311.78,45.06 311.68,44.96 311.07,44.96 310.96,45.07 310.55,45.07 309.9,45.72
  L24_VI w0.635: 309.9,45.72 304.04,45.72 279.46,70.29 ; 268.1,81.02 268.1,81.03 268.1,139.43
  BOTTOM w0.508: 264.38,193.35 UNK8K12.4
  BOTTOM w0.635: 265.17,193.35 264.38,193.35 ; 265.17,193.35 265.17,188.1 264.45,187.38 264.21,187.38 ; 265.17,193.35 265.17,197.54 264.54,198.18 v1(264.16,198.18)
SL18_VI100_21_A_HS: length 145.1
  L26_VI w0.254: 309.9,68.74 310.38,68.74 310.46,68.82 311.29,68.82 312.16,67.96 312.81,67.96 313.81,68.96 313.93,68.96 314.67,69.69 SLOT18.E52
  L26_VI w0.635: 300.4,201.7 306.98,195.11 306.98,69.77 308.01,68.74 309.9,68.74
  vias: v2(267.45,206.74)
SL18_VI100_22_A_HF: length 128.1
  L24_VI w0.254: SLOT18.F25 312.5,43.65 311.58,44.57 309.9,44.57 ; 266.95,81.02 266.95,80.55 266.88,80.48 266.88,79.39 267.31,78.96 267.97,78.96 268.51,79.5 269.9,79.5 270.26,79.14 270.26,78.39 270.69,77.96 271.3,77.96 271.78,78.44 272.42,78.44 272.9,77.96 273.55,77.96 274.02,78.43 274.67,78.43 275.15,77.96 275.8,77.96 276.27,78.43 276.92,78.43 277.36,78 277.36,70.78 279.46,68.68
  L24_VI w0.635: 266.95,139.81 266.95,81.02 ; 309.9,44.57 303.56,44.57 279.46,68.68
  vias: v2(267.05,206.24)
SL18_VI100_22_A_HS: length 174.5
  L24_VI w0.254: 314.27,81.93 314.27,81.67 312.89,80.3 312.89,79.39 313.32,78.96 313.93,78.96 314.41,79.43 315.06,79.43 315.49,79 315.49,78.35 315.14,78 315.14,77.39 315.57,76.96 315.66,76.96 316.62,76 316.62,75.39 316.18,74.96 316.18,74.43 316.62,74 316.62,73.39 316.18,72.96 316.18,72.43 316.62,72 316.62,71.39 316.18,70.96 316.18,70.43 316.62,70 316.62,69.39 315.88,68.65 SLOT18.E50
  L24_VI w0.635: v1(266.96,193.35) 267.96,192.35 268.53,192.35 268.97,191.91 268.97,191.17 270.7,189.44 273.58,189.44 277.32,185.7 277.32,182.58 278.88,181.02 280.47,181.02 281.3,180.18 281.3,178.6 282.08,177.82 283.19,177.82 283.97,178.6 283.97,180.18 285.15,181.37 307.45,181.37 314.27,174.55 314.27,81.93
  vias: v2(267.45,206.24)
SL18_VI100_22_B_HF: length 144.3
  TOP w0.305: SITE8.30_F v2(268.8,211.66)
  L26_VI w0.254: 309.9,66.46 310.38,66.46 310.52,66.6 312.41,66.6 SLOT18.F49
  L26_VI w0.635: 298.78,200.08 304.7,194.17 304.7,68.82 307.06,66.46 309.9,66.46
SL18_VI100_22_B_HS: length 145
  L26_VI w0.254: 309.9,67.6 311.29,67.6 SLOT18.G50
  L26_VI w0.635: 309.9,67.6 307.54,67.6 305.84,69.3 305.84,194.64 299.59,200.89
  BOTTOM w0.203: v2(268.8,209.59) 268.8,211.01 269.84,212.05 UNK8K46.4
SL18_VI100_23_A_HF: length 133
  L24_VI w0.254: SLOT18.F23 312.5,41.61 311.15,42.97 309.9,42.97 ; 265.81,81.02 265.81,80.55 265.69,80.43 265.06,80.43 264.63,80 264.63,79.39 265.06,78.96 265.27,78.96 265.76,78.47 265.76,78.39 266.19,77.96 266.8,77.96 267.31,78.47 267.92,78.47 268.44,77.96 268.56,77.96 269.56,76.96 270.17,76.96 270.82,77.6 271.13,77.6 271.77,76.96 272.47,76.96 272.94,77.43 273.55,77.43 274.02,76.96 274.72,76.96 275.19,77.43 275.8,77.43 276.23,77 276.23,76.35 275.88,76 275.88,75.39 276.31,74.96 276.31,74.43 275.88,74 275.88,73.39 276.31,72.96 276.31,72.43 275.88,72 275.88,71.39 276.31,70.96 276.68,70.96 278.4,69.23 278.4,67.46 279.46,66.4
  L24_VI w0.635: 309.9,42.97 302.9,42.97 279.46,66.4 ; 265.81,139.81 265.81,81.02
  vias: v2(269.8,204.99)
SL18_VI100_23_A_HS: length 100.3
  L24_VI w0.254: 309.9,61.89 310.24,61.89 311.05,62.7 311.42,62.7 312.68,63.96 312.81,63.96 313.81,64.96 313.93,64.96 314.67,65.69 SLOT18.E48
  L24_VI w0.635: 290.79,143.64 290.79,139.51 290.95,139.36 290.95,75.52 304.58,61.89 309.9,61.89
  vias: v1(274.07,193.35) v2(269.8,205.39)
SL18_VI100_23_B_HF: length 155.3
  TOP w0.305: 268.07,211.04 268.29,210.82 268.29,210.3 268.3,210.29 SITE8.31_F
  TOP w0.635: v1(269.84,219.54) 269.08,218.78 269.08,213.58 268.07,212.57 268.07,211.04
  L26_VI w0.254: SLOT18.F47 310.9,64.69 310.38,64.17 309.9,64.17
  L26_VI w0.635: 309.9,64.17 305.6,64.17 302.41,67.37 302.41,193.22 297.16,198.46
SL18_VI100_23_B_HS: length 157.6
  L26_VI w0.254: SLOT18.G48 310.76,65.69 310.38,65.32 309.9,65.32
  L26_VI w0.635: 297.97,199.27 303.55,193.69 303.55,68.35 306.59,65.32 309.9,65.32
  BOTTOM w0.203: v2(268.3,209.59) 268.3,211.84 269.05,212.6 269.05,223.33 v1(269.84,224.11)
SL18_VI100_24_A_HF: length 138
  L24_VI w0.254: 263.32,81.02 263.32,80.55 262.76,79.99 262.76,78.38 262.38,78 262.38,77.39 262.81,76.96 262.94,76.96 263.94,75.96 264.55,75.96 265.19,76.6 265.63,76.6 265.76,76.47 265.76,76.39 266.32,75.82 266.45,75.82 267.31,74.96 267.92,74.96 268.57,75.6 268.88,75.6 269.52,74.96 270.22,74.96 270.69,75.43 271.3,75.43 271.77,74.96 272.47,74.96 272.94,75.43 273.55,75.43 273.98,75 273.98,74.35 273.63,74 273.63,73.39 274.06,72.96 274.06,72.43 273.63,72 273.63,71.39 274.06,70.96 274.06,70.43 273.63,70 273.63,69.39 274.06,68.96 274.19,68.96 275.19,67.96 275.8,67.96 276.44,68.6 277.46,68.6 277.69,68.37 277.69,65.46 279.46,63.69 279.46,62.94 ; 309.9,38.69 SLOT18.F21
  L24_VI w0.635: 309.9,38.69 303.7,38.69 279.46,62.94 ; 263.32,139.81 263.32,81.02
SL18_VI100_24_A_HS: length 29.5
  L26_VI w0.254: SLOT18.E46 317.09,63.69 317.82,64.43 318.43,64.43 319.17,63.69 319.3,63.69 319.99,63 319.99,62.79 320.07,62.7 320.07,62.43 319.64,62 319.64,61.39 320.07,60.96 320.07,60.43 319.64,60 319.64,59.39 320.07,58.96 320.68,58.96 321.31,59.58 321.7,59.58 322.32,58.96 322.93,58.96 323.56,59.58 323.95,59.58 324.57,58.96 324.97,58.96 325.14,58.79 325.33,58.79 325.97,58.15 325.97,57.96 327.32,56.61 328.05,56.61
  L26_VI w0.635: 337.69,56.61 328.05,56.61
SL18_VI100_24_B_HF: length 106.1
  TOP w0.305: SITE8.20_F 274.73,207.24 275.04,206.93
  TOP w0.635: v1(276.03,205.94) 275.04,206.93
  L24_VI w0.254: 309.9,59.6 310.24,59.6 311.6,60.96 311.68,60.96 312.5,61.78 SLOT18.F45
  L24_VI w0.635: 288.51,143.05 288.51,138.56 288.66,138.41 288.66,74.57 303.63,59.6 309.9,59.6
  BOTTOM w0.635: v1(276.03,205.94) UNK8C61.2
SL18_VI100_24_B_HS: length 123.5
  L24_VI w0.254: SLOT18.G46 310.72,63.03 309.9,63.03
  L24_VI w0.635: 291.94,157.06 291.94,139.98 292.09,139.83 292.09,76 299.45,68.64 299.52,68.64 305.13,63.03 309.9,63.03
  BOTTOM w0.203: v2(271.65,207.24) 274.53,207.24 274.7,207.06 286.93,207.06 v1(288.42,205.58)
SL18_VI100_25_A_HF: length 110.5
  L24_VI w0.254: 309.9,54.96 311.68,54.96 312.5,55.78 SLOT18.F39
  L24_VI w0.635: 309.9,54.96 309.83,55.03 301.74,55.03 281.79,74.98 281.79,79.73 272.58,88.93 272.58,141.41
SL18_VI100_25_A_HS: length 140.6
  L24_VI w0.254: 322.32,81.93 322.32,81.38 320.64,79.69 SLOT18.C62
  L24_VI w0.635: 322.32,81.93 322.32,174.7 312.31,184.71 284.67,184.71 UNK8K24.5
SL18_VI100_25_B_HF: length 195.3
  TOP w0.305: 274.28,207.99 274.03,207.74 SITE8.21_F
  TOP w0.635: 274.28,207.99 278.64,207.99 v1(279.27,208.62)
  L24_VI w0.254: SLOT18.F61 312.5,79.9 312.31,80.09 312.31,80.99 313.13,81.8 313.13,81.93
  L24_VI w0.635: v1(279.27,208.62) 278.76,208.11 277.42,208.11 276.91,208.62 275.33,208.62 271.47,204.76 270.37,204.76 265.84,200.23 265.84,197.27 265.31,196.74 265.31,187.49 267.12,185.68 267.12,178.69 268.59,177.21 270.8,177.21 271.19,177.6 279.1,177.6 280.03,176.67 283.66,176.67 285.11,178.13 285.11,179.71 285.63,180.22 306.98,180.22 313.13,174.07 313.13,81.93
SL18_VI100_25_B_HS: length 189.3
  L24_VI w0.254: 315.41,81.93 315.41,81.48 SLOT18.F62
  L24_VI w0.635: 315.41,81.93 315.41,175.45 308.11,182.74 284.91,182.74 283.19,181.02 282.08,181.02 281.3,181.8 281.3,187.6 281.94,188.23 287.9,188.23 288.54,188.87 288.54,196.86 284.84,200.56 284.84,201.95 282.87,203.93 280.71,203.93 280.27,204.37 280.27,204.99 282.26,206.97 284.15,206.97 284.59,207.41 284.59,208.03 284,208.62 v1(283.84,208.62)
  BOTTOM w0.203: v2(271.65,207.74) 274.58,207.74 276.34,209.49 282.97,209.49 v1(283.84,208.62)
SL18_VI100_26_A_HF: length 153.1
  TOP w0.305: 271.98,204.74 271.55,204.74 SITE8.16_F
  TOP w0.635: v1(277.37,198.18) 276.72,198.83 276.72,200.01 271.98,204.74
  L24_VI w0.254: 279.46,58.86 278.32,60.01 278.32,61.78 278.05,62.05 278.05,63.34 276.79,64.6 276.44,64.6 275.8,63.96 275.19,63.96 274.76,64.39 274.76,65 275.19,65.43 275.19,65.96 274.54,66.6 274.19,66.6 273.55,65.96 272.94,65.96 271.94,66.96 271.81,66.96 271.38,67.39 271.38,68 271.81,68.43 271.81,68.96 271.38,69.39 271.38,70 271.81,70.43 271.81,70.96 271.38,71.39 271.38,72 271.73,72.35 271.73,73 271.3,73.43 270.69,73.43 270.2,72.94 269.54,72.94 269.05,73.43 268.4,73.43 267.92,72.96 267.31,72.96 266.67,73.6 266.32,73.6 265.67,72.96 265.06,72.96 264.06,73.96 263.94,73.96 263.29,74.6 262.67,74.6 261.29,75.98 ; 309.9,35.81 310.38,35.81 310.99,36.43 311.73,36.43 312.5,35.65 SLOT18.F17
  L24_VI w0.635: 261.04,139.81 261.04,76.23 261.29,75.98 ; 279.46,58.86 302.51,35.81 309.9,35.81
