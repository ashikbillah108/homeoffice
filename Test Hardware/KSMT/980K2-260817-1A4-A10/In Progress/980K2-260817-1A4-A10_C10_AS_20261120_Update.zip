# Allegro board 980K2-260817_261120-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL06_DP_143: length 618.8
  L30_DP w0.079: v1(276.79,168.7) 278.42,170.33 284.81,170.33 301.56,187.08 301.56,286.2 280.97,306.79 120.56,306.79 93.1,279.33 93.1,124.46 160.87,56.69 SLOT06.F39
  BOTTOM w0.203: UNK8R15.1 276.79,167.38 v1(276.79,168.7)
SL06_DP_144: length 187.6
  L30_DP w0.079: SLOT06.A17 179.64,34.69 179.81,34.86 180.48,34.86 180.96,35.34 182.12,35.34 182.57,35.79 200.39,35.79 200.39,35.79 200.86,35.79 212.19,47.12 212.19,111.79 212.19,111.8 212.19,111.98 267.27,167.06 270.07,167.06 v1(271.71,168.7)
  BOTTOM w0.203: UNK8R17.1 271.71,167.38 v1(271.71,168.7)
SL13_DP_0: length 193.5
  L03_DP w0.079: SLOT13.C61 245.96,396.29 247.69,398.02 248.48,398.02 248.86,397.64 249.39,397.64 250.39,398.64 250.52,398.64 251.07,399.18 251.82,399.18 252.3,399.67 252.3,402.28 251.64,402.94 251.07,402.94 250.59,402.46 249.91,402.46 249.36,403 249.18,403 248.83,403.35 248.83,403.63 248.34,404.12 247.97,404.12 247.15,404.94 246.32,404.94 246.02,404.64 245.48,404.64 245,405.12 244.59,405.12 243.77,405.94 243.22,405.94 242.83,405.54 242.17,405.54 241.46,406.25 241.1,406.25 240.41,406.94 239.86,406.94 239.3,406.38 238.7,406.38 238.08,407 229.02,407 216.23,394.21 216.23,388.21 157.07,329.04 157.07,301.9 145.42,290.24 v1(145.42,286.99)
SL13_DP_1: length 219
  L03_DP w0.079: v1(140.83,266.69) 139.99,267.53 139.99,277.21 141.18,278.4 141.18,282.63 138.96,284.85 138.96,287.48 156.32,304.83 156.32,329.18 215.6,388.47 215.6,394.47 228.76,407.63 236.41,407.63 236.61,407.43 238.23,407.43 238.73,407.94 239.27,407.94 239.91,407.3 240.34,407.3 240.98,407.94 241.52,407.94 242.34,407.12 242.72,407.12 243.3,406.53 243.96,406.53 244.36,406.94 244.89,406.94 245.71,406.12 246.09,406.12 246.71,405.5 247.29,405.5 247.73,405.94 248.27,405.94 249.09,405.12 249.47,405.12 249.95,404.63 249.95,404.14 250.16,403.94 250.52,403.94 251.16,403.3 251.79,403.3 252.66,402.43 252.66,398.65 249.64,395.64 247.52,395.64 SLOT13.D61
SL13_DP_2: length 215.9
  L03_DP w0.079: SLOT13.E61 249.13,397.11 250.48,398.46 250.59,398.46 251.07,398.94 251.82,398.94 252.48,399.59 252.48,402.35 251.72,403.12 251,403.12 250.52,402.64 249.98,402.64 249.6,403.02 249.6,403.56 249.77,403.73 249.77,404.56 249.39,404.94 248.86,404.94 248.39,404.47 247.87,404.47 247.22,405.12 246.84,405.12 246.02,405.94 245.48,405.94 244.99,405.44 244.52,405.44 243.84,406.12 243.46,406.12 242.64,406.94 242.11,406.94 241.62,406.45 241.16,406.45 240.49,407.12 239.75,407.12 239.27,406.64 238.73,406.64 238.19,407.18 236.46,407.18 236.32,407.31 228.89,407.31 215.92,394.34 215.92,388.34 156.71,329.13 156.71,302.06 141.58,286.93 141.58,265.41 v1(140.83,264.66)
SL13_DP_3: length 222.7
  L03_DP w0.079: v1(136.26,264.66) 136.26,266.2 135.09,267.37 135.09,274.8 131.06,278.83 131.06,286.87 134.8,290.61 134.8,294.47 155.85,315.52 155.85,329.17 215.29,388.6 215.29,394.34 215.29,394.6 228.63,407.94 236.35,407.94 236.68,407.61 238.15,407.61 238.66,408.12 239.34,408.12 239.98,407.48 240.27,407.48 240.91,408.12 241.59,408.12 242.37,407.34 242.64,407.34 243.23,407.94 243.77,407.94 244.59,407.12 244.97,407.12 245.7,406.38 246.05,406.38 246.61,406.94 247.16,406.94 247.98,406.12 248.34,406.12 249.1,405.36 249.41,405.36 249.98,405.94 250.52,405.94 250.9,405.56 250.9,404.73 250.73,404.56 250.73,404.02 251.27,403.48 251.87,403.48 252.88,402.46 252.88,398.62 251.38,397.11 SLOT13.F61
SL13_DP_4: length 195.7
  L05_DP w0.079: SLOT13.A59 239.08,398.29 238.12,397.32 220.24,397.32 216.86,393.95 216.86,386.96 159.88,329.97 159.88,303.63 146.78,290.54 146.78,271.83 145.24,270.3 145.24,254.16 v1(146.06,253.35)
SL13_DP_5: length 222
  L05_DP w0.079: SLOT13.B59 241.33,398.29 240.68,398.94 239.57,398.94 239.1,398.47 239.01,398.47 238.18,397.64 220.1,397.64 216.55,394.08 216.55,393.82 216.55,387.09 159.56,330.1 159.56,303.84 146.45,290.73 146.45,285.59 144.24,283.37 144.24,262.02 142.4,260.18 132.74,260.18 131.01,258.46 131.01,245.02 133.66,242.38 K15.2
SL13_DP_6: length 185.4
  L05_DP w0.079: SLOT13.C59 245.96,398.29 246.61,398.94 247.14,398.94 247.52,398.56 247.52,397.73 247.35,397.56 247.35,397.02 247.65,396.72 247.65,395.26 248.06,394.85 248.06,388.98 246.42,387.34 246.42,381.02 156.56,291.16 156.56,271.96 152.69,268.09 152.69,265.31 149.29,261.92 149.29,259.25 v1(148.22,258.18)
SL13_DP_7: length 204.4
  L05_DP w0.079: v1(148.22,253.35) 147.61,253.96 147.61,258.75 147.01,259.35 147.01,264.34 145.73,265.62 145.73,269.91 148.79,272.97 148.79,277.96 149.24,278.42 149.24,291.65 160.19,302.6 160.19,329.84 217.18,386.82 217.18,393.82 220.37,397.01 238.36,397.01 239.89,395.48 244.86,395.48 246.88,397.49 SLOT13.D59
SL13_DP_8: length 207.9
  L03_DP w0.079: SLOT13.E59 249.52,398.68 249.52,399.49 250,399.97 250.62,399.97 251.12,399.48 251.86,399.48 252.12,399.74 252.12,400.58 251.72,400.98 250.99,400.98 250.62,400.6 250.02,400.6 249.16,401.46 248.78,401.46 247.78,402.46 247.66,402.46 247.14,402.97 246.35,402.97 246.02,402.64 245.48,402.64 245,403.12 244.25,403.12 243.77,402.64 243.23,402.64 242.77,403.1 241.98,403.1 241.52,402.64 240.98,402.64 240.52,403.1 239.99,403.1 239.34,402.46 239.11,402.46 238.12,401.48 237.11,401.48 162.48,326.85 162.48,299.76 157.22,294.49 157.22,282.42 156.88,282.09 156.88,271.77 153.05,267.94 153.05,265.16 150.12,262.23 150.12,254.24 v1(151.01,253.35)
SL13_DP_9: length 181.5
  L05_DP w0.079: v1(153.17,258.18) 153.7,258.71 153.7,267.67 156.98,270.94 156.98,291.13 246.73,380.89 246.73,387.21 248.4,388.87 248.4,396.48 250.2,398.29 SLOT13.F59
SL13_DP_10: length 196.8
  L03_DP w0.079: SLOT13.Z59 238.05,398.46 239.34,398.46 240.04,399.16 240.2,399.16 240.98,399.94 241.81,399.94 242.11,399.64 242.64,399.64 243.02,400.02 243.02,400.56 242.64,400.94 242.06,400.94 242.06,400.94 241.95,400.94 241.57,400.55 240.9,400.55 240.5,400.96 239.76,400.96 239.37,400.57 238.7,400.57 238.33,400.94 237.03,400.94 162.81,326.71 162.81,299.62 157.54,294.36 157.54,282.29 157.2,281.95 157.2,271.62 153.38,267.8 153.38,264.79 151.96,263.37 151.96,259.45 152.6,258.81 152.6,253.92 v1(153.17,253.35)
SL13_DP_11: length 196.1
  L03_DP w0.079: K23.2 152.74,243.91 152.74,247.7 154.67,249.63 154.67,261.96 154.11,262.52 154.11,267.59 156.49,269.96 158.04,269.96 158.58,270.5 158.58,275.57 157.89,276.26 157.89,281.69 158.2,282 158.2,294.05 163.48,299.33 163.48,326.44 237.32,400.29 SLOT13.Z57
SL13_DP_12: length 204.6
  L03_DP w0.079: SLOT13.A57 239.08,400.29 237.91,399.12 236.68,399.12 163.8,326.24 163.8,291.53 168.11,287.22 168.11,279.31 164.69,275.89 161.38,275.89 159.93,274.44 159.93,270.6 158.96,269.64 156.67,269.64 154.47,267.44 154.47,262.64 155.12,261.99 155.12,253.36 156.06,252.42 157.64,252.42 158.11,251.95 158.11,243.68 K24.2
SL13_DP_13: length 192.6
  L03_DP w0.079: v1(156.47,253.35) 155.46,254.36 155.46,262.16 154.79,262.83 154.79,267.31 155.83,268.35 158.12,268.35 160.24,270.47 160.24,274.3 161.52,275.57 164.82,275.57 168.43,279.18 168.43,287.53 165.11,290.85 165.11,327.07 236.97,398.94 238.14,398.94 238.44,398.64 239.27,398.64 239.98,399.35 240.11,399.35 241.04,400.29 SLOT13.B57
SL13_DP_14: length 177.4
  L03_DP w0.079: SLOT13.C57 245.07,399.84 245.07,398.76 245.27,398.56 245.27,398.02 244.89,397.64 244.07,397.64 243.77,397.94 243.23,397.94 242.23,396.94 242.11,396.94 241.63,396.46 241.3,396.46 240.27,395.43 236.24,395.43 170.4,329.59 170.4,291.34 170.02,290.97 170.02,278.01 167.62,275.6 167.62,270.47 166.39,269.24 166.39,264.42 164.73,262.76 164.73,261.75 v1(163.84,260.87)
SL13_DP_15: length 177.2
  L03_DP w0.079: SLOT13.D57 246.88,399.47 246.58,399.17 246.58,398.94 246.18,398.54 246.18,397.78 246.4,397.56 246.4,397.02 246.02,396.64 245.32,396.64 245.02,396.94 244.36,396.94 244.35,396.93 242.28,394.87 237.37,394.87 173.89,331.39 173.89,289.69 170.97,286.78 170.97,283.36 171.62,282.71 171.62,269.7 170.82,268.9 170.82,262.72 170.37,262.27 169.82,262.27 v1(168.42,260.87)
SL13_DP_16: length 179.3
  L03_DP w0.079: SLOT13.E57 248.83,400.58 247.78,400.58 247.24,401.12 247.22,401.12 246.5,401.12 246.02,400.64 245.35,400.64 245.05,400.94 244.32,400.94 243.98,400.59 243.98,400.02 244.33,399.66 244.33,398.94 243.5,398.12 243.16,398.12 242.16,397.12 242.03,397.12 241.55,396.64 240.98,396.64 240.49,397.13 239.78,397.13 238.29,395.64 235.87,395.64 169.41,329.18 169.41,294.32 170.05,293.68 170.05,291.56 169.7,291.21 169.7,278.26 166.53,275.09 166.53,270.4 164.81,268.67 164.81,265.64 v1(163.84,264.68)
SL13_DP_17: length 178.1
  L03_DP w0.079: v1(168.42,264.68) 169.7,265.96 169.7,267.21 169.23,267.67 169.23,276.09 170.66,277.51 170.66,289.57 172.69,291.6 172.69,330.79 237.01,395.11 242.24,395.11 244.59,397.46 244.97,397.46 245.45,397.94 245.45,398.07 246.4,399.02 246.4,399.52 246.41,399.52 246.41,399.8 246.21,399.99 246.21,400.54 246.23,400.55 246.23,400.56 246.61,400.94 247.14,400.94 247.16,400.93 247.71,400.39 247.91,400.39 248.73,399.57 249.34,399.57 249.92,400.15 251.24,400.15 SLOT13.F57
SL13_DP_18: length 184
  L05_DP w0.079: v1(163.84,267.72) 164.46,268.34 164.46,268.79 166.21,270.54 166.21,275.32 169.38,278.5 169.38,289.57 168.32,290.63 168.32,302.03 247.05,380.76 247.05,387.07 248.72,388.75 248.72,391.44 252.02,394.74 252.02,398.56 251.64,398.94 251.11,398.94 250.81,398.64 249.69,398.64 249.39,398.94 248.86,398.94 248.56,398.64 247.7,398.64 247.22,399.12 246.84,399.12 246.02,399.94 245.48,399.94 245.1,399.56 245.1,399.22 244.82,398.94 244.36,398.94 244,398.58 243.04,398.58 240.13,401.49 SLOT13.A55
SL13_DP_19: length 179.6
  L05_DP w0.079: SLOT13.B55 242.82,401.84 242.82,400.76 243.46,400.12 243.88,400.12 244.36,399.64 244.89,399.64 245.37,400.12 246.13,400.12 246.61,399.64 247.14,399.64 247.62,400.12 248.38,400.12 248.86,399.64 249.39,399.64 249.87,400.12 250.59,400.12 251.18,399.53 251.47,399.53 252.2,398.79 252.2,394.32 249.04,391.15 249.04,388.62 247.36,386.94 247.36,380.63 171.61,304.87 171.61,291.6 170.34,290.33 170.34,277.76 167.96,275.38 167.96,270.27 167.51,269.83 167.51,268.63 v1(168.42,267.72)
SL13_DP_20: length 171.2
  L03_DP w0.079: SLOT13.C55 244.28,401.94 244.28,401.15 243.8,400.66 243.8,399.94 244.15,399.59 244.15,399.02 243.77,398.64 243.23,398.64 242.79,399.08 242.25,399.08 241.63,398.46 241.47,398.46 240.47,397.46 239.78,397.46 239.21,398.03 238.79,398.03 238.22,397.46 236.67,397.46 167.13,327.92 167.13,290.4 169.06,288.47 169.06,278.75 165,274.69 165,273.47 164.69,273.16 164.69,271.62 v1(163.84,270.77)
SL13_DP_21: length 171.5
  L03_DP w0.079: SLOT13.D55 245.54,402.29 244.89,402.94 244.36,402.94 243.63,402.21 243.5,402.21 242.75,401.46 242.75,401.1 243.2,400.65 243.2,399.94 242.52,399.26 242.17,399.26 241.55,398.64 241.39,398.64 240.39,397.64 239.86,397.64 239.28,398.21 238.72,398.21 238.14,397.64 236.3,397.64 166.09,327.43 166.09,290.34 168.74,287.69 168.74,278.97 164.68,274.9 164.68,274.24 v1(163.84,273.41)
SL13_DP_22: length 181.9
  L03_DP w0.079: v1(156.08,272.17) 154.28,273.97 154.28,293.71 161.22,300.65 161.22,328.03 236.73,403.53 238.04,403.53 238.7,404.19 239.31,404.19 239.86,403.64 240.39,403.64 240.94,404.19 241.56,404.19 242.11,403.64 242.64,403.64 243.17,404.17 243.79,404.17 244.42,403.54 244.8,403.54 244.89,403.64 245.46,404.2 246.04,404.2 246.61,403.64 247.14,403.64 247.44,403.94 248.27,403.94 248.65,403.56 248.65,402.76 SLOT13.E55
SL13_DP_23: length 178.3
  L03_DP w0.079: v1(156.08,276.75) 154.59,278.23 154.59,293.47 161.54,300.41 161.54,327.62 236.94,403.02 238.34,403.02 238.73,402.64 239.27,402.64 239.91,403.28 240.29,403.28 241.02,404.01 241.48,404.01 242.03,403.46 242.72,403.46 243.25,403.99 243.72,403.99 244.34,403.36 244.9,403.36 245.46,403.92 245.47,403.92 245.49,403.94 246.05,403.94 246.53,403.46 246.91,403.46 247.73,402.64 247.86,402.64 248.86,401.64 249.39,401.64 249.81,402.05 251.14,402.05 SLOT13.F55
SL13_DP_24: length 155.7
  L03_DP w0.079: SLOT13.Z55 237.6,402.56 237.13,402.56 161.85,327.28 161.85,300.15 156.58,294.87 156.58,282.7 156.08,282.19 v1(156.08,281.32)
SL13_DP_25: length 167.8
  L03_DP w0.079: v1(153.15,272.17) 153.96,272.98 153.96,293.95 160.91,300.9 160.91,328.39 236.53,404.02 237.61,404.02 SLOT13.Z53
SL13_DP_26: length 160.5
  L03_DP w0.079: v1(153.15,282.59) 153.15,283.34 153.64,283.82 153.64,294.2 160.59,301.15 160.59,328.53 236.63,404.57 237.24,404.57 237.61,404.94 238.14,404.94 238.71,404.37 240.04,404.37 SLOT13.A53
SL13_DP_27: length 177.4
  L03_DP w0.079: SLOT13.B53 242.29,404.37 240.96,404.37 240.23,405.1 239.73,405.1 239.27,404.64 238.73,404.64 238.13,405.23 237.65,405.23 237.3,404.88 229.81,404.88 218.28,393.36 218.28,386.71 160.28,328.7 160.28,301.41 151.55,292.68 151.55,274.51 v1(150.74,273.7)
SL13_DP_28: length 170
  L03_DP w0.079: SLOT13.C53 243.93,404.29 243.87,404.35 243.23,404.35 242.64,404.94 242.11,404.94 241.79,404.62 241,404.62 240.34,405.28 239.93,405.28 239.27,405.94 238.73,405.94 238.21,405.41 229.84,405.41 217.93,393.51 217.93,386.87 159.96,328.9 159.96,301.64 151.22,292.91 151.22,284.6 v1(150.74,284.11)
SL13_DP_29: length 180.7
  L03_DP w0.079: v1(148.33,278.27) 148.87,278.81 148.87,291.95 158.51,301.6 158.51,328.61 217.18,387.27 217.18,393.82 229.41,406.05 233.37,406.05 233.69,405.73 236.04,405.73 236.16,405.61 238.15,405.61 238.66,406.12 239.34,406.12 240,405.46 240.5,405.46 240.98,405.94 241.52,405.94 242.11,405.35 242.49,405.35 243.31,404.53 243.95,404.53 244.36,404.94 244.89,404.94 245.42,404.41 246.75,404.41 SLOT13.D53
SL13_DP_30: length 342.6
  L05_DP w0.079: SLOT13.E53 249.29,404.12 250.63,404.12 251.11,403.63 254.08,403.63 254.35,403.9 255.27,403.9 258.07,401.1 258.07,361.81 220.64,324.38 220.64,305.65 217.72,302.73 217.72,298.83 215.42,296.52 215.42,290.28 214.12,288.98 211.77,288.98 209.85,287.06 209.85,279.01 213.17,275.69 213.17,275.17 213.17,268.64 214.64,267.17 219.57,267.17 219.92,266.82 219.92,265.21 220,265.13 221.02,265.13 221.3,264.86 221.3,264.63 222.07,263.86 222.07,263.04 222.71,262.4 222.71,260.95 225.07,258.59 225.07,254.61 225.48,254.2 227.24,254.2 227.75,253.7 227.75,251.16 227.25,250.67 225.43,250.67 224.24,249.49 219.17,249.49 217.72,248.04 212.64,248.04 211.21,246.62 211.21,242.34 212.9,240.65 222.28,240.65 225.44,243.81 225.44,247.52 227.22,249.3 229.62,249.3 230.45,250.13 230.45,251.79 230.94,252.27 232.14,252.27 232.7,252.83 232.7,253.65 233,253.96 234.45,253.96 235.23,253.17 235.23,250.43 232.52,247.71 232.52,241.99 233.48,241.03 243.46,241.03 248.61,246.18 248.61,256.54 244.82,260.34 244.82,262.07 243.39,263.5 227,263.5 224.63,265.87 224.63,274.63 224.29,274.96 224.29,286.04 225.25,286.99 v1(225.41,286.99)
SL13_DP_31: length 171.7
  L05_DP w0.079: v1(220.83,266.69) 220.04,267.49 214.77,267.49 213.48,268.77 213.48,275.04 213.48,275.82 210.16,279.14 210.16,286.93 211.9,288.67 214.25,288.67 215.73,290.15 215.73,296.39 218.04,298.7 218.04,302.6 220.96,305.52 220.96,324.25 258.38,361.68 258.38,401.23 255.33,404.29 SLOT13.F53
SL13_DP_32: length 223.5
  L05_DP w0.079: SLOT13.A51 240.13,405.49 243.16,402.46 243.84,402.46 244.32,402.94 244.89,402.94 245.48,402.35 246.02,402.35 246.61,402.94 247.14,402.94 247.62,402.46 248.38,402.46 248.86,402.94 249.39,402.94 249.87,402.46 250.63,402.46 251.13,402.96 254.88,402.96 257.12,400.71 257.12,362.2 219.7,324.78 219.7,306.05 216.78,303.13 216.78,299.22 214.29,296.73 214.29,291.95 213.73,291.38 211.91,291.38 208.9,288.38 208.9,269.78 209.36,269.32 209.36,267.89 208.49,267.02 208.49,266.58 209.33,265.74 209.33,264.5 209.86,263.97 210.91,263.97 211.83,263.05 219.11,263.05 220.03,262.14 220.03,258.6 221.13,257.5 221.13,253.39 222.18,252.34 226.83,252.34 227.43,252.95 227.43,253.54 227.09,253.89 225.35,253.89 224.76,254.48 224.76,258.46 222.98,260.24 222.09,260.24 221.76,260.58 221.76,263.73 v1(220.83,264.66)
SL13_DP_33: length 181.1
  L05_DP w0.079: SLOT13.B51 242.38,405.2 243.02,404.56 243.02,403.82 242.82,403.61 242.82,403.05 243.23,402.64 243.77,402.64 244.25,403.12 244.97,403.12 245.56,402.53 245.95,402.53 246.53,403.12 247.22,403.12 247.7,402.64 248.3,402.64 248.78,403.12 249.47,403.12 249.95,402.64 250.55,402.64 251.19,403.27 255.01,403.27 257.44,400.84 257.44,362.07 220.01,324.64 220.01,305.92 217.09,303 217.09,299.09 214.79,296.79 214.79,292 213.86,291.07 212.04,291.07 209.22,288.25 209.22,278.75 212.54,275.43 212.54,268.38 v1(216.26,264.66)
SL13_DP_34: length 197.4
  L05_DP w0.079: SLOT13.C51 244.63,405.4 246.69,403.33 247.13,403.33 247.73,403.94 248.27,403.94 248.87,403.33 249.38,403.33 249.98,403.94 250.52,403.94 251,403.45 254.22,403.45 254.35,403.59 255.14,403.59 257.75,400.97 257.75,361.94 220.33,324.51 220.33,305.79 217.41,302.87 217.41,298.96 215.1,296.65 215.1,291.87 213.99,290.75 212.17,290.75 209.53,288.12 209.53,278.88 212.85,275.56 212.85,268.51 216.23,265.13 219.27,265.13 219.8,264.61 219.8,263.82 221.44,262.18 221.44,253.52 222.31,252.66 225.37,252.66 v1(226.06,253.35)
SL13_DP_35: length 221.5
  L05_DP w0.079: SLOT13.D51 246.88,405.49 247.73,404.64 248.27,404.64 248.76,405.12 249.5,405.12 249.98,404.64 250.52,404.64 251.52,405.64 251.64,405.64 251.93,405.92 254.62,405.92 259.01,401.53 259.01,361.42 221.59,323.99 221.59,305.26 218.67,302.34 218.67,290.15 216.75,288.24 215.87,288.24 213.75,286.12 211.97,286.12 210.79,284.95 210.79,279.4 214.11,276.08 214.11,274.2 218.19,270.13 218.19,268.5 218.52,268.17 220.46,268.17 222.02,266.62 222.02,264.81 222.7,264.12 222.7,263.3 223.34,262.67 223.34,261.21 225.39,259.16 226.89,259.16 227.61,258.44 227.61,254.9 228.22,254.29 229.35,254.29 229.55,254.1 229.55,253.58 230.14,253 230.14,250.26 229.49,249.61 227.09,249.61 225.12,247.65 225.12,243.94 224.53,243.36 214.66,243.36 UNK3K15.2
SL13_DP_36: length 180.4
  L05_DP w0.079: v1(228.22,258.18) 228.69,258.65 228.69,260.86 227.94,261.61 226.21,261.61 222.74,265.08 222.74,266.46 221.81,267.39 221.81,268.13 222.74,269.05 222.74,271.59 221.37,272.96 221.37,282.47 220.5,283.33 220.5,284.92 221.17,285.59 221.17,296.07 220.5,296.73 220.5,298.82 221.9,300.22 221.9,323.86 260.86,362.82 260.86,401.81 255.84,406.83 254.37,406.83 254.26,406.94 251.11,406.94 250.46,406.29 SLOT13.E51
SL13_DP_37: length 201.6
  L05_DP w0.079: v1(228.22,253.35) 228.22,253.68 227.38,254.52 225.61,254.52 225.39,254.74 225.39,258.72 223.03,261.08 223.03,262.53 222.39,263.17 222.39,263.99 221.62,264.77 221.62,266.57 220.33,267.85 217.44,267.85 216.96,268.33 216.96,270.91 213.8,274.07 213.8,275.95 210.48,279.27 210.48,285.08 211.84,286.43 213.62,286.43 215.74,288.55 216.62,288.55 218.35,290.28 218.35,302.47 221.27,305.39 221.27,324.12 258.7,361.55 258.7,401.37 255.26,404.81 254.35,404.81 254.22,404.94 251.11,404.94 250.62,404.45 249.88,404.45 249.39,404.94 248.86,404.94 248.38,404.46 247.62,404.46 246.18,405.9 246.18,406.51 246.61,406.94 247.14,406.94 248.14,405.94 248.27,405.94 248.57,405.64 249.64,405.64 249.95,405.95 251.04,405.95 SLOT13.F51
SL13_DP_38: length 195.3
  L05_DP w0.079: SLOT13.A49 240.31,408.1 241.36,408.1 241.97,407.49 242.79,407.49 243.23,407.94 243.77,407.94 244.31,407.4 244.95,407.4 245.48,407.94 246.02,407.94 246.53,407.43 247.22,407.43 247.73,407.94 248.27,407.94 248.78,407.43 249.47,407.43 249.98,407.94 250.52,407.94 251.02,407.43 256.13,407.43 261.49,402.07 261.49,362.56 223.47,324.54 223.47,300.88 222.14,299.54 222.14,273.17 223.37,271.95 223.37,265.34 226.47,262.24 228.2,262.24 230.18,260.25 230.18,254.18 v1(231.01,253.35)
SL13_DP_39: length 189.3
  L05_DP w0.079: v1(233.17,258.18) 232.41,258.94 232.41,260.18 230.03,262.55 226.61,262.55 223.68,265.47 223.68,274.24 223.35,274.57 223.35,300.31 223.79,300.75 223.79,324.41 261.81,362.43 261.81,402.2 256.26,407.75 251.75,407.75 251.64,407.64 251.07,407.64 250.59,408.12 249.91,408.12 249.4,407.61 248.89,407.61 248.38,408.12 247.66,408.12 247.18,407.64 246.61,407.64 246.13,408.12 245.41,408.12 244.93,407.64 244.32,407.64 243.77,408.19 242.47,408.19 SLOT13.B49
SL13_DP_40: length 260.6
  L05_DP w0.079: v1(233.17,253.35) 233.17,252.69 232.63,252.16 232.63,249.94 230.94,248.24 227.97,248.24 226.76,247.03 226.76,238.62 227.71,237.67 239.64,237.67 242.43,240.46 243.46,240.46 243.7,240.46 249.01,245.78 249.18,245.94 249.18,256.78 247.48,258.48 247.48,262.28 245.63,264.13 227.26,264.13 225.57,265.81 225.57,271.09 225.89,271.4 225.89,286.3 226.22,286.63 226.22,292.57 235.67,302.02 235.67,334.52 263.07,361.91 263.07,402.72 256.59,409.2 254.43,409.2 254.33,409.3 251.16,409.3 250.52,409.94 249.98,409.94 249.16,409.12 248.78,409.12 248.3,408.64 247.73,408.64 247.43,408.94 246.61,408.94 245.97,408.3 245.33,408.3 245.32,408.29 SLOT13.C49
SL13_DP_41: length 233.5
  L05_DP w0.079: UNK3K23.2 232.79,240.74 234.62,240.74 235.7,239.66 238.53,239.66 239.61,240.74 243.58,240.74 248.9,246.06 248.9,256.66 246.39,259.17 246.39,262.45 245.02,263.81 227.13,263.81 224.94,266 224.94,274.81 224.73,275.02 224.73,285.59 225.9,286.76 225.9,292.7 235.36,302.15 235.36,334.65 262.75,362.04 262.75,402.59 256.43,408.92 251.92,408.92 251.72,409.12 251.03,409.12 250.51,408.59 249.74,408.59 249.39,408.94 248.86,408.94 248.22,408.3 247.58,408.3 247.57,408.29 SLOT13.D49
SL13_DP_42: length 204.8
  L05_DP w0.079: SLOT13.E49 249.58,408.29 249.71,408.41 250.58,408.41 251.11,408.94 251.64,408.94 251.98,408.6 256.3,408.6 262.44,402.46 262.44,362.17 235.04,334.78 235.04,302.28 223.98,291.21 223.98,274.83 224.31,274.5 224.31,265.74 226.87,263.18 236.54,263.18 238.46,261.27 238.46,257.89 237.96,257.39 237.96,243.83 UNK3K24.2
SL13_DP_43: length 187
  L05_DP w0.079: v1(236.47,253.35) 236.47,253.44 235.73,254.18 235.73,260.04 232.9,262.87 226.74,262.87 224,265.61 224,274.37 223.66,274.7 223.66,300.18 224.1,300.62 224.1,324.28 262.12,362.3 262.12,402.33 256.17,408.29 255.12,408.29 SLOT13.F49
SL13_DP_44: length 247.3
  L05_DP w0.079: v1(243.84,260.87) 248.3,256.41 248.3,246.31 243.33,241.34 236.32,241.34 235.55,242.11 235.55,253.3 234.58,254.27 232.87,254.27 232.38,253.79 232.38,252.96 232.01,252.59 231.08,252.59 229.87,253.8 229.87,260.12 228.07,261.92 226.34,261.92 223.05,265.21 223.05,271.72 221.68,273.09 221.68,299.56 222.22,300.09 222.22,323.73 261.18,362.69 261.18,401.94 256,407.12 251,407.12 250.52,406.64 249.98,406.64 249.5,407.12 248.75,407.12 248.27,406.64 247.73,406.64 247.25,407.12 246.5,407.12 246.02,406.64 245.48,406.64 245,407.12 244.25,407.12 243.77,406.64 243.23,406.64 242.75,407.12 242.03,407.12 241.55,406.64 240.86,406.64 239.21,408.29 SLOT13.Z49
SL13_DP_45: length 212.9
  L05_DP w0.079: SLOT13.Z47 238.57,410.29 238.93,409.94 239.27,409.94 239.65,409.56 239.65,409.21 239.93,408.94 240.39,408.94 241,408.33 241.5,408.33 242.11,408.94 242.64,408.94 243.21,408.37 243.79,408.37 244.36,408.94 244.89,408.94 245.27,408.56 245.97,408.56 246.53,409.12 246.91,409.12 247.73,409.94 248.27,409.94 248.72,409.49 249.28,409.49 249.91,410.12 250.59,410.12 251.16,409.55 256.69,409.55 263.38,402.85 263.38,361.78 235.99,334.38 235.99,301.89 226.53,292.44 226.53,286.5 226.2,286.17 226.2,271.27 225.89,270.96 225.89,265.94 227.38,264.45 232.78,264.45 234.81,266.48 236.6,266.48 236.96,266.12 247.1,266.12 247.5,265.72 247.5,263.78 248.89,262.39 248.89,261.34 v1(248.42,260.87)
SL13_DP_46: length 232.3
  L05_DP w0.079: SLOT13.A47 240.13,409.46 240.95,408.64 241.55,408.64 242.03,409.12 242.75,409.12 243.22,408.64 243.8,408.64 244.28,409.12 244.66,409.12 245.48,409.94 246.31,409.94 246.61,409.64 247.18,409.64 247.66,410.12 248.1,410.12 248.48,410.49 248.48,410.56 248.86,410.94 249.39,410.94 249.85,410.48 250.39,410.48 251.03,411.12 251.91,411.12 252.05,410.97 255.87,410.97 256.35,410.49 257.08,410.49 264.33,403.24 264.33,361.39 236.93,333.99 236.93,301.5 229.12,293.68 229.12,285.54 228.81,285.24 228.81,272.68 230.49,271 233.72,271 234.38,271.66 234.38,272.67 234.86,273.16 236.61,273.16 237.13,273.68 237.13,274.48 237.92,275.27 245.89,275.27 246.48,274.69 246.48,270.71 245.31,269.55 243.66,269.55 243.23,269.12 243.23,267.3 243.81,266.73 247.24,266.73 247.81,266.16 247.81,264.37 248.28,263.9 250.14,263.9 250.86,263.18 250.86,260.02 250.23,259.39 248.54,259.39 247.79,260.14 247.79,262.41 246.07,264.13 246.07,264.87 245.79,265.15 244.31,265.15 v1(243.84,264.68)
SL13_DP_47: length 226.3
  L05_DP w0.079: SLOT13.B47 243.71,410.29 244.36,410.94 244.89,410.94 245.36,410.47 245.88,410.47 246.24,410.82 246.24,410.86 246.4,411.02 246.4,411.84 246.23,412.02 246.23,412.56 246.61,412.94 247.14,412.94 247.5,412.58 248.25,412.58 248.78,413.12 249.16,413.12 249.98,413.94 250.52,413.94 251.15,413.3 251.95,413.3 252.28,412.97 254.09,412.97 254.35,413.23 256.02,413.23 256.28,413.23 257.13,412.38 257.86,412.38 272.42,397.82 272.42,389.1 266.22,382.9 266.22,360.6 238.82,333.21 238.82,289.48 236.56,287.22 236.56,282.71 235.65,281.79 234.98,281.79 234.28,281.09 234.28,276.47 234.79,275.95 236.83,275.95 237.57,276.7 237.57,281.49 238.14,282.05 238.14,284.9 239.34,286.1 248.92,286.1 250.17,284.85 250.17,276.13 252.23,274.07 252.23,267.56 250.74,266.07 249.81,266.07 v1(248.42,264.68)
SL13_DP_48: length 206.2
  L05_DP w0.079: SLOT13.C47 245.96,410.29 246.42,410.75 246.42,410.75 246.6,410.94 247.16,410.94 247.35,411.12 247.35,411.56 247.73,411.94 248.27,411.94 248.27,411.93 248.68,411.52 249.31,411.52 249.91,412.12 250.59,412.12 251.16,411.55 256.18,411.55 256.61,411.12 257.34,411.12 264.96,403.5 264.96,361.13 237.56,333.73 237.56,290 233.64,286.08 233.64,283.97 233.49,283.82 232.63,283.82 232.37,283.82 231.47,282.91 231.47,282.26 231.72,282.01 231.72,275.48 230.27,274.03 230.27,273 231.58,271.7 233.35,271.7 233.67,272.02 233.67,273.1 233.96,273.38 233.96,274.35 234.47,274.86 236.27,274.86 237.31,275.9 247.48,275.9 248.89,274.49 248.89,267.53 248.4,267.04 244.52,267.04 v1(243.84,267.72)
SL13_DP_49: length 200.1
  L05_DP w0.079: SLOT13.D47 247.43,410.29 247.78,410.64 248.3,410.64 248.78,411.12 249.16,411.12 249.98,411.94 250.52,411.94 251.1,411.35 254.28,411.35 254.37,411.26 256.02,411.26 256.48,410.81 257.21,410.81 264.64,403.37 264.64,361.26 237.25,333.86 237.25,290.13 233.7,286.58 231.66,286.58 231.22,286.14 231.22,285.38 230.81,284.97 229.55,284.97 229.17,284.59 229.17,272.77 230.62,271.32 233.59,271.32 234.06,271.79 234.06,272.8 234.32,273.06 234.32,274.15 234.71,274.55 236.4,274.55 237.44,275.59 247.35,275.59 248.58,274.36 248.58,270.15 247.65,269.22 247.65,268.49 v1(248.42,267.72)
SL13_DP_50: length 190.4
  L05_DP w0.079: v1(243.84,270.77) 244.71,271.63 244.71,274.33 244.36,274.68 243.46,274.68 243.09,274.32 243.09,273.3 242.64,272.84 234.99,272.84 234.69,272.54 234.69,271.53 233.85,270.69 230.36,270.69 228.83,272.22 227.41,272.22 226.83,272.8 226.83,284.71 227.04,284.92 228.05,284.92 228.8,285.67 228.8,293.81 236.62,301.63 236.62,334.12 264.01,361.52 264.01,403.11 256.95,410.18 256.22,410.18 255.79,410.6 252.17,410.6 251.83,410.94 251.11,410.94 250.47,410.3 249.83,410.3 249.82,410.29 SLOT13.E47
SL13_DP_51: length 192.5
  L05_DP w0.079: SLOT13.F47 255.66,410.29 256.09,409.86 256.82,409.86 263.7,402.98 263.7,361.65 236.3,334.25 236.3,301.76 226.85,292.3 226.85,286.37 226.52,286.03 226.52,271.14 226.2,270.83 226.2,266.07 227.58,264.69 231.64,264.69 233.99,267.04 242.42,267.04 242.92,267.54 242.92,272.48 v1(243.84,273.41)
SL13_DP_52: length 216.7
  L03_DP w0.079: v1(236.07,272.17) 234.28,273.97 234.28,336.07 260.78,362.57 260.78,382.54 265.29,387.05 265.29,418.06 253.23,430.13 252.13,430.13 251.64,429.64 251.11,429.64 250.62,430.13 249.88,430.13 249.39,429.64 248.86,429.64 248.37,430.13 247.63,430.13 247.14,429.64 246.61,429.64 246.13,430.12 245.37,430.12 244.86,429.6 244.36,429.6 243.84,430.12 243.12,430.12 242.61,429.6 242.11,429.6 241.59,430.12 240.91,430.12 240.39,429.6 239.86,429.6 239.34,430.12 238.66,430.12 237.84,429.3 237.46,429.3 236.18,428.02 236.18,413.07 237.61,411.64 238.14,411.64 238.79,412.29 SLOT13.A45
SL13_DP_53: length 177.7
  L05_DP w0.079: SLOT13.B45 243.71,412.29 245.36,413.94 246.02,413.94 246.27,413.68 246.32,413.64 247.18,413.64 247.66,414.12 248.04,414.12 248.86,414.94 249.41,414.94 249.86,414.48 250.39,414.48 251.03,415.12 251.72,415.12 252.2,414.63 252.2,413.81 252.5,413.51 253.69,413.51 254.35,414.18 255.63,414.18 255.89,414.18 256.67,414.18 257.52,413.33 258.25,413.33 273.36,398.22 273.36,388.71 267.16,382.51 267.16,360.21 239.77,332.82 239.77,289.09 237.51,286.83 237.51,282.31 236.94,281.75 236.94,278.53 236.07,277.66 v1(236.07,276.75)
SL13_DP_54: length 168.1
  L05_DP w0.079: SLOT13.C45 245.7,412.29 246.53,413.12 246.91,413.12 247.73,413.94 248.27,413.94 248.7,413.51 249.3,413.51 249.91,414.12 250.63,414.12 250.93,413.82 251.26,413.48 252.02,413.48 252.35,413.15 253.96,413.15 254.35,413.55 255.89,413.55 256.15,413.55 256.41,413.55 257.26,412.7 257.99,412.7 272.73,397.96 272.73,388.97 266.53,382.77 266.53,360.47 239.14,333.08 239.14,289.35 236.88,287.09 236.88,282.58 236.07,281.77 v1(236.07,281.32)
SL13_DP_55: length 174.2
  L05_DP w0.079: SLOT13.D45 248.21,412.29 248.86,412.94 249.39,412.94 249.85,412.48 250.39,412.48 251.03,413.12 251.85,413.12 252.32,412.65 254.08,412.65 254.35,412.92 256.15,412.92 257,412.07 257.21,412.07 257.73,412.07 272.1,397.69 272.1,389.23 265.9,383.03 265.9,360.74 238.51,333.34 238.51,289.61 234.58,285.68 234.58,283.57 233.96,282.95 233.96,274.81 233.64,274.49 233.64,273.51 233.15,273.03 v1(233.15,272.17)
SL13_DP_56: length 160.4
  L05_DP w0.079: SLOT13.E45 249.82,412.29 249.83,412.3 250.47,412.3 251.11,412.94 251.77,412.94 252.24,412.47 254.22,412.47 254.35,412.6 256.02,412.6 256.87,411.75 257.08,411.75 257.08,411.75 257.34,411.75 257.34,411.75 257.6,411.75 271.79,397.56 271.79,389.36 265.59,383.16 265.59,360.87 238.19,333.47 238.19,289.74 234.27,285.81 234.27,283.7 v1(233.15,282.59)
SL13_DP_57: length 165.5
  L05_DP w0.079: SLOT13.F45 255.89,412.29 256.74,411.44 257.21,411.44 257.47,411.44 265.27,403.63 265.27,361 237.88,333.6 237.88,289.87 233.95,285.95 233.95,283.84 233.62,283.5 232.5,283.5 231.78,282.78 231.78,282.39 232.35,281.83 233.31,281.83 233.65,281.49 233.65,274.95 233.42,274.72 231.76,274.72 v1(230.74,273.7)
SL13_DP_58: length 200.4
  L03_DP w0.079: SLOT13.Z45 236.36,413.8 236.36,427.94 237.53,429.12 237.91,429.12 238.73,429.94 239.27,429.94 239.78,429.42 240.47,429.42 240.98,429.94 241.52,429.94 242.03,429.42 242.69,429.42 243.2,429.94 243.77,429.94 244.28,429.42 244.97,429.42 245.48,429.94 246.05,429.94 246.53,429.46 247.22,429.46 247.71,429.94 248.29,429.94 248.78,429.46 249.47,429.46 249.96,429.94 250.54,429.94 251.03,429.46 251.75,429.46 252.23,429.94 253.02,429.94 264.03,418.92 264.03,387.57 259.52,383.06 259.52,363.1 231.22,334.8 231.22,284.6 v1(230.74,284.11)
SL13_DP_59: length 208.1
  L03_DP w0.079: SLOT13.Z43 237.88,415.12 240.77,418.02 240.77,418.56 240.39,418.94 239.86,418.94 239.31,418.39 238.72,418.39 238.18,418.94 237.4,418.94 236.54,419.8 236.54,427.87 237.61,428.94 238.14,428.94 238.58,428.5 239.16,428.5 239.78,429.12 240.47,429.12 240.98,428.6 241.52,428.6 242.03,429.12 242.72,429.12 243.23,428.6 243.77,428.6 244.28,429.12 244.97,429.12 245.46,428.62 246.04,428.62 246.53,429.12 247.25,429.12 247.73,428.64 248.27,428.64 248.78,429.15 249.47,429.15 249.98,428.64 250.52,428.64 251.03,429.15 251.72,429.15 252.23,428.64 253.92,428.64 263.4,419.15 263.4,387.83 258.89,383.32 258.89,363.36 228.87,333.33 228.87,278.81 v1(228.33,278.27)
SL13_DP_60: length 261.4
  L05_DP w0.079: v1(145.42,226.99) 145.42,231.04 140.14,236.31 132.9,236.31 127.58,241.63 127.58,284.52 131.77,288.71 140.92,288.71 146.78,294.57 148.51,294.57 158.3,304.36 158.3,330.62 215.29,387.61 215.29,393.3 215.29,393.3 215.29,394.6 219.58,398.9 228.2,398.9 233.42,404.13 233.42,413.55 235.25,415.38 237.99,415.38 238.82,414.54 239.87,414.54 SLOT13.A43
SL13_DP_61: length 294.4
  L03_DP w0.079: v1(140.83,206.69) 139.99,207.53 139.99,217.21 141.18,218.4 141.18,222.63 138.4,225.41 134.19,225.41 133.39,226.21 119.86,226.21 114.77,231.29 114.77,301.7 223.91,410.85 237.52,410.85 237.61,410.94 238.14,410.94 238.62,410.46 239.34,410.46 239.86,410.97 240.43,410.97 240.82,410.58 241.49,410.58 242.55,411.64 242.64,411.64 243.02,412.02 243.02,412.56 242.38,413.2 SLOT13.B43
SL13_DP_62: length 296.2
  L03_DP w0.079: v1(140.83,204.66) 141.58,205.41 141.58,227.51 140.47,228.62 122.8,228.62 115.09,236.33 115.09,301.57 223.48,409.96 236.04,409.96 236.42,409.58 238.12,409.58 238.66,410.12 239.34,410.12 239.9,409.56 240.35,409.56 241.19,410.4 241.57,410.4 242.63,411.46 242.72,411.46 243.2,411.94 243.36,411.94 244.63,413.2 SLOT13.C43
SL13_DP_63: length 290.4
  L03_DP w0.079: v1(136.26,204.66) 136.26,206.2 135.09,207.37 135.09,214.8 131.06,218.83 126.66,218.83 114.46,231.04 114.46,301.83 223.8,411.17 238.19,411.17 238.73,410.64 239.27,410.64 240.09,411.46 240.47,411.46 241,411.99 241.16,411.99 241.91,412.74 241.91,413.84 241.73,414.02 241.73,414.56 242.11,414.94 242.64,414.94 242.94,414.64 243.77,414.64 244.14,415.01 245.11,415.01 245.83,414.29 SLOT13.D43
SL13_DP_64: length 307
  L05_DP w0.079: SLOT13.A37 240.42,419.99 240.42,418.94 240.84,418.52 240.84,418.05 240.42,417.63 240.42,417.5 239.48,416.56 239.48,416.02 239.86,415.64 239.95,415.64 240.95,414.63 240.95,413.94 240.47,413.46 239.78,413.46 239.3,413.94 238.71,413.94 238.66,413.88 238.42,413.64 237.61,413.64 236.5,414.75 235.51,414.75 234.05,413.29 234.05,403.86 228.46,398.27 219.84,398.27 215.92,394.34 215.92,393.56 215.92,387.35 158.93,330.36 158.93,304.1 148.77,293.94 147.04,293.94 141.92,288.82 141.92,276.14 139.22,273.43 136.82,273.43 128.76,265.37 128.76,241.59 133.27,237.08 137.22,237.08 138.55,238.41 144.79,238.41 146.22,236.98 146.22,226.58 141.63,221.99 141.63,202.52 144.75,199.4 144.75,194.66 v1(146.06,193.35)
SL13_DP_65: length 324.6
  L05_DP w0.079: UNK5K15.2 133.66,182.38 131.01,185.02 131.01,198.46 132.74,200.18 138.59,200.18 141.35,202.95 141.35,222.16 145.9,226.71 145.9,231 140.27,236.62 133.08,236.62 128.15,241.56 128.15,265.21 136.69,273.75 139.09,273.75 141.61,276.27 141.61,288.95 146.91,294.26 148.64,294.26 158.62,304.23 158.62,330.49 215.6,387.48 215.6,393.43 215.6,393.43 215.6,394.47 219.71,398.58 228.33,398.58 233.74,403.99 233.74,413.42 235.38,415.06 238.05,415.06 238.75,414.36 239.13,414.36 239.86,413.64 240.39,413.64 240.77,414.02 240.77,414.56 239.87,415.46 239.78,415.46 239.3,415.94 239.3,416.63 239.78,417.11 239.78,417.72 239.36,418.13 239.36,418.73 239.65,419.02 239.65,419.56 239.36,419.84 239.36,420.73 239.86,421.23 240.39,421.23 241,420.62 242.05,420.62 SLOT13.B37
SL13_DP_66: length 279.1
  L03_DP w0.079: v1(148.22,198.18) 149.29,199.25 149.29,201.92 152.69,205.31 152.69,208.09 156.55,211.95 156.55,214.79 156.98,215.22 156.98,223.7 160.09,226.81 160.09,234.35 171.96,246.22 171.96,247.8 173.4,249.23 177.77,249.23 181.11,252.58 181.11,256.09 180.78,256.43 180.78,258.64 183.55,261.42 183.55,271.03 184.43,271.91 184.43,301.06 250.33,366.95 250.33,385.9 255.53,391.1 255.53,416.47 255.42,416.57 255.42,416.58 253.89,418.12 252.46,418.12 251.64,418.94 251.07,418.94 250.5,418.36 250,418.36 249.38,418.98 248.9,418.98 248.22,418.3 247.78,418.3 245.96,420.12 244.8,420.12 SLOT13.C37
SL13_DP_67: length 316.5
  L05_DP w0.079: v1(148.22,193.35) 147.4,194.16 145.64,194.16 145.03,194.77 145.03,199.28 145.03,199.52 142.75,201.8 142.75,211.58 141.91,212.42 141.91,221.78 146.53,226.4 146.53,237.11 144.92,238.72 138.42,238.72 137.09,237.39 133.41,237.39 129.31,241.49 129.31,265.49 136.95,273.12 139.35,273.12 142.24,276.01 142.24,288.69 147.17,293.63 148.9,293.63 159.25,303.97 159.25,330.23 216.23,387.22 216.23,393.69 216.23,394.21 219.97,397.95 228.59,397.95 234.37,403.73 234.37,413.16 235.65,414.43 236.56,414.43 237.58,413.41 237.96,413.41 238.73,412.64 239.27,412.64 239.82,413.19 240.43,413.19 240.98,412.64 241.52,412.64 241.9,413.02 241.9,413.56 241.52,413.94 241.52,414.64 241.9,415.02 241.9,415.56 240.6,416.85 240.6,417.56 241.02,417.98 241.02,418.6 240.6,419.02 240.6,419.56 240.98,419.94 241.52,419.94 241.82,419.64 242.64,419.64 243.18,420.17 243.82,420.17 244.36,419.64 244.89,419.64 245.43,420.17 246.76,420.17 SLOT13.D37
SL13_DP_68: length 279.4
  L03_DP w0.079: SLOT13.E37 249.13,419.49 250.08,418.54 250.42,418.54 251,419.12 251.72,419.12 252.5,418.33 254.12,418.33 255.74,416.71 255.74,416.7 255.84,416.6 255.84,390.97 250.78,385.9 250.78,366.77 184.88,300.87 184.88,271.77 183.88,270.76 183.88,261.28 181.11,258.52 181.11,256.55 181.44,256.23 181.44,252.44 177.87,248.88 173.5,248.88 172.28,247.66 172.28,246.08 160.41,234.22 160.41,226.68 157.3,223.57 157.3,215.09 156.95,214.74 156.95,211.83 153.05,207.94 153.05,205.16 150.12,202.23 150.12,194.82 151.01,193.93 v1(151.01,193.35)
SL13_DP_69: length 272.5
  L03_DP w0.079: v1(153.17,198.18) 153.17,198.82 153.7,199.35 153.7,207.67 156.38,210.34 157.91,210.34 158.21,210.64 158.21,217.88 157.98,218.11 157.98,223.29 163.03,228.34 163.03,230.65 163.43,231.05 163.43,234.01 162.81,234.62 162.81,235.66 172.83,245.68 177.32,245.68 178.16,246.53 178.16,248.24 178.34,248.42 182.16,252.24 182.16,256.26 182.65,256.76 182.65,259.14 184.53,261.01 184.53,269.22 186.44,271.13 186.44,301.37 251.53,366.46 251.53,385.77 256.47,390.71 256.47,417.37 253.55,420.29 SLOT13.F37
SL13_DP_70: length 289.8
  L03_DP w0.079: v1(153.17,193.35) 153.17,194.06 152.6,194.63 152.6,198.81 151.96,199.45 151.96,203.37 153.38,204.79 153.38,207.8 157.23,211.65 157.23,214.57 157.54,214.88 157.54,214.88 157.62,214.96 157.62,223.43 161.78,227.59 161.78,235.13 172.6,245.95 172.6,247.53 173.58,248.51 177.96,248.51 181.78,252.33 181.78,256.34 181.45,256.67 181.45,258.41 184.2,261.15 184.2,269.38 186.03,271.22 186.03,301.53 251.13,366.63 251.13,385.81 256.16,390.84 256.16,416.73 256.05,416.83 256.05,416.84 252.96,419.94 252.23,419.94 251.87,419.57 251.12,419.57 250.28,420.41 249.92,420.41 249.39,420.94 248.86,420.94 248.38,420.46 247.66,420.46 247.15,420.97 246.61,420.97 246.09,420.46 245.41,420.46 244.66,421.21 244.34,421.21 243.77,420.64 243.2,420.64 242.72,421.12 242.46,421.12 241.29,422.29 SLOT13.A35
SL13_DP_71: length 309.8
  L03_DP w0.079: UNK5K23.2 152.74,183.91 152.74,187.7 154.67,189.63 154.67,201.96 154.11,202.52 154.11,207.59 156.49,209.96 158.04,209.96 158.55,210.46 158.55,215.05 159.09,215.59 164.39,215.59 168.2,219.41 168.2,225.86 165.42,228.65 164.28,228.65 163.38,229.55 163.38,230.19 163.82,230.62 163.82,236.19 171.05,243.43 177.49,243.43 178.58,244.51 178.58,248.18 182.49,252.09 182.49,253.48 183.27,254.26 184.17,254.26 184.52,254.61 184.52,257.7 184.91,258.09 184.91,269.11 186.84,271.04 186.84,301.2 251.93,366.29 251.93,385.72 256.79,390.57 256.79,417.5 253.82,420.47 252.11,420.47 251.64,420.94 251.11,420.94 250.76,420.59 250,420.59 249.47,421.12 248.78,421.12 248.3,420.64 247.73,420.64 247.22,421.15 246.53,421.15 246.02,420.64 245.48,420.64 244.73,421.39 244.32,421.39 243.68,422.02 242.64,422.02 SLOT13.B35
SL13_DP_72: length 308.2
  L03_DP w0.079: SLOT13.C35 244.98,421.94 246.02,421.94 246.5,421.46 247.25,421.46 247.73,421.94 248.27,421.94 248.79,421.41 249.46,421.41 249.98,421.94 250.52,421.94 251,421.45 251.75,421.45 252.23,421.94 252.79,421.94 257.1,417.63 257.1,390.44 252.28,385.63 252.28,366.1 189,302.81 189,272.59 186.33,269.92 186.33,261.38 185.26,260.32 185.26,257.88 184.89,257.5 184.89,251.57 184.43,251.11 181.98,251.11 179.84,248.97 179.84,243.77 177.38,241.31 170.69,241.31 164.81,235.43 164.81,230.52 168.49,226.84 168.49,219.24 164.52,215.27 160.76,215.27 159.93,214.44 159.93,210.7 158.86,209.64 156.92,209.64 154.39,207.11 154.39,202.72 155.12,201.99 155.12,193.36 156.06,192.42 157.64,192.42 158.11,191.95 158.11,184.28 159.44,182.96 UNK5K24.2
SL13_DP_73: length 296.2
  L03_DP w0.079: SLOT13.D35 248.17,422.29 248.87,421.59 249.38,421.59 249.91,422.12 250.59,422.12 251.08,421.63 251.67,421.63 252.16,422.12 253.06,422.12 257.42,417.76 257.42,390.31 252.63,385.53 252.63,365.95 189.34,302.66 189.34,272.86 192.55,269.65 192.55,265.04 191.13,263.62 189.13,263.62 185.59,260.08 185.59,257.63 185.23,257.27 185.23,251.25 184.72,250.73 183.1,250.73 181.34,248.98 181.34,243.57 178.74,240.96 170.85,240.96 165.13,235.24 165.13,230.83 168.8,227.16 168.8,219.12 164.64,214.96 160.9,214.96 160.24,214.3 160.24,210.47 156.71,206.93 155.47,206.93 154.79,206.25 154.79,202.83 155.46,202.16 155.46,195.1 156.47,194.09 v1(156.47,193.35)
SL13_DP_74: length 406.9
  L05_DP w0.079: SLOT13.E35 249.14,422.27 250.44,422.27 251.08,421.64 251.64,421.64 252.12,422.12 253.17,422.12 255.16,420.12 271.83,420.12 279.73,412.21 279.73,393.93 288.92,384.75 288.92,349.78 309.83,328.86 309.83,240.16 299.54,229.87 271.98,229.87 271.25,229.14 270.86,229.14 270.14,229.87 265.89,229.87 264.24,228.22 264.24,226.1 263.51,225.37 254.99,225.37 254.15,226.21 251.86,226.21 250.62,224.97 250.62,215.74 247.12,212.24 241.37,212.24 239.4,210.27 237.53,210.27 231.16,203.9 225.72,203.9 224.51,202.69 213.87,202.69 212.47,204.09 212.47,210.71 212.47,210.71 212.47,210.95 208.25,215.17 197.77,215.17 196.85,214.25 196.85,209.8 191.26,204.22 182.88,204.22 181.26,202.59 171.76,202.59 171.48,202.31 165.29,202.31 v1(163.84,200.87)
SL13_DP_75: length 403.2
  L05_DP w0.079: SLOT13.F35 251.6,422.51 252.07,422.51 252.22,422.36 253.79,422.36 255.71,420.44 271.91,420.44 280.02,412.33 280.02,394.04 289.2,384.86 289.2,350.86 311.08,328.98 311.08,236.34 302.21,227.47 281.3,227.47 278.95,225.12 271.93,225.12 271.54,224.73 271.54,216.99 270.83,216.29 269.2,216.29 268.61,215.7 257.51,215.7 255.41,213.61 249.39,213.61 248.33,212.54 248.33,211.4 246.89,209.96 237.66,209.96 231.32,203.62 226.23,203.62 223.22,200.62 214.17,200.62 212.19,202.59 212.19,210.83 208.14,214.88 199.01,214.88 197.13,213.01 197.13,209.69 191.38,203.93 183,203.93 180.85,201.79 180.2,201.79 179.96,201.55 177.17,201.55 176.93,201.79 173.7,201.79 173.33,201.42 168.97,201.42 v1(168.42,200.87)
SL13_DP_76: length 290.2
  L03_DP w0.079: v1(163.84,204.68) 164.81,205.64 164.81,208.67 166.53,210.4 166.53,214.94 170.08,218.49 170.08,233.65 169.41,234.32 169.41,235.63 171.16,237.38 177.61,237.38 183.79,243.56 183.79,244.57 187.1,247.87 187.1,248.37 187.99,249.27 191.64,249.27 192.69,250.31 192.69,258.49 193.98,259.79 193.98,305.27 254.01,365.3 254.01,385.13 258.68,389.79 258.68,418.03 252.77,423.94 252.23,423.94 251.62,423.32 251.13,423.32 250.52,423.94 249.98,423.94 249.41,423.37 249.09,423.37 248.34,424.12 248.22,424.12 247.22,425.12 246.84,425.12 245.95,426.01 245.95,426.14 244.79,427.3 244.41,427.3 243.77,427.94 243.23,427.94 242.59,427.3 242.16,427.3 241.52,427.94 240.98,427.94 240.16,427.12 239.75,427.12 238.17,425.54 238.17,424.91 238.52,424.56 238.52,424.02 237.62,423.11 237.62,422.55 SLOT13.Z35
SL13_DP_77: length 290.5
  L03_DP w0.079: SLOT13.Z33 236.9,425.26 236.9,426.89 237.47,427.46 238.22,427.46 238.7,427.94 239.56,427.94 239.86,427.64 240.39,427.64 240.87,428.12 241.59,428.12 242.23,427.48 242.52,427.48 243.16,428.12 243.84,428.12 244.48,427.48 245.02,427.48 245.48,427.94 246.05,427.94 246.53,427.46 246.87,427.46 250.21,424.12 250.59,424.12 251.21,423.5 251.54,423.5 252.16,424.12 253.03,424.12 259.62,417.53 259.62,389.4 255.11,384.89 255.11,364.92 196.64,306.46 196.64,262.19 195.44,260.99 195.44,246.33 194.7,245.59 190.5,245.59 189.79,244.87 186.68,244.87 178.12,236.31 173.18,236.31 172.69,235.82 172.69,231.6 171.04,229.94 171.04,216.17 169.23,214.37 169.23,207.67 169.7,207.21 169.7,205.96 v1(168.42,204.68)
SL13_DP_78: length 550.8
  L05_DP w0.079: v1(163.84,207.72) 164.87,208.75 164.87,214.37 164.19,215.05 160.04,215.05 157.23,217.86 155.79,217.86 154.21,219.45 154.21,222.62 151.83,225 149.29,225 148.18,223.89 148.18,222.75 146.02,220.59 146.02,214.17 147.35,212.84 149.64,212.84 153.73,208.75 153.73,203.71 155.04,202.4 155.04,190.38 156.09,189.33 158.74,189.33 159.46,188.61 163.41,188.61 166.34,185.68 166.34,183.94 175.94,174.34 229.5,174.34 231.79,172.06 290.69,172.06 317.91,199.27 317.91,332.37 317.91,332.37 317.91,332.6 294.27,356.24 294.27,386.97 285.09,396.15 285.09,415.09 284.93,415.26 274.66,425.52 266.62,425.52 259.68,432.46 252.41,432.46 251.67,433.2 251.08,433.2 250.52,432.64 249.98,432.64 249.42,433.2 248.83,433.2 248.27,432.64 247.73,432.64 247.17,433.2 246.58,433.2 246.02,432.64 245.48,432.64 244.66,433.46 244.28,433.46 243.78,433.96 243.22,433.96 242.72,433.46 242,433.46 241.52,433.94 240.98,433.94 240.16,433.12 239.75,433.12 239.27,432.64 238.44,432.64 238.14,432.94 237.58,432.94 237.11,432.46 237.11,428 238.55,426.56 238.55,425.75 238.35,425.56 238.35,425.02 239.08,424.29 SLOT13.A33
SL13_DP_79: length 552.4
  L05_DP w0.079: v1(168.42,207.72) 167.57,206.88 163.7,206.88 162.94,207.65 162.94,208.92 164.59,210.57 164.59,214.25 164.07,214.77 159.9,214.77 157.09,217.58 155.67,217.58 153.92,219.33 153.92,222.5 151.71,224.72 149.4,224.72 148.46,223.77 148.46,222.63 146.3,220.47 146.3,214.29 147.47,213.13 149.75,213.13 154.01,208.87 154.01,203.82 155.32,202.51 155.32,190.5 156.21,189.61 158.86,189.61 159.58,188.89 163.53,188.89 166.62,185.8 166.62,184.06 176.06,174.62 229.62,174.62 231.9,172.34 290.58,172.34 317.63,199.39 317.63,332.49 293.99,356.12 293.99,386.85 284.81,396.03 284.81,414.98 274.54,425.24 266.5,425.24 259.56,432.18 252.43,432.18 251.6,433.02 251.15,433.02 250.59,432.46 249.91,432.46 249.35,433.02 248.9,433.02 248.34,432.46 247.66,432.46 247.1,433.02 246.69,433.02 246.11,432.44 245.43,432.44 244.93,432.94 244.07,432.94 243.77,432.64 243.23,432.64 242.75,433.12 242,433.12 241.52,432.64 240.69,432.64 240.39,432.94 239.82,432.94 239.34,432.46 239.25,432.46 238.35,431.56 238.35,431.02 238.65,430.72 238.65,429.86 238.35,429.56 238.35,428.89 240.3,426.94 240.39,426.94 241.39,425.94 241.52,425.94 242.38,425.08 SLOT13.B33
SL13_DP_80: length 272.1
  L03_DP w0.079: SLOT13.C33 245.67,424.29 246.32,424.94 247.14,424.94 248.14,423.94 248.27,423.94 249.02,423.19 249.43,423.19 249.98,422.64 250.21,422.64 250.21,422.63 250.55,422.63 251.03,423.12 251.72,423.12 252.36,422.48 253.59,422.48 258.05,418.02 258.05,390.05 253.34,385.34 253.34,365.68 191.76,304.1 191.76,271.59 193.26,270.1 193.26,262.78 190.06,259.58 190.06,253.32 189.28,252.54 188.32,252.54 187.72,251.94 187.72,250.27 185.57,248.12 182.94,248.12 182.38,247.56 182.38,243.4 179.21,240.23 172.86,240.23 167.21,234.58 167.21,230.33 169.44,228.1 169.44,218.86 165,214.42 165,211.93 v1(163.84,210.77)
SL13_DP_81: length 268.8
  L03_DP w0.079: v1(163.84,213.41) 164.69,214.26 164.69,214.55 169.12,218.99 169.12,227.31 166.09,230.34 166.09,235.72 170.98,240.6 178.97,240.6 181.71,243.34 181.71,248.26 182.91,249.46 184.64,249.46 185.57,250.38 185.57,256.86 186.04,257.33 186.99,257.33 187.54,257.88 187.54,260.32 188.36,261.15 189.82,261.15 192.89,264.21 192.89,269.85 191.42,271.32 191.42,304.24 253,365.82 253,385.45 257.73,390.18 257.73,417.89 253.33,422.3 252.28,422.3 251.64,422.94 251.11,422.94 250.62,422.45 249.88,422.45 249.39,422.94 248.86,422.94 248.54,422.62 247.75,422.62 246.88,423.49 SLOT13.D33
SL13_DP_82: length 419.1
  L05_DP w0.079: v1(156.08,212.18) 156.59,211.66 156.59,202.82 159.92,199.49 182.48,199.49 185.6,202.61 196.5,202.61 197.26,203.36 207.86,203.36 209.89,201.34 211.03,201.34 212.6,199.77 223.63,199.77 225.01,201.15 230.52,201.15 235.82,206.45 246.86,206.45 247.6,207.18 247.6,209.33 248.92,210.65 254.09,210.65 256.26,212.82 260.62,212.82 261.86,211.58 265.43,211.58 267.01,213.16 280.51,213.16 280.97,212.7 287.06,212.7 287.52,213.16 298.36,213.16 312.03,226.82 312.03,329.37 290.04,351.35 290.04,385.21 280.86,394.39 280.86,412.68 272.25,421.29 256.77,421.29 253.88,424.18 252.19,424.18 251.64,423.64 251.11,423.64 250.61,424.13 249.28,424.13 SLOT13.E33
SL13_DP_83: length 423.8
  L05_DP w0.079: SLOT13.F33 251.97,424.29 252.1,424.42 254.04,424.42 256.88,421.58 272.37,421.58 281.14,412.8 281.14,394.51 290.33,385.33 290.33,351.52 312.34,329.5 312.34,226.69 298.49,212.84 287.65,212.84 287.19,212.39 280.83,212.39 280.38,212.84 271.82,212.84 271.43,212.45 266.75,212.45 265.56,211.26 261.73,211.26 260.49,212.5 256.39,212.5 253.41,209.52 248.61,209.52 247.91,208.82 247.91,207.05 246.99,206.14 241.81,206.14 240.54,204.86 239.21,204.86 238.78,205.29 235.57,205.29 231.15,200.87 225.13,200.87 223.66,199.4 209.16,199.4 205.51,203.05 198.78,203.05 197.93,202.19 185.63,202.19 182.7,199.26 182.65,199.26 182.6,199.21 159.8,199.21 156.31,202.7 156.31,202.72 154.86,204.17 154.86,210.2 154.48,210.58 154.48,214.62 155.97,216.11 156,216.11 156.08,216.19 v1(156.08,216.75)
SL13_DP_84: length 275
  L03_DP w0.079: v1(156.08,221.32) 156.67,221.91 156.67,223.83 159.72,226.89 159.72,234.55 170.74,245.56 170.74,255.25 174.56,259.07 179.02,259.07 180.35,260.41 180.35,269.62 184.05,273.32 184.05,301.22 249.95,367.11 249.95,385.96 255.21,391.23 255.21,416.34 253.62,417.94 252.23,417.94 251.85,417.56 251.15,417.56 250.59,418.12 249.87,418.12 249.25,417.49 248.97,417.49 248.34,418.12 247.62,418.12 247.14,417.64 246.32,417.64 244.02,419.94 243.64,419.94 242.64,420.94 241.82,420.94 241.52,420.64 240.69,420.64 239.48,421.85 239.48,422.56 239.86,422.94 240.68,422.94 241.09,422.53 241.44,422.53 242.03,423.12 242.75,423.12 243.23,422.64 243.77,422.64 244.15,423.02 244.15,423.59 243.8,423.94 243.8,424.63 244.28,425.12 244.41,425.12 245.27,425.98 245.27,426.56 244.89,426.94 244.36,426.94 243.71,426.29 243.29,426.29 242.64,426.94 242.11,426.94 241.46,426.29 SLOT13.A31
SL13_DP_85: length 283.1
  L03_DP w0.079: SLOT13.B31 242.38,425.49 241.52,424.64 240.98,424.64 240.68,424.94 239.78,424.94 238.77,423.94 238.73,423.94 238.35,423.56 238.35,422.73 238.52,422.56 238.52,422.02 238.12,421.62 238.12,420.95 239.14,419.94 239.27,419.94 239.85,419.35 240.4,419.35 240.98,419.94 241.52,419.94 242.52,418.94 242.64,418.94 243.64,417.94 243.77,417.94 244.25,417.46 244.41,417.46 245.41,416.46 246.09,416.46 246.57,416.94 247.14,416.94 247.61,416.47 248.13,416.47 248.78,417.12 249.47,417.12 250.17,416.41 250.59,416.41 251.11,416.94 251.67,416.94 253.57,415.04 253.57,392.2 248.04,386.66 248.04,368.01 178.8,298.78 178.8,289.88 181.57,287.11 181.57,277.97 179.09,275.49 178.04,275.49 172.53,269.97 172.53,260.61 168.77,256.85 168.77,246.25 168.13,245.61 162.18,245.61 161.16,244.59 161.16,239.32 159.61,237.77 155.3,237.77 154.7,237.17 154.7,236.91 154.7,228.98 151.78,226.06 151.78,220.47 152.73,219.53 152.73,215.57 152.53,215.38 152.53,212.8 v1(153.15,212.18)
SL13_DP_86: length 273.4
  L03_DP w0.079: SLOT13.C31 244.27,425.94 243.23,425.94 242.85,425.56 242.85,425.02 243.09,424.77 243.09,424.05 242.68,423.64 241.94,423.64 241.64,423.94 240.69,423.94 240.39,423.64 239.87,423.64 239.65,423.42 239.65,423.02 239.27,422.64 238.87,422.64 238.71,422.47 238.71,421.94 238.31,421.54 238.31,421.03 239.22,420.12 239.34,420.12 239.93,419.53 240.33,419.53 240.91,420.12 241.59,420.12 242.59,419.12 242.72,419.12 243.72,418.12 243.84,418.12 244.32,417.64 244.48,417.64 245.48,416.64 246.02,416.64 246.5,417.12 246.91,417.12 247.73,417.94 248.27,417.94 248.91,417.3 249.34,417.3 249.98,417.94 250.52,417.94 251.08,417.37 251.48,417.37 253.9,414.96 253.9,391.95 248.44,386.5 248.44,367.87 181.88,301.32 181.88,277.7 180.19,276.01 180.19,273.88 177.11,270.8 177.11,260.92 176.56,260.37 172.85,260.37 169.17,256.69 169.17,246.12 166.44,243.4 162.26,243.4 161.48,242.62 161.48,239.2 159.74,237.46 155.43,237.46 155.02,237.04 155.02,228.48 156.38,227.12 156.38,225.82 v1(153.15,222.59)
