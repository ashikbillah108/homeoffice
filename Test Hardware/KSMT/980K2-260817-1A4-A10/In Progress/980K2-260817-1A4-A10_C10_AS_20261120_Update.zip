# Allegro board 980K2-260817_261120-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL06_DP_64: length 163.9
  L30_DP w0.079: v1(186.06,193.35) 185.58,192.88 185.58,189.82 189.57,185.84 189.57,176.61 191.35,174.83 198.88,174.83 201.17,172.53 201.17,171.97 201.63,171.51 201.63,69.49 187.71,55.57 187.47,55.57 187.15,55.57 186.98,55.4 186.92,55.34 180.96,55.34 180.32,54.7 179.68,54.7 179.67,54.69 SLOT06.A37
SL06_DP_65: length 147.4
  L28_DP w0.079: UNK6K15.2 175.28,182.35 181.23,176.4 181.23,127.58 190.88,117.93 190.88,93.45 190.92,93.25 190.92,92.17 190.32,89.13 190.32,59.88 185.3,54.86 182.31,54.86 181.49,54.04 180.96,54.04 180.39,54.61 179.81,54.61 179.24,54.04 178.71,54.04 178.07,54.68 176.73,54.68 SLOT06.B37
SL06_DP_66: length 175.9
  L30_DP w0.079: SLOT06.C37 174.64,54.52 175.94,54.52 176.42,54.04 177.03,54.04 177.26,54.27 177.51,54.52 178.19,54.52 178.83,53.88 179.12,53.88 179.76,54.52 180.44,54.52 180.95,54.01 181.46,54.01 181.77,54.32 186.3,54.32 187.26,55.28 187.36,55.28 187.82,55.28 201.92,69.38 201.92,171.63 201.46,172.09 201.46,175.91 201.22,176.14 191.27,176.14 190.03,177.38 190.03,187.32 189.03,188.32 189.02,188.32 188.75,188.6 188.75,188.61 187.5,189.86 187.5,195.28 187.71,195.5 187.71,197.67 v1(188.22,198.18)
SL06_DP_67: length 172.1
  L30_DP w0.079: v1(188.22,193.35) 190.35,191.22 190.35,189.59 192.54,187.4 192.54,178.52 193.69,177.38 200.38,177.38 201.74,176.02 201.74,172.2 202.2,171.74 202.2,69.26 187.94,55 187.38,55 186.41,54.03 181.83,54.03 181.62,53.83 180.88,53.83 180.37,54.34 179.83,54.34 179.19,53.7 178.76,53.7 178.12,54.34 177.58,54.34 176.94,53.7 176.51,53.7 175.87,54.34 175.33,54.34 174.69,53.7 174.27,53.7 173.62,54.36 172.56,54.36 SLOT06.D37
SL06_DP_68: length 174.3
  L30_DP w0.079: SLOT06.E37 169.97,53.9 171.01,52.86 171.22,52.86 171.88,53.52 172.57,53.52 173.23,52.86 173.47,52.86 174.13,53.52 174.82,53.52 175.41,52.93 175.79,52.93 176.38,53.52 177.07,53.52 177.55,53.04 178.12,53.04 178.6,53.52 179.32,53.52 179.89,52.95 180.31,52.95 181.01,53.65 186.57,53.65 187.64,54.72 188.06,54.72 202.48,69.14 202.48,171.86 202.02,172.32 202.02,176.14 200.5,177.66 200.27,177.66 196.58,177.66 195.73,178.51 195.73,187.02 193.79,188.96 192.66,188.96 191.54,190.09 191.54,192.83 v1(191.01,193.35)
SL06_DP_69: length 178.9
  L30_DP w0.079: SLOT06.F37 168.95,54.69 169.79,53.85 169.79,53.83 170.94,52.68 171.3,52.68 171.96,53.34 172.49,53.34 173.15,52.68 173.55,52.68 174.21,53.34 174.74,53.34 175.34,52.75 175.86,52.75 176.46,53.34 176.99,53.34 177.58,52.75 178.12,52.75 178.71,53.34 179.24,53.34 179.83,52.75 180.37,52.75 180.96,53.35 187.08,53.35 202.76,69.03 202.76,171.98 202.3,172.44 202.3,176.26 200.57,177.99 198.64,177.99 197.04,179.58 197.04,186.45 194.82,188.68 194.82,196.53 v1(193.17,198.18)
SL06_DP_70: length 373.4
  L28_DP w0.079: SLOT06.A35 180.31,52.69 180.96,53.34 181.49,53.34 182.14,52.69 184.82,52.69 192.34,60.22 192.34,118.09 181.64,128.79 181.64,199.66 184.42,202.44 184.42,223.32 185.85,224.75 191.7,224.75 192.89,223.56 197.5,223.56 198.21,224.27 199.08,224.27 200.38,225.58 203.85,225.58 207.08,228.81 227.38,228.81 228.99,230.42 241.55,230.42 242.45,231.33 242.62,231.49 251.06,231.49 251.06,231.49 251.3,231.49 251.3,231.49 251.32,231.49 ; 251.32,227.71 239.54,227.71 239.45,227.8 239.05,227.8 239.03,227.78 235.71,227.78 235.68,227.8 235.29,227.8 235.27,227.78 234.39,227.78 234.37,227.8 233.97,227.8 233.95,227.78 231.91,227.78 231.21,227.08 231.21,227.08 230.94,226.8 230.93,226.8 227.3,223.17 227.13,223.17 226.86,222.9 226.86,222.73 216.65,212.53 199.46,212.53 196.86,209.93 196.86,198.83 194.72,196.69 194.72,194.9 v1(193.17,193.35)
  L28_DP w0.102: 251.32,231.49 253.93,231.49 256.02,233.58 262.13,233.58 266.49,229.22 266.49,227.16 265.36,226.04 265.35,226.04 265.27,225.96 255.78,225.96 254.03,227.71 251.32,227.71
SL06_DP_71: length 180.9
  L28_DP w0.079: UNK6K23.2 189.61,180.78 189.61,177.47 185.94,173.79 185.94,127.68 194.6,119.02 194.6,51.98 190.36,47.74 181,47.74 180.4,48.34 179.8,48.34 179.32,47.86 178.6,47.86 178.12,48.34 177.58,48.34 177.1,47.86 176.35,47.86 175.87,48.34 175.33,48.34 174.8,47.81 174.15,47.81 173.62,48.34 173.08,48.34 172.26,47.52 171.88,47.52 171.39,47.03 171.1,47.03 171.03,46.96 170.62,46.96 170.24,47.34 169.71,47.34 169.28,46.92 168.58,46.92 167.08,48.42 167.08,48.96 167.46,49.34 167.58,49.34 168.58,50.34 168.67,50.34 171.67,53.34 172.78,53.34 173.08,53.04 173.62,53.04 173.92,53.34 174.74,53.34 175.39,52.69 SLOT06.B35
SL06_DP_72: length 153.2
  L30_DP w0.079: SLOT06.C35 174.64,52.52 175.94,52.52 176.42,52.04 177.03,52.04 177.26,52.27 177.51,52.52 178.19,52.52 178.83,51.88 179.12,51.88 179.76,52.52 180.44,52.52 180.95,52.01 181.46,52.01 181.77,52.32 188.04,52.32 203.72,68 203.72,176.56 201.63,178.65 201.63,180.16 UNK6K24.2
SL06_DP_73: length 169
  L30_DP w0.079: SLOT06.D35 172.56,52.36 173.62,52.36 174.27,51.7 174.69,51.7 175.33,52.34 175.87,52.34 176.51,51.7 176.94,51.7 177.58,52.34 178.12,52.34 178.76,51.7 179.19,51.7 179.83,52.34 180.37,52.34 180.88,51.83 181.62,51.83 181.83,52.03 188.16,52.03 204,67.88 204,179.24 201.28,181.96 201.28,188.54 v1(196.47,193.35)
SL06_DP_74: length 181
  L30_DP w0.079: v1(203.84,200.87) 208.07,196.64 208.07,187.55 204.28,183.76 204.28,67.76 188.18,51.65 181.01,51.65 180.31,50.95 179.89,50.95 179.32,51.52 178.63,51.52 177.99,50.88 177.71,50.88 177.07,51.52 176.38,51.52 175.79,50.93 175.41,50.93 174.82,51.52 174.13,51.52 173.47,50.86 173.23,50.86 172.57,51.52 171.88,51.52 171.22,50.86 171.01,50.86 169.97,51.9 SLOT06.E35
SL06_DP_75: length 182
  L30_DP w0.079: v1(208.42,200.87) 208.91,200.37 208.91,198.98 208.36,198.42 208.36,187.43 204.57,183.64 204.57,67.64 188.29,51.37 180.98,51.37 180.31,50.7 179.89,50.7 179.24,51.34 178.71,51.34 178.06,50.7 177.64,50.7 176.99,51.34 176.46,51.34 175.86,50.75 175.34,50.75 174.74,51.34 174.21,51.34 173.55,50.68 173.15,50.68 172.49,51.34 171.96,51.34 171.3,50.68 170.9,50.68 169.23,52.36 168.06,52.36 SLOT06.F35
SL06_DP_76: length 177.1
  L30_DP w0.079: v1(203.84,204.68) 202.97,203.81 195.96,203.81 195.1,202.94 195.1,188.79 197.52,186.37 197.52,181.78 198.14,181.16 199.4,181.16 200.77,179.79 200.77,179.12 203.44,176.44 203.44,68.11 188.02,52.69 SLOT06.Z35
SL06_DP_77: length 169.9
  L30_DP w0.079: v1(208.42,204.68) 208.42,202.6 209.19,201.83 209.19,187.87 204.85,183.52 204.85,67.53 188.01,50.69 SLOT06.Z33
SL06_DP_78: length 181.5
  L30_DP w0.079: SLOT06.A33 178.97,49.9 179.83,49.04 180.66,49.04 180.96,49.34 187.06,49.34 205.13,67.41 205.13,183.41 209.64,187.91 209.64,203.17 209.21,203.6 209.21,205.72 208.46,206.47 205.1,206.47 v1(203.84,207.72)
SL06_DP_79: length 182.5
  L30_DP w0.079: SLOT06.B33 176.72,49.87 177.63,48.96 178.33,48.96 178.71,49.34 179.24,49.34 179.62,48.96 179.62,48.66 179.76,48.52 180.48,48.52 180.96,48.04 181.58,48.04 181.73,48.19 186.31,48.19 205.41,67.29 205.41,183.29 209.92,187.8 209.92,198.98 210.68,199.74 210.68,205.85 208.81,207.72 v1(208.42,207.72)
SL06_DP_80: length 192.8
  L30_DP w0.079: SLOT06.C33 174.47,49.81 175.59,48.7 175.82,48.7 176.46,49.34 176.99,49.34 177.37,48.96 177.37,48.53 177.56,48.34 178.12,48.34 178.55,47.91 179.39,47.91 179.83,48.34 180.37,48.34 180.97,47.74 181.56,47.74 181.73,47.91 186.42,47.91 205.69,67.18 205.69,183.17 210.2,187.68 210.2,198.86 210.96,199.63 210.96,206.05 209.55,207.46 209.55,208.42 208.38,209.58 205.03,209.58 v1(203.84,210.77)
SL06_DP_81: length 200
  L30_DP w0.079: SLOT06.D33 172.52,50.4 173.56,50.4 174,49.96 174,49.14 173.83,48.96 173.83,48.42 174.29,47.96 174.69,47.96 175.26,48.52 175.94,48.52 176.85,47.62 176.97,47.62 177.55,47.04 177.55,46.94 177.63,46.86 177.96,46.86 178.63,47.52 179.32,47.52 179.8,47.04 180.4,47.04 180.88,47.52 181.62,47.52 181.73,47.62 186.54,47.62 205.98,67.06 205.98,183.06 210.48,187.56 210.48,198.75 212.57,200.83 212.57,205.59 210.95,207.2 210.95,208.89 207.69,212.16 205.1,212.16 v1(203.84,213.41)
SL06_DP_82: length 214.6
  L30_DP w0.079: SLOT06.E33 170.21,50.46 171.26,50.46 172.19,49.52 172.57,49.52 173.05,49.04 173.05,48.66 173.37,48.34 173.62,48.34 174.26,47.7 174.69,47.7 175.33,48.34 175.87,48.34 176.87,47.34 176.99,47.34 177.37,46.96 177.37,46.84 177.87,46.34 178.12,46.34 178.5,45.96 179.19,45.96 179.76,46.52 180.14,46.52 180.96,47.34 186.66,47.34 206.26,66.94 206.26,182.94 210.76,187.45 210.76,198.63 212.85,200.71 212.85,203.02 213.86,204.03 213.86,209.29 208.12,215.03 199.31,215.03 196.46,212.18 v1(196.08,212.18)
SL06_DP_83: length 222.6
  L30_DP w0.079: SLOT06.F33 167.72,49.89 168.57,49.04 169.15,49.04 169.63,49.52 170.35,49.52 170.83,49.04 171.37,49.04 171.67,49.34 172.49,49.34 172.87,48.96 172.87,48.42 172.7,48.25 172.7,47.42 173.11,47.01 173.62,47.01 174.13,47.52 174.82,47.52 175.37,46.97 175.82,46.52 175.94,46.52 176.94,45.52 177.07,45.52 177.55,45.04 178.15,45.04 178.63,45.52 179.01,45.52 179.83,46.34 180.37,46.34 181,45.72 185.43,45.72 206.54,66.83 206.54,182.82 211.05,187.33 211.05,198.51 215.23,202.7 215.23,210.86 210.17,215.93 196.89,215.93 v1(196.08,216.75)
SL06_DP_84: length 197.7
  L28_DP w0.079: v1(196.08,221.32) 193.76,219 193.76,212.01 193,211.25 191.68,211.25 190.65,212.28 188.23,212.28 186.25,210.3 186.25,196.91 186.44,196.72 186.44,196.72 186.53,196.62 186.53,196.23 186.44,196.14 186.44,196.09 184.84,194.49 184.84,189.28 185.02,189.11 185.02,188.48 184.84,188.3 184.84,127.58 193.75,118.67 193.75,54.26 188.13,48.64 182.19,48.64 181.49,49.34 180.96,49.34 180.32,48.7 179.65,48.7 179.64,48.69 SLOT06.A31
SL06_DP_85: length 189.5
  L28_DP w0.079: v1(193.15,212.18) 192.57,212.76 187.89,212.76 185.9,210.77 185.9,196.94 184.21,195.25 184.21,189.41 183.58,188.78 183.58,187.08 184.21,186.45 184.21,127.81 193.47,118.56 193.47,54.45 188.17,49.15 182.09,49.15 181.71,49.52 180.88,49.52 180.31,48.95 179.64,48.95 179.24,49.34 178.71,49.34 178.07,48.7 177.4,48.7 177.39,48.69 SLOT06.B31
SL06_DP_86: length 209.3
  L28_DP w0.079: SLOT06.C31 174.51,48.66 175.1,48.66 175.15,48.7 175.82,48.7 176.46,49.34 176.99,49.34 177.33,49.01 178.12,49.01 178.97,49.86 179.32,49.86 179.44,49.99 179.47,49.99 179.83,50.34 180.37,50.34 180.96,49.75 182.02,49.75 182.19,49.58 188.21,49.58 193.19,54.56 193.19,118.44 183.47,128.16 183.47,183.76 183.73,184.03 183.73,185.83 183.23,186.34 183.23,189.49 183.73,189.99 183.73,191.8 183.47,192.06 183.47,194.55 183.73,194.82 183.73,195.8 185.42,197.49 185.42,211.18 187.4,213.17 191.38,213.17 191.81,213.6 191.81,215.23 190.91,216.13 187.53,216.13 186.43,217.23 186.43,218.8 189.56,221.93 192.49,221.93 v1(193.15,222.59)
SL06_DP_87: length 193.1
  L28_DP w0.079: v1(190.74,213.7) 187.2,213.7 185.02,211.51 185.02,198.23 183.69,196.9 183.07,196.9 182.79,196.62 182.79,128.43 192.9,118.32 192.9,54.86 188.07,50.03 187.84,50.03 187.84,50.03 180.93,50.03 180.44,50.52 179.76,50.52 179.4,50.17 179.37,50.17 179.24,50.04 178.9,50.04 178.81,49.96 178.5,49.96 178.12,50.34 177.58,50.34 177.2,49.96 177.2,49.87 176.85,49.52 176.38,49.52 175.75,48.89 175.19,48.89 174.74,49.34 174.21,49.34 173.57,48.7 172.9,48.7 172.89,48.69 SLOT06.D31
SL06_DP_88: length 205.6
  L28_DP w0.079: SLOT06.E31 170.64,48.69 170.72,48.78 171.39,48.78 171.96,49.34 172.49,49.34 172.8,49.03 173.64,49.03 174.13,49.52 174.51,49.52 175.33,50.34 175.87,50.34 176.51,49.7 176.78,49.7 177.02,49.95 177.02,50.04 177.51,50.52 178.25,50.52 178.33,50.6 178.33,50.96 178.71,51.34 179.24,51.34 179.88,50.7 180.32,50.7 180.96,51.34 181.49,51.34 182.52,50.31 187.96,50.31 192.62,54.98 192.62,118.21 182.05,128.78 182.05,196.38 183.69,198.02 183.69,198.57 184.7,199.58 184.7,219.25 188.6,223.14 189.77,223.14 189.92,223.29 190.15,223.29 190.74,223.89 v1(190.74,224.11)
SL06_DP_89: length 220.5
  L28_DP w0.079: SLOT06.F31 169.06,48.69 169.71,48.04 170.24,48.04 170.79,48.6 171.37,48.6 171.92,48.04 172.49,48.04 172.97,48.52 173.69,48.52 174.17,48.04 174.74,48.04 175.22,48.52 175.94,48.52 176.42,48.04 176.99,48.04 177.47,48.52 178.19,48.52 178.67,48.04 179.24,48.04 179.72,48.52 180.48,48.52 180.58,48.43 180.58,48.42 180.96,48.04 181.38,48.04 181.4,48.02 190.14,48.02 194.31,52.2 194.31,118.91 185.65,127.57 185.65,177.64 186.31,178.3 186.31,189.77 186.53,189.99 186.53,190.39 186.31,190.61 186.31,191.19 187.75,192.62 187.75,194.22 188.07,194.54 188.41,194.54 188.69,194.82 188.69,195.16 191.44,197.92 191.44,198.37 191.72,198.65 192.17,198.65 192.53,199.01 192.53,203.08 193.17,203.72 193.17,209.7 194.7,211.24 194.7,212.37 194.98,212.65 195.3,212.65 196.11,213.45 196.27,213.45 196.55,213.73 196.55,213.89 197.79,215.14 197.79,220.97 196.66,222.1 194.74,222.1 193.22,220.58 191.57,220.58 189.26,218.27 v1(188.33,218.27)
SL06_DP_90: length 292.2
  L28_DP w0.079: SLOT06.Z31 181.56,48.36 190.07,48.36 194.03,52.32 194.03,118.79 185.37,127.45 185.37,177.76 185.54,177.92 185.97,178.36 185.97,189.07 185.44,189.61 185.44,193.44 187.41,195.41 187.41,196.29 188.61,197.49 189.1,197.49 192.16,200.55 192.16,209.36 194.17,211.37 194.17,216.41 195.48,217.72 196.29,217.72 196.88,218.31 196.88,221.49 196.55,221.82 194.86,221.82 193.34,220.3 192.93,220.3 189.8,217.16 187.29,217.16 186.76,217.7 186.76,218.64 187.23,219.11 188.61,219.11 190.1,220.6 191,220.6 191.46,221.06 192.25,221.06 193.04,221.85 194.07,221.85 194.62,222.39 197.6,222.39 200.5,225.3 203.97,225.3 207.19,228.53 227.5,228.53 229.11,230.14 241.66,230.14 242.72,231.2 251.18,231.2
  L28_DP w0.102: v1(265.41,226.99) 263.78,228.63 255.49,228.63 252.93,231.19 251.19,231.19 251.18,231.2
SL06_DP_91: length 199.6
  L28_DP w0.079: v1(260.83,206.69) 260.41,206.69 255.59,201.87 254.89,201.87 250.2,197.18 250.2,177.45 195.95,123.2 195.95,121.45 195.44,120.94 195.44,50.81 194.86,50.23 194.86,50.21 191.35,46.69 SLOT06.Z29
SL06_DP_92: length 201
  L28_DP w0.079: SLOT06.A29 179.14,46.53 180.47,46.53 180.96,46.04 181.49,46.04 181.86,46.41 191.23,46.41 191.46,46.41 195.14,50.09 195.14,50.11 195.72,50.69 195.72,120.82 196.46,121.56 196.46,122.56 251.01,177.11 251.01,195.84 255.86,200.68 255.86,201.53 257.94,203.61 259.78,203.61 v1(260.83,204.66)
SL06_DP_93: length 199.8
  L28_DP w0.079: SLOT06.B29 176.81,46.61 177.3,46.61 177.39,46.69 178.06,46.69 178.71,47.34 179.24,47.34 179.87,46.71 180.32,46.71 180.96,47.34 181.49,47.34 181.78,47.06 190.82,47.06 195.16,51.4 195.16,121.06 195.58,121.47 195.58,124.55 249.77,178.75 249.77,197.66 255.79,203.68 255.79,204.19 v1(256.26,204.66)
SL06_DP_94: length 265
  L30_DP w0.079: v1(266.06,193.35) 266.91,194.2 266.91,195.81 268.12,197.02 269.41,197.02 269.93,197.54 269.93,198.6 269.46,199.08 266.68,199.08 264.68,197.08 264.68,190.24 265.02,189.9 265.02,178 272.18,170.84 272.18,167.65 271.31,166.78 267.39,166.78 212.48,111.87 212.48,47.01 212.15,46.68 211.98,46.51 209.9,44.43 209.9,44.43 200.98,35.51 200.28,35.51 200.28,35.51 182.68,35.51 181.87,34.7 181.87,34.42 181.49,34.04 180.96,34.04 180.32,34.68 179.88,34.68 179.24,34.04 178.71,34.04 178.21,34.54 177.49,34.54 176.99,34.04 176.46,34.04 176.08,34.42 176.08,34.57 175.61,35.04 175.33,35.04 174.69,35.68 174.26,35.68 173.62,35.04 173.08,35.04 172.44,35.68 172.01,35.68 171.37,35.04 170.83,35.04 170.45,35.42 170.45,35.7 170.11,36.04 169.71,36.04 169.33,36.42 169.33,36.77 169.05,37.04 168.58,37.04 168.2,37.42 168.2,37.82 167.97,38.04 167.46,38.04 167.08,38.42 167.08,38.96 167.33,39.21 167.33,39.92 166.9,40.35 166.9,40.89 166.89,40.89 166.89,41.04 167.38,41.52 168.12,41.52 168.2,41.6 168.2,41.96 168.58,42.34 169.12,42.34 169.76,41.7 170.19,41.7 170.83,42.34 171.49,42.34 171.58,42.42 171.58,42.96 171.75,43.14 171.75,43.96 171.83,44.04 172.49,44.04 172.87,44.42 172.87,44.96 172.73,45.11 172.73,45.4 172.7,45.42 172.7,45.96 173.22,46.48 174.27,46.48 SLOT06.C29
SL06_DP_95: length 183.2
  L28_DP w0.079: UNK8K15.2 252.07,180.76 252.07,176.76 196.01,120.7 196.01,50.34 191.64,45.97 181.68,45.97 181.57,45.86 180.88,45.86 180.74,46.01 180.7,46.01 180.37,46.34 179.83,46.34 179.49,46.01 178.74,46.01 178.24,46.51 177.46,46.51 176.86,45.91 176.56,45.91 175.94,46.52 175.26,46.52 174.64,45.91 174.05,45.91 173.62,46.34 173.08,46.34 173.03,46.29 172.63,46.29 SLOT06.D29
SL06_DP_96: length 285.7
  L30_DP w0.079: v1(268.22,198.18) 267.51,197.47 265.88,197.47 265.25,196.85 265.25,193.09 265.26,193.09 265.26,190.46 265.59,190.13 265.59,178.23 272.74,171.08 272.74,167.41 271.54,166.21 267.62,166.21 213.04,111.63 213.04,46.26 181.42,14.64 168.61,14.64 158.05,25.2 158.05,38.18 166.63,46.76 166.89,46.76 167.08,46.94 167.08,46.96 167.46,47.34 167.99,47.34 168.64,46.69 SLOT06.E29
SL06_DP_97: length 263.6
  L30_DP w0.079: v1(268.22,193.35) 267.57,192.71 266.04,192.71 265.53,193.21 265.53,196.57 265.86,196.9 267.34,196.9 267.84,197.4 269.37,197.4 269.59,197.62 269.59,198.37 269.31,198.65 266.65,198.65 264.97,196.96 264.97,192.98 264.98,192.97 264.98,190.34 265.31,190.01 265.31,178.11 272.46,170.96 272.46,167.53 271.43,166.49 267.5,166.49 212.76,111.75 212.76,46.69 200.84,34.77 182.62,34.77 181.71,33.86 180.88,33.86 180.24,34.5 179.96,34.5 179.32,33.86 178.63,33.86 178.14,34.36 177.56,34.36 177.07,33.86 176.38,33.86 175.48,34.77 175.32,34.77 174.74,35.34 174.21,35.34 173.63,34.77 173.07,34.77 172.49,35.34 171.96,35.34 171.48,34.86 170.76,34.86 169.76,35.86 169.63,35.86 168.63,36.86 168.51,36.86 167.51,37.86 167.38,37.86 164.03,41.21 164.03,42.41 166.67,45.04 166.87,45.04 167.72,45.9 SLOT06.F29
SL06_DP_98: length 352.3
  L30_DP w0.079: SLOT06.A27 179.04,44.76 180.38,44.76 180.96,45.34 181.51,45.34 182.01,44.85 185.36,44.85 207.1,66.59 207.1,140.48 226.74,160.12 239.83,160.12 247.94,168.23 247.94,183.9 243.36,188.48 240.4,188.48 237.77,191.11 237.77,193.08 237.84,193.16 237.84,198.42 238.54,199.12 238.54,218.03 237.22,219.35 237.22,226.92 241.47,231.16 252.41,231.16 254.13,232.89 254.13,235.35 254.42,235.63 256.2,237.41 260.33,237.41 260.89,236.85 269.53,236.85 270,236.38 284.44,236.38 293.22,227.6 293.22,201.65 290.84,199.27 285.99,199.27 284.87,200.39 282.24,200.39 282.22,200.41 282.22,200.41 281.95,200.68 281.88,200.68 281.22,201.34 279.51,201.34 279.47,201.3 279.08,201.3 279.03,201.34 277.06,201.34 274.66,198.93 274.66,193.12 274.42,192.88 271.48,192.88 v1(271.01,193.35)
SL06_DP_99: length 328.6
  L30_DP w0.079: SLOT06.B27 176.89,44.53 178.1,44.53 178.59,44.04 179.28,44.04 179.76,44.52 180.48,44.52 181.01,43.99 185.23,43.99 185.52,44.29 185.59,44.29 207.67,66.36 207.67,140.2 226.7,159.23 240.24,159.23 249.02,168.01 249.02,202.37 248.69,202.69 248.69,203.09 249.02,203.41 249.02,205.78 248.41,206.39 248.41,207.01 248.89,207.49 248.89,213.72 248.48,214.12 248.48,225.3 254.7,231.51 254.7,235.11 254.98,235.4 254.98,235.4 256.06,236.48 260.4,236.48 261.91,234.97 284.93,234.97 292.61,227.28 292.61,202.25 290.64,200.27 290.27,199.91 287.24,199.91 285.22,201.93 284.34,201.93 284.04,202.24 277.97,202.24 277.93,202.19 277.19,202.19 v1(273.17,198.18)
SL06_DP_100: length 338.9
  L30_DP w0.079: SLOT06.C27 174.47,44.09 174.95,43.62 174.95,43.42 175.33,43.04 176.16,43.04 176.46,43.34 177.26,43.34 177.55,43.04 178.15,43.04 178.85,43.74 179.23,43.74 179.83,44.34 180.37,44.34 181,43.71 185.11,43.71 185.34,43.71 185.64,44 185.71,44 207.95,66.24 207.95,140.08 226.81,158.94 240.35,158.94 249.3,167.89 249.3,202.36 249.64,202.69 249.64,203.09 249.3,203.42 249.3,205.9 248.69,206.5 248.69,206.9 249.17,207.37 249.17,213.83 248.98,214.02 248.98,214.88 249.3,215.19 249.3,225.72 254.98,231.4 254.98,235 255.26,235.28 256.18,236.2 260.28,236.2 261.87,234.61 284.89,234.61 292.33,227.17 292.33,202.36 290.15,200.19 288.43,200.19 288.22,200.39 288.22,200.39 287.94,200.67 287.94,200.67 286.4,202.22 284.46,202.22 283.47,203.21 275.11,203.21 272.7,200.8 272.7,193.82 v1(273.17,193.35)
SL06_DP_101: length 359.4
  L30_DP w0.079: UNK8K23.2 273.18,184.35 273.18,187.54 275.13,189.5 275.13,198.59 276.93,200.39 281.84,200.39 282.1,200.13 282.11,200.13 282.12,200.11 284.75,200.11 285.88,198.99 290.96,198.99 293.5,201.53 293.5,227.72 283.9,237.33 262.87,237.33 261.79,238.41 260.3,238.41 259.59,237.7 256.08,237.7 253.85,235.47 253.85,233.01 252.29,231.44 241.35,231.44 234.59,224.68 234.59,191.32 236.57,189.33 236.57,183.9 237.49,182.98 237.49,174.13 237.24,173.89 237.24,168.91 237.26,168.89 237.26,168.5 237.24,168.49 237.24,162.42 235.22,160.4 226.62,160.4 206.82,140.6 206.82,66.71 185.24,45.13 182.12,45.13 181.73,45.52 180.88,45.52 180.3,44.94 179.64,44.94 179.24,45.34 178.71,45.34 178.1,44.74 177.6,44.74 176.99,45.34 176.87,45.34 175.87,46.34 175.74,46.34 174.74,47.34 174.21,47.34 173.53,46.66 173.15,46.66 172.22,45.74 SLOT06.D27
SL06_DP_102: length 290.8
  L30_DP w0.079: 279.43,182.35 UNK8K24.2 280.89,180.9 280.89,175.47 275.02,169.6 275.02,169.43 275.02,166.25 274.14,165.37 273.9,165.37 273.9,165.37 267.97,165.37 213.89,111.28 213.89,37.35 190.2,13.67 166.55,13.67 156.17,24.05 156.17,40.63 162.68,47.14 163.84,47.14 163.86,47.16 165.41,47.16 165.52,47.28 165.67,47.28 165.77,47.38 165.77,48.04 166.26,48.52 166.94,48.52 167.01,48.46 167.04,48.46 167.56,47.94 167.92,47.94 168.51,48.52 169.19,48.52 170.01,47.7 170.19,47.7 170.83,48.34 171.37,48.34 171.75,47.96 171.75,47.42 171.33,47.01 171.33,46.38 171.75,45.96 171.75,45.42 171.37,45.04 170.33,45.04 SLOT06.E27
SL06_DP_103: length 315.1
  L30_DP w0.079: v1(276.47,193.35) 281.2,188.62 281.2,174.49 276.2,169.5 276.2,165.72 274.08,163.6 266.61,163.6 214.17,111.17 214.17,36.67 190.89,13.39 165.83,13.39 155.88,23.34 155.88,41.36 162.21,47.69 165.16,47.69 166.18,48.7 166.82,48.7 167.46,49.34 167.99,49.34 168.63,48.7 169.07,48.7 169.71,49.34 170.24,49.34 171.06,48.52 171.44,48.52 171.93,48.04 171.93,47.89 171.93,47.32 171.54,46.92 171.54,46.46 172.04,45.96 172.04,45.46 171.44,44.86 171.06,44.86 170.45,44.25 170.45,43.42 170.63,43.24 170.63,42.4 170.25,42.01 169.7,42.01 169.19,42.52 168.47,42.52 167.99,42.04 167.46,42.04 166.98,42.52 166.98,43.15 167.72,43.9 SLOT06.F27
SL06_DP_104: length 311.3
  L30_DP w0.079: SLOT06.Z27 181.64,44.27 184.54,44.27 184.83,44.57 185.48,44.57 207.38,66.48 207.38,140.37 226.85,159.84 239.95,159.84 248.4,168.29 248.4,200.21 247.61,201.01 247.61,223.18 247.97,224.06 248.03,224.34 248.03,224.49 248.03,224.64 247.97,224.92 247.94,224.99 247.94,225.45 254.42,231.92 254.42,235.23 254.7,235.51 255.95,236.76 260.51,236.76 261.36,235.91 264.78,235.91 265.22,235.47 265.61,235.47 266.05,235.91 271.2,235.91 271.21,235.92 278.71,235.92 278.71,235.91 284.38,235.91 292.89,227.4 292.89,202.13 290.39,199.62 286.1,199.62 284.86,200.87 v1(283.84,200.87)
SL06_DP_105: length 305
  L30_DP w0.079: SLOT06.Z25 185.46,42.69 185.63,42.86 185.69,42.86 185.99,43.16 186.06,43.16 208.3,65.4 208.79,65.89 208.79,139.73 227.16,158.1 240.7,158.1 241.2,158.59 250.15,167.54 250.15,168.01 250.15,199.78 251.23,200.86 251.23,201.78 251.11,201.9 251.11,207.92 251.64,208.45 251.64,214.36 250.15,215.85 250.15,225.33 256.24,231.43 260.45,231.43 261.66,232.64 285.57,232.64 291.1,227.11 291.1,209.32 289.97,208.2 289.97,208.2 289.69,207.92 289.69,207.92 288.21,206.43 283.97,206.43 282.94,205.4 282.94,204.1 283.36,203.68 285.6,203.68 v1(288.42,200.87)
SL06_DP_106: length 302.1
  L30_DP w0.079: v1(283.84,204.68) 285.22,206.05 289.82,206.05 291.11,207.33 291.11,207.92 291.51,208.33 291.51,227.19 285.51,233.19 260.69,233.19 260.26,233.63 256.21,233.63 255.54,232.96 255.54,231.16 249.86,225.48 249.86,215.7 250.64,214.92 250.64,210.28 250.55,210.19 250.55,209.8 250.64,209.7 250.64,201.97 250.95,201.66 250.95,200.98 249.86,199.9 249.86,167.89 249.86,167.66 240.92,158.71 240.59,158.38 227.05,158.38 208.51,139.85 208.51,66.01 208.18,65.68 185.94,43.44 185.87,43.44 185.58,43.15 185.42,43.15 185.35,43.07 181.76,43.07 181.49,43.34 180.96,43.34 180.41,42.8 179.08,42.8 SLOT06.A25
SL06_DP_107: length 303.7
  L30_DP w0.079: v1(288.42,204.68) 288.86,205.12 289.64,205.12 292.05,207.53 292.05,207.92 291.92,208.05 291.92,227.18 284.83,234.27 261.81,234.27 260.16,235.92 256.3,235.92 255.54,235.16 255.26,234.88 255.26,231.28 249.58,225.6 249.58,215.08 249.26,214.76 249.26,214.13 249.69,213.71 249.69,203.43 249.92,203.2 249.92,201.76 249.73,201.5 249.58,201.35 249.58,167.77 240.64,158.83 240.64,158.83 240.47,158.66 226.93,158.66 208.23,139.96 208.23,66.13 208.07,65.96 185.83,43.72 185.75,43.72 185.46,43.43 185.29,43.43 185.22,43.35 181.74,43.35 181.57,43.52 180.88,43.52 180.35,42.99 179.88,42.99 179.31,43.56 178.92,43.56 178.16,42.8 177.29,42.8 177.19,42.69 SLOT06.B25
SL06_DP_108: length 302.5
  L30_DP w0.079: v1(283.84,207.72) 284.68,206.89 288.26,206.89 290.74,209.36 290.74,226.86 285.56,232.03 263.25,232.03 260.45,229.23 254.6,229.23 250.43,225.05 250.43,215.97 252.25,214.14 252.25,203.24 251.48,202.47 251.48,201.92 251.51,201.9 251.51,200.75 250.43,199.66 250.43,168.12 250.43,168.12 250.43,167.42 241.48,158.48 240.82,157.82 227.28,157.82 209.08,139.61 209.08,65.77 208.42,65.11 186.18,42.88 186.1,42.88 185.81,42.58 185.74,42.58 185.57,42.41 181.93,42.41 181.56,42.04 180.96,42.04 180.48,42.52 179.76,42.52 179.2,41.96 178.75,41.96 178.19,42.52 177.45,42.52 177.37,42.44 177.37,42.42 176.99,42.04 176.46,42.04 175.98,42.52 175.94,42.52 175.77,42.69 SLOT06.C25
SL06_DP_109: length 297.1
  L30_DP w0.079: SLOT06.D25 173.59,42.69 173.83,42.46 173.83,42.42 174.47,41.78 174.77,41.78 175.33,42.34 175.9,42.34 176.38,41.86 177.07,41.86 177.55,42.34 178.12,42.34 178.68,41.78 179.27,41.78 179.83,42.34 180.4,42.34 180.88,41.86 181.91,41.86 182.16,42.11 185.65,42.11 185.67,42.13 185.69,42.13 185.86,42.3 185.93,42.3 186.22,42.59 186.29,42.59 208.53,64.83 208.53,64.83 209.36,65.66 209.36,139.49 227.4,157.53 240.94,157.53 241.76,158.36 250.71,167.31 250.71,168.24 250.71,168.24 250.71,199.13 252.52,200.93 252.52,202.95 252.53,202.97 252.53,214.26 250.71,216.08 250.71,224.93 254.18,228.4 260.02,228.4 262.38,230.76 284.73,230.76 290.27,225.22 290.27,209.58 v1(288.42,207.72)
SL06_DP_110: length 323.9
  L30_DP w0.079: v1(283.84,210.77) 283.2,210.77 276.93,204.51 273.35,204.51 270.49,201.65 270.49,197.31 269.88,196.7 269.88,190.3 267.69,188.11 267.69,185.15 266.31,183.77 266.31,179.82 272.16,173.97 272.16,173.5 273.31,172.35 273.31,171.08 273.31,167.18 271.78,165.65 267.85,165.65 213.6,111.4 213.6,37.47 190.09,13.95 167.37,13.95 156.75,24.57 156.75,40.36 163.23,46.84 163.94,46.84 163.98,46.88 165.52,46.88 165.95,47.31 165.95,47.96 166.33,48.34 166.87,48.34 167.51,47.7 167.94,47.7 168.58,48.34 169.12,48.34 169.94,47.52 170.32,47.52 170.8,47.04 170.8,46.35 170.48,46.03 170.48,46 169.83,45.34 169.71,45.34 169.33,44.96 169.33,44.17 169.97,43.52 SLOT06.E25
SL06_DP_111: length 322.4
  L30_DP w0.079: v1(283.84,213.41) 281.96,211.53 281.96,210.1 276.65,204.79 273.23,204.79 270.21,201.77 270.21,197.43 269.6,196.82 269.6,190.41 267.41,188.22 267.41,185.27 266.03,183.88 266.03,178.19 273.03,171.19 273.03,167.3 271.66,165.93 267.74,165.93 213.32,111.52 213.32,38 206.87,31.55 206.87,31.37 189.73,14.24 168.24,14.24 157.38,25.09 157.38,39.89 164.1,46.6 166.21,46.6 166.55,46.94 166.82,46.94 166.9,47.02 166.9,47.04 167.38,47.52 168.07,47.52 168.65,46.94 169.31,46.94 169.71,47.34 170.24,47.34 170.62,46.96 170.62,46.42 169.72,45.52 169.63,45.52 169.15,45.04 169.15,44.95 167.72,43.53 SLOT06.F25
SL06_DP_112: length 266.7
  L30_DP w0.079: v1(276.07,212.18) 275.31,211.41 271.63,211.41 271.55,211.49 271.55,212.21 272.04,212.69 273.08,212.69 274.15,213.76 274.15,225.83 273.57,226.41 268.21,226.41 268.14,226.33 268.13,226.33 268.04,226.24 265.28,226.24 261.62,222.58 261.62,200.01 261.62,200 261.62,198.72 261.07,198.17 261.07,196.49 261.7,195.85 261.7,192.32 258.61,189.22 254.6,189.22 251.27,185.9 251.27,168.47 251.27,168.47 251.27,167.07 242.33,158.13 241.17,156.97 227.63,156.97 209.92,139.26 209.92,64.1 209.76,63.93 187.5,41.68 186.83,41.68 186.7,41.55 182.75,41.55 182.44,41.24 181.59,41.24 181.49,41.34 180.96,41.34 180.47,40.86 179.14,40.86 SLOT06.A23
SL06_DP_113: length 272.3
  L30_DP w0.079: SLOT06.B23 177.2,40.22 177.2,39.42 177.58,39.04 178.12,39.04 178.94,39.86 179.32,39.86 179.8,40.35 180.65,40.35 180.96,40.04 181.49,40.04 181.63,40.18 199.96,40.18 210.3,50.52 210.3,113.01 210.3,113.01 210.3,113.71 210.3,113.94 261.29,164.92 261.29,191.5 261.82,192.03 261.99,192.2 261.99,195.97 261.35,196.61 261.35,198.05 261.9,198.61 261.9,199.89 262.79,200.78 262.79,207.84 262.08,208.55 262.08,221.43 265.89,225.24 272.92,225.24 273.87,224.29 273.87,213.88 272.96,212.97 271.92,212.97 271.27,212.32 271.27,211.38 271.44,211.21 271.52,211.13 275.7,211.13 276.55,211.98 276.55,216.28 v1(276.07,216.75)
SL06_DP_114: length 265.7
  L30_DP w0.079: SLOT06.C23 174.15,41.02 174.15,41.82 173.62,42.34 173.08,42.34 172.08,41.34 171.96,41.34 171.55,40.93 170.91,40.93 170.32,41.52 169.63,41.52 169.15,41.04 169.15,41.01 169.07,40.93 168.4,40.93 167.99,41.34 167.46,41.34 167.08,40.96 167.08,40.42 167.8,39.7 167.8,39.69 168.02,39.47 168.02,39.35 168.51,38.86 168.63,38.86 169.63,37.86 170.19,37.86 170.27,37.78 170.27,37.35 171.28,36.34 171.37,36.34 171.46,36.26 171.49,36.26 171.88,35.86 172.57,35.86 172.96,36.26 172.99,36.26 173.08,36.34 173.62,36.34 173.71,36.26 173.74,36.26 174.13,35.86 174.82,35.86 175.21,36.26 175.24,36.26 175.47,36.49 175.76,36.49 176.38,35.86 177.07,35.86 177.71,36.5 177.99,36.5 178.63,35.86 179.32,35.86 179.96,36.5 180.24,36.5 180.88,35.86 181.71,35.86 183.11,37.26 199.04,37.26 211.71,49.93 211.71,113.36 264.74,166.37 264.74,189.79 264.35,190.17 264.35,197.14 272.6,205.39 272.6,209.66 273.79,210.85 275.82,210.85 276.83,211.86 276.83,216.7 275.6,217.93 275.6,220.85 v1(276.07,221.32)
SL06_DP_115: length 268.9
  L30_DP w0.079: SLOT06.D23 173.38,40.69 174.03,40.04 174.74,40.04 175.12,40.42 175.12,40.87 175.3,41.04 175.87,41.04 176.51,41.68 176.94,41.68 177.58,41.04 178.12,41.04 178.56,41.49 179.23,41.49 179.68,41.04 180.4,41.04 180.88,41.52 182.3,41.52 182.61,41.83 186.59,41.83 186.71,41.96 187.35,41.96 187.45,42.06 187.49,42.06 209.64,64.21 209.64,139.38 227.51,157.25 241.05,157.25 242.04,158.24 242.04,158.24 250.99,167.19 250.99,168.36 250.99,168.36 250.99,186.02 254.48,189.51 258.49,189.51 261.42,192.43 261.42,195.74 260.78,196.38 260.78,198.29 261.34,198.84 261.34,222.69 265.16,226.52 267.92,226.52 268.02,226.62 268.02,226.62 268.1,226.69 273.46,226.69 273.69,226.69 274.43,225.95 274.43,213.45 v1(273.15,212.18)
SL06_DP_116: length 251.7
  L30_DP w0.079: v1(273.15,222.59) 272.55,223.2 269.47,223.2 268.17,221.9 266.43,221.9 263.26,218.73 263.26,213.19 263.27,213.18 263.27,212.86 263.26,212.85 263.26,208.17 263.63,207.8 263.63,200.75 262.72,199.83 262.72,192.13 262.25,191.66 262.25,165.09 210.86,113.71 210.86,113.24 210.86,50.28 198.69,38.11 181.55,38.11 181.49,38.04 181.37,38.04 180.37,37.04 179.83,37.04 179.26,37.62 178.69,37.62 178.12,37.04 177.58,37.04 177.01,37.62 176.48,37.62 175.9,37.04 175.3,37.04 174.3,38.04 173.92,38.04 173.62,38.34 173.49,38.34 172.49,39.34 171.83,39.34 171.75,39.42 171.75,39.96 171.37,40.34 170.64,40.34 170.22,40.77 170.05,40.77 SLOT06.E23
SL06_DP_117: length 245
  L30_DP w0.079: SLOT06.F23 168.2,40.22 168.2,39.42 168.58,39.04 168.71,39.04 169.71,38.04 170.26,38.04 170.45,37.86 170.45,37.42 171.35,36.52 171.44,36.52 171.53,36.44 171.57,36.44 171.96,36.04 172.49,36.04 173,36.55 173.7,36.55 174.21,36.04 174.74,36.04 175.13,36.44 175.17,36.44 175.4,36.67 175.83,36.67 176.46,36.04 176.99,36.04 177.63,36.68 178.07,36.68 178.71,36.04 179.24,36.04 179.88,36.68 180.32,36.68 180.96,36.04 181.49,36.04 182.99,37.54 198.92,37.54 211.43,50.05 211.43,113.48 264.29,166.33 264.29,185.84 263.53,186.6 263.53,188.72 264.07,189.27 264.07,196.69 264.02,196.74 264.02,197.21 264.29,197.48 264.29,197.49 264.71,197.91 264.71,210.95 267.46,213.7 v1(270.74,213.7)
SL06_DP_118: length 250.5
  L30_DP w0.079: SLOT06.Z23 180.56,40.69 180.42,40.55 179.75,40.55 179.24,40.04 178.5,40.04 177.76,40.79 177.45,40.79 177.37,40.87 177.37,40.96 176.97,41.37 176.48,41.37 176.08,40.96 176.08,40.29 177.51,38.86 177.85,38.86 178.69,38.03 179.26,38.03 179.76,38.52 180.14,38.52 180.96,39.34 181.49,39.34 181.78,39.06 183.42,39.06 183.88,39.51 199.69,39.51 210.58,50.4 210.58,113.13 210.58,113.83 261.88,165.12 261.88,191.7 262.27,192.08 262.27,196.09 261.63,196.73 261.63,197.94 262.18,198.49 262.18,199.73 262.63,200.19 262.67,200.19 263.15,200.67 263.15,207.88 262.52,208.51 262.52,212.82 262.48,212.86 262.48,213.18 262.52,213.22 262.52,220.34 266.93,224.75 270.11,224.75 v1(270.74,224.11)
SL06_DP_119: length 257.9
  L30_DP w0.079: v1(268.33,218.27) 264.04,213.98 264.04,200.76 263.71,200.43 263.71,198.39 263.69,198.37 263.69,197.98 263.71,197.96 263.71,196.64 263.79,196.57 263.79,192.79 262.74,191.74 262.74,165.18 211.14,113.59 211.14,113.36 211.14,50.17 198.8,37.82 181.4,37.82 180.44,36.86 179.76,36.86 179.18,37.44 178.77,37.44 178.19,36.86 177.51,36.86 176.93,37.44 176.55,37.44 175.96,36.85 175.24,36.85 174.74,37.34 174.21,37.34 173.69,36.83 173,36.83 172.49,37.34 171.93,37.34 171.75,37.52 171.75,38 171.4,38.35 171.4,38.76 171.29,38.86 170.76,38.86 170.27,39.35 170.27,39.48 169.33,40.42 169.33,40.96 169.71,41.34 170.24,41.34 171.06,40.52 171.44,40.52 172.44,39.52 172.57,39.52 173.33,38.76 173.62,38.76 174.21,39.34 174.74,39.34 175.12,38.96 175.12,38.84 175.62,38.34 175.87,38.34 175.89,38.32 176.18,38.32 176.46,38.04 177.28,38.04 177.58,38.34 178.12,38.34 178.61,37.85 179.34,37.85 179.83,38.34 180.87,38.34 SLOT06.Z21
SL06_DP_121: length 361.2
  TOP w0.381: UNK2TP_OUT+_1.1 v1(166.61,295.54)
  L28_DP w0.079: SLOT06.B21 175.39,38.69 174.74,39.34 174.21,39.34 173.57,38.7 173.13,38.7 172.49,39.34 171.96,39.34 171.34,38.73 170.86,38.73 170.24,39.34 169.71,39.34 169.11,38.75 168.59,38.75 167.99,39.34 167.46,39.34 166.77,38.66 159.18,38.66 148.07,49.77 148.07,70.49 104.46,114.11 104.46,288.41 115.53,299.48 162.68,299.48 v1(166.61,295.54)
SL06_DP_122: length 361.8
  TOP w0.381: UNK2TP_OUT-_1.1 v1(164.31,295.54)
  L28_DP w0.079: SLOT06.C21 174.72,38.45 175.76,38.45 176.27,37.94 177.06,37.94 177.42,38.3 177.42,39.11 177.19,39.34 176.17,39.34 175.87,39.04 175.33,39.04 174.85,39.52 174.13,39.52 173.56,38.95 173.14,38.95 172.57,39.52 171.88,39.52 171.31,38.95 171.28,38.95 171.23,38.91 170.94,38.91 170.32,39.52 169.78,39.52 169.63,39.52 169.03,38.93 168.66,38.93 168.07,39.52 167.38,39.52 166.8,38.94 159.52,38.94 148.75,49.71 148.75,71.07 140.16,79.67 139.88,79.67 105.12,114.42 105.12,288.09 115.78,298.75 161.1,298.75 v1(164.31,295.54)
SL06_DP_123: length 369.4
  TOP w0.381: UNK2TP_OUT+_2.1 v1(173.22,295.54)
  L28_DP w0.079: SLOT06.D21 171.93,38.39 170.88,38.39 169.83,37.34 169.71,37.34 169.33,36.96 169.33,36.84 169.01,36.52 168.47,36.52 167.99,36.04 167.46,36.04 166.98,36.52 159.44,36.52 145.67,50.3 145.67,70.56 102.72,113.51 102.72,290.18 113.71,301.17 167.59,301.17 v1(173.22,295.54)
SL06_DP_124: length 362.5
  TOP w0.381: UNK2TP_OUT-_2.1 v1(170.91,295.54)
  L28_DP w0.079: SLOT06.E21 169.5,38.22 169.5,37.42 169.12,37.04 168.58,37.04 168.45,37.17 168.16,37.17 167.99,37.34 167.46,37.34 167.07,36.96 159.56,36.96 146.23,50.29 146.23,70.79 103.32,113.7 103.32,289.61 113.97,300.26 166.2,300.26 v1(170.91,295.54)
SL06_DP_125: length 451.7
  L28_DP w0.079: v1(196.79,228.7) 193.72,231.77 193.72,233.27 194.57,234.11 194.57,237.54 192.8,239.31 192.8,246.59 194.57,248.36 194.57,269.73 198.27,273.43 198.27,277.29 197.54,278.02 197.54,287.3 189.69,295.15 180.93,295.15 180.45,295.63 179.61,295.63 179.13,295.15 177.73,295.15 177.25,295.63 176.41,295.63 175.93,295.15 173.8,295.15 173.54,294.89 170.59,294.89 170.12,295.37 169.8,295.37 165.23,299.93 114.94,299.93 103.86,288.86 103.86,113.92 147.46,70.32 147.46,49.77 158.86,38.38 167.41,38.38 SLOT06.F21
  BOTTOM w0.203: UNK2R15.1 196.79,227.38 v1(196.79,228.7)
SL06_DP_126: length 476.5
  L28_DP w0.079: v1(191.71,228.7) 192.25,229.24 195.54,229.24 196.55,228.23 197.09,228.23 197.82,228.96 197.82,230.1 195.1,232.82 195.1,238.44 195.68,239.03 195.68,257.15 197.18,258.65 197.49,258.65 198.56,259.72 198.56,277.54 197.86,278.25 197.86,290.46 187.17,301.15 187.11,301.15 185.88,302.39 113.74,302.39 102.15,290.79 102.15,113.21 145.05,70.3 145.05,50.25 159.91,35.39 165.99,35.39 166.33,35.04 166.87,35.04 167.21,35.39 168.24,35.39 168.58,35.04 169.12,35.04 169.46,35.39 170.49,35.39 170.83,35.04 171.37,35.04 171.9,35.57 172.02,35.57 173.14,36.69 173.56,36.69 174.21,37.34 174.74,37.34 175.39,36.69 SLOT06.B19
  BOTTOM w0.203: UNK2R17.1 191.71,227.38 v1(191.71,228.7)
SL06_DP_127: length 481.7
  TOP w0.381: UNK4TP_OUT+_1.1 v1(246.61,295.54)
  L28_DP w0.079: v1(246.61,295.54) 250.21,299.15 251.32,299.15 ; 267.49,299.15 314.01,299.15 341.12,272.03 341.12,113.28 279.84,52 279.84,37.12 277.72,35 276.1,35 275.76,35.34 275.23,35.34 274.89,35 273.85,35 273.51,35.34 272.98,35.34 272.53,34.9 271.71,34.9 271.26,35.34 270.73,35.34 270.14,34.76 269.6,34.76 269.01,35.34 268.48,35.34 267.94,34.81 267.3,34.81 266.76,35.34 266.23,35.34 265.66,34.78 265.12,34.78 264.55,35.34 263.98,35.34 263.04,34.41 228.73,34.41 227.98,35.16 227.69,35.16 227.5,35.34 226.97,35.34 226.73,35.11 226.44,35.11 226.25,34.92 225.77,34.92 225.58,35.11 225.49,35.11 225.25,35.34 224.72,35.34 224.34,34.96 223.38,34.96 223,35.34 222.47,35.34 222.17,35.05 221.88,35.05 221.88,35.04 221.34,35.04 221.34,35.05 221.05,35.05 220.75,35.34 220.22,35.34 219.68,34.8 219.11,34.8 218.35,35.56 217.89,35.56 217.16,34.82 216.77,34.82 216.25,35.34 215.72,35.34 215.2,34.82 215.07,34.82 214.05,33.8 180.91,33.8 180.37,34.34 179.83,34.34 179.53,34.04 178.42,34.04 178.12,34.34 177.87,34.34 177.37,34.84 177.37,34.96 176.99,35.34 176.87,35.34 175.87,36.34 175.33,36.34 175.23,36.25 174.92,36.25 SLOT06.C19
  L28_DP w0.102: 251.32,299.15 267.49,299.15
SL06_DP_128: length 368.1
  TOP w0.381: UNK4TP_OUT-_1.1 v1(244.31,295.54)
  L30_DP w0.079: SLOT06.E43 170.64,60.69 170.83,60.5 171.5,60.5 171.96,60.04 172.49,60.04 172.95,60.5 173.75,60.5 174.21,60.04 174.74,60.04 175.27,60.57 175.93,60.57 176.46,60.04 176.99,60.04 177.47,60.52 178.23,60.52 178.71,60.04 179.24,60.04 179.54,60.34 180.4,60.34 180.88,59.86 182.76,59.86 188.7,65.8 188.7,79.41 188.7,79.64 173.81,94.53 173.81,169.68 182.05,177.92 182.05,196.45 183.32,197.71 183.32,223.39 186.44,226.51 186.44,229.89 189.63,233.08 198.48,233.08 199.49,232.07 212.38,232.07 214.21,233.9 214.21,235.33 216.58,237.7 218.45,237.7 223.79,243.04 223.79,246.45 223.35,246.89 223.35,248.84 223.79,249.28 223.79,256.55 225.23,257.99 225.23,260.69 229.18,264.64 238.56,264.64 239.49,263.71 255.05,263.71 255.66,263.1 271.36,263.1 273.83,265.57 273.83,285.96 271.73,288.06 251.8,288.06 v1(244.31,295.54)
SL06_DP_129: length 365.6
  TOP w0.381: UNK4TP_OUT+_2.1 v1(253.21,295.54)
  L30_DP w0.079: v1(253.21,295.54) 254.62,294.14 254.62,290.51 256.79,288.34 271.85,288.34 274.12,286.07 274.12,265.45 271.48,262.82 255.55,262.82 254.94,263.43 239.38,263.43 238.45,264.36 229.3,264.36 225.51,260.57 225.51,257.87 224.84,257.2 224.84,243.68 218.57,237.42 216.7,237.42 214.49,235.21 214.49,233.78 212.49,231.79 199.38,231.79 198.36,232.8 189.75,232.8 186.72,229.77 186.72,226.39 183.6,223.27 183.6,197.6 182.36,196.35 182.36,177.83 174.09,169.56 174.09,94.64 188.98,79.76 188.98,79.29 188.98,79.29 188.98,65.69 188.04,64.75 188.04,64.74 182.89,59.58 181.73,59.58 181.62,59.68 181.01,59.68 180.37,59.04 179.83,59.04 179.18,59.7 178.77,59.7 178.12,59.04 177.58,59.04 176.93,59.7 176.81,59.7 175.86,58.75 175.34,58.75 174.74,59.34 174.21,59.34 173.55,58.68 173.15,58.68 172.49,59.34 171.96,59.34 171.3,58.68 170.9,58.68 169.23,60.36 168.06,60.36 SLOT06.F43
SL06_DP_130: length 396.6
  TOP w0.381: UNK4TP_OUT-_2.1 v1(250.91,295.54)
  L28_DP w0.079: 251.32,288.81 241.16,288.81 241.1,288.87 240.71,288.87 240.65,288.81 227.49,288.81 ; v1(250.91,295.54) 251.32,295.14 ; 265.33,282.57 265.46,282.44 265.61,282.44 265.93,282.12 270.82,282.12 271.27,282.57 271.27,284.61 270.74,285.14 267.49,285.14 ; SLOT06.A41 179.15,58.52 180.44,58.52 180.93,58.04 181.99,58.04 185.32,61.37 185.32,79.35 168.58,96.08 168.58,190.24 168.59,190.29 168.59,190.69 168.58,190.73 168.58,199.1 167.49,200.19 167.49,213.43 169.42,215.36 169.42,226.33 168.01,227.74 164.18,227.74 162.05,229.87 162.05,234.06 162.41,234.42 162.49,234.42 162.77,234.7 162.77,234.78 162.83,234.84 162.83,235.09 164.09,236.35 181.08,236.35 185.42,232.01 185.42,228.1 188.41,225.11 194.14,225.11 194.58,224.67 195.22,224.67 195.88,224.01 196.27,224.01 196.93,224.67 198.6,224.67 200.35,226.41 202.28,226.41 208.7,232.83 208.7,233.05 208.98,233.33 209.37,233.33 209.52,233.17 210.57,233.17 212.74,235.35 212.74,235.74 213.02,236.02 216.18,236.02 222.72,242.56 222.72,253.46 225.1,255.83 225.1,281.62 224.94,281.77 224.94,282.17 226.39,283.61 226.39,287.71
  L28_DP w0.102: 267.49,285.14 265.53,285.14 263.5,287.17 263.5,290.39 260.45,293.45 259.41,293.45 259.4,293.43 257.26,293.43 257.25,293.45 256.41,293.45 256.4,293.43 253.02,293.43 251.32,295.14 ; 227.49,288.81 226.39,287.71 ; 251.32,288.81 259.67,288.81 260.43,288.05 260.45,288.05 261.44,287.06 261.44,286.46 265.33,282.57
SL06_DP_131: length 492.5
  L30_DP w0.079: v1(276.79,228.7) 278.29,230.2 284.5,230.2 289.71,224.99 289.71,211.61 287.85,209.75 282.98,209.75 281.56,208.33 281.56,207.12 279.35,204.92 277.74,204.92 277.05,204.22 273.46,204.22 270.78,201.54 270.78,197.19 270.17,196.58 270.17,187.59 269.13,186.55 269.13,181.75 270.3,180.57 274.58,180.57 275.69,181.69 275.69,197.69 276.9,198.89 278.17,198.89 278.79,199.51 284.56,199.51 285.64,198.43 291.19,198.43 294.07,201.3 294.07,227.95 284.13,237.89 263.49,237.89 261.17,240.22 253.81,240.22 249.96,244.08 249.96,256.46 246.64,259.78 239.69,259.78 235.4,264.07 229.41,264.07 225.8,260.46 225.8,257.75 225.12,257.08 225.12,243.57 218.69,237.14 216.81,237.14 214.77,235.09 214.77,233.67 212.61,231.51 199.26,231.51 198.25,232.52 189.87,232.52 187,229.65 187,226.27 183.88,223.15 183.88,201.05 184.69,200.24 184.69,197.19 182.64,195.13 182.64,177.71 174.37,169.44 174.37,94.76 189.26,79.87 189.26,79.17 189.26,65.57 189.02,65.32 189.02,65.31 183,59.3 181.73,59.3 181.68,59.34 180.96,59.34 180.14,58.52 179.76,58.52 179.45,58.22 179.28,58.04 178.71,58.04 178.06,58.69 SLOT06.B41
  BOTTOM w0.203: v1(276.79,228.7) 276.79,227.38 UNK4R15.1
SL06_DP_132: length 503.1
  L30_DP w0.079: SLOT06.C41 174.64,58.52 175.94,58.52 176.66,57.81 177.05,57.81 177.58,58.34 178.12,58.34 178.75,57.71 179.19,57.71 179.83,58.34 180.37,58.34 180.91,57.81 181.25,57.81 181.77,58.32 182.16,58.32 182.86,59.02 183.12,59.02 189.3,65.19 189.3,65.21 189.54,65.45 189.54,79.05 189.54,79.99 174.65,94.88 174.65,169.33 183.76,178.43 183.76,186.42 183.34,186.84 183.34,189.42 183.76,189.83 183.76,195.85 184.98,197.07 184.98,200.35 184.16,201.17 184.16,223.04 187.28,226.16 187.28,229.53 189.98,232.24 198.13,232.24 199.14,231.22 212.73,231.22 215.05,233.55 215.05,234.98 216.93,236.85 218.81,236.85 225.4,243.45 225.4,256.96 226.08,257.64 226.08,260.34 229.53,263.79 235.28,263.79 239.58,259.5 246.52,259.5 249.28,256.73 249.28,241.31 252.62,237.98 257.1,237.98 257.81,238.69 262.25,238.69 263.33,237.61 284.01,237.61 293.78,227.84 293.78,201.42 291.08,198.71 285.76,198.71 284.67,199.8 278.67,199.8 278.05,199.18 276.78,199.18 275.41,197.8 275.41,181.81 274.46,180.86 270.42,180.86 269.41,181.87 269.41,186.43 270.45,187.47 270.45,195.2 271.48,196.23 271.48,197.57 271.06,198 271.06,201.42 273.58,203.94 277.17,203.94 277.86,204.63 279.47,204.63 281.84,207 281.84,208.21 283.09,209.47 287.96,209.47 289.99,211.5 289.99,225.1 284.61,230.48 273.49,230.48 v1(271.71,228.7)
  BOTTOM w0.203: v1(271.71,228.7) 271.71,227.38 UNK4R17.1
SL06_DP_133: length 210.8
  TOP w0.381: UNK6TP_OUT+_1.1 v1(166.61,235.54)
  L28_DP w0.079: SLOT06.D41 170.89,58.69 170.24,59.34 169.71,59.34 169.25,58.89 169.25,58.54 169.33,58.47 169.33,58.42 169.71,58.04 169.83,58.04 170.83,57.04 171.37,57.04 171.89,57.57 172.56,57.57 173.08,57.04 173.62,57.04 174.44,57.86 174.82,57.86 175.36,58.4 175.84,58.4 176.59,57.66 176.97,57.66 177.6,57.02 178.13,57.02 178.63,57.52 179.32,57.52 179.82,57.02 180.38,57.02 180.88,57.52 181.57,57.52 181.82,57.27 181.96,57.27 182.12,57.11 183.47,57.11 186.31,59.96 186.31,79.88 169.15,97.04 169.15,190.19 169.16,190.23 169.16,190.75 169.15,190.79 169.15,197.52 169.69,198.07 169.69,206.84 169.55,206.99 169.55,214.64 170.21,215.31 170.21,232.48 169.37,233.33 168.83,233.33 v1(166.61,235.54)
SL06_DP_134: length 206
  TOP w0.381: UNK6TP_OUT-_1.1 v1(164.31,235.54)
  L28_DP w0.079: SLOT06.E41 170.33,58.34 171.37,58.34 171.4,58.31 171.42,58.31 171.78,57.94 172.42,57.94 172.82,58.34 173.08,58.34 173.62,58.34 173.62,58.34 173.91,58.34 174.21,58.04 174.74,58.04 175.28,58.58 175.92,58.58 176.66,57.84 177.08,57.84 177.58,58.34 178.12,58.34 178.76,57.7 179.19,57.7 179.83,58.34 180.37,58.34 181.01,57.7 181.64,57.7 181.79,57.56 182.08,57.56 182.24,57.4 183,57.4 185.8,60.2 185.8,79.63 168.87,96.56 168.87,190.22 168.88,190.26 168.88,190.72 168.87,190.76 168.87,199.75 167.88,200.73 167.88,213.42 169.93,215.47 169.93,229.92 v1(164.31,235.54)
SL06_DP_135: length 211.6
  TOP w0.381: UNK6TP_OUT+_2.1 v1(173.22,235.54)
  L28_DP w0.079: SLOT06.F41 167.72,57.9 169.58,56.04 170.24,56.04 170.88,56.68 171.32,56.68 171.96,56.04 172.49,56.04 173.13,56.68 173.57,56.68 174.21,56.04 174.74,56.04 175.48,56.78 175.72,56.78 176.46,56.04 176.99,56.04 177.46,56.52 177.5,56.52 177.51,56.52 178.19,56.52 178.67,56.04 179.24,56.04 179.76,56.56 180.44,56.56 180.96,56.04 181.62,56.04 181.73,56.15 183.67,56.15 187.03,59.51 187.03,80.56 169.71,97.88 169.71,190.12 169.72,190.17 169.72,190.8 169.71,190.85 169.71,197.29 171.82,199.39 171.82,201.59 171.48,201.93 171.48,202.31 171.82,202.65 171.82,207.3 172.05,207.53 172.05,207.92 171.82,208.15 171.82,223.2 171.61,223.34 171.4,223.55 171.24,223.79 171.13,224.06 171.07,224.34 171.07,224.64 171.13,224.92 171.24,225.19 171.4,225.43 171.61,225.64 171.82,225.78 171.82,232.59 171.74,232.66 171.74,232.7 171.39,233.05 171.39,233.66 173.22,235.48 v1(173.22,235.54)
SL06_DP_136: length 223.1
  TOP w0.381: UNK6TP_OUT-_2.1 v1(170.91,235.54)
  L28_DP w0.079: SLOT06.Z41 180.75,59.17 180.75,59.96 180.37,60.34 179.83,60.34 179.72,60.23 179.69,60.23 179.32,59.86 178.6,59.86 178.12,60.34 177.58,60.34 177.2,59.96 177.2,59.6 177.12,59.52 176.38,59.52 175.91,59.06 175.88,59.06 175.87,59.04 175.33,59.04 175.32,59.06 175.03,59.06 174.74,59.34 174.21,59.34 173.92,59.06 173.63,59.06 173.41,58.83 173.29,58.83 173.2,58.93 172.91,58.93 172.49,59.34 171.96,59.34 171.54,58.93 170.95,58.93 170.26,59.62 169.72,59.62 169.07,58.97 169.07,58.42 169.63,57.86 169.76,57.86 170.76,56.86 171.44,56.86 171.97,57.39 172.48,57.39 173.01,56.86 173.69,56.86 174.18,57.35 175.03,57.35 175.41,56.97 175.79,56.97 175.79,56.96 176.08,56.96 176.46,57.34 176.99,57.34 177.57,56.77 178.13,56.77 178.71,57.34 179.24,57.34 179.75,56.83 180.44,56.83 180.96,57.34 181.49,57.34 182,56.83 183.58,56.83 186.65,59.9 186.65,80.41 169.43,97.63 169.43,190.16 169.44,190.2 169.44,190.78 169.43,190.82 169.43,197.41 171.19,199.17 171.19,207.44 171.11,207.53 171.11,207.92 171.19,208.01 171.19,209.5 171.49,209.8 171.49,210.19 171.19,210.49 171.19,223.36 171.18,223.37 170.99,223.66 170.86,223.98 170.79,224.32 170.79,224.66 170.86,225 170.99,225.32 171.18,225.61 171.19,225.62 171.19,231.92 170.39,232.72 170.39,235.02 v1(170.91,235.54)
SL06_DP_137: length 126.4
  L30_DP w0.079: SLOT06.Z39 187.24,56.69 195.66,65.11 195.66,93.17 200.51,98.03 200.51,157.7 196.79,161.42 v1(196.79,168.7)
  BOTTOM w0.203: v1(196.79,168.7) 196.79,167.38 UNK6R15.1
SL06_DP_138: length 130.3
  L30_DP w0.079: SLOT06.A39 179.67,56.69 179.68,56.7 180.32,56.7 180.96,57.34 187.49,57.34 195.25,65.1 195.25,93.17 200.22,98.14 200.22,157.59 191.71,166.1 v1(191.71,168.7)
  BOTTOM w0.203: UNK6R17.1 191.71,167.38 v1(191.71,168.7)
SL06_DP_139: length 257.9
  TOP w0.381: UNK8TP_OUT+_1.1 v1(246.61,235.54)
  L30_DP w0.079: v1(246.61,235.54) 246.1,236.05 230.4,236.05 225.58,231.23 220.45,231.23 220.45,231.23 215.1,231.23 214.39,230.53 196.7,230.53 193.7,227.53 193.7,227.37 191.38,225.05 187.53,225.05 186.24,223.76 186.24,221 184.78,219.54 184.78,201.35 184.94,201.19 185.59,200.54 185.59,197.02 184.39,195.83 184.39,189.42 186.38,187.43 186.38,169.52 195.83,160.08 197.34,160.08 199.94,157.47 199.94,98.26 194.87,93.18 194.87,65.12 187.37,57.62 180.98,57.62 180.4,57.04 179.54,57.04 179.24,57.34 178.71,57.34 178.07,56.7 177.43,56.7 177.42,56.69 SLOT06.B39
SL06_DP_140: length 261.6
  TOP w0.381: UNK8TP_OUT-_1.1 v1(244.31,235.54)
  L30_DP w0.079: v1(244.31,235.54) 244.31,235.24 242.92,233.85 239.22,233.85 236.05,230.68 229.9,230.68 228.14,228.91 214.51,228.91 212.37,226.78 196.61,226.78 193.39,223.55 189.18,223.55 185.06,219.42 185.06,201.47 185.93,200.6 185.93,196.97 184.68,195.71 184.68,189.53 186.88,187.32 186.88,175.31 189.94,172.25 197.63,172.25 200.79,169.1 200.79,69.84 187.36,56.41 181.86,56.41 181.49,56.04 180.96,56.04 180.48,56.52 179.76,56.52 179.75,56.51 179.71,56.51 179.24,56.04 178.71,56.04 178.23,56.52 177.51,56.52 177.5,56.51 177.46,56.51 176.99,56.04 176.46,56.04 175.81,56.69 SLOT06.C39
SL06_DP_141: length 274.2
  TOP w0.381: UNK8TP_OUT+_2.1 v1(253.21,235.54)
  L30_DP w0.079: SLOT06.D39 172.32,56.6 173.65,56.6 174.21,56.04 174.74,56.04 175.21,56.51 175.73,56.51 176.38,55.86 177.07,55.86 177.54,56.33 177.57,56.33 177.58,56.34 178.15,56.34 178.63,55.86 179.32,55.86 179.79,56.33 179.82,56.33 179.83,56.34 180.4,56.34 180.88,55.86 181.57,55.86 181.82,56.11 181.96,56.11 181.98,56.13 187.24,56.13 187.24,56.13 187.47,56.13 201.07,69.73 201.07,169.21 197.75,172.53 197.52,172.53 190.06,172.53 187.17,175.42 187.17,187.44 184.96,189.65 184.96,194.66 186.53,196.23 186.53,197.94 186.49,197.98 186.49,198.13 186.21,198.41 186.21,200.71 185.34,201.58 185.34,219.31 189.3,223.27 193.5,223.27 196.73,226.49 212.49,226.49 214.63,228.63 228.25,228.63 230.02,230.4 236.17,230.4 239.34,233.56 246.64,233.56 249.56,236.49 252.27,236.49 v1(253.21,235.54)
SL06_DP_142: length 278
  TOP w0.381: UNK8TP_OUT-_2.1 v1(250.91,235.54)
  L30_DP w0.079: SLOT06.E39 169.97,55.9 171.01,54.86 171.22,54.86 171.94,55.59 172.54,55.59 173.08,55.04 173.62,55.04 174.16,55.59 174.79,55.59 175.33,55.04 175.87,55.04 176.51,55.68 176.94,55.68 177.58,55.04 178.12,55.04 178.76,55.68 179.19,55.68 179.83,55.04 180.37,55.04 181.01,55.68 181.64,55.68 181.79,55.83 182.08,55.83 182.09,55.85 187.12,55.85 187.59,55.85 201.35,69.61 201.35,171.39 198.26,174.49 190.3,174.49 189.29,175.5 189.29,185.72 185.3,189.7 185.3,194.02 185.79,194.5 186.32,194.5 187.43,195.61 187.43,199.9 185.62,201.7 185.62,217.13 187.57,219.08 189.63,219.08 189.65,219.07 195.98,219.07 197.19,220.28 197.19,223.47 199.93,226.21 212.61,226.21 214.75,228.35 228.37,228.35 230.13,230.11 236.29,230.11 238.24,232.07 249.09,232.07 250.39,233.37 250.39,235.02 v1(250.91,235.54)
