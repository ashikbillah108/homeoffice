# Allegro board 980K2-260817_261120-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL01_VI100_7_A_HS: length 352.2
  L07_VI w0.254: 90.75,430.94 90.84,430.94 93.92,434.02 94.53,434.02 95.17,433.38 95.52,433.38 96.17,434.02 96.78,434.02 97.42,433.38 97.77,433.38 98.42,434.02 99.58,434.02 SLOT01.C23
  L07_VI w0.635: 90.75,430.94 88.89,430.94 82.7,424.76 82.7,413.23 82.7,408.49 68.21,394 68.21,373.73 111.86,330.08 170.17,330.08 170.6,329.66 170.78,329.47 189.07,311.19 189.07,290.6 189.74,289.94 191.49,288.18 191.49,275.14 191.05,274.7 189.44,274.7 188.38,273.64 187.1,273.64 183.38,269.92 183.38,260.86 181.04,258.52 181.04,257.19 181.55,256.68 181.55,252.18 178.95,249.58 174.47,249.58 170.76,245.87 170.76,245.11 163.47,237.82 150.63,237.82 149.85,238.6 149.85,243.06 148.13,244.78 148.13,249.04 150.26,251.17 150.26,253.66 150.87,254.27 151.32,254.27 151.76,254.71 152.42,254.71 152.86,254.27 153.31,254.27 154.07,253.51 v1(154.07,253.35)
  vias: v2(149.8,265.39)
SL01_VI100_7_B_HF: length 252.1
  TOP w0.305: SITE1.31_F 148.3,270.29 148.29,270.3 148.29,270.82 148.07,271.04
  TOP w0.635: v1(149.84,279.54) 149.08,278.78 149.08,273.58 148.07,272.57 148.07,271.04
  L07_VI w0.254: 90.75,428.5 92.8,430.55 94.53,430.55 95.53,431.55 95.65,431.55 96.12,432.02 96.78,432.02 97.25,431.55 97.9,431.55 98.51,432.16 98.93,432.16 99.54,431.55 100.19,431.55 100.67,432.02 100.79,432.02 101.79,433.02 102.44,433.02 102.92,432.55 103.53,432.55 104.35,433.37 SLOT01.E23
  L07_VI w0.635: 90.75,428.5 90.24,427.99 89.16,427.99 84.99,423.81 84.99,414.17 84.99,407.54 70.5,393.06 70.5,374.68 112.81,332.37 171.12,332.37 171.54,331.94 171.73,331.76 191.36,312.13 191.36,297.86
SL01_VI100_7_B_HS: length 153.3
  L09_VI w0.254: 90.51,409.19 92.12,409.19 92.71,409.79 93.61,409.79 93.89,410.07 94.55,410.07 95.01,409.61 95.01,409.51 95.02,409.5 95.67,409.5 95.68,409.51 95.68,409.61 96.14,410.07 96.8,410.07 97.26,409.61 97.26,409.54 97.51,409.29 SLOT01.C48
  L09_VI w0.635: 159.43,312.57 159.43,322.31 87.29,394.45 87.29,407.26 89.22,409.19 90.51,409.19
  BOTTOM w0.203: v1(149.84,284.11) 149.05,283.33 149.05,272.6 148.3,271.84 v2(148.3,269.59)
SL01_VI100_8_A_HF: length 253.4
  L09_VI w0.254: SLOT01.D21 100.93,436.29 100.19,437.02 99.5,437.02 99.03,436.55 98.37,436.55 98.21,436.72 97.9,437.02 97.25,437.02 96.78,436.55 96.12,436.55 95.64,437.03 95.01,437.03 94.53,436.55 93.62,436.55 92.38,435.31 90.75,435.31
  L09_VI w0.635: 101.51,275.7 72.6,275.7 42.58,305.73 42.58,420.11 57.78,435.31 90.75,435.31
SL01_VI100_8_A_HS: length 247.2
  L09_VI w0.254: 90.75,434.16 91.22,434.16 91.77,434.71 92.6,434.71 93.92,436.02 94.53,436.02 95,435.55 95.65,435.55 96.12,436.02 96.78,436.02 97.25,435.55 97.9,435.55 98.55,436.19 99.75,436.19 SLOT01.C21
  L09_VI w0.635: 90.75,434.16 58.25,434.16 43.72,419.64 43.72,306.2 73.08,276.85 101.51,276.85
SL01_VI100_8_B_HF: length 5.7
  TOP w0.305: SITE1.20_F 154.73,267.24 155.04,266.93
  TOP w0.635: v1(156.03,265.94) 155.04,266.93
  BOTTOM w0.635: v1(156.03,265.94) C61.2
SL01_VI100_8_B_HS: length 157.1
  L09_VI w0.254: SLOT01.C46 97.51,411.29 96.78,410.55 96.17,410.55 95.52,411.19 95.17,411.19 94.53,410.55 91.88,410.55 91.86,410.57 90.62,410.57
  L09_VI w0.635: 90.62,410.57 88.98,410.57 86.14,407.74 86.14,393.98 158.29,321.84 158.29,312.57
  BOTTOM w0.203: v1(168.42,265.58) 166.93,267.06 154.7,267.06 154.53,267.24 v2(151.65,267.24)
SL01_VI100_9_A_HF: length 185.6
  L09_VI w0.254: 90.75,417.14 93.32,417.14 93.92,416.55 94.53,416.55 95.17,417.19 95.52,417.19 96.17,416.55 96.78,416.55 97.42,417.19 97.77,417.19 98.42,416.55 99.03,416.55 100.03,417.55 100.15,417.55 100.89,418.29 SLOT01.D39
  L09_VI w0.635: 101.54,291.71 79.23,291.71 59.17,311.77 59.17,311.77 58.58,312.36 58.58,389.44 76.1,406.96 86.28,417.14 90.75,417.14
SL01_VI100_9_A_HS: length 186.3
  L09_VI w0.254: 90.75,418.29 94.3,418.29 95.04,417.55 95.65,417.55 96.39,418.29 96.55,418.29 97.29,417.55 97.9,417.55 98.64,418.29 SLOT01.C39
  L09_VI w0.635: 90.75,418.29 85.81,418.29 74.95,407.43 57.44,389.92 57.44,311.88 57.98,311.35 58,311.32 62.69,306.64 62.69,306.64 78.76,290.56 101.54,290.56
SL01_VI100_9_B_HF: length 7.6
  TOP w0.305: SITE1.21_F 154.03,267.74 154.28,267.99
  TOP w0.635: v1(159.27,268.62) 158.64,267.99 154.28,267.99
SL01_VI100_9_B_HS: length 19.8
  L07_VI w0.254: SLOT01.F37 109.02,420.29
  L07_VI w0.635: 109.02,420.29 113.15,420.29
  BOTTOM w0.203: v1(163.84,268.62) 162.97,269.49 156.34,269.49 154.58,267.74 v2(151.65,267.74)
SL01_VI100_10_A_HF: length 313.9
  TOP w0.305: SITE1.16_F 151.55,264.74 151.98,264.74
  TOP w0.635: v1(157.37,258.18) 156.72,258.83 156.72,260.01 151.98,264.74
  L07_VI w0.254: SLOT01.D17 101.89,440.49 100.68,440.49 100.15,441.02 99.5,441.02 98.95,440.47 98.45,440.47 97.9,441.02 97.25,441.02 96.78,440.55 96.12,440.55 95.65,441.02 95,441.02 94.53,440.55 93.64,440.55 90.75,437.65
  L07_VI w0.635: v1(157.37,258.18) 159.31,260.12 168.73,260.12 169.17,260.56 169.17,261.83 172.35,265.01 172.35,269.06 184.18,280.89 184.18,311.23 168.75,326.65 110.44,326.65 64.78,372.31 64.78,395.42 79.27,409.91 79.27,411.81 79.27,426.18 90.75,437.65
SL01_VI100_10_A_HS: length 332.3
  L07_VI w0.254: 90.75,436.04 93.26,438.55 94.53,438.55 95.53,439.55 95.65,439.55 96.12,440.02 96.78,440.02 97.25,439.55 97.9,439.55 98.47,440.11 99.67,440.11 SLOT01.C17
  L07_VI w0.635: 90.75,436.04 80.42,425.71 80.42,412.28 80.42,409.44 65.93,394.95 65.93,372.78 110.92,327.79 169.23,327.79 169.65,327.37 186.78,310.24 186.78,286.22 186.16,285.6 186.16,281.26 173.49,268.59 173.49,266.74 175.38,264.84 175.38,263.08 173.67,261.37 171.89,261.37 168.31,257.79 168.31,249.42 167.25,248.36 160.66,248.36 157.37,251.65 v1(157.37,253.35)
  BOTTOM w0.203: v1(157.37,253.35) 157.37,254.05 157.17,254.25 156.08,254.25 155.83,254.51 155.83,260.6 151.3,265.13 v2(151.3,265.39)
SL01_VI100_10_B_HF: length 264.6
  TOP w0.305: SITE1.25_F v2(151.3,270.39)
  L09_VI w0.254: 90.75,437.59 91.79,437.59 92.75,438.55 94.53,438.55 95,439.02 95.65,439.02 96.12,438.55 96.78,438.55 97.25,439.02 97.9,439.02 98.37,438.55 99.03,438.55 100.03,439.55 100.15,439.55 100.62,440.02 101.28,440.02 101.75,439.55 102.4,439.55 103.14,440.29 SLOT01.E17
  L09_VI w0.635: 90.75,437.59 56.83,437.59 40.3,421.06 40.3,304.78 71.66,273.42 102.03,273.42
SL01_VI100_10_B_HS: length 5.7
  BOTTOM w0.203: v2(151.3,269.59) 151.36,269.65 153.95,269.65 155.17,270.87 v1(155.17,272.17)
SL01_VI100_11_A_HF: length 222.4
  TOP w0.305: 153.62,265.67 153.05,266.24 SITE1.18_F
  TOP w0.635: 153.62,265.67 156.62,262.67 v1(157.73,262.67)
  L07_VI w0.254: 90.75,441.95 91.5,442.71 93.76,442.71 93.92,442.55 94.53,442.55 95.01,443.03 95.64,443.03 96.12,442.55 96.78,442.55 97.25,443.02 97.9,443.02 98.21,442.72 98.37,442.55 99.03,442.55 99.5,443.02 100.19,443.02 100.93,442.29 SLOT01.D15
  L07_VI w0.635: 155.38,306.17 151.4,310.15 146.37,310.15 132.15,324.37 109.5,324.37 62.5,371.36 62.5,372.31 62.5,396.37 76.99,410.86 76.99,427.13 89.75,439.89 89.75,440.96 90.75,441.95
SL01_VI100_11_A_HS: length 260
  L07_VI w0.254: SLOT01.C15 99.75,442.19 98.55,442.19 97.9,441.55 97.25,441.55 96.78,442.02 96.12,442.02 95.65,441.55 95,441.55 94.53,442.02 92.02,442.02 90.75,440.75 90.75,439.27
  L07_VI w0.635: 183.03,304.74 183.03,310.76 168.28,325.51 109.97,325.51 63.64,371.84 63.64,395.9 78.13,410.39 78.13,411.33 78.13,426.65 90.75,439.27
  BOTTOM w0.203: v1(168.42,261.77) 166.28,263.91 154.31,263.91 151.97,266.24 v2(151.65,266.24)
SL01_VI100_11_B_HF: length 0.4
  TOP w0.305: SITE1.26_F v2(150.8,270.39)
SL01_VI100_11_B_HS: length 10.5
  BOTTOM w0.203: v2(150.8,269.59) 150.8,269.67 151.16,270.03 151.57,270.03 151.7,270.16 153.88,270.16 154.43,270.7 154.43,276 v1(155.17,276.75)
SL01_VI100_12_A_HF: length 291.9
  TOP w0.305: 154.31,266.19 154.13,266.19 153.59,266.74 SITE1.19_F
  TOP w0.635: 154.31,266.19 155.58,264.92 158.62,264.92 v1(159.27,265.58)
  L09_VI w0.254: 90.75,444.45 90.84,444.55 94.53,444.55 95,445.02 95.65,445.02 96.12,444.55 96.78,444.55 97.25,445.02 97.9,445.02 98.37,444.55 99.03,444.55 99.5,445.02 100.15,445.02 100.89,444.29 SLOT01.D13
  L09_VI w0.635: 102.03,266.56 68.82,266.56 33.44,301.94 33.44,423.9 53.99,444.45 90.75,444.45
SL01_VI100_12_A_HS: length 290.4
  L09_VI w0.254: 90.75,443.31 91.22,443.31 91.97,444.06 94.53,444.06 95.04,443.55 95.65,443.55 96.3,444.19 96.65,444.19 97.29,443.55 97.9,443.55 98.55,444.19 99.75,444.19 SLOT01.C13
  L09_VI w0.635: 90.75,443.31 54.46,443.31 34.58,423.42 34.58,302.41 69.29,267.7 102.03,267.7
  BOTTOM w0.203: v2(151.65,266.74) 154.27,266.74 154.43,266.58 162.84,266.58 v1(163.84,265.58)
SL01_VI100_12_B_HF: length 1.1
  TOP w0.305: SITE1.27_F 150.3,270.49 150,270.79 v2(149.8,270.79)
SL01_VI100_12_B_HS: length 25.5
  L07_VI w0.254: SLOT01.B59 97.6,397.33 96.86,396.59 96.86,395.94 97.21,395.59 97.21,392.46
  L07_VI w0.635: 97.21,388.6 97.21,392.46
  BOTTOM w0.152: 150.71,270.8 150.44,270.53 150.44,269.73 v2(150.3,269.59)
  BOTTOM w0.203: v1(155.17,281.32) 154.05,280.2 154.05,276.2 154.03,276.17 154.03,271.32 153.5,270.8 150.71,270.8
SL01_VI100_13_A_HF: length 299.7
  TOP w0.305: SITE1.22_F 152.44,268.24 152.44,268.25 153.26,268.25 153.66,268.65
  TOP w0.635: v1(157.73,268.86) 157.62,268.98 153.99,268.98 153.66,268.65
  L09_VI w0.254: SLOT01.D11 100.89,446.29 100.15,447.02 99.5,447.02 99.03,446.55 98.37,446.55 97.9,447.02 97.25,447.02 96.78,446.55 96.12,446.55 95.65,447.02 95,447.02 94.53,446.55 93.92,446.55 93.73,446.74 90.75,446.74
  L09_VI w0.635: 102.03,264.27 67.87,264.27 31.15,300.99 31.15,424.84 53.04,446.74 90.75,446.74
  BOTTOM w0.635: C64.2 156.03,268.22 156.67,268.86 v1(157.73,268.86)
SL01_VI100_13_A_HS: length 303.2
  L09_VI w0.254: 90.75,445.59 93.49,445.59 93.92,446.02 94.53,446.02 95.17,445.38 95.52,445.38 96.17,446.02 96.78,446.02 97.25,445.55 97.9,445.55 98.55,446.19 99.75,446.19 SLOT01.C11
  L09_VI w0.635: 90.75,445.59 53.52,445.59 32.29,424.37 32.29,301.47 68.34,265.42 102.03,265.42
  BOTTOM w0.203: v1(168.42,268.62) 167.04,270 156.21,270 154.45,268.24 v2(151.65,268.24)
SL01_VI100_13_B_HF: length 329.9
  TOP w0.305: SITE1.32_F v2(147.8,270.39)
  L09_VI w0.254: SLOT01.E11 104.35,447.2 105.08,447.94 105.08,448.63 104.73,448.98 104.73,449.63 105.08,449.98 105.08,450.63 104.73,450.98 104.73,451.63 105.08,451.98 105.08,452.59 104.65,453.02 104.53,453.02 103.53,454.02 102.87,454.02 102.4,453.55 101.79,453.55 101.32,454.02 100.62,454.02 100.15,453.55 99.5,453.55 99.17,453.88 99.03,454.02 98.37,454.02 97.9,453.55 97.25,453.55 96.78,454.02 96.17,454.02 95.69,453.55 95,453.55 94.53,454.02 93.92,454.02 93.44,453.55 92.41,453.55 91.22,454.74 90.75,454.74
  L09_VI w0.635: 90.75,454.74 49.73,454.74 23.15,428.16 23.15,297.68 64.56,256.27 102.03,256.27
  vias: v1(147.43,284.11)
SL01_VI100_13_B_HS: length 142.8
  L09_VI w0.254: 93.29,408.26 94.11,408.26 94.3,408.07 94.55,408.07 95.01,407.61 95.01,407.51 95.02,407.5 95.67,407.5 95.68,407.51 95.68,407.61 96.14,408.07 96.22,408.07 96.43,408.29 SLOT01.B49
  L09_VI w0.635: 93.29,408.26 92.88,408.26 88.44,403.82 88.44,394.92 160.57,322.78 160.57,312.57
  BOTTOM w0.203: v2(147.8,269.59) 147.8,269.86 147.33,270.33 147.33,271.45 148.59,272.71 148.59,275.84 147.43,277.01 v1(147.43,278.27)
SL01_VI100_14_A_HF: length 307.4
  TOP w0.305: SITE1.23_F 152.52,268.74 152.97,269.19
  TOP w0.635: v1(159.27,271.67) 157.57,269.97 153.75,269.97 152.97,269.19
  L09_VI w0.254: SLOT01.D9 100.89,448.29 100.15,449.02 99.5,449.02 99.03,448.55 98.37,448.55 97.9,449.02 97.25,449.02 96.78,448.55 96.12,448.55 95.65,449.02 95,449.02 94.53,448.55 91.69,448.55 91.22,449.02 90.75,449.02
  L09_VI w0.635: 102.03,261.99 66.92,261.99 28.87,300.05 28.87,425.79 52.1,449.02 90.75,449.02
SL01_VI100_14_A_HS: length 307.5
  L09_VI w0.254: SLOT01.C9 99.75,448.19 98.55,448.19 97.9,447.55 97.29,447.55 96.65,448.19 96.3,448.19 95.58,447.48 95.07,447.48 94.53,448.02 93.92,448.02 93.77,447.88 90.75,447.88
  L09_VI w0.635: 102.03,263.13 67.4,263.13 30.01,300.52 30.01,425.32 52.57,447.88 90.75,447.88
  BOTTOM w0.203: v1(163.84,271.67) 162.85,272.67 157.43,272.67 157.12,272.36 157.12,271.23 156.59,270.7 156.27,270.7 154.31,268.74 v2(151.65,268.74)
SL01_VI100_14_B_HS: length 489.6
  L07_VI w0.254: SLOT01.B45 96.39,412.29 95.65,411.55 95.04,411.55 94.3,412.29 93.28,412.29 92.06,411.08 92.06,403.22 90.75,401.9
  L07_VI w0.635: 90.75,401.9 79.17,390.32 78.5,389.65 78.5,377.99 114.7,341.79 171.4,341.79 198.21,314.97 198.21,308.79 201.82,305.18 208.52,305.18 218.44,295.26 218.44,289.57 219.37,288.64 220.66,288.64 221.62,287.69 221.62,285.83 223.36,284.08 223.36,277.66 222.2,276.5 222.2,268.82 223.03,268 223.03,264.9 220.08,261.95 220.08,257.99 221.75,256.32 221.75,252.23 219.09,249.57 214.55,249.57 211.77,246.79 211.77,244.17 208.17,240.56 208.17,234.32 204.56,230.71 197.35,230.71 196.79,230.15 191.59,230.15 191.37,230.37 187.44,230.37 186.16,229.09 186.16,225.52 183.69,223.04 183.69,215.45 181.39,213.15 173.35,213.15 171.53,211.33 169.25,211.33 167.78,209.86 152.9,209.86 151.29,211.47 150.08,211.47 149.05,212.51 147.25,212.51 144.18,215.58 141.01,215.58 138.79,213.37 133.44,213.37 129.74,217.06 129.74,221.75 128.47,223.02 128.47,225.96 129.53,227.02 129.53,228.32 126.7,231.15 126.7,233.28 127.49,234.06 127.49,241 127.37,241.13 127.37,262.63 132.44,267.7 141.11,267.7 146.67,262.15 152.71,262.15 154.07,260.79 v1(154.07,258.18)
  BOTTOM w0.203: v2(149.3,265.39) 149.3,264.72 154.07,259.95 v1(154.07,258.18)
SL01_VI100_15_A_HF: length 316.7
  TOP w0.305: 152.28,269.81 152.05,269.58 SITE1.24_F
  TOP w0.635: v1(159.27,274.21) 158.47,273.41 157.62,273.41 156.98,272.77 156.98,271.92 155.98,270.92 153.39,270.92 152.28,269.81
  L09_VI w0.254: 90.75,451.31 91.69,451.31 92.73,451.31 93.49,450.55 94.53,450.55 95,451.02 95.65,451.02 96.12,450.55 96.78,450.55 97.25,451.02 97.9,451.02 98.37,450.55 99.03,450.55 99.5,451.02 100.15,451.02 100.89,450.29 SLOT01.D7
  L09_VI w0.635: 90.75,451.31 51.15,451.31 26.58,426.74 26.58,299.1 65.98,259.7 102.03,259.7
SL01_VI100_15_A_HS: length 317.5
  L09_VI w0.254: SLOT01.C7 99.75,450.19 98.55,450.19 97.9,449.55 97.29,449.55 96.65,450.19 96.3,450.19 95.65,449.55 95.04,449.55 94.48,450.11 92.27,450.11 92.21,450.17 90.75,450.17
  L09_VI w0.635: 102.03,260.85 66.45,260.85 27.72,299.57 27.72,426.27 51.62,450.17 90.75,450.17
  BOTTOM w0.203: v1(163.84,274.21) 162.72,275.34 156.97,275.34 156.72,275.08 156.72,271.4 156.46,271.14 156.08,271.14 154.18,269.24 v2(151.65,269.24)
SL01_VI100_15_B_HS: length 351.2
  L07_VI w0.254: 90.75,432.55 92.34,434.14 92.34,436.45 93.96,438.07 94.52,438.07 95.04,437.55 95.65,437.55 96.17,438.07 97.38,438.07 SLOT01.B19
  L07_VI w0.635: 90.75,432.55 88.87,432.55 81.56,425.23 81.56,412.75 81.56,408.97 67.79,395.19 67.79,395.19 67.07,394.48 67.07,373.26 111.39,328.94 169.7,328.94 170.12,328.52 170.12,328.52 187.93,310.71 187.93,288.74 189.08,287.58 189.08,277.87 187.33,276.12 185.03,276.12 179.94,271.04 179.94,261.93 178.5,260.48 176.84,260.48 176.84,260.47 174.39,260.47 174.15,260.23 172.36,260.23 169.45,257.32 169.45,245.48 164.68,240.71 158.63,240.71 158.14,241.2 155.73,241.2 155.13,240.6 153.44,240.6 152.76,241.27 152.76,249.53 151.97,250.33 151.97,252.28
  BOTTOM w0.203: v2(148.8,265.39) 148.8,262.17 150.36,260.61 150.36,254.46 150.57,254.25 151.51,254.25 151.91,253.85 v1(151.91,253.35)
SL01_VI100_16_A_HF: length 310.7
  TOP w0.305: SITE1.28_F v2(149.8,270.39)
  L09_VI w0.254: 90.75,452.45 91.22,452.45 91.59,452.08 94.47,452.08 95,451.55 95.65,451.55 96.12,452.02 96.78,452.02 97.25,451.55 97.9,451.55 98.37,452.02 99.03,452.02 99.5,451.55 100.15,451.55 100.89,452.29 SLOT01.D5
  L09_VI w0.635: 90.75,452.45 50.68,452.45 25.44,427.21 25.44,298.62 65.5,258.56 102.03,258.56
SL01_VI100_16_A_HS: length 316.1
  L09_VI w0.254: 90.75,453.59 91.29,453.59 92.45,452.43 94.45,452.43 95.04,453.02 95.65,453.02 96.3,452.38 96.6,452.38 97.25,453.02 97.9,453.02 98.55,452.38 99.75,452.38 SLOT01.C5
  L09_VI w0.635: 90.75,453.59 50.2,453.59 24.29,427.69 24.29,298.15 65.03,257.42 102.03,257.42
  BOTTOM w0.152: 150.25,270.97 150.14,270.86 150.14,270.08 149.8,269.74 v2(149.8,269.59)
  BOTTOM w0.203: 150.25,270.97 150.49,271.2 151.28,271.2 v1(152.25,272.17)
SL01_VI100_16_B_HS: length 32.2
  L07_VI w0.254: SLOT01.B1 97.6,459.16 97.61,459.18
  L07_VI w0.635: 118.56,460.67 99.1,460.67 97.61,459.18
  BOTTOM w0.203: v1(149.12,258.18) 149.12,260.08 147.8,261.39 v2(147.8,265.39)
SL01_VI100_18_A_HF: length 11.5
  TOP w0.305: SITE3.2_F 226.18,268.74
  TOP w0.635: v1(220.83,268.59) 220.98,268.74 226.18,268.74
  BOTTOM w0.635: UNK3C49.2 216.82,267.59 219.83,267.59 v1(220.83,268.59)
SL01_VI100_18_A_HS: length 7.8
  BOTTOM w0.203: v1(220.83,265.79) 221.97,265.79 224.92,268.74 v2(227.45,268.74)
SL01_VI100_18_B_HF: length 215.9
  TOP w0.305: 229.94,271.84 229.31,271.21 229.31,271.02 229.29,271 229.29,270.58 229.31,270.56 229.31,270.3 229.3,270.29 SITE3.29_F
  TOP w0.635: 229.94,271.84 231.49,273.39 231.49,277.25 v1(232.25,278.02)
  L07_VI w0.254: SLOT01.F57 108.4,400.29 109.02,399.67
  L07_VI w0.635: 109.02,399.67 111.98,396.71 111.98,392.35 113.81,390.51 113.81,371.97 132.57,353.22 168.05,353.22 170.61,350.66 172.83,350.66 204.67,318.82 217.3,318.82 232.68,303.43 232.68,287.28 233.9,286.06 233.9,278.99 232.93,278.02 v1(232.25,278.02)
SL01_VI100_18_B_HS: length 212.1
  L07_VI w0.254: 109.02,397.99 SLOT01.G58
  L07_VI w0.635: v1(232.25,282.59) 231.54,283.3 231.54,302.96 216.82,317.68 204.2,317.68 172.36,349.52 170.14,349.52 167.58,352.07 132.09,352.07 112.67,371.49 112.67,390.04 110.83,391.88 110.83,396.17 109.02,397.99
  BOTTOM w0.203: v1(232.25,282.59) 231.38,281.72 231.38,273.02 229.21,270.84 229.21,269.68 v2(229.3,269.59)
SL01_VI100_19_A_HF: length 22.9
  TOP w0.305: SITE3.5_F 225.45,267.24
  TOP w0.635: v1(220.83,261.22) 223.13,263.52 223.13,264.92 225.45,267.24
  L07_VI w0.254: 109.02,426.29 SLOT01.F31
  L07_VI w0.635: 113.14,426.29 109.02,426.29
  BOTTOM w0.635: v1(215.11,261.22) 215.11,260.93 215.75,260.3 220.19,260.3 220.83,260.93 v1(220.83,261.22)
SL01_VI100_19_A_HS: length 13.4
  BOTTOM w0.203: v2(227.45,267.24) 226.97,267.24 222.62,262.89 217.13,262.89 v1(216.26,263.76)
SL01_VI100_19_B_HS: length 202.6
  L07_VI w0.254: 109.02,400.81 108.18,400.81 107.72,401.28 SLOT01.G56
  L07_VI w0.635: 109.02,400.81 109.49,400.81 113.12,397.19 113.12,392.83 114.29,391.66 114.96,390.99 114.96,372.44 133.04,354.36 168.53,354.36 171.08,351.8 173.31,351.8 205.15,319.96 217.77,319.96 233.83,303.9 233.83,294.15
  BOTTOM w0.203: v1(229.12,253.35) 229.86,254.09 229.86,260.22 228.3,261.78 v2(228.3,265.39)
SL01_VI100_20_A_HS: length 8.3
  BOTTOM w0.203: v2(227.45,267.74) 225.82,267.74 221.84,263.76 v1(220.83,263.76)
SL01_VI100_20_B_HS: length 214.7
  L07_VI w0.254: SLOT01.G54 107.72,402.33 108.09,401.96 109.02,401.96
  L07_VI w0.635: 109.02,401.96 109.97,401.96 114.26,397.66 114.26,393.3 116.1,391.46 116.1,372.92 133.51,355.5 169,355.5 170.7,353.8 174.13,353.8 205.97,321.96 218.6,321.96 235.83,304.73 235.83,287.39 236.28,286.94
  BOTTOM w0.203: v2(231.65,265.74) 233.97,263.42 242.19,263.42 v1(243.84,261.77)
SL01_VI100_21_A_HF: length 29.3
  TOP w0.305: 226.18,266.45 226.47,266.74 SITE3.6_F
  TOP w0.635: 226.18,266.45 224.16,264.43 v1(224.16,258.18)
  L07_VI w0.254: 109.02,430.29 SLOT01.F27
  L07_VI w0.635: 112.86,430.29 109.02,430.29
  BOTTOM w0.508: 224.38,253.35 UNK3K12.4
  BOTTOM w0.635: 225.18,253.35 225.18,257.54 224.54,258.18 v1(224.16,258.18) ; 225.18,253.35 225.18,248.1 224.45,247.38 224.21,247.38 ; 225.18,253.35 224.38,253.35
SL01_VI100_21_A_HS:
  vias: v2(227.45,266.74)
SL01_VI100_22_A_HF: length 6.4
  L07_VI w0.254: 109.02,431.7 108.62,432.1 106.78,432.1 SLOT01.F25
  L07_VI w0.635: 112.74,431.58 109.14,431.58 109.02,431.7
  vias: v2(227.05,266.24)
SL01_VI100_22_A_HS:
  vias: v1(226.96,253.35) v2(227.45,266.24)
SL01_VI100_22_B_HF: length 199.9
  TOP w0.305: SITE3.30_F v2(228.8,271.66)
  L07_VI w0.254: SLOT01.F49 107.88,408.29 109.02,407.14
  L07_VI w0.635: 238.11,295.48 238.11,305.68 219.55,324.25 206.92,324.25 175.08,356.09 171.65,356.09 169.95,357.79 134.46,357.79 118.39,373.86 118.39,392.41 116.55,394.25 116.55,398.61 114.68,400.48 114.68,401.48 109.02,407.14
SL01_VI100_22_B_HS: length 230.1
  L07_VI w0.254: 109.02,405.53 107.72,406.83 SLOT01.G50
  L07_VI w0.635: UNK3K46.4 229.84,273.54 230.43,272.95 233.24,272.95 234.04,273.75 234.04,276.67 234.86,277.5 236.13,277.5 236.97,278.33 236.97,283.44 238.71,285.18 238.71,286.12 236.97,287.86 236.97,305.21 219.07,323.11 206.45,323.11 174.61,354.95 171.17,354.95 169.47,356.65 133.99,356.65 117.24,373.39 117.24,391.94 115.41,393.77 115.41,398.13 113.54,400 113.54,401.01 109.02,405.53
  BOTTOM w0.203: UNK3K46.4 229.84,272.05 228.8,271.01 v2(228.8,269.59)
SL01_VI100_23_A_HF: length 6.1
  L07_VI w0.254: SLOT01.F23 109.02,434.29
  L07_VI w0.635: 109.02,434.29 112.67,434.29
  vias: v2(229.8,264.99)
SL01_VI100_23_A_HS:
  vias: v1(234.07,253.35) v2(229.8,265.39)
SL01_VI100_23_B_HF: length 212.3
  TOP w0.305: SITE3.31_F 228.3,270.29 228.29,270.3 228.29,270.82 228.07,271.04
  TOP w0.635: 228.07,271.04 228.07,272.57 229.08,273.58 229.08,278.78 v1(229.84,279.54)
  L07_VI w0.254: 109.02,409.43 108.74,409.43 107.88,410.29 SLOT01.F47
  L07_VI w0.635: 109.02,409.43 109.97,409.43 116.97,402.43 116.97,401.42 118.83,399.55 118.83,395.21 120.87,393.18 120.87,374.61 135.41,360.07 170.89,360.07 172.59,358.37 176.03,358.37 207.87,326.53 220.49,326.53 240.4,306.63 240.4,295.48
SL01_VI100_23_B_HS: length 214.1
  L07_VI w0.254: SLOT01.G48 108.72,408.28 109.02,408.28
  L07_VI w0.635: 239.26,295.48 239.26,306.15 220.02,325.39 207.39,325.39 175.55,357.23 172.12,357.23 170.42,358.93 134.93,358.93 119.53,374.34 119.53,392.88 117.69,394.72 117.69,399.08 115.82,400.95 115.82,401.96 109.49,408.28 109.02,408.28
  BOTTOM w0.203: v1(229.84,284.11) 229.05,283.33 229.05,272.6 228.3,271.84 v2(228.3,269.59)
SL01_VI100_24_A_HF: length 6.1
  L07_VI w0.254: SLOT01.F21 109.02,436.29
  L07_VI w0.635: 109.02,436.29 112.72,436.29
SL01_VI100_24_B_HF: length 214.7
  TOP w0.305: SITE3.20_F 234.73,267.24 235.04,266.93
  TOP w0.635: v1(236.03,265.94) 235.04,266.93
  L07_VI w0.254: 109.02,411.71 108.55,411.71 107.98,412.29 SLOT01.F45
  L07_VI w0.635: 242.69,297.74 242.69,307.57 221.44,328.82 208.81,328.82 176.98,360.66 173.54,360.66 171.84,362.36 136.35,362.36 127.89,370.82 127.89,404.47 120.65,411.71 109.02,411.71
  BOTTOM w0.635: v1(236.03,265.94) UNK3C61.2
SL01_VI100_24_B_HS: length 223.5
  L07_VI w0.254: 109.02,410.57 108.44,410.57 SLOT01.G46
  L07_VI w0.635: 241.54,297.74 241.54,307.1 220.97,327.68 208.34,327.68 176.5,359.52 173.07,359.52 171.37,361.22 135.88,361.22 126.75,370.35 126.75,404 120.18,410.57 109.02,410.57
  BOTTOM w0.203: v2(231.65,267.24) 234.53,267.24 234.7,267.06 246.93,267.06 v1(248.42,265.58)
SL01_VI100_25_A_HF: length 51.4
  L07_VI w0.254: 109.02,418.29 SLOT01.F39
  L07_VI w0.635: 139.4,390.31 139.4,402.26 123.38,418.29 109.02,418.29
SL01_VI100_25_B_HF: length 189.7
  TOP w0.305: 234.28,267.99 234.03,267.74 SITE3.21_F
  TOP w0.635: v1(239.27,268.62) 238.64,267.99 234.28,267.99
  L07_VI w0.254: SLOT01.F61 108.65,396.29 109.02,395.91
  L07_VI w0.635: 109.02,395.91 109.69,395.24 109.69,391.41 111.53,389.57 111.53,371.02 131.62,350.93 167.11,350.93 203.07,314.96 215.7,314.96 228.83,301.83 228.83,294.15
SL01_VI100_25_B_HS: length 194.1
  L07_VI w0.254: SLOT01.F62 107.05,395.29 108.55,393.78 108.55,392.46
  L07_VI w0.635: 227.68,294.15 227.68,301.36 215.23,313.82 202.6,313.82 166.63,349.79 131.15,349.79 110.39,370.55 110.39,389.09 108.55,390.93 108.55,392.46
  BOTTOM w0.203: v2(231.65,267.74) 234.58,267.74 236.34,269.49 242.97,269.49 v1(243.84,268.62)
SL01_VI100_26_A_HF: length 15.8
  TOP w0.305: 231.98,264.74 231.55,264.74 SITE3.16_F
  TOP w0.635: 231.98,264.74 236.72,260.01 236.72,258.83 v1(237.37,258.18)
  L07_VI w0.254: SLOT01.F17 109.02,440.29
  L07_VI w0.635: 109.02,440.29 112.86,440.29
SL01_VI100_26_A_HS: length 15.2
  BOTTOM w0.203: v2(231.3,265.39) 231.3,265.13 235.83,260.6 235.83,254.51 236.08,254.25 237.17,254.25 237.37,254.05 v1(237.37,253.35)
SL01_VI100_26_B_HF: length 213.1
  TOP w0.305: SITE3.25_F v2(231.3,270.39)
  L07_VI w0.254: SLOT01.F43 108.26,414.29 108.55,414 109.02,414
  L07_VI w0.635: 244.97,297.74 244.97,308.52 222.39,331.11 209.76,331.11 177.92,362.95 174.49,362.95 172.79,364.65 137.3,364.65 130.18,371.77 130.18,405.42 121.6,414 109.02,414
SL01_VI100_26_B_HS: length 215.4
  L07_VI w0.254: 109.02,412.86 108.15,412.86 SLOT01.G44
  L07_VI w0.635: 243.83,297.74 243.83,308.05 221.91,329.96 209.29,329.96 177.45,361.8 174.01,361.8 172.31,363.5 136.83,363.5 129.04,371.29 129.04,404.95 121.13,412.86 109.02,412.86
  BOTTOM w0.203: v1(235.17,272.17) 235.17,270.87 233.95,269.65 231.36,269.65 v2(231.3,269.59)
SL01_VI100_27_A_HF: length 13.5
  TOP w0.305: SITE3.18_F 233.05,266.24 233.62,265.67
  TOP w0.635: v1(237.73,262.67) 236.62,262.67 233.62,265.67
  L07_VI w0.254: SLOT01.F15 109.02,442.29
  L07_VI w0.635: 109.02,442.29 112.9,442.29
SL01_VI100_27_A_HS: length 18.6
  BOTTOM w0.203: v1(248.42,261.77) 246.28,263.91 234.3,263.91 231.97,266.24 v2(231.65,266.24)
SL01_VI100_27_B_HF: length 48.5
  TOP w0.305: SITE3.26_F v2(230.8,270.39)
  L07_VI w0.254: 109.02,416.29 SLOT01.F41
  L07_VI w0.635: 137.4,390.31 137.4,401.43 122.55,416.29 109.02,416.29
SL01_VI100_27_B_HS: length 223.9
  L07_VI w0.254: 109.02,415.14 108.55,415.14 108.4,415.29 SLOT01.G42
  L07_VI w0.635: 109.02,415.14 122.07,415.14 131.32,405.89 131.32,372.24 137.77,365.79 173.26,365.79 174.96,364.09 178.4,364.09 210.24,332.25 222.86,332.25 246.11,308.99 246.11,297.74
  BOTTOM w0.203: v1(235.17,276.75) 234.43,276 234.43,270.7 233.88,270.16 231.7,270.16 231.57,270.03 231.16,270.03 230.8,269.67 v2(230.8,269.59)
SL01_VI100_28_A_HF: length 14.5
  TOP w0.305: 234.3,266.19 234.13,266.19 233.59,266.74 SITE3.19_F
  TOP w0.635: v1(239.27,265.58) 238.62,264.92 235.57,264.92 234.3,266.19
  L07_VI w0.254: SLOT01.F13 109.02,444.29
  L07_VI w0.635: 109.02,444.29 112.84,444.29
SL01_VI100_28_A_HS: length 12.7
  BOTTOM w0.203: v1(243.84,265.58) 242.84,266.58 234.43,266.58 234.27,266.74 v2(231.65,266.74)
SL01_VI100_28_B_HF: length 1.1
  TOP w0.305: SITE3.27_F 230.3,270.49 230,270.79 v2(229.8,270.79)
SL01_VI100_28_B_HS: length 15.4
  BOTTOM w0.152: v2(230.3,269.59) 230.44,269.73 230.44,270.53 230.71,270.8
  BOTTOM w0.203: 230.71,270.8 233.5,270.8 234.03,271.32 234.03,276.17 234.05,276.2 234.05,280.2 v1(235.17,281.32)
SL01_VI100_29_A_HF: length 14.6
  TOP w0.305: SITE3.22_F 232.44,268.24 232.44,268.25 233.26,268.25 233.66,268.65
  TOP w0.635: v1(237.73,268.86) 237.62,268.98 233.99,268.98 233.66,268.65
  L07_VI w0.254: SLOT01.F11 109.02,446.29
  L07_VI w0.635: 109.02,446.29 112.82,446.29
  BOTTOM w0.635: v1(237.73,268.86) 236.67,268.86 236.03,268.22 UNK3C64.2
SL01_VI100_29_A_HS: length 18.1
  BOTTOM w0.203: v1(248.42,268.62) 247.04,270 236.21,270 234.45,268.24 v2(231.65,268.24)
SL01_VI100_29_B_HF: length 0.4
  TOP w0.305: SITE3.32_F v2(227.8,270.39)
  vias: v1(227.43,284.11)
SL01_VI100_29_B_HS: length 9.9
  BOTTOM w0.203: v2(227.8,269.59) 227.8,269.86 227.33,270.33 227.33,271.45 228.59,272.71 228.59,275.84 227.43,277.01 v1(227.43,278.27)
SL01_VI100_30_A_HF: length 14.7
  TOP w0.305: SITE3.23_F 232.52,268.74 232.97,269.19
  TOP w0.635: v1(239.27,271.67) 237.57,269.97 233.75,269.97 232.97,269.19
  L07_VI w0.254: SLOT01.F9 109.02,448.29
  L07_VI w0.635: 109.02,448.29 112.85,448.29
SL01_VI100_30_A_HS: length 14.9
  BOTTOM w0.203: v2(231.65,268.74) 234.31,268.74 236.27,270.7 236.59,270.7 237.12,271.23 237.12,272.36 237.43,272.67 242.85,272.67 v1(243.84,271.67)
SL01_VI100_30_B_HS: length 9.2
  BOTTOM w0.203: v1(234.07,258.18) 234.07,259.95 229.3,264.72 v2(229.3,265.39)
SL01_VI100_31_A_HF: length 16.4
  TOP w0.305: SITE3.24_F 232.05,269.58 232.28,269.81
  TOP w0.635: 232.28,269.81 233.39,270.92 235.98,270.92 236.98,271.92 236.98,272.77 237.62,273.41 238.47,273.41 v1(239.27,274.21)
  L07_VI w0.254: SLOT01.F7 109.02,450.29
  L07_VI w0.635: 109.02,450.29 112.99,450.29
SL01_VI100_31_A_HS: length 40.7
  L07_VI w0.254: SLOT01.B3 97.82,454.51 99.03,454.51 99.54,455.02 100.15,455.02 100.62,454.55 101.28,454.55 101.75,455.02 102.4,455.02 102.87,454.55 103.53,454.55 104.05,455.07 104.21,455.07 105.16,456.02 105.82,456.02 106.29,455.55 106.9,455.55 108.59,457.24 109.02,457.24
  L07_VI w0.635: 109.02,457.24 118.57,457.24
  BOTTOM w0.203: v2(231.65,269.24) 234.18,269.24 236.08,271.14 236.46,271.14 236.72,271.4 236.72,275.08 236.97,275.34 242.72,275.34 v1(243.84,274.21)
SL01_VI100_31_B_HS: length 22.9
  L07_VI w0.254: 109.02,438.55 107.42,438.55 106.94,439.02 106.29,439.02 105.55,438.29 SLOT01.E19
  L07_VI w0.635: 112.85,438.55 109.02,438.55
  BOTTOM w0.203: v1(231.91,253.35) 231.91,253.85 231.51,254.25 230.57,254.25 230.36,254.46 230.36,260.61 228.8,262.17 v2(228.8,265.39)
SL01_VI100_32_A_HF: length 6.8
  TOP w0.305: SITE3.28_F v2(229.8,270.39)
  L07_VI w0.254: 109.02,452.29 SLOT01.F5
  L07_VI w0.635: 112.97,452.29 109.02,452.29
SL01_VI100_32_A_HS: length 22.6
  L07_VI w0.254: SLOT01.D1 102.71,456.29 103.42,457 103.42,458.45 104.15,459.18
  L07_VI w0.635: 118.44,459.53 104.5,459.53 104.15,459.18
  BOTTOM w0.152: v2(229.8,269.59) 229.8,269.74 230.14,270.08 230.14,270.86 230.25,270.97
  BOTTOM w0.203: v1(232.25,272.17) 231.28,271.2 230.49,271.2 230.25,270.97
SL01_VI100_32_B_HS: length 20.5
  L07_VI w0.254: SLOT01.F1 108.7,458.39 109.02,458.39
  L07_VI w0.635: 109.02,458.39 118.51,458.39
  BOTTOM w0.203: v2(227.8,265.39) 227.8,261.39 229.12,260.08 v1(229.12,258.18)
SL02_VI100_2_A_HF: length 11.5
  TOP w0.305: SITE2.2_F 186.18,268.74
  TOP w0.635: 186.18,268.74 180.98,268.74 v1(180.83,268.59)
  BOTTOM w0.635: v1(180.83,268.59) 179.83,267.59 176.82,267.59 UNK2C49.2
SL02_VI100_2_A_HS: length 7.8
  BOTTOM w0.203: v2(187.45,268.74) 184.92,268.74 181.97,265.79 v1(180.83,265.79)
SL02_VI100_2_B_HF: length 9.3
  TOP w0.305: SITE2.29_F 189.3,270.29 189.31,270.3 189.31,270.56 189.29,270.58 189.29,271 189.31,271.02 189.31,271.21 189.94,271.84
  TOP w0.635: 189.94,271.84 191.49,273.39 191.49,277.25 v1(192.25,278.02)
SL02_VI100_2_B_HS: length 14.3
  BOTTOM w0.203: v2(189.3,269.59) 189.21,269.68 189.21,270.84 191.38,273.02 191.38,281.72 v1(192.25,282.59)
SL02_VI100_3_A_HF: length 16.3
  TOP w0.305: SITE2.5_F 185.45,267.24
  TOP w0.635: 185.45,267.24 183.13,264.92 183.13,263.52 v1(180.83,261.22)
  BOTTOM w0.635: v1(175.11,261.22) 175.11,260.93 175.75,260.3 180.19,260.3 180.83,260.93 v1(180.83,261.22)
SL02_VI100_3_A_HS: length 13.4
  BOTTOM w0.203: v1(176.26,263.76) 177.13,262.89 182.62,262.89 186.97,267.24 v2(187.45,267.24)
SL02_VI100_3_B_HS: length 13
  BOTTOM w0.203: v2(188.3,265.39) 188.3,261.78 189.86,260.22 189.86,254.09 v1(189.12,253.35)
SL02_VI100_4_A_HS: length 8.3
  BOTTOM w0.203: v1(180.83,263.76) 181.84,263.76 185.82,267.74 v2(187.45,267.74)
SL02_VI100_4_B_HS: length 13.8
  BOTTOM w0.203: v2(191.65,265.74) 193.97,263.42 202.19,263.42 v1(203.84,261.77)
SL02_VI100_5_A_HF: length 23.1
  TOP w0.305: 186.18,266.45 186.47,266.74 SITE2.6_F
  TOP w0.635: v1(184.16,258.18) 184.16,264.43 186.18,266.45
  BOTTOM w0.508: 184.38,253.35 UNK2K12.4
  BOTTOM w0.635: v1(184.16,258.18) 184.54,258.18 185.18,257.54 185.18,253.35 ; 184.21,247.38 184.45,247.38 185.18,248.1 185.18,253.35 ; 185.18,253.35 184.38,253.35
SL02_VI100_5_A_HS:
  vias: v2(187.45,266.74)
SL02_VI100_6_A_HF:
  vias: v2(187.05,266.24)
SL02_VI100_6_A_HS:
  vias: v1(186.96,253.35) v2(187.45,266.24)
SL02_VI100_6_B_HF: length 1.7
  TOP w0.305: SITE2.30_F v2(188.8,271.66)
SL02_VI100_6_B_HS: length 4.5
  BOTTOM w0.203: UNK2K46.4 189.84,272.05 188.8,271.01 v2(188.8,269.59)
SL02_VI100_7_A_HF:
  vias: v2(189.8,264.99)
SL02_VI100_7_A_HS:
  vias: v1(194.07,253.35) v2(189.8,265.39)
SL02_VI100_7_B_HF: length 10.4
  TOP w0.305: 188.07,271.04 188.29,270.82 188.29,270.3 188.3,270.29 SITE2.31_F
  TOP w0.635: 188.07,271.04 188.07,272.57 189.08,273.58 189.08,278.78 v1(189.84,279.54)
SL02_VI100_7_B_HS: length 15.2
  BOTTOM w0.203: v2(188.3,269.59) 188.3,271.84 189.05,272.6 189.05,283.33 v1(189.84,284.11)
SL02_VI100_8_B_HF: length 5.7
  TOP w0.305: 195.04,266.93 194.73,267.24 SITE2.20_F
  TOP w0.635: v1(196.03,265.94) 195.04,266.93
  BOTTOM w0.635: v1(196.03,265.94) UNK2C61.2
SL02_VI100_8_B_HS: length 17.5
  BOTTOM w0.203: v2(191.65,267.24) 194.53,267.24 194.7,267.06 206.93,267.06 v1(208.42,265.58)
SL02_VI100_9_B_HF: length 7.6
  TOP w0.305: 194.28,267.99 194.03,267.74 SITE2.21_F
  TOP w0.635: 194.28,267.99 198.64,267.99 v1(199.27,268.62)
SL02_VI100_9_B_HS: length 13.3
  BOTTOM w0.203: v2(191.65,267.74) 194.58,267.74 196.34,269.49 202.97,269.49 v1(203.84,268.62)
SL02_VI100_10_A_HF: length 9.6
  TOP w0.305: SITE2.16_F 191.55,264.74 191.98,264.74
  TOP w0.635: v1(197.37,258.18) 196.72,258.83 196.72,260.01 191.98,264.74
SL02_VI100_10_A_HS: length 15.2
  BOTTOM w0.203: v2(191.3,265.39) 191.3,265.13 195.83,260.6 195.83,254.51 196.08,254.25 197.17,254.25 197.37,254.05 v1(197.37,253.35)
SL02_VI100_10_B_HF: length 0.4
  TOP w0.305: SITE2.25_F v2(191.3,270.39)
SL02_VI100_10_B_HS: length 5.7
  BOTTOM w0.203: v2(191.3,269.59) 191.36,269.65 193.95,269.65 195.17,270.87 v1(195.17,272.17)
SL02_VI100_11_A_HF: length 7.2
  TOP w0.305: 193.62,265.67 193.05,266.24 SITE2.18_F
  TOP w0.635: 193.62,265.67 196.62,262.67 v1(197.73,262.67)
SL02_VI100_11_A_HS: length 18.6
  BOTTOM w0.203: v2(191.65,266.24) 191.97,266.24 194.3,263.91 206.28,263.91 v1(208.42,261.77)
SL02_VI100_11_B_HF: length 0.4
  TOP w0.305: SITE2.26_F v2(190.8,270.39)
SL02_VI100_11_B_HS: length 10.5
  BOTTOM w0.203: v1(195.17,276.75) 194.43,276 194.43,270.7 193.88,270.16 191.7,270.16 191.57,270.03 191.16,270.03 190.8,269.67 v2(190.8,269.59)
SL02_VI100_12_A_HF: length 8.2
  TOP w0.305: 194.3,266.19 194.13,266.19 193.59,266.74 SITE2.19_F
  TOP w0.635: 194.3,266.19 195.57,264.92 198.62,264.92 v1(199.27,265.58)
SL02_VI100_12_A_HS: length 12.7
  BOTTOM w0.203: v2(191.65,266.74) 194.27,266.74 194.43,266.58 202.84,266.58 v1(203.84,265.58)
SL02_VI100_12_B_HF: length 1.1
  TOP w0.305: v2(189.8,270.79) 190,270.79 190.3,270.49 SITE2.27_F
SL02_VI100_12_B_HS: length 15.4
  BOTTOM w0.152: v2(190.3,269.59) 190.44,269.73 190.44,270.53 190.71,270.8
  BOTTOM w0.203: 190.71,270.8 193.5,270.8 194.03,271.32 194.03,276.17 194.05,276.2 194.05,280.2 v1(195.17,281.32)
SL02_VI100_13_A_HF: length 8.4
  TOP w0.305: SITE2.22_F 192.44,268.24 192.44,268.25 193.26,268.25 193.66,268.65
  TOP w0.635: v1(197.73,268.86) 197.62,268.98 193.99,268.98 193.66,268.65
  BOTTOM w0.635: v1(197.73,268.86) 196.67,268.86 196.03,268.22 UNK2C64.2
SL02_VI100_13_A_HS: length 18.1
  BOTTOM w0.203: v1(208.42,268.62) 207.04,270 196.21,270 194.45,268.24 v2(191.65,268.24)
SL02_VI100_13_B_HF: length 0.4
  TOP w0.305: SITE2.32_F v2(187.8,270.39)
  vias: v1(187.43,284.11)
SL02_VI100_13_B_HS: length 9.9
  BOTTOM w0.203: v2(187.8,269.59) 187.8,269.86 187.33,270.33 187.33,271.45 188.59,272.71 188.59,275.84 187.43,277.01 v1(187.43,278.27)
SL02_VI100_14_A_HF: length 8.4
  TOP w0.305: 192.97,269.19 192.52,268.74 SITE2.23_F
  TOP w0.635: v1(199.27,271.67) 197.57,269.97 193.75,269.97 192.97,269.19
SL02_VI100_14_A_HS: length 14.9
  BOTTOM w0.203: v2(191.65,268.74) 194.31,268.74 196.27,270.7 196.59,270.7 197.12,271.23 197.12,272.36 197.43,272.67 202.85,272.67 v1(203.84,271.67)
SL02_VI100_14_B_HS: length 9.2
  BOTTOM w0.203: v2(189.3,265.39) 189.3,264.72 194.07,259.95 v1(194.07,258.18)
SL02_VI100_15_A_HF: length 10
  TOP w0.305: 192.28,269.81 192.05,269.58 SITE2.24_F
  TOP w0.635: 192.28,269.81 193.39,270.92 195.98,270.92 196.98,271.92 196.98,272.77 197.62,273.41 198.47,273.41 v1(199.27,274.21)
SL02_VI100_15_A_HS: length 17.3
  BOTTOM w0.203: v1(203.84,274.21) 202.72,275.34 196.97,275.34 196.72,275.08 196.72,271.4 196.46,271.14 196.08,271.14 194.18,269.24 v2(191.65,269.24)
SL02_VI100_15_B_HS: length 13.9
  BOTTOM w0.203: v1(191.91,253.35) 191.91,253.85 191.51,254.25 190.57,254.25 190.36,254.46 190.36,260.61 188.8,262.17 v2(188.8,265.39)
SL02_VI100_16_A_HF: length 0.4
  TOP w0.305: SITE2.28_F v2(189.8,270.39)
SL02_VI100_16_A_HS: length 4.1
  BOTTOM w0.152: 190.25,270.97 190.14,270.86 190.14,270.08 189.8,269.74 v2(189.8,269.59)
  BOTTOM w0.203: 190.25,270.97 190.49,271.2 191.28,271.2 v1(192.25,272.17)
SL02_VI100_16_B_HS: length 7.8
  BOTTOM w0.203: v1(189.12,258.18) 189.12,260.08 187.8,261.39 v2(187.8,265.39)
SL02_VI100_18_A_HF: length 11.5
  TOP w0.305: SITE4.2_F 266.18,268.74
  TOP w0.635: 266.18,268.74 260.98,268.74 v1(260.83,268.59)
  BOTTOM w0.635: UNK4C49.2 256.82,267.59 259.83,267.59 v1(260.83,268.59)
SL02_VI100_18_A_HS: length 7.8
  BOTTOM w0.203: v1(260.83,265.79) 261.97,265.79 264.92,268.74 v2(267.45,268.74)
SL02_VI100_18_B_HF: length 9.3
  TOP w0.305: 269.94,271.84 269.31,271.21 269.31,271.02 269.29,271 269.29,270.58 269.31,270.56 269.31,270.3 269.3,270.29 SITE4.29_F
  TOP w0.635: 269.94,271.84 271.49,273.39 271.49,277.25 v1(272.25,278.02)
SL02_VI100_18_B_HS: length 14.3
  BOTTOM w0.203: v2(269.3,269.59) 269.21,269.68 269.21,270.84 271.38,273.02 271.38,281.72 v1(272.25,282.59)
SL02_VI100_19_A_HF: length 16.3
  TOP w0.305: SITE4.5_F 265.45,267.24
  TOP w0.635: v1(260.83,261.22) 263.13,263.52 263.13,264.92 265.45,267.24
  BOTTOM w0.635: v1(255.11,261.22) 255.11,260.93 255.75,260.3 260.19,260.3 260.83,260.93 v1(260.83,261.22)
SL02_VI100_19_A_HS: length 13.4
  BOTTOM w0.203: v2(267.45,267.24) 266.97,267.24 262.62,262.89 257.13,262.89 v1(256.26,263.76)
SL02_VI100_19_B_HS: length 13
  BOTTOM w0.203: v1(269.12,253.35) 269.86,254.09 269.86,260.22 268.3,261.78 v2(268.3,265.39)
SL02_VI100_20_A_HS: length 8.3
  BOTTOM w0.203: v2(267.45,267.74) 265.82,267.74 261.84,263.76 v1(260.83,263.76)
SL02_VI100_20_B_HS: length 13.8
  BOTTOM w0.203: v1(283.84,261.77) 282.19,263.42 273.97,263.42 v2(271.65,265.74)
SL02_VI100_21_A_HF: length 23.1
  TOP w0.305: SITE4.6_F 266.47,266.74 266.18,266.45
  TOP w0.635: v1(264.16,258.18) 264.16,264.43 266.18,266.45
  BOTTOM w0.508: 264.38,253.35 UNK4K12.4
  BOTTOM w0.635: 265.17,253.35 265.17,257.54 264.54,258.18 v1(264.16,258.18) ; 265.17,253.35 265.17,248.1 264.45,247.38 264.21,247.38 ; 265.17,253.35 264.38,253.35
SL02_VI100_21_A_HS:
  vias: v2(267.45,266.74)
SL02_VI100_22_A_HF:
  vias: v2(267.05,266.24)
SL02_VI100_22_A_HS:
  vias: v1(266.96,253.35) v2(267.45,266.24)
SL02_VI100_22_B_HF: length 1.7
  TOP w0.305: SITE4.30_F v2(268.8,271.66)
SL02_VI100_22_B_HS: length 4.5
  BOTTOM w0.203: UNK4K46.4 269.84,272.05 268.8,271.01 v2(268.8,269.59)
SL02_VI100_23_A_HF:
  vias: v2(269.8,264.99)
SL02_VI100_23_A_HS:
  vias: v1(274.07,253.35) v2(269.8,265.39)
SL02_VI100_23_B_HF: length 10.4
  TOP w0.305: SITE4.31_F 268.3,270.29 268.29,270.3 268.29,270.82 268.07,271.04
  TOP w0.635: v1(269.84,279.54) 269.08,278.78 269.08,273.58 268.07,272.57 268.07,271.04
SL02_VI100_23_B_HS: length 15.2
  BOTTOM w0.203: v2(268.3,269.59) 268.3,271.84 269.05,272.6 269.05,283.33 v1(269.84,284.11)
SL02_VI100_24_B_HF: length 5.7
  TOP w0.305: SITE4.20_F 274.73,267.24 275.04,266.93
  TOP w0.635: v1(276.03,265.94) 275.04,266.93
  BOTTOM w0.635: v1(276.03,265.94) UNK4C61.2
SL02_VI100_24_B_HS: length 17.5
  BOTTOM w0.203: v1(288.42,265.58) 286.93,267.06 274.7,267.06 274.53,267.24 v2(271.65,267.24)
SL02_VI100_25_B_HF: length 7.6
  TOP w0.305: SITE4.21_F 274.03,267.74 274.28,267.99
  TOP w0.635: v1(279.27,268.62) 278.64,267.99 274.28,267.99
SL02_VI100_25_B_HS: length 13.3
  BOTTOM w0.203: v1(283.84,268.62) 282.97,269.49 276.34,269.49 274.58,267.74 v2(271.65,267.74)
SL02_VI100_26_A_HF: length 9.6
  TOP w0.305: SITE4.16_F 271.55,264.74 271.98,264.74
  TOP w0.635: 271.98,264.74 276.72,260.01 276.72,258.83 v1(277.37,258.18)
SL02_VI100_26_A_HS: length 15.2
  BOTTOM w0.203: v1(277.37,253.35) 277.37,254.05 277.17,254.25 276.08,254.25 275.83,254.51 275.83,260.6 271.3,265.13 v2(271.3,265.39)
SL02_VI100_26_B_HF: length 0.4
  TOP w0.305: SITE4.25_F v2(271.3,270.39)
SL02_VI100_26_B_HS: length 5.7
  BOTTOM w0.203: v1(275.17,272.17) 275.17,270.87 273.95,269.65 271.36,269.65 v2(271.3,269.59)
SL02_VI100_27_A_HF: length 7.2
  TOP w0.305: 273.62,265.67 273.05,266.24 SITE4.18_F
  TOP w0.635: v1(277.73,262.67) 276.62,262.67 273.62,265.67
SL02_VI100_27_A_HS: length 18.6
  BOTTOM w0.203: v1(288.42,261.77) 286.28,263.91 274.3,263.91 271.97,266.24 v2(271.65,266.24)
SL02_VI100_27_B_HF: length 0.4
  TOP w0.305: SITE4.26_F v2(270.8,270.39)
SL02_VI100_27_B_HS: length 10.5
  BOTTOM w0.203: v1(275.17,276.75) 274.43,276 274.43,270.7 273.88,270.16 271.7,270.16 271.57,270.03 271.16,270.03 270.8,269.67 v2(270.8,269.59)
SL02_VI100_28_A_HF: length 8.2
  TOP w0.305: 274.3,266.19 274.13,266.19 273.59,266.74 SITE4.19_F
  TOP w0.635: 274.3,266.19 275.57,264.92 278.62,264.92 v1(279.27,265.58)
SL02_VI100_28_A_HS: length 12.7
  BOTTOM w0.203: v1(283.84,265.58) 282.84,266.58 274.43,266.58 274.27,266.74 v2(271.65,266.74)
SL02_VI100_28_B_HF: length 1.1
  TOP w0.305: v2(269.8,270.79) 270,270.79 270.3,270.49 SITE4.27_F
SL02_VI100_28_B_HS: length 15.4
  BOTTOM w0.152: 270.71,270.8 270.44,270.53 270.44,269.73 v2(270.3,269.59)
  BOTTOM w0.203: v1(275.17,281.32) 274.05,280.2 274.05,276.2 274.03,276.17 274.03,271.32 273.5,270.8 270.71,270.8
SL02_VI100_29_A_HF: length 8.4
  TOP w0.305: 273.66,268.65 273.26,268.25 272.44,268.25 272.44,268.24 SITE4.22_F
  TOP w0.635: v1(277.73,268.86) 277.62,268.98 273.99,268.98 273.66,268.65
  BOTTOM w0.635: v1(277.73,268.86) 276.67,268.86 276.03,268.22 UNK4C64.2
SL02_VI100_29_A_HS: length 18.1
  BOTTOM w0.203: v1(288.42,268.62) 287.04,270 276.21,270 274.45,268.24 v2(271.65,268.24)
SL02_VI100_29_B_HF: length 0.4
  TOP w0.305: SITE4.32_F v2(267.8,270.39)
  vias: v1(267.43,284.11)
SL02_VI100_29_B_HS: length 9.9
  BOTTOM w0.203: v1(267.43,278.27) 267.43,277.01 268.59,275.84 268.59,272.71 267.33,271.45 267.33,270.33 267.8,269.86 v2(267.8,269.59)
SL02_VI100_30_A_HF: length 8.4
  TOP w0.305: 272.97,269.19 272.52,268.74 SITE4.23_F
  TOP w0.635: v1(279.27,271.67) 277.57,269.97 273.75,269.97 272.97,269.19
SL02_VI100_30_A_HS: length 14.9
  BOTTOM w0.203: v2(271.65,268.74) 274.31,268.74 276.27,270.7 276.59,270.7 277.12,271.23 277.12,272.36 277.43,272.67 282.85,272.67 v1(283.84,271.67)
SL02_VI100_30_B_HS: length 9.2
  BOTTOM w0.203: v2(269.3,265.39) 269.3,264.72 274.07,259.95 v1(274.07,258.18)
SL02_VI100_31_A_HF: length 10
  TOP w0.305: 272.28,269.81 272.05,269.58 SITE4.24_F
  TOP w0.635: v1(279.27,274.21) 278.47,273.41 277.62,273.41 276.98,272.77 276.98,271.92 275.98,270.92 273.39,270.92 272.28,269.81
SL02_VI100_31_A_HS: length 17.3
  BOTTOM w0.203: v2(271.65,269.24) 274.18,269.24 276.08,271.14 276.46,271.14 276.72,271.4 276.72,275.08 276.97,275.34 282.72,275.34 v1(283.84,274.21)
SL02_VI100_31_B_HS: length 13.9
  BOTTOM w0.203: v2(268.8,265.39) 268.8,262.17 270.36,260.61 270.36,254.46 270.57,254.25 271.51,254.25 271.91,253.85 v1(271.91,253.35)
SL02_VI100_32_A_HF: length 0.4
  TOP w0.305: SITE4.28_F v2(269.8,270.39)
SL02_VI100_32_A_HS: length 4.1
  BOTTOM w0.152: v2(269.8,269.59) 269.8,269.74 270.14,270.08 270.14,270.86 270.25,270.97
  BOTTOM w0.203: 270.25,270.97 270.49,271.2 271.28,271.2 v1(272.25,272.17)
SL02_VI100_32_B_HS: length 7.8
  BOTTOM w0.203: v1(269.12,258.18) 269.12,260.08 267.8,261.39 v2(267.8,265.39)
SL05_PMVI_10_HF:
  vias: v1(148.21,243.34)
SL05_PMVI_11_HF:
  vias: v1(156.46,243.34)
SL05_PMVI_12_HF: length 0.3
  BOTTOM w0.203: U1.4 v1(124.31,294.24)
SL05_PMVI_13_HF:
  vias: v1(130.91,294.24)
SL05_PMVI_14_HF:
  vias: v1(155.49,231.3)
SL05_PMVI_15_HF: length 2.2
  BOTTOM w0.203: U3.1 R15.2 C72.1
SL05_PMVI_16_HF: length 2.7
  BOTTOM w0.381: v1(155.49,226.57) 155.94,226.57 156.14,226.77 U3.3
SL05_PMVI_17_HF:
  vias: v1(150.41,231.3)
SL05_PMVI_18_HF: length 2.2
  BOTTOM w0.203: C73.1 R17.2 U4.1
SL05_PMVI_19_HF: length 0.9
  BOTTOM w0.381: TP_REF_2.1 v1(151.06,229.62)
SL05_PMVI_20_HF:
  vias: v1(228.21,243.34)
SL05_PMVI_21_HF:
  vias: v1(236.46,243.34)
SL05_PMVI_22_HF: length 0.3
  BOTTOM w0.203: UNK3U1.4 v1(204.31,294.24)
SL05_PMVI_23_HF:
  vias: v1(210.91,294.24)
SL05_PMVI_24_HF:
  vias: v1(235.49,231.3)
SL05_PMVI_25_HF: length 2.2
  BOTTOM w0.203: UNK3C72.1 UNK3R15.2 UNK3U3.1
SL05_PMVI_26_HF: length 2.7
  BOTTOM w0.381: v1(235.49,226.57) 235.94,226.57 236.14,226.77 UNK3U3.3
SL05_PMVI_27_HF:
  vias: v1(230.41,231.3)
SL05_PMVI_28_HF: length 2.2
  BOTTOM w0.203: UNK3C73.1 UNK3R17.2 UNK3U4.1
SL05_PMVI_29_HF: length 0.9
  BOTTOM w0.381: UNK3TP_REF_2.1 v1(231.06,229.62)
SL05_PMVI_30_HF:
  vias: v1(148.21,183.34)
SL05_PMVI_31_HF:
  vias: v1(156.46,183.34)
SL05_PMVI_32_HF: length 0.3
  BOTTOM w0.203: UNK5U1.4 v1(124.31,234.24)
SL05_PMVI_33_HF:
  vias: v1(130.91,234.24)
SL05_PMVI_34_HF:
  vias: v1(155.49,171.3)
SL05_PMVI_35_HF: length 2.2
  BOTTOM w0.203: UNK5C72.1 UNK5R15.2 UNK5U3.1
SL05_PMVI_36_HF: length 2.7
  BOTTOM w0.381: v1(155.49,166.57) 155.94,166.57 156.14,166.77 UNK5U3.3
SL05_PMVI_37_HF:
  vias: v1(150.41,171.3)
SL05_PMVI_38_HF: length 2.2
  BOTTOM w0.203: UNK5U4.1 UNK5R17.2 UNK5C73.1
SL05_PMVI_39_HF: length 0.9
  BOTTOM w0.381: UNK5TP_REF_2.1 v1(151.06,169.62)
SL05_PMVI_40_HF:
  vias: v1(228.21,183.34)
SL05_PMVI_41_HF:
  vias: v1(236.46,183.34)
SL05_PMVI_42_HF: length 0.3
  BOTTOM w0.203: UNK7U1.4 v1(204.31,234.24)
SL05_PMVI_43_HF:
  vias: v1(210.91,234.24)
SL05_PMVI_44_HF:
  vias: v1(235.49,171.3)
SL05_PMVI_45_HF: length 2.2
  BOTTOM w0.203: UNK7C72.1 UNK7R15.2 UNK7U3.1
SL05_PMVI_46_HF: length 2.7
  BOTTOM w0.381: v1(235.49,166.57) 235.94,166.57 236.14,166.77 UNK7U3.3
SL05_PMVI_47_HF:
  vias: v1(230.41,171.3)
SL05_PMVI_48_HF: length 2.2
  BOTTOM w0.203: UNK7C73.1 UNK7R17.2 UNK7U4.1
SL05_PMVI_49_HF: length 0.9
  BOTTOM w0.381: UNK7TP_REF_2.1 v1(231.06,169.62)
SL06_DP_0: length 328.7
  L28_DP w0.079: SLOT06.C61 174,78.22 174,77.42 173.62,77.04 173.08,77.04 172.57,77.56 171.88,77.56 171.37,77.04 170.83,77.04 170.52,77.35 169.68,77.35 169.19,76.86 168.81,76.86 167.54,75.6 162.47,75.6 107.08,130.98 107.08,286.47 109.49,288.88 184.17,288.88 185.41,287.63 v1(185.41,286.99)
SL06_DP_1: length 268.2
  L28_DP w0.079: SLOT06.D61 172.22,79.9 112.79,139.33 112.79,245.45 127.96,260.62 154.34,260.62 155.92,262.19 157.93,262.19 158.15,262.42 169.36,262.42 169.53,262.59 176.32,262.59 180.42,266.69 v1(180.83,266.69)
SL06_DP_2: length 218.6
  L30_DP w0.079: SLOT06.E61 169.97,79.19 140.95,108.22 140.95,168.75 149.72,177.53 149.72,201.21 154.34,205.83 154.34,221.47 154.72,221.85 154.72,227.43 156.68,229.39 157.13,229.39 160.47,232.73 160.47,234.02 164.03,237.58 167.13,237.58 169.82,240.27 169.82,254.29 175.17,259.63 178.52,259.63 180.28,261.39 180.28,264.11 v1(180.83,264.66)
SL06_DP_3: length 262.2
  L28_DP w0.079: v1(176.26,264.66) 175.79,264.19 174.07,264.19 173.79,263.91 160.05,263.91 159.36,263.23 129.44,263.23 112.06,245.84 112.06,138.42 167.72,82.75 SLOT06.F61
SL06_DP_4: length 306.6
  L30_DP w0.079: SLOT06.A59 178.82,76.85 177.8,76.85 176.99,76.04 176.46,76.04 175.65,76.85 175.53,76.85 174.95,77.42 174.95,77.71 174.62,78.04 174.21,78.04 173.91,78.34 173.08,78.34 172.74,78 171.71,78 171.37,78.34 170.83,78.34 170.53,78.04 169.71,78.04 169.33,78.42 169.33,79 108.78,139.54 108.78,254.36 117.19,262.77 141.16,262.77 141.8,263.41 172.53,263.41 176.28,267.16 181.28,267.16 182.75,265.7 182.75,256.23 185.63,253.35 v1(186.06,253.35)
SL06_DP_5: length 186.7
  L30_DP w0.079: UNK2K15.2 168.6,237.3 166.01,237.3 164.9,236.19 164.9,232.41 161.5,229.01 158.11,229.01 156.79,227.69 156.79,221.29 154.62,219.12 154.62,205.71 154.58,205.67 154.58,189.18 157.77,185.99 157.77,178.89 169.02,167.64 169.02,92.12 176.62,84.51 176.62,82.65 176.62,82.42 176.62,79.51 176.05,78.93 176.05,78.17 176.72,77.49 SLOT06.B59
SL06_DP_6: length 306.7
  L30_DP w0.079: v1(188.22,258.18) 187.62,258.77 187.62,263.15 180.78,270 176.74,270 172.91,266.17 161.07,266.17 158.96,264.06 142.26,264.06 141.09,265.23 117.27,265.23 106.99,254.95 106.99,139.11 167.08,79.02 167.08,78.42 168.46,77.04 169.12,77.04 169.6,77.53 170.09,77.53 170.79,76.83 171.17,76.83 171.96,76.04 172.49,76.04 173.49,77.04 174.12,77.04 SLOT06.C59
SL06_DP_7: length 301.4
  L30_DP w0.079: v1(188.22,253.35) 188.22,253.54 185.04,256.72 185.04,264.01 181.09,267.95 175.68,267.95 171.42,263.7 141.67,263.7 141.06,263.09 116.75,263.09 108.16,254.5 108.16,139.18 168.37,78.96 168.37,78.92 168.95,78.34 169.12,78.34 169.52,77.95 169.55,77.95 169.63,77.86 170.01,77.86 170.83,77.04 171.37,77.04 171.48,77.16 171.76,77.16 SLOT06.D59
SL06_DP_8: length 344.4
  L28_DP w0.079: SLOT06.E59 171.27,76.69 171.92,77.34 172.53,77.34 173.01,76.86 173.69,76.86 175.19,78.36 176.14,78.36 176.46,78.04 176.99,78.04 177.31,78.36 178.39,78.36 180.77,75.98 181.43,75.98 181.87,76.42 181.87,78.96 181.08,79.76 174.2,79.76 172.87,78.43 172.87,78.42 172.49,78.04 172.48,78.04 172.39,77.95 172.04,77.95 171.41,78.58 170.79,78.58 170.56,78.34 170.54,78.34 170.24,78.04 169.71,78.04 169.14,78.61 168.53,78.61 168.37,78.46 168.37,78.42 167.99,78.04 167.96,78.04 167.89,77.98 164.41,77.98 109,133.38 109,265.38 110.94,267.31 140.98,267.31 143.91,264.38 152.09,264.38 154.25,266.54 163.56,266.54 167.6,270.58 180.28,270.58 189.65,261.21 189.65,254.92 191.01,253.56 v1(191.01,253.35)
SL06_DP_9: length 318.4
  L28_DP w0.079: SLOT06.F59 162.77,76.69 107.79,131.67 107.79,266.42 114,272.63 142.71,272.63 142.71,272.63 143.04,272.63 143.04,272.63 152.04,272.63 152.06,272.65 156.27,272.65 156.32,272.6 180.34,272.6 180.7,272.23 190.74,272.23 192.97,269.99 192.97,260.18 192.7,259.91 192.7,259.52 192.97,259.25 192.97,258.41 193.17,258.21 v1(193.17,258.18)
SL06_DP_10: length 332.1
  L28_DP w0.079: SLOT06.Z59 181.22,77.56 179.39,79.4 174.13,79.4 172.48,77.74 171.97,77.74 171.31,78.4 170.87,78.4 170.63,78.16 170.62,78.16 170.32,77.86 169.63,77.86 169.06,78.43 168.73,78.43 168.64,78.34 168.58,78.34 168.2,77.96 168.2,77.9 167.92,77.62 163.44,77.62 108.38,132.68 108.38,265.9 110.25,267.76 140.99,267.76 144.08,264.67 151.96,264.67 156.79,269.51 165.05,269.51 166.84,271.3 180.05,271.3 190.44,260.91 190.44,256.3 193.17,253.58 v1(193.17,253.35)
SL06_DP_11: length 225.3
  L28_DP w0.079: SLOT06.Z57 182.83,76.3 182.83,78.85 165.61,96.07 165.61,169.4 160.19,174.81 152.75,174.81 148.69,178.88 148.69,179.08 148.41,179.36 148.21,179.36 145.42,182.14 145.42,220.26 145.89,220.73 145.89,227.51 151.87,233.5 151.87,233.6 153.24,234.97 153.63,234.97 153.91,235.25 153.91,235.26 159.29,240.64 187.89,240.64 188.02,240.77 188.41,240.77 188.54,240.64 189.47,240.64 UNK2K23.2
