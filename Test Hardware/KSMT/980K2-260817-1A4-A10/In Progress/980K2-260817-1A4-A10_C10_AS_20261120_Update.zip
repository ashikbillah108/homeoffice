# Allegro board 980K2-260817_261120-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL06_DP_12: length 269.8
  L28_DP w0.079: UNK2K24.2 200.44,241.35 200.44,231.18 197.14,227.87 196.5,227.87 195.43,228.95 193.03,228.95 192.87,228.79 192.58,228.51 192.19,228.51 191.9,228.23 191.51,228.23 191.23,228.51 190.59,228.51 190.25,228.85 190.25,228.96 190.22,228.99 190.22,230.16 190.25,230.19 190.25,230.39 192.01,232.16 192.01,233.74 192.29,234.01 192.29,242.67 191.6,243.36 190.76,243.36 190.18,242.77 190.18,241.75 189.55,241.12 159.37,241.12 154.17,235.92 152.96,235.92 144.83,227.79 144.83,181.03 151.4,174.46 160.15,174.46 165.33,169.28 165.33,95.95 182.43,78.85 182.43,76.59 181.96,76.11 181.82,76.11 181.5,75.8 181.12,75.8 180.37,75.04 180,75.04 179.65,74.69 SLOT06.A57
SL06_DP_13: length 334.8
  L30_DP w0.079: SLOT06.B57 176.72,75.65 176.51,75.86 176.38,75.86 176.2,76.04 176.17,76.04 175.87,76.34 175.33,76.34 175.25,76.27 174.97,76.27 174.74,76.04 174.21,76.04 173.83,76.42 173.83,76.61 173.72,76.72 173.42,76.72 172.57,75.86 171.88,75.86 171.19,76.56 170.76,76.56 170.24,76.04 169.71,76.04 169.09,76.66 168.6,76.66 167.99,76.04 167.46,76.04 167.08,76.42 167.08,76.96 167.24,77.13 167.24,77.92 104.6,140.56 104.6,257.27 118.58,271.25 151.97,271.25 153.11,270.1 157.03,270.1 159.41,272.49 169.61,272.49 170.01,272.88 180.76,272.88 181.43,272.21 190.63,272.21 195.4,267.45 195.4,254.41 196.46,253.35 v1(196.47,253.35)
SL06_DP_14: length 455.8
  L30_DP w0.079: SLOT06.C57 175.82,74.69 175.9,74.62 175.9,74.35 176.38,73.86 176.76,73.86 176.79,73.84 176.93,73.84 176.94,73.83 177.07,73.83 177.58,74.34 177.71,74.34 178.71,75.34 179.24,75.34 179.46,75.13 179.75,75.13 179.83,75.04 180.37,75.04 180.45,75.13 180.49,75.13 180.56,75.2 180.82,75.2 180.96,75.34 181.49,75.34 183,73.84 183,71.96 182.84,71.79 182.72,71.68 182.72,70.78 182.72,70.78 182.72,70.07 182.72,70.07 182.72,69.27 181,67.55 180.88,67.55 180.37,67.04 179.83,67.04 179.19,67.68 178.76,67.68 178.12,67.04 177.55,67.04 177.25,67.34 176.46,67.34 175.98,66.86 175.26,66.86 174.73,67.39 174.22,67.39 173.69,66.86 173.01,66.86 172.53,67.34 171.96,67.34 171.89,67.28 171.86,67.28 171.44,66.86 170.76,66.86 170.27,67.35 170.27,67.52 170.19,67.6 169.68,67.6 169.12,67.04 168.58,67.04 167.76,67.86 167.38,67.86 166.63,68.61 149.35,68.61 93.39,124.58 93.39,279.22 120.68,306.51 198.09,306.51 207.28,297.32 207.28,294.07 210.51,290.84 210.51,278.67 206.5,274.66 206.5,263.52 203.84,260.87 v1(203.84,260.87)
SL06_DP_15: length 286.7
  L28_DP w0.079: v1(208.42,260.87) 208.42,248.32 203.45,243.36 202.22,243.36 201.63,242.76 201.63,237.12 201.52,237.01 201.52,233.16 201.63,233.05 201.63,231.97 197.2,227.54 196.44,227.54 195.31,228.67 193.15,228.67 192.7,228.22 192.3,228.22 192.02,227.94 191.4,227.94 191.12,228.22 190.48,228.22 190.48,228.23 189.54,228.23 189.26,228.5 189.26,228.89 189.93,229.56 189.93,237.81 188.69,239.05 188.69,239.08 188.41,239.36 188.38,239.36 187.58,240.16 162.22,240.16 161.63,239.57 161.63,239.53 159.09,236.98 159.09,236.66 158.81,236.38 158.74,236.38 157.24,234.89 157.24,228.91 157.26,228.89 157.26,228.5 157.24,228.49 157.24,226.77 153.93,223.46 153.93,198.98 154.54,198.37 154.54,188.73 153.09,187.28 153.09,178.86 156.04,175.92 158.71,175.92 158.99,175.64 158.99,175.58 159.47,175.09 160.31,175.09 165.89,169.51 165.89,96.19 183.2,78.88 183.2,75.58 181.66,74.04 180.96,74.04 180.58,74.42 180.58,74.44 180.34,74.68 179.89,74.68 179.72,74.51 179.71,74.51 179.24,74.04 178.71,74.04 178.33,74.42 178.33,74.96 178.5,75.14 178.5,75.96 178.12,76.34 177.83,76.34 177.37,76.8 177.37,76.96 176.99,77.34 176.17,77.34 175.87,77.04 175.33,77.04 175.12,76.84 175.12,76.42 174.74,76.04 174.21,76.04 173.57,76.68 173.2,76.68 172.7,76.18 172.7,75.17 SLOT06.D57
SL06_DP_16: length 453
  L30_DP w0.079: SLOT06.E57 171.51,74.69 171.58,74.63 171.58,74.42 171.96,74.04 172.49,74.04 172.87,74.42 172.87,74.61 173.04,74.78 173.75,74.78 173.83,74.7 173.83,74.42 174.21,74.04 174.87,74.04 174.95,73.96 174.95,73.42 175.33,73.04 175.87,73.04 176.51,73.68 176.69,73.68 176.71,73.66 176.85,73.66 176.87,73.65 176.94,73.65 177.47,73.12 177.51,73.12 177.58,73.04 178.12,73.04 178.19,73.12 178.35,73.12 179.76,74.52 180.44,74.52 180.85,74.11 180.89,74.11 181.01,73.99 182.04,73.99 182.72,73.31 182.72,72.07 182.44,71.79 182.44,70.66 182.44,70.19 181.96,69.71 181.67,69.71 181.64,69.68 181.3,69.68 180.41,68.8 180.25,68.8 179.32,67.86 178.63,67.86 177.99,68.5 177.71,68.5 177.07,67.86 176.69,67.86 175.87,67.04 175.33,67.04 174.81,67.57 174.14,67.57 173.62,67.04 173.08,67.04 172.56,67.57 171.89,67.57 171.37,67.04 170.83,67.04 170.45,67.42 170.45,67.6 170.27,67.78 169.98,67.78 169.9,67.86 169.63,67.86 169.15,68.35 169.15,68.39 168.98,68.56 168.47,68.56 168.37,68.46 168.37,68.42 167.99,68.04 167.46,68.04 166.6,68.9 149.84,68.9 93.86,124.89 93.86,278.53 121.01,305.69 197.88,305.69 206.06,297.51 206.06,293.71 209.93,289.84 209.93,278.91 206.08,275.06 206.08,266.79 203.96,264.68 v1(203.84,264.68)
SL06_DP_17: length 283.4
  L28_DP w0.079: SLOT06.F57 168.2,75.17 168.2,75.96 168.58,76.34 169.12,76.34 169.13,76.33 169.42,76.33 169.71,76.04 169.79,76.04 170.27,75.56 170.31,75.56 171.35,74.52 171.44,74.52 171.49,74.48 171.53,74.48 171.96,74.04 172.49,74.04 172.87,74.42 172.87,74.58 173.34,75.04 173.62,75.04 174.44,75.86 174.82,75.86 175.15,76.2 175.19,76.2 175.33,76.34 175.87,76.34 176.01,76.2 176.3,76.2 176.46,76.04 176.54,76.04 178.15,74.44 178.15,74.35 178.63,73.86 179.32,73.86 179.79,74.33 179.8,74.33 179.91,74.44 180.32,74.44 180.39,74.37 180.39,74.35 180.88,73.86 182.2,73.86 183.64,75.31 183.64,78.83 166.17,96.3 166.17,169.91 159.09,177 159.09,177.05 158.81,177.33 158.76,177.33 155.65,180.43 155.65,188.51 155,189.16 155,198.31 154.34,198.98 154.34,222.09 156.26,224.01 156.27,224.01 156.55,224.28 156.55,224.3 158.12,225.87 158.12,232.93 163.16,237.97 180.34,237.97 180.77,238.41 181.17,238.41 188.59,230.98 188.59,228.86 188.98,228.47 188.98,228.39 189.42,227.94 190.36,227.94 190.36,227.94 191,227.94 191.28,227.66 192.14,227.66 192.42,227.94 192.82,227.94 193.26,228.39 195.19,228.39 196.32,227.26 197.32,227.26 201.91,231.85 201.91,232.16 201.91,232.16 201.91,233.17 201.8,233.27 201.8,236.9 203.95,239.04 203.95,242.79 209.28,248.11 209.28,261.74 208.42,262.6 v1(208.42,264.68)
SL06_DP_18: length 434.5
  L30_DP w0.079: v1(203.84,267.72) 204.15,267.72 205.08,268.65 205.08,274.81 209.34,279.07 209.34,289.82 205.72,293.44 205.72,297.05 197.6,305.17 121.59,305.17 94.44,278.03 94.44,125.1 150.35,69.19 167.3,69.19 167.6,69.49 167.88,69.49 168.51,68.86 168.93,68.86 169.33,68.47 169.33,68.42 169.71,68.04 170.24,68.04 170.77,68.57 171.18,68.57 171.88,67.86 172.57,67.86 172.99,68.29 173.03,68.29 173.08,68.34 173.62,68.34 173.67,68.29 173.71,68.29 174.13,67.86 174.82,67.86 175.24,68.29 175.28,68.29 175.35,68.36 176.14,68.36 176.46,68.04 176.99,68.04 177.63,68.68 178.07,68.68 178.71,68.04 179.24,68.04 180.18,68.98 180.3,68.98 181.19,69.86 181.57,69.86 181.61,69.9 181.75,69.9 182.16,70.31 182.16,70.54 182.16,71.91 182.44,72.19 182.44,73.2 181.93,73.71 181.73,73.71 181.72,73.71 181,73.71 180.37,74.34 179.83,74.34 178.97,73.49 SLOT06.A55
SL06_DP_19: length 276.1
  L28_DP w0.079: v1(208.42,267.72) 208.42,266.42 209.16,265.67 209.16,263.57 210.99,261.74 210.99,249.22 204.23,242.46 204.23,238.55 202.69,237.01 202.69,235.17 202.82,235.04 202.82,234.57 203.04,234.35 203.04,232.11 197.03,226.1 194.69,226.1 193.41,227.38 191.51,227.38 190.94,226.8 190.55,226.8 190.27,227.08 190.27,227.47 190.08,227.66 189.3,227.66 188.7,228.27 188.7,228.35 188.31,228.74 188.31,228.76 188.09,228.97 188.09,230.92 181.48,237.54 181.24,237.54 181.17,237.46 180.77,237.46 180.7,237.54 163.14,237.54 158.5,232.89 158.5,225.66 157.31,224.47 157.31,221.82 154.7,219.22 154.7,216.55 154.74,216.51 154.74,212.41 154.7,212.37 154.7,199.01 155.28,198.43 155.28,189.79 156.98,188.1 156.98,179.86 166.45,170.38 166.45,96.56 184.02,78.99 184.02,77.09 183.92,76.99 183.92,75.19 182.31,73.58 181.73,73.58 181.62,73.68 181.01,73.68 180.37,73.04 179.83,73.04 179.34,73.53 178.61,73.53 178.12,73.04 177.08,73.04 SLOT06.B55
SL06_DP_20: length 432.1
  L30_DP w0.079: v1(203.84,270.77) 203.92,270.77 204.66,271.52 204.66,275 208.78,279.11 208.78,289.02 205.05,292.75 205.05,296.99 197.56,304.48 122.04,304.48 95.08,277.52 95.08,125.28 150.52,69.83 167.16,69.83 167.31,69.68 167.94,69.68 168.58,69.04 169.12,69.04 169.76,69.68 170.11,69.68 170.27,69.52 170.27,69.35 170.76,68.86 171.14,68.86 171.96,68.04 172.49,68.04 173.13,68.68 173.57,68.68 174.21,68.04 174.74,68.04 175.45,68.75 175.48,68.75 175.6,68.86 175.94,68.86 176.44,69.36 177.01,69.36 177.51,68.86 178.19,68.86 179.19,69.86 179.32,69.86 180.14,70.68 180.32,70.68 180.96,70.04 181.49,70.04 181.87,70.42 181.87,72.03 182.16,72.31 182.16,73.08 181.71,73.52 180.88,73.52 179.88,72.52 179.69,72.52 179.62,72.46 179.62,72.42 179.24,72.04 179.21,72.04 179.1,71.93 178.79,71.93 178.19,72.52 177.81,72.52 176.99,73.34 176.46,73.34 175.82,72.7 175.18,72.7 175.17,72.69 SLOT06.C55
SL06_DP_21: length 427.2
  L30_DP w0.079: SLOT06.D55 173.52,72.69 174.17,72.04 174.78,72.04 175.26,72.52 175.94,72.52 176.43,72.04 176.43,71.6 176.51,71.53 177.06,71.53 177.2,71.67 177.2,71.96 177.58,72.34 178.12,72.34 178.82,71.64 179.25,71.64 179.45,71.84 179.45,71.96 179.83,72.34 179.96,72.34 180.96,73.34 181.49,73.34 181.87,72.96 181.87,72.42 181.4,71.96 181.4,71.83 180.44,70.86 180.06,70.86 179.24,70.04 178.66,70.04 178.5,69.88 178.5,69.42 178.12,69.04 177.58,69.04 177.09,69.54 176.36,69.54 175.87,69.04 175.33,69.04 174.86,69.51 174.34,69.51 173.69,68.86 172.97,68.86 172.2,69.63 171.96,69.63 171.37,69.04 170.83,69.04 170.45,69.42 170.45,69.69 170.27,69.86 169.6,69.86 169.12,70.34 168.58,70.34 168.1,69.86 167.38,69.86 167.1,70.15 150.91,70.15 95.83,125.24 95.83,277.19 122.19,303.56 197.71,303.56 203.78,297.48 203.78,292.51 208.25,288.04 208.25,279.37 204.34,275.46 204.34,273.85 203.9,273.41 v1(203.84,273.41)
SL06_DP_22: length 366
  L28_DP w0.079: v1(196.08,272.17) 197.16,273.26 197.16,285.05 188.75,293.46 111.55,293.46 105.78,287.69 105.78,114.78 146.02,74.55 166.7,74.55 167.38,73.86 168.1,73.86 168.58,74.34 169.15,74.34 169.63,73.86 169.72,73.86 169.97,73.61 SLOT06.E55
SL06_DP_23: length 313.2
  L30_DP w0.079: v1(196.08,276.75) 196.08,276 195.89,275.81 195.88,275.81 195.6,275.53 195.6,275.52 192.74,272.66 184.15,272.66 182.61,274.2 170.82,274.2 169.45,272.83 156.33,272.83 156.2,272.96 143.37,272.96 143.04,272.63 119.03,272.63 103.97,257.57 103.97,139.97 165.98,77.96 165.98,74.44 SLOT06.F55
SL06_DP_24: length 338
  L30_DP w0.079: v1(196.08,281.32) 196.08,281.21 193.07,278.2 193.07,275.92 192.68,275.53 192.68,274.37 191.32,273.01 184.4,273.01 182.75,274.65 170.73,274.65 170.46,274.93 157.17,274.93 156.12,275.98 140.18,275.98 137.66,273.45 118.65,273.45 103.29,258.09 103.29,139.4 165.26,77.44 165.26,74.42 167.08,72.6 167.08,72.42 167.46,72.04 167.99,72.04 168.79,72.84 168.91,72.84 169.43,73.35 170.06,73.35 170.07,73.34 170.24,73.34 170.62,72.96 170.62,72.79 170.89,72.52 171.44,72.52 171.74,72.23 171.78,72.23 171.96,72.04 172.58,72.04 172.88,72.34 173.62,72.34 174.22,71.74 174.52,71.74 174.56,71.7 174.69,71.7 175.33,72.34 175.87,72.34 176.25,71.96 176.25,71.53 176.43,71.35 176.58,71.35 176.58,71.34 176.99,71.34 177.37,70.96 177.37,70.78 177.61,70.54 178.09,70.54 178.33,70.77 178.33,70.96 178.71,71.34 179.24,71.34 179.54,71.04 180.37,71.04 181.22,71.9 SLOT06.Z55
SL06_DP_25: length 379.7
  L28_DP w0.079: v1(193.15,272.17) 193.15,273.09 196.61,276.54 196.61,284.73 190.7,290.64 181.4,290.64 180.62,291.42 110.85,291.42 106.45,287.02 106.45,114.91 146.3,75.06 166.44,75.06 167.46,74.04 167.99,74.04 168.99,75.04 169.12,75.04 169.64,75.56 170.02,75.56 170.2,75.38 170.24,75.38 171.28,74.34 171.37,74.34 171.42,74.3 171.45,74.3 171.88,73.86 172.6,73.86 173.6,74.86 173.69,74.86 174.14,75.31 174.17,75.31 174.21,75.34 175.03,75.34 175.33,75.04 175.65,75.04 176.08,74.62 176.08,74.42 176.46,74.04 176.46,73.34 176.08,72.96 176.08,72.42 176.46,72.04 176.99,72.04 177.81,72.86 178.19,72.86 178.61,73.28 178.64,73.28 178.71,73.34 179.24,73.34 179.31,73.28 179.34,73.28 179.76,72.86 180.14,72.86 181.22,71.78 SLOT06.Z53
SL06_DP_26: length 340.7
  L30_DP w0.079: v1(193.15,282.59) 193.07,282.59 192.26,283.4 183.44,283.4 180.81,286.03 176.41,286.03 174.15,288.29 161.46,288.29 161.1,287.93 142.36,287.93 142,288.29 124.53,288.29 101.31,265.08 101.31,137.71 164.07,74.96 164.07,73.13 166.11,71.09 167.21,71.09 167.46,71.34 167.99,71.34 168.24,71.09 168.28,71.09 168.51,70.86 169.19,70.86 169.42,71.09 169.46,71.09 169.71,71.34 170.24,71.34 170.49,71.09 170.53,71.09 170.76,70.86 171.14,70.86 171.96,70.04 172.66,70.04 173.46,70.84 173.71,70.84 174.21,71.34 174.74,71.34 175.12,70.96 175.12,70.62 175.4,70.34 175.87,70.34 176.49,69.72 177.06,69.72 177.2,69.86 177.2,69.96 177.58,70.34 178.12,70.34 178.14,70.32 178.6,70.32 SLOT06.A53
SL06_DP_27: length 324.9
  L30_DP w0.079: v1(190.74,273.7) 184.38,273.7 182.76,275.32 158.46,275.32 153.28,280.5 143.7,280.5 137.17,273.98 118.18,273.98 102.7,258.49 102.7,138.8 164.8,76.69 164.8,73.57 165.55,72.81 165.7,72.81 166.65,71.86 168.08,71.86 168.64,72.42 169.33,72.42 169.71,72.04 170.53,72.04 170.83,72.34 171.37,72.34 171.67,72.04 171.7,72.04 171.88,71.86 172.26,71.86 173.08,71.04 173.62,71.04 174.02,71.45 174.06,71.45 174.13,71.52 174.82,71.52 175.65,70.69 SLOT06.B53
SL06_DP_28: length 335
  L30_DP w0.079: SLOT06.C53 174.47,69.9 173.62,69.04 173.08,69.04 172.26,69.86 171.88,69.86 171.32,70.43 170.63,70.43 170.24,70.04 169.71,70.04 169.33,70.42 169.33,70.55 169.2,70.67 168.62,70.67 167.99,70.04 167.46,70.04 166.83,70.67 165.95,70.67 163.79,72.84 163.79,73.86 100.77,136.88 100.77,265.69 124.13,289.06 181.62,289.06 185.85,284.83 190.06,284.83 190.74,284.15 v1(190.74,284.11)
SL06_DP_29: length 327.9
  L30_DP w0.079: v1(188.33,278.27) 188.33,278.18 185.84,275.7 159.59,275.7 154.15,281.15 154.15,282.78 153.28,283.65 150.94,283.65 150.94,283.64 147.23,283.64 147.23,283.65 140.96,283.65 138.63,285.98 123.51,285.98 102,264.46 102,138.24 164.35,75.89 164.35,73.54 166.26,71.63 167.99,71.63 168.58,71.04 169.12,71.04 169.5,71.42 169.5,71.5 169.63,71.63 170.25,71.63 170.83,71.04 171.87,71.04 SLOT06.D53
SL06_DP_30: length 498.5
  L28_DP w0.079: SLOT06.E53 169.5,71.17 169.5,71.96 169.12,72.34 168.58,72.34 168.48,72.24 168.19,72.24 167.99,72.04 167.1,72.04 167.05,71.99 166.56,71.99 161.36,66.79 161.36,44.56 165.64,40.28 166.27,40.28 166.33,40.34 166.87,40.34 167.51,39.7 167.66,39.7 167.94,39.7 168.58,40.34 169.12,40.34 169.76,39.7 169.86,39.7 170.19,39.7 170.83,40.34 171.37,40.34 172.01,39.7 172.44,39.7 173.08,40.34 173.62,40.34 174.26,39.7 174.69,39.7 175.33,40.34 175.87,40.34 176.52,39.69 176.93,39.69 177.58,40.34 178.12,40.34 178.5,39.96 178.5,39.82 178.98,39.34 179.24,39.34 179.81,38.78 180.39,38.78 180.96,39.34 181.49,39.34 182.34,38.5 204.02,38.5 212.6,47.07 212.6,83.82 228.57,99.79 305.02,99.79 337.44,132.21 337.44,266.32 307.95,295.8 274.23,295.8 267.49,289.07
  L28_DP w0.102: v1(265.41,286.99) 267.49,289.07
SL06_DP_31: length 513.2
  L28_DP w0.079: SLOT06.F53 167.72,70.1 162.47,64.85 162.47,44.82 166.27,41.02 166.88,41.02 167.38,41.52 168.07,41.52 168.71,40.88 168.99,40.88 169.63,41.52 170.32,41.52 170.96,40.88 171.24,40.88 171.88,41.52 172.57,41.52 173.21,40.88 173.49,40.88 174.13,41.52 174.85,41.52 175.33,41.04 175.87,41.04 175.94,41.11 175.97,41.11 176.38,41.52 177.07,41.52 177.71,40.88 177.99,40.88 178.63,41.52 179.32,41.52 180.32,40.52 180.44,40.52 181.08,39.88 181.72,39.88 181.76,39.84 182.19,39.84 182.2,39.84 203.3,39.84 210.19,46.72 210.19,84.96 227.2,101.98 227.2,103.62 290.31,103.62 329.31,142.62 329.31,266.12 319.08,276.35 319.02,276.35 306.8,288.57 279.43,288.57 274.47,283.61 274.47,277.76 270.91,274.19 270.4,274.19 265.92,269.72 265.92,258.13 266.37,257.68 267.63,257.68 270,255.31 270,253.57 269.04,252.6 265.81,252.6 263.73,254.68 263.73,255.21 262.79,256.15 262.79,256.62 263.53,257.35 263.53,264 v1(260.83,266.69)
SL06_DP_32: length 476.5
  L28_DP w0.079: v1(260.83,264.66) 261.49,264 261.49,254.04 265.95,249.58 269.01,249.58 270.09,250.66 273.13,250.66 276,253.53 276,253.55 276.28,253.82 277.57,253.82 277.84,253.55 277.84,252.32 276.94,251.42 276.94,251.41 276.67,251.13 276.66,251.13 273.69,248.16 252.22,248.16 249.81,250.57 249.81,255.25 256.79,262.23 256.79,267.85 258.61,269.67 258.61,269.68 258.88,269.96 258.9,269.96 259.36,270.42 259.36,271.93 268.19,280.76 271.07,280.76 271.6,281.29 271.6,285.67 270.94,286.33 268.13,286.33 267.73,285.93 267.49,285.93 ; SLOT06.A51 178.97,69.49 179.83,70.34 180.37,70.34 180.5,70.22 180.67,70.04 181.49,70.04 184.53,73.08 184.53,78.99 168.02,95.5 168.02,190.3 168.03,190.34 168.03,190.64 168.02,190.68 168.02,197.64 164.82,200.83 164.82,214 168.63,217.81 168.63,226.32 167.78,227.18 163.46,227.18 160.4,230.23 160.4,234.21 163.33,237.14 181.37,237.14 186.24,232.27 186.24,229.07 186.71,228.6 187.96,228.6 189.07,227.49 189.08,227.49 189.19,227.38 189.57,227.38 190.43,226.52 191.05,226.52 191.63,227.1 193.17,227.1 195.04,225.23 197.82,225.23 199.79,227.2 200.52,227.2 203.73,230.41 203.77,230.41 205.74,232.38 205.81,232.38 206.08,232.66 206.08,232.72 211.1,237.74 217.04,237.74 222.16,242.86 222.16,256.56 223.69,258.09 223.69,258.37 223.95,258.63 223.95,287.73 232.23,296.02 244.5,296.02 245.57,294.95 247.98,294.95 249.19,296.16 251.32,296.16
  L28_DP w0.102: 267.49,285.93 265.25,285.93 264.09,287.09 264.09,291.99 261.05,295.03 261.05,295.05 260.45,295.65 260.43,295.65 259.92,296.16 251.32,296.16
SL06_DP_33: length 359.5
  L28_DP w0.079: 251.32,239.64 248.79,242.16 248.79,256.56 255.65,263.42 255.65,264.06 v1(256.26,264.66) ; 251.32,226.69 242.96,226.69 241.68,225.41 235.56,225.41 233.87,223.72 233.87,201.96 232.48,200.57 232.48,189.43 233.05,188.85 233.05,182.64 195.19,144.77 195.19,121.48 194.88,121.17 194.88,51.57 190.65,47.34 181.75,47.34 181.57,47.52 180.88,47.52 180.25,46.89 179.95,46.89 179.32,47.52 178.63,47.52 177.98,46.87 177.46,46.87 176.99,47.34 176.46,47.34 175.96,46.85 175.24,46.85 174.74,47.34 174.21,47.34 173.71,46.85 172.99,46.85 172.49,47.34 171.96,47.34 171.46,46.85 171.17,46.85 170.35,46.02 169.44,46.02 169.12,46.34 168.58,46.34 168.26,46.02 167.38,46.02 166.82,46.59 166.82,47 167.25,47.42 167.25,47.96 166.82,48.39 166.82,49 167.87,50.04 167.99,50.04 168.37,50.42 168.37,50.55 168.87,51.04 169.12,51.04 169.5,51.42 169.5,51.96 169.12,52.34 168.9,52.34 168.37,52.87 168.37,52.96 167.99,53.34 167.9,53.34 165.51,55.73 165.51,59.66 167.38,61.52 168.07,61.52 168.55,61.04 169.15,61.04 169.7,61.59 170.18,61.59 170.45,61.87 170.45,61.96 170.83,62.34 171.37,62.34 172.01,61.7 172.44,61.7 173.08,62.34 173.62,62.34 174,61.96 174,61.42 174.08,61.34 174.74,61.34 175.21,60.87 175.99,60.87 176.46,61.34 176.99,61.34 177.29,61.04 178.24,61.04 178.33,60.96 178.33,60.42 178.71,60.04 179.24,60.04 179.71,60.51 179.71,61.17 179.45,61.42 179.45,61.96 179.96,62.47 179.96,62.48 181.99,64.52 181.99,67.01 180.31,68.69 179.89,68.69 179.24,68.04 178.71,68.04 178.06,68.69 SLOT06.B51
  L28_DP w0.102: 251.32,226.69 254.28,226.69 255.61,225.37 265.11,225.37 265.48,225.73 265.49,225.73 266.6,226.84 266.62,226.84 266.8,227.02 266.8,227.05 267.24,227.49 267.24,231.97 262.8,236.41 254.55,236.41 251.32,239.64
SL06_DP_34: length 509.5
  L28_DP w0.079: v1(266.06,253.35) 265.02,254.39 265.02,274.18 266.1,275.26 266.1,275.26 269.66,278.82 272.94,278.82 273.69,279.57 273.69,283.74 279.28,289.33 309.09,289.33 330.27,268.16 330.27,140.78 291.4,101.92 228.28,101.92 211.01,84.65 211.01,46.66 203.17,38.81 182.42,38.81 181.96,39.28 181.82,39.28 181.57,39.52 180.88,39.52 180.31,38.96 179.89,38.96 179.32,39.52 179.23,39.52 178.23,40.52 177.47,40.52 176.99,40.04 176.46,40.04 175.98,40.52 175.22,40.52 174.74,40.04 174.21,40.04 173.73,40.52 172.97,40.52 172.49,40.04 171.96,40.04 171.48,40.52 170.72,40.52 170.24,40.04 169.71,40.04 169.23,40.52 168.47,40.52 167.99,40.04 167.46,40.04 166.98,40.52 165.89,40.52 161.78,44.63 161.78,66.32 167.13,71.66 167.96,71.66 168.84,70.78 168.97,70.78 169.72,70.03 169.96,70.03 169.97,70.04 170.24,70.04 170.62,70.42 170.62,70.7 170.97,71.04 171.37,71.04 171.75,71.42 171.75,71.57 171.84,71.67 172.46,71.67 173.08,71.04 173.41,71.04 173.83,70.63 173.83,70.42 174.21,70.04 174.41,70.04 174.47,69.98 SLOT06.C51
SL06_DP_35: length 392.2
  L28_DP w0.079: 267.49,241.33 276.99,241.33 279.02,243.36 293.73,243.36 310.77,226.31 310.77,140.97 285.75,115.95 223.01,115.95 201.95,94.89 201.95,51.46 195.68,45.2 182.04,45.2 181.71,45.52 180.85,45.52 180.37,45.04 179.8,45.04 179.32,45.52 178.6,45.52 178.12,45.04 177.55,45.04 177.07,45.52 176.69,45.52 175.87,46.34 175.33,46.34 174.51,45.52 174.1,45.52 173.62,45.04 173.05,45.04 172.57,45.52 171.85,45.52 171.37,45.04 170.8,45.04 170.32,45.52 169.6,45.52 169.12,45.04 168.55,45.04 168.07,45.52 167.35,45.52 166.87,45.04 166.33,45.04 165.14,46.24 165.14,60.15 166.69,61.71 168.04,61.71 168.2,61.88 168.2,61.96 168.58,62.34 168.67,62.34 171.75,65.42 171.75,66.25 171.58,66.42 171.58,67.25 171.75,67.42 171.75,68.22 SLOT06.D51
  L28_DP w0.102: UNK4K15.2 254.67,243.37 257.28,243.37 257.87,242.77 257.87,242.76 259.3,241.33 267.49,241.33
SL06_DP_36: length 444.6
  L28_DP w0.079: v1(268.22,258.18) 268.69,258.65 268.69,260.48 277.54,269.33 277.71,269.33 283.46,275.08 311.15,275.08 320.42,265.81 320.42,138.05 289.56,107.19 226.31,107.19 208.15,89.03 208.15,48.01 202.85,42.7 182.53,42.7 181.96,43.27 181.82,43.27 181.57,43.52 180.88,43.52 180.24,42.88 179.96,42.88 179.32,43.52 178.63,43.52 177.99,42.88 177.71,42.88 177.07,43.52 176.38,43.52 175.74,42.88 175.49,42.88 175.32,43.05 175.29,43.05 174.82,43.52 174.13,43.52 173.49,42.88 173.21,42.88 172.57,43.52 171.88,43.52 171.24,42.88 170.96,42.88 170.32,43.52 169.63,43.52 168.99,42.88 168.71,42.88 168.07,43.52 167.38,43.52 166.74,42.88 166.18,42.88 163.66,45.4 163.66,63.43 167.08,66.84 167.08,66.96 167.46,67.34 168.03,67.34 168.51,66.86 169.19,66.86 169.97,67.65 SLOT06.E51
SL06_DP_37: length 501
  L28_DP w0.079: SLOT06.F51 167.47,68.95 167.47,69.52 168.37,70.42 168.37,70.96 167.99,71.34 167.37,71.34 162.16,66.13 162.16,44.65 166.07,40.74 166.38,40.74 166.42,40.7 166.82,40.7 167.46,41.34 167.99,41.34 168.63,40.7 169.07,40.7 169.71,41.34 170.24,41.34 170.88,40.7 171.32,40.7 171.96,41.34 172.49,41.34 173.13,40.7 173.57,40.7 174.21,41.34 174.74,41.34 175.38,40.7 175.82,40.7 176.46,41.34 176.99,41.34 177.63,40.7 178.07,40.7 178.71,41.34 179.24,41.34 179.62,40.96 179.62,40.9 180.18,40.34 180.37,40.34 181.01,39.7 181.64,39.7 181.79,39.56 182.08,39.56 182.54,39.09 203.05,39.09 210.57,46.61 210.57,84.84 228.22,102.49 290.56,102.49 329.95,141.88 329.95,267.06 307.96,289.05 279.4,289.05 273.97,283.62 273.97,278.66 273.89,278.59 272.63,277.33 269.37,277.33 267.02,274.98 266.22,274.98 265.3,274.07 265.3,258.06 267.75,255.62 267.75,254.82 268.22,254.35 v1(268.22,253.35)
SL06_DP_38: length 426.9
  L30_DP w0.079: 227.49,293.67 237.65,303.83 280.81,303.83 293.83,290.81 293.83,260.76 293.66,260.59 291.42,258.35 285.85,258.35 284.93,259.27 280.01,259.27 275.15,254.41 275.15,253.76 273.83,252.45 271.91,252.45 v1(271.01,253.35) ; 223.3,289 223.3,287.23 223.35,287.19 223.35,286.29 222.64,285.59 222.64,278.25 222.15,277.75 222.15,276.55 218.74,273.15 218.13,273.15 211.4,266.41 211.4,263.03 210.92,262.55 210.92,262.28 208.61,259.98 208.61,249.38 207.21,247.98 205,247.98 204.21,248.77 199.18,248.77 198.66,249.29 189,249.29 183.12,243.41 181.17,243.41 179.42,241.66 179.42,239.93 174.9,235.41 174.9,234.06 167.69,226.85 161.87,226.85 157.63,222.61 157.63,216.15 158.8,214.99 158.8,206.56 155.42,203.18 155.42,193.33 161.23,187.53 161.23,176.63 169.86,167.99 169.86,92.89 184.73,78.02 184.73,67.58 183.38,66.23 181.73,66.23 181.54,66.04 180.96,66.04 180.48,66.52 179.15,66.52 SLOT06.A49
  L30_DP w0.102: 223.3,289 223.3,289.47 227.49,293.67
SL06_DP_39: length 473.8
  L30_DP w0.079: 221.99,288.49 221.99,283.04 221.51,282.56 221.51,276.71 218.51,273.71 217.72,273.71 212.2,268.2 211.38,268.2 209.11,265.92 209.11,263.81 207.94,262.64 207.94,260.67 208.05,260.57 208.05,249.61 206.98,248.55 205.23,248.55 204.39,249.39 199.36,249.39 197.65,251.1 188.05,251.1 185.73,248.77 185.73,247.77 184.27,246.32 183.28,246.32 177.55,240.59 175.93,240.59 174.66,239.32 174.66,238.73 174.34,238.41 174.34,234.29 167.57,227.53 161.75,227.53 157.07,222.85 157.07,205.77 154.86,203.56 154.86,190.74 156.14,189.46 158.15,189.46 160.67,186.94 160.67,176.39 169.3,167.76 169.3,92.65 184.17,77.79 184.17,68.63 182.9,67.37 180.95,67.37 180.44,66.86 179.76,66.86 179.74,66.88 179.7,66.88 179.24,67.34 178.71,67.34 178.07,66.7 177.43,66.7 177.42,66.69 SLOT06.B49 ; 227.49,294.63 237.25,304.39 281.04,304.39 294.39,291.04 294.39,290.81 294.39,260.52 294.23,260.36 293.39,259.52 293.39,250.96 282.94,240.51 277.35,240.51 276.67,239.83 276.28,239.83 275.61,240.49 269.08,240.49 268.41,239.83 266.72,239.83 264.9,241.64 264.9,256.34 266.17,257.6 272.59,257.6 v1(273.17,258.18)
  L30_DP w0.102: 227.49,294.63 221.99,289.13 221.99,288.49
SL06_DP_40: length 429.9
  L30_DP w0.079: SLOT06.C49 174.83,66.34 175.87,66.34 176.51,65.7 176.94,65.7 177.58,66.34 178.12,66.34 178.76,65.7 179.19,65.7 179.83,66.34 180.37,66.34 180.98,65.73 181.26,65.73 181.38,65.84 181.62,65.84 181.73,65.95 183.5,65.95 185.01,67.46 185.01,78.14 170.14,93 170.14,168.11 161.51,176.74 161.51,188.11 158.26,191.36 157.8,191.36 155.71,193.45 155.71,202.81 159.78,206.88 159.78,214.4 157.91,216.27 157.91,222.5 161.99,226.57 167.81,226.57 175.18,233.94 175.18,235.29 179.7,239.81 179.7,241.55 181.29,243.13 183.24,243.13 188.43,248.32 190.46,248.32 191.15,249.01 196.59,249.01 197.28,248.32 197.67,248.32 197.83,248.49 204.09,248.49 204.88,247.7 207.33,247.7 208.89,249.26 208.89,258.92 211.2,261.23 211.2,262.43 211.68,262.91 211.68,266.29 218.25,272.86 218.63,272.86 218.86,272.86 222.43,276.43 222.43,277.63 222.93,278.13 222.93,285.47 223.65,286.19 223.65,289.17 224.35,289.87 224.35,289.89 227.25,292.79 227.27,292.79 237.89,303.42 251.32,303.42 ; 267.49,303.42 280.82,303.42 293.55,290.69 293.55,260.87 293.38,260.71 291.31,258.63 285.96,258.63 285.04,259.55 278.83,259.55 277.84,258.57 277.84,257.98 277.57,257.71 276.98,257.71 274.84,255.56 274.84,255.02 v1(273.17,253.35)
  L30_DP w0.102: 267.49,303.42 251.32,303.42
SL06_DP_41: length 433.9
  L30_DP w0.079: 267.49,303.02 280.82,303.02 293.26,290.58 293.26,260.99 293.1,260.82 291.19,258.91 286.08,258.91 285.16,259.83 278.36,259.83 274.22,255.7 271.03,255.7 269.65,254.32 269.65,249.03 269.69,248.99 269.69,248.6 269.65,248.56 269.65,247.62 269.69,247.58 269.69,247.19 269.65,247.15 269.65,243.88 UNK4K23.2 ; 251.23,303.08 251.17,303.13 238.01,303.13 227.39,292.51 227.37,292.51 224.63,289.77 224.63,289.76 223.93,289.06 223.93,286.08 223.21,285.35 223.21,278.01 222.71,277.51 222.71,276.31 218.98,272.58 218.51,272.58 218.36,272.58 212.05,266.27 212.05,262.88 211.48,262.32 211.48,261.12 209.17,258.81 209.17,249.14 207.45,247.42 204.76,247.42 203.98,248.21 197.95,248.21 197.78,248.04 197.16,248.04 196.47,248.73 191.27,248.73 190.57,248.04 188.55,248.04 183.36,242.85 181.4,242.85 179.98,241.43 179.98,239.7 175.46,235.18 175.46,233.83 168.08,226.44 168.08,212.13 169.64,210.57 169.64,199.86 168.04,198.27 168.04,170.61 170.43,168.23 170.43,93.12 185.29,78.25 185.29,67.34 183.61,65.66 181.45,65.66 181.34,65.55 180.9,65.55 180.28,64.93 179.91,64.93 179.32,65.52 178.63,65.52 178.04,64.93 177.66,64.93 177.07,65.52 176.38,65.52 175.79,64.93 175.41,64.93 174.82,65.52 174.1,65.52 173.62,65.04 173.06,65.04 172.22,65.88 SLOT06.D49
  L30_DP w0.102: 267.49,303.02 251.5,303.02 251.44,303.08 251.23,303.08
SL06_DP_42: length 452.9
  L30_DP w0.079: 227.49,292.22 238.05,302.77 251.32,302.77 ; 267.49,302.68 280.76,302.68 292.98,290.46 292.98,261.11 292.82,260.94 292.82,260.94 291.07,259.2 286.2,259.2 285.21,260.19 277.38,260.19 277.1,259.91 277.1,259.08 274.95,256.93 270.85,256.93 267.53,253.61 267.53,242.07 268.25,241.34 278.43,241.34 UNK4K24.2 ; SLOT06.E49 169.97,65.9 171.13,64.75 171.36,64.75 171.96,65.34 172.49,65.34 173.09,64.75 173.61,64.75 174.21,65.34 174.74,65.34 175.34,64.75 175.86,64.75 176.46,65.34 176.99,65.34 177.59,64.75 178.11,64.75 178.71,65.34 179.24,65.34 179.84,64.75 180.36,64.75 180.97,65.37 183.74,65.37 185.57,67.21 185.57,78.14 185.58,78.14 185.58,78.37 170.71,93.24 170.71,168.34 168.32,170.73 168.32,198.15 170.68,200.51 170.68,209.67 170.55,209.8 170.55,210.09 168.36,212.27 168.36,226.32 175.75,233.71 175.75,235.06 180.27,239.58 180.27,241.31 181.52,242.57 183.47,242.57 185.8,244.9 187.4,244.9 189.75,247.25 190.18,247.25 191.38,248.45 195.39,248.45 196.93,246.91 197.67,246.91 198.68,247.92 203.86,247.92 204.65,247.14 207.56,247.14 209.45,249.03 209.45,258.69 212.42,261.66 212.42,266.24 218.39,272.2 218.5,272.2 218.58,272.13 218.58,271.74 218.8,271.51 219.13,271.51 219.36,271.74 219.36,272.57 222.46,275.67 222.99,276.2 222.99,277.4 223.49,277.9 223.49,285.24 224.32,286.06 224.32,289.03
  L30_DP w0.102: 267.49,302.68 251.41,302.68 251.32,302.77 ; 227.49,292.22 224.93,289.65 224.93,289.64 224.32,289.03
SL06_DP_43: length 491
  L28_DP w0.079: SLOT06.F49 167.72,65.9 168.44,65.19 168.44,64.49 167.99,64.04 167.47,64.04 164.41,60.98 164.41,45.9 165.78,44.52 166.94,44.52 167.58,43.88 167.87,43.88 168.51,44.52 169.19,44.52 169.83,43.88 170.12,43.88 170.76,44.52 171.44,44.52 172.08,43.88 172.37,43.88 173.01,44.52 173.69,44.52 174.33,43.88 174.62,43.88 175.26,44.52 175.94,44.52 176.58,43.88 176.87,43.88 177.51,44.52 178.19,44.52 178.83,43.88 179.12,43.88 179.76,44.52 180.44,44.52 181.08,43.88 181.62,43.88 181.73,43.99 182.05,43.99 182.47,43.56 200.66,43.56 202.17,45.07 202.17,45.1 207.07,50 207.07,90.01 225.71,108.65 288.95,108.65 318.96,138.65 318.96,265.21 311.88,272.29 281.87,272.29 280.55,270.97 280.55,270.58 276.38,266.41 275.84,266.41 272.45,263.02 272.45,255.46 268.97,251.98 268.97,251.29 268.39,250.71 265.89,250.71 262.51,254.08 262.51,256.74 262.61,256.84 262.61,258.09 263.24,258.72 263.24,262.92 260.84,265.32 260.35,265.32 259.59,264.56 259.59,257.9 260.09,257.4 260.59,256.65 260.94,255.82 261.11,254.94 261.11,253.11 262.79,251.43 262.79,251.41 263.07,251.13 263.09,251.13 264.92,249.3 272.95,249.3 273.64,249.99 273.64,250.52 v1(276.47,253.35)
SL06_DP_44: length 479.4
  L30_DP w0.079: v1(283.84,260.87) 281.36,263.35 277.45,263.35 276.77,262.68 276.77,259.15 274.94,257.32 266.28,257.32 265.18,256.22 265.18,243.98 268.37,240.79 282.82,240.79 293.11,251.08 293.11,259.64 294.11,260.64 294.11,290.93 280.92,304.11 237.46,304.11 222.36,289.01 222.36,278.36 221.86,277.86 221.86,276.66 218.63,273.43 218.01,273.43 217.85,273.26 211.06,266.47 211.06,263.09 210.64,262.67 210.64,262.4 208.33,260.09 208.33,249.49 207.1,248.26 205.11,248.26 204.27,249.11 199.24,249.11 197.53,250.81 189.58,250.81 183.46,244.69 183.07,244.69 182.07,243.7 181.05,243.7 177.6,240.24 176.42,240.24 175.85,239.67 175.85,236.76 174.62,235.53 174.62,234.18 167.69,227.25 167.46,227.25 167.46,227.25 161.87,227.25 157.35,222.73 157.35,216.04 158.52,214.87 158.52,206.67 155.14,203.3 155.14,192.27 156,191.41 156,191.41 156.28,191.13 156.28,191.13 157.67,189.74 158.27,189.74 160.95,187.06 160.95,176.51 169.58,167.88 169.58,92.77 184.45,77.9 184.45,67.95 183.19,66.69 SLOT06.Z49
SL06_DP_45: length 389.2
  L30_DP w0.079: 267.49,302.35 280.69,302.35 292.7,290.34 292.7,275.11 286.32,268.74 286.32,262.96 v1(288.42,260.87) ; SLOT06.Z47 183.48,64.69 185.23,66.44 185.23,66.46 185.69,66.92 185.86,67.09 185.86,78.02 185.86,78.02 185.86,78.49 185.86,78.49 170.99,93.36 170.99,168.46 168.61,170.84 168.61,198.04 170.96,200.39 170.96,205.64 172.35,207.03 172.35,209.44 168.64,213.14 168.64,226.21 175.97,233.54 177.16,233.54 177.96,234.34 177.96,236.87 180.55,239.46 180.55,241.2 181.64,242.29 183.59,242.29 185.92,244.62 187.52,244.62 188.64,245.74 206.57,245.74 209.57,248.75 209.74,248.91 209.74,257.72 212.17,260.15 212.5,260.48 218.29,260.48 223.27,265.46 223.27,277.28 223.82,277.83 223.82,284.59 226.24,287.01 226.24,290.03 226.23,290.04 226.23,290.28 226.24,290.29 226.24,290.55 227.79,292.1 227.79,292.11 238.02,302.35 251.32,302.35
  L30_DP w0.102: 251.32,302.35 267.49,302.35
SL06_DP_46: length 390.8
  L30_DP w0.079: 267.49,301.95 280.69,301.95 292.42,290.23 292.42,275.23 283.32,266.14 283.32,265.2 v1(283.84,264.68) ; SLOT06.A47 179.64,64.69 179.76,64.57 180.43,64.57 180.96,64.04 183.25,64.04 185.51,66.31 185.51,66.35 185.81,66.64 186.14,66.97 186.14,77.9 186.14,77.9 186.14,78.6 186.14,78.61 171.27,93.48 171.27,168.58 168.89,170.96 168.89,197.92 171.33,200.36 171.33,205.61 172.63,206.92 172.63,209.63 168.92,213.34 168.92,226.09 174.26,231.43 177.25,231.43 178.24,232.42 178.24,234.64 178.24,234.64 178.24,236.76 180.83,239.35 180.83,241.08 181.75,242 183.71,242 186.04,244.34 189.98,244.34 190.86,243.46 195.91,243.46 196.59,244.13 198.43,244.13 199.14,243.42 202.93,243.42 203.64,244.13 206.41,244.13 210.02,247.74 210.02,257.61 212.45,260.04 212.61,260.2 218.41,260.2 223.56,265.35 223.56,273.92 225.89,276.25 225.89,285.4 225.89,285.63 225.89,285.87 226.52,286.5 226.52,290.13 ; 251.32,301.95 238.35,301.95 227.81,291.42
  L30_DP w0.102: 267.49,301.95 251.32,301.95 ; 227.81,291.42 226.52,290.13
SL06_DP_47: length 410.2
  L30_DP w0.079: SLOT06.B47 177.39,64.69 177.51,64.57 178.18,64.57 178.71,64.04 179.24,64.04 179.59,64.39 180.36,64.39 180.98,63.76 183.13,63.76 183.36,63.76 185.8,66.19 185.8,66.23 185.93,66.36 186.42,66.86 186.42,77.79 186.42,77.79 186.42,78.72 186.42,78.73 171.55,93.59 171.55,168.69 169.17,171.08 169.17,197.8 171.77,200.4 171.77,200.65 172.42,201.31 172.42,202.32 172.23,202.51 172.23,206.11 172.91,206.8 172.91,209.91 169.21,213.62 169.21,225.97 172.31,229.08 175.84,229.08 175.91,229.16 177.18,229.16 178.52,230.5 178.52,235.12 178.52,235.12 178.52,236.64 181.11,239.23 181.11,240.96 181.87,241.72 183.82,241.72 186.16,244.05 188.64,244.05 190.18,242.52 190.18,241.93 190.87,241.24 203.01,241.24 205.62,243.85 206.52,243.85 210.3,247.63 210.3,257.49 212.73,259.92 218.74,259.92 223.84,265.02 223.84,273.8 226.17,276.13 226.17,285.52 226.17,285.52 226.17,285.75 226.8,286.38 226.8,289.91 238.39,301.49 251.32,301.49 ; v1(288.42,264.68) 290.92,262.17 290.92,260.8 290.4,260.29 288.3,260.29 284.95,263.63 283.84,263.63 283.04,264.44 283.04,266.25 283.21,266.42 286.51,269.72 286.51,277.01 292.14,282.64 292.14,290.11 280.75,301.49 267.49,301.49
  L30_DP w0.102: 267.49,301.49 251.32,301.49
SL06_DP_48: length 394.8
  L30_DP w0.079: SLOT06.C47 175.14,64.69 175.26,64.57 175.93,64.57 176.46,64.04 176.99,64.04 177.34,64.39 178.11,64.39 178.63,63.86 179.26,63.86 179.45,63.68 179.45,63.42 179.83,63.04 180.4,63.04 180.88,63.52 181.68,63.52 181.73,63.48 181.75,63.48 182.04,63.19 182.54,63.19 182.83,63.48 183.01,63.48 183.25,63.48 183.48,63.48 186.08,66.08 186.08,66.11 186.7,66.74 186.7,77.67 186.7,78.84 171.84,93.71 171.84,168.81 169.47,171.17 169.47,197.71 172.05,200.28 172.05,200.54 172.71,201.19 172.71,202.43 172.51,202.63 172.51,205.99 173.2,206.68 173.2,210.07 169.49,213.78 169.49,225.86 171.27,227.64 174.79,227.64 176.03,228.87 177.29,228.87 178.8,230.38 178.8,236.52 181.39,239.11 181.39,240.85 181.99,241.44 183.94,241.44 186.27,243.77 187.11,243.77 188.01,242.87 189.42,242.87 189.89,242.4 189.89,241.82 190.76,240.96 203.12,240.96 205.74,243.57 206.64,243.57 210.58,247.51 210.58,257.37 212.85,259.64 219.97,259.64 221.3,260.97 221.3,261.12 224.12,263.93 224.12,273.58 226.45,275.91 226.45,285.63 226.92,286.1 226.92,286.1 227.08,286.27 227.08,289.71 238.42,301.05 251.32,301.05 ; v1(283.84,267.72) 284.84,268.72 284.84,275.75 291.85,282.76 291.85,289.99 280.8,301.05 267.49,301.05
  L30_DP w0.102: 267.49,301.05 251.32,301.05
SL06_DP_49: length 402.7
  L30_DP w0.079: 267.49,297.75 276.77,288.47 276.77,278.4 275.97,277.6 275.07,277.6 274.53,277.07 274.53,271.39 279.88,266.05 280.39,266.05 285.12,261.31 285.12,260.67 286.31,259.48 290.96,259.48 291.95,260.47 291.95,262.22 289.64,264.54 289.64,266.9 288.81,267.72 v1(288.42,267.72) ; SLOT06.D47 172.89,64.69 173.01,64.57 173.68,64.57 176.21,62.04 177.28,62.04 177.58,62.34 178.12,62.34 178.42,62.04 179.53,62.04 179.83,62.34 180.37,62.34 180.67,62.04 181.98,62.04 182.45,62.52 182.55,62.52 182.66,62.63 182.78,62.63 183.07,62.92 183.25,62.92 183.71,62.92 186.83,66.03 186.83,66.07 187.27,66.5 187.27,77.44 187.27,79.08 172.4,93.94 172.4,169.05 170.04,171.41 170.04,197.47 172.61,200.05 172.61,200.3 175.22,202.91 175.22,205.09 175.28,205.15 175.28,210.31 170.05,215.53 170.05,225.62 171.5,227.07 175.03,227.07 175.36,227.4 176.14,228.19 180.09,228.19 181.96,230.06 181.96,234.3 185.55,237.89 196.47,237.89 198.97,240.39 203.36,240.39 205.97,243 206.87,243 212.76,248.89 217.83,248.89 221.62,252.67 221.62,256.61 221.36,256.86 221.36,257.49 221.62,257.74 221.62,259.29 224.68,262.36 224.68,273.12 229.25,277.68 229.25,290.97 238.28,300.01 251.32,300.01
  L30_DP w0.102: 251.32,300.01 264.8,300.01 267.06,297.75 267.49,297.75
SL06_DP_50: length 405.2
  L28_DP w0.079: v1(283.84,270.77) 284.31,271.24 311.18,271.24 317.73,264.69 317.73,139.17 288.44,109.88 225.2,109.88 205.61,90.3 205.61,49.15 200.53,44.07 182.36,44.07 181.87,44.56 181.87,44.96 181.49,45.34 180.96,45.34 180.32,44.7 179.88,44.7 179.24,45.34 178.71,45.34 178.07,44.7 177.63,44.7 176.99,45.34 176.17,45.34 175.53,44.7 175.38,44.7 174.74,45.34 174.21,45.34 173.57,44.7 173.13,44.7 172.49,45.34 171.96,45.34 171.32,44.7 170.88,44.7 170.24,45.34 169.71,45.34 169.07,44.7 168.63,44.7 167.99,45.34 167.46,45.34 166.82,44.7 166.48,44.7 166.18,44.7 164.75,46.14 164.75,60.92 167.69,63.86 168.07,63.86 168.9,64.69 SLOT06.E47
SL06_DP_51: length 409.5
  L28_DP w0.079: v1(283.84,273.41) 284.21,273.78 311.35,273.78 319.64,265.49 319.64,138.37 289.24,107.97 225.99,107.97 207.63,89.6 207.63,49.77 201.04,43.18 182.45,43.18 181.93,43.7 181.01,43.7 180.37,44.34 179.83,44.34 179.19,43.7 178.76,43.7 178.12,44.34 177.58,44.34 176.94,43.7 176.51,43.7 175.87,44.34 175.33,44.34 174.69,43.7 174.26,43.7 173.62,44.34 173.08,44.34 172.44,43.7 172.01,43.7 171.37,44.34 170.83,44.34 170.19,43.7 169.76,43.7 169.12,44.34 168.58,44.34 167.94,43.7 167.51,43.7 166.87,44.34 165.7,44.34 165.67,44.38 165.52,44.38 164.12,45.78 164.12,45.8 164.02,45.91 164.02,60.99 SLOT06.F47
SL06_DP_52: length 477.9
  L28_DP w0.079: SLOT06.A45 178.57,62.29 178.17,62.29 178.12,62.34 177.58,62.34 177.09,61.85 176.36,61.85 175.87,62.34 175.33,62.34 174.84,61.85 174.4,61.85 174.27,61.98 174.24,61.98 173.69,62.52 172.97,62.52 172.49,62.04 171.96,62.04 171.58,62.42 171.58,62.96 172.04,63.43 172.04,63.56 172.87,64.39 172.87,65.25 172.5,65.63 172.5,66.05 172.87,66.42 172.87,67.25 172.7,67.42 172.7,67.96 172.87,68.14 172.87,68.96 172.49,69.34 171.96,69.34 171.48,68.87 171.48,68.86 170.72,68.86 170.24,69.34 169.71,69.34 169.24,68.88 169.24,68.22 169.5,67.96 169.5,67.42 169.12,67.04 168.58,67.04 167.94,67.68 167.41,67.68 163.38,63.65 163.38,45.28 166.01,42.65 166.13,42.65 166.18,42.7 166.82,42.7 167.46,43.34 167.99,43.34 168.63,42.7 169.07,42.7 169.71,43.34 170.24,43.34 170.88,42.7 171.32,42.7 171.96,43.34 172.49,43.34 173.13,42.7 173.57,42.7 174.21,43.34 174.74,43.34 175.38,42.7 175.82,42.7 176.46,43.34 176.99,43.34 177.63,42.7 178.07,42.7 178.71,43.34 179.24,43.34 179.88,42.7 180.32,42.7 180.96,43.34 181.49,43.34 182.42,42.42 203.33,42.42 208.53,47.62 208.53,88.77 225.93,106.17 290.32,106.17 327.8,143.65 327.8,264.97 305.65,287.12 282.17,287.12 277.86,282.81 277.86,281.51 277.8,281.45 277.8,277.68 277.24,277.12 277.24,273.34 v1(276.07,272.17)
SL06_DP_53: length 363.3
  L30_DP w0.079: 251.32,300.39 238.26,300.39 227.37,289.49 227.37,286.15 227.2,285.99 227.04,285.82 226.78,285.57 226.78,275.67 224.4,273.29 224.4,262.88 222.71,261.19 222.71,260.95 221.11,259.35 219.24,259.35 219.24,259.36 212.96,259.36 210.86,257.26 210.86,247.39 206.76,243.29 205.85,243.29 203.24,240.67 198.4,240.67 197.52,239.8 196.02,239.8 195.14,240.67 188.51,240.67 188.41,240.77 185.92,240.77 181.68,236.53 181.68,230.18 179.97,228.47 176.03,228.47 175.08,227.52 174.91,227.36 171.39,227.36 169.77,225.74 169.77,215.32 170.17,214.92 170.21,214.92 170.49,214.64 170.49,214.6 175,210.09 175,207.08 173.97,206.05 173.97,202.06 172.33,200.42 172.33,200.16 169.76,197.59 169.76,171.29 172.12,168.93 172.12,93.83 186.98,78.96 186.98,78.96 186.98,66.62 186.36,66 186.36,65.96 183.6,63.2 183.36,63.2 183.13,63.2 182.95,63.2 182.66,62.91 182.54,62.91 182.44,62.8 182.03,62.8 181.49,63.34 180.96,63.34 180.36,62.75 179.83,62.75 179.24,63.34 178.71,63.34 178.07,62.7 177.43,62.7 177.42,62.69 SLOT06.B45 ; 267.49,298.46 277.05,288.91 277.05,277.72 v1(276.07,276.75)
  L30_DP w0.102: 251.32,300.39 265.06,300.39 266.99,298.46 267.49,298.46
SL06_DP_54: length 469.5
  L28_DP w0.079: v1(276.07,281.32) 276.73,281.98 276.73,283.34 281.69,288.29 306.18,288.29 328.98,265.49 328.98,143.13 289.87,104.01 226.95,104.01 209.74,86.8 209.74,46.67 204.3,41.23 182.4,41.23 182.08,41.56 181.79,41.56 181.64,41.7 181.01,41.7 180.37,42.34 179.83,42.34 179.19,41.7 178.76,41.7 178.12,42.34 177.58,42.34 176.94,41.7 176.51,41.7 175.87,42.34 175.33,42.34 174.69,41.7 174.26,41.7 173.62,42.34 173.08,42.34 172.44,41.7 172.01,41.7 171.37,42.34 170.83,42.34 170.19,41.7 169.76,41.7 169.12,42.34 168.58,42.34 167.94,41.7 167.51,41.7 166.87,42.34 166.33,42.34 165.97,41.98 165.82,41.98 165.6,42.2 165.6,42.2 162.82,44.98 162.82,64.05 166.63,67.87 167,67.87 167.18,68.04 167.99,68.04 168.37,68.42 168.37,69.25 168.2,69.42 168.2,69.96 168.58,70.34 169.12,70.34 169.76,69.7 170.19,69.7 171.23,70.75 171.35,70.75 171.94,71.34 172.49,71.34 173.49,70.34 173.62,70.34 174,69.96 174,69.42 173.83,69.25 173.83,68.42 174.47,67.78 174.47,67.61 175.12,66.96 175.12,66.42 174.47,65.78 174.47,65.61 175.12,64.96 175.12,64.42 174.47,63.78 SLOT06.C45
SL06_DP_55: length 471.1
  L28_DP w0.079: v1(273.15,272.17) 273.15,273.15 276.96,276.96 276.96,277.23 277.52,277.8 277.52,281.57 277.58,281.63 277.58,282.97 282.01,287.4 305.77,287.4 328.08,265.09 328.08,143.53 290.09,105.54 226.06,105.54 208.82,88.29 208.82,47.02 203.89,42.09 183.52,42.09 183.32,41.88 181.08,41.88 180.44,42.52 179.76,42.52 179.12,41.88 178.83,41.88 178.19,42.52 177.51,42.52 176.87,41.88 176.58,41.88 175.94,42.52 175.26,42.52 174.77,42.04 174.18,42.04 173.69,42.52 173.01,42.52 172.37,41.88 172.08,41.88 171.44,42.52 170.76,42.52 170.12,41.88 169.83,41.88 169.19,42.52 168.51,42.52 167.87,41.88 167.58,41.88 166.94,42.52 166.26,42.52 166.04,42.31 165.93,42.31 163.1,45.14 163.1,63.83 166.95,67.69 167.08,67.69 167.26,67.86 168.07,67.86 168.9,68.7 168.99,68.7 169.06,68.78 169.06,68.96 169.63,69.52 170.35,69.52 170.83,69.04 171.37,69.04 172.02,69.7 172.43,69.7 173.53,68.59 173.53,68.44 174,67.97 174,67.14 173.83,66.96 173.83,66.42 174,66.25 174,65.26 172.22,63.49 SLOT06.D45
SL06_DP_56: length 334.7
  L30_DP w0.079: v1(273.15,282.59) 270.86,280.3 269.64,280.3 268.66,279.32 266.23,279.32 264.25,277.33 262.86,277.33 258,272.48 240.26,272.48 239.81,272.93 228.06,272.93 224.97,269.83 224.97,262.24 221.9,259.17 221.9,257.63 221.64,257.37 221.64,256.98 221.9,256.73 221.9,252.55 217.95,248.61 212.87,248.61 206.99,242.72 206.09,242.72 204.51,241.15 204.51,239.61 200.99,236.08 185.94,236.08 185.61,236.41 184.62,236.41 182.24,234.03 182.24,229.94 182.15,229.86 182.15,227.73 180.35,225.93 176.01,225.93 175.14,226.79 171.62,226.79 170.33,225.51 170.33,215.73 175.56,210.5 175.56,205.03 175.5,204.97 175.5,202.8 172.89,200.19 172.89,199.93 170.32,197.36 170.32,171.52 172.68,169.16 172.68,94.06 187.55,79.19 187.55,79.19 187.55,77.32 187.55,66.39 187.11,65.95 187.11,65.91 183.83,62.63 183.54,62.63 182.56,61.65 180.98,61.65 180.37,61.04 179.83,61.04 179.22,61.65 178.76,61.65 177.99,60.88 177.71,60.88 177.07,61.52 176.38,61.52 175.79,60.93 175.41,60.93 174.82,61.52 174.13,61.52 173.47,60.86 173.23,60.86 172.57,61.52 171.88,61.52 171.22,60.86 171.01,60.86 169.97,61.9 SLOT06.E45
SL06_DP_57: length 336.1
  L30_DP w0.079: v1(270.74,273.7) 269.17,275.27 269.17,278.25 268.38,279.04 266.35,279.04 264.36,277.05 262.97,277.05 258.12,272.19 240.14,272.19 239.69,272.65 228.18,272.65 225.25,269.71 225.25,262.12 222.18,259.05 222.18,257.78 222.58,257.37 222.58,256.98 222.18,256.58 222.18,252.43 218.07,248.32 212.99,248.32 207.11,242.44 206.2,242.44 204.79,241.03 204.79,239.49 200.73,235.42 199.16,235.42 198.71,234.97 191.21,234.97 190.76,235.42 185.43,235.42 182.52,232.51 182.52,227.7 180.47,225.65 175.89,225.65 175.03,226.51 171.74,226.51 170.62,225.39 170.62,215.89 175.84,210.66 175.84,205.15 175.84,204.91 175.79,204.86 175.79,202.68 173.17,200.07 173.17,199.81 170.6,197.24 170.6,171.64 172.96,169.28 172.96,94.18 187.83,79.31 187.83,77.2 187.83,77.2 187.83,66.27 187.39,65.83 187.39,65.8 183.95,62.35 183.67,62.35 182.69,61.37 181.73,61.37 181.66,61.43 181.01,61.43 180.44,60.86 179.76,60.86 179.19,61.43 178.8,61.43 178.06,60.7 177.64,60.7 176.99,61.34 176.46,61.34 175.86,60.75 175.34,60.75 174.74,61.34 174.21,61.34 173.55,60.68 173.15,60.68 172.49,61.34 171.96,61.34 171.3,60.68 170.9,60.68 169.23,62.36 168.06,62.36 SLOT06.F45
SL06_DP_58: length 364.1
  L28_DP w0.079: 224.43,287.49 224.43,258.57 224.64,258.37 224.64,257.98 224.43,257.78 224.43,256.85 222.44,254.86 222.44,242.67 216.78,237.02 211.7,237.02 210.39,235.71 210.39,234.7 209.83,234.14 208.83,234.14 208.01,233.33 207.57,233.33 207.29,233.05 207.29,232.6 205.19,230.5 205.14,230.5 204.67,230.04 204.67,229.63 201.83,226.78 199.77,226.78 197.94,224.95 194.69,224.95 193.3,226.34 192.16,226.34 191.21,225.39 190.55,225.39 188.95,226.99 188.71,226.99 188.52,226.8 188.13,226.8 187.94,226.99 187.65,226.99 187.57,227.07 187.57,227.33 185.96,228.95 185.96,232.16 181.26,236.86 163.45,236.86 160.69,234.09 160.69,230.35 163.58,227.46 167.89,227.46 168.91,226.44 168.91,216.28 166.19,213.56 166.19,200.47 168.3,198.36 168.3,190.71 168.31,190.66 168.31,190.32 168.3,190.27 168.3,95.86 185.04,79.12 185.04,66.51 SLOT06.Z45 ; 227.49,290.54 228.09,291.14 251.32,291.14 ; 267.64,283.64 270.27,283.64 v1(270.74,284.11)
  L28_DP w0.102: 267.64,283.64 267.63,283.63 267.23,283.63 267.22,283.64 265.35,283.64 259.77,289.23 259.47,289.23 257.56,291.14 257.36,291.14 257.25,291.25 256.41,291.25 256.3,291.14 251.32,291.14 ; 224.43,287.49 227.49,290.54
SL06_DP_59: length 315.2
  L30_DP w0.079: v1(268.33,278.27) 268.33,276.99 261.48,270.14 251.54,270.14 251.21,270.47 250.82,270.47 250.5,270.14 233.62,270.14 231.45,272.32 228.25,272.32 225.53,269.6 225.53,262.01 222.46,258.94 222.46,257.89 222.87,257.49 222.87,256.86 222.46,256.46 222.46,252.32 218.18,248.04 213.11,248.04 207.22,242.16 206.32,242.16 205.08,240.91 205.08,239.37 200.18,234.47 185.45,234.47 182.8,231.82 182.8,227.59 180.58,225.37 175.77,225.37 174.91,226.23 171.85,226.23 170.9,225.27 170.9,216.01 176.13,210.78 176.13,205.46 176.73,204.86 176.73,202.17 170.88,196.32 170.88,171.76 173.25,169.4 173.25,94.29 188.11,79.43 188.11,77.09 188.11,66.15 187.95,65.99 187.67,65.72 187.67,65.68 184.06,62.07 183.86,62.07 182.48,60.69 SLOT06.Z43
SL06_DP_60: length 185.6
  L30_DP w0.079: SLOT06.A43 179.64,60.69 179.76,60.58 180.42,60.58 180.96,60.04 181.49,60.04 181.63,60.19 182.68,60.19 188.42,65.92 188.42,79.52 173.53,94.41 173.53,170.45 181.28,178.21 181.28,184.32 181.29,184.33 181.29,185.64 181.28,185.65 181.28,199.53 179.74,201.07 179.74,215.23 182.39,217.88 182.39,223.96 v1(185.41,226.99)
SL06_DP_61: length 200.9
  L28_DP w0.079: v1(180.83,206.69) 179.27,205.13 178.88,205.13 175.44,201.69 174.92,201.69 170.43,197.21 170.43,99.19 187.83,81.79 187.83,58.67 184.74,55.58 180.91,55.58 180.37,55.04 179.83,55.04 179.33,55.55 178.62,55.55 178.12,55.04 177.58,55.04 177.08,55.55 176.37,55.55 175.87,55.04 175.33,55.04 174.83,55.55 174.12,55.55 173.62,55.04 173.08,55.04 172.58,55.55 171.87,55.55 171.37,55.04 170.83,55.04 170.19,55.68 170.01,55.68 169.19,54.86 168.51,54.86 168.02,55.35 168.02,55.48 166.46,57.04 166.33,57.04 165.95,57.42 165.95,57.96 166.3,58.31 166.3,58.47 167.35,59.52 167.51,59.52 168.02,60.03 168.02,60.04 168.51,60.52 169.19,60.52 169.69,60.03 170.26,60.03 170.78,60.55 171.16,60.55 171.96,61.34 172.49,61.34 173.14,60.69 173.17,60.69 173.35,60.51 173.74,60.51 174.21,60.04 174.74,60.04 175.39,60.69 SLOT06.B43
SL06_DP_62: length 201.4
  L28_DP w0.079: v1(180.83,204.66) 178.14,201.97 178.14,201.92 176.96,200.75 175.48,200.75 170.72,195.99 170.72,100.05 180.46,90.3 180.55,90.1 181.15,89.2 181.91,88.44 182.81,87.84 183.01,87.75 188.34,82.42 188.34,58.5 184.99,55.14 181.69,55.14 181.49,55.34 180.96,55.34 180.76,55.14 180.72,55.14 180.44,54.86 179.76,54.86 179.25,55.37 178.7,55.37 178.19,54.86 177.51,54.86 177,55.37 176.45,55.37 175.94,54.86 175.26,54.86 174.75,55.37 174.2,55.37 173.69,54.86 173.01,54.86 172.5,55.37 171.95,55.37 171.44,54.86 171.06,54.86 170.24,54.04 169.71,54.04 169.07,54.68 168.63,54.68 168.54,54.59 168.45,54.59 168.37,54.51 168.37,54.42 167.99,54.04 167.46,54.04 167.08,54.42 167.08,54.96 167.46,55.34 167.46,55.56 167.25,55.76 167.25,55.96 166.35,56.86 166.26,56.86 165.77,57.35 165.77,57.44 165.69,57.52 165.69,57.87 165.77,57.95 165.77,58.04 166.12,58.39 166.12,59.36 166.2,59.44 166.37,59.44 167.08,60.14 167.08,60.96 167.46,61.34 167.99,61.34 168.63,60.7 169.07,60.7 169.71,61.34 170.24,61.34 170.86,60.73 171.09,60.73 171.88,61.52 172.6,61.52 173.43,60.69 SLOT06.C43
SL06_DP_63: length 189.7
  L28_DP w0.079: SLOT06.D43 171.88,60.35 170.84,60.35 170.29,59.8 169.66,59.8 169.12,60.34 168.58,60.34 168.2,59.96 168.2,59.94 167.6,59.34 167.46,59.34 167.01,58.89 167.01,58.36 168.58,56.79 168.58,56.34 168.2,55.96 168.2,55.42 168.58,55.04 169.12,55.04 169.94,55.86 170.35,55.86 170.83,56.34 171.37,56.34 171.98,55.73 172.47,55.73 173.08,56.34 173.62,56.34 174.23,55.73 174.72,55.73 175.33,56.34 175.87,56.34 176.48,55.73 176.97,55.73 177.58,56.34 178.12,56.34 178.73,55.73 179.21,55.73 179.83,56.34 180.37,56.34 180.8,55.91 180.83,55.91 180.88,55.86 181.73,55.86 181.73,55.87 184.39,55.87 187.41,58.88 187.41,81.07 169.99,98.48 169.99,190.09 170,190.14 170,190.83 169.99,190.87 169.99,197.14 170.15,197.3 170.15,197.32 173.94,201.11 173.94,202.34 v1(176.26,204.66)
