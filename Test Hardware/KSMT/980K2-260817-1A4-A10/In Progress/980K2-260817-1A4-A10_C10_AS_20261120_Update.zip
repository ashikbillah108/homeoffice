# Allegro board 980K2-260817_261120-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL13_DP_87: length 431.7
  L05_DP w0.079: SLOT13.D31 246.88,425.49 248.73,423.64 249.39,423.64 249.69,423.94 250.52,423.94 251,423.46 251.72,423.46 252.26,424 253.31,424 256.3,421 271.91,421 271.91,421.01 272.14,421.01 280.58,412.57 280.58,394.28 289.76,385.1 289.76,351.19 311.71,329.24 311.71,226.95 299.65,214.88 277.14,214.88 276.73,214.47 267.88,214.47 265.3,211.89 261.99,211.89 260.75,213.13 256.13,213.13 253.96,210.97 248.79,210.97 247.15,209.33 246.8,209.33 246.49,209.01 246.49,207.74 245.52,206.77 235.69,206.77 230.36,201.44 224.9,201.44 223.51,200.05 212.82,200.05 209.2,203.68 197.13,203.68 196.37,202.92 185.47,202.92 182.48,199.94 182.32,199.77 163.92,199.77 162.81,199.77 160.27,202.31 160.27,214 156.97,217.3 154.34,217.3 v1(150.74,213.7)
SL13_DP_88: length 456.3
  L05_DP w0.079: SLOT13.E31 250.46,426.29 251.11,425.64 251.64,425.64 252.19,426.18 253.34,426.18 254.37,425.16 255.09,425.16 257.66,422.59 257.66,422.59 257.83,422.42 272.72,422.42 281.99,413.15 281.99,394.86 291.17,385.68 291.17,352.52 313.42,330.27 313.42,224.72 298.14,209.45 279.42,209.45 279.22,209.65 277.19,209.65 276.99,209.45 275.37,209.45 273.57,207.64 273.57,205.49 272.38,204.3 267.02,204.3 265.78,205.55 263.3,205.55 261.63,207.22 255.71,207.22 254.31,205.82 252.6,205.82 252.34,205.82 250.51,203.99 237.35,203.99 233.92,200.56 225.32,200.56 223.88,199.12 199.15,199.12 197.95,200.32 184.19,200.32 181.27,197.4 181.27,192.22 177.7,188.65 165.43,188.65 164.63,189.46 161.06,189.46 157.99,192.53 157.99,198.37 156.03,200.34 156.03,202.6 154.57,204.06 154.57,209.1 149.16,214.52 149.16,223.08 149.51,223.44 149.96,223.44 150.64,224.11 v1(150.74,224.11)
SL13_DP_89: length 446.2
  L05_DP w0.079: SLOT13.F31 251.53,426.45 253.4,426.45 254.41,425.44 255.21,425.44 257.94,422.7 273.49,422.7 282.27,413.92 282.27,394.98 291.45,385.8 291.45,352.68 313.74,330.4 313.74,224.59 298.27,209.13 279.29,209.13 279.09,209.33 277.32,209.33 277.12,209.13 275.51,209.13 273.88,207.51 273.88,205.36 272.51,203.99 266.89,203.99 265.67,205.21 257.16,205.21 256.87,205.51 252.47,205.51 250.64,203.68 237.48,203.68 234.05,200.25 227.58,200.25 226.31,198.98 226.31,197.4 217.13,188.21 200.53,188.21 199.38,189.36 178.81,189.36 177.82,188.37 165.32,188.37 164.51,189.18 159.69,189.18 156,192.87 156,199.96 155.74,200.22 155.74,202.49 154.29,203.94 154.29,208.99 148.33,214.95 v1(148.33,218.27)
SL13_DP_90: length 568.3
  L05_DP w0.079: v1(225.41,226.99) 224.1,225.68 216.28,225.68 215.14,226.82 201.04,226.82 196.72,222.5 196.72,219.89 195.78,218.95 182.74,218.95 179.69,215.9 160.66,215.9 157.86,218.69 157.86,229.24 157.35,229.74 153.8,229.74 152.27,228.22 148.61,228.22 147.1,226.71 147.1,226.4 147.1,226.17 142.48,221.55 142.48,212.65 143.31,211.82 143.31,206.93 149.87,200.37 149.87,189.73 154.04,185.56 154.93,185.56 157.23,183.26 157.23,179.7 160.98,175.95 160.98,167.18 158.27,164.46 145.2,164.46 128.79,180.87 128.79,203.76 112.14,220.41 112.14,299.01 208.13,395 208.13,402.82 221.33,416.02 221.33,426.87 234,439.55 238.34,439.55 238.73,439.94 239.27,439.94 239.66,439.55 240.59,439.55 240.98,439.94 241.77,439.94 244.7,437.01 245.11,437.01 245.48,436.64 246.02,436.64 246.53,437.14 246.94,437.14 247.73,437.94 248.39,437.94 249.77,436.56 249.77,435.73 249.6,435.56 249.6,434.73 249.77,434.56 249.77,434.02 249.39,433.64 248.86,433.64 248.41,434.09 247.59,434.09 247.14,433.64 246.61,433.64 246.16,434.09 245.34,434.09 244.89,433.64 244.36,433.64 243.85,434.14 243.15,434.14 242.64,433.64 242.07,433.64 241.59,434.12 240.91,434.12 240.43,433.64 239.86,433.64 239.46,434.03 238.8,434.03 238.22,433.46 237.5,433.46 236.47,432.43 236.47,427.69 SLOT13.Z31
SL13_DP_91: length 342
  L05_DP w0.079: SLOT13.Z29 238.35,427.81 238.35,427.02 238.73,426.64 238.82,426.64 242.53,422.94 242.64,422.94 243.64,421.94 244.06,421.94 244.36,421.64 245.18,421.64 245.48,421.94 246.02,421.94 246.66,421.3 247.09,421.3 247.73,421.94 248.27,421.94 249.09,421.12 249.47,421.12 250,420.58 250.5,420.58 251.03,421.12 251.72,421.12 252.72,420.12 252.84,420.12 253.46,419.5 271.65,419.5 279.17,411.98 279.17,393.69 288.35,384.51 288.35,349.45 309.2,328.61 309.2,240.42 299.28,230.5 264.52,230.5 262.59,228.56 252.29,228.56 249.97,226.24 249.97,216.59 248.2,214.82 240.55,214.82 239.47,213.74 238.82,213.74 236.27,211.19 224.88,211.19 220.83,207.14 v1(220.83,206.69)
SL13_DP_92: length 481.6
  L05_DP w0.079: SLOT13.A29 240.79,428.29 241.14,427.94 241.64,427.94 242.94,426.64 243.32,426.64 246.84,423.12 247.22,423.12 247.78,422.56 248.22,422.56 248.78,423.12 249.47,423.12 250.08,422.51 250.42,422.51 251.03,423.12 251.72,423.12 252.29,422.54 254.37,422.54 256.19,420.72 272.02,420.72 280.3,412.45 280.3,394.16 289.48,384.98 289.48,351.03 311.4,329.11 311.4,236.21 302.34,227.15 281.43,227.15 278.17,223.9 274.65,223.9 274.13,223.37 274.13,215.64 273.31,214.83 269.48,214.83 268.93,215.39 257.64,215.39 255.55,213.29 249.52,213.29 248.64,212.41 248.64,211.27 247.02,209.64 237.84,209.64 229.91,201.72 224.78,201.72 223.4,200.33 212.94,200.33 209.32,203.96 191.8,203.96 191.05,203.2 185.35,203.2 182.2,200.05 163.8,200.05 163.32,200.53 163.32,202.82 164.08,203.58 170.81,203.58 176.15,208.92 176.15,210.69 181.48,216.03 196.05,216.03 196.63,215.45 210.64,215.45 215.01,211.07 215.01,207.9 217.17,205.74 218.82,205.74 219.9,204.66 v1(220.83,204.66)
SL13_DP_93: length 353.2
  L05_DP w0.079: SLOT13.B29 242.21,428.12 241.21,428.12 240.39,428.94 239.86,428.94 239.48,428.56 239.48,428.02 240.38,427.12 240.47,427.12 241.47,426.12 241.59,426.12 243.07,424.64 243.77,424.64 243.98,424.43 243.98,424.02 244.36,423.64 244.48,423.64 245.48,422.64 246.31,422.64 246.61,422.94 247.14,422.94 247.7,422.38 248.08,422.38 249.16,421.3 249.34,421.3 249.98,421.94 250.52,421.94 251.16,421.3 251.59,421.3 252.23,421.94 252.79,421.94 254.94,419.79 271.53,419.79 271.76,419.79 279.45,412.1 279.45,393.81 288.63,384.63 288.63,349.62 309.52,328.73 309.52,240.29 299.41,230.18 265.76,230.18 263.92,228.35 263.92,226.23 263.38,225.68 255.12,225.68 254.28,226.53 251.73,226.53 250.3,225.1 250.3,215.87 246.99,212.55 241.24,212.55 239.27,210.59 237.4,210.59 231,204.18 225.6,204.18 224.39,202.97 217.94,202.97 v1(216.26,204.66)
SL13_DP_94: length 298.7
  L03_DP w0.079: v1(226.06,193.35) 225.17,194.24 225.17,197.23 225.78,197.84 225.78,218.45 218.29,225.94 218.29,245.73 221.21,248.66 221.21,258.18 224.13,261.1 224.13,294.14 221.24,297.03 213.48,297.03 211.74,295.29 211.74,292.49 210.81,291.56 209.18,291.56 208.25,292.49 208.25,293.25 207.74,293.76 207.74,296.15 210.35,298.76 210.35,319.18 255.81,364.64 255.81,384.6 260.32,389.11 260.32,421.04 253.26,428.1 252.36,428.1 251.72,427.46 251.03,427.46 250.52,427.97 249.98,427.97 249.47,427.46 248.78,427.46 248.27,427.97 247.48,427.97 247.14,427.64 246.61,427.64 246.13,428.12 245.24,428.12 245.07,428.29 SLOT13.C29
SL13_DP_95: length 320.1
  L03_DP w0.079: SLOT13.D29 247.01,428.15 248.34,428.15 248.86,427.64 249.39,427.64 249.91,428.15 250.59,428.15 251.11,427.64 251.64,427.64 252.28,428.28 253.48,428.28 260.6,421.16 260.6,388.99 256.09,384.48 256.09,364.52 210.63,319.06 210.63,298.64 208.03,296.04 208.03,293.88 208.53,293.37 208.53,292.61 209.3,291.85 210.69,291.85 211.46,292.61 211.46,295.4 213.36,297.31 221.36,297.31 224.41,294.26 224.41,260.99 221.49,258.06 221.49,248.54 218.57,245.62 218.57,226.06 226.06,218.57 226.06,197.49 227.58,195.96 227.58,187.07 221.23,180.72 215.28,180.72 UNK7K15.2
SL13_DP_96: length 340.1
  L05_DP w0.079: SLOT13.E29 249.64,428.29 249.79,428.13 250.36,428.13 251.03,427.46 251.41,427.46 252.23,426.64 253.69,426.64 254.61,425.72 254.69,425.72 254.69,425.72 255.44,425.72 258.17,422.99 273.61,422.99 282.55,414.04 282.55,395.1 291.73,385.91 291.73,352.85 314.05,330.53 314.05,223.97 297.36,207.28 291.8,207.28 291.77,207.25 291.38,207.25 291.35,207.28 290.39,207.28 290.36,207.25 289.97,207.25 289.94,207.28 288.64,207.28 288.61,207.25 288.22,207.25 288.19,207.28 287.23,207.28 287.2,207.25 286.81,207.25 286.78,207.28 285.82,207.28 285.79,207.25 285.4,207.25 285.37,207.28 284.07,207.28 284.04,207.25 283.65,207.25 283.62,207.28 282.66,207.28 282.63,207.25 282.24,207.25 282.21,207.28 281.25,207.28 281.22,207.25 280.83,207.25 280.8,207.28 276.68,207.28 272.76,203.35 261.84,203.35 261.67,203.19 251.29,203.19 251.11,203.36 237.61,203.36 232.38,198.13 232.38,197.75 232.15,197.52 228.87,197.52 v1(228.22,198.18)
SL13_DP_97: length 344.5
  L05_DP w0.079: v1(228.22,193.35) 229.35,194.48 233.5,194.48 235.09,196.07 235.09,198.41 235.82,199.14 238.24,199.14 239.16,200.06 264.03,200.06 266.34,202.38 276.58,202.38 277.67,203.47 299.03,203.47 315,219.44 315,330.92 292.3,353.62 292.3,386.15 283.12,395.33 283.12,414.27 273.84,423.55 258.41,423.55 255.67,426.28 255.44,426.28 254.94,426.28 253.06,428.17 251.49,428.17 SLOT13.F29
SL13_DP_98: length 357.6
  L05_DP w0.079: v1(231.01,193.35) 231.86,194.2 233.39,194.2 233.62,194.2 235.37,195.95 235.37,198.24 235.95,198.82 238.37,198.82 239.29,199.75 264.25,199.75 265.41,200.91 276.44,200.91 277.31,201.78 278.53,201.78 279.1,202.36 300.69,202.36 315.31,216.98 315.31,331.05 292.58,353.78 292.58,386.27 283.4,395.45 283.4,414.39 273.96,423.83 258.72,423.83 254.15,428.41 252.21,428.41 251.46,429.15 251.03,429.15 250.52,428.64 249.98,428.64 249.47,429.15 248.79,429.15 248.25,428.6 247.73,428.6 246.88,429.46 246.53,429.46 246.05,429.94 245.48,429.94 245.18,429.64 244.36,429.64 243.36,430.64 243.23,430.64 242.93,430.94 241.82,430.94 241.36,430.48 240.32,430.48 SLOT13.A27
SL13_DP_99: length 343.5
  L05_DP w0.079: v1(233.17,198.18) 236.81,201.82 238.13,201.82 238.62,202.31 250.44,202.31 250.72,202.59 261.52,202.59 261.97,203.04 272.89,203.04 275.31,205.47 276.23,205.47 276.95,206.19 296.72,206.19 314.37,223.84 314.37,330.66 292.02,353.01 292.02,386.03 282.84,395.21 282.84,414.16 273.73,423.27 258.29,423.27 255.56,426 254.73,426 254.6,426.13 254.59,426.13 252.73,427.99 252,427.99 251.64,427.64 251.11,427.64 250.43,428.31 250.02,428.31 249.39,428.94 248.86,428.94 248.42,428.5 248.4,428.5 248.32,428.42 247.66,428.42 247.14,428.94 246.61,428.94 246.1,428.43 245.48,428.43 245.45,428.46 245.41,428.46 244.41,429.46 244.28,429.46 243.45,430.29 SLOT13.B27
SL13_DP_100: length 350.6
  L05_DP w0.079: SLOT13.C27 245.96,430.29 246.61,429.64 247.14,429.64 247.44,429.94 248.27,429.94 248.83,429.38 249.43,429.38 249.98,429.94 250.52,429.94 251.08,429.38 251.49,429.38 252.24,428.62 254.33,428.62 258.84,424.11 274.08,424.11 283.68,414.51 283.68,395.56 292.86,386.38 292.86,353.95 315.63,331.18 315.63,216.72 298.75,199.84 281.38,199.84 280.63,200.59 265.54,200.59 264.38,199.43 239.42,199.43 237.43,197.44 236.39,197.44 235.65,196.7 235.65,195.83 v1(233.17,193.35)
SL13_DP_101: length 363.2
  L05_DP w0.079: SLOT13.D27 248.17,430.29 248.82,429.64 249.43,429.64 249.91,430.12 250.29,430.12 251.11,430.94 251.64,430.94 252.25,430.33 253.42,430.33 259.07,424.68 274.31,424.68 284.25,414.74 284.25,395.8 293.43,386.62 293.43,354.72 316.57,331.57 316.57,207.37 294.95,185.75 278.63,185.75 277.87,186.5 276.03,186.5 275.13,185.6 270.91,185.6 269.94,186.57 259.43,186.57 258.57,185.71 242.05,185.71 239.8,183.46 239.03,183.46 238.64,183.85 236.12,183.85 235.8,183.53 233.61,183.53 232.43,182.35 UNK7K23.2
SL13_DP_102: length 352
  L05_DP w0.079: UNK7K24.2 240.51,182.35 241.6,183.44 267.01,183.44 267.46,183.89 269.67,183.89 270.12,183.44 275.9,183.44 276.35,183.89 278.47,183.89 278.87,183.5 293.28,183.5 316.89,207.11 316.89,331.7 293.71,354.88 293.71,386.73 284.53,395.91 284.53,414.86 274.43,424.96 259.19,424.96 253.64,430.51 252.32,430.51 251.72,431.12 251.03,431.12 250.36,430.44 249.28,430.44 SLOT13.E27
SL13_DP_103: length 341.2
  L05_DP w0.079: v1(236.47,193.35) 237.96,194.84 237.96,197.52 239.55,199.12 265.49,199.12 265.62,198.99 280.42,198.99 280.97,199.53 298.96,199.53 315.94,216.51 315.94,331.31 293.14,354.11 293.14,386.5 283.96,395.68 283.96,414.63 274.19,424.4 258.96,424.4 253.3,430.05 251.61,430.05 SLOT13.F27
SL13_DP_104: length 351.2
  L03_DP w0.079: SLOT13.Z27 237.05,431.12 237.05,436.63 237.53,437.12 237.62,437.12 238.66,438.15 239.34,438.15 239.86,437.64 240.39,437.64 240.91,438.15 241.59,438.15 242.11,437.64 242.64,437.64 243.16,438.15 243.84,438.15 244.36,437.64 244.89,437.64 245.37,438.12 246.09,438.12 246.57,437.64 247.14,437.64 247.72,438.21 248.29,438.21 248.86,437.64 249.39,437.64 249.97,438.21 250.54,438.21 251.11,437.64 251.64,437.64 252.02,438.02 255.43,438.02 284.43,409.01 284.43,394.72 299.74,379.41 299.74,345.24 314.33,330.64 314.33,217.55 300.34,203.55 288.65,203.55 287.96,202.87 279.17,202.87 278.4,202.1 277.18,202.1 276.31,201.22 265.28,201.22 264.14,200.08 244.63,200.08 v1(243.84,200.87)
SL13_DP_105: length 343.2
  L03_DP w0.079: v1(248.42,200.87) 249.23,200.87 249.7,200.39 263.51,200.39 264.7,201.59 275.64,201.59 277.92,203.87 300.21,203.87 314.02,217.68 314.02,330.51 299.43,345.1 299.43,379.28 284.12,394.59 284.12,408.88 256.53,436.48 252.36,436.48 251.38,437.46 251.03,437.46 250.47,438.02 250.04,438.02 249.47,437.46 248.78,437.46 248.22,438.02 247.79,438.02 247.22,437.46 246.5,437.46 246.02,437.94 245.45,437.94 244.97,437.46 244.28,437.46 243.77,437.97 243.23,437.97 242.72,437.46 242.03,437.46 241.52,437.97 240.98,437.97 240.47,437.46 239.78,437.46 239.27,437.97 238.73,437.97 237.7,436.94 237.61,436.94 237.23,436.56 237.23,436.02 237.7,435.55 237.7,435.02 237.23,434.56 237.23,433.6 237.88,432.95 SLOT13.Z25
SL13_DP_106: length 330.7
  L03_DP w0.079: SLOT13.A25 240.13,433.21 242.03,435.12 242.72,435.12 243.2,434.64 243.93,434.64 245.41,436.12 246.11,436.12 246.59,435.64 247.18,435.64 247.68,436.14 248.06,436.14 248.86,436.94 249.39,436.94 250.03,436.3 250.47,436.3 251.11,436.94 251.64,436.94 252.28,436.3 252.92,436.3 282.23,406.99 282.23,393.79 297.53,378.49 297.53,344.32 312.12,329.73 312.12,224.31 298.01,210.21 275.74,210.21 274.56,211.38 269.67,211.38 269.23,210.95 256.04,210.95 252.34,207.24 246.41,207.24 v1(243.84,204.68)
SL13_DP_107: length 333.1
  L05_DP w0.079: SLOT13.B25 242.14,432.05 241.1,432.05 240.42,431.38 240.3,431.38 239.48,430.56 239.48,430.02 239.86,429.64 240.39,429.64 240.91,430.15 241.59,430.15 242.11,429.64 242.23,429.64 243.75,428.12 243.84,428.12 244.32,427.64 244.89,427.64 245.43,428.17 246.07,428.17 246.61,427.64 246.73,427.64 247.73,426.64 247.86,426.64 248.86,425.64 249.39,425.64 249.76,426 250.49,426 251.03,425.46 251.72,425.46 252.26,426 253.24,426 254.37,424.87 254.98,424.87 257.38,422.47 257.54,422.31 257.54,422.3 257.71,422.14 272.6,422.14 281.71,413.03 281.71,394.75 290.89,385.56 290.89,352.35 313.11,330.14 313.11,224.86 298.01,209.76 279.55,209.76 279.35,209.96 277.06,209.96 276.86,209.76 275.24,209.76 273.25,207.77 273.25,207.51 273.25,205.62 272.25,204.63 267.15,204.63 265.19,206.58 262.72,206.58 261.76,207.54 255.58,207.54 254.2,206.16 249.9,206.16 v1(248.42,204.68)
SL13_DP_108: length 323.9
  L03_DP w0.079: v1(243.84,207.72) 245.27,209.15 248.45,209.15 249.95,210.64 254.85,210.64 257.62,213.41 269.31,213.41 269.88,212.84 299.76,212.84 311.49,224.57 311.49,329.46 296.9,344.05 296.9,378.23 281.6,393.53 281.6,407 253.33,435.26 253.33,435.63 252.84,436.12 252.16,436.12 251.65,435.61 251.1,435.61 250.59,436.12 249.91,436.12 249.36,435.57 248.64,435.57 248.27,435.94 247.73,435.94 247.25,435.46 246.52,435.46 246.04,435.94 245.48,435.94 245.1,435.56 245.1,435.02 245.55,434.57 245.55,434 245.1,433.56 245.1,432.76 SLOT13.C25
SL13_DP_109: length 334.2
  L05_DP w0.079: v1(248.42,207.72) 248.94,207.2 251.85,207.2 255.36,210.71 268.55,210.71 269.01,211.17 271.69,211.17 272.78,210.08 276.73,210.08 276.93,210.28 279.48,210.28 279.68,210.08 297.44,210.08 312.79,225.43 312.79,330.01 290.61,352.19 290.61,385.45 281.43,394.63 281.43,412.92 272.48,421.86 257.08,421.86 254.35,424.6 252.02,424.6 251.45,425.16 251.04,425.16 250.52,424.64 249.98,424.64 249.16,425.46 248.78,425.46 247.78,426.46 247.66,426.46 246.66,427.46 246.53,427.46 246.05,427.94 245.45,427.94 244.97,427.46 244.25,427.46 243.77,427.94 243.68,427.94 242.16,429.46 242.03,429.46 241.52,429.97 240.98,429.97 240.47,429.46 239.78,429.46 239.3,429.94 239.3,430.63 240.3,431.64 240.43,431.64 241.03,432.23 241.41,432.23 242.11,432.94 242.64,432.94 243.64,431.94 244.06,431.94 244.36,431.64 244.89,431.64 245.19,431.94 246.52,431.94 SLOT13.D25
SL13_DP_110: length 317.5
  L03_DP w0.079: v1(243.84,210.77) 244.54,211.47 244.54,212.36 244.9,212.71 247.61,212.71 249.33,214.44 249.33,215.51 251.05,217.24 251.05,227.54 252.27,228.76 268.33,228.76 269.76,230.18 299.41,230.18 310.23,241 310.23,328.94 295.64,343.53 295.64,377.71 280.34,393.01 280.34,407.84 253.15,435.03 253.15,435.56 252.77,435.94 252.23,435.94 251.73,435.43 251.02,435.43 250.52,435.94 249.98,435.94 249.34,435.29 248.98,435.29 248.13,434.45 247.89,434.45 247.22,435.12 246.53,435.12 246.05,434.63 246.05,433.94 246.53,433.46 246.66,433.46 247.66,432.46 248.95,432.46 SLOT13.E25
SL13_DP_111: length 315.6
  L03_DP w0.079: SLOT13.F25 251.02,432.64 249.98,432.64 249.56,433.06 248.75,433.06 248.33,432.64 247.73,432.64 246.73,433.64 246.61,433.64 246.23,434.02 246.23,434.56 246.61,434.94 247.14,434.94 247.96,434.12 248.38,434.12 248.86,433.64 249.39,433.64 250.39,434.64 250.52,434.64 251,435.12 251.72,435.12 252.72,434.12 253.38,434.12 280.02,407.47 280.02,392.88 295.32,377.58 295.32,343.4 309.91,328.81 309.91,241.13 299.28,230.5 269.63,230.5 268.2,229.07 252.14,229.07 250.67,227.6 250.67,217.3 248.04,214.67 245.1,214.67 v1(243.84,213.41)
SL13_DP_112: length 341.9
  L05_DP w0.079: v1(236.07,212.18) 236.42,212.18 239.48,215.24 248.16,215.24 249.65,216.72 249.65,227.03 252.01,229.39 254.09,229.39 256.01,231.31 264.25,231.31 264.74,230.81 299.15,230.81 308.88,240.55 308.88,328.47 288.07,349.29 288.07,384.4 278.89,393.58 278.89,411.86 271.53,419.22 253.48,419.22 252.77,419.94 252.64,419.94 251.64,420.94 251.11,420.94 250.57,420.4 249.93,420.4 249.39,420.94 248.86,420.94 248.22,420.3 248.04,420.3 247.22,421.12 246.53,421.12 245.95,420.53 245.55,420.53 244.97,421.12 244.25,421.12 243.66,420.53 243.34,420.53 242.75,421.12 242.62,421.12 241.62,422.12 240.91,422.12 240.38,421.59 239.87,421.59 239.34,422.12 238.62,422.12 238.14,421.64 235.91,421.64 234.52,423.03 234.52,431.81 236.35,433.64 238.14,433.64 238.72,434.21 240.05,434.21 SLOT13.A23
SL13_DP_113: length 322.8
  L03_DP w0.079: v1(236.07,216.75) 237.86,218.53 237.86,223.24 240.64,226.01 247.52,226.01 249.41,227.91 249.41,229.34 251.65,231.58 251.65,234.89 253.17,236.41 260.33,236.41 261.46,235.28 261.46,235.28 263.5,233.24 268.86,233.24 270.23,234.61 301.61,234.61 308.65,241.65 308.65,328.29 273.36,363.58 273.36,382.18 278.76,387.58 278.76,406.4 253.05,432.12 252.12,432.12 251.64,431.64 251.11,431.64 250.63,432.12 249.87,432.12 249.36,431.6 248.89,431.6 248.38,432.12 247.66,432.12 247.14,431.6 246.61,431.6 246.03,432.18 245.44,432.18 244.89,431.64 244.32,431.64 243.32,432.64 243.23,432.64 242.38,433.49 SLOT13.B23
SL13_DP_114: length 322
  L03_DP w0.079: SLOT13.C23 243.29,434.29 242.64,434.94 242.11,434.94 241.73,434.56 241.73,433.89 243.16,432.46 243.25,432.46 244.25,431.46 244.97,431.46 245.12,431.61 245.16,431.61 245.48,431.94 246.02,431.94 246.53,431.42 247.22,431.42 247.73,431.94 248.27,431.94 248.78,431.42 249.47,431.42 249.98,431.94 250.55,431.94 251.03,431.46 251.72,431.46 252.2,431.94 252.77,431.94 278.45,406.26 278.45,387.71 273.05,382.31 273.05,363.45 308.34,328.16 308.34,241.78 301.48,234.93 269.71,234.93 267.21,237.43 260.24,237.43 259.53,236.72 251.43,236.72 250.39,235.69 250.39,230.77 249.1,229.47 249.1,228.04 247.38,226.33 240.51,226.33 236.07,221.89 v1(236.07,221.32)
SL13_DP_115: length 320.1
  L03_DP w0.079: SLOT13.D23 247.22,434.29 247.57,433.94 248.27,433.94 248.75,433.46 249.47,433.46 250.47,434.46 250.59,434.46 251.07,434.94 251.64,434.94 252.64,433.94 252.88,433.94 279.39,407.42 279.39,392.56 285.34,386.61 285.45,386.54 294.58,377.41 294.65,377.3 294.65,343.18 309.28,328.55 309.28,241.39 300.08,232.19 263.43,232.19 262,233.61 256.42,233.61 253.98,231.18 252.13,231.18 250.04,229.08 250.04,217.56 247.79,215.31 240.9,215.31 240.15,214.57 240.15,213.46 239.67,212.98 234.72,212.98 233.91,212.18 v1(233.15,212.18)
SL13_DP_116: length 347.7
  L05_DP w0.079: SLOT13.E23 248.82,434.59 247.49,434.59 247.14,434.94 246.59,434.94 245.95,434.29 245.54,434.29 244.89,434.94 244.36,434.94 243.88,434.46 243.12,434.46 242.64,434.94 242.11,434.94 241.63,434.46 240.87,434.46 240.39,434.94 239.86,434.94 239.38,434.46 238.66,434.46 238.02,435.1 237.36,435.1 234.2,431.94 234.2,422.9 235.83,421.27 238.07,421.27 238.73,421.94 239.27,421.94 239.8,421.41 240.45,421.41 240.98,421.94 241.52,421.94 242.52,420.94 242.64,420.94 243.23,420.35 243.77,420.35 244.36,420.94 244.89,420.94 245.48,420.35 246.02,420.35 246.61,420.94 247.14,420.94 247.96,420.12 248.34,420.12 248.98,419.48 249.27,419.48 249.91,420.12 250.63,420.12 251.11,419.64 251.23,419.64 252.23,418.64 252.77,418.64 253.07,418.94 265.43,418.94 277.82,406.55 277.82,387.97 272.42,382.57 272.42,363.19 307.71,327.9 307.71,242.07 303.27,237.63 269,237.63 268.72,237.35 250.22,237.35 247.11,234.25 247.11,229.33 242.97,225.19 235,225.19 233.15,223.34 v1(233.15,222.59)
SL13_DP_117: length 323
  L03_DP w0.079: v1(230.74,213.7) 231.63,213.7 232.18,213.16 234.45,213.16 234.59,213.3 236.11,213.3 236.55,213.73 236.55,214.56 237.62,215.63 247.66,215.63 249.73,217.69 249.73,229.21 252,231.49 253.85,231.49 254.5,232.14 254.5,234.61 255.98,236.09 260.2,236.09 263.37,232.92 300.37,232.92 308.97,241.52 308.97,328.42 273.68,363.71 273.68,382.05 279.08,387.45 279.08,406.47 279.05,406.5 279.05,406.52 252.93,432.64 252.23,432.64 251.85,433.02 251.85,433.69 251.85,433.7 251.85,433.81 SLOT13.F23
SL13_DP_118: length 322.4
  L03_DP w0.079: SLOT13.Z23 237.88,433.83 238.17,433.53 238.17,432.94 238.66,432.46 239.19,432.46 239.3,432.36 239.3,431.94 239.78,431.46 240.47,431.46 240.95,431.94 241.55,431.94 242.55,430.94 242.64,430.94 243.12,430.46 243.88,430.46 244.36,430.94 244.89,430.94 245.53,430.3 245.97,430.3 246.61,430.94 247.14,430.94 247.77,430.31 248.23,430.31 248.86,430.94 249.43,430.94 249.91,430.46 250.59,430.46 251.11,430.97 251.64,430.97 252.16,430.46 253.29,430.46 277.5,406.25 277.5,388.1 272.1,382.7 272.1,363.06 307.39,327.77 307.39,245.82 301.83,240.26 278.65,240.26 277.98,239.59 275.99,239.59 275.32,240.27 270.44,240.27 269.65,239.48 260.77,239.48 258.97,237.67 247.62,237.67 246.12,236.17 246.12,229.78 245.31,228.97 240.45,228.97 239.8,228.32 239.8,226.96 238.35,225.51 234.8,225.51 234.48,225.19 231.82,225.19 v1(230.74,224.11)
SL13_DP_119: length 335.7
  L03_DP w0.079: v1(228.33,218.27) 229.05,218.27 229.51,218.73 233.27,218.73 234.05,219.52 234.05,223.09 234.86,223.89 237.63,223.89 240.38,226.64 247.25,226.64 248.28,227.67 248.28,234.97 250.35,237.04 259.23,237.04 260.61,238.43 267.15,238.43 269.3,236.28 302.36,236.28 308.02,241.94 308.02,328.03 272.73,363.32 272.73,382.44 278.13,387.84 278.13,406.01 253.51,430.64 252.23,430.64 251.72,431.15 251.03,431.15 250.52,430.64 249.98,430.64 249.5,431.12 248.78,431.12 248.15,430.49 247.85,430.49 247.22,431.12 246.53,431.12 245.89,430.48 245.61,430.48 244.92,431.17 244.3,431.17 243.77,430.64 243.2,430.64 242.72,431.12 242.63,431.12 241.62,432.12 240.88,432.12 240.39,431.64 239.86,431.64 239.48,432.02 239.48,432.43 239.27,432.64 238.73,432.64 238.35,433.02 238.35,433.56 238.48,433.68 238.48,433.97 238.52,434.02 238.52,434.56 237.88,435.2 SLOT13.Z21
SL13_DP_121: length 196.9
  TOP w0.381: TP_OUT+_1.1 v1(126.61,295.54)
  L05_DP w0.079: v1(126.61,295.54) 126.61,306.96 212.73,393.08 212.73,406.13 222.24,415.64 222.24,426.49 232.48,436.74 236.51,436.74 237.61,435.64 238.14,435.64 238.69,436.19 239.31,436.19 239.86,435.64 240.39,435.64 240.94,436.19 242.27,436.19 SLOT13.B21
SL13_DP_122: length 200.3
  TOP w0.381: TP_OUT-_1.1 v1(124.31,295.54)
  L05_DP w0.079: v1(124.31,295.54) 124.31,305.22 212.34,393.25 212.34,406.18 221.93,415.77 221.93,426.63 232.35,437.05 238.32,437.05 238.77,436.6 239.52,436.6 239.86,436.94 240.39,436.94 240.73,436.6 241.76,436.6 242.29,437.12 242.75,437.12 243.58,436.29 SLOT13.C21
SL13_DP_123: length 199.8
  TOP w0.381: TP_OUT+_2.1 v1(133.22,295.54)
  L05_DP w0.079: SLOT13.D21 246.88,435.49 245.85,434.47 245.62,434.47 244.97,435.12 244.28,435.12 243.8,434.64 243.2,434.64 242.72,435.12 242.03,435.12 241.55,434.64 240.95,434.64 240.47,435.12 239.78,435.12 239.3,434.64 238.73,434.64 238.09,435.28 237.46,435.28 236.63,436.11 232.74,436.11 222.87,426.23 222.87,415.38 213.51,406.02 213.51,392.76 133.22,312.47 v1(133.22,295.54)
SL13_DP_124: length 202.5
  TOP w0.381: TP_OUT-_2.1 v1(130.91,295.54)
  L05_DP w0.079: SLOT13.E21 248.08,436.29 247.4,436.96 246.64,436.96 245.61,435.94 245.19,435.94 244.89,435.64 244.36,435.64 244.06,435.94 242.94,435.94 242.64,435.64 242.11,435.64 241.81,435.94 240.98,435.94 240.5,435.46 239.78,435.46 239.28,435.96 238.72,435.96 238.22,435.46 237.53,435.46 236.57,436.42 232.61,436.42 222.56,426.36 222.56,415.51 213.15,406.11 213.15,392.91 130.91,310.68 v1(130.91,295.54)
SL13_DP_125: length 463.7
  L05_DP w0.079: SLOT13.F21 251.38,437.22 249.66,438.94 248.86,438.94 248.56,438.64 247.61,438.64 245.81,440.44 245.39,440.44 244.89,440.94 244.07,440.94 243.77,440.64 243.23,440.64 242.67,441.2 242.08,441.2 241.52,440.64 240.98,440.64 240.42,441.2 239.83,441.2 239.27,440.64 238.73,440.64 238.17,441.2 237.36,441.2 236.6,440.44 234.09,440.44 220.76,427.11 220.76,416.25 207.57,403.06 207.57,395.23 111.58,299.24 111.58,220.18 128.23,203.53 128.23,180.64 144.97,163.9 158.5,163.9 161.55,166.95 161.55,181.86 160.02,183.39 157.9,183.39 155.73,185.55 155.73,187.44 154.55,188.62 151.77,188.62 150.43,189.96 150.43,200.6 143.88,207.16 143.88,212.97 143.04,213.81 143.04,221.32 148.17,226.44 151.29,226.44 153.55,228.7 v1(156.79,228.7)
  BOTTOM w0.203: v1(156.79,228.7) 156.79,227.38 R15.1
SL13_DP_126: length 447.3
  L05_DP w0.079: SLOT13.B19 241.33,438.29 240.68,438.94 239.73,438.94 238.16,437.37 232.22,437.37 221.61,426.76 221.61,415.9 208.41,402.71 208.41,394.88 208.17,394.64 115.1,301.57 115.1,301.57 112.6,299.07 112.6,220.35 129.08,203.88 129.08,180.99 145.32,164.74 158.15,164.74 160.7,167.3 160.7,175.83 158.99,177.55 151.09,177.55 148.72,179.92 148.72,192.15 149.59,193.02 149.59,200.25 143.03,206.81 143.03,211.7 142.2,212.53 142.2,221.67 146.81,226.28 146.81,226.52 146.81,228.09 148.84,230.12 151.38,230.12 151.71,229.79 v1(151.71,228.7)
  BOTTOM w0.203: v1(151.71,228.7) 151.71,227.38 R17.1
SL13_DP_127: length 653.6
  TOP w0.381: UNK3TP_OUT+_1.1 v1(206.61,295.54)
  L05_DP w0.079: SLOT13.C19 244.63,439.37 243.54,440.46 243.16,440.46 242.6,441.02 242.16,441.02 241.59,440.46 240.91,440.46 240.35,441.02 239.91,441.02 239.34,440.46 238.66,440.46 238.1,441.02 237.44,441.02 236.57,440.15 234.21,440.15 221.05,426.99 221.05,416.14 207.85,402.94 207.85,395.11 111.86,299.12 111.86,220.3 128.51,203.64 128.51,180.75 145.09,164.18 158.38,164.18 161.27,167.06 161.27,178.84 157.51,182.6 157.51,183.38 155.45,185.44 155.45,187.33 154.43,188.34 151.66,188.34 150.15,189.84 150.15,200.49 143.6,207.04 143.6,212.85 142.76,213.69 142.76,221.43 148.13,226.8 148.52,226.8 149.66,227.94 152.39,227.94 153.91,229.46 156.92,229.46 157.58,228.8 157.58,218.58 160.54,215.62 180.28,215.62 181.38,216.72 187.54,216.72 189.48,218.67 193.48,218.67 194.44,217.71 195.95,217.71 197.23,218.99 197.23,222.61 201.16,226.54 215.02,226.54 216.16,225.4 225.02,225.4 226.31,226.7 226.31,227.33 225.81,227.84 221.98,227.84 221.62,228.21 202.7,228.21 200.15,230.76 200.15,234.31 206.76,240.92 206.76,247.42 209.65,250.32 209.65,257.38 206.5,260.53 206.5,276.93 207.58,278 207.58,281 208.34,281.76 208.34,287.49 205.26,290.58 201.68,290.58 200.15,292.1 200.15,294.51 201.8,296.16 205.99,296.16 v1(206.61,295.54)
SL13_DP_128: length 344.4
  TOP w0.381: UNK3TP_OUT-_1.1 v1(204.31,295.54)
  L05_DP w0.079: SLOT13.E43 249.82,414.29 249.83,414.3 250.47,414.3 251.11,414.94 251.64,414.94 252.02,414.56 252.02,413.73 252.1,413.66 252.43,413.33 253.82,413.33 254.35,413.86 255.76,413.86 255.76,413.86 256.02,413.86 256.54,413.86 257.39,413.01 258.12,413.01 273.05,398.09 273.05,388.84 266.85,382.64 266.85,360.34 239.45,332.95 239.45,289.22 237.19,286.96 237.19,282.45 236.63,281.88 236.63,279.75 236.21,279.33 235.35,279.33 234.69,278.67 234.69,276.53 234.94,276.28 236.71,276.28 237.26,276.83 237.26,281.62 237.82,282.18 237.82,285.03 239.21,286.41 249.05,286.41 250.48,284.98 250.48,276.39 252.88,273.99 252.88,265.11 252.55,264.78 252.55,258.62 250.85,256.92 250.85,245.9 239.48,234.52 230.08,234.52 229.14,233.59 219.29,233.59 215.27,237.61 211.7,237.61 209.93,239.38 209.93,257.5 207.86,259.57 207.86,280.89 208.62,281.65 208.62,287.61 205.09,291.14 205.09,294.76 v1(204.31,295.54)
SL13_DP_129: length 478.2
  TOP w0.381: UNK3TP_OUT+_2.1 v1(213.21,295.54)
  L03_DP w0.079: SLOT13.F43 252.32,414.29 253.29,413.32 253.29,392.31 247.75,386.78 247.75,386.57 247.72,386.53 247.72,368.14 178.49,298.91 178.49,285.42 181.25,282.65 181.25,278.1 178.96,275.81 177.91,275.81 172.21,270.1 172.21,263.05 171.17,262 171.17,259.69 168.45,256.98 168.45,249.94 166.81,248.3 162.03,248.3 160.85,247.12 160.85,241.68 159.92,240.75 158.57,240.75 158.05,240.24 158.05,238.54 157.6,238.09 155.17,238.09 154.39,237.3 154.39,236.78 154.39,229.16 153.12,227.89 150.56,227.89 148.9,226.23 148.9,213.24 145.24,209.58 145.24,175.82 148.59,172.47 162.63,172.47 166.06,175.9 166.06,184.76 169.28,187.98 169.28,195.56 173.64,199.92 182.45,199.92 183.86,201.33 183.86,235.8 185.58,237.52 203.07,237.52 208.72,243.17 208.72,255.85 210.54,257.67 210.54,259.79 211.12,260.38 211.12,265.46 212.99,267.34 212.99,275.65 209.94,278.71 209.94,287.23 211.55,288.84 213.73,288.84 214.89,290 214.89,293.87 v1(213.21,295.54)
SL13_DP_130: length 192.4
  TOP w0.381: UNK3TP_OUT-_2.1 v1(210.91,295.54)
  L03_DP w0.079: SLOT13.A41 240.13,417.11 240.95,417.94 240.95,418.63 240.47,419.12 239.93,419.12 239.78,419.12 239.24,418.57 238.8,418.57 238.25,419.12 238.1,419.12 237.48,419.12 236.72,419.87 236.72,426.97 237.39,427.64 238.14,427.64 238.83,428.32 239.24,428.32 239.86,428.94 240.39,428.94 240.91,428.42 241.59,428.42 242.11,428.94 242.64,428.94 243.16,428.42 243.84,428.42 244.36,428.94 244.89,428.94 245.39,428.44 246.12,428.44 246.61,428.94 247.18,428.94 247.66,428.46 248.34,428.46 248.86,428.97 249.39,428.97 249.91,428.46 250.59,428.46 251.11,428.97 251.64,428.97 252.16,428.46 253.7,428.46 260.88,421.28 260.88,388.88 256.37,384.37 256.37,364.4 210.91,318.95 v1(210.91,295.54)
SL13_DP_131: length 303.4
  L05_DP w0.079: v1(236.79,228.7) 237.37,229.28 244.01,229.28 245.03,230.29 245.03,235.8 250.24,241.02 302.14,241.02 307.08,245.95 307.08,327.64 271.79,362.92 271.79,382.83 276.83,387.87 276.83,401.65 260.37,418.12 252.12,418.12 251.64,417.64 251.11,417.64 250.7,418.05 250.7,418.53 250.9,418.73 250.9,419.56 250.52,419.94 249.98,419.94 249.34,419.3 248.91,419.3 248.27,419.94 247.73,419.94 247.25,419.46 246.5,419.46 246.02,419.94 245.48,419.94 245,419.46 244.25,419.46 243.77,419.94 243.23,419.94 243.03,419.73 242.41,419.12 242.03,419.12 241.55,418.63 241.55,417.91 242.38,417.08 SLOT13.B41
  BOTTOM w0.203: v1(236.79,228.7) 236.79,227.38 UNK3R15.1
SL13_DP_132: length 306.3
  L05_DP w0.079: SLOT13.C41 244.27,416.64 243.11,416.64 241.73,418.02 241.73,418.56 242.11,418.94 242.64,418.94 242.99,418.59 243.72,418.59 244.25,419.12 244.97,419.12 245.49,418.59 246.26,418.59 246.61,418.94 247.14,418.94 247.61,418.47 248.13,418.47 248.78,419.12 249.47,419.12 249.95,418.63 249.95,418.5 251,417.46 251.75,417.46 252.23,417.94 252.77,417.94 254.35,416.35 261.73,416.35 276.55,401.53 276.55,388.04 271.47,382.96 271.47,362.79 306.76,327.51 306.76,246.08 302.01,241.33 249.43,241.33 243.84,235.74 243.84,234.05 243.84,234.04 243.84,231.59 241.85,229.6 232.61,229.6 v1(231.71,228.7)
  BOTTOM w0.203: v1(231.71,228.7) 231.71,227.38 UNK3R17.1
SL13_DP_133: length 257.5
  TOP w0.381: UNK5TP_OUT+_1.1 v1(126.61,235.54)
  L03_DP w0.079: v1(126.61,235.54) 115.73,246.42 115.73,301.31 223.72,409.29 235.95,409.29 236.03,409.21 238.15,409.21 238.73,408.64 239.27,408.64 239.83,409.2 240.42,409.2 240.98,408.64 241.52,408.64 242.34,409.46 242.75,409.46 243.23,409.94 243.32,409.94 244.84,411.46 245,411.46 245.48,411.94 245.57,411.94 246.66,413.02 246.78,413.02 247.22,413.46 247.22,413.46 247.7,413.94 247.7,413.95 248.22,414.46 248.34,414.46 249.77,415.89 249.77,416.56 249.39,416.94 248.86,416.94 248.21,416.29 SLOT13.D41
SL13_DP_134: length 252.9
  TOP w0.381: UNK5TP_OUT-_1.1 v1(124.31,235.54)
  L03_DP w0.079: SLOT13.E41 249.13,415.49 248.27,414.64 248.14,414.64 247.52,414.02 247.52,414.02 247.14,413.64 247.14,413.64 246.7,413.2 246.58,413.2 245.5,412.12 245.41,412.12 244.93,411.64 244.77,411.64 243.25,410.12 243.16,410.12 242.68,409.64 241.82,409.64 241.52,409.94 240.98,409.94 240.42,409.38 239.83,409.38 239.27,409.94 238.73,409.94 238.19,409.39 236.35,409.39 236.17,409.58 223.55,409.58 115.42,301.44 115.42,244.44 v1(124.31,235.54)
SL13_DP_135: length 257.8
  TOP w0.381: UNK5TP_OUT+_2.1 v1(133.22,235.54)
  L03_DP w0.079: SLOT13.F41 251.38,415.49 248.34,412.46 248,412.46 244.56,409.02 244.15,409.02 243.77,408.64 243.23,408.64 242.85,409.02 242.19,409.02 241.47,408.3 241.03,408.3 240.31,409.02 239.91,409.02 239.34,408.46 238.66,408.46 238.17,408.94 224.26,408.94 116.37,301.05 116.37,252.39 v1(133.22,235.54)
SL13_DP_136: length 242
  TOP w0.381: UNK5TP_OUT-_2.1 v1(130.91,235.54)
  L05_DP w0.079: v1(130.91,235.54) 126.64,239.81 126.64,284.03 131.63,289.03 140.79,289.03 146.65,294.89 148.38,294.89 157.99,304.49 157.99,330.75 214.97,387.74 214.97,393.17 214.97,393.17 214.97,394.73 219.45,399.21 228.07,399.21 233.11,404.26 233.11,413.68 235.72,416.29 SLOT13.Z41
SL13_DP_137: length 338.7
  L05_DP w0.079: v1(156.79,168.7) 156.79,168.2 156.46,167.88 142.63,167.88 129.39,181.12 129.39,204.01 118.59,214.81 118.59,276.42 130.71,288.55 130.71,290.23 131.8,291.32 142.64,291.32 146.52,295.2 148.25,295.2 157.67,304.62 157.67,330.88 214.66,387.87 214.66,393.04 214.66,394.86 219.32,399.53 227.94,399.53 232.79,404.39 232.79,413.81 236.24,417.25 236.84,417.25 SLOT13.Z39
  BOTTOM w0.203: UNK5R15.1 156.79,167.38 v1(156.79,168.7)
SL13_DP_138: length 340.9
  L03_DP w0.079: v1(151.71,168.7) 151.71,169.88 151.3,170.29 140.66,170.29 129.71,181.25 129.71,204.14 113.23,220.61 113.23,301.05 223.64,411.46 238.22,411.46 238.7,411.94 239.27,411.94 239.57,411.64 240.39,411.64 240.77,412.02 240.77,412.56 240.39,412.94 239.86,412.94 239.56,412.64 238.5,412.64 237.22,413.92 237.22,416.71 238.72,418.21 240.05,418.21 SLOT13.A39
  BOTTOM w0.203: UNK5R17.1 151.71,167.38 v1(151.71,168.7)
SL13_DP_139: length 326.5
  TOP w0.381: UNK7TP_OUT+_1.1 v1(206.61,235.54)
  L05_DP w0.079: v1(206.61,235.54) 208.4,235.54 209.84,236.98 213.96,236.98 215.3,235.64 215.3,229.97 216.15,229.12 221.84,229.12 224.87,232.15 237.9,232.15 251.42,245.66 251.42,246.7 253.99,249.27 258.62,249.27 258.99,249.64 279.62,249.64 280.94,248.32 301.28,248.32 305.5,252.55 305.5,326.98 270.21,362.27 270.21,383.48 275.61,388.88 275.61,401.18 261.7,415.09 252.25,415.09 251.87,415.48 251.23,415.48 250.59,416.12 249.87,416.12 249.39,415.64 248.86,415.64 248.48,416.02 248.48,416.56 248.69,416.77 248.69,417.62 248.28,418.02 247.53,418.02 247.14,417.64 246.32,417.64 246.02,417.94 245.89,417.94 244.89,418.94 244.36,418.94 243.71,418.29 SLOT13.B39
SL13_DP_140: length 322.4
  TOP w0.381: UNK7TP_OUT-_1.1 v1(204.31,235.54)
  L05_DP w0.079: SLOT13.C39 245.1,417.81 245.1,417.02 245.48,416.64 246.31,416.64 246.61,416.94 247.3,416.94 248.78,415.46 249.47,415.46 249.95,415.94 250.52,415.94 251.16,415.3 251.79,415.3 252.31,414.78 261.57,414.78 275.3,401.05 275.3,389.01 269.9,383.61 269.9,362.14 305.19,326.85 305.19,252.68 301.15,248.64 281.07,248.64 278.85,250.86 259.8,250.86 258.5,249.56 253.87,249.56 251.14,246.82 251.14,245.78 238.35,232.99 225.26,232.99 223.55,231.27 216.56,231.27 215.61,232.23 215.61,235.77 214.09,237.29 207.38,237.29 205.63,235.54 v1(204.31,235.54)
SL13_DP_141: length 314.9
  TOP w0.381: UNK7TP_OUT+_2.1 v1(213.21,235.54)
  L05_DP w0.079: SLOT13.D39 248.21,418.29 248.86,418.94 249.39,418.94 249.77,418.56 249.77,418.02 249.6,417.84 249.6,416.98 249.95,416.64 250.55,416.64 251.03,417.12 251.72,417.12 253.11,415.72 261.96,415.72 276.24,401.44 276.24,388.62 270.84,383.22 270.84,362.53 306.13,327.24 306.13,252.29 299.54,245.7 278.85,245.7 278.02,246.53 276,246.53 275.14,245.67 270.5,245.67 269.6,246.57 260.19,246.57 259.25,245.63 252.37,245.63 236.97,230.23 223.84,230.23 222.1,228.49 215.89,228.49 214.67,229.71 214.67,234.09 v1(213.21,235.54)
SL13_DP_142: length 315.3
  TOP w0.381: UNK7TP_OUT-_2.1 v1(210.91,235.54)
  L05_DP w0.079: SLOT13.E39 249.13,417.2 249.87,416.46 250.63,416.46 251.11,416.94 251.64,416.94 253.17,415.41 261.83,415.41 275.93,401.31 275.93,388.75 270.53,383.35 270.53,362.4 305.82,327.11 305.82,252.42 301.41,248.01 270.61,248.01 269.49,246.89 260.73,246.89 258.63,248.99 254.11,248.99 251.7,246.58 251.7,245.55 236.69,230.54 223.71,230.54 221.97,228.8 216.02,228.8 214.98,229.84 214.98,235.51 214.06,236.43 212.5,236.43 211.61,235.54 v1(210.91,235.54)
SL13_DP_143: length 534.3
  L05_DP w0.079: SLOT13.F39 252.04,418.29 252.21,418.46 260.96,418.46 277.11,402.31 277.11,387.76 272.07,382.71 272.07,363.04 307.36,327.75 307.36,245.84 302.26,240.73 279.47,240.73 276.86,238.12 262.25,238.12 261.49,238.89 259.08,238.89 257.94,237.74 247.9,237.74 246,235.84 246,233.43 246.38,233.05 246.38,229 242.85,225.47 233.6,225.47 231.78,223.65 231.78,213.87 230,212.09 220.98,212.09 217.34,215.73 199.43,215.73 197.74,217.42 189.48,217.42 188.5,216.44 181.49,216.44 180.39,215.34 160.42,215.34 157.3,218.46 157.3,221.16 153.18,225.28 147.46,225.28 143.64,221.45 143.64,213.61 144.16,213.09 144.16,207.28 150.72,200.72 150.72,198.41 152.53,196.6 152.53,193.04 154.69,190.88 154.69,188.88 156.01,187.56 156.01,186.38 156.72,185.67 164.21,185.67 177.67,172.21 230.89,172.21 234.4,168.7 v1(236.79,168.7)
  BOTTOM w0.203: v1(236.79,168.7) 236.79,167.38 UNK7R15.1
SL13_DP_144: length 388.5
  L03_DP w0.079: SLOT13.A17 240.13,439.49 240.98,438.64 241.52,438.64 241.92,439.04 242.83,439.04 243.23,438.64 243.77,438.64 244.17,439.04 245.08,439.04 245.48,438.64 246.02,438.64 246.42,439.04 247.04,439.04 247.56,438.52 248.44,438.52 248.86,438.94 249.39,438.94 249.81,438.52 250.57,438.52 250.99,438.94 251.64,438.94 252.18,438.4 256.8,438.4 286.26,408.95 286.26,393.95 301.95,378.27 301.95,346.48 316.77,331.66 316.77,189.93 297.3,170.46 232.99,170.46 231.71,169.17 v1(231.71,168.7)
  BOTTOM w0.203: UNK7R17.1 231.71,167.38 v1(231.71,168.7)
SL14_PMVI_10_HF:
  vias: v1(188.21,243.34)
SL14_PMVI_11_HF:
  vias: v1(196.46,243.34)
SL14_PMVI_12_HF: length 0.3
  BOTTOM w0.203: UNK2U1.4 v1(164.31,294.24)
SL14_PMVI_13_HF:
  vias: v1(170.91,294.24)
SL14_PMVI_14_HF:
  vias: v1(195.49,231.3)
SL14_PMVI_15_HF: length 2.2
  BOTTOM w0.203: UNK2C72.1 UNK2R15.2 UNK2U3.1
SL14_PMVI_16_HF: length 2.7
  BOTTOM w0.381: UNK2U3.3 196.14,226.77 195.94,226.57 v1(195.49,226.57)
SL14_PMVI_17_HF:
  vias: v1(190.41,231.3)
SL14_PMVI_18_HF: length 2.2
  BOTTOM w0.203: UNK2U4.1 UNK2R17.2 UNK2C73.1
SL14_PMVI_19_HF: length 0.9
  BOTTOM w0.381: UNK2TP_REF_2.1 v1(191.06,229.62)
SL14_PMVI_20_HF:
  vias: v1(268.21,243.34)
SL14_PMVI_21_HF:
  vias: v1(276.46,243.34)
SL14_PMVI_22_HF: length 0.3
  BOTTOM w0.203: UNK4U1.4 v1(244.31,294.24)
SL14_PMVI_23_HF:
  vias: v1(250.91,294.24)
SL14_PMVI_24_HF:
  vias: v1(275.49,231.3)
SL14_PMVI_25_HF: length 2.2
  BOTTOM w0.203: UNK4U3.1 UNK4R15.2 UNK4C72.1
SL14_PMVI_26_HF: length 2.7
  BOTTOM w0.381: UNK4U3.3 276.14,226.77 275.94,226.57 v1(275.49,226.57)
SL14_PMVI_27_HF:
  vias: v1(270.41,231.3)
SL14_PMVI_28_HF: length 2.2
  BOTTOM w0.203: UNK4C73.1 UNK4R17.2 UNK4U4.1
SL14_PMVI_29_HF: length 0.9
  BOTTOM w0.381: UNK4TP_REF_2.1 v1(271.06,229.62)
SL14_PMVI_30_HF:
  vias: v1(188.21,183.34)
SL14_PMVI_31_HF:
  vias: v1(196.46,183.34)
SL14_PMVI_32_HF: length 0.3
  BOTTOM w0.203: UNK6U1.4 v1(164.31,234.24)
SL14_PMVI_33_HF:
  vias: v1(170.91,234.24)
SL14_PMVI_34_HF:
  vias: v1(195.49,171.3)
SL14_PMVI_35_HF: length 2.2
  BOTTOM w0.203: UNK6U3.1 UNK6R15.2 UNK6C72.1
SL14_PMVI_36_HF: length 2.7
  BOTTOM w0.381: v1(195.49,166.57) 195.94,166.57 196.14,166.77 UNK6U3.3
SL14_PMVI_37_HF:
  vias: v1(190.41,171.3)
SL14_PMVI_38_HF: length 2.2
  BOTTOM w0.203: UNK6U4.1 UNK6R17.2 UNK6C73.1
SL14_PMVI_39_HF: length 0.9
  BOTTOM w0.381: UNK6TP_REF_2.1 v1(191.06,169.62)
SL14_PMVI_40_HF:
  vias: v1(268.21,183.34)
SL14_PMVI_41_HF:
  vias: v1(276.46,183.34)
SL14_PMVI_42_HF: length 0.3
  BOTTOM w0.203: UNK8U1.4 v1(244.31,234.24)
SL14_PMVI_43_HF:
  vias: v1(250.91,234.24)
SL14_PMVI_44_HF:
  vias: v1(275.49,171.3)
SL14_PMVI_45_HF: length 2.2
  BOTTOM w0.203: UNK8U3.1 UNK8R15.2 UNK8C72.1
SL14_PMVI_46_HF: length 2.7
  BOTTOM w0.381: UNK8U3.3 276.14,166.77 275.94,166.57 v1(275.49,166.57)
SL14_PMVI_47_HF:
  vias: v1(270.41,171.3)
SL14_PMVI_48_HF: length 2.2
  BOTTOM w0.203: UNK8U4.1 UNK8R17.2 UNK8C73.1
SL14_PMVI_49_HF: length 0.9
  BOTTOM w0.381: UNK8TP_REF_2.1 v1(271.06,169.62)
SL17_VI100_2_A_HF: length 11.5
  TOP w0.305: SITE5.2_F 146.18,208.74
  TOP w0.635: 146.18,208.74 140.98,208.74 v1(140.83,208.59)
  BOTTOM w0.635: v1(140.83,208.59) 139.83,207.59 136.82,207.59 UNK5C49.2
SL17_VI100_2_A_HS: length 7.8
  BOTTOM w0.203: v1(140.83,205.79) 141.97,205.79 144.92,208.74 v2(147.45,208.74)
SL17_VI100_2_B_HF: length 9.3
  TOP w0.305: SITE5.29_F 149.3,210.29 149.31,210.3 149.31,210.56 149.29,210.58 149.29,211 149.31,211.02 149.31,211.21 149.94,211.84
  TOP w0.635: 149.94,211.84 151.49,213.39 151.49,217.25 v1(152.25,218.02)
SL17_VI100_2_B_HS: length 14.3
  BOTTOM w0.203: v1(152.25,222.59) 151.38,221.72 151.38,213.02 149.21,210.84 149.21,209.68 v2(149.3,209.59)
SL17_VI100_3_A_HF: length 16.3
  TOP w0.305: SITE5.5_F 145.45,207.24
  TOP w0.635: 145.45,207.24 143.13,204.92 143.13,203.52 v1(140.83,201.22)
  BOTTOM w0.635: v1(135.11,201.22) 135.11,200.93 135.75,200.3 140.19,200.3 140.83,200.93 v1(140.83,201.22)
SL17_VI100_3_A_HS: length 13.4
  BOTTOM w0.203: v2(147.45,207.24) 146.97,207.24 142.62,202.89 137.13,202.89 v1(136.26,203.76)
SL17_VI100_3_B_HS: length 13
  BOTTOM w0.203: v1(149.12,193.35) 149.86,194.09 149.86,200.22 148.3,201.78 v2(148.3,205.39)
SL17_VI100_4_A_HS: length 8.3
  BOTTOM w0.203: v1(140.83,203.76) 141.84,203.76 145.82,207.74 v2(147.45,207.74)
SL17_VI100_4_B_HS: length 13.8
  BOTTOM w0.203: v2(151.65,205.74) 153.98,203.42 162.2,203.42 v1(163.84,201.77)
SL17_VI100_5_A_HF: length 23.1
  TOP w0.305: SITE5.6_F 146.47,206.74 146.18,206.45
  TOP w0.635: v1(144.16,198.18) 144.16,204.43 146.18,206.45
  BOTTOM w0.508: 144.39,193.35 UNK5K12.4
  BOTTOM w0.635: 145.18,193.35 144.39,193.35 ; 145.18,193.35 145.18,188.1 144.45,187.38 144.21,187.38 ; 145.18,193.35 145.18,197.54 144.54,198.18 v1(144.16,198.18)
SL17_VI100_5_A_HS:
  vias: v2(147.45,206.74)
SL17_VI100_6_A_HF:
  vias: v2(147.05,206.24)
SL17_VI100_6_A_HS:
  vias: v1(146.96,193.35) v2(147.45,206.24)
SL17_VI100_6_B_HF: length 1.7
  TOP w0.305: SITE5.30_F v2(148.8,211.66)
SL17_VI100_6_B_HS: length 4.5
  BOTTOM w0.203: v2(148.8,209.59) 148.8,211.01 149.84,212.05 UNK5K46.4
SL17_VI100_7_A_HF:
  vias: v2(149.8,204.99)
SL17_VI100_7_A_HS:
  vias: v1(154.07,193.35) v2(149.8,205.39)
SL17_VI100_7_B_HF: length 10.4
  TOP w0.305: 148.07,211.04 148.29,210.82 148.29,210.3 148.3,210.29 SITE5.31_F
  TOP w0.635: v1(149.84,219.54) 149.08,218.78 149.08,213.58 148.07,212.57 148.07,211.04
SL17_VI100_7_B_HS: length 15.2
  BOTTOM w0.203: v1(149.84,224.11) 149.05,223.33 149.05,212.6 148.3,211.84 v2(148.3,209.59)
SL17_VI100_8_B_HF: length 5.7
  TOP w0.305: 155.04,206.93 154.73,207.24 SITE5.20_F
  TOP w0.635: v1(156.03,205.94) 155.04,206.93
  BOTTOM w0.635: v1(156.03,205.94) UNK5C61.2
SL17_VI100_8_B_HS: length 17.5
  BOTTOM w0.203: v2(151.65,207.24) 154.53,207.24 154.7,207.06 166.93,207.06 v1(168.42,205.58)
SL17_VI100_9_B_HF: length 7.6
  TOP w0.305: SITE5.21_F 154.03,207.74 154.28,207.99
  TOP w0.635: v1(159.27,208.62) 158.64,207.99 154.28,207.99
SL17_VI100_9_B_HS: length 13.3
  BOTTOM w0.203: v1(163.84,208.62) 162.97,209.49 156.34,209.49 154.58,207.74 v2(151.65,207.74)
SL17_VI100_10_A_HF: length 9.6
  TOP w0.305: 151.98,204.74 151.55,204.74 SITE5.16_F
  TOP w0.635: 151.98,204.74 156.72,200.01 156.72,198.83 v1(157.37,198.18)
SL17_VI100_10_A_HS: length 15.2
  BOTTOM w0.203: v2(151.3,205.39) 151.3,205.13 155.83,200.6 155.83,194.51 156.08,194.25 157.17,194.25 157.37,194.05 v1(157.37,193.35)
SL17_VI100_10_B_HF: length 0.4
  TOP w0.305: SITE5.25_F v2(151.3,210.39)
SL17_VI100_10_B_HS: length 5.7
  BOTTOM w0.203: v1(155.17,212.18) 155.17,210.87 153.95,209.65 151.36,209.65 v2(151.3,209.59)
SL17_VI100_11_A_HF: length 7.2
  TOP w0.305: 153.62,205.67 153.05,206.24 SITE5.18_F
  TOP w0.635: 153.62,205.67 156.62,202.67 v1(157.73,202.67)
SL17_VI100_11_A_HS: length 18.6
  BOTTOM w0.203: v2(151.65,206.24) 151.97,206.24 154.31,203.91 166.28,203.91 v1(168.42,201.77)
SL17_VI100_11_B_HF: length 0.4
  TOP w0.305: SITE5.26_F v2(150.8,210.39)
SL17_VI100_11_B_HS: length 10.5
  BOTTOM w0.203: v2(150.8,209.59) 150.8,209.67 151.16,210.03 151.57,210.03 151.7,210.16 153.88,210.16 154.43,210.7 154.43,216 v1(155.17,216.75)
SL17_VI100_12_A_HF: length 8.2
  TOP w0.305: 154.31,206.19 154.13,206.19 153.59,206.74 SITE5.19_F
  TOP w0.635: 154.31,206.19 155.58,204.92 158.62,204.92 v1(159.27,205.58)
SL17_VI100_12_A_HS: length 12.7
  BOTTOM w0.203: v2(151.65,206.74) 154.27,206.74 154.43,206.58 162.84,206.58 v1(163.84,205.58)
SL17_VI100_12_B_HF: length 1.1
  TOP w0.305: v2(149.8,210.79) 150,210.79 150.3,210.49 SITE5.27_F
SL17_VI100_12_B_HS: length 15.4
  BOTTOM w0.152: 150.71,210.8 150.44,210.53 150.44,209.73 v2(150.3,209.59)
  BOTTOM w0.203: 150.71,210.8 153.5,210.8 154.03,211.32 154.03,216.17 154.05,216.2 154.05,220.2 v1(155.17,221.32)
SL17_VI100_13_A_HF: length 8.4
  TOP w0.305: 153.66,208.65 153.26,208.25 152.44,208.25 152.44,208.24 SITE5.22_F
  TOP w0.635: v1(157.73,208.86) 157.62,208.98 153.99,208.98 153.66,208.65
  BOTTOM w0.635: UNK5C64.2 156.03,208.22 156.67,208.86 v1(157.73,208.86)
SL17_VI100_13_A_HS: length 18.1
  BOTTOM w0.203: v2(151.65,208.24) 154.45,208.24 156.21,210 167.04,210 v1(168.42,208.62)
SL17_VI100_13_B_HF: length 0.4
  TOP w0.305: SITE5.32_F v2(147.8,210.39)
  vias: v1(147.43,224.11)
SL17_VI100_13_B_HS: length 9.9
  BOTTOM w0.203: v2(147.8,209.59) 147.8,209.86 147.33,210.33 147.33,211.45 148.59,212.71 148.59,215.84 147.43,217.01 v1(147.43,218.27)
SL17_VI100_14_A_HF: length 8.4
  TOP w0.305: SITE5.23_F 152.52,208.74 152.97,209.19
  TOP w0.635: 152.97,209.19 153.75,209.97 157.57,209.97 v1(159.27,211.67)
SL17_VI100_14_A_HS: length 14.9
  BOTTOM w0.203: v1(163.84,211.67) 162.85,212.67 157.43,212.67 157.12,212.36 157.12,211.23 156.59,210.7 156.27,210.7 154.31,208.74 v2(151.65,208.74)
SL17_VI100_14_B_HS: length 9.2
  BOTTOM w0.203: v1(154.07,198.18) 154.07,199.95 149.3,204.72 v2(149.3,205.39)
SL17_VI100_15_A_HF: length 10
  TOP w0.305: 152.28,209.81 152.05,209.58 SITE5.24_F
  TOP w0.635: 152.28,209.81 153.39,210.92 155.98,210.92 156.98,211.92 156.98,212.77 157.62,213.41 158.47,213.41 v1(159.27,214.21)
SL17_VI100_15_A_HS: length 17.3
  BOTTOM w0.203: v2(151.65,209.24) 154.18,209.24 156.08,211.15 156.46,211.15 156.72,211.4 156.72,215.08 156.97,215.34 162.72,215.34 v1(163.84,214.21)
SL17_VI100_15_B_HS: length 13.9
  BOTTOM w0.203: v2(148.8,205.39) 148.8,202.17 150.36,200.61 150.36,194.46 150.57,194.25 151.51,194.25 151.91,193.85 v1(151.91,193.35)
SL17_VI100_16_A_HF: length 0.4
  TOP w0.305: SITE5.28_F v2(149.8,210.39)
SL17_VI100_16_A_HS: length 4.1
  BOTTOM w0.152: v2(149.8,209.59) 149.8,209.74 150.14,210.08 150.14,210.86 150.25,210.97
  BOTTOM w0.203: v1(152.25,212.18) 151.28,211.2 150.49,211.2 150.25,210.97
SL17_VI100_16_B_HS: length 7.8
  BOTTOM w0.203: v2(147.8,205.39) 147.8,201.39 149.12,200.08 v1(149.12,198.18)
SL17_VI100_18_A_HF: length 11.5
  TOP w0.305: SITE7.2_F 226.18,208.74
  TOP w0.635: v1(220.83,208.59) 220.98,208.74 226.18,208.74
  BOTTOM w0.635: v1(220.83,208.59) 219.83,207.59 216.82,207.59 UNK7C49.2
SL17_VI100_18_A_HS: length 7.8
  BOTTOM w0.203: v2(227.45,208.74) 224.92,208.74 221.97,205.79 v1(220.83,205.79)
SL17_VI100_18_B_HF: length 9.3
  TOP w0.305: 229.94,211.84 229.31,211.21 229.31,211.02 229.29,211 229.29,210.58 229.31,210.56 229.31,210.3 229.3,210.29 SITE7.29_F
  TOP w0.635: v1(232.25,218.02) 231.49,217.25 231.49,213.39 229.94,211.84
SL17_VI100_18_B_HS: length 14.3
  BOTTOM w0.203: v1(232.25,222.59) 231.38,221.72 231.38,213.02 229.21,210.84 229.21,209.68 v2(229.3,209.59)
SL17_VI100_19_A_HF: length 16.3
  TOP w0.305: SITE7.5_F 225.45,207.24
  TOP w0.635: 225.45,207.24 223.13,204.92 223.13,203.52 v1(220.83,201.22)
  BOTTOM w0.635: v1(215.11,201.22) 215.11,200.93 215.75,200.3 220.19,200.3 220.83,200.93 v1(220.83,201.22)
SL17_VI100_19_A_HS: length 13.4
  BOTTOM w0.203: v1(216.26,203.76) 217.13,202.89 222.62,202.89 226.97,207.24 v2(227.45,207.24)
SL17_VI100_19_B_HS: length 13
  BOTTOM w0.203: v2(228.3,205.39) 228.3,201.78 229.86,200.22 229.86,194.09 v1(229.12,193.35)
SL17_VI100_20_A_HS: length 8.3
  BOTTOM w0.203: v2(227.45,207.74) 225.82,207.74 221.84,203.76 v1(220.83,203.76)
SL17_VI100_20_B_HS: length 13.8
  BOTTOM w0.203: v2(231.65,205.74) 233.97,203.42 242.19,203.42 v1(243.84,201.77)
SL17_VI100_21_A_HF: length 23.1
  TOP w0.305: 226.18,206.45 226.47,206.74 SITE7.6_F
  TOP w0.635: 226.18,206.45 224.16,204.43 v1(224.16,198.18)
  BOTTOM w0.508: 224.38,193.35 UNK7K12.4
  BOTTOM w0.635: 225.18,193.35 225.18,188.1 224.45,187.38 224.21,187.38 ; 225.18,193.35 224.38,193.35 ; 225.18,193.35 225.18,197.54 224.54,198.18 v1(224.16,198.18)
SL17_VI100_21_A_HS:
  vias: v2(227.45,206.74)
SL17_VI100_22_A_HF:
  vias: v2(227.05,206.24)
SL17_VI100_22_A_HS:
  vias: v1(226.96,193.35) v2(227.45,206.24)
SL17_VI100_22_B_HF: length 1.7
  TOP w0.305: SITE7.30_F v2(228.8,211.66)
SL17_VI100_22_B_HS: length 4.5
  BOTTOM w0.203: UNK7K46.4 229.84,212.05 228.8,211.01 v2(228.8,209.59)
SL17_VI100_23_A_HF:
  vias: v2(229.8,204.99)
