# Allegro board 980K2-260817_261120-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18727278: length 25.6
  BOTTOM w0.203: UNK6K15.6 178.34,186.04 178.34,188.58 181.35,191.59 181.35,198.83 183.32,200.79 183.32,201.61 v2(187.45,205.74)
N18727296: length 1.5
  BOTTOM w0.203: UNK6K5.1 177.77,208.59 UNK6RK5.1
N18727298: length 1.5
  BOTTOM w0.203: UNK6RK6.1 177.77,205.79 UNK6K6.1
N18727300: length 1.5
  BOTTOM w0.203: UNK6RK8.1 177.77,201.22 UNK6K8.1
N18727301: length 1.5
  BOTTOM w0.203: UNK6RK9.1 172.05,201.22 UNK6K9.1
N18727302: length 1.5
  BOTTOM w0.203: UNK6K10.1 173.2,203.76 UNK6RK10.1
N18727303: length 1.5
  BOTTOM w0.203: UNK6RK11.1 184.16,195.12 UNK6K11.1
N18727306: length 1.3
  BOTTOM w0.508: UNK6C58.1 UNK6K11.3
N18727309: length 1.5
  BOTTOM w0.203: UNK6K12.1 184.16,190.29 UNK6RK12.1
N18727311: length 1.5
  BOTTOM w0.203: UNK6K13.1 184.16,184.32 UNK6RK13.1
N18727314: length 1.5
  BOTTOM w0.203: UNK6K14.1 186.96,190.29 UNK6RK14.1
N18727316: length 3.4
  BOTTOM w0.203: UNK6RK2.1 182.47,223.73 182.87,223.32 UNK6K2.1
N18727317: length 1.9
  BOTTOM w0.203: UNK6K3.1 UNK6RK3.1
N18727318: length 2.4
  BOTTOM w0.203: UNK6K4.1 182.87,236.1 182.04,236.93 UNK6RK4.1
N18727338: length 27.9
  TOP w0.305: SITE6.8_F 186.71,205.4
  TOP w0.635: UNK6K15.3 175.29,186.19 175.29,187.82 175.89,188.41 177.92,188.41 185.16,195.65 185.16,203.85 186.71,205.4
N18727350: length 1.5
  BOTTOM w0.203: UNK6C60.1 UNK6K16.3
N18727363: length 1.5
  BOTTOM w0.203: UNK6K17.1 189.12,195.12 UNK6RK17.1
N18727377: length 1.5
  BOTTOM w0.203: UNK6K16.1 186.96,195.12 UNK6RK16.1
N18727381: length 1.5
  BOTTOM w0.203: UNK6K18.1 189.12,190.29 UNK6RK18.1
N18728531: length 1.5
  BOTTOM w0.203: UNK6C69.1 UNK6K19.3
N18728558: length 1.5
  BOTTOM w0.203: UNK6RK19.1 191.91,195.12 UNK6K19.1
N18728560: length 1.5
  BOTTOM w0.203: UNK6RK20.1 191.91,190.29 UNK6K20.1
N18728561: length 1.5
  BOTTOM w0.203: UNK6K21.1 194.07,195.12 UNK6RK21.1
N18728586: length 1.5
  BOTTOM w0.203: UNK6K22.1 194.07,190.29 UNK6RK22.1
N18728592: length 24.1
  BOTTOM w0.203: 194.38,184.3 193.24,185.44 193.24,187.49 194.81,189.07 194.81,199.97 190.3,204.48 v2(190.3,205.39)
N18728606: length 28.6
  BOTTOM w0.203: v2(190.8,205.39) 190.8,204.74 195.32,200.22 195.32,189.96 195.8,189.48 200.21,189.48 201.15,188.53 201.15,185.78 202.64,184.3
N18728616: length 1.5
  BOTTOM w0.203: UNK6C62.1 UNK6K25.3
N18728634: length 1.5
  BOTTOM w0.203: UNK6K25.1 197.37,195.12 UNK6RK25.1
N18728638: length 1.5
  BOTTOM w0.203: UNK6K26.1 197.37,190.29 UNK6RK26.1
N18728643: length 1.5
  BOTTOM w0.203: UNK6C63.1 UNK6K27.3
N18728659: length 1.5
  BOTTOM w0.203: UNK6K28.1 206.9,201.77 UNK6RK28.1
N18728680: length 1.5
  BOTTOM w0.203: UNK6RK27.1 202.33,201.77 UNK6K27.1
N18728682: length 1.1
  BOTTOM w0.203: UNK6RK29.1 UNK6K29.1
N18728687: length 1.5
  BOTTOM w0.203: UNK6C61.1 UNK6K30.3
N18728701: length 1.5
  BOTTOM w0.203: UNK6RK31.1 206.9,205.58 UNK6K31.1
N18728721: length 1.5
  BOTTOM w0.203: UNK6K30.1 202.33,205.58 UNK6RK30.1
N18728724: length 1.1
  BOTTOM w0.203: UNK6RK32.1 UNK6K32.1
N18728726: length 1.5
  BOTTOM w0.203: UNK6RK35.1 211.48,208.62 UNK6K35.1
N18728728: length 1.5
  BOTTOM w0.203: UNK6K34.1 206.9,208.62 UNK6RK34.1
N18728730: length 1.5
  BOTTOM w0.203: UNK6K33.1 202.33,208.62 UNK6RK33.1
N18728733: length 1.5
  BOTTOM w0.203: UNK6C64.1 UNK6K33.3
N18728768: length 1.5
  BOTTOM w0.203: UNK6RK37.1 206.9,211.67 UNK6K37.1
N18728769: length 1.5
  BOTTOM w0.203: UNK6K36.1 202.33,211.67 UNK6RK36.1
N18728775: length 1.5
  BOTTOM w0.203: UNK6C65.1 UNK6K36.3
N18730061: length 1.5
  BOTTOM w0.203: UNK6K39.1 206.9,214.21 UNK6RK39.1
N18730062: length 1.5
  BOTTOM w0.203: UNK6K38.1 202.33,214.21 UNK6RK38.1
N18730068: length 1.5
  BOTTOM w0.203: UNK6C74.1 UNK6K38.3
N18730087: length 1.5
  BOTTOM w0.203: UNK6RK40.1 195.17,215.24 UNK6K40.1
N18730100: length 1.5
  BOTTOM w0.203: UNK6RK41.1 195.17,219.81 UNK6K41.1
N18730113: length 1.5
  BOTTOM w0.203: UNK6K42.1 195.17,224.38 UNK6RK42.1
N18730125: length 1.5
  BOTTOM w0.203: UNK6RK43.1 192.25,215.24 UNK6K43.1
N18730138: length 1.5
  BOTTOM w0.203: UNK6K45.1 192.25,225.65 UNK6RK45.1
N18730139: length 1.5
  BOTTOM w0.203: UNK6RK44.1 192.25,221.08 UNK6K44.1
N18730149: length 1.5
  BOTTOM w0.203: UNK6C66.1 193.05,216.71 UNK6K44.3
N18730167: length 1.5
  BOTTOM w0.203: UNK6RK46.1 189.84,216.76 UNK6K46.1
N18730183: length 1.5
  BOTTOM w0.203: UNK6C67.1 190.64,218.23 UNK6K47.3
N18730196: length 1.5
  BOTTOM w0.203: UNK6K48.1 189.84,227.17 UNK6RK48.1
N18730197: length 1.5
  BOTTOM w0.203: UNK6K47.1 189.84,222.6 UNK6RK47.1
N18730207: length 1.5
  BOTTOM w0.203: UNK6C68.1 188.23,222.8 UNK6K49.3
N18730220: length 1.5
  BOTTOM w0.203: UNK6RK50.1 187.43,221.33 UNK6K50.1
N18730221: length 1.5
  BOTTOM w0.203: UNK6RK49.1 187.43,227.17 UNK6K49.1
N18731035: length 1.3
  BOTTOM w0.203: UNK6R7.2 188.32,184.45 UNK6K51.4
N18731047: length 1.3
  BOTTOM w0.203: UNK6R8.2 196.57,184.45 UNK6K53.4
N18731049: length 1.5
  BOTTOM w0.203: UNK6RK53.1 196.57,188.69 UNK6K53.1
N18731071: length 2.3
  BOTTOM w0.203: v1(166.61,234.24) UNK6R11.2 UNK6R19.1
N18731083: length 2.3
  BOTTOM w0.203: v1(173.22,234.24) UNK6R14.2 UNK6R20.1
N18731093: length 1.5
  BOTTOM w0.203: UNK6K55.1 161.26,231.95 UNK6RK59.1
N18731096: length 1.3
  BOTTOM w0.508: UNK6R19.2 UNK6K55.4
N18731098: length 3
  BOTTOM w0.305: UNK6RK60.1 UNK6K56.1
N18731115: length 3.4
  BOTTOM w0.203: UNK6TP_IN-_3.1 198.51,172.74 198.31,172.54 UNK6R16.1 197.41,171.32 UNK6U3.8
N18731116: length 3.4
  BOTTOM w0.203: UNK6U3.7 196.81,171.32 UNK6R16.2 195.89,172.54 195.68,172.74 UNK6TP_IN+_3.1
N18731144: length 3.4
  BOTTOM w0.203: UNK6U4.7 191.73,171.32 UNK6R18.2 190.81,172.54 190.6,172.74 UNK6TP_IN+_4.1
N18731148: length 3.4
  BOTTOM w0.203: UNK6TP_IN-_4.1 193.43,172.74 193.23,172.54 UNK6R18.1 192.33,171.32 UNK6U4.8
N18731159: length 7.5
  BOTTOM w0.508: UNK6K56.4 171.43,227.4 170.92,227.91 UNK6K61.4 UNK6R20.2
N18731160: length 1.5
  BOTTOM w0.203: UNK6RK54.1 197.37,178.99 UNK6K54.1
N18731164: length 1.5
  BOTTOM w0.203: UNK6K51.1 188.32,188.69 UNK6RK51.1
N18731166: length 1.5
  BOTTOM w0.203: UNK6RK52.1 189.12,178.99 UNK6K52.1
N18731230: length 1.5
  BOTTOM w0.203: UNK6RK55.2 197.71,176.76 UNK6K57.1
N18731231: length 1.5
  BOTTOM w0.203: UNK6RK56.2 195.68,176.76 UNK6K58.1
N18731232: length 1.5
  BOTTOM w0.203: UNK6K59.1 192.63,176.76 UNK6RK57.2
N18731233: length 1.5
  BOTTOM w0.203: UNK6K60.1 190.6,176.76 UNK6RK58.2
N18731236: length 1.5
  BOTTOM w0.203: UNK6K61.1 167.86,231.95 UNK6RK61.1
N18732367: length 2.2
  BOTTOM w0.635: UNK7C48.1 UNK7K2.3
N18732376: length 6.9
  BOTTOM w0.635: UNK7K3.3 216.91,214.45 216.27,213.81 UNK7C49.1
N18732385: length 1.5
  BOTTOM w0.508: UNK7C50.1 UNK7K5.3
N18732418: length 1.5
  BOTTOM w0.203: UNK7K7.1 217.77,203.76 UNK7RK7.1
N18732425: length 1.5
  BOTTOM w0.203: UNK7C53.1 222.14,202.02 UNK7K8.3
N18732434: length 1.5
  BOTTOM w0.203: UNK7K9.3 216.42,202.02 UNK7C54.1
N18732464: length 6.9
  BOTTOM w0.508: 222.67,193.35 UNK7K12.3
  BOTTOM w0.635: UNK7C59.1 220.59,189.17 222.22,190.8 222.22,192.9 222.67,193.35
N18732471: length 1.5
  BOTTOM w0.203: UNK7K13.3 223.36,188.69 UNK7R1.1
N18732489: length 25.6
  BOTTOM w0.203: v2(227.45,205.74) 223.32,201.61 223.32,200.79 221.35,198.83 221.35,191.59 218.34,188.58 218.34,186.04 UNK7K15.6
N18732507: length 1.5
  BOTTOM w0.203: UNK7K5.1 217.77,208.59 UNK7RK5.1
N18732509: length 1.5
  BOTTOM w0.203: UNK7K6.1 217.77,205.79 UNK7RK6.1
N18732511: length 1.5
  BOTTOM w0.203: UNK7RK8.1 217.77,201.22 UNK7K8.1
N18732512: length 1.5
  BOTTOM w0.203: UNK7K9.1 212.05,201.22 UNK7RK9.1
N18732513: length 1.5
  BOTTOM w0.203: UNK7K10.1 213.2,203.76 UNK7RK10.1
N18732514: length 1.5
  BOTTOM w0.203: UNK7K11.1 224.16,195.12 UNK7RK11.1
N18732517: length 1.3
  BOTTOM w0.508: UNK7C58.1 UNK7K11.3
N18732520: length 1.5
  BOTTOM w0.203: UNK7RK12.1 224.16,190.29 UNK7K12.1
N18732522: length 1.5
  BOTTOM w0.203: UNK7RK13.1 224.16,184.32 UNK7K13.1
N18732525: length 1.5
  BOTTOM w0.203: UNK7RK14.1 226.96,190.29 UNK7K14.1
N18732527: length 3.4
  BOTTOM w0.203: UNK7K2.1 222.87,223.32 222.47,223.73 UNK7RK2.1
N18732528: length 1.9
  BOTTOM w0.203: UNK7K3.1 UNK7RK3.1
N18732529: length 2.4
  BOTTOM w0.203: UNK7RK4.1 222.04,236.93 222.87,236.1 UNK7K4.1
N18732549: length 27.9
  TOP w0.305: SITE7.8_F 226.71,205.4
  TOP w0.635: 226.71,205.4 225.16,203.85 225.16,195.65 217.92,188.41 215.89,188.41 215.29,187.82 215.29,186.19 UNK7K15.3
N18732561: length 1.5
  BOTTOM w0.203: UNK7C60.1 UNK7K16.3
N18732574: length 1.5
  BOTTOM w0.203: UNK7RK17.1 229.12,195.12 UNK7K17.1
N18732588: length 1.5
  BOTTOM w0.203: UNK7RK16.1 226.96,195.12 UNK7K16.1
N18732592: length 1.5
  BOTTOM w0.203: UNK7K18.1 229.12,190.29 UNK7RK18.1
N18733742: length 1.5
  BOTTOM w0.203: UNK7C69.1 UNK7K19.3
N18733769: length 1.5
  BOTTOM w0.203: UNK7K19.1 231.91,195.12 UNK7RK19.1
N18733771: length 1.5
  BOTTOM w0.203: UNK7RK20.1 231.91,190.29 UNK7K20.1
N18733772: length 1.5
  BOTTOM w0.203: UNK7RK21.1 234.07,195.12 UNK7K21.1
N18733797: length 1.5
  BOTTOM w0.203: UNK7RK22.1 234.07,190.29 UNK7K22.1
N18733803: length 24.1
  BOTTOM w0.203: 234.38,184.3 233.24,185.44 233.24,187.49 234.81,189.07 234.81,199.97 230.3,204.48 v2(230.3,205.39)
N18733817: length 28.6
  BOTTOM w0.203: 242.64,184.3 241.15,185.78 241.15,188.53 240.21,189.48 235.8,189.48 235.32,189.96 235.32,200.22 230.8,204.74 v2(230.8,205.39)
N18733827: length 1.5
  BOTTOM w0.203: UNK7C62.1 UNK7K25.3
N18733845: length 1.5
  BOTTOM w0.203: UNK7RK25.1 237.37,195.12 UNK7K25.1
N18733849: length 1.5
  BOTTOM w0.203: UNK7RK26.1 237.37,190.29 UNK7K26.1
N18733854: length 1.5
  BOTTOM w0.203: UNK7C63.1 UNK7K27.3
N18733870: length 1.5
  BOTTOM w0.203: UNK7K28.1 246.9,201.77 UNK7RK28.1
N18733891: length 1.5
  BOTTOM w0.203: UNK7K27.1 242.33,201.77 UNK7RK27.1
N18733893: length 1.1
  BOTTOM w0.203: UNK7RK29.1 UNK7K29.1
N18733898: length 1.5
  BOTTOM w0.203: UNK7C61.1 UNK7K30.3
N18733912: length 1.5
  BOTTOM w0.203: UNK7RK31.1 246.9,205.58 UNK7K31.1
N18733932: length 1.5
  BOTTOM w0.203: UNK7RK30.1 242.33,205.58 UNK7K30.1
N18733935: length 1.1
  BOTTOM w0.203: UNK7RK32.1 UNK7K32.1
N18733937: length 1.5
  BOTTOM w0.203: UNK7RK35.1 251.48,208.62 UNK7K35.1
N18733939: length 1.5
  BOTTOM w0.203: UNK7RK34.1 246.9,208.62 UNK7K34.1
N18733941: length 1.5
  BOTTOM w0.203: UNK7K33.1 242.33,208.62 UNK7RK33.1
N18733944: length 1.5
  BOTTOM w0.203: UNK7C64.1 UNK7K33.3
N18733979: length 1.5
  BOTTOM w0.203: UNK7K37.1 246.9,211.67 UNK7RK37.1
N18733980: length 1.5
  BOTTOM w0.203: UNK7RK36.1 242.33,211.67 UNK7K36.1
N18733986: length 1.5
  BOTTOM w0.203: UNK7C65.1 UNK7K36.3
N18735272: length 1.5
  BOTTOM w0.203: UNK7K39.1 246.9,214.21 UNK7RK39.1
N18735273: length 1.5
  BOTTOM w0.203: UNK7K38.1 242.33,214.21 UNK7RK38.1
N18735279: length 1.5
  BOTTOM w0.203: UNK7C74.1 UNK7K38.3
N18735298: length 1.5
  BOTTOM w0.203: UNK7RK40.1 235.17,215.24 UNK7K40.1
N18735311: length 1.5
  BOTTOM w0.203: UNK7RK41.1 235.17,219.81 UNK7K41.1
N18735324: length 1.5
  BOTTOM w0.203: UNK7RK42.1 235.17,224.38 UNK7K42.1
N18735336: length 1.5
  BOTTOM w0.203: UNK7RK43.1 232.25,215.24 UNK7K43.1
N18735349: length 1.5
  BOTTOM w0.203: UNK7RK45.1 232.25,225.65 UNK7K45.1
N18735350: length 1.5
  BOTTOM w0.203: UNK7RK44.1 232.25,221.08 UNK7K44.1
N18735360: length 1.5
  BOTTOM w0.203: UNK7K44.3 233.05,216.71 UNK7C66.1
N18735378: length 1.5
  BOTTOM w0.203: UNK7K46.1 229.84,216.76 UNK7RK46.1
N18735394: length 1.5
  BOTTOM w0.203: UNK7C67.1 230.64,218.23 UNK7K47.3
N18735407: length 1.5
  BOTTOM w0.203: UNK7RK48.1 229.84,227.17 UNK7K48.1
N18735408: length 1.5
  BOTTOM w0.203: UNK7RK47.1 229.84,222.6 UNK7K47.1
N18735418: length 1.5
  BOTTOM w0.203: UNK7K49.3 228.23,222.8 UNK7C68.1
N18735431: length 1.5
  BOTTOM w0.203: UNK7K50.1 227.43,221.33 UNK7RK50.1
N18735432: length 1.5
  BOTTOM w0.203: UNK7K49.1 227.43,227.17 UNK7RK49.1
N18736246: length 1.3
  BOTTOM w0.203: UNK7K51.4 228.32,184.45 UNK7R7.2
N18736258: length 1.3
  BOTTOM w0.203: UNK7R8.2 236.57,184.45 UNK7K53.4
N18736260: length 1.5
  BOTTOM w0.203: UNK7RK53.1 236.57,188.69 UNK7K53.1
N18736282: length 2.3
  BOTTOM w0.203: UNK7R19.1 UNK7R11.2 v1(206.61,234.24)
N18736294: length 2.3
  BOTTOM w0.203: v1(213.21,234.24) UNK7R14.2 UNK7R20.1
N18736304: length 1.5
  BOTTOM w0.203: UNK7K55.1 201.26,231.95 UNK7RK59.1
N18736307: length 1.3
  BOTTOM w0.508: UNK7R19.2 UNK7K55.4
N18736309: length 3
  BOTTOM w0.305: UNK7RK60.1 UNK7K56.1
N18736326: length 3.4
  BOTTOM w0.203: UNK7U3.8 237.41,171.32 UNK7R16.1 238.31,172.54 238.51,172.74 UNK7TP_IN-_3.1
N18736327: length 3.4
  BOTTOM w0.203: UNK7U3.7 236.81,171.32 UNK7R16.2 235.89,172.54 235.68,172.74 UNK7TP_IN+_3.1
N18736355: length 3.4
  BOTTOM w0.203: UNK7U4.7 231.73,171.32 UNK7R18.2 230.81,172.54 230.6,172.74 UNK7TP_IN+_4.1
N18736359: length 3.4
  BOTTOM w0.203: UNK7TP_IN-_4.1 233.43,172.74 233.23,172.54 UNK7R18.1 232.33,171.32 UNK7U4.8
N18736370: length 7.5
  BOTTOM w0.508: UNK7R20.2 UNK7K61.4 210.92,227.91 211.43,227.4 UNK7K56.4
N18736371: length 1.5
  BOTTOM w0.203: UNK7RK54.1 237.37,178.99 UNK7K54.1
N18736375: length 1.5
  BOTTOM w0.203: UNK7RK51.1 228.32,188.69 UNK7K51.1
N18736377: length 1.5
  BOTTOM w0.203: UNK7RK52.1 229.12,178.99 UNK7K52.1
N18736441: length 1.5
  BOTTOM w0.203: UNK7K57.1 237.71,176.76 UNK7RK55.2
N18736442: length 1.5
  BOTTOM w0.203: UNK7K58.1 235.68,176.76 UNK7RK56.2
N18736443: length 1.5
  BOTTOM w0.203: UNK7K59.1 232.63,176.76 UNK7RK57.2
N18736444: length 1.5
  BOTTOM w0.203: UNK7RK58.2 230.6,176.76 UNK7K60.1
N18736447: length 1.5
  BOTTOM w0.203: UNK7K61.1 207.86,231.95 UNK7RK61.1
N18737578: length 2.2
  BOTTOM w0.635: UNK8C48.1 UNK8K2.3
N18737587: length 6.9
  BOTTOM w0.635: UNK8C49.1 256.27,213.81 256.91,214.45 UNK8K3.3
N18737596: length 1.5
  BOTTOM w0.508: UNK8C50.1 UNK8K5.3
N18737629: length 1.5
  BOTTOM w0.203: UNK8K7.1 257.77,203.76 UNK8RK7.1
N18737636: length 1.5
  BOTTOM w0.203: UNK8C53.1 262.14,202.02 UNK8K8.3
N18737645: length 1.5
  BOTTOM w0.203: UNK8K9.3 256.42,202.02 UNK8C54.1
N18737675: length 6.9
  BOTTOM w0.508: 262.67,193.35 UNK8K12.3
  BOTTOM w0.635: 262.67,193.35 262.22,192.9 262.22,190.8 260.59,189.17 UNK8C59.1
N18737682: length 1.5
  BOTTOM w0.203: UNK8K13.3 263.36,188.69 UNK8R1.1
N18737700: length 25.6
  BOTTOM w0.203: v2(267.45,205.74) 263.32,201.61 263.32,200.79 261.35,198.83 261.35,191.59 258.34,188.58 258.34,186.04 UNK8K15.6
N18737718: length 1.5
  BOTTOM w0.203: UNK8RK5.1 257.77,208.59 UNK8K5.1
N18737720: length 1.5
  BOTTOM w0.203: UNK8RK6.1 257.77,205.79 UNK8K6.1
N18737722: length 1.5
  BOTTOM w0.203: UNK8K8.1 257.77,201.22 UNK8RK8.1
N18737723: length 1.5
  BOTTOM w0.203: UNK8RK9.1 252.05,201.22 UNK8K9.1
N18737724: length 1.5
  BOTTOM w0.203: UNK8K10.1 253.2,203.76 UNK8RK10.1
N18737725: length 1.5
  BOTTOM w0.203: UNK8RK11.1 264.16,195.12 UNK8K11.1
N18737728: length 1.3
  BOTTOM w0.508: UNK8C58.1 UNK8K11.3
N18737731: length 1.5
  BOTTOM w0.203: UNK8RK12.1 264.16,190.29 UNK8K12.1
N18737733: length 1.5
  BOTTOM w0.203: UNK8RK13.1 264.16,184.32 UNK8K13.1
N18737736: length 1.5
  BOTTOM w0.203: UNK8K14.1 266.96,190.29 UNK8RK14.1
N18737738: length 3.4
  BOTTOM w0.203: UNK8RK2.1 262.47,223.73 262.87,223.32 UNK8K2.1
N18737739: length 1.9
  BOTTOM w0.203: UNK8K3.1 UNK8RK3.1
N18737740: length 2.4
  BOTTOM w0.203: UNK8K4.1 262.87,236.1 262.04,236.93 UNK8RK4.1
N18737760: length 27.9
  TOP w0.305: SITE8.8_F 266.71,205.4
  TOP w0.635: UNK8K15.3 255.29,186.19 255.29,187.82 255.89,188.41 257.92,188.41 265.16,195.65 265.16,203.85 266.71,205.4
N18737772: length 1.5
  BOTTOM w0.203: UNK8C60.1 UNK8K16.3
N18737785: length 1.5
  BOTTOM w0.203: UNK8K17.1 269.12,195.12 UNK8RK17.1
N18737799: length 1.5
  BOTTOM w0.203: UNK8RK16.1 266.96,195.12 UNK8K16.1
N18737803: length 1.5
  BOTTOM w0.203: UNK8K18.1 269.12,190.29 UNK8RK18.1
N18738953: length 1.5
  BOTTOM w0.203: UNK8C69.1 UNK8K19.3
N18738980: length 1.5
  BOTTOM w0.203: UNK8RK19.1 271.91,195.12 UNK8K19.1
N18738982: length 1.5
  BOTTOM w0.203: UNK8K20.1 271.91,190.29 UNK8RK20.1
N18738983: length 1.5
  BOTTOM w0.203: UNK8RK21.1 274.07,195.12 UNK8K21.1
N18739008: length 1.5
  BOTTOM w0.203: UNK8RK22.1 274.07,190.29 UNK8K22.1
N18739014: length 24.1
  BOTTOM w0.203: 274.38,184.3 273.24,185.44 273.24,187.49 274.81,189.07 274.81,199.97 270.3,204.48 v2(270.3,205.39)
N18739028: length 28.6
  BOTTOM w0.203: 282.64,184.3 281.15,185.78 281.15,188.53 280.21,189.48 275.8,189.48 275.32,189.96 275.32,200.22 270.8,204.74 v2(270.8,205.39)
N18739038: length 1.5
  BOTTOM w0.203: UNK8C62.1 UNK8K25.3
N18739056: length 1.5
  BOTTOM w0.203: UNK8RK25.1 277.37,195.12 UNK8K25.1
N18739060: length 1.5
  BOTTOM w0.203: UNK8RK26.1 277.37,190.29 UNK8K26.1
N18739065: length 1.5
  BOTTOM w0.203: UNK8C63.1 UNK8K27.3
N18739081: length 1.5
  BOTTOM w0.203: UNK8K28.1 286.9,201.77 UNK8RK28.1
N18739102: length 1.5
  BOTTOM w0.203: UNK8K27.1 282.33,201.77 UNK8RK27.1
N18739104: length 1.1
  BOTTOM w0.203: UNK8RK29.1 UNK8K29.1
N18739109: length 1.5
  BOTTOM w0.203: UNK8C61.1 UNK8K30.3
N18739123: length 1.5
  BOTTOM w0.203: UNK8RK31.1 286.9,205.58 UNK8K31.1
N18739143: length 1.5
  BOTTOM w0.203: UNK8K30.1 282.33,205.58 UNK8RK30.1
N18739146: length 1.1
  BOTTOM w0.203: UNK8RK32.1 UNK8K32.1
N18739148: length 1.5
  BOTTOM w0.203: UNK8K35.1 291.48,208.62 UNK8RK35.1
N18739150: length 1.5
  BOTTOM w0.203: UNK8RK34.1 286.9,208.62 UNK8K34.1
N18739152: length 1.5
  BOTTOM w0.203: UNK8RK33.1 282.33,208.62 UNK8K33.1
N18739155: length 1.5
  BOTTOM w0.203: UNK8C64.1 UNK8K33.3
N18739190: length 1.5
  BOTTOM w0.203: UNK8K37.1 286.9,211.67 UNK8RK37.1
N18739191: length 1.5
  BOTTOM w0.203: UNK8RK36.1 282.33,211.67 UNK8K36.1
N18739197: length 1.5
  BOTTOM w0.203: UNK8C65.1 UNK8K36.3
N18740483: length 1.5
  BOTTOM w0.203: UNK8RK39.1 286.9,214.21 UNK8K39.1
N18740484: length 1.5
  BOTTOM w0.203: UNK8RK38.1 282.33,214.21 UNK8K38.1
N18740490: length 1.5
  BOTTOM w0.203: UNK8C74.1 UNK8K38.3
N18740509: length 1.5
  BOTTOM w0.203: UNK8K40.1 275.17,215.24 UNK8RK40.1
N18740522: length 1.5
  BOTTOM w0.203: UNK8RK41.1 275.17,219.81 UNK8K41.1
N18740535: length 1.5
  BOTTOM w0.203: UNK8RK42.1 275.17,224.38 UNK8K42.1
N18740547: length 1.5
  BOTTOM w0.203: UNK8K43.1 272.25,215.24 UNK8RK43.1
N18740560: length 1.5
  BOTTOM w0.203: UNK8RK45.1 272.25,225.65 UNK8K45.1
N18740561: length 1.5
  BOTTOM w0.203: UNK8RK44.1 272.25,221.08 UNK8K44.1
N18740571: length 1.5
  BOTTOM w0.203: UNK8K44.3 273.05,216.71 UNK8C66.1
N18740589: length 1.5
  BOTTOM w0.203: UNK8RK46.1 269.84,216.76 UNK8K46.1
N18740605: length 1.5
  BOTTOM w0.203: UNK8C67.1 270.64,218.23 UNK8K47.3
N18740618: length 1.5
  BOTTOM w0.203: UNK8K48.1 269.84,227.17 UNK8RK48.1
N18740619: length 1.5
  BOTTOM w0.203: UNK8RK47.1 269.84,222.6 UNK8K47.1
N18740629: length 1.5
  BOTTOM w0.203: UNK8C68.1 268.23,222.8 UNK8K49.3
N18740642: length 1.5
  BOTTOM w0.203: UNK8RK50.1 267.43,221.33 UNK8K50.1
N18740643: length 1.5
  BOTTOM w0.203: UNK8K49.1 267.43,227.17 UNK8RK49.1
N18741457: length 1.3
  BOTTOM w0.203: UNK8K51.4 268.32,184.45 UNK8R7.2
N18741469: length 1.3
  BOTTOM w0.203: UNK8R8.2 276.57,184.45 UNK8K53.4
N18741471: length 1.5
  BOTTOM w0.203: UNK8RK53.1 276.57,188.69 UNK8K53.1
N18741493: length 2.3
  BOTTOM w0.203: UNK8R19.1 UNK8R11.2 v1(246.61,234.24)
N18741505: length 2.3
  BOTTOM w0.203: v1(253.21,234.24) UNK8R14.2 UNK8R20.1
N18741515: length 1.5
  BOTTOM w0.203: UNK8K55.1 241.26,231.95 UNK8RK59.1
N18741518: length 1.3
  BOTTOM w0.508: UNK8R19.2 UNK8K55.4
N18741520: length 3
  BOTTOM w0.305: UNK8RK60.1 UNK8K56.1
N18741537: length 3.4
  BOTTOM w0.203: UNK8U3.8 277.41,171.32 UNK8R16.1 278.31,172.54 278.51,172.74 UNK8TP_IN-_3.1
N18741538: length 3.4
  BOTTOM w0.203: UNK8TP_IN+_3.1 275.68,172.74 275.89,172.54 UNK8R16.2 276.81,171.32 UNK8U3.7
N18741566: length 3.4
  BOTTOM w0.203: UNK8TP_IN+_4.1 270.6,172.74 270.81,172.54 UNK8R18.2 271.73,171.32 UNK8U4.7
N18741570: length 3.4
  BOTTOM w0.203: UNK8U4.8 272.33,171.32 UNK8R18.1 273.23,172.54 273.43,172.74 UNK8TP_IN-_4.1
N18741581: length 7.5
  BOTTOM w0.508: UNK8K56.4 251.43,227.4 250.92,227.91 UNK8K61.4 UNK8R20.2
N18741582: length 1.5
  BOTTOM w0.203: UNK8RK54.1 277.37,178.99 UNK8K54.1
N18741586: length 1.5
  BOTTOM w0.203: UNK8RK51.1 268.32,188.69 UNK8K51.1
N18741588: length 1.5
  BOTTOM w0.203: UNK8K52.1 269.12,178.99 UNK8RK52.1
N18741652: length 1.5
  BOTTOM w0.203: UNK8RK55.2 277.71,176.76 UNK8K57.1
N18741653: length 1.5
  BOTTOM w0.203: UNK8RK56.2 275.68,176.76 UNK8K58.1
N18741654: length 1.5
  BOTTOM w0.203: UNK8K59.1 272.63,176.76 UNK8RK57.2
N18741655: length 1.5
  BOTTOM w0.203: UNK8RK58.2 270.6,176.76 UNK8K60.1
N18741658: length 1.5
  BOTTOM w0.203: UNK8RK61.1 247.86,231.95 UNK8K61.1

## Copper pours and planes (outline as drawn)
GND on L02_GND: 78.11,1.27 76.76,1.83 76.2,3.18 76.2,31.75 75.85,33.48 74.85,34.94 64.77,44.73 64.77,69.85 59.56,82.42 46.99,87.63 6.35,87.63 2.76,89.12 1.27,92.71 1.27,382.27 2.76,385.86 6.35,387.35 46.99,387.35 59.56,392.56 64.77,405.13 64.77,430.25 74.85,440.04 75.85,441.5 76.2,443.23 76.2,471.81 76.76,473.15 78.11,473.71 341,473.71 342.34,473.15 342.9,471.81 342.9,443.23 343.25,441.5 344.25,440.04 354.33,430.25 354.33,405.13 359.54,392.56 372.11,387.35 412.75,387.35 416.34,385.86 417.83,382.27 417.83,92.71 416.34,89.12 412.75,87.63 372.11,87.63 359.54,82.42 354.33,69.85 354.33,44.73 344.25,34.94 343.25,33.48 342.9,31.75 342.9,3.18 342.34,1.83 341,1.27
DUT1_GND on L02_GND: 120.27,295.27 120.27,286.64 128.91,278 128.91,269.88 129.54,269.24 131.96,269.24 132.47,268.73 132.47,265.56 131.32,264.41 131.32,258.58 128.91,256.16 128.91,241.94 132.84,238 138.68,238 139.19,238.51 146.18,238.51 146.69,238 163.32,238 164.97,239.65 164.97,254.38 171.07,260.48 171.07,265.94 172.34,267.21 172.34,268.61 171.83,269.11 169.29,269.11 168.66,269.75 168.66,277.88 147.45,299.09 124.08,299.09
DUT2_GND on L02_GND: 160.27,295.27 160.27,286.64 168.9,278 168.9,269.88 169.54,269.24 171.96,269.24 172.47,268.73 172.47,265.56 171.32,264.41 171.32,258.58 168.9,256.16 168.9,241.94 172.84,238 178.68,238 179.19,238.51 186.18,238.51 186.68,238 203.32,238 204.97,239.65 204.97,254.38 211.07,260.48 211.07,265.94 212.34,267.21 212.34,268.61 211.83,269.11 209.43,269.11 208.66,269.88 208.66,277.88 187.45,299.09 164.08,299.09
DUT3_GND on L02_GND: 200.27,295.27 200.27,286.64 208.9,278 208.9,269.88 209.54,269.24 211.96,269.24 212.47,268.73 212.47,265.56 211.32,264.41 211.32,258.58 208.9,256.16 208.9,241.94 212.84,238 218.68,238 219.19,238.51 226.18,238.51 226.68,238 243.32,238 244.97,239.65 244.97,254.38 251.07,260.48 251.07,265.94 252.34,267.21 252.34,268.61 251.84,269.11 249.31,269.11 248.66,269.76 248.66,277.88 227.45,299.09 204.08,299.09
DUT4_GND on L02_GND: 240.27,295.27 240.27,286.64 248.9,278 248.9,269.88 249.54,269.24 251.96,269.24 252.47,268.73 252.47,265.56 251.32,264.41 251.32,258.58 248.9,256.16 248.9,241.94 252.84,238 258.68,238 259.19,238.51 266.18,238.51 266.68,238 283.32,238 284.97,239.65 284.97,254.38 291.07,260.48 291.07,265.94 292.34,267.21 292.34,268.61 291.58,269.37 289.42,269.37 288.66,270.13 288.66,277.88 267.45,299.09 244.08,299.09
DUT5_GND on L02_GND: 120.27,235.28 120.27,226.64 128.91,218 128.91,209.88 129.54,209.24 131.96,209.24 132.47,208.73 132.47,205.56 131.32,204.41 131.32,198.58 128.91,196.16 128.91,181.94 132.84,178 138.68,178 139.19,178.51 146.18,178.51 146.69,178 163.32,178 164.97,179.65 164.97,194.38 171.07,200.48 171.07,205.94 172.34,207.21 172.34,208.61 171.78,209.17 169.29,209.17 168.69,209.77 168.69,210.09 168.66,210.13 168.66,217.88 149.17,237.36 146.69,237.36 145.67,238.38 140.59,238.38 139.83,237.62 130.12,237.62 128.65,239.09 124.08,239.09
DUT6_GND on L02_GND: 160.27,235.28 160.27,226.64 168.9,218 168.9,209.88 169.54,209.24 171.96,209.24 172.47,208.73 172.47,205.56 171.32,204.41 171.32,198.58 168.9,196.16 168.9,181.94 172.84,178 178.68,178 179.19,178.51 186.18,178.51 186.68,178 203.32,178 204.97,179.65 204.97,194.38 211.07,200.48 211.07,205.94 212.34,207.21 212.34,208.61 211.9,209.04 209.55,209.04 208.69,209.9 208.69,210.09 208.66,210.13 208.66,217.88 188.82,237.71 182.4,237.71 181.61,238.51 179.58,238.51 178.82,237.74 172.16,237.74 170.81,239.09 164.97,239.09 163.42,237.53 162.52,237.53
DUT7_GND on L02_GND: 200.27,235.28 200.27,226.64 208.9,218 208.9,209.88 209.54,209.24 211.96,209.24 212.47,208.73 212.47,205.56 211.32,204.41 211.32,198.58 208.9,196.16 208.9,181.94 212.84,178 218.68,178 219.19,178.51 226.18,178.51 226.68,178 243.32,178 244.97,179.65 244.97,194.38 251.07,200.48 251.07,205.94 252.34,207.21 252.34,208.61 251.77,209.17 249.43,209.17 248.7,209.9 248.7,210.09 248.66,210.13 248.66,217.88 228.88,237.65 222.22,237.65 221.36,238.51 219.71,238.51 218.95,237.74 212.29,237.74 210.95,239.09 205.18,239.09 203.75,237.66 202.65,237.66
DUT8_GND on L02_GND: 240.27,235.28 240.27,226.64 248.9,218 248.9,209.88 249.54,209.24 251.96,209.24 252.47,208.73 252.47,205.56 251.32,204.41 251.32,198.58 248.9,196.16 248.9,181.94 252.84,178 258.68,178 259.19,178.51 266.18,178.51 266.68,178 283.32,178 284.97,179.65 284.97,194.38 291.07,200.48 291.07,205.94 292.34,207.21 292.34,208.61 291.58,209.37 289.42,209.37 288.66,210.13 288.66,217.88 269.17,237.36 266.32,237.36 265.18,238.51 260.22,238.51 259.19,237.47 242.46,237.47
