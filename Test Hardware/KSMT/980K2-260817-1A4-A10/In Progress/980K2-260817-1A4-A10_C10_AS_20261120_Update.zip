# Allegro board 980K2-260817_261120-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CBIT_16:
  vias: v1(146.06,256.43) v1(146.06,196.43) v1(226.06,256.43) v1(226.06,196.43)
CBIT_17:
  vias: v1(148.22,256.43) v1(148.22,196.43) v1(228.22,256.43) v1(228.22,196.43)
CBIT_18:
  vias: v1(148.22,251.6) v1(148.22,191.6) v1(228.22,251.6) v1(228.22,191.6)
CBIT_19:
  vias: v1(151.01,256.43) v1(151.01,196.43) v1(231.01,256.43) v1(231.01,196.43)
CBIT_20:
  vias: v1(151.01,251.6) v1(151.01,191.6) v1(231.01,251.6) v1(231.01,191.6)
CBIT_21:
  vias: v1(153.17,256.43) v1(153.17,196.43) v1(233.17,256.43) v1(233.17,196.43)
CBIT_22:
  vias: v1(153.17,251.6) v1(153.17,191.6) v1(233.17,251.6) v1(233.17,191.6)
CBIT_25:
  vias: v1(156.47,256.43) v1(156.47,196.43) v1(236.47,256.43) v1(236.47,196.43)
CBIT_26:
  vias: v1(156.47,251.6) v1(156.47,191.6) v1(236.47,251.6) v1(236.47,191.6)
CBIT_27:
  vias: v1(161.02,260.87) v1(161.02,200.87) v1(241.02,260.87) v1(241.02,200.87)
CBIT_28:
  vias: v1(165.59,260.87) v1(165.59,200.87) v1(245.59,260.87) v1(245.59,200.87)
CBIT_29:
  vias: v1(170.17,260.87) v1(170.17,200.87) v1(250.17,260.87) v1(250.17,200.87)
CBIT_30:
  vias: v1(161.02,264.68) v1(161.02,204.68) v1(241.02,264.68) v1(241.02,204.68)
CBIT_31:
  vias: v1(165.59,264.68) v1(165.59,204.68) v1(245.59,264.68) v1(245.59,204.68)
CBIT_32:
  vias: v1(170.17,264.68) v1(170.17,204.68) v1(250.17,264.68) v1(250.17,204.68)
CBIT_33:
  vias: v1(161.02,267.72) v1(161.02,207.72) v1(241.02,267.72) v1(241.02,207.72)
CBIT_34:
  vias: v1(165.59,267.72) v1(165.59,207.72) v1(245.59,267.72) v1(245.59,207.72)
CBIT_35:
  vias: v1(170.17,267.72) v1(170.17,207.72) v1(250.17,267.72) v1(250.17,207.72)
CBIT_36:
  vias: v1(161.02,270.77) v1(161.02,210.77) v1(241.02,270.77) v1(241.02,210.77)
CBIT_37:
  vias: v1(165.59,270.77) v1(165.59,210.77) v1(245.59,270.77) v1(245.59,210.77)
CBIT_38:
  vias: v1(161.02,273.31) v1(161.02,213.31) v1(241.02,273.31) v1(241.02,213.31)
CBIT_39:
  vias: v1(165.59,273.31) v1(165.59,213.31) v1(245.59,273.31) v1(245.59,213.31)
CBIT_40:
  vias: v1(156.08,273.93) v1(156.08,213.93) v1(236.07,273.93) v1(236.07,213.93)
CBIT_41:
  vias: v1(156.08,278.5) v1(156.08,218.5) v1(236.07,278.5) v1(236.07,218.5)
CBIT_42:
  vias: v1(156.08,283.07) v1(156.08,223.07) v1(236.07,283.07) v1(236.07,223.07)
CBIT_43:
  vias: v1(153.15,273.93) v1(153.15,213.93) v1(233.15,273.93) v1(233.15,213.93)
CBIT_44:
  vias: v1(153.15,279.77) v1(153.15,219.77) v1(233.15,279.77) v1(233.15,219.77)
CBIT_45:
  vias: v1(153.15,284.34) v1(153.15,224.34) v1(233.15,284.34) v1(233.15,224.34)
CBIT_46:
  vias: v1(150.74,275.45) v1(150.74,215.45) v1(230.74,275.45) v1(230.74,215.45)
CBIT_47:
  vias: v1(150.74,281.29) v1(150.74,221.29) v1(230.74,281.29) v1(230.74,221.29)
CBIT_48:
  vias: v1(150.74,285.86) v1(150.74,225.86) v1(230.74,285.86) v1(230.74,225.86)
CBIT_49:
  vias: v1(148.33,285.86) v1(148.33,225.86) v1(228.33,285.86) v1(228.33,225.86)
CBIT_50:
  vias: v1(148.33,280.02) v1(148.33,220.02) v1(228.33,280.02) v1(228.33,220.02)
CBIT_51:
  vias: v1(149.22,247.38) v1(149.22,187.38) v1(229.22,247.38) v1(229.22,187.38)
CBIT_52:
  vias: v1(148.22,240.3) v1(148.22,180.3) v1(228.22,240.3) v1(228.22,180.3)
CBIT_53:
  vias: v1(157.47,247.38) v1(157.47,187.38) v1(237.47,247.38) v1(237.47,187.38)
CBIT_54:
  vias: v1(156.47,240.3) v1(156.47,180.3) v1(236.47,240.3) v1(236.47,180.3)
CBIT_55:
  vias: v1(122.57,292.85) v1(122.57,232.85) v1(202.57,292.85) v1(202.57,232.85)
CBIT_56:
  vias: v1(123.92,289.94) v1(123.92,229.94) v1(203.92,289.94) v1(203.92,229.94)
CBIT_57:
  vias: v1(158.52,235.44) v1(158.52,175.44) v1(238.51,235.44) v1(238.51,175.44)
CBIT_58:
  vias: v1(156.48,235.44) v1(156.48,175.44) v1(236.48,235.44) v1(236.48,175.44)
CBIT_59:
  vias: v1(153.44,235.44) v1(153.44,175.44) v1(233.43,235.44) v1(233.43,175.44)
CBIT_60:
  vias: v1(151.4,235.44) v1(151.4,175.44) v1(231.4,235.44) v1(231.4,175.44)
CBIT_62:
  vias: v1(185.41,281.97) v1(185.41,221.97) v1(265.41,281.97) v1(265.41,221.97)
CBIT_63:
  vias: v1(170.02,274.45) v1(170.02,214.45) v1(250.02,274.45) v1(250.02,214.45)
CBIT_64:
  vias: v1(185.41,295.94) v1(185.41,235.94) v1(265.41,295.94) v1(265.41,235.94)
CBIT_65:
  vias: v1(179.08,269.49) v1(179.08,209.49) v1(259.08,269.49) v1(259.08,209.49)
CBIT_66:
  vias: v1(179.08,266.69) v1(179.08,206.69) v1(259.08,266.69) v1(259.08,206.69)
CBIT_67:
  vias: v1(179.08,264.66) v1(179.08,204.66) v1(259.08,264.66) v1(259.08,204.66)
CBIT_68:
  vias: v1(179.08,262.12) v1(179.08,202.12) v1(259.08,262.12) v1(259.08,202.12)
CBIT_69:
  vias: v1(173.36,262.12) v1(173.36,202.12) v1(253.36,262.12) v1(253.36,202.12)
CBIT_70:
  vias: v1(174.51,264.66) v1(174.51,204.66) v1(254.51,264.66) v1(254.51,204.66)
CBIT_71:
  vias: v1(183.26,256.43) v1(183.26,196.43) v1(263.26,256.43) v1(263.26,196.43)
CBIT_72:
  vias: v1(183.26,251.6) v1(183.26,191.6) v1(263.26,251.6) v1(263.26,191.6)
CBIT_73:
  vias: v1(183.26,245.63) v1(183.26,185.63) v1(263.26,245.63) v1(263.26,185.63)
CBIT_74:
  vias: v1(186.06,251.6) v1(186.06,191.6) v1(266.06,251.6) v1(266.06,191.6)
CBIT_76:
  vias: v1(186.06,256.43) v1(186.06,196.43) v1(266.06,256.43) v1(266.06,196.43)
CBIT_77:
  vias: v1(188.22,256.43) v1(188.22,196.43) v1(268.22,256.43) v1(268.22,196.43)
CBIT_78:
  vias: v1(188.22,251.6) v1(188.22,191.6) v1(268.22,251.6) v1(268.22,191.6)
CBIT_79:
  vias: v1(191.01,256.43) v1(191.01,196.43) v1(271.01,256.43) v1(271.01,196.43)
CBIT_80:
  vias: v1(191.01,251.6) v1(191.01,191.6) v1(271.01,251.6) v1(271.01,191.6)
CBIT_81:
  vias: v1(193.17,256.43) v1(193.17,196.43) v1(273.17,256.43) v1(273.17,196.43)
CBIT_82:
  vias: v1(193.17,251.6) v1(193.17,191.6) v1(273.17,251.6) v1(273.17,191.6)
CBIT_85:
  vias: v1(196.47,256.43) v1(196.47,196.43) v1(276.47,256.43) v1(276.47,196.43)
CBIT_86:
  vias: v1(196.47,251.6) v1(196.47,191.6) v1(276.47,251.6) v1(276.47,191.6)
CBIT_87:
  vias: v1(201.02,260.87) v1(201.02,200.87) v1(281.02,260.87) v1(281.02,200.87)
CBIT_88:
  vias: v1(205.59,260.87) v1(205.59,200.87) v1(285.59,260.87) v1(285.59,200.87)
CBIT_89:
  vias: v1(210.17,260.87) v1(210.17,200.87) v1(290.17,260.87) v1(290.17,200.87)
CBIT_90:
  vias: v1(201.02,264.68) v1(201.02,204.68) v1(281.02,264.68) v1(281.02,204.68)
CBIT_91:
  vias: v1(205.59,264.68) v1(205.59,204.68) v1(285.59,264.68) v1(285.59,204.68)
CBIT_92:
  vias: v1(210.17,264.68) v1(210.17,204.68) v1(290.17,264.68) v1(290.17,204.68)
CBIT_93:
  vias: v1(201.02,267.72) v1(201.02,207.72) v1(281.02,267.72) v1(281.02,207.72)
CBIT_94:
  vias: v1(205.59,267.72) v1(205.59,207.72) v1(285.59,267.72) v1(285.59,207.72)
CBIT_95:
  vias: v1(210.17,267.72) v1(210.17,207.72) v1(290.17,267.72) v1(290.17,207.72)
CBIT_96:
  vias: v1(201.02,270.77) v1(201.02,210.77) v1(281.02,270.77) v1(281.02,210.77)
CBIT_97:
  vias: v1(205.59,270.77) v1(205.59,210.77) v1(285.59,270.77) v1(285.59,210.77)
CBIT_98:
  vias: v1(201.02,273.31) v1(201.02,213.31) v1(281.02,273.31) v1(281.02,213.31)
CBIT_99:
  vias: v1(205.59,273.31) v1(205.59,213.31) v1(285.59,273.31) v1(285.59,213.31)
CBIT_100:
  vias: v1(196.08,273.93) v1(196.08,213.93) v1(276.07,273.93) v1(276.07,213.93)
CBIT_101:
  vias: v1(196.08,278.5) v1(196.08,218.5) v1(276.07,278.5) v1(276.07,218.5)
CBIT_102:
  vias: v1(196.08,283.07) v1(196.08,223.07) v1(276.07,283.07) v1(276.07,223.07)
CBIT_103:
  vias: v1(193.15,273.93) v1(193.15,213.93) v1(273.15,273.93) v1(273.15,213.93)
CBIT_104:
  vias: v1(193.15,279.77) v1(193.15,219.77) v1(273.15,279.77) v1(273.15,219.77)
CBIT_105:
  vias: v1(193.15,284.34) v1(193.15,224.34) v1(273.15,284.34) v1(273.15,224.34)
CBIT_106:
  vias: v1(190.74,275.45) v1(190.74,215.45) v1(270.74,275.45) v1(270.74,215.45)
CBIT_107:
  vias: v1(190.74,281.29) v1(190.74,221.29) v1(270.74,281.29) v1(270.74,221.29)
CBIT_108:
  vias: v1(190.74,285.86) v1(190.74,225.86) v1(270.74,285.86) v1(270.74,225.86)
CBIT_109:
  vias: v1(188.33,285.86) v1(188.33,225.86) v1(268.33,285.86) v1(268.33,225.86)
CBIT_110:
  vias: v1(188.33,280.02) v1(188.33,220.02) v1(268.33,280.02) v1(268.33,220.02)
CBIT_111:
  vias: v1(189.22,247.38) v1(189.22,187.38) v1(269.22,247.38) v1(269.22,187.38)
CBIT_112:
  vias: v1(188.22,240.3) v1(188.22,180.3) v1(268.22,240.3) v1(268.22,180.3)
CBIT_113:
  vias: v1(197.47,247.38) v1(197.47,187.38) v1(277.47,247.38) v1(277.47,187.38)
CBIT_114:
  vias: v1(196.47,240.3) v1(196.47,180.3) v1(276.47,240.3) v1(276.47,180.3)
CBIT_115:
  vias: v1(162.57,292.85) v1(162.57,232.85) v1(242.57,292.85) v1(242.57,232.85)
CBIT_116:
  vias: v1(163.92,289.94) v1(163.92,229.94) v1(243.92,289.94) v1(243.92,229.94)
CBIT_117:
  vias: v1(198.51,235.44) v1(198.51,175.44) v1(278.51,235.44) v1(278.51,175.44)
CBIT_118:
  vias: v1(196.48,235.44) v1(196.48,175.44) v1(276.48,235.44) v1(276.48,175.44)
CBIT_119:
  vias: v1(193.43,235.44) v1(193.43,175.44) v1(273.43,235.44) v1(273.43,175.44)
CBIT_120:
  vias: v1(191.4,235.44) v1(191.4,175.44) v1(271.4,235.44) v1(271.4,175.44)
CBIT_127:
  vias: v1(129.17,292.85) v1(129.17,232.85) v1(209.17,292.85) v1(209.17,232.85)
CBIT_128:
  vias: v1(169.17,292.85) v1(169.17,232.85) v1(249.17,292.85) v1(249.17,232.85)
DUT1_GND: length 7.8
  BOTTOM w0.203: 125.61,292.84 v1(125.61,292.85)
  BOTTOM w0.305: R14.1 132.21,294.59 132.52,294.89 U2.2 ; U1.2 125.92,294.89 125.61,294.59 R11.1
  BOTTOM w0.381: R14.1 v1(132.21,292.85) ; U4.4 v1(149.73,228.7) ; v1(125.61,292.85) R11.1 ; U3.4 v1(155.49,227.33)
  vias: v1(122.3,294.89) v1(128.92,294.89) v1(136.53,261.22) v1(140.36,245.44) v1(140.36,244.98) v1(140.36,244.53) v1(140.82,245.44) v1(140.82,244.98) v1(140.82,244.53) v1(142.11,257.18) v1(142.28,267.69) v1(142.24,261.22) v1(144.26,248.79) v1(147.33,282.7) v1(147.43,274.72) v1(148.22,242.05) v1(149.84,278.13) v1(152.25,276.61) v1(154.17,227.33) v1(156.47,242.05) v1(157.57,259.72) v1(157.73,274.41) v1(157.73,271.87) v1(159.25,227.33) v2(147.05,268.24) v2(147.45,268.24)
DUT2_GND: length 7.8
  BOTTOM w0.203: 165.61,292.84 v1(165.61,292.85)
  BOTTOM w0.305: UNK2U1.2 165.92,294.89 165.61,294.59 UNK2R11.1 ; UNK2U2.2 172.52,294.89 172.21,294.59 UNK2R14.1
  BOTTOM w0.381: v1(165.61,292.85) UNK2R11.1 ; UNK2U3.4 v1(195.49,227.33) ; UNK2U4.4 v1(189.73,228.7) ; UNK2R14.1 v1(172.21,292.85)
  vias: v1(162.3,294.89) v1(168.92,294.89) v1(176.52,261.22) v1(180.36,245.44) v1(180.36,244.98) v1(180.36,244.53) v1(180.82,245.44) v1(180.82,244.98) v1(180.82,244.53) v1(182.11,257.18) v1(182.28,267.69) v1(182.24,261.22) v1(184.26,248.79) v1(187.33,282.7) v1(187.43,274.72) v1(188.22,242.05) v1(189.84,278.13) v1(192.25,276.61) v1(194.17,227.33) v1(196.47,242.05) v1(197.57,259.72) v1(197.73,274.41) v1(197.73,271.87) v1(199.25,227.33) v2(187.05,268.24) v2(187.45,268.24)
DUT3_GND: length 7.8
  BOTTOM w0.203: 205.61,292.84 v1(205.61,292.85)
  BOTTOM w0.305: UNK3U2.2 212.52,294.89 212.21,294.59 UNK3R14.1 ; UNK3U1.2 205.92,294.89 205.61,294.59 UNK3R11.1
  BOTTOM w0.381: UNK3U4.4 v1(229.73,228.7) ; UNK3R14.1 v1(212.21,292.85) ; v1(205.61,292.85) UNK3R11.1 ; UNK3U3.4 v1(235.49,227.33)
  vias: v1(202.3,294.89) v1(208.92,294.89) v1(216.52,261.22) v1(220.36,245.44) v1(220.36,244.98) v1(220.36,244.53) v1(220.82,245.44) v1(220.82,244.98) v1(220.82,244.53) v1(222.11,257.18) v1(222.28,267.69) v1(222.24,261.22) v1(224.26,248.79) v1(227.33,282.7) v1(227.43,274.72) v1(228.22,242.05) v1(229.84,278.13) v1(232.25,276.61) v1(234.17,227.33) v1(236.47,242.05) v1(237.57,259.72) v1(237.73,274.41) v1(237.73,271.87) v1(239.25,227.33) v2(227.05,268.24) v2(227.45,268.24)
DUT4_GND: length 7.8
  BOTTOM w0.203: 245.61,292.84 v1(245.61,292.85)
  BOTTOM w0.305: UNK4U1.2 245.92,294.89 245.61,294.59 UNK4R11.1 ; UNK4U2.2 252.52,294.89 252.21,294.59 UNK4R14.1
  BOTTOM w0.381: UNK4U4.4 v1(269.73,228.7) ; UNK4R14.1 v1(252.21,292.85) ; UNK4U3.4 v1(275.49,227.33) ; v1(245.61,292.85) UNK4R11.1
  vias: v1(242.3,294.89) v1(248.92,294.89) v1(256.52,261.22) v1(260.36,245.44) v1(260.36,244.98) v1(260.36,244.53) v1(260.82,245.44) v1(260.82,244.98) v1(260.82,244.53) v1(262.11,257.18) v1(262.28,267.69) v1(262.24,261.22) v1(264.26,248.79) v1(267.33,282.7) v1(267.43,274.72) v1(268.22,242.05) v1(269.84,278.13) v1(272.25,276.61) v1(274.17,227.33) v1(276.47,242.05) v1(277.57,259.72) v1(277.73,274.41) v1(277.73,271.87) v1(279.25,227.33) v2(267.05,268.24) v2(267.45,268.24)
DUT5_GND: length 7.8
  BOTTOM w0.203: 125.61,232.84 v1(125.61,232.85)
  BOTTOM w0.305: UNK5R14.1 132.21,234.59 132.52,234.89 UNK5U2.2 ; UNK5U1.2 125.92,234.89 125.61,234.59 UNK5R11.1
  BOTTOM w0.381: UNK5U4.4 v1(149.73,168.7) ; UNK5R14.1 v1(132.21,232.85) ; UNK5U3.4 v1(155.49,167.33) ; v1(125.61,232.85) UNK5R11.1
  vias: v1(122.3,234.89) v1(128.92,234.89) v1(136.53,201.22) v1(140.36,185.44) v1(140.36,184.98) v1(140.36,184.53) v1(140.82,185.44) v1(140.82,184.98) v1(140.82,184.53) v1(142.11,197.18) v1(142.28,207.69) v1(142.24,201.22) v1(144.26,188.79) v1(147.33,222.7) v1(147.43,214.72) v1(148.22,182.05) v1(149.84,218.13) v1(152.25,216.61) v1(154.17,167.33) v1(156.47,182.05) v1(157.57,199.72) v1(157.73,214.41) v1(157.73,211.87) v1(159.25,167.33) v2(147.05,208.24) v2(147.45,208.24)
DUT6_GND: length 7.8
  BOTTOM w0.203: 165.61,232.84 v1(165.61,232.85)
  BOTTOM w0.305: UNK6U1.2 165.92,234.89 165.61,234.59 UNK6R11.1 ; UNK6R14.1 172.21,234.59 172.52,234.89 UNK6U2.2
  BOTTOM w0.381: v1(165.61,232.85) UNK6R11.1 ; UNK6R14.1 v1(172.21,232.85) ; UNK6U3.4 v1(195.49,167.33) ; UNK6U4.4 v1(189.73,168.7)
  vias: v1(162.3,234.89) v1(168.92,234.89) v1(176.52,201.22) v1(180.36,185.44) v1(180.36,184.98) v1(180.36,184.53) v1(180.82,185.44) v1(180.82,184.98) v1(180.82,184.53) v1(182.11,197.18) v1(182.28,207.69) v1(182.24,201.22) v1(184.26,188.79) v1(187.33,222.7) v1(187.43,214.72) v1(188.22,182.05) v1(189.84,218.13) v1(192.25,216.61) v1(194.17,167.33) v1(196.47,182.05) v1(197.57,199.72) v1(197.73,214.41) v1(197.73,211.87) v1(199.25,167.33) v2(187.05,208.24) v2(187.45,208.24)
DUT7_GND: length 7.8
  BOTTOM w0.203: 205.61,232.84 v1(205.61,232.85)
  BOTTOM w0.305: UNK7R11.1 205.61,234.59 205.92,234.89 UNK7U1.2 ; UNK7R14.1 212.21,234.59 212.52,234.89 UNK7U2.2
  BOTTOM w0.381: UNK7U3.4 v1(235.49,167.33) ; UNK7R14.1 v1(212.21,232.85) ; UNK7U4.4 v1(229.73,168.7) ; v1(205.61,232.85) UNK7R11.1
  vias: v1(202.3,234.89) v1(208.92,234.89) v1(216.52,201.22) v1(220.36,185.44) v1(220.36,184.98) v1(220.36,184.53) v1(220.82,185.44) v1(220.82,184.98) v1(220.82,184.53) v1(222.11,197.18) v1(222.28,207.69) v1(222.24,201.22) v1(224.26,188.79) v1(227.33,222.7) v1(227.43,214.72) v1(228.22,182.05) v1(229.84,218.13) v1(232.25,216.61) v1(234.17,167.33) v1(236.47,182.05) v1(237.57,199.72) v1(237.73,214.41) v1(237.73,211.87) v1(239.25,167.33) v2(227.05,208.24) v2(227.45,208.24)
DUT8_GND: length 7.8
  BOTTOM w0.203: 245.61,232.84 v1(245.61,232.85)
  BOTTOM w0.305: UNK8U2.2 252.52,234.89 252.21,234.59 UNK8R14.1 ; UNK8R11.1 245.61,234.59 245.92,234.89 UNK8U1.2
  BOTTOM w0.381: UNK8U3.4 v1(275.49,167.33) ; UNK8R14.1 v1(252.21,232.85) ; UNK8U4.4 v1(269.73,168.7) ; v1(245.61,232.85) UNK8R11.1
  vias: v1(242.3,234.89) v1(248.92,234.89) v1(256.52,201.22) v1(260.36,185.44) v1(260.36,184.98) v1(260.36,184.53) v1(260.82,185.44) v1(260.82,184.98) v1(260.82,184.53) v1(262.11,197.18) v1(262.28,207.69) v1(262.24,201.22) v1(264.26,188.79) v1(267.33,222.7) v1(267.43,214.72) v1(268.22,182.05) v1(269.84,218.13) v1(272.25,216.61) v1(274.17,167.33) v1(276.47,182.05) v1(277.57,199.72) v1(277.73,214.41) v1(277.73,211.87) v1(279.25,167.33) v2(267.05,208.24) v2(267.45,208.24)
S1_C1B_F: length 8.9
  TOP w0.305: 152.36,265.43 SITE1.17_F
  TOP w0.635: v1(159.27,261.77) 156.32,261.77 152.65,265.43 152.36,265.43
  vias: v1(130.92,292.85)
S1_IS1N_F: length 7
  TOP w0.305: SITE1.12_F 149.35,264.94 149.35,263.53 149.61,263.28
  TOP w0.635: v1(153.17,259.72) 152.91,259.72 149.61,263.02 149.61,263.28
  vias: v1(157.71,233.69)
S1_IS1P_F: length 8.2
  TOP w0.305: 148.66,263.21 148.8,263.35 SITE1.11_F
  TOP w0.635: v1(151.91,258.18) 151.91,259.06 148.66,262.31 148.66,263.21
  vias: v1(156.48,233.69)
S1_IS2N_F: length 5.8
  TOP w0.305: 148.08,264.03 148.08,264.29 148.3,264.51 SITE1.10_F
  TOP w0.635: v1(148.22,259.72) 147.57,260.36 147.57,263.53 148.08,264.03
  vias: v1(152.63,233.69)
S1_IS2P_F: length 7.5
  TOP w0.305: 147.57,264.76 SITE1.9_F
  TOP w0.635: v1(146.96,258.18) 146.56,258.58 146.56,263.75 147.57,264.76
  vias: v1(151.4,233.69)
S1_SCL_F: length 30.3
  TOP w0.305: SITE1.15_F 150.8,264.74 151.64,263.91
  TOP w0.635: 151.64,263.91 155.72,259.82 155.72,247.28 158.71,244.3 159.44,244.3
  BOTTOM w0.559: 157.37,244.55 K54.4 ; 157.37,244.55 K24.3 ; 157.37,244.55 K53.3
S1_SDA_F: length 29.7
  TOP w0.305: 150.56,263.59 150.3,263.85 SITE1.14_F
  TOP w0.635: 151.18,244.3 152.78,245.9 152.78,247.71 154.82,249.75 154.82,259.33 150.56,263.59
  BOTTOM w0.559: 149.12,244.55 K51.3 ; 149.12,244.55 K52.4 ; 149.12,244.55 K23.3
S1_SRD_F: length 15.1
  BOTTOM w0.305: v2(147.05,269.24) 146.56,269.73
  BOTTOM w0.635: 146.56,269.73 145.4,270.89 145,270.89 v2(142.88,273.02) 140.08,273.02 v2(138.97,271.91) ; K56.3 134.34,289.94 K1.3
S1_SRD_S: length 27.2
  TOP w0.203: v1(142.88,286.99) 141.76,285.88 141.76,275.53 147.45,269.84 SITE1.1_S
  BOTTOM w0.203: v1(142.88,286.99) 142.88,289.59 K1.6
S1_SRG_F: length 0.7
  TOP w0.305: SITE1.4_F 146.95,267.74 146.65,268.04 v2(146.65,268.24)
  vias: v1(124.32,292.85)
S2_C1B_F: length 8.9
  TOP w0.305: 192.36,265.43 SITE2.17_F
  TOP w0.635: 192.36,265.43 192.65,265.43 196.32,261.77 v1(199.27,261.77)
  vias: v1(170.92,292.85)
S2_IS1N_F: length 7
  TOP w0.305: 189.61,263.28 189.35,263.53 189.35,264.94 SITE2.12_F
  TOP w0.635: 189.61,263.28 189.61,263.02 192.91,259.72 v1(193.17,259.72)
  vias: v1(197.71,233.69)
S2_IS1P_F: length 8.2
  TOP w0.305: 188.66,263.21 188.8,263.35 SITE2.11_F
  TOP w0.635: v1(191.91,258.18) 191.91,259.06 188.66,262.31 188.66,263.21
  vias: v1(196.48,233.69)
S2_IS2N_F: length 5.8
  TOP w0.305: 188.08,264.03 188.08,264.29 188.3,264.51 SITE2.10_F
  TOP w0.635: 188.08,264.03 187.57,263.53 187.57,260.36 v1(188.22,259.72)
  vias: v1(192.63,233.69)
S2_IS2P_F: length 7.5
  TOP w0.305: 187.57,264.76 SITE2.9_F
  TOP w0.635: 187.57,264.76 186.56,263.75 186.56,258.58 v1(186.96,258.18)
  vias: v1(191.4,233.69)
S2_SCL_F: length 30.3
  TOP w0.305: 191.64,263.91 190.8,264.74 SITE2.15_F
  TOP w0.635: 191.64,263.91 195.72,259.82 195.72,247.28 198.71,244.3 199.44,244.3
  BOTTOM w0.559: 197.37,244.55 UNK2K54.4 ; 197.37,244.55 UNK2K53.3 ; 197.37,244.55 UNK2K24.3
S2_SDA_F: length 29.7
  TOP w0.305: SITE2.14_F 190.3,263.85 190.56,263.59
  TOP w0.635: 191.18,244.3 192.78,245.9 192.78,247.71 194.82,249.75 194.82,259.33 190.56,263.59
  BOTTOM w0.559: 189.12,244.55 UNK2K51.3 ; 189.12,244.55 UNK2K23.3 ; 189.12,244.55 UNK2K52.4
S2_SRD_F: length 15.1
  BOTTOM w0.305: v2(187.05,269.24) 186.56,269.73
  BOTTOM w0.635: UNK2K56.3 174.34,289.94 UNK2K1.3 ; v2(178.97,271.91) 180.08,273.02 v2(182.87,273.02) 185,270.89 185.4,270.89 186.56,269.73
S2_SRD_S: length 27.2
  TOP w0.203: SITE2.1_S 187.45,269.84 181.76,275.53 181.76,285.88 v1(182.87,286.99)
  BOTTOM w0.203: v1(182.87,286.99) 182.87,289.59 UNK2K1.6
S2_SRG_F: length 0.7
  TOP w0.305: v2(186.65,268.24) 186.65,268.04 186.95,267.74 SITE2.4_F
  vias: v1(164.32,292.85)
S3_C1B_F: length 8.9
  TOP w0.305: 232.36,265.43 SITE3.17_F
  TOP w0.635: v1(239.27,261.77) 236.32,261.77 232.65,265.43 232.36,265.43
  vias: v1(210.92,292.85)
S3_IS1N_F: length 7
  TOP w0.305: 229.61,263.28 229.35,263.53 229.35,264.94 SITE3.12_F
  TOP w0.635: v1(233.17,259.72) 232.91,259.72 229.61,263.02 229.61,263.28
  vias: v1(237.71,233.69)
S3_IS1P_F: length 8.2
  TOP w0.305: SITE3.11_F 228.8,263.35 228.66,263.21
  TOP w0.635: 228.66,263.21 228.66,262.31 231.91,259.06 v1(231.91,258.18)
  vias: v1(236.48,233.69)
S3_IS2N_F: length 5.8
  TOP w0.305: 228.08,264.03 228.08,264.29 228.3,264.51 SITE3.10_F
  TOP w0.635: v1(228.22,259.72) 227.57,260.36 227.57,263.53 228.08,264.03
  vias: v1(232.63,233.69)
S3_IS2P_F: length 7.5
  TOP w0.305: 227.57,264.76 SITE3.9_F
  TOP w0.635: v1(226.96,258.18) 226.56,258.58 226.56,263.75 227.57,264.76
  vias: v1(231.4,233.69)
S3_SCL_F: length 30.3
  TOP w0.305: 231.64,263.91 230.8,264.74 SITE3.15_F
  TOP w0.635: 231.64,263.91 235.72,259.82 235.72,247.28 238.71,244.3 239.44,244.3
  BOTTOM w0.559: UNK3K24.3 237.37,244.55 ; 237.37,244.55 UNK3K53.3 ; 237.37,244.55 UNK3K54.4
S3_SDA_F: length 29.7
  TOP w0.305: 230.56,263.59 230.3,263.85 SITE3.14_F
  TOP w0.635: 230.56,263.59 234.82,259.33 234.82,249.75 232.78,247.71 232.78,245.9 231.18,244.3
  BOTTOM w0.559: UNK3K52.4 229.12,244.55 ; 229.12,244.55 UNK3K51.3 ; 229.12,244.55 UNK3K23.3
S3_SRD_F: length 15.1
  BOTTOM w0.305: v2(227.05,269.24) 226.56,269.73
  BOTTOM w0.635: UNK3K1.3 214.34,289.94 UNK3K56.3 ; v2(218.97,271.91) 220.08,273.02 v2(222.87,273.02) 225,270.89 225.4,270.89 226.56,269.73
S3_SRD_S: length 27.2
  TOP w0.203: v1(222.87,286.99) 221.76,285.88 221.76,275.53 227.45,269.84 SITE3.1_S
  BOTTOM w0.203: UNK3K1.6 222.87,289.59 v1(222.87,286.99)
S3_SRG_F: length 0.7
  TOP w0.305: SITE3.4_F 226.95,267.74 226.65,268.04 v2(226.65,268.24)
  vias: v1(204.32,292.85)
S4_C1B_F: length 8.9
  TOP w0.305: 272.36,265.43 SITE4.17_F
  TOP w0.635: v1(279.27,261.77) 276.32,261.77 272.65,265.43 272.36,265.43
  vias: v1(250.92,292.85)
S4_IS1N_F: length 7
  TOP w0.305: 269.61,263.28 269.35,263.53 269.35,264.94 SITE4.12_F
  TOP w0.635: v1(273.17,259.72) 272.91,259.72 269.61,263.02 269.61,263.28
  vias: v1(277.71,233.69)
S4_IS1P_F: length 8.2
  TOP w0.305: SITE4.11_F 268.8,263.35 268.66,263.21
  TOP w0.635: v1(271.91,258.18) 271.91,259.06 268.66,262.31 268.66,263.21
  vias: v1(276.48,233.69)
S4_IS2N_F: length 5.8
  TOP w0.305: 268.08,264.03 268.08,264.29 268.3,264.51 SITE4.10_F
  TOP w0.635: v1(268.22,259.72) 267.57,260.36 267.57,263.53 268.08,264.03
  vias: v1(272.63,233.69)
S4_IS2P_F: length 7.5
  TOP w0.305: 267.57,264.76 SITE4.9_F
  TOP w0.635: 267.57,264.76 266.56,263.75 266.56,258.58 v1(266.96,258.18)
  vias: v1(271.4,233.69)
S4_SCL_F: length 30.3
  TOP w0.305: 271.64,263.91 270.8,264.74 SITE4.15_F
  TOP w0.635: 279.44,244.3 278.71,244.3 275.72,247.28 275.72,259.82 271.64,263.91
  BOTTOM w0.559: 277.37,244.55 UNK4K54.4 ; 277.37,244.55 UNK4K53.3 ; 277.37,244.55 UNK4K24.3
S4_SDA_F: length 29.7
  TOP w0.305: SITE4.14_F 270.3,263.85 270.56,263.59
  TOP w0.635: 271.18,244.3 272.78,245.9 272.78,247.71 274.82,249.75 274.82,259.33 270.56,263.59
  BOTTOM w0.559: UNK4K52.4 269.12,244.55 ; 269.12,244.55 UNK4K23.3 ; 269.12,244.55 UNK4K51.3
S4_SRD_F: length 15.1
  BOTTOM w0.305: v2(267.05,269.24) 266.56,269.73
  BOTTOM w0.635: 266.56,269.73 265.4,270.89 265,270.89 v2(262.87,273.02) 260.08,273.02 v2(258.97,271.91) ; UNK4K56.3 254.34,289.94 UNK4K1.3
S4_SRD_S: length 27.2
  TOP w0.203: v1(262.87,286.99) 261.76,285.88 261.76,275.53 267.45,269.84 SITE4.1_S
  BOTTOM w0.203: UNK4K1.6 262.87,289.59 v1(262.87,286.99)
S4_SRG_F: length 0.7
  TOP w0.305: v2(266.65,268.24) 266.65,268.04 266.95,267.74 SITE4.4_F
  vias: v1(244.32,292.85)
S5_C1B_F: length 8.9
  TOP w0.305: 152.36,205.43 SITE5.17_F
  TOP w0.635: v1(159.27,201.77) 156.32,201.77 152.65,205.43 152.36,205.43
  vias: v1(130.92,232.85)
S5_IS1N_F: length 7
  TOP w0.305: 149.61,203.28 149.35,203.53 149.35,204.94 SITE5.12_F
  TOP w0.635: 149.61,203.28 149.61,203.02 152.91,199.72 v1(153.17,199.72)
  vias: v1(157.71,173.69)
S5_IS1P_F: length 8.2
  TOP w0.305: SITE5.11_F 148.8,203.35 148.66,203.21
  TOP w0.635: 148.66,203.21 148.66,202.31 151.91,199.06 v1(151.91,198.18)
  vias: v1(156.48,173.69)
S5_IS2N_F: length 5.8
  TOP w0.305: SITE5.10_F 148.3,204.51 148.08,204.29 148.08,204.03
  TOP w0.635: v1(148.22,199.72) 147.57,200.36 147.57,203.53 148.08,204.03
  vias: v1(152.63,173.69)
S5_IS2P_F: length 7.5
  TOP w0.305: 147.57,204.76 SITE5.9_F
  TOP w0.635: v1(146.96,198.18) 146.56,198.58 146.56,203.75 147.57,204.76
  vias: v1(151.4,173.69)
S5_SCL_F: length 30.3
  TOP w0.305: 151.64,203.91 150.8,204.74 SITE5.15_F
  TOP w0.635: 159.44,184.3 158.71,184.3 155.72,187.28 155.72,199.82 151.64,203.91
  BOTTOM w0.559: UNK5K24.3 157.37,184.55 ; 157.37,184.55 UNK5K53.3 ; 157.37,184.55 UNK5K54.4
S5_SDA_F: length 29.7
  TOP w0.305: 150.56,203.59 150.3,203.85 SITE5.14_F
  TOP w0.635: 150.56,203.59 154.82,199.33 154.82,189.75 152.78,187.71 152.78,185.9 151.18,184.3
  BOTTOM w0.559: 149.12,184.55 UNK5K23.3 ; 149.12,184.55 UNK5K51.3 ; 149.12,184.55 UNK5K52.4
S5_SRD_F: length 15.1
  BOTTOM w0.305: v2(147.05,209.24) 146.56,209.73
  BOTTOM w0.635: v2(138.97,211.91) 140.08,213.02 v2(142.88,213.02) 145,210.89 145.4,210.89 146.56,209.73 ; UNK5K1.3 134.34,229.94 UNK5K56.3
S5_SRD_S: length 27.2
  TOP w0.203: SITE5.1_S 147.45,209.84 141.76,215.53 141.76,225.88 v1(142.88,226.99)
  BOTTOM w0.203: v1(142.88,226.99) 142.88,229.59 UNK5K1.6
S5_SRG_F: length 0.7
  TOP w0.305: SITE5.4_F 146.95,207.74 146.65,208.04 v2(146.65,208.24)
  vias: v1(124.32,232.85)
S6_C1B_F: length 8.9
  TOP w0.305: 192.36,205.43 SITE6.17_F
  TOP w0.635: v1(199.27,201.77) 196.32,201.77 192.65,205.43 192.36,205.43
  vias: v1(170.92,232.85)
S6_IS1N_F: length 7
  TOP w0.305: 189.61,203.28 189.35,203.53 189.35,204.94 SITE6.12_F
  TOP w0.635: 189.61,203.28 189.61,203.02 192.91,199.72 v1(193.17,199.72)
  vias: v1(197.71,173.69)
S6_IS1P_F: length 8.2
  TOP w0.305: 188.66,203.21 188.8,203.35 SITE6.11_F
  TOP w0.635: 188.66,203.21 188.66,202.31 191.91,199.06 v1(191.91,198.18)
  vias: v1(196.48,173.69)
S6_IS2N_F: length 5.8
  TOP w0.305: SITE6.10_F 188.3,204.51 188.08,204.29 188.08,204.03
  TOP w0.635: 188.08,204.03 187.57,203.53 187.57,200.36 v1(188.22,199.72)
  vias: v1(192.63,173.69)
S6_IS2P_F: length 7.5
  TOP w0.305: 187.57,204.76 SITE6.9_F
  TOP w0.635: 187.57,204.76 186.56,203.75 186.56,198.58 v1(186.96,198.18)
  vias: v1(191.4,173.69)
S6_SCL_F: length 30.3
  TOP w0.305: 191.64,203.91 190.8,204.74 SITE6.15_F
  TOP w0.635: 199.44,184.3 198.71,184.3 195.72,187.28 195.72,199.82 191.64,203.91
  BOTTOM w0.559: UNK6K24.3 197.37,184.55 ; 197.37,184.55 UNK6K54.4 ; 197.37,184.55 UNK6K53.3
S6_SDA_F: length 29.7
  TOP w0.305: 190.56,203.59 190.3,203.85 SITE6.14_F
  TOP w0.635: 191.18,184.3 192.78,185.9 192.78,187.71 194.82,189.75 194.82,199.33 190.56,203.59
  BOTTOM w0.559: UNK6K52.4 189.12,184.55 ; 189.12,184.55 UNK6K51.3 ; 189.12,184.55 UNK6K23.3
S6_SRD_F: length 15.1
  BOTTOM w0.305: v2(187.05,209.24) 186.56,209.73
  BOTTOM w0.635: v2(178.97,211.91) 180.08,213.02 v2(182.87,213.02) 185,210.89 185.4,210.89 186.56,209.73 ; UNK6K56.3 174.34,229.94 UNK6K1.3
S6_SRD_S: length 27.2
  TOP w0.203: SITE6.1_S 187.45,209.84 181.76,215.53 181.76,225.88 v1(182.87,226.99)
  BOTTOM w0.203: v1(182.87,226.99) 182.87,229.59 UNK6K1.6
S6_SRG_F: length 0.7
  TOP w0.305: v2(186.65,208.24) 186.65,208.04 186.95,207.74 SITE6.4_F
  vias: v1(164.32,232.85)
S7_C1B_F: length 8.9
  TOP w0.305: 232.36,205.43 SITE7.17_F
  TOP w0.635: 232.36,205.43 232.65,205.43 236.32,201.77 v1(239.27,201.77)
  vias: v1(210.92,232.85)
S7_IS1N_F: length 7
  TOP w0.305: 229.61,203.28 229.35,203.53 229.35,204.94 SITE7.12_F
  TOP w0.635: v1(233.17,199.72) 232.91,199.72 229.61,203.02 229.61,203.28
  vias: v1(237.71,173.69)
S7_IS1P_F: length 8.2
  TOP w0.305: 228.66,203.21 228.8,203.35 SITE7.11_F
  TOP w0.635: v1(231.91,198.18) 231.91,199.06 228.66,202.31 228.66,203.21
  vias: v1(236.48,173.69)
S7_IS2N_F: length 5.8
  TOP w0.305: 228.08,204.03 228.08,204.29 228.3,204.51 SITE7.10_F
  TOP w0.635: 228.08,204.03 227.57,203.53 227.57,200.36 v1(228.22,199.72)
  vias: v1(232.63,173.69)
S7_IS2P_F: length 7.5
  TOP w0.305: 227.57,204.76 SITE7.9_F
  TOP w0.635: v1(226.96,198.18) 226.56,198.58 226.56,203.75 227.57,204.76
  vias: v1(231.4,173.69)
S7_SCL_F: length 30.3
  TOP w0.305: SITE7.15_F 230.8,204.74 231.64,203.91
  TOP w0.635: 231.64,203.91 235.72,199.82 235.72,187.28 238.71,184.3 239.44,184.3
  BOTTOM w0.559: UNK7K24.3 237.37,184.55 ; 237.37,184.55 UNK7K54.4 ; 237.37,184.55 UNK7K53.3
S7_SDA_F: length 29.7
  TOP w0.305: SITE7.14_F 230.3,203.85 230.56,203.59
  TOP w0.635: 230.56,203.59 234.82,199.33 234.82,189.75 232.78,187.71 232.78,185.9 231.18,184.3
  BOTTOM w0.559: 229.12,184.55 UNK7K51.3 ; 229.12,184.55 UNK7K23.3 ; 229.12,184.55 UNK7K52.4
S7_SRD_F: length 15.1
  BOTTOM w0.305: v2(227.05,209.24) 226.56,209.73
  BOTTOM w0.635: 226.56,209.73 225.4,210.89 225,210.89 v2(222.87,213.02) 220.08,213.02 v2(218.97,211.91) ; UNK7K56.3 214.34,229.94 UNK7K1.3
S7_SRD_S: length 27.2
  TOP w0.203: SITE7.1_S 227.45,209.84 221.76,215.53 221.76,225.88 v1(222.87,226.99)
  BOTTOM w0.203: v1(222.87,226.99) 222.87,229.59 UNK7K1.6
S7_SRG_F: length 0.7
  TOP w0.305: v2(226.65,208.24) 226.65,208.04 226.95,207.74 SITE7.4_F
  vias: v1(204.32,232.85)
S8_C1B_F: length 8.9
  TOP w0.305: 272.36,205.43 SITE8.17_F
  TOP w0.635: 272.36,205.43 272.65,205.43 276.32,201.77 v1(279.27,201.77)
  vias: v1(250.92,232.85)
S8_IS1N_F: length 7
  TOP w0.305: 269.61,203.28 269.35,203.53 269.35,204.94 SITE8.12_F
  TOP w0.635: 269.61,203.28 269.61,203.02 272.91,199.72 v1(273.17,199.72)
  vias: v1(277.71,173.69)
S8_IS1P_F: length 8.2
  TOP w0.305: 268.66,203.21 268.8,203.35 SITE8.11_F
  TOP w0.635: 268.66,203.21 268.66,202.31 271.91,199.06 v1(271.91,198.18)
  vias: v1(276.48,173.69)
S8_IS2N_F: length 5.8
  TOP w0.305: SITE8.10_F 268.3,204.51 268.08,204.29 268.08,204.03
  TOP w0.635: v1(268.22,199.72) 267.57,200.36 267.57,203.53 268.08,204.03
  vias: v1(272.63,173.69)
S8_IS2P_F: length 7.5
  TOP w0.305: 267.57,204.76 SITE8.9_F
  TOP w0.635: 267.57,204.76 266.56,203.75 266.56,198.58 v1(266.96,198.18)
  vias: v1(271.4,173.69)
S8_SCL_F: length 30.3
  TOP w0.305: SITE8.15_F 270.8,204.74 271.64,203.91
  TOP w0.635: 271.64,203.91 275.72,199.82 275.72,187.28 278.71,184.3 279.44,184.3
  BOTTOM w0.559: 277.37,184.55 UNK8K54.4 ; 277.37,184.55 UNK8K24.3 ; 277.37,184.55 UNK8K53.3
S8_SDA_F: length 29.7
  TOP w0.305: 270.56,203.59 270.3,203.85 SITE8.14_F
  TOP w0.635: 271.18,184.3 272.78,185.9 272.78,187.71 274.82,189.75 274.82,199.33 270.56,203.59
  BOTTOM w0.559: UNK8K52.4 269.12,184.55 ; 269.12,184.55 UNK8K23.3 ; 269.12,184.55 UNK8K51.3
S8_SRD_F: length 15.1
  BOTTOM w0.305: v2(267.05,209.24) 266.56,209.73
  BOTTOM w0.635: UNK8K56.3 254.34,229.94 UNK8K1.3 ; v2(258.97,211.91) 260.08,213.02 v2(262.87,213.02) 265,210.89 265.4,210.89 266.56,209.73
S8_SRD_S: length 27.2
  TOP w0.203: v1(262.87,226.99) 261.76,225.88 261.76,215.53 267.45,209.84 SITE8.1_S
  BOTTOM w0.203: UNK8K1.6 262.87,229.59 v1(262.87,226.99)
S8_SRG_F: length 0.7
  TOP w0.305: SITE8.4_F 266.95,207.74 266.65,208.04 v2(266.65,208.24)
  vias: v1(244.32,232.85)
SDUP5V_FILTER: length 20.8
  BOTTOM w0.381: UNK4U1.5 v1(243.3,294.89) ; UNK5U1.5 v1(123.3,234.89) ; UNK4U2.5 v1(249.92,294.89) ; UNK8U2.5 v1(249.92,234.89) ; UNK8U1.5 v1(243.3,234.89) ; UNK6U1.5 v1(163.3,234.89) ; UNK2U1.5 v1(163.3,294.89) ; U2.5 v1(129.92,294.89) ; UNK6U2.5 v1(169.92,234.89) ; UNK5U2.5 v1(129.92,234.89) ; UNK2U2.5 v1(169.92,294.89) ; UNK3U2.5 v1(209.92,294.89) ; UNK7U2.5 v1(209.92,234.89) ; UNK7U1.5 v1(203.3,234.89) ; U1.5 v1(123.3,294.89) ; UNK3U1.5 v1(203.3,294.89)
SDUR5V_FILTER:
  vias: v1(120.9,288.4) v1(120.9,228.4) v1(121.16,292.85) v1(121.16,232.85) v1(127.76,292.85) v1(127.76,232.85) v1(131.02,269.99) v1(131.02,209.99) v1(131.95,262.12) v1(131.95,202.12) v1(133.1,264.66) v1(133.1,204.66) v1(137.67,269.49) v1(137.67,266.69) v1(137.67,264.66) v1(137.67,262.12) v1(137.67,209.49) v1(137.67,206.69) v1(137.67,204.66) v1(137.67,202.12) v1(140.97,297.93) v1(140.97,284.73) v1(140.97,237.93) v1(140.97,224.73) v1(143.26,255.02) v1(143.26,250.19) v1(143.26,244.22) v1(143.26,195.02) v1(143.26,190.19) v1(143.26,184.22) v1(146.06,255.02) v1(146.06,250.19) v1(146.06,195.02) v1(146.06,190.19) v1(148.22,255.02) v1(148.22,250.19) v1(148.22,238.89) v1(148.22,195.02) v1(148.22,190.19) v1(148.22,178.89) v1(148.33,287.27) v1(148.33,281.43) v1(148.33,227.27) v1(148.33,221.43) v1(149.22,248.79) v1(149.22,188.79) v1(150.74,287.27) v1(150.74,282.7) v1(150.74,276.86) v1(150.74,227.27) v1(150.74,222.7) v1(150.74,216.86) v1(151.01,255.02) v1(151.01,250.19) v1(151.01,195.02) v1(151.01,190.19) v1(151.5,236.86) v1(151.5,176.86) v1(153.15,285.75) v1(153.15,281.18) v1(153.15,275.34) v1(153.17,255.02) v1(153.17,250.19) v1(153.15,225.75) v1(153.15,221.18) v1(153.15,215.34) v1(153.17,195.02) v1(153.17,190.19) v1(153.54,236.86) v1(153.54,176.86) v1(156.08,284.48) v1(156.08,279.91) v1(156.08,275.34) v1(156.08,224.48) v1(156.08,219.91) v1(156.08,215.34) v1(156.47,255.02) v1(156.47,250.19) v1(156.47,238.89) v1(156.47,195.02) v1(156.47,190.19) v1(156.47,178.89) v1(156.58,236.86) v1(156.58,176.86) v1(157.47,248.79) v1(157.47,188.79) v1(158.62,236.86) v1(158.62,176.86) v1(160.9,288.4) v1(160.9,228.4) v1(161.16,292.85) v1(161.16,232.85) v1(162.43,273.31) v1(162.43,270.77) v1(162.43,267.72) v1(162.43,264.68) v1(162.43,260.87) v1(162.43,213.31) v1(162.43,210.77) v1(162.43,207.72) v1(162.43,204.68) v1(162.43,200.87) v1(167,273.31) v1(167,270.77) v1(167,267.72) v1(167,264.68) v1(167,260.87) v1(167,213.31) v1(167,210.77) v1(167,207.72) v1(167,204.68) v1(167,200.87) v1(167.76,292.85) v1(167.76,232.85) v1(169.17,266.7) v1(169.17,262.89) v1(169.17,206.7) v1(169.17,202.89) v1(171.02,269.99) v1(171.02,209.99) v1(171.58,267.72) v1(171.58,207.72) v1(171.95,262.12) v1(171.95,202.12) v1(173.1,264.66) v1(173.1,204.66) v1(177.67,269.49) v1(177.67,266.69) v1(177.67,264.66) v1(177.67,262.12) v1(177.67,209.49) v1(177.67,206.69) v1(177.67,204.66) v1(177.67,202.12) v1(180.97,297.93) v1(180.97,284.73) v1(180.97,237.93) v1(180.97,224.73) v1(183.26,255.02) v1(183.26,250.19) v1(183.26,244.22) v1(183.26,195.02) v1(183.26,190.19) v1(183.26,184.22) v1(186.06,255.02) v1(186.06,250.19) v1(186.06,195.02) v1(186.06,190.19) v1(188.22,255.02) v1(188.22,250.19) v1(188.22,238.89) v1(188.22,195.02) v1(188.22,190.19) v1(188.22,178.89) v1(188.33,287.27) v1(188.33,281.43) v1(188.33,227.27) v1(188.33,221.43) v1(189.22,248.79) v1(189.22,188.79) v1(190.74,287.27) v1(190.74,282.7) v1(190.74,276.86) v1(190.74,227.27) v1(190.74,222.7) v1(190.74,216.86) v1(191.01,255.02) v1(191.01,250.19) v1(191.01,195.02) v1(191.01,190.19) v1(191.5,236.86) v1(191.5,176.86) v1(193.15,285.75) v1(193.15,281.18) v1(193.15,275.34) v1(193.17,255.02) v1(193.17,250.19) v1(193.15,225.75) v1(193.15,221.18) v1(193.15,215.34) v1(193.17,195.02) v1(193.17,190.19) v1(193.54,236.86) v1(193.54,176.86) v1(196.08,284.48) v1(196.08,279.91) v1(196.08,275.34) v1(196.08,224.48) v1(196.08,219.91) v1(196.08,215.34) v1(196.47,255.02) v1(196.47,250.19) v1(196.47,238.89) v1(196.47,195.02) v1(196.47,190.19) v1(196.47,178.89) v1(196.58,236.86) v1(196.58,176.86) v1(197.47,248.79) v1(197.47,188.79) v1(198.62,236.86) v1(198.62,176.86) v1(200.9,288.4) v1(200.9,228.4) v1(201.16,292.85) v1(201.16,232.85) v1(202.43,273.31) v1(202.43,270.77) v1(202.43,267.72) v1(202.43,264.68) v1(202.43,260.87) v1(202.43,213.31) v1(202.43,210.77) v1(202.43,207.72) v1(202.43,204.68) v1(202.43,200.87) v1(207,273.31) v1(207,270.77) v1(207,267.72) v1(207,264.68) v1(207,260.87) v1(207,213.31) v1(207,210.77) v1(207,207.72) v1(207,204.68) v1(207,200.87) v1(207.76,292.85) v1(207.76,232.85) v1(209.17,266.7) v1(209.17,262.89) v1(209.17,206.7) v1(209.17,202.89) v1(211.02,269.99) v1(211.02,209.99) v1(211.58,267.72) v1(211.58,207.72) v1(211.95,262.12) v1(211.95,202.12) v1(213.1,264.66) v1(213.1,204.66) v1(217.67,269.49) v1(217.67,266.69) v1(217.67,264.66) v1(217.67,262.12) v1(217.67,209.49) v1(217.67,206.69) v1(217.67,204.66) v1(217.67,202.12) v1(220.97,297.93) v1(220.97,284.73) v1(220.97,237.93) v1(220.97,224.73) v1(223.26,255.02) v1(223.26,250.19) v1(223.26,244.22) v1(223.26,195.02) v1(223.26,190.19) v1(223.26,184.22) v1(226.06,255.02) v1(226.06,250.19) v1(226.06,195.02) v1(226.06,190.19) v1(228.22,255.02) v1(228.22,250.19) v1(228.22,238.89) v1(228.22,195.02) v1(228.22,190.19) v1(228.22,178.89) v1(228.33,287.27) v1(228.33,281.43) v1(228.33,227.27) v1(228.33,221.43) v1(229.22,248.79) v1(229.22,188.79) v1(230.74,287.27) v1(230.74,282.7) v1(230.74,276.86) v1(230.74,227.27) v1(230.74,222.7) v1(230.74,216.86) v1(231.01,255.02) v1(231.01,250.19) v1(231.01,195.02) v1(231.01,190.19) v1(231.5,236.86) v1(231.5,176.86) v1(233.15,285.75) v1(233.15,281.18) v1(233.15,275.34) v1(233.17,255.02) v1(233.17,250.19) v1(233.15,225.75) v1(233.15,221.18) v1(233.15,215.34) v1(233.17,195.02) v1(233.17,190.19) v1(233.53,236.86) v1(233.53,176.86) v1(236.07,284.48) v1(236.07,279.91) v1(236.07,275.34) v1(236.07,224.48) v1(236.07,219.91) v1(236.07,215.34) v1(236.47,255.02) v1(236.47,250.19) v1(236.47,238.89) v1(236.47,195.02) v1(236.47,190.19) v1(236.47,178.89) v1(236.58,236.86) v1(236.58,176.86) v1(237.47,248.79) v1(237.47,188.79) v1(238.61,236.86) v1(238.61,176.86) v1(240.9,288.4) v1(240.9,228.4) v1(241.16,292.85) v1(241.16,232.85) v1(242.43,273.31) v1(242.43,270.77) v1(242.43,267.72) v1(242.43,264.68) v1(242.43,260.87) v1(242.43,213.31) v1(242.43,210.77) v1(242.43,207.72) v1(242.43,204.68) v1(242.43,200.87) v1(247,273.31) v1(247,270.77) v1(247,267.72) v1(247,264.68) v1(247,260.87) v1(247,213.31) v1(247,210.77) v1(247,207.72) v1(247,204.68) v1(247,200.87) v1(247.76,292.85) v1(247.76,232.85) v1(249.17,266.7) v1(249.17,262.89) v1(249.17,206.7) v1(249.17,202.89) v1(251.02,269.99) v1(251.02,209.99) v1(251.58,267.72) v1(251.58,207.72) v1(251.95,262.12) v1(251.95,202.12) v1(253.1,264.66) v1(253.1,204.66) v1(257.67,269.49) v1(257.67,266.69) v1(257.67,264.66) v1(257.67,262.12) v1(257.67,209.49) v1(257.67,206.69) v1(257.67,204.66) v1(257.67,202.12) v1(260.97,297.93) v1(260.97,284.73) v1(260.97,237.93) v1(260.97,224.73) v1(263.26,255.02) v1(263.26,250.19) v1(263.26,244.22) v1(263.26,195.02) v1(263.26,190.19) v1(263.26,184.22) v1(266.06,255.02) v1(266.06,250.19) v1(266.06,195.02) v1(266.06,190.19) v1(268.22,255.02) v1(268.22,250.19) v1(268.22,238.89) v1(268.22,195.02) v1(268.22,190.19) v1(268.22,178.89) v1(268.33,287.27) v1(268.33,281.43) v1(268.33,227.27) v1(268.33,221.43) v1(269.22,248.79) v1(269.22,188.79) v1(270.74,287.27) v1(270.74,282.7) v1(270.74,276.86) v1(270.74,227.27) v1(270.74,222.7) v1(270.74,216.86) v1(271.01,255.02) v1(271.01,250.19) v1(271.01,195.02) v1(271.01,190.19) v1(271.5,236.86) v1(271.5,176.86) v1(273.15,285.75) v1(273.15,281.18) v1(273.15,275.34) v1(273.17,255.02) v1(273.17,250.19) v1(273.15,225.75) v1(273.15,221.18) v1(273.15,215.34) v1(273.17,195.02) v1(273.17,190.19) v1(273.53,236.86) v1(273.53,176.86) v1(276.07,284.48) v1(276.07,279.91) v1(276.07,275.34) v1(276.07,224.48) v1(276.07,219.91) v1(276.07,215.34) v1(276.47,255.02) v1(276.47,250.19) v1(276.47,238.89) v1(276.47,195.02) v1(276.47,190.19) v1(276.47,178.89) v1(276.58,236.86) v1(276.58,176.86) v1(277.47,248.79) v1(277.47,188.79) v1(278.61,236.86) v1(278.61,176.86) v1(282.43,273.31) v1(282.43,270.77) v1(282.43,267.72) v1(282.43,264.68) v1(282.43,260.87) v1(282.43,213.31) v1(282.43,210.77) v1(282.43,207.72) v1(282.43,204.68) v1(282.43,200.87) v1(287,273.31) v1(287,270.77) v1(287,267.72) v1(287,264.68) v1(287,260.87) v1(287,213.31) v1(287,210.77) v1(287,207.72) v1(287,204.68) v1(287,200.87) v1(289.17,266.7) v1(289.17,262.89) v1(289.17,206.7) v1(289.17,202.89) v1(291.58,267.72) v1(291.58,207.72)
SL01_VI100_2_A_HF: length 11.5
  TOP w0.305: SITE1.2_F 146.18,268.74
  TOP w0.635: v1(140.83,268.59) 140.98,268.74 146.18,268.74
  BOTTOM w0.635: v1(140.83,268.59) 139.83,267.59 136.82,267.59 C49.2
SL01_VI100_2_A_HS: length 475.9
  L07_VI w0.254: 90.75,405.13 90.75,421.17 93.95,424.38 94.35,424.38 95,425.02 95.65,425.02 96.12,424.55 96.78,424.55 97.25,425.02 97.9,425.02 98.37,424.55 99.58,424.55 SLOT01.C33
  L07_VI w0.635: v1(140.83,265.79) 132.15,265.79 128.51,262.16 128.51,241.6 134.61,235.5 134.61,230.49 129.61,225.49 129.61,223.5 130.89,222.22 130.89,217.53 133.91,214.51 138.32,214.51 140.53,216.72 147.96,216.72 148.71,215.98 148.71,214.46 150.55,212.61 151.45,212.61 152.01,213.18 157.49,213.18 158.19,212.47 171.05,212.47 172.87,214.3 179.97,214.3 180.92,214.3 182.54,215.92 182.54,223.52 183.62,224.6 183.62,228.17 187.93,232.48 198.79,232.48 200.77,234.46 200.77,239.47 202.16,240.86 204.26,240.86 210.63,247.23 210.63,253.83 210.1,254.35 210.1,257.38 214.25,261.53 214.25,262.07 215.44,263.26 215.44,271.35 221.5,277.41 221.5,282.95 219,285.44 216.17,285.44 214.52,287.1 214.52,296.48 208.07,302.93 202.46,302.93 197.74,307.65 197.07,308.32 197.07,314.5 173.86,337.71 173.86,337.71 173.49,338.08 115.18,338.08 76.21,377.04 76.21,390.6 78.22,392.61 90.75,405.13
  BOTTOM w0.203: v1(140.83,265.79) 141.97,265.79 144.92,268.74 v2(147.45,268.74)
SL01_VI100_2_B_HF: length 182.3
  TOP w0.305: SITE1.29_F 149.3,270.29 149.31,270.3 149.31,270.56 149.29,270.58 149.29,271 149.31,271.02 149.31,271.21 149.94,271.84
  TOP w0.635: v1(152.25,278.02) 151.49,277.25 151.49,273.39 149.94,271.84
  L07_VI w0.254: SLOT01.E33 103.14,424.29 102.4,423.55 101.75,423.55 101.28,424.02 100.62,424.02 100.15,423.55 99.5,423.55 99.03,424.02 98.37,424.02 97.9,423.55 97.25,423.55 96.78,424.02 96.12,424.02 95.65,423.55 95.57,423.55 94.41,422.39 93.75,422.39 91.5,420.15 91.5,404.27 90.75,403.51
  L07_VI w0.635: 170.93,340.64 114.23,340.64 77.36,377.52 77.36,390.12 78.7,391.46 90.75,403.51
SL01_VI100_2_B_HS: length 31.4
  L07_VI w0.254: SLOT01.C58 98.72,398.37 99.54,397.55 99.67,397.55 101.36,395.86 101.36,395.57 104.3,392.63 104.3,392.46
  L07_VI w0.635: 104.3,392.46 104.3,384.56
  BOTTOM w0.203: v2(149.3,269.59) 149.21,269.68 149.21,270.84 151.38,273.02 151.38,281.72 v1(152.25,282.59)
SL01_VI100_3_A_HF: length 460
  TOP w0.305: SITE1.5_F 145.45,267.24
  TOP w0.635: v1(140.83,261.22) 143.13,263.52 143.13,264.92 145.45,267.24
  L07_VI w0.254: SLOT01.D31 100.89,426.29 100.15,425.55 99.5,425.55 99.03,426.02 98.37,426.02 97.9,425.55 97.25,425.55 96.78,426.02 96.12,426.02 95.48,425.38 95.17,425.38 94.53,426.02 93.66,426.02 91.89,424.25 91.89,423.45 90.75,422.3 90.75,422.3
  L07_VI w0.635: 90.75,422.3 89.73,421.29 89.73,405.73 77.75,393.75 77.75,393.75 75.07,391.07 75.07,376.57 114.7,336.94 173.02,336.94 173.39,336.57 195.93,314.03 195.93,306.89 205.21,297.6 205.21,294.31 210.62,288.91 210.62,276.99 208.9,275.27 208.9,273.96 212.33,270.53 212.33,265.69 211.2,264.57 211.2,260.1 208.96,257.86 208.96,253.88 209.49,253.35 209.49,249.14 207.63,247.28 206.68,247.28 204.93,247.28 204.26,247.95 203.8,248.41 201.69,248.41 201.01,247.73 201.01,242.04 199.65,240.68 197.99,240.68 197.54,241.12 195.04,241.12 194.93,241.02 194.13,241.02 192.51,239.4 192.51,235.5 191.46,234.44 188.29,234.44 181.72,227.88 181.72,224.31 181.4,223.99 181.4,216.39 180.45,215.44 159.34,215.44 157.28,217.5 153.83,217.5 152.56,218.77 152.11,218.77 149.09,221.78 149.09,223.83 147.5,225.42 147.5,227.57 145.56,229.51 141.56,229.51 140.69,228.64 139.37,228.64 138.44,229.57 138.44,239.81 137.51,240.74 131.58,240.74 129.65,242.67 129.65,255.76 v1(135.11,261.22) 136.23,260.1 139.71,260.1 v1(140.83,261.22)
  BOTTOM w0.635: v1(140.83,261.22) 140.83,260.93 140.19,260.3 135.75,260.3 135.11,260.93 v1(135.11,261.22)
SL01_VI100_3_A_HS: length 440.1
  L07_VI w0.254: SLOT01.C31 99.27,426.29 99.17,426.38 98.55,426.38 97.9,427.02 97.29,427.02 96.65,426.38 96.3,426.38 95.65,427.02 95.04,427.02 94.4,426.38 92.88,426.38 90.75,424.25
  L07_VI w0.635: v1(136.26,263.76) 138.75,263.76 139.89,262.62 142.14,262.62 143.32,261.44 143.32,260.25 141.09,258.02 141.09,256.33 141.8,255.62 141.8,253.22 141.33,252.75 141.33,248.6 142.38,247.55 142.38,234.31 149.77,226.92 149.77,225.75 150.41,225.11 151.05,225.11 152.44,226.5 153.46,226.5 154.15,225.82 161.29,225.82 162.71,227.24 172.84,227.24 174.63,225.44 177.49,225.44 178.44,226.4 178.44,227.69 179.37,228.62 180.66,228.62 181.62,229.57 181.62,230.35 185.72,234.46 186.54,234.46 189.56,237.48 189.56,239.42 190.63,240.48 191.74,240.48 192.77,241.51 192.77,247.22 193.85,248.3 195.64,248.3 196.92,249.58 204.25,249.58 205.4,248.43 207.16,248.43 208.35,249.61 208.35,252.88 207.82,253.41 207.82,257.31 204.67,260.46 204.67,262.08 203.35,263.39 199.41,263.39 198.48,264.32 198.48,269.62 201.36,272.5 207.25,272.5 207.75,273 207.75,275.74 209.47,277.46 209.47,287.09 208.8,287.76 208.8,287.76 207.03,289.53 207.03,290.54 206.15,291.42 201.22,291.42 194.78,297.86 194.78,313.55 173.05,335.29 172.96,335.37 172.54,335.8 114.23,335.8 73.93,376.1 73.93,391.55 77.27,394.89 77.28,394.89 88.59,406.2 88.59,422.45 90.39,424.25 90.75,424.25
  BOTTOM w0.203: v2(147.45,267.24) 146.97,267.24 142.62,262.89 137.13,262.89 v1(136.26,263.76)
SL01_VI100_3_B_HS: length 522.8
  L07_VI w0.254: 90.75,400.28 92.31,401.84 93.74,401.84 93.92,402.02 94.53,402.02 95,401.55 95.65,401.55 96,401.9 96.12,402.02 96.78,402.02 97.51,401.29 SLOT01.C56
  L07_VI w0.635: v1(149.12,253.35) 149.12,256.54 149.75,257.18 153.48,257.18 153.62,257.03 154.54,257.03 155.21,257.7 155.21,261.26 153.19,263.29 147.14,263.29 144.76,265.67 144.76,268.5 142.52,270.74 128.45,270.74 119.36,261.65 119.36,216.85 128.76,207.44 141.35,207.44 144.87,203.93 170.87,203.93 174.75,207.8 178.87,207.8 183.5,212.44 190.71,212.44 191.83,213.55 191.83,215.12 194.05,217.34 194.05,223.82 196.56,226.34 202.51,226.34 206.11,229.94 213.02,229.94 215.24,232.17 215.24,243.01 215.18,243.07 215.18,246.96 216.64,248.42 222.56,248.42 225.14,251.01 225.14,261.28 224.51,261.91 224.51,288.18 222.55,290.13 222.55,295.43 221.65,296.33 219.36,296.33 209.36,306.33 202.29,306.33 199.36,309.26 199.36,315.45 166.16,348.64 109.46,348.64 79.64,378.46 79.64,389.18 90.75,400.28
  BOTTOM w0.203: v2(148.3,265.39) 148.3,261.78 149.86,260.22 149.86,254.09 v1(149.12,253.35)
SL01_VI100_4_A_HS: length 380
  L07_VI w0.254: 90.75,426.79 91.52,426.79 93.27,428.55 94.53,428.55 95,429.02 95.65,429.02 96.12,428.55 96.78,428.55 97.25,429.02 97.9,429.02 98.38,428.54 99.59,428.54 SLOT01.C29
  L07_VI w0.635: v1(140.83,263.76) 142.89,263.76 145.75,260.91 145.75,258.09 145.31,257.66 145.31,249.19 145.82,248.69 145.82,237.57 151.19,232.2 158.13,232.2 158.97,231.36 172.75,231.36 174.7,233.31 174.7,235.65 175.52,236.48 177.02,236.48 186.84,246.29 186.84,251.28 187.91,252.35 189.18,252.35 190.24,253.41 190.24,262.9 193.08,265.74 193.08,268.12 196.84,271.88 196.84,286.07 192.5,290.41 192.5,312.61 172.1,333 172.02,333.09 171.59,333.51 113.28,333.51 71.64,375.15 71.64,392.58 86.13,407.07 86.13,423.34 89.32,426.53 89.33,426.53 89.59,426.79 90.75,426.79
  BOTTOM w0.203: v2(147.45,267.74) 145.82,267.74 141.84,263.76 v1(140.83,263.76)
SL01_VI100_4_B_HS: length 140.6
  L09_VI w0.254: SLOT01.C54 97.51,403.29 97.26,403.03 97.26,402.96 96.8,402.5 96.14,402.5 96.13,402.51 96.13,402.61 95.67,403.07 95.02,403.07 94.56,402.61 94.56,402.33 94.3,402.07 93.89,402.07 91.9,400.08
  L09_VI w0.635: 162.86,312.57 162.86,323.73 90.72,395.87 90.72,398.9 91.9,400.08
  BOTTOM w0.203: v1(163.84,261.77) 162.2,263.42 153.98,263.42 v2(151.65,265.74)
SL01_VI100_5_A_HF: length 417.2
  TOP w0.305: SITE1.6_F 146.47,266.74 146.18,266.45
  TOP w0.635: v1(144.16,258.18) 144.16,264.43 146.18,266.45
  L07_VI w0.254: SLOT01.D27 102.1,429.33 101.32,428.55 101.15,428.55 100.15,427.55 99.5,427.55 99.03,428.02 98.37,428.02 97.9,427.55 97.25,427.55 96.78,428.02 96.12,428.02 95.65,427.55 95,427.55 94.53,428.02 93.38,428.02 90.75,425.39
  L07_VI w0.635: v1(144.16,258.18) K12.4 143.54,253.35 142.47,252.28 142.47,249.08 K13.4 144.16,244.02 143.52,243.38 143.52,236.04 149.2,230.37 151.37,230.37 151.97,229.77 161.23,229.77 162.37,228.62 177.46,228.62 178.42,229.57 178.42,235.26 179.37,236.22 180.31,236.22 185.56,241.47 185.56,243.4 187.98,245.82 187.98,248.62 188.91,249.54 189.53,249.54 189.63,249.44 193.96,249.44 194.82,250.3 194.82,258.49 194.47,258.84 194.47,267.55 198.52,271.6 198.52,274.52 199.42,275.42 205.82,275.42 208.33,277.93 208.33,286.61 205.97,288.97 202.05,288.97 194.31,296.71 193.64,297.38 193.64,313.08 172.58,334.14 172.49,334.23 172.07,334.65 113.76,334.65 72.79,375.62 72.79,392.11 87.27,406.6 87.27,422.87 89.8,425.39 90.75,425.39
  BOTTOM w0.508: 144.39,253.35 K12.4
  BOTTOM w0.635: 145.18,253.35 145.18,257.54 144.54,258.18 v1(144.16,258.18) ; 145.18,253.35 144.39,253.35 ; 145.18,253.35 145.18,248.1 144.45,247.38 144.21,247.38
SL01_VI100_5_A_HS: length 214.6
  L09_VI w0.254: 90.75,428.15 91.62,428.15 93.5,430.04 94.51,430.04 95,429.55 95.65,429.55 96.65,430.55 96.78,430.55 97.25,431.02 97.94,431.02 98.68,430.29 SLOT01.C27
  L09_VI w0.635: 101.8,282.56 75.44,282.56 49.44,308.57 49.44,393.23 66.95,410.74 66.95,410.75 70.26,414.05 70.26,414.09 84.32,428.15 90.75,428.15
  vias: v2(147.45,266.74)
SL01_VI100_6_A_HF:
  vias: v2(147.05,266.24)
SL01_VI100_6_A_HS: length 361
  L07_VI w0.254: 90.75,429.8 90.76,429.8 93.03,432.07 94.05,432.07 95,433.02 95.65,433.02 96.12,432.55 96.78,432.55 97.25,433.02 97.9,433.02 98.37,432.55 99.58,432.55 SLOT01.C25
  L07_VI w0.635: v1(146.96,253.35) 146.96,239.05 150.43,235.58 150.43,235.33 151.06,234.69 159.39,234.69 161.37,236.67 173.42,236.67 175.27,238.52 175.27,247.05 176.3,248.08 182.22,248.08 185.27,251.14 185.27,259.07 184.52,259.82 184.52,269.44 187.47,272.39 189.53,272.39 190.79,271.13 193.17,271.13 194.07,272.03 194.07,287.22 190.21,291.08 190.21,311.66 171.26,330.62 171.25,330.62 171.07,330.8 170.65,331.22 112.34,331.22 69.36,374.2 69.36,393.53 83.85,408.02 83.85,424.29 89.36,429.8 90.75,429.8
  vias: v2(147.45,266.24)
SL01_VI100_6_B_HF: length 10.6
  TOP w0.305: SITE1.30_F v2(148.8,271.66)
  L07_VI w0.254: 109.02,433.1 109.01,433.09 108.7,433.09 108.16,432.55 107.42,432.55 107.3,432.67 106.94,433.02 106.29,433.02 105.55,432.29 SLOT01.E25
  L07_VI w0.635: 112.56,433.1 109.02,433.1
SL01_VI100_6_B_HS: length 135.7
  L09_VI w0.254: 93.24,405.69 93.82,406.26 94.24,406.26 94.48,406.5 94.55,406.5 94.56,406.51 94.56,406.61 95.02,407.07 95.67,407.07 96.13,406.61 96.13,406.58 96.17,406.55 96.78,406.55 97.51,407.29 SLOT01.C50
  L09_VI w0.635: 93.24,405.69 89.58,402.03 89.58,395.39 161.72,323.26 161.72,312.57
  BOTTOM w0.203: v2(148.8,269.59) 148.8,271.01 149.84,272.05 K46.4
SL01_VI100_7_A_HF: length 246
  L09_VI w0.254: 90.75,433.02 91.22,433.02 92.23,434.04 93.17,434.04 93.69,434.55 94.53,434.55 95,435.02 95.65,435.02 96.12,434.55 96.78,434.55 97.25,435.02 97.9,435.02 98.45,434.47 98.95,434.47 99.5,435.02 100.15,435.02 100.68,434.49 101.89,434.49 SLOT01.D23
  L09_VI w0.635: 90.75,433.02 58.73,433.02 44.87,419.16 44.87,306.67 73.55,277.99 101.51,277.99
  vias: v2(149.8,264.99)
