# Allegro board 980K2-260817_261117-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL06_DP_127: length 467.3
  TOP w0.381: UNK4TP_OUT+_1.1 v1(246.61,295.54)
  L28_DP w0.079: SLOT06.C19 174.92,36.25 175.23,36.25 175.33,36.34 175.87,36.34 176.87,35.34 176.99,35.34 177.37,34.96 177.37,34.84 177.87,34.34 178.12,34.34 178.42,34.04 179.53,34.04 179.83,34.34 180.37,34.34 180.91,33.8 214.05,33.8 214.59,34.34 215.13,34.34 215.51,33.96 215.51,33.79 215.69,33.6 216.19,33.6 216.46,33.87 216.46,34.18 216.79,34.51 217.45,34.51 217.59,34.64 217.59,34.96 217.97,35.34 218.5,35.34 218.88,34.96 218.88,34.79 219.16,34.51 219.7,34.51 219.84,34.64 219.84,34.96 220.22,35.34 220.75,35.34 221.13,34.96 221.13,34.79 221.41,34.51 221.95,34.51 222.09,34.64 222.09,34.96 222.47,35.34 223,35.34 223.38,34.96 223.38,34.79 223.66,34.51 224.2,34.51 224.34,34.64 224.34,34.96 224.72,35.34 225.25,35.34 225.63,34.96 225.63,34.79 225.91,34.51 226.45,34.51 226.59,34.64 226.59,34.96 226.97,35.34 227.5,35.34 227.88,34.96 227.88,34.79 228.16,34.51 228.7,34.51 260.63,66.43 261.55,67.04 263.68,67.04 263.98,67.34 264.51,67.34 264.81,67.04 265.93,67.04 266.23,67.34 266.76,67.34 267.06,67.04 268.18,67.04 268.48,67.34 269.01,67.34 269.31,67.04 270.43,67.04 270.73,67.34 271.26,67.34 271.56,67.04 272.68,67.04 272.98,67.34 273.51,67.34 273.81,67.04 274.93,67.04 275.23,67.34 275.76,67.34 276.06,67.04 294.58,67.04 334.37,106.83 334.37,275.55 311,298.92 249.98,298.92 v1(246.61,295.54)
SL06_DP_128: length 326.7
  TOP w0.381: UNK4TP_OUT-_1.1 v1(244.31,295.54)
  L30_DP w0.079: v1(244.31,295.54) 248.32,299.55 296.42,299.55 332.04,263.93 332.04,151.23 261.86,81.06 261.86,71.23
SL06_DP_129: length 313.2
  TOP w0.381: UNK4TP_OUT+_2.1 v1(253.21,295.54)
  L30_DP w0.079: 260.22,71.28 260.22,81.74 330.39,151.92 330.39,263.2 297.04,296.56 254.23,296.56 v1(253.21,295.54)
SL06_DP_130: length 317.3
  TOP w0.381: UNK4TP_OUT-_2.1 v1(250.91,295.54)
  L30_DP w0.079: v1(250.91,295.54) 252.83,297.46 297.32,297.46 331.25,263.53 331.25,151.56 261.07,81.38 261.07,71.23
SL06_DP_131: length 1.4
  BOTTOM w0.203: v1(276.79,228.7) 276.79,227.38 UNK4R15.1
SL06_DP_132: length 1.4
  BOTTOM w0.203: v1(271.71,228.7) 271.71,227.38 UNK4R17.1
SL06_DP_133: length 219.4
  TOP w0.381: UNK6TP_OUT+_1.1 v1(166.61,235.54)
  L28_DP w0.079: SLOT06.D41 170.89,58.69 170.24,59.34 169.71,59.34 169.25,58.89 169.25,58.54 169.33,58.47 169.33,58.42 169.71,58.04 169.83,58.04 170.83,57.04 171.37,57.04 171.89,57.57 172.56,57.57 173.08,57.04 173.62,57.04 174.44,57.86 174.82,57.86 175.36,58.4 175.84,58.4 176.38,57.86 177.07,57.86 177.47,58.27 177.52,58.27 177.64,58.39 178.06,58.39 178.18,58.27 178.23,58.27 178.63,57.86 179.32,57.86 179.64,58.18 179.67,58.18 179.83,58.34 180.37,58.34 180.53,58.18 180.56,58.18 181.07,57.67 184.02,57.67 186.74,60.39 186.74,77.82 167.43,97.13 167.43,183.38 163.05,187.76 162.82,187.76 157.87,192.71 157.87,199.35 158.21,199.68 158.21,202.68 163.37,207.85 163.37,208.82 163.65,209.1 164.62,209.1 169,213.48 169,232.36 168.7,232.66 168.7,233.45 v1(166.61,235.54)
SL06_DP_134: length 212.3
  TOP w0.381: UNK6TP_OUT-_1.1 v1(164.31,235.54)
  L28_DP w0.079: SLOT06.E41 170.33,58.34 171.37,58.34 171.4,58.31 171.42,58.31 171.78,57.94 172.42,57.94 172.82,58.34 173.08,58.34 173.62,58.34 173.62,58.34 173.91,58.34 174.21,58.04 174.74,58.04 175.28,58.58 175.92,58.58 176.46,58.04 176.99,58.04 177.4,58.45 177.44,58.45 177.56,58.57 178.14,58.57 178.26,58.45 178.3,58.45 178.71,58.04 179.24,58.04 179.79,58.59 180.41,58.59 181.14,57.87 181.72,57.87 186.15,62.29 186.15,77.38 166.74,96.79 166.74,181.06 163.64,184.16 163.64,184.97 163.05,185.56 162.24,185.56 161.36,186.44 161.36,187.8 156,193.16 156,193.55 157.59,195.13 157.59,197.3 156.9,197.98 156.9,198.37 157.38,198.85 157.38,199.24 157.1,199.52 157.1,199.91 157.59,200.4 157.59,202.14 157.26,202.47 157.26,202.86 157.59,203.19 157.59,208.34 157.26,208.66 157.26,209.05 157.59,209.38 157.59,211.35 157.26,211.68 157.26,212.07 157.59,212.39 157.59,213.89 157.26,214.22 157.26,214.61 157.59,214.93 157.59,222.5 163.45,228.36 163.45,230.14 163.84,230.52 163.84,234.44 164.31,234.91 v1(164.31,235.54)
SL06_DP_135: length 213.2
  TOP w0.381: UNK6TP_OUT+_2.1 v1(173.22,235.54)
  L28_DP w0.079: v1(173.22,235.54) 173.22,235.48 171.39,233.66 171.39,233.05 171.39,233.05 171.39,232.66 171.39,232.66 171.39,225.42 171.24,225.19 171.13,224.92 171.07,224.64 171.07,224.34 171.13,224.06 171.24,223.79 171.39,223.56 171.39,212.41 167.63,208.65 167.63,197.55 168.53,196.65 168.53,97.5 188.1,77.92 188.1,60.58 183.67,56.15 181.73,56.15 181.62,56.04 180.96,56.04 180.44,56.56 179.76,56.56 179.24,56.04 178.71,56.04 177.91,56.84 177.79,56.84 176.99,56.04 176.46,56.04 175.72,56.78 175.48,56.78 174.74,56.04 174.21,56.04 173.57,56.68 173.13,56.68 172.49,56.04 171.96,56.04 171.32,56.68 170.88,56.68 170.24,56.04 169.58,56.04 167.72,57.9 SLOT06.F41
SL06_DP_136: length 222.7
  TOP w0.381: UNK6TP_OUT-_2.1 v1(170.91,235.54)
  L28_DP w0.079: v1(170.91,235.54) 170.5,235.13 170.5,234.49 170.44,234.44 170.44,234.05 170.5,233.99 170.5,233.09 170.45,233.05 170.45,232.66 170.5,232.61 170.5,212.11 166.32,207.93 166.32,198.02 168.1,196.24 168.1,97.32 187.4,78.01 187.4,60.65 184.14,57.39 180.71,57.39 180.37,57.04 179.83,57.04 179.36,57.51 178.59,57.51 178.12,57.04 177.58,57.04 177.11,57.51 176.34,57.51 175.87,57.04 175.33,57.04 175.03,57.35 174.18,57.35 173.69,56.86 173.01,56.86 172.48,57.39 171.97,57.39 171.44,56.86 170.76,56.86 169.76,57.86 169.63,57.86 169.07,58.42 169.07,58.97 169.63,59.52 170.32,59.52 170.81,59.03 171.64,59.03 171.96,59.34 172.49,59.34 172.85,58.99 173.85,58.99 174.21,59.34 175.03,59.34 175.33,59.04 176.16,59.04 176.46,59.34 177.28,59.34 177.58,59.04 178.41,59.04 178.71,59.34 179.24,59.34 179.54,59.04 180.21,59.04 180.56,58.69 SLOT06.Z41
SL06_DP_137: length 1.4
  BOTTOM w0.203: UNK6R15.1 196.79,167.38 v1(196.79,168.7)
SL06_DP_138: length 1.4
  BOTTOM w0.203: UNK6R17.1 191.71,167.38 v1(191.71,168.7)
SL06_DP_139: length 230.1
  TOP w0.381: UNK8TP_OUT+_1.1 v1(246.61,235.54)
  L30_DP w0.079: SLOT06.B39 177.08,56.34 178.12,56.34 178.5,55.96 178.5,55.58 178.74,55.34 179.24,55.34 180.06,54.52 180.44,54.52 180.93,54.04 180.93,53.91 181.07,53.76 187.53,53.76 200.11,66.35 200.11,75.62 203.95,79.46 203.95,86.86 201.48,89.33 201.48,120.81 243.37,162.7 243.37,171.84 238.82,176.38 238.42,176.38 238.14,176.66 238.14,177.06 236.79,178.42 236.28,178.42 236,178.69 236,179.2 235.99,179.21 235.99,183.44 235.67,183.76 235.67,188.72 235.36,189.02 235.36,193.65 234.72,194.29 234.72,197.77 234.82,197.86 234.82,198.49 234.72,198.59 234.72,211.96 234.6,212.09 234.6,216.84 234.75,216.99 234.75,221.07 234.7,221.12 234.7,223.46 235.6,224.36 235.6,224.68 235.88,224.95 236.19,224.95 241.54,230.3 242.6,230.3 245,232.7 245,233.91 246.61,235.53 v1(246.61,235.54)
SL06_DP_140: length 230.3
  TOP w0.381: UNK8TP_OUT-_1.1 v1(244.31,235.54)
  L30_DP w0.079: SLOT06.C39 175.14,56.69 175.25,56.81 175.92,56.81 176.46,57.34 176.99,57.34 177.37,56.96 177.37,56.8 177.65,56.52 178.19,56.52 178.64,56.08 178.67,56.08 179.23,55.52 179.32,55.52 180.14,54.7 180.32,54.7 180.96,55.34 181.49,55.34 182.79,54.05 187.04,54.05 199.83,66.83 199.83,75.8 203.64,79.61 203.64,86.58 201.13,89.09 201.13,120.94 242.36,162.17 242.36,171.39 238.77,174.97 238.32,174.97 238.04,175.25 238.04,175.7 237.05,176.69 237.05,177.05 236.78,177.33 236.42,177.33 235.32,178.42 235.32,178.67 235.39,178.73 235.39,179.57 235.32,179.63 235.32,181.87 235.39,181.93 235.39,182.77 235.32,182.83 235.32,184.07 235.39,184.14 235.39,188.6 234.61,189.38 234.61,193.48 234.44,193.65 234.44,197.88 234.54,197.98 234.54,198.37 234.25,198.67 234.25,223.79 243.5,233.04 243.5,234.38 244.31,235.19 v1(244.31,235.54)
SL06_DP_141: length 248.7
  TOP w0.381: UNK8TP_OUT+_2.1 v1(253.21,235.54)
  L30_DP w0.079: v1(253.21,235.54) 251.1,233.43 250.65,233.43 249.6,232.38 246.58,232.38 244.39,230.2 244.39,229.75 244.12,229.47 243.67,229.47 236.7,222.51 236.7,221.76 236.83,221.63 236.83,221.01 236.7,220.88 236.7,220.35 236.83,220.22 236.83,219.6 236.7,219.47 236.7,217.19 236.94,216.94 236.94,211.98 236.7,211.74 236.7,196.86 236.94,196.62 236.94,194.45 237.84,193.55 237.84,193.16 237.58,192.89 237.58,189.35 237.94,188.99 237.94,178.06 238.39,177.61 238.93,177.61 239.37,177.17 239.37,176.63 243.93,172.07 243.93,162.07 202.04,120.18 202.04,89.82 204.6,87.27 204.6,79.09 200.77,75.27 200.77,64.99 188.64,52.86 181.98,52.86 181.49,53.34 180.96,53.34 180.47,52.86 180.14,52.86 180.13,52.87 179.71,52.87 179.24,53.34 179.15,53.34 178.05,54.45 177.92,54.45 177.68,54.69 177.64,54.69 176.99,55.34 176.46,55.34 176,54.89 175.37,54.89 175.3,54.95 175.3,55.04 174.82,55.52 174.73,55.52 174.61,55.64 174.32,55.64 173.62,56.34 173.08,56.34 172.7,55.96 172.7,55.6 172.62,55.52 171.83,55.52 171.75,55.6 171.75,55.96 171.37,56.34 170.83,56.34 170.19,55.7 170.05,55.7 169.33,56.42 169.33,56.96 169.71,57.34 170.24,57.34 170.31,57.28 170.6,57.28 170.83,57.04 171.87,57.04 SLOT06.D39
SL06_DP_142: length 242.9
  TOP w0.381: UNK8TP_OUT-_2.1 v1(250.91,235.54)
  L30_DP w0.079: SLOT06.E39 171.46,56.69 171.58,56.58 171.58,56.42 171.96,56.04 172.49,56.04 172.87,56.42 172.87,56.69 173.03,56.84 173.71,56.84 173.83,56.73 173.83,56.42 174.21,56.04 174.74,56.04 175.33,56.63 175.87,56.63 176.46,56.04 176.75,56.04 177.2,55.59 177.2,55.42 177.91,54.72 178.03,54.72 178.79,53.96 179.45,53.96 179.83,54.34 180.37,54.34 180.75,53.96 180.75,53.74 180.96,53.52 181.57,53.52 181.82,53.27 181.96,53.27 182.04,53.19 187.87,53.19 200.39,65.71 200.39,75.43 204.27,79.31 204.27,87.02 201.76,89.53 201.76,120.49 243.65,162.38 243.65,171.95 239.09,176.52 239.09,177.05 238.81,177.33 238.28,177.33 236.94,178.66 236.94,182.24 236.94,182.25 236.94,183.54 236.66,183.81 236.55,183.81 235.95,184.42 235.95,188.83 235.75,189.03 235.75,193.9 235.29,194.37 235.29,205.86 236.42,206.99 236.42,211.85 236.55,211.98 236.55,216.94 236.42,217.07 236.42,217.33 235.74,218.01 235.74,218.17 235.6,218.3 235.6,218.69 235.74,218.83 235.74,218.91 236.42,219.59 236.55,219.71 236.55,220.1 236.3,220.35 236.3,220.87 236.55,221.12 236.55,221.51 236.3,221.76 236.3,222.62 236.55,222.87 236.55,223.48 241,227.93 241.1,227.93 241.37,228.21 241.37,228.31 245.45,232.38 245.81,232.38 246.08,232.66 246.08,233.01 248.61,235.54 v1(250.91,235.54)
SL06_DP_143: length 1.4
  BOTTOM w0.203: v1(276.79,168.7) 276.79,167.38 UNK8R15.1
SL06_DP_144: length 1.4
  BOTTOM w0.203: UNK8R17.1 271.71,167.38 v1(271.71,168.7)
SL13_DP_0: length 193.5
  L03_DP w0.079: v1(145.42,286.99) 145.42,290.24 157.07,301.9 157.07,329.04 216.23,388.21 216.23,394.21 229.02,407 238.08,407 238.7,406.38 239.3,406.38 239.86,406.94 240.41,406.94 241.1,406.25 241.46,406.25 242.17,405.54 242.83,405.54 243.22,405.94 243.77,405.94 244.59,405.12 245,405.12 245.48,404.64 246.02,404.64 246.32,404.94 247.15,404.94 247.97,404.12 248.34,404.12 248.83,403.63 248.83,403.35 249.18,403 249.36,403 249.91,402.46 250.59,402.46 251.07,402.94 251.64,402.94 252.3,402.28 252.3,399.67 251.82,399.18 251.07,399.18 250.52,398.64 250.39,398.64 249.39,397.64 248.86,397.64 248.48,398.02 247.69,398.02 245.96,396.29 SLOT13.C61
SL13_DP_1: length 219.1
  L03_DP w0.079: SLOT13.D61 247.24,395.92 248.41,395.92 248.7,395.64 249.64,395.64 252.66,398.65 252.66,402.43 251.79,403.3 251.16,403.3 250.52,403.94 250.16,403.94 249.95,404.14 249.95,404.63 249.47,405.12 249.09,405.12 248.27,405.94 247.73,405.94 247.29,405.5 246.71,405.5 246.09,406.12 245.71,406.12 244.89,406.94 244.36,406.94 243.72,406.3 243.54,406.3 242.72,407.12 242.34,407.12 241.52,407.94 240.98,407.94 240.34,407.3 239.91,407.3 239.27,407.94 238.73,407.94 238.23,407.43 236.61,407.43 236.49,407.55 236.05,407.55 235.98,407.63 228.76,407.63 215.6,394.47 215.6,388.47 156.32,329.18 156.32,304.83 138.96,287.48 138.96,284.85 141.18,282.63 141.18,278.4 139.99,277.21 139.99,267.53 v1(140.83,266.69)
SL13_DP_2: length 215.9
  L03_DP w0.079: SLOT13.E61 249.13,397.11 250.48,398.46 250.59,398.46 251.07,398.94 251.82,398.94 252.48,399.59 252.48,402.35 251.72,403.12 251,403.12 250.52,402.64 249.98,402.64 249.6,403.02 249.6,403.56 249.77,403.73 249.77,404.56 249.39,404.94 248.86,404.94 248.39,404.47 247.87,404.47 247.22,405.12 246.84,405.12 246.02,405.94 245.48,405.94 244.99,405.44 244.52,405.44 243.84,406.12 243.46,406.12 242.64,406.94 242.11,406.94 241.62,406.45 241.16,406.45 240.49,407.12 239.75,407.12 239.27,406.64 238.73,406.64 238.19,407.18 236.18,407.18 236.05,407.31 228.89,407.31 215.92,394.34 215.92,388.34 156.71,329.13 156.71,302.06 141.58,286.93 141.58,265.41 v1(140.83,264.66)
SL13_DP_3: length 222.7
  L03_DP w0.079: v1(136.26,264.66) 136.26,266.2 135.09,267.37 135.09,274.8 131.06,278.83 131.06,286.87 134.8,290.61 134.8,294.47 155.85,315.52 155.85,329.17 215.29,388.6 215.29,394.34 215.29,394.6 228.63,407.94 236.04,407.94 236.16,407.82 236.48,407.82 236.68,407.61 238.15,407.61 238.66,408.12 239.34,408.12 239.98,407.48 240.27,407.48 240.91,408.12 241.59,408.12 242.37,407.34 242.64,407.34 243.23,407.94 243.77,407.94 244.59,407.12 244.97,407.12 245.7,406.38 246.05,406.38 246.61,406.94 247.16,406.94 247.98,406.12 248.34,406.12 249.1,405.36 249.41,405.36 249.98,405.94 250.52,405.94 250.9,405.56 250.9,404.73 250.73,404.56 250.73,404.02 251.27,403.48 251.87,403.48 252.88,402.46 252.88,398.62 251.38,397.11 SLOT13.F61
SL13_DP_4: length 195.7
  L05_DP w0.079: SLOT13.A59 239.08,398.29 238.12,397.32 220.24,397.32 216.86,393.95 216.86,386.96 159.88,329.97 159.88,303.63 146.78,290.54 146.78,271.83 145.24,270.3 145.24,254.16 v1(146.06,253.35)
SL13_DP_5: length 222.2
  L05_DP w0.079: K15.2 133.66,242.38 131.01,245.02 131.01,258.46 132.74,260.18 142.4,260.18 144.24,262.02 144.24,283.37 146.45,285.59 146.45,290.73 159.56,303.84 159.56,330.1 216.55,387.09 216.55,393.82 216.55,394.08 220.1,397.64 238.14,397.64 238.52,398.02 238.52,398.3 238.86,398.64 239.27,398.64 239.57,398.94 240.68,398.94 241.33,398.29 SLOT13.B59
SL13_DP_6: length 186.7
  L05_DP w0.079: v1(148.22,258.18) 149.29,259.25 149.29,261.92 152.69,265.31 152.69,268.09 156.56,271.96 156.56,291.16 246.42,381.02 246.42,387.34 248.06,388.98 248.06,394.85 247.27,395.64 246.61,395.64 246.23,396.02 246.23,396.59 247.01,397.37 247.52,397.89 247.52,398.56 247.14,398.94 246.61,398.94 245.96,398.29 SLOT13.C59
SL13_DP_7: length 204.3
  L05_DP w0.079: SLOT13.D59 246.88,397.49 246.02,396.64 245.48,396.64 245.18,396.94 244.36,396.94 244.06,396.64 243.23,396.64 242.93,396.94 242.11,396.94 241.81,396.64 240.98,396.64 240.68,396.94 239.86,396.94 239.56,396.64 238.73,396.64 238.23,397.14 236.17,397.14 236.04,397.01 220.37,397.01 217.18,393.82 217.18,386.82 160.19,329.84 160.19,302.6 149.24,291.65 149.24,278.42 148.79,277.96 148.79,272.97 145.73,269.91 145.73,265.62 147.01,264.34 147.01,259.35 147.61,258.75 147.61,253.96 v1(148.22,253.35)
SL13_DP_8: length 207.9
  L03_DP w0.079: v1(151.01,253.35) 150.12,254.24 150.12,262.23 153.05,265.16 153.05,267.94 156.88,271.77 156.88,282.09 157.22,282.42 157.22,294.49 162.48,299.76 162.48,326.85 237.11,401.48 238.12,401.48 238.67,402.02 239.47,402.02 239.86,401.64 240.39,401.64 240.79,402.03 241.71,402.03 242.11,401.64 242.67,401.64 243.53,402.49 243.65,402.49 244.27,403.12 245,403.12 245.48,402.64 246.02,402.64 246.33,402.94 246.86,402.94 246.87,402.94 247.14,402.94 247.52,402.56 247.52,402.48 247.52,402.47 247.52,402.33 247.85,402 248.24,402 248.78,401.46 249.19,401.46 249.6,401.04 249.6,401.02 250.02,400.6 250.62,400.6 250.99,400.98 251.72,400.98 252.12,400.58 252.12,399.74 251.86,399.48 251.12,399.48 250.62,399.97 250,399.97 249.52,399.49 249.52,398.68 SLOT13.E59
SL13_DP_9: length 182
  L05_DP w0.079: SLOT13.F59 250.33,398.29 249.6,397.56 249.6,397.02 249.85,396.76 249.85,396.1 249.39,395.64 248.73,395.64 248.4,395.31 248.4,388.87 246.73,387.21 246.73,380.89 156.98,291.13 156.98,270.94 153.7,267.67 153.7,258.71 v1(153.17,258.18)
SL13_DP_10: length 196.8
  L03_DP w0.079: SLOT13.Z59 238.05,398.46 239.34,398.46 240.04,399.16 240.2,399.16 240.98,399.94 241.81,399.94 242.11,399.64 242.64,399.64 243.02,400.02 243.02,400.56 242.64,400.94 242.06,400.94 242.06,400.94 241.95,400.94 241.57,400.55 240.9,400.55 240.5,400.96 239.76,400.96 239.37,400.57 238.7,400.57 238.33,400.94 237.03,400.94 162.81,326.71 162.81,299.62 157.54,294.36 157.54,282.29 157.2,281.95 157.2,271.62 153.38,267.8 153.38,264.79 151.96,263.37 151.96,259.45 152.6,258.81 152.6,253.92 v1(153.17,253.35)
SL13_DP_11: length 196.1
  L03_DP w0.079: SLOT13.Z57 237.32,400.29 163.48,326.44 163.48,299.33 158.2,294.05 158.2,282 157.89,281.69 157.89,276.26 158.58,275.57 158.58,270.5 158.04,269.96 156.49,269.96 154.11,267.59 154.11,262.52 154.67,261.96 154.67,249.63 152.74,247.7 152.74,243.91 K23.2
SL13_DP_12: length 204.6
  L03_DP w0.079: K24.2 158.11,243.68 158.11,251.95 157.64,252.42 156.06,252.42 155.12,253.36 155.12,261.99 154.47,262.64 154.47,267.44 156.67,269.64 158.96,269.64 159.93,270.6 159.93,274.44 161.38,275.89 164.69,275.89 168.11,279.31 168.11,287.22 163.8,291.53 163.8,326.24 236.68,399.12 237.91,399.12 239.08,400.29 SLOT13.A57
SL13_DP_13: length 192.6
  L03_DP w0.079: SLOT13.B57 241.04,400.29 240.11,399.35 239.98,399.35 239.27,398.64 238.44,398.64 238.14,398.94 236.97,398.94 165.11,327.07 165.11,290.85 168.43,287.53 168.43,279.18 164.82,275.57 161.52,275.57 160.24,274.3 160.24,270.47 158.12,268.35 155.83,268.35 154.79,267.31 154.79,262.83 155.46,262.16 155.46,254.36 v1(156.47,253.35)
SL13_DP_14: length 177.9
  L03_DP w0.079: SLOT13.C57 245.07,399.84 245.07,398.76 245.27,398.56 245.27,398.02 244.89,397.64 244.07,397.64 243.77,397.94 243.23,397.94 242.75,397.46 242.3,397.46 242.08,397.24 242.08,396.94 241.59,396.46 241.3,396.46 240.27,395.43 237.51,395.43 237.18,395.76 236.57,395.76 170.4,329.59 170.4,291.34 170.02,290.97 170.02,278.01 167.62,275.6 167.62,270.47 166.39,269.24 166.39,264.42 164.73,262.76 164.73,261.75 v1(163.84,260.87)
SL13_DP_15: length 177.2
  L03_DP w0.079: SLOT13.D57 246.88,399.47 246.58,399.17 246.58,398.94 246.18,398.54 246.18,397.78 246.4,397.56 246.4,397.02 246.02,396.64 245.32,396.64 245.02,396.94 244.36,396.94 244.35,396.93 242.28,394.87 237.37,394.87 173.89,331.39 173.89,289.69 170.97,286.78 170.97,283.36 171.62,282.71 171.62,269.7 170.82,268.9 170.82,262.72 170.37,262.27 169.82,262.27 v1(168.42,260.87)
SL13_DP_16: length 180.2
  L03_DP w0.079: SLOT13.E57 248.81,400.6 247.82,400.6 247.79,400.63 247.73,400.63 247.24,401.12 247.22,401.12 246.5,401.12 246.02,400.64 245.35,400.64 245.05,400.94 244.32,400.94 243.98,400.59 243.98,400.02 244.33,399.66 244.33,398.94 243.84,398.46 243.26,398.46 243.02,398.22 243.02,398.02 242.64,397.64 242.12,397.64 241.9,397.42 241.9,397.02 241.52,396.64 240.98,396.64 240.34,397.28 239.93,397.28 238.29,395.64 237.61,395.64 237.11,396.14 236.37,396.14 169.41,329.18 169.41,294.32 170.05,293.68 170.05,291.56 169.7,291.21 169.7,278.26 166.53,275.09 166.53,270.4 164.81,268.67 164.81,265.64 v1(163.84,264.68)
SL13_DP_17: length 178.5
  L03_DP w0.079: SLOT13.F57 251.24,400.15 249.92,400.15 249.34,399.57 248.73,399.57 247.91,400.39 247.71,400.39 247.16,400.93 247.14,400.94 246.61,400.94 246.23,400.56 246.23,400.55 246.21,400.54 246.21,399.99 246.41,399.8 246.41,399.52 246.4,399.52 246.4,399.02 245.45,398.07 245.45,397.94 244.97,397.46 244.28,397.46 244.15,397.32 244.15,397.02 243.77,396.64 243.31,396.64 243.02,396.36 243.02,396.02 242.64,395.64 242.31,395.64 241.78,395.11 237.01,395.11 172.69,330.79 172.69,291.6 170.66,289.57 170.66,277.51 169.23,276.09 169.23,267.67 169.7,267.21 169.7,265.96 v1(168.42,264.68)
SL13_DP_18: length 184.9
  L05_DP w0.079: v1(163.84,267.72) 164.46,268.34 164.46,268.79 166.21,270.54 166.21,275.32 169.38,278.5 169.38,289.57 168.32,290.63 168.32,302.03 247.05,380.76 247.05,387.07 248.72,388.75 248.72,394.62 252.02,397.92 252.02,398.56 251.64,398.94 251.2,398.94 250.9,399.23 250.9,399.56 250.52,399.94 249.98,399.94 249.6,399.56 249.6,399.22 249.31,398.94 248.86,398.94 248.56,398.64 247.7,398.64 247.22,399.12 246.84,399.12 246.02,399.94 245.48,399.94 245.1,399.56 245.1,399.22 244.82,398.94 244.36,398.94 244,398.58 243.04,398.58 240.13,401.49 SLOT13.A55
SL13_DP_19: length 180.6
  L05_DP w0.079: v1(168.42,267.72) 167.51,268.63 167.51,269.83 167.96,270.27 167.96,275.38 170.34,277.76 170.34,290.33 171.61,291.6 171.61,304.87 247.36,380.63 247.36,386.94 249.04,388.62 249.04,394.68 250,395.64 251.64,395.64 252.2,396.2 252.2,398.79 251.47,399.53 251.18,399.53 250.59,400.12 249.87,400.12 249.39,399.64 248.86,399.64 248.38,400.12 247.62,400.12 247.14,399.64 246.61,399.64 246.13,400.12 245.37,400.12 244.89,399.64 244.36,399.64 243.88,400.12 243.46,400.12 242.82,400.76 242.82,401.84 SLOT13.B55
SL13_DP_20: length 171.4
  L03_DP w0.079: v1(163.84,270.77) 164.69,271.62 164.69,273.16 165,273.47 165,274.69 169.06,278.75 169.06,288.47 167.13,290.4 167.13,327.92 236.67,397.46 238.22,397.46 238.79,398.03 239.21,398.03 239.78,397.46 240.47,397.46 240.95,397.94 240.95,398.25 241.16,398.46 241.63,398.46 242.25,399.08 242.79,399.08 243.23,398.64 243.77,398.64 244.15,399.02 244.15,399.59 243.8,399.94 243.8,400.66 244.28,401.15 244.28,401.94 SLOT13.C55
SL13_DP_21: length 171.9
  L03_DP w0.079: v1(163.84,273.41) 164.68,274.24 164.68,274.9 168.74,278.97 168.74,287.69 166.09,290.34 166.09,327.43 236.3,397.64 238.14,397.64 238.72,398.21 239.28,398.21 239.86,397.64 240.39,397.64 240.77,398.02 240.77,398.33 241.08,398.64 241.52,398.64 241.9,399.02 241.9,399.37 241.99,399.46 242.72,399.46 243.2,399.94 243.2,400.65 242.75,401.1 242.75,401.46 243.5,402.21 243.63,402.21 244.36,402.94 244.89,402.94 245.62,402.21 246.8,402.21 SLOT13.D55
SL13_DP_22: length 181.5
  L03_DP w0.079: SLOT13.E55 248.65,402.76 248.65,403.56 248.27,403.94 247.73,403.94 247.41,403.61 246.64,403.61 246.61,403.64 246.61,403.64 246.23,404.02 246.23,404.02 246.05,404.2 245.46,404.2 245.27,404.02 244.8,403.54 244.42,403.54 243.84,404.12 243.16,404.12 242.65,403.6 242.06,403.6 241.62,404.04 240.92,404.04 240.52,403.64 239.75,403.64 239.45,403.94 238.44,403.94 238.04,403.53 236.73,403.53 161.22,328.03 161.22,300.65 154.28,293.71 154.28,273.97 v1(156.08,272.17)
SL13_DP_23: length 178.5
  L03_DP w0.079: SLOT13.F55 251.14,402.05 249.81,402.05 249.39,401.64 248.86,401.64 248.32,402.18 247.93,402.18 247.7,402.4 247.7,402.63 247.22,403.12 246.99,403.12 246.87,403.24 246.74,403.24 246.03,403.94 245.49,403.94 245.47,403.92 245.46,403.92 244.9,403.36 244.34,403.36 243.77,403.94 243.23,403.94 242.85,403.56 242.85,403.4 242.38,402.94 242.11,402.94 241.7,402.53 241.05,402.53 240.48,403.09 239.72,403.09 239.27,402.64 238.73,402.64 238.34,403.02 236.94,403.02 161.54,327.62 161.54,300.41 154.59,293.47 154.59,278.23 v1(156.08,276.75)
SL13_DP_24: length 155.7
  L03_DP w0.079: SLOT13.Z55 237.6,402.56 237.13,402.56 161.85,327.28 161.85,300.15 156.58,294.87 156.58,282.7 156.08,282.19 v1(156.08,281.32)
SL13_DP_25: length 167.8
  L03_DP w0.079: SLOT13.Z53 237.61,404.02 236.53,404.02 160.91,328.39 160.91,300.9 153.96,293.95 153.96,272.98 v1(153.15,272.17)
SL13_DP_26: length 160.5
  L03_DP w0.079: v1(153.15,282.59) 153.15,283.34 153.64,283.82 153.64,294.2 160.59,301.15 160.59,328.53 236.63,404.57 237.24,404.57 237.61,404.94 238.14,404.94 238.79,404.29 SLOT13.A53
SL13_DP_27: length 177.3
  L03_DP w0.079: v1(150.74,273.7) 151.55,274.51 151.55,292.68 160.28,301.41 160.28,328.7 218.28,386.71 218.28,393.36 229.81,404.88 237.3,404.88 237.53,405.12 238.22,405.12 238.87,404.47 239.39,404.47 239.86,404.94 240.39,404.94 241.04,404.29 SLOT13.B53
SL13_DP_28: length 170.1
  L03_DP w0.079: SLOT13.C53 243.93,404.29 243.87,404.35 243.23,404.35 242.64,404.94 242.11,404.94 241.64,404.47 241.15,404.47 240.34,405.28 239.93,405.28 239.27,405.94 238.73,405.94 238.21,405.41 229.84,405.41 217.93,393.51 217.93,386.87 159.96,328.9 159.96,301.64 151.22,292.91 151.22,284.6 v1(150.74,284.11)
SL13_DP_29: length 180.7
  L03_DP w0.079: SLOT13.D53 246.75,404.41 245.42,404.41 244.89,404.94 244.36,404.94 243.95,404.53 243.31,404.53 242.49,405.35 242.11,405.35 241.52,405.94 240.98,405.94 240.5,405.46 240,405.46 239.34,406.12 238.66,406.12 238.15,405.61 236.16,405.61 236.04,405.73 233.69,405.73 233.37,406.05 229.41,406.05 217.18,393.82 217.18,387.27 158.51,328.61 158.51,301.6 148.87,291.95 148.87,278.81 v1(148.33,278.27)
SL13_DP_30: length 342.6
  L05_DP w0.079: v1(225.41,286.99) 225.25,286.99 224.29,286.04 224.29,274.96 224.63,274.63 224.63,265.87 227,263.5 243.39,263.5 244.82,262.07 244.82,260.34 248.61,256.54 248.61,246.18 243.46,241.03 233.48,241.03 232.52,241.99 232.52,247.71 235.23,250.43 235.23,253.17 234.45,253.96 233,253.96 232.7,253.65 232.7,252.83 232.14,252.27 230.94,252.27 230.45,251.79 230.45,250.13 229.62,249.3 227.22,249.3 225.44,247.52 225.44,243.81 222.28,240.65 212.9,240.65 211.21,242.34 211.21,246.62 212.64,248.04 217.72,248.04 219.17,249.49 224.24,249.49 225.43,250.67 227.25,250.67 227.75,251.16 227.75,253.7 227.24,254.2 225.48,254.2 225.07,254.61 225.07,258.59 222.71,260.95 222.71,262.4 222.07,263.04 222.07,263.86 221.3,264.63 221.3,264.86 221.02,265.13 220,265.13 219.92,265.21 219.92,266.82 219.57,267.17 214.64,267.17 213.17,268.64 213.17,275.17 213.17,275.69 209.85,279.01 209.85,287.06 211.77,288.98 214.12,288.98 215.42,290.28 215.42,296.52 217.72,298.83 217.72,302.73 220.64,305.65 220.64,324.38 258.07,361.81 258.07,401.1 255.27,403.9 254.35,403.9 254.08,403.63 251.11,403.63 250.63,404.12 249.29,404.12 SLOT13.E53
SL13_DP_31: length 171.7
  L05_DP w0.079: SLOT13.F53 255.33,404.29 258.38,401.23 258.38,361.68 220.96,324.25 220.96,305.52 218.04,302.6 218.04,298.7 215.73,296.39 215.73,290.15 214.25,288.67 211.9,288.67 210.16,286.93 210.16,279.14 213.48,275.82 213.48,275.04 213.48,268.77 214.77,267.49 220.04,267.49 v1(220.83,266.69)
SL13_DP_32: length 223.7
  L05_DP w0.079: v1(220.83,264.66) 221.76,263.73 221.76,260.58 222.09,260.24 222.98,260.24 224.76,258.46 224.76,254.48 225.35,253.89 227.09,253.89 227.43,253.54 227.43,252.95 226.83,252.34 222.18,252.34 221.13,253.39 221.13,257.5 220.03,258.6 220.03,262.14 219.11,263.05 211.83,263.05 210.91,263.97 209.86,263.97 209.33,264.5 209.33,265.74 208.49,266.58 208.49,267.02 209.36,267.89 209.36,269.32 208.9,269.78 208.9,288.38 211.91,291.38 213.73,291.38 214.29,291.95 214.29,296.73 216.78,299.22 216.78,303.13 219.7,306.05 219.7,324.78 257.12,362.2 257.12,400.71 254.88,402.96 251.13,402.96 250.52,402.34 249.99,402.34 249.39,402.94 248.86,402.94 248.27,402.34 247.74,402.34 247.14,402.94 246.61,402.94 246.02,402.35 245.48,402.35 244.89,402.94 244.36,402.94 243.77,402.35 243.26,402.35 240.13,405.49 SLOT13.A51
SL13_DP_33: length 181.1
  L05_DP w0.079: v1(216.26,264.66) 212.54,268.38 212.54,275.43 209.22,278.75 209.22,288.25 212.04,291.07 213.86,291.07 214.79,292 214.79,296.79 217.09,299.09 217.09,303 220.01,305.92 220.01,324.64 257.44,362.07 257.44,400.84 255.01,403.27 251.19,403.27 250.55,402.64 249.95,402.64 249.47,403.12 248.78,403.12 248.3,402.64 247.7,402.64 247.22,403.12 246.53,403.12 245.95,402.53 245.56,402.53 244.97,403.12 244.25,403.12 243.77,402.64 243.23,402.64 242.82,403.05 242.82,403.61 243.02,403.82 243.02,404.56 242.38,405.2 SLOT13.B51
SL13_DP_34: length 197.4
  L05_DP w0.079: SLOT13.C51 244.63,405.4 246.69,403.33 247.13,403.33 247.73,403.94 248.27,403.94 248.87,403.33 249.38,403.33 249.98,403.94 250.52,403.94 251,403.45 254.22,403.45 254.35,403.59 255.14,403.59 257.75,400.97 257.75,361.94 220.33,324.51 220.33,305.79 217.41,302.87 217.41,298.96 215.1,296.65 215.1,291.87 213.99,290.75 212.17,290.75 209.53,288.12 209.53,278.88 212.85,275.56 212.85,268.51 216.23,265.13 219.27,265.13 219.8,264.61 219.8,263.82 221.44,262.18 221.44,253.52 222.31,252.66 225.37,252.66 v1(226.06,253.35)
SL13_DP_35: length 221.5
  L05_DP w0.079: SLOT13.D51 246.88,405.49 247.73,404.64 248.27,404.64 248.76,405.12 249.5,405.12 249.98,404.64 250.52,404.64 251.52,405.64 251.64,405.64 251.93,405.92 254.62,405.92 259.01,401.53 259.01,361.42 221.59,323.99 221.59,305.26 218.67,302.34 218.67,290.15 216.75,288.24 215.87,288.24 213.75,286.12 211.97,286.12 210.79,284.95 210.79,279.4 214.11,276.08 214.11,274.2 218.19,270.13 218.19,268.5 218.52,268.17 220.46,268.17 222.02,266.62 222.02,264.81 222.7,264.12 222.7,263.3 223.34,262.67 223.34,261.21 225.39,259.16 226.89,259.16 227.61,258.44 227.61,254.9 228.22,254.29 229.35,254.29 229.55,254.1 229.55,253.58 230.14,253 230.14,250.26 229.49,249.61 227.09,249.61 225.12,247.65 225.12,243.94 224.53,243.36 214.66,243.36 UNK3K15.2
SL13_DP_36: length 180.4
  L05_DP w0.079: SLOT13.E51 249.79,406.29 249.8,406.3 250.47,406.3 251.11,406.94 254.22,406.94 254.35,406.8 255.87,406.8 260.86,401.81 260.86,362.82 221.9,323.86 221.9,300.22 220.5,298.82 220.5,296.73 221.17,296.07 221.17,285.59 220.5,284.92 220.5,283.33 221.37,282.47 221.37,272.96 222.74,271.59 222.74,269.05 221.81,268.13 221.81,267.39 222.74,266.46 222.74,265.08 226.21,261.61 227.94,261.61 228.69,260.86 228.69,258.65 v1(228.22,258.18)
SL13_DP_37: length 201.6
  L05_DP w0.079: v1(228.22,253.35) 228.22,253.68 227.38,254.52 225.61,254.52 225.39,254.74 225.39,258.72 223.03,261.08 223.03,262.53 222.39,263.17 222.39,263.99 221.62,264.77 221.62,266.57 220.33,267.85 217.44,267.85 216.96,268.33 216.96,270.91 213.8,274.07 213.8,275.95 210.48,279.27 210.48,285.08 211.84,286.43 213.62,286.43 215.74,288.55 216.62,288.55 218.35,290.28 218.35,302.47 221.27,305.39 221.27,324.12 258.7,361.55 258.7,401.37 255.26,404.81 254.35,404.81 254.22,404.94 251.11,404.94 250.62,404.45 249.88,404.45 249.39,404.94 248.86,404.94 248.38,404.46 247.62,404.46 246.18,405.9 246.18,406.51 246.61,406.94 247.14,406.94 248.14,405.94 248.27,405.94 248.57,405.64 249.64,405.64 250.11,406.12 250.54,406.12 250.71,406.29 SLOT13.F51
SL13_DP_38: length 195.4
  L05_DP w0.079: v1(231.01,253.35) 230.18,254.18 230.18,260.25 228.2,262.24 226.47,262.24 223.37,265.34 223.37,271.95 222.14,273.17 222.14,299.54 223.47,300.88 223.47,324.54 261.49,362.56 261.49,402.07 256.13,407.43 255.61,407.43 254.35,407.43 254.22,407.3 251.16,407.3 250.52,407.94 249.98,407.94 249.47,407.43 248.78,407.43 248.27,407.94 247.73,407.94 247.22,407.43 246.53,407.43 246.02,407.94 245.48,407.94 244.95,407.4 244.31,407.4 243.77,407.94 243.23,407.94 242.79,407.49 241.97,407.49 241.36,408.1 240.31,408.1 SLOT13.A49
SL13_DP_39: length 189.4
  L05_DP w0.079: v1(233.17,258.18) 232.41,258.94 232.41,260.18 230.03,262.55 226.61,262.55 223.68,265.47 223.68,274.24 223.35,274.57 223.35,300.31 223.79,300.75 223.79,324.41 261.81,362.43 261.81,402.2 256.26,407.75 255.48,407.75 254.35,407.75 254.08,407.48 251.23,407.48 250.59,408.12 249.91,408.12 249.4,407.61 248.89,407.61 248.38,408.12 247.66,408.12 247.18,407.64 246.61,407.64 246.13,408.12 245.41,408.12 244.93,407.64 244.32,407.64 243.77,408.19 242.47,408.19 SLOT13.B49
SL13_DP_40: length 261.7
  L05_DP w0.079: v1(233.17,253.35) 233.17,252.69 232.63,252.16 232.63,249.94 230.94,248.24 227.97,248.24 226.76,247.03 226.76,238.62 227.71,237.67 239.64,237.67 242.23,240.25 244.09,240.25 249.69,245.85 249.69,257.42 247.48,259.63 247.48,262.28 245.63,264.13 227.26,264.13 225.57,265.81 225.57,271.09 225.89,271.4 225.89,286.3 226.22,286.63 226.22,292.57 235.67,302.02 235.67,334.52 263.07,361.91 263.07,402.72 256.56,409.23 254.35,409.23 253.95,408.83 252.37,408.83 251.9,409.3 251.16,409.3 250.52,409.94 249.98,409.94 249.16,409.12 248.78,409.12 248.3,408.64 247.73,408.64 247.43,408.94 246.61,408.94 245.97,408.3 245.33,408.3 245.32,408.29 SLOT13.C49
SL13_DP_41: length 234.4
  L05_DP w0.079: SLOT13.D49 247.57,408.29 247.58,408.3 248.22,408.3 248.86,408.94 249.39,408.94 249.74,408.59 250.51,408.59 251.03,409.12 251.72,409.12 252.19,408.65 254.08,408.65 254.35,408.92 255.38,408.92 255.38,408.92 256.43,408.92 262.75,402.59 262.75,362.04 235.36,334.65 235.36,302.15 225.9,292.7 225.9,286.76 224.73,285.59 224.73,275.02 224.94,274.81 224.94,266 227.13,263.81 245.02,263.81 246.39,262.45 246.39,260.23 249.37,257.24 249.37,246.04 243.9,240.57 242.1,240.57 241.68,240.16 239.02,240.16 238.53,239.66 236.44,239.66 235.95,240.16 233.38,240.16 UNK3K23.2
SL13_DP_42: length 204.9
  L05_DP w0.079: UNK3K24.2 237.96,243.83 237.96,257.39 238.46,257.89 238.46,261.27 236.54,263.18 226.87,263.18 224.31,265.74 224.31,274.5 223.98,274.83 223.98,291.21 235.04,302.28 235.04,334.78 262.44,362.17 262.44,402.46 256.3,408.6 255.25,408.6 255.25,408.6 254.48,408.6 254.35,408.47 252.11,408.47 251.64,408.94 251.11,408.94 250.58,408.41 249.71,408.41 249.58,408.29 SLOT13.E49
SL13_DP_43: length 187
  L05_DP w0.079: v1(236.47,253.35) 236.47,253.44 235.73,254.18 235.73,260.04 232.9,262.87 226.74,262.87 224,265.61 224,274.37 223.66,274.7 223.66,300.18 224.1,300.62 224.1,324.28 262.12,362.3 262.12,402.33 256.17,408.29 255.12,408.29 SLOT13.F49
SL13_DP_44: length 247.3
  L05_DP w0.079: SLOT13.Z49 239.21,408.29 240.86,406.64 241.55,406.64 242.03,407.12 242.75,407.12 243.23,406.64 243.77,406.64 244.25,407.12 245,407.12 245.48,406.64 246.02,406.64 246.5,407.12 247.25,407.12 247.73,406.64 248.27,406.64 248.75,407.12 249.5,407.12 249.98,406.64 250.52,406.64 251,407.12 255.74,407.12 256,407.12 261.18,401.94 261.18,362.69 222.22,323.73 222.22,300.09 221.68,299.56 221.68,273.09 223.05,271.72 223.05,265.21 226.34,261.92 228.07,261.92 229.87,260.12 229.87,253.8 231.08,252.59 232.01,252.59 232.38,252.96 232.38,253.79 232.87,254.27 234.58,254.27 235.55,253.3 235.55,242.11 236.32,241.34 243.33,241.34 248.3,246.31 248.3,256.41 v1(243.84,260.87)
SL13_DP_45: length 213.3
  L05_DP w0.079: v1(248.42,260.87) 248.89,261.34 248.89,262.39 247.5,263.78 247.5,265.72 247.1,266.12 236.96,266.12 236.6,266.48 234.81,266.48 232.78,264.45 227.38,264.45 225.89,265.94 225.89,270.96 226.2,271.27 226.2,286.17 226.53,286.5 226.53,292.44 235.99,301.89 235.99,334.38 263.38,361.78 263.38,402.85 256.69,409.55 254.35,409.55 253.81,409.01 252.44,409.01 251.97,409.48 251.23,409.48 250.59,410.12 249.91,410.12 249.28,409.49 248.72,409.49 248.27,409.94 247.73,409.94 246.91,409.12 246.53,409.12 245.97,408.56 245.27,408.56 244.89,408.94 244.36,408.94 243.79,408.37 243.21,408.37 242.64,408.94 242.11,408.94 241.5,408.33 241,408.33 240.39,408.94 239.93,408.94 239.65,409.21 239.65,409.56 239.27,409.94 238.93,409.94 238.57,410.29 SLOT13.Z47
SL13_DP_46: length 232.5
  L05_DP w0.079: SLOT13.A47 240.13,409.46 240.95,408.64 241.55,408.64 242.03,409.12 242.75,409.12 243.22,408.64 243.8,408.64 244.28,409.12 244.66,409.12 245.48,409.94 246.31,409.94 246.61,409.64 247.18,409.64 247.66,410.12 248.1,410.12 248.48,410.49 248.48,410.56 248.86,410.94 249.39,410.94 249.85,410.48 250.39,410.48 251.03,411.12 251.91,411.12 252.38,410.65 254.08,410.65 254.35,410.92 255.4,410.92 255.4,410.92 255.92,410.92 256.35,410.49 257.08,410.49 264.33,403.24 264.33,361.39 236.93,333.99 236.93,301.5 229.12,293.68 229.12,285.54 228.81,285.24 228.81,272.68 230.49,271 233.72,271 234.38,271.66 234.38,272.67 234.86,273.16 236.61,273.16 237.13,273.68 237.13,274.48 237.92,275.27 245.89,275.27 246.48,274.69 246.48,270.71 245.31,269.55 243.66,269.55 243.23,269.12 243.23,267.3 243.81,266.73 247.24,266.73 247.81,266.16 247.81,264.37 248.28,263.9 250.14,263.9 250.86,263.18 250.86,260.02 250.23,259.39 248.54,259.39 247.79,260.14 247.79,262.41 246.07,264.13 246.07,264.87 245.79,265.15 244.31,265.15 v1(243.84,264.68)
SL13_DP_47: length 226.3
  L05_DP w0.079: v1(248.42,264.68) 249.81,266.07 250.74,266.07 252.23,267.56 252.23,274.07 250.17,276.13 250.17,284.85 248.92,286.1 239.34,286.1 238.14,284.9 238.14,282.05 237.57,281.49 237.57,276.7 236.83,275.95 234.79,275.95 234.28,276.47 234.28,281.09 234.98,281.79 235.65,281.79 236.56,282.71 236.56,287.22 238.82,289.48 238.82,333.21 266.22,360.6 266.22,382.9 272.42,389.1 272.42,397.82 257.86,412.38 257.13,412.38 256.28,413.23 256.02,413.23 254.35,413.23 254.09,412.97 252.28,412.97 251.95,413.3 251.15,413.3 250.52,413.94 249.98,413.94 249.16,413.12 248.78,413.12 248.25,412.58 247.5,412.58 247.14,412.94 246.61,412.94 246.23,412.56 246.23,412.02 246.4,411.84 246.4,411.02 246.24,410.86 246.24,410.82 245.88,410.47 245.36,410.47 244.89,410.94 244.36,410.94 243.71,410.29 SLOT13.B47
SL13_DP_48: length 206.7
  L05_DP w0.079: v1(243.84,267.72) 244.52,267.04 248.4,267.04 248.89,267.53 248.89,274.49 247.48,275.9 237.31,275.9 236.27,274.86 234.47,274.86 233.96,274.35 233.96,273.38 233.67,273.1 233.67,272.02 233.35,271.7 231.58,271.7 230.27,273 230.27,274.03 231.72,275.48 231.72,282.01 231.47,282.26 231.47,282.91 232.37,283.82 232.63,283.82 233.49,283.82 233.64,283.97 233.64,286.08 237.56,290 237.56,333.73 264.96,361.13 264.96,403.5 257.34,411.12 256.61,411.12 256.18,411.55 255.14,411.55 254.35,411.55 254.17,411.36 254.17,411.3 253.87,411.01 252.53,411.01 252.06,411.48 251.23,411.48 250.59,412.12 249.91,412.12 249.31,411.52 248.68,411.52 248.27,411.94 247.73,411.94 247.35,411.56 247.35,411.12 247.16,410.94 246.6,410.94 246.42,410.75 246.42,410.75 245.96,410.29 SLOT13.C47
SL13_DP_49: length 200.4
  L05_DP w0.079: v1(248.42,267.72) 247.65,268.49 247.65,269.22 248.58,270.15 248.58,274.36 247.35,275.59 237.44,275.59 236.4,274.55 234.71,274.55 234.32,274.15 234.32,273.06 234.06,272.8 234.06,271.79 233.59,271.32 230.62,271.32 229.17,272.77 229.17,284.59 229.55,284.97 230.81,284.97 231.22,285.38 231.22,286.14 231.66,286.58 233.7,286.58 237.25,290.13 237.25,333.86 264.64,361.26 264.64,403.37 257.21,410.81 256.48,410.81 256.05,411.23 255.27,411.23 254.35,411.23 253.95,410.83 252.45,410.83 251.98,411.3 251.16,411.3 250.52,411.94 249.98,411.94 249.16,411.12 248.78,411.12 248.3,410.64 247.78,410.64 247.43,410.29 SLOT13.D47
SL13_DP_50: length 190.5
  L05_DP w0.079: v1(243.84,270.77) 244.71,271.63 244.71,274.33 244.36,274.68 243.46,274.68 243.09,274.32 243.09,273.3 242.64,272.84 234.99,272.84 234.69,272.54 234.69,271.53 233.85,270.69 230.36,270.69 228.83,272.22 227.41,272.22 226.83,272.8 226.83,284.71 227.04,284.92 228.05,284.92 228.8,285.67 228.8,293.81 236.62,301.63 236.62,334.12 264.01,361.52 264.01,403.11 256.95,410.18 256.22,410.18 255.79,410.6 255.53,410.6 254.35,410.6 254.22,410.47 252.3,410.47 251.83,410.94 251.11,410.94 250.47,410.3 249.83,410.3 249.82,410.29 SLOT13.E47
SL13_DP_51: length 192.5
  L05_DP w0.079: v1(243.84,273.41) 242.92,272.48 242.92,267.54 242.42,267.04 233.99,267.04 231.64,264.69 227.58,264.69 226.2,266.07 226.2,270.83 226.52,271.14 226.52,286.03 226.85,286.37 226.85,292.3 236.3,301.76 236.3,334.25 263.7,361.65 263.7,402.98 256.82,409.86 256.09,409.86 255.66,410.29 SLOT13.F47
SL13_DP_52: length 215.8
  L03_DP w0.079: v1(236.07,272.17) 234.28,273.97 234.28,336.07 260.78,362.57 260.78,382.54 265.29,387.05 265.29,414.76 253.94,426.12 252.46,426.12 251.64,426.94 251.52,426.94 248.33,430.13 247.63,430.13 247.14,429.64 246.61,429.64 246.13,430.12 245.37,430.12 244.73,429.48 244.48,429.48 243.84,430.12 243.16,430.12 242.52,429.48 242.23,429.48 241.59,430.12 240.91,430.12 240.35,429.56 239.9,429.56 239.34,430.12 238.81,430.12 238.66,430.12 237.84,429.3 237.46,429.3 236.69,428.52 236.69,421.79 237.45,421.03 237.45,420.77 237.23,420.56 237.23,420.02 237.61,419.64 238.09,419.64 238.17,419.56 238.17,418.94 238.33,418.78 238.33,418.75 238.52,418.56 238.52,418.02 238.33,417.83 238.33,417.79 236.71,416.17 236.71,412.53 237.61,411.64 238.14,411.64 238.79,412.29 SLOT13.A45
SL13_DP_53: length 177.7
  L05_DP w0.079: SLOT13.B45 243.71,412.29 245.36,413.94 246.02,413.94 246.27,413.68 246.32,413.64 247.18,413.64 247.66,414.12 248.04,414.12 248.86,414.94 249.41,414.94 249.86,414.48 250.39,414.48 251.03,415.12 251.72,415.12 252.2,414.63 252.2,413.81 252.5,413.51 253.69,413.51 254.35,414.18 255.63,414.18 255.89,414.18 256.67,414.18 257.52,413.33 258.25,413.33 273.36,398.22 273.36,388.71 267.16,382.51 267.16,360.21 239.77,332.82 239.77,289.09 237.51,286.83 237.51,282.31 236.94,281.75 236.94,278.53 236.07,277.66 v1(236.07,276.75)
SL13_DP_54: length 168.1
  L05_DP w0.079: SLOT13.C45 245.7,412.29 246.53,413.12 246.91,413.12 247.73,413.94 248.27,413.94 248.7,413.51 249.3,413.51 249.91,414.12 250.63,414.12 250.93,413.82 251.26,413.48 252.02,413.48 252.35,413.15 253.96,413.15 254.35,413.55 255.89,413.55 256.15,413.55 256.41,413.55 257.26,412.7 257.99,412.7 272.73,397.96 272.73,388.97 266.53,382.77 266.53,360.47 239.14,333.08 239.14,289.35 236.88,287.09 236.88,282.58 236.07,281.77 v1(236.07,281.32)
SL13_DP_55: length 174.2
  L05_DP w0.079: SLOT13.D45 248.21,412.29 248.86,412.94 249.39,412.94 249.85,412.48 250.39,412.48 251.03,413.12 251.85,413.12 252.32,412.65 254.08,412.65 254.35,412.92 256.15,412.92 257,412.07 257.21,412.07 257.73,412.07 272.1,397.69 272.1,389.23 265.9,383.03 265.9,360.74 238.51,333.34 238.51,289.61 234.58,285.68 234.58,283.57 233.96,282.95 233.96,274.81 233.64,274.49 233.64,273.51 233.15,273.03 v1(233.15,272.17)
SL13_DP_56: length 160.4
  L05_DP w0.079: v1(233.15,282.59) 234.27,283.7 234.27,285.81 238.19,289.74 238.19,333.47 265.59,360.87 265.59,383.16 271.79,389.36 271.79,397.56 257.6,411.75 257.34,411.75 257.34,411.75 257.08,411.75 257.08,411.75 256.87,411.75 256.02,412.6 254.35,412.6 254.22,412.47 252.24,412.47 251.77,412.94 251.11,412.94 250.47,412.3 249.83,412.3 249.82,412.29 SLOT13.E45
SL13_DP_57: length 165.5
  L05_DP w0.079: SLOT13.F45 255.89,412.29 256.74,411.44 257.21,411.44 257.47,411.44 265.27,403.63 265.27,361 237.88,333.6 237.88,289.87 233.95,285.95 233.95,283.84 233.62,283.5 232.5,283.5 231.78,282.78 231.78,282.39 232.35,281.83 233.31,281.83 233.65,281.49 233.65,274.95 233.42,274.72 231.76,274.72 v1(230.74,273.7)
SL13_DP_58: length 202.9
  L03_DP w0.079: SLOT13.Z45 237.04,413.13 237.04,414.97 237.71,415.64 238.14,415.64 238.52,416.02 238.52,416.56 238.14,416.94 238.14,417.35 238.85,418.05 238.85,418.52 238.35,419.02 238.35,419.56 238.85,420.05 238.85,420.38 238.77,420.46 238.66,420.46 238.17,420.94 238.17,421.2 238.09,421.28 237.46,421.28 236.87,421.87 236.87,422.71 237.35,423.19 237.35,423.38 236.87,423.87 236.87,428.45 237.53,429.12 237.91,429.12 238.73,429.94 239.27,429.94 239.91,429.3 240.34,429.3 240.98,429.94 241.52,429.94 242.16,429.3 242.59,429.3 243.23,429.94 243.77,429.94 244.41,429.3 244.84,429.3 245.48,429.94 246.02,429.94 246.66,429.3 247.09,429.3 247.73,429.94 248.27,429.94 248.65,429.56 248.65,429.02 248.15,428.52 248.15,428.31 248.82,427.64 248.95,427.64 250.47,426.12 250.59,426.12 251.41,425.3 251.59,425.3 252.23,425.94 253.62,425.94 264.03,415.52 264.03,387.57 259.52,383.06 259.52,363.1 231.22,334.8 231.22,284.6 v1(230.74,284.11)
SL13_DP_59: length 206.8
  L03_DP w0.079: v1(228.33,278.27) 228.87,278.81 228.87,333.33 258.89,363.36 258.89,383.32 263.4,387.83 263.4,415.71 254.58,424.53 252.31,424.53 251.72,425.12 251.34,425.12 250.52,425.94 249.87,425.94 249.77,426.03 249.77,426.56 249.39,426.94 248.87,426.94 248.65,427.16 248.65,427.56 248.27,427.94 247.87,427.94 247.7,428.1 247.7,428.63 247.22,429.12 246.53,429.12 245.89,428.48 245.61,428.48 244.97,429.12 244.28,429.12 243.64,428.48 243.36,428.48 242.72,429.12 242.03,429.12 241.39,428.48 241.11,428.48 240.47,429.12 239.78,429.12 238.96,428.3 238.78,428.3 238.14,428.94 237.61,428.94 237.05,428.37 237.05,423.94 237.53,423.46 237.53,423.12 237.05,422.63 237.05,421.94 237.53,421.46 238.27,421.46 238.35,421.38 238.35,421.02 238.73,420.64 239.22,420.64 239.3,420.56 239.3,419.94 239.78,419.46 240.32,419.46 240.42,419.36 240.42,418.94 240.8,418.56 240.8,417.75 240.6,417.56 240.6,417.25 240.29,416.94 239.86,416.94 239.48,416.56 239.48,416.02 239.92,415.58 239.92,415.03 239.17,414.29 SLOT13.Z43
SL13_DP_60: length 261.4
  L05_DP w0.079: SLOT13.A43 239.87,414.54 238.82,414.54 237.99,415.38 235.25,415.38 233.42,413.55 233.42,404.13 228.2,398.9 219.58,398.9 215.29,394.6 215.29,393.3 215.29,393.3 215.29,387.61 158.3,330.62 158.3,304.36 148.51,294.57 146.78,294.57 140.92,288.71 131.77,288.71 127.58,284.52 127.58,241.63 132.9,236.31 140.14,236.31 145.42,231.04 v1(145.42,226.99)
SL13_DP_61: length 296.1
  L03_DP w0.079: v1(140.83,206.69) 139.99,207.53 139.99,217.21 141.18,218.4 141.18,222.63 138.4,225.41 134.19,225.41 133.39,226.21 119.86,226.21 114.77,231.29 114.77,301.7 223.87,410.8 237.47,410.8 237.61,410.94 238.14,410.94 238.78,410.3 239.22,410.3 239.86,410.94 240.46,410.94 240.82,410.58 241.49,410.58 242.55,411.64 242.64,411.64 243.64,412.64 243.77,412.64 244.15,413.02 244.15,413.56 243.71,413.99 242.67,413.99 SLOT13.B43
SL13_DP_62: length 296.9
  L03_DP w0.079: v1(140.83,204.66) 141.58,205.41 141.58,227.51 140.47,228.62 122.8,228.62 115.09,236.33 115.09,301.57 223.48,409.96 236.04,409.96 236.44,409.56 238.1,409.56 238.66,410.12 239.34,410.12 239.9,409.56 240.35,409.56 240.91,410.12 241.54,410.12 241.73,410.3 241.73,410.56 242.11,410.94 242.74,410.94 242.85,411.05 242.85,411.56 243.23,411.94 243.74,411.94 243.98,412.18 243.98,412.56 244.63,413.2 SLOT13.C43
SL13_DP_63: length 290.7
  L03_DP w0.079: v1(136.26,204.66) 136.26,206.2 135.09,207.37 135.09,214.8 131.06,218.83 126.66,218.83 114.46,231.04 114.46,301.83 223.74,411.12 238.22,411.12 238.85,410.48 239.15,410.48 239.78,411.12 240.38,411.12 240.6,411.34 240.6,411.56 240.98,411.94 241.2,411.94 241.73,412.46 241.73,412.56 241.91,412.74 241.91,413.84 241.73,414.02 241.73,414.56 242.11,414.94 242.64,414.94 242.94,414.64 243.77,414.64 244.14,415.01 245.11,415.01 245.48,414.64 246.02,414.64 246.07,414.69 246.47,414.69 SLOT13.D43
SL13_DP_64: length 304.5
  L05_DP w0.079: SLOT13.A37 240.42,419.99 240.42,418.94 240.84,418.52 240.84,418.05 240.42,417.63 240.42,417.5 239.48,416.56 239.48,416.02 239.71,415.79 239.71,415.75 239.8,415.66 239.83,415.66 239.86,415.64 239.95,415.64 240.95,414.63 240.95,413.94 240.47,413.46 239.78,413.46 239.3,413.94 238.71,413.94 238.66,413.88 238.42,413.64 237.61,413.64 236.5,414.75 235.51,414.75 234.05,413.29 234.05,403.86 228.46,398.27 219.84,398.27 215.92,394.34 215.92,393.56 215.92,387.35 158.93,330.36 158.93,304.1 148.77,293.94 147.04,293.94 141.92,288.82 141.92,276.14 139.22,273.43 136.82,273.43 128.76,265.37 128.76,241.59 133.27,237.08 137.22,237.08 138.55,238.41 144.79,238.41 146.22,236.98 146.22,226.58 144.64,225 144.64,194.77 v1(146.06,193.35)
SL13_DP_65: length 327.2
  L05_DP w0.079: SLOT13.B37 242.05,420.62 241,420.62 240.39,421.23 239.86,421.23 239.36,420.73 239.36,419.84 239.65,419.56 239.65,419.02 239.36,418.73 239.36,418.13 239.9,417.59 239.9,417.24 239.3,416.63 239.3,415.94 239.53,415.71 239.53,415.68 239.72,415.48 239.76,415.48 239.9,415.33 239.9,415.01 239.98,414.94 240.39,414.94 240.77,414.56 240.77,414.02 240.39,413.64 239.86,413.64 239.48,414.02 239.48,414.13 239.25,414.36 238.75,414.36 238.05,415.06 235.38,415.06 233.74,413.42 233.74,403.99 228.33,398.58 219.71,398.58 215.6,394.47 215.6,393.43 215.6,393.43 215.6,387.48 158.62,330.49 158.62,304.23 148.64,294.26 146.91,294.26 141.61,288.95 141.61,276.27 139.09,273.75 136.69,273.75 128.15,265.21 128.15,241.56 133.08,236.62 140.27,236.62 145.9,231 145.9,226.71 144.24,225.05 144.24,202.02 142.4,200.18 132.74,200.18 131.01,198.46 131.01,185.02 133.66,182.38 UNK5K15.2
SL13_DP_66: length 280.1
  L03_DP w0.079: v1(148.22,198.18) 149.29,199.25 149.29,201.92 152.69,205.31 152.69,208.09 156.63,212.03 156.63,212.33 156.98,212.68 156.98,213.61 156.63,213.96 156.63,214.87 156.98,215.22 156.98,223.7 160.09,226.81 160.09,234.35 171.96,246.22 171.96,247.8 173.4,249.23 177.77,249.23 181.11,252.58 181.11,256.09 180.78,256.43 180.78,258.64 183.55,261.42 183.55,271.03 184.43,271.91 184.43,301.06 250.33,366.95 250.33,385.9 255.53,391.1 255.53,416.47 255.42,416.57 255.42,416.58 253.89,418.12 252.46,418.12 251.64,418.94 251.07,418.94 250.5,418.36 250,418.36 249.38,418.98 248.9,418.98 248.22,418.3 247.78,418.3 247.14,418.94 246.61,418.94 246.29,418.62 245.5,418.62 244.63,419.49 SLOT13.C37
SL13_DP_67: length 313.8
  L05_DP w0.079: SLOT13.D37 246.88,420.25 246.8,420.17 245.43,420.17 244.89,419.64 244.36,419.64 243.82,420.17 243.18,420.17 242.64,419.64 241.82,419.64 241.52,419.94 240.98,419.94 240.6,419.56 240.6,419.02 241.02,418.6 241.02,417.95 241.01,417.94 240.98,417.94 240.6,417.56 240.6,417.02 240.89,416.73 240.89,416.56 241.9,415.56 241.9,415.02 241.52,414.64 241.52,413.94 241.9,413.56 241.9,413.02 241.52,412.64 240.98,412.64 240.43,413.19 239.82,413.19 239.27,412.64 238.73,412.64 237.96,413.41 237.58,413.41 236.56,414.43 235.65,414.43 234.37,413.16 234.37,403.73 228.59,397.95 219.97,397.95 216.23,394.21 216.23,393.69 216.23,387.22 159.25,330.23 159.25,303.97 148.9,293.63 147.17,293.63 142.24,288.69 142.24,276.01 139.35,273.12 136.95,273.12 129.31,265.49 129.31,241.49 133.41,237.39 137.09,237.39 138.42,238.72 144.92,238.72 146.53,237.11 146.53,226.45 145.89,225.8 145.89,218.67 146.44,218.11 146.44,210.99 145.56,210.11 145.56,194.56 145.95,194.16 147.4,194.16 v1(148.22,193.35)
SL13_DP_68: length 279.7
  L03_DP w0.079: v1(151.01,193.35) 151.01,193.93 150.12,194.82 150.12,202.23 153.05,205.16 153.05,207.94 156.95,211.83 156.95,212.2 157.3,212.55 157.3,213.73 156.95,214.09 156.95,214.74 157.3,215.09 157.3,223.57 160.41,226.68 160.41,234.22 172.28,246.08 172.28,247.66 173.5,248.88 177.87,248.88 181.44,252.44 181.44,256.23 181.11,256.55 181.11,258.52 183.88,261.28 183.88,270.76 184.88,271.77 184.88,300.87 250.78,366.77 250.78,385.9 255.84,390.97 255.84,416.6 255.74,416.7 255.74,416.71 254.12,418.33 252.5,418.33 251.72,419.12 251,419.12 250.42,418.54 250.08,418.54 249.13,419.49 SLOT13.E37
SL13_DP_69: length 272.5
  L03_DP w0.079: SLOT13.F37 253.55,420.29 256.47,417.37 256.47,390.71 251.53,385.77 251.53,366.46 186.44,301.37 186.44,271.13 184.53,269.22 184.53,261.01 182.65,259.14 182.65,256.76 182.16,256.26 182.16,252.24 178.34,248.42 178.16,248.24 178.16,246.53 177.32,245.68 172.83,245.68 162.81,235.66 162.81,234.62 163.43,234.01 163.43,231.05 163.03,230.65 163.03,228.34 157.98,223.29 157.98,218.11 158.21,217.88 158.21,210.64 157.91,210.34 156.38,210.34 153.7,207.67 153.7,199.35 153.17,198.82 v1(153.17,198.18)
SL13_DP_70: length 309.5
  L03_DP w0.079: SLOT13.A35 240.13,423.37 239.48,424.02 239.48,424.56 240.13,425.2 240.13,425.37 239.48,426.02 239.48,426.56 239.86,426.94 240.39,426.94 240.86,426.47 241.38,426.47 242.03,427.12 242.72,427.12 243.37,426.47 243.63,426.47 244.28,427.12 244.97,427.12 245.45,426.63 245.45,425.91 245.1,425.56 245.1,425.2 244.84,424.94 244.36,424.94 243.98,424.56 243.98,423.73 244.15,423.56 244.15,423.02 243.77,422.64 243.07,422.64 242.77,422.94 242.11,422.94 241.62,422.45 241.62,422.12 242.11,421.64 242.23,421.64 243.23,420.64 243.77,420.64 244.12,420.99 244.84,420.99 245.89,419.94 246.02,419.94 246.47,419.49 247.28,419.49 247.88,420.08 248.29,420.08 248.48,420.27 248.48,420.56 248.86,420.94 249.39,420.94 249.77,420.56 249.77,420.12 249.96,419.94 250.52,419.94 250.88,419.57 251.87,419.57 252.23,419.94 252.96,419.94 256.05,416.84 256.05,416.83 256.16,416.73 256.16,390.84 251.13,385.81 251.13,366.63 186.03,301.53 186.03,271.22 184.2,269.38 184.2,261.15 181.45,258.41 181.45,256.67 181.78,256.34 181.78,252.33 177.96,248.51 173.58,248.51 172.6,247.53 172.6,245.95 161.78,235.13 161.78,227.59 157.62,223.43 157.62,214.96 157.54,214.88 157.54,214.88 157.26,214.61 157.26,214.22 157.54,213.94 157.54,213.94 157.62,213.86 157.62,212.42 157.54,212.34 157.54,212.34 157.26,212.07 157.26,211.68 153.38,207.8 153.38,204.79 151.96,203.37 151.96,199.45 152.6,198.81 152.6,194.63 153.17,194.06 v1(153.17,193.35)
