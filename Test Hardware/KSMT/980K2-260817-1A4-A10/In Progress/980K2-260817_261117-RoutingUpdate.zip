# Allegro board 980K2-260817_261117-1.brd (continued)
## Nets (continued)
SL18_VI100_19_A_HS: SITE8.5_S(VSR_S) SLOT18.E56(19_A_HS) UNK8K10.4 UNK8TP_VSR_S.1
SL18_VI100_19_B_HG: SLOT18.E55(19_B_HG)
SL18_VI100_19_B_HS: SITE8.10_S(IS2N_S) SLOT18.G56(19_B_HS) UNK8K18.4 UNK8TP_IS2N_S.1
SL18_VI100_19_LS: SLOT18.D56(19_LS) UNK8SH3.1
SL18_VI100_20_A_HG: SLOT18.D53(20_A_HG)
SL18_VI100_20_A_HS: SITE8.4_S(SRG_S) SLOT18.E54(20_A_HS) UNK8K7.4 UNK8TP_SRG_S.1
SL18_VI100_20_B_HG: SLOT18.E53(20_B_HG)
SL18_VI100_20_B_HS: SITE8.17_S(C1B_S) SLOT18.G54(20_B_HS) UNK8K28.4 UNK8TP_C1B_S.1
SL18_VI100_20_LS: SLOT18.D54(20_LS) UNK8SH4.1
SL18_VI100_21_A_HF: SITE8.6_F(VCC_F) SLOT18.F27(21_A_HF) UNK8K11.4 UNK8K12.4 UNK8K13.4 UNK8TP_VCC_F.1
SL18_VI100_21_A_HG: SLOT18.D51(21_A_HG)
SL18_VI100_21_A_HS: SITE8.6_S(VCC_S) SLOT18.E52(21_A_HS) UNK8TP_VCC_S.1
SL18_VI100_21_B_HF: SLOT18.F51(21_B_HF)
SL18_VI100_21_B_HG: SLOT18.E51(21_B_HG)
SL18_VI100_21_B_HS: SLOT18.G52(21_B_HS)
SL18_VI100_21_LS: SLOT18.D52(21_LS) UNK8SH5.1
SL18_VI100_22_A_HF: SITE8.7_F(OPTO_F) SLOT18.F25(22_A_HF) UNK8TP_OPTO_F.1
SL18_VI100_22_A_HG: SLOT18.D49(22_A_HG)
SL18_VI100_22_A_HS: SITE8.7_S(OPTO_S) SLOT18.E50(22_A_HS) UNK8K14.4 UNK8TP_OPTO_S.1
SL18_VI100_22_B_HF: SITE8.30_F(GB2_F) SLOT18.F49(22_B_HF)
SL18_VI100_22_B_HG: SLOT18.E49(22_B_HG)
SL18_VI100_22_B_HS: SITE8.30_S(GB2_S) SLOT18.G50(22_B_HS) UNK8K46.4 UNK8TP_GB2_S.1
SL18_VI100_22_LS: SLOT18.D50(22_LS) UNK8SH6.1
SL18_VI100_23_A_HF: SITE8.13_F(STB_F) SLOT18.F23(23_A_HF) UNK8TP_STB_F.1
SL18_VI100_23_A_HG: SLOT18.D47(23_A_HG)
SL18_VI100_23_A_HS: SITE8.13_S(STB_S) SLOT18.E48(23_A_HS) UNK8K22.4 UNK8TP_STB_S.1
SL18_VI100_23_B_HF: SITE8.31_F(VO2_F) SLOT18.F47(23_B_HF) UNK8K47.4
SL18_VI100_23_B_HG: SLOT18.E47(23_B_HG)
SL18_VI100_23_B_HS: SITE8.31_S(VO2_S) SLOT18.G48(23_B_HS) UNK8K48.4 UNK8TP_VO2_S.1
SL18_VI100_23_LS: SLOT18.D48(23_LS) UNK8SH7.1
SL18_VI100_24_A_HF: SLOT18.F21(24_A_HF) UNK8K23.4
SL18_VI100_24_A_HG: SLOT18.D45(24_A_HG)
SL18_VI100_24_A_HS: SLOT18.E46(24_A_HS) UNK8K23.5
SL18_VI100_24_B_HF: SITE8.20_F(C2B_F) SLOT18.F45(24_B_HF) UNK8C61.2 UNK8TP_C2B_F.1
SL18_VI100_24_B_HG: SLOT18.E45(24_B_HG)
SL18_VI100_24_B_HS: SITE8.20_S(C2B_S) SLOT18.G46(24_B_HS) UNK8K32.4 UNK8TP_C2B_S.1
SL18_VI100_24_LS: SLOT18.D46(24_LS) UNK8SH8.1
SL18_VI100_25_A_HF: SLOT18.F39(25_A_HF) UNK8K24.4
SL18_VI100_25_A_HG: SLOT18.D61(25_A_HG)
SL18_VI100_25_A_HS: SLOT18.C62(25_A_HS) UNK8K24.5
SL18_VI100_25_B_HF: SITE8.21_F(C3B_F) SLOT18.F61(25_B_HF) UNK8K33.4 UNK8TP_C3B_F.1
SL18_VI100_25_B_HG: SLOT18.E61(25_B_HG)
SL18_VI100_25_B_HS: SITE8.21_S(C3B_S) SLOT18.F62(25_B_HS) UNK8K34.4 UNK8TP_C3B_S.1
SL18_VI100_25_LS: SLOT18.B62(25_LS) UNK8SH9.1
SL18_VI100_26_A_HF: SITE8.16_F(VDD0_F) SLOT18.F17(26_A_HF) UNK8K25.4 UNK8TP_VDD0_F.1
SL18_VI100_26_A_HG: SLOT18.D43(26_A_HG)
SL18_VI100_26_A_HS: SITE8.16_S(VDD0_S) SLOT18.E44(26_A_HS) UNK8K26.4 UNK8TP_VDD0_S.1
SL18_VI100_26_B_HF: SITE8.25_F(GA2_F) SLOT18.F43(26_B_HF)
SL18_VI100_26_B_HG: SLOT18.E43(26_B_HG)
SL18_VI100_26_B_HS: SITE8.25_S(GA2_S) SLOT18.G44(26_B_HS) UNK8K40.4 UNK8TP_GA2_S.1
SL18_VI100_26_LS: SLOT18.D44(26_LS) UNK8SH10.1
SL18_VI100_27_A_HF: SITE8.18_F(C1A_F) SLOT18.F15(27_A_HF) UNK8C63.2 UNK8TP_C1A_F.1
SL18_VI100_27_A_HG: SLOT18.D41(27_A_HG)
SL18_VI100_27_A_HS: SITE8.18_S(C1A_S) SLOT18.E42(27_A_HS) UNK8K29.4 UNK8TP_C1A_S.1
SL18_VI100_27_B_HF: SITE8.26_F(GA1_F) SLOT18.F41(27_B_HF)
SL18_VI100_27_B_HG: SLOT18.E41(27_B_HG)
SL18_VI100_27_B_HS: SITE8.26_S(GA1_S) SLOT18.G42(27_B_HS) UNK8K41.4 UNK8TP_GA1_S.1
SL18_VI100_27_LS: SLOT18.D42(27_LS) UNK8SH11.1
SL18_VI100_28_A_HF: SITE8.19_F(C2A_F) SLOT18.F13(28_A_HF) UNK8K30.4 UNK8TP_C2A_F.1
SL18_VI100_28_A_HG: SLOT18.A61(28_A_HG)
SL18_VI100_28_A_HS: SITE8.19_S(C2A_S) SLOT18.A60(28_A_HS) UNK8K31.4 UNK8TP_C2A_S.1
SL18_VI100_28_B_HF: SITE8.27_F(GB1_F) SLOT18.A57(28_B_HF)
SL18_VI100_28_B_HG: SLOT18.B57(28_B_HG)
SL18_VI100_28_B_HS: SITE8.27_S(GB1_S) SLOT18.A56(28_B_HS) UNK8K42.4 UNK8TP_GB1_S.1
SL18_VI100_28_LS: SLOT18.A58(28_LS) UNK8SH12.1
SL18_VI100_29_A_HF: SITE8.22_F(C3A_F) SLOT18.F11(29_A_HF) UNK8C64.2 UNK8TP_C3A_F.1
SL18_VI100_29_A_HG: SLOT18.B53(29_A_HG)
SL18_VI100_29_A_HS: SITE8.22_S(C3A_S) SLOT18.B55(29_A_HS) UNK8K35.4 UNK8TP_C3A_S.1
SL18_VI100_29_B_HF: SITE8.32_F(VDD2_F) SLOT18.A51(29_B_HF) UNK8K49.4
SL18_VI100_29_B_HG: SLOT18.A53(29_B_HG)
SL18_VI100_29_B_HS: SITE8.32_S(VDD2_S) SLOT18.A52(29_B_HS) UNK8K50.4 UNK8TP_VDD2_S.1
SL18_VI100_29_LS: SLOT18.A55(29_LS) UNK8SH13.1
SL18_VI100_30_A_HF: SITE8.23_F(VDDI_F) SLOT18.F9(30_A_HF) UNK8K36.4 UNK8TP_VDDI_F.1
SL18_VI100_30_A_HG: SLOT18.A47(30_A_HG)
SL18_VI100_30_A_HS: SITE8.23_S(VDDI_S) SLOT18.A48(30_A_HS) UNK8K37.4 UNK8TP_VDDI_S.1
SL18_VI100_30_B_HG: SLOT18.B43(30_B_HG)
SL18_VI100_30_B_HS: SITE8.12_S(IS1N_S) SLOT18.A44(30_B_HS) UNK8K21.4 UNK8TP_IS1N_S.1
SL18_VI100_30_LS: SLOT18.A46(30_LS) UNK8SH14.1
SL18_VI100_31_A_HF: SITE8.24_F(VIN_F) SLOT18.F7(31_A_HF) UNK8K38.4 UNK8TP_VIN_F.1
SL18_VI100_31_A_HG: SLOT18.B41(31_A_HG)
SL18_VI100_31_A_HS: SITE8.24_S(VIN_S) SLOT18.B3(31_A_HS) UNK8K39.4 UNK8TP_VIN_S.1
SL18_VI100_31_B_HG: SLOT18.C19(31_B_HG)
SL18_VI100_31_B_HS: SITE8.11_S(IS1P_S) SLOT18.E19(31_B_HS) UNK8K20.4
SL18_VI100_31_LS: SLOT18.A3(31_LS) UNK8SH15.1
SL18_VI100_32_A_HF: SITE8.28_F(VO1_F) SLOT18.F5(32_A_HF)
SL18_VI100_32_A_HG: SLOT18.D3(32_A_HG)
SL18_VI100_32_A_HS: SITE8.28_S(VO1_S) SLOT18.D1(32_A_HS) UNK8K43.4 UNK8TP_VO1_S.1
SL18_VI100_32_B_HG: SLOT18.E3(32_B_HG)
SL18_VI100_32_B_HS: SITE8.9_S(IS2P_S) SLOT18.F1(32_B_HS) UNK8K17.4 UNK8TP_IS2P_S.1
SL18_VI100_32_LS: SLOT18.C1(32_LS) UNK8SH16.1
SPARE0: SLOT0.A8
SPARE1: SLOT0.G22
SPARE2: SLOT0.A20
SPARE3: SLOT0.G26
SPARE4: SLOT0.A24
SPARE5: SLOT0.G30
SPARE6: SLOT0.A28
SPARE7: SLOT0.G34
SPARE8: SLOT0.A32
SPARE9: SLOT0.G40
SPARE10: SLOT0.A36
SPARE11: SLOT0.F40
SPARE12: SLOT0.C40
SPARE13: SLOT0.E40
SPARE14: SLOT0.D40
SPI_CS_N: SLOT0.E16
SPI_MISO: SLOT0.F18
SPI_MOSI: SLOT0.E18
SPI_SCLK: SLOT0.E14
SYS_SCLK: BR8.2 SLOT0.G14
SYS_SDA: BR9.2 SLOT0.G18
TMU_INPUT_A: SLOT0.B12
TMU_INPUT_B: SLOT0.D12
TMU_REF_GND: SLOT0.A37 UNK0BS1.1
TMU_TRIGGER: SLOT0.F12
USER_12V: SLOT0.F6 SLOT0.G6
USER_SCLK: SLOT0.F14
USER_SDA: SLOT0.F16
N00304: LD1.1(A) RT1.2
N16304853: CT1.1 F1.2 LT1.1 RT1.1
N16305479: LD3.1(A) RT2.2
N16305515: CT7.1 F2.2 LT3.1 RT2.1
N17260776: C48.1 K2.3
N17261204: C49.1 K3.3
N17261720: C50.1 K5.3
N17263068: K7.1 RK7.1
N17264482: C53.1 K8.3
N17264547: C54.1 K9.3
N17266096: C59.1 K12.3
N17266582: K13.3 R1.1
N17267238: K15.6 SITE1.8_S(ATT_S) TP_ATT_S.1(TP)
N17270245: C69.1 K19.3
N17370523: BC9.1 BR5.1 BR6.1 BR7.1 BU1.8(VCC)
N17370531: BR6.2 BR9.1 BU1.5(SDA)
N17370539: BR5.2 BR8.1 BU1.6(SCL)
N17493363: K5.1 RK5.1
N17493593: K6.1 RK6.1
N17493900: K8.1 RK8.1
N17494047: K9.1 RK9.1
N17494316: K10.1 RK10.1
N17494507: K11.1 RK11.1
N17494587: C58.1 K11.3
N17494912: K12.1 RK12.1
N17495143: K13.1 RK13.1
N17495451: K14.1 RK14.1
N17495920: K19.1 RK19.1
N17496065: K20.1 RK20.1
N17496168: K21.1 RK21.1
N17508143: K2.1 RK2.1
N17508406: K3.1 RK3.1
N17508530: K4.1 RK4.1
N17654577: K51.4 R7.2
N17654648: K53.4 R8.2
N17654652: K53.1 RK53.1
N17654805: R11.2 R19.1 TP_IN+_1.1(TP) U1.3(+IN)
N17654898: R14.2 R20.1 TP_IN+_2.1(TP) U2.3(+IN)
N17655019: K55.1 RK59.1
N17655025: K55.4 R19.2
N17655029: K56.1 RK60.1
N17655138: K57.3 R16.1 TP_IN-_3.1(TP) U3.8(IN-)
N17655140: K58.4 R16.2 TP_IN+_3.1(TP) U3.7(IN+)
N17655324: K60.4 R18.2 TP_IN+_4.1(TP) U4.7(IN+)
N17655339: K59.3 R18.1 TP_IN-_4.1(TP) U4.8(IN-)
N17655440: K56.4 K61.4 R20.2
N17655462: K54.1 RK54.1
N17655480: K51.1 RK51.1
N17655494: K52.1 RK52.1
N17702527: K15.3 SITE1.8_F(ATT_F) TP_ATT_F.1(TP)
N18407736: C60.1 K16.3
N18407764: K17.1 RK17.1
N18407893: K16.1 RK16.1
N18407930: K18.1 RK18.1
N18409262: K22.1 RK22.1
N18420672: K23.6 SITE1.14_S(SDA_S) TP_SDA_S.1(TP)
N18420953: K24.6 SITE1.15_S(SCL_S)
N18432405: C62.1 K25.3
N18432504: K25.1 RK25.1
N18432522: K26.1 RK26.1
N18432973: C63.1 K27.3
N18433005: K28.1 RK28.1
N18433172: K27.1 RK27.1
N18433200: K29.1 RK29.1
N18433570: C61.1 K30.3
N18433598: K31.1 RK31.1
N18433748: K30.1 RK30.1
N18433778: K32.1 RK32.1
N18434722: K39.1 RK39.1
N18434762: K38.1 RK38.1
N18434888: C74.1 K38.3
N18465960: K35.1 RK35.1
N18465976: K34.1 RK34.1
N18465984: K33.1 RK33.1
N18466028: C64.1 K33.3
N18511830: K37.1 RK37.1
N18511832: K36.1 RK36.1
N18511862: C65.1 K36.3
N18556624: K40.1 RK40.1
N18556932: K41.1 RK41.1
N18557107: K42.1 RK42.1
N18557324: K43.1 RK43.1
N18568668: K45.1 RK45.1
N18568680: K44.1 RK44.1
N18568712: C66.1 K44.3
N18580009: K46.1 RK46.1
N18580265: C67.1 K47.3
N18580347: K48.1 RK48.1
N18580359: K47.1 RK47.1
N18580906: C68.1 K49.3
N18580988: K50.1 RK50.1
N18581000: K49.1 RK49.1
N18705535: K57.1 RK55.2
N18705626: K58.1 RK56.2
N18705736: K59.1 RK57.2
N18705861: K60.1 RK58.2
N18706153: K61.1 RK61.1
N18706312: UNK2C48.1 UNK2K2.3
N18706321: UNK2C49.1 UNK2K3.3
N18706330: UNK2C50.1 UNK2K5.3
N18706363: UNK2K7.1 UNK2RK7.1
N18706370: UNK2C53.1 UNK2K8.3
N18706379: UNK2C54.1 UNK2K9.3
N18706409: UNK2C59.1 UNK2K12.3
N18706416: UNK2K13.3 UNK2R1.1
N18706434: SITE2.8_S(ATT_S) UNK2K15.6 UNK2TP_ATT_S.1
N18706452: UNK2K5.1 UNK2RK5.1
N18706454: UNK2K6.1 UNK2RK6.1
N18706456: UNK2K8.1 UNK2RK8.1
N18706457: UNK2K9.1 UNK2RK9.1
N18706458: UNK2K10.1 UNK2RK10.1
N18706459: UNK2K11.1 UNK2RK11.1
N18706462: UNK2C58.1 UNK2K11.3
N18706465: UNK2K12.1 UNK2RK12.1
N18706467: UNK2K13.1 UNK2RK13.1
N18706470: UNK2K14.1 UNK2RK14.1
N18706472: UNK2K2.1 UNK2RK2.1
N18706473: UNK2K3.1 UNK2RK3.1
N18706474: UNK2K4.1 UNK2RK4.1
N18706494: SITE2.8_F(ATT_F) UNK2K15.3 UNK2TP_ATT_F.1
N18706506: UNK2C60.1 UNK2K16.3
N18706519: UNK2K17.1 UNK2RK17.1
N18706533: UNK2K16.1 UNK2RK16.1
N18706537: UNK2K18.1 UNK2RK18.1
N18707687: UNK2C69.1 UNK2K19.3
N18707714: UNK2K19.1 UNK2RK19.1
N18707716: UNK2K20.1 UNK2RK20.1
N18707717: UNK2K21.1 UNK2RK21.1
N18707742: UNK2K22.1 UNK2RK22.1
N18707748: SITE2.14_S(SDA_S) UNK2K23.6 UNK2TP_SDA_S.1
N18707762: SITE2.15_S(SCL_S) UNK2K24.6
N18707772: UNK2C62.1 UNK2K25.3
N18707790: UNK2K25.1 UNK2RK25.1
N18707794: UNK2K26.1 UNK2RK26.1
N18707799: UNK2C63.1 UNK2K27.3
N18707815: UNK2K28.1 UNK2RK28.1
N18707836: UNK2K27.1 UNK2RK27.1
N18707838: UNK2K29.1 UNK2RK29.1
N18707843: UNK2C61.1 UNK2K30.3
N18707857: UNK2K31.1 UNK2RK31.1
N18707877: UNK2K30.1 UNK2RK30.1
N18707880: UNK2K32.1 UNK2RK32.1
N18707882: UNK2K35.1 UNK2RK35.1
N18707884: UNK2K34.1 UNK2RK34.1
N18707886: UNK2K33.1 UNK2RK33.1
N18707889: UNK2C64.1 UNK2K33.3
N18707924: UNK2K37.1 UNK2RK37.1
N18707925: UNK2K36.1 UNK2RK36.1
N18707931: UNK2C65.1 UNK2K36.3
N18709217: UNK2K39.1 UNK2RK39.1
N18709218: UNK2K38.1 UNK2RK38.1
N18709224: UNK2C74.1 UNK2K38.3
N18709243: UNK2K40.1 UNK2RK40.1
N18709256: UNK2K41.1 UNK2RK41.1
N18709269: UNK2K42.1 UNK2RK42.1
N18709281: UNK2K43.1 UNK2RK43.1
N18709294: UNK2K45.1 UNK2RK45.1
N18709295: UNK2K44.1 UNK2RK44.1
N18709305: UNK2C66.1 UNK2K44.3
N18709323: UNK2K46.1 UNK2RK46.1
N18709339: UNK2C67.1 UNK2K47.3
N18709352: UNK2K48.1 UNK2RK48.1
N18709353: UNK2K47.1 UNK2RK47.1
N18709363: UNK2C68.1 UNK2K49.3
N18709376: UNK2K50.1 UNK2RK50.1
N18709377: UNK2K49.1 UNK2RK49.1
N18710191: UNK2K51.4 UNK2R7.2
N18710203: UNK2K53.4 UNK2R8.2
N18710205: UNK2K53.1 UNK2RK53.1
N18710227: UNK2R11.2 UNK2R19.1 UNK2TP_IN+_1.1 UNK2U1.3
N18710239: UNK2R14.2 UNK2R20.1 UNK2TP_IN+_2.1 UNK2U2.3
N18710249: UNK2K55.1 UNK2RK59.1
N18710252: UNK2K55.4 UNK2R19.2
N18710254: UNK2K56.1 UNK2RK60.1
N18710271: UNK2K57.3 UNK2R16.1 UNK2TP_IN-_3.1 UNK2U3.8
N18710272: UNK2K58.4 UNK2R16.2 UNK2TP_IN+_3.1 UNK2U3.7
N18710300: UNK2K60.4 UNK2R18.2 UNK2TP_IN+_4.1 UNK2U4.7
N18710304: UNK2K59.3 UNK2R18.1 UNK2TP_IN-_4.1 UNK2U4.8
N18710315: UNK2K56.4 UNK2K61.4 UNK2R20.2
N18710316: UNK2K54.1 UNK2RK54.1
N18710320: UNK2K51.1 UNK2RK51.1
N18710322: UNK2K52.1 UNK2RK52.1
N18710386: UNK2K57.1 UNK2RK55.2
N18710387: UNK2K58.1 UNK2RK56.2
N18710388: UNK2K59.1 UNK2RK57.2
N18710389: UNK2K60.1 UNK2RK58.2
N18710392: UNK2K61.1 UNK2RK61.1
N18711523: UNK3C48.1 UNK3K2.3
N18711532: UNK3C49.1 UNK3K3.3
N18711541: UNK3C50.1 UNK3K5.3
N18711574: UNK3K7.1 UNK3RK7.1
N18711581: UNK3C53.1 UNK3K8.3
N18711590: UNK3C54.1 UNK3K9.3
N18711620: UNK3C59.1 UNK3K12.3
N18711627: UNK3K13.3 UNK3R1.1
N18711645: SITE3.8_S(ATT_S) UNK3K15.6 UNK3TP_ATT_S.1
N18711663: UNK3K5.1 UNK3RK5.1
N18711665: UNK3K6.1 UNK3RK6.1
N18711667: UNK3K8.1 UNK3RK8.1
N18711668: UNK3K9.1 UNK3RK9.1
N18711669: UNK3K10.1 UNK3RK10.1
N18711670: UNK3K11.1 UNK3RK11.1
N18711673: UNK3C58.1 UNK3K11.3
N18711676: UNK3K12.1 UNK3RK12.1
N18711678: UNK3K13.1 UNK3RK13.1
N18711681: UNK3K14.1 UNK3RK14.1
N18711683: UNK3K2.1 UNK3RK2.1
N18711684: UNK3K3.1 UNK3RK3.1
N18711685: UNK3K4.1 UNK3RK4.1
N18711705: SITE3.8_F(ATT_F) UNK3K15.3 UNK3TP_ATT_F.1
N18711717: UNK3C60.1 UNK3K16.3
N18711730: UNK3K17.1 UNK3RK17.1
N18711744: UNK3K16.1 UNK3RK16.1
N18711748: UNK3K18.1 UNK3RK18.1
N18712898: UNK3C69.1 UNK3K19.3
N18712925: UNK3K19.1 UNK3RK19.1
N18712927: UNK3K20.1 UNK3RK20.1
N18712928: UNK3K21.1 UNK3RK21.1
N18712953: UNK3K22.1 UNK3RK22.1
N18712959: SITE3.14_S(SDA_S) UNK3K23.6 UNK3TP_SDA_S.1
N18712973: SITE3.15_S(SCL_S) UNK3K24.6
N18712983: UNK3C62.1 UNK3K25.3
N18713001: UNK3K25.1 UNK3RK25.1
N18713005: UNK3K26.1 UNK3RK26.1
N18713010: UNK3C63.1 UNK3K27.3
N18713026: UNK3K28.1 UNK3RK28.1
N18713047: UNK3K27.1 UNK3RK27.1
N18713049: UNK3K29.1 UNK3RK29.1
N18713054: UNK3C61.1 UNK3K30.3
N18713068: UNK3K31.1 UNK3RK31.1
N18713088: UNK3K30.1 UNK3RK30.1
N18713091: UNK3K32.1 UNK3RK32.1
N18713093: UNK3K35.1 UNK3RK35.1
N18713095: UNK3K34.1 UNK3RK34.1
N18713097: UNK3K33.1 UNK3RK33.1
N18713100: UNK3C64.1 UNK3K33.3
N18713135: UNK3K37.1 UNK3RK37.1
N18713136: UNK3K36.1 UNK3RK36.1
N18713142: UNK3C65.1 UNK3K36.3
N18714428: UNK3K39.1 UNK3RK39.1
N18714429: UNK3K38.1 UNK3RK38.1
N18714435: UNK3C74.1 UNK3K38.3
N18714454: UNK3K40.1 UNK3RK40.1
N18714467: UNK3K41.1 UNK3RK41.1
N18714480: UNK3K42.1 UNK3RK42.1
N18714492: UNK3K43.1 UNK3RK43.1
N18714505: UNK3K45.1 UNK3RK45.1
N18714506: UNK3K44.1 UNK3RK44.1
N18714516: UNK3C66.1 UNK3K44.3
N18714534: UNK3K46.1 UNK3RK46.1
N18714550: UNK3C67.1 UNK3K47.3
N18714563: UNK3K48.1 UNK3RK48.1
N18714564: UNK3K47.1 UNK3RK47.1
N18714574: UNK3C68.1 UNK3K49.3
N18714587: UNK3K50.1 UNK3RK50.1
N18714588: UNK3K49.1 UNK3RK49.1
N18715402: UNK3K51.4 UNK3R7.2
N18715414: UNK3K53.4 UNK3R8.2
N18715416: UNK3K53.1 UNK3RK53.1
N18715438: UNK3R11.2 UNK3R19.1 UNK3TP_IN+_1.1 UNK3U1.3
N18715450: UNK3R14.2 UNK3R20.1 UNK3TP_IN+_2.1 UNK3U2.3
N18715460: UNK3K55.1 UNK3RK59.1
N18715463: UNK3K55.4 UNK3R19.2
N18715465: UNK3K56.1 UNK3RK60.1
N18715482: UNK3K57.3 UNK3R16.1 UNK3TP_IN-_3.1 UNK3U3.8
N18715483: UNK3K58.4 UNK3R16.2 UNK3TP_IN+_3.1 UNK3U3.7
N18715511: UNK3K60.4 UNK3R18.2 UNK3TP_IN+_4.1 UNK3U4.7
N18715515: UNK3K59.3 UNK3R18.1 UNK3TP_IN-_4.1 UNK3U4.8
N18715526: UNK3K56.4 UNK3K61.4 UNK3R20.2
N18715527: UNK3K54.1 UNK3RK54.1
N18715531: UNK3K51.1 UNK3RK51.1
N18715533: UNK3K52.1 UNK3RK52.1
N18715597: UNK3K57.1 UNK3RK55.2
N18715598: UNK3K58.1 UNK3RK56.2
N18715599: UNK3K59.1 UNK3RK57.2
N18715600: UNK3K60.1 UNK3RK58.2
N18715603: UNK3K61.1 UNK3RK61.1
N18716734: UNK4C48.1 UNK4K2.3
N18716743: UNK4C49.1 UNK4K3.3
N18716752: UNK4C50.1 UNK4K5.3
N18716785: UNK4K7.1 UNK4RK7.1
N18716792: UNK4C53.1 UNK4K8.3
N18716801: UNK4C54.1 UNK4K9.3
N18716831: UNK4C59.1 UNK4K12.3
N18716838: UNK4K13.3 UNK4R1.1
N18716856: SITE4.8_S(ATT_S) UNK4K15.6 UNK4TP_ATT_S.1
N18716874: UNK4K5.1 UNK4RK5.1
N18716876: UNK4K6.1 UNK4RK6.1
N18716878: UNK4K8.1 UNK4RK8.1
N18716879: UNK4K9.1 UNK4RK9.1
N18716880: UNK4K10.1 UNK4RK10.1
N18716881: UNK4K11.1 UNK4RK11.1
N18716884: UNK4C58.1 UNK4K11.3
N18716887: UNK4K12.1 UNK4RK12.1
N18716889: UNK4K13.1 UNK4RK13.1
N18716892: UNK4K14.1 UNK4RK14.1
N18716894: UNK4K2.1 UNK4RK2.1
N18716895: UNK4K3.1 UNK4RK3.1
N18716896: UNK4K4.1 UNK4RK4.1
N18716916: SITE4.8_F(ATT_F) UNK4K15.3 UNK4TP_ATT_F.1
N18716928: UNK4C60.1 UNK4K16.3
N18716941: UNK4K17.1 UNK4RK17.1
N18716955: UNK4K16.1 UNK4RK16.1
N18716959: UNK4K18.1 UNK4RK18.1
N18718109: UNK4C69.1 UNK4K19.3
N18718136: UNK4K19.1 UNK4RK19.1
N18718138: UNK4K20.1 UNK4RK20.1
N18718139: UNK4K21.1 UNK4RK21.1
N18718164: UNK4K22.1 UNK4RK22.1
N18718170: SITE4.14_S(SDA_S) UNK4K23.6 UNK4TP_SDA_S.1
N18718184: SITE4.15_S(SCL_S) UNK4K24.6
N18718194: UNK4C62.1 UNK4K25.3
N18718212: UNK4K25.1 UNK4RK25.1
N18718216: UNK4K26.1 UNK4RK26.1
N18718221: UNK4C63.1 UNK4K27.3
N18718237: UNK4K28.1 UNK4RK28.1
N18718258: UNK4K27.1 UNK4RK27.1
N18718260: UNK4K29.1 UNK4RK29.1
N18718265: UNK4C61.1 UNK4K30.3
N18718279: UNK4K31.1 UNK4RK31.1
N18718299: UNK4K30.1 UNK4RK30.1
N18718302: UNK4K32.1 UNK4RK32.1
N18718304: UNK4K35.1 UNK4RK35.1
N18718306: UNK4K34.1 UNK4RK34.1
N18718308: UNK4K33.1 UNK4RK33.1
N18718311: UNK4C64.1 UNK4K33.3
N18718346: UNK4K37.1 UNK4RK37.1
N18718347: UNK4K36.1 UNK4RK36.1
N18718353: UNK4C65.1 UNK4K36.3
N18719639: UNK4K39.1 UNK4RK39.1
N18719640: UNK4K38.1 UNK4RK38.1
N18719646: UNK4C74.1 UNK4K38.3
N18719665: UNK4K40.1 UNK4RK40.1
N18719678: UNK4K41.1 UNK4RK41.1
N18719691: UNK4K42.1 UNK4RK42.1
N18719703: UNK4K43.1 UNK4RK43.1
N18719716: UNK4K45.1 UNK4RK45.1
N18719717: UNK4K44.1 UNK4RK44.1
N18719727: UNK4C66.1 UNK4K44.3
N18719745: UNK4K46.1 UNK4RK46.1
N18719761: UNK4C67.1 UNK4K47.3
N18719774: UNK4K48.1 UNK4RK48.1
N18719775: UNK4K47.1 UNK4RK47.1
N18719785: UNK4C68.1 UNK4K49.3
N18719798: UNK4K50.1 UNK4RK50.1
N18719799: UNK4K49.1 UNK4RK49.1
N18720613: UNK4K51.4 UNK4R7.2
N18720625: UNK4K53.4 UNK4R8.2
N18720627: UNK4K53.1 UNK4RK53.1
N18720649: UNK4R11.2 UNK4R19.1 UNK4TP_IN+_1.1 UNK4U1.3
N18720661: UNK4R14.2 UNK4R20.1 UNK4TP_IN+_2.1 UNK4U2.3
N18720671: UNK4K55.1 UNK4RK59.1
N18720674: UNK4K55.4 UNK4R19.2
N18720676: UNK4K56.1 UNK4RK60.1
N18720693: UNK4K57.3 UNK4R16.1 UNK4TP_IN-_3.1 UNK4U3.8
N18720694: UNK4K58.4 UNK4R16.2 UNK4TP_IN+_3.1 UNK4U3.7
N18720722: UNK4K60.4 UNK4R18.2 UNK4TP_IN+_4.1 UNK4U4.7
N18720726: UNK4K59.3 UNK4R18.1 UNK4TP_IN-_4.1 UNK4U4.8
N18720737: UNK4K56.4 UNK4K61.4 UNK4R20.2
N18720738: UNK4K54.1 UNK4RK54.1
N18720742: UNK4K51.1 UNK4RK51.1
N18720744: UNK4K52.1 UNK4RK52.1
N18720808: UNK4K57.1 UNK4RK55.2
N18720809: UNK4K58.1 UNK4RK56.2
N18720810: UNK4K59.1 UNK4RK57.2
N18720811: UNK4K60.1 UNK4RK58.2
N18720814: UNK4K61.1 UNK4RK61.1
N18721945: UNK5C48.1 UNK5K2.3
N18721954: UNK5C49.1 UNK5K3.3
N18721963: UNK5C50.1 UNK5K5.3
N18721996: UNK5K7.1 UNK5RK7.1
N18722003: UNK5C53.1 UNK5K8.3
N18722012: UNK5C54.1 UNK5K9.3
N18722042: UNK5C59.1 UNK5K12.3
N18722049: UNK5K13.3 UNK5R1.1
N18722067: SITE5.8_S(ATT_S) UNK5K15.6 UNK5TP_ATT_S.1
N18722085: UNK5K5.1 UNK5RK5.1
N18722087: UNK5K6.1 UNK5RK6.1
N18722089: UNK5K8.1 UNK5RK8.1
N18722090: UNK5K9.1 UNK5RK9.1
N18722091: UNK5K10.1 UNK5RK10.1
N18722092: UNK5K11.1 UNK5RK11.1
N18722095: UNK5C58.1 UNK5K11.3
N18722098: UNK5K12.1 UNK5RK12.1
N18722100: UNK5K13.1 UNK5RK13.1
N18722103: UNK5K14.1 UNK5RK14.1
N18722105: UNK5K2.1 UNK5RK2.1
N18722106: UNK5K3.1 UNK5RK3.1
N18722107: UNK5K4.1 UNK5RK4.1
N18722127: SITE5.8_F(ATT_F) UNK5K15.3 UNK5TP_ATT_F.1
N18722139: UNK5C60.1 UNK5K16.3
N18722152: UNK5K17.1 UNK5RK17.1
N18722166: UNK5K16.1 UNK5RK16.1
N18722170: UNK5K18.1 UNK5RK18.1
N18723320: UNK5C69.1 UNK5K19.3
N18723347: UNK5K19.1 UNK5RK19.1
N18723349: UNK5K20.1 UNK5RK20.1
N18723350: UNK5K21.1 UNK5RK21.1
N18723375: UNK5K22.1 UNK5RK22.1
N18723381: SITE5.14_S(SDA_S) UNK5K23.6 UNK5TP_SDA_S.1
N18723395: SITE5.15_S(SCL_S) UNK5K24.6
N18723405: UNK5C62.1 UNK5K25.3
N18723423: UNK5K25.1 UNK5RK25.1
N18723427: UNK5K26.1 UNK5RK26.1
N18723432: UNK5C63.1 UNK5K27.3
N18723448: UNK5K28.1 UNK5RK28.1
N18723469: UNK5K27.1 UNK5RK27.1
N18723471: UNK5K29.1 UNK5RK29.1
N18723476: UNK5C61.1 UNK5K30.3
N18723490: UNK5K31.1 UNK5RK31.1
N18723510: UNK5K30.1 UNK5RK30.1
N18723513: UNK5K32.1 UNK5RK32.1
N18723515: UNK5K35.1 UNK5RK35.1
N18723517: UNK5K34.1 UNK5RK34.1
N18723519: UNK5K33.1 UNK5RK33.1
N18723522: UNK5C64.1 UNK5K33.3
N18723557: UNK5K37.1 UNK5RK37.1
N18723558: UNK5K36.1 UNK5RK36.1
N18723564: UNK5C65.1 UNK5K36.3
N18724850: UNK5K39.1 UNK5RK39.1
N18724851: UNK5K38.1 UNK5RK38.1
N18724857: UNK5C74.1 UNK5K38.3
N18724876: UNK5K40.1 UNK5RK40.1
N18724889: UNK5K41.1 UNK5RK41.1
N18724902: UNK5K42.1 UNK5RK42.1
N18724914: UNK5K43.1 UNK5RK43.1
N18724927: UNK5K45.1 UNK5RK45.1
N18724928: UNK5K44.1 UNK5RK44.1
N18724938: UNK5C66.1 UNK5K44.3
N18724956: UNK5K46.1 UNK5RK46.1
N18724972: UNK5C67.1 UNK5K47.3
N18724985: UNK5K48.1 UNK5RK48.1
N18724986: UNK5K47.1 UNK5RK47.1
N18724996: UNK5C68.1 UNK5K49.3
N18725009: UNK5K50.1 UNK5RK50.1
N18725010: UNK5K49.1 UNK5RK49.1
N18725824: UNK5K51.4 UNK5R7.2
N18725836: UNK5K53.4 UNK5R8.2
N18725838: UNK5K53.1 UNK5RK53.1
N18725860: UNK5R11.2 UNK5R19.1 UNK5TP_IN+_1.1 UNK5U1.3
N18725872: UNK5R14.2 UNK5R20.1 UNK5TP_IN+_2.1 UNK5U2.3
N18725882: UNK5K55.1 UNK5RK59.1
N18725885: UNK5K55.4 UNK5R19.2
N18725887: UNK5K56.1 UNK5RK60.1
N18725904: UNK5K57.3 UNK5R16.1 UNK5TP_IN-_3.1 UNK5U3.8
N18725905: UNK5K58.4 UNK5R16.2 UNK5TP_IN+_3.1 UNK5U3.7
N18725933: UNK5K60.4 UNK5R18.2 UNK5TP_IN+_4.1 UNK5U4.7
N18725937: UNK5K59.3 UNK5R18.1 UNK5TP_IN-_4.1 UNK5U4.8
N18725948: UNK5K56.4 UNK5K61.4 UNK5R20.2
N18725949: UNK5K54.1 UNK5RK54.1
N18725953: UNK5K51.1 UNK5RK51.1
N18725955: UNK5K52.1 UNK5RK52.1
N18726019: UNK5K57.1 UNK5RK55.2
N18726020: UNK5K58.1 UNK5RK56.2
N18726021: UNK5K59.1 UNK5RK57.2
N18726022: UNK5K60.1 UNK5RK58.2
N18726025: UNK5K61.1 UNK5RK61.1
N18727156: UNK6C48.1 UNK6K2.3
N18727165: UNK6C49.1 UNK6K3.3
N18727174: UNK6C50.1 UNK6K5.3
N18727207: UNK6K7.1 UNK6RK7.1
N18727214: UNK6C53.1 UNK6K8.3
N18727223: UNK6C54.1 UNK6K9.3
N18727253: UNK6C59.1 UNK6K12.3
N18727260: UNK6K13.3 UNK6R1.1
N18727278: SITE6.8_S(ATT_S) UNK6K15.6 UNK6TP_ATT_S.1
N18727296: UNK6K5.1 UNK6RK5.1
N18727298: UNK6K6.1 UNK6RK6.1
N18727300: UNK6K8.1 UNK6RK8.1
N18727301: UNK6K9.1 UNK6RK9.1
N18727302: UNK6K10.1 UNK6RK10.1
N18727303: UNK6K11.1 UNK6RK11.1
N18727306: UNK6C58.1 UNK6K11.3
N18727309: UNK6K12.1 UNK6RK12.1
N18727311: UNK6K13.1 UNK6RK13.1
N18727314: UNK6K14.1 UNK6RK14.1
N18727316: UNK6K2.1 UNK6RK2.1
N18727317: UNK6K3.1 UNK6RK3.1
N18727318: UNK6K4.1 UNK6RK4.1
N18727338: SITE6.8_F(ATT_F) UNK6K15.3 UNK6TP_ATT_F.1
N18727350: UNK6C60.1 UNK6K16.3
N18727363: UNK6K17.1 UNK6RK17.1
N18727377: UNK6K16.1 UNK6RK16.1
N18727381: UNK6K18.1 UNK6RK18.1
N18728531: UNK6C69.1 UNK6K19.3
N18728558: UNK6K19.1 UNK6RK19.1
N18728560: UNK6K20.1 UNK6RK20.1
N18728561: UNK6K21.1 UNK6RK21.1
N18728586: UNK6K22.1 UNK6RK22.1
N18728592: SITE6.14_S(SDA_S) UNK6K23.6 UNK6TP_SDA_S.1
N18728606: SITE6.15_S(SCL_S) UNK6K24.6
N18728616: UNK6C62.1 UNK6K25.3
N18728634: UNK6K25.1 UNK6RK25.1
N18728638: UNK6K26.1 UNK6RK26.1
N18728643: UNK6C63.1 UNK6K27.3
N18728659: UNK6K28.1 UNK6RK28.1
N18728680: UNK6K27.1 UNK6RK27.1
N18728682: UNK6K29.1 UNK6RK29.1
N18728687: UNK6C61.1 UNK6K30.3
N18728701: UNK6K31.1 UNK6RK31.1
N18728721: UNK6K30.1 UNK6RK30.1
N18728724: UNK6K32.1 UNK6RK32.1
N18728726: UNK6K35.1 UNK6RK35.1
N18728728: UNK6K34.1 UNK6RK34.1
N18728730: UNK6K33.1 UNK6RK33.1
N18728733: UNK6C64.1 UNK6K33.3
N18728768: UNK6K37.1 UNK6RK37.1
N18728769: UNK6K36.1 UNK6RK36.1
N18728775: UNK6C65.1 UNK6K36.3
N18730061: UNK6K39.1 UNK6RK39.1
N18730062: UNK6K38.1 UNK6RK38.1
N18730068: UNK6C74.1 UNK6K38.3
N18730087: UNK6K40.1 UNK6RK40.1
N18730100: UNK6K41.1 UNK6RK41.1
N18730113: UNK6K42.1 UNK6RK42.1
N18730125: UNK6K43.1 UNK6RK43.1
N18730138: UNK6K45.1 UNK6RK45.1
N18730139: UNK6K44.1 UNK6RK44.1
N18730149: UNK6C66.1 UNK6K44.3
N18730167: UNK6K46.1 UNK6RK46.1
N18730183: UNK6C67.1 UNK6K47.3
N18730196: UNK6K48.1 UNK6RK48.1
N18730197: UNK6K47.1 UNK6RK47.1
N18730207: UNK6C68.1 UNK6K49.3
N18730220: UNK6K50.1 UNK6RK50.1
N18730221: UNK6K49.1 UNK6RK49.1
N18731035: UNK6K51.4 UNK6R7.2
N18731047: UNK6K53.4 UNK6R8.2
N18731049: UNK6K53.1 UNK6RK53.1
N18731071: UNK6R11.2 UNK6R19.1 UNK6TP_IN+_1.1 UNK6U1.3
N18731083: UNK6R14.2 UNK6R20.1 UNK6TP_IN+_2.1 UNK6U2.3
N18731093: UNK6K55.1 UNK6RK59.1
N18731096: UNK6K55.4 UNK6R19.2
N18731098: UNK6K56.1 UNK6RK60.1
N18731115: UNK6K57.3 UNK6R16.1 UNK6TP_IN-_3.1 UNK6U3.8
N18731116: UNK6K58.4 UNK6R16.2 UNK6TP_IN+_3.1 UNK6U3.7
N18731144: UNK6K60.4 UNK6R18.2 UNK6TP_IN+_4.1 UNK6U4.7
N18731148: UNK6K59.3 UNK6R18.1 UNK6TP_IN-_4.1 UNK6U4.8
N18731159: UNK6K56.4 UNK6K61.4 UNK6R20.2
N18731160: UNK6K54.1 UNK6RK54.1
N18731164: UNK6K51.1 UNK6RK51.1
N18731166: UNK6K52.1 UNK6RK52.1
N18731230: UNK6K57.1 UNK6RK55.2
N18731231: UNK6K58.1 UNK6RK56.2
N18731232: UNK6K59.1 UNK6RK57.2
N18731233: UNK6K60.1 UNK6RK58.2
N18731236: UNK6K61.1 UNK6RK61.1
N18732367: UNK7C48.1 UNK7K2.3
N18732376: UNK7C49.1 UNK7K3.3
N18732385: UNK7C50.1 UNK7K5.3
N18732418: UNK7K7.1 UNK7RK7.1
N18732425: UNK7C53.1 UNK7K8.3
N18732434: UNK7C54.1 UNK7K9.3
N18732464: UNK7C59.1 UNK7K12.3
N18732471: UNK7K13.3 UNK7R1.1
N18732489: SITE7.8_S(ATT_S) UNK7K15.6 UNK7TP_ATT_S.1
N18732507: UNK7K5.1 UNK7RK5.1
N18732509: UNK7K6.1 UNK7RK6.1
N18732511: UNK7K8.1 UNK7RK8.1
N18732512: UNK7K9.1 UNK7RK9.1
N18732513: UNK7K10.1 UNK7RK10.1
N18732514: UNK7K11.1 UNK7RK11.1
N18732517: UNK7C58.1 UNK7K11.3
N18732520: UNK7K12.1 UNK7RK12.1
N18732522: UNK7K13.1 UNK7RK13.1
N18732525: UNK7K14.1 UNK7RK14.1
N18732527: UNK7K2.1 UNK7RK2.1
N18732528: UNK7K3.1 UNK7RK3.1
N18732529: UNK7K4.1 UNK7RK4.1
N18732549: SITE7.8_F(ATT_F) UNK7K15.3 UNK7TP_ATT_F.1
N18732561: UNK7C60.1 UNK7K16.3
N18732574: UNK7K17.1 UNK7RK17.1
N18732588: UNK7K16.1 UNK7RK16.1
N18732592: UNK7K18.1 UNK7RK18.1
N18733742: UNK7C69.1 UNK7K19.3
N18733769: UNK7K19.1 UNK7RK19.1
N18733771: UNK7K20.1 UNK7RK20.1
N18733772: UNK7K21.1 UNK7RK21.1
N18733797: UNK7K22.1 UNK7RK22.1
N18733803: SITE7.14_S(SDA_S) UNK7K23.6 UNK7TP_SDA_S.1
N18733817: SITE7.15_S(SCL_S) UNK7K24.6
N18733827: UNK7C62.1 UNK7K25.3
N18733845: UNK7K25.1 UNK7RK25.1
N18733849: UNK7K26.1 UNK7RK26.1
N18733854: UNK7C63.1 UNK7K27.3
N18733870: UNK7K28.1 UNK7RK28.1
N18733891: UNK7K27.1 UNK7RK27.1
N18733893: UNK7K29.1 UNK7RK29.1
N18733898: UNK7C61.1 UNK7K30.3
N18733912: UNK7K31.1 UNK7RK31.1
N18733932: UNK7K30.1 UNK7RK30.1
N18733935: UNK7K32.1 UNK7RK32.1
N18733937: UNK7K35.1 UNK7RK35.1
N18733939: UNK7K34.1 UNK7RK34.1
N18733941: UNK7K33.1 UNK7RK33.1
N18733944: UNK7C64.1 UNK7K33.3
N18733979: UNK7K37.1 UNK7RK37.1
N18733980: UNK7K36.1 UNK7RK36.1
N18733986: UNK7C65.1 UNK7K36.3
N18735272: UNK7K39.1 UNK7RK39.1
N18735273: UNK7K38.1 UNK7RK38.1
N18735279: UNK7C74.1 UNK7K38.3
N18735298: UNK7K40.1 UNK7RK40.1
N18735311: UNK7K41.1 UNK7RK41.1
N18735324: UNK7K42.1 UNK7RK42.1
N18735336: UNK7K43.1 UNK7RK43.1
N18735349: UNK7K45.1 UNK7RK45.1
N18735350: UNK7K44.1 UNK7RK44.1
N18735360: UNK7C66.1 UNK7K44.3
N18735378: UNK7K46.1 UNK7RK46.1
N18735394: UNK7C67.1 UNK7K47.3
N18735407: UNK7K48.1 UNK7RK48.1
N18735408: UNK7K47.1 UNK7RK47.1
N18735418: UNK7C68.1 UNK7K49.3
N18735431: UNK7K50.1 UNK7RK50.1
N18735432: UNK7K49.1 UNK7RK49.1
N18736246: UNK7K51.4 UNK7R7.2
N18736258: UNK7K53.4 UNK7R8.2
N18736260: UNK7K53.1 UNK7RK53.1
N18736282: UNK7R11.2 UNK7R19.1 UNK7TP_IN+_1.1 UNK7U1.3
N18736294: UNK7R14.2 UNK7R20.1 UNK7TP_IN+_2.1 UNK7U2.3
N18736304: UNK7K55.1 UNK7RK59.1
N18736307: UNK7K55.4 UNK7R19.2
N18736309: UNK7K56.1 UNK7RK60.1
N18736326: UNK7K57.3 UNK7R16.1 UNK7TP_IN-_3.1 UNK7U3.8
N18736327: UNK7K58.4 UNK7R16.2 UNK7TP_IN+_3.1 UNK7U3.7
N18736355: UNK7K60.4 UNK7R18.2 UNK7TP_IN+_4.1 UNK7U4.7
N18736359: UNK7K59.3 UNK7R18.1 UNK7TP_IN-_4.1 UNK7U4.8
N18736370: UNK7K56.4 UNK7K61.4 UNK7R20.2
N18736371: UNK7K54.1 UNK7RK54.1
N18736375: UNK7K51.1 UNK7RK51.1
N18736377: UNK7K52.1 UNK7RK52.1
N18736441: UNK7K57.1 UNK7RK55.2
N18736442: UNK7K58.1 UNK7RK56.2
N18736443: UNK7K59.1 UNK7RK57.2
N18736444: UNK7K60.1 UNK7RK58.2
N18736447: UNK7K61.1 UNK7RK61.1
N18737578: UNK8C48.1 UNK8K2.3
N18737587: UNK8C49.1 UNK8K3.3
N18737596: UNK8C50.1 UNK8K5.3
N18737629: UNK8K7.1 UNK8RK7.1
N18737636: UNK8C53.1 UNK8K8.3
N18737645: UNK8C54.1 UNK8K9.3
N18737675: UNK8C59.1 UNK8K12.3
N18737682: UNK8K13.3 UNK8R1.1
N18737700: SITE8.8_S(ATT_S) UNK8K15.6 UNK8TP_ATT_S.1
N18737718: UNK8K5.1 UNK8RK5.1
N18737720: UNK8K6.1 UNK8RK6.1
N18737722: UNK8K8.1 UNK8RK8.1
N18737723: UNK8K9.1 UNK8RK9.1
N18737724: UNK8K10.1 UNK8RK10.1
N18737725: UNK8K11.1 UNK8RK11.1
N18737728: UNK8C58.1 UNK8K11.3
N18737731: UNK8K12.1 UNK8RK12.1
N18737733: UNK8K13.1 UNK8RK13.1
N18737736: UNK8K14.1 UNK8RK14.1
N18737738: UNK8K2.1 UNK8RK2.1
N18737739: UNK8K3.1 UNK8RK3.1
N18737740: UNK8K4.1 UNK8RK4.1
N18737760: SITE8.8_F(ATT_F) UNK8K15.3 UNK8TP_ATT_F.1
N18737772: UNK8C60.1 UNK8K16.3
N18737785: UNK8K17.1 UNK8RK17.1
N18737799: UNK8K16.1 UNK8RK16.1
N18737803: UNK8K18.1 UNK8RK18.1
N18738953: UNK8C69.1 UNK8K19.3
N18738980: UNK8K19.1 UNK8RK19.1
N18738982: UNK8K20.1 UNK8RK20.1
N18738983: UNK8K21.1 UNK8RK21.1
N18739008: UNK8K22.1 UNK8RK22.1
N18739014: SITE8.14_S(SDA_S) UNK8K23.6 UNK8TP_SDA_S.1
N18739028: SITE8.15_S(SCL_S) UNK8K24.6
N18739038: UNK8C62.1 UNK8K25.3
N18739056: UNK8K25.1 UNK8RK25.1
N18739060: UNK8K26.1 UNK8RK26.1
N18739065: UNK8C63.1 UNK8K27.3
N18739081: UNK8K28.1 UNK8RK28.1
N18739102: UNK8K27.1 UNK8RK27.1
N18739104: UNK8K29.1 UNK8RK29.1
N18739109: UNK8C61.1 UNK8K30.3
N18739123: UNK8K31.1 UNK8RK31.1
N18739143: UNK8K30.1 UNK8RK30.1
N18739146: UNK8K32.1 UNK8RK32.1
N18739148: UNK8K35.1 UNK8RK35.1
N18739150: UNK8K34.1 UNK8RK34.1
N18739152: UNK8K33.1 UNK8RK33.1
N18739155: UNK8C64.1 UNK8K33.3
N18739190: UNK8K37.1 UNK8RK37.1
N18739191: UNK8K36.1 UNK8RK36.1
N18739197: UNK8C65.1 UNK8K36.3
N18740483: UNK8K39.1 UNK8RK39.1
N18740484: UNK8K38.1 UNK8RK38.1
N18740490: UNK8C74.1 UNK8K38.3
N18740509: UNK8K40.1 UNK8RK40.1
N18740522: UNK8K41.1 UNK8RK41.1
N18740535: UNK8K42.1 UNK8RK42.1
N18740547: UNK8K43.1 UNK8RK43.1
N18740560: UNK8K45.1 UNK8RK45.1
N18740561: UNK8K44.1 UNK8RK44.1
N18740571: UNK8C66.1 UNK8K44.3
N18740589: UNK8K46.1 UNK8RK46.1
N18740605: UNK8C67.1 UNK8K47.3
N18740618: UNK8K48.1 UNK8RK48.1
N18740619: UNK8K47.1 UNK8RK47.1
N18740629: UNK8C68.1 UNK8K49.3
N18740642: UNK8K50.1 UNK8RK50.1
N18740643: UNK8K49.1 UNK8RK49.1
N18741457: UNK8K51.4 UNK8R7.2
N18741469: UNK8K53.4 UNK8R8.2
N18741471: UNK8K53.1 UNK8RK53.1
N18741493: UNK8R11.2 UNK8R19.1 UNK8TP_IN+_1.1 UNK8U1.3
N18741505: UNK8R14.2 UNK8R20.1 UNK8TP_IN+_2.1 UNK8U2.3
N18741515: UNK8K55.1 UNK8RK59.1
N18741518: UNK8K55.4 UNK8R19.2
N18741520: UNK8K56.1 UNK8RK60.1
N18741537: UNK8K57.3 UNK8R16.1 UNK8TP_IN-_3.1 UNK8U3.8
N18741538: UNK8K58.4 UNK8R16.2 UNK8TP_IN+_3.1 UNK8U3.7
N18741566: UNK8K60.4 UNK8R18.2 UNK8TP_IN+_4.1 UNK8U4.7
N18741570: UNK8K59.3 UNK8R18.1 UNK8TP_IN-_4.1 UNK8U4.8
N18741581: UNK8K56.4 UNK8K61.4 UNK8R20.2
N18741582: UNK8K54.1 UNK8RK54.1
N18741586: UNK8K51.1 UNK8RK51.1
N18741588: UNK8K52.1 UNK8RK52.1
N18741652: UNK8K57.1 UNK8RK55.2
N18741653: UNK8K58.1 UNK8RK56.2
N18741654: UNK8K59.1 UNK8RK57.2
N18741655: UNK8K60.1 UNK8RK58.2
N18741658: UNK8K61.1 UNK8RK61.1

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; FD7 1; FD8 1; FD9 1; FD10 1; FD11 1; FD12 1; FD13 1; FD14 1; FD15 1; FD16 1; K15 7; K23 7; K24 7; REF NUT1 NUT2 NUT3 NUT4; SITE1 NUT1 NUT2 NUT3 NUT4; SITE2 NUT1 NUT2 NUT3 NUT4; SITE3 NUT1 NUT2 NUT3 NUT4; SITE4 NUT1 NUT2 NUT3 NUT4; SITE5 NUT1 NUT2 NUT3 NUT4; SITE6 NUT1 NUT2 NUT3 NUT4; SITE7 NUT1 NUT2 NUT3 NUT4; SITE8 NUT1 NUT2 NUT3 NUT4; SLOT0 A1 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT01 A1 A19 A37 A42 A45 A49 A50 A54 A59 B37 B42 B44 B46 B48 B50 B52 B54 B56 B58 B60 C37 D19 D37 E1 E37 E62 F42 F44 F46 F48 F50 F52 F54 F56 F58 F60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT02 A1 A19 A37 A42 A45 A49 A50 A54 A59 B37 B42 B44 B46 B48 B50 B52 B54 B56 B58 B60 C37 D19 D37 E1 E37 E62 F42 F44 F46 F48 F50 F52 F54 F56 F58 F60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT03 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT04 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT05 B6 D6 D23 D27 D31 D35 E4 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT06 A1 A2 A3 A4 A19 A61 B1 B2 B3 B4 B61 B62 C1 C2 C3 C4 C62 D1 D2 D3 D4 D19 E1 E2 E3 E4 E19 E62 F1 F2 F3 F4 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z17 Z19 Z37 Z51 Z61; SLOT07 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT08 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT09 A10 G10 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT10 A10 G10 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT11 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT12 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT13 A1 A2 A3 A4 A19 A61 B1 B2 B3 B4 B61 B62 C1 C2 C3 C4 C62 D1 D2 D3 D4 D19 E1 E2 E3 E4 E19 E62 F1 F2 F3 F4 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z17 Z19 Z37 Z51 Z61; SLOT14 B6 D6 D23 D27 D31 D35 E4 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT15 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT16 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT17 A1 A19 A37 A42 A45 A49 A50 A54 A59 B37 B42 B44 B46 B48 B50 B52 B54 B56 B58 B60 C37 D19 D37 E1 E37 E62 F42 F44 F46 F48 F50 F52 F54 F56 F58 F60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT18 A1 A19 A37 A42 A45 A49 A50 A54 A59 B37 B42 B44 B46 B48 B50 B52 B54 B56 B58 B60 C37 D19 D37 E1 E37 E62 F42 F44 F46 F48 F50 F52 F54 F56 F58 F60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; SLOT19 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 A18 A19 A20 A21 A22 A23 A24 A25 A26 A27 A28 A29 A30 A31 A32 A33 A34 A35 A36 A37 A38 A39 A40 A41 A42 A43 A44 A45 A46 A47 A48 A49 A50 A51 A52 A53 A54 A55 A56 A57 A58 A59 A60 A61 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 B18 B19 B20 B21 B22 B23 B24 B25 B26 B27 B28 B29 B30 B31 B32 B33 B34 B35 B36 B37 B38 B39 B40 B41 B42 B43 B44 B45 B46 B47 B48 B49 B50 B51 B52 B53 B54 B55 B56 B57 B58 B59 B60 B61 B62 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 C18 C19 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C49 C50 C51 C52 C53 C54 C55 C56 C57 C58 C59 C60 C61 C62 D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16 D17 D18 D19 D20 D21 D22 D23 D24 D25 D26 D27 D28 D29 D30 D31 D32 D33 D34 D35 D36 D37 D38 D39 D40 D41 D42 D43 D44 D45 D46 D47 D48 D49 D50 D51 D52 D53 D54 D55 D56 D57 D58 D59 D60 D61 E1 E2 E3 E4 E5 E6 E7 E8 E9 E10 E11 E12 E13 E14 E15 E16 E17 E18 E19 E20 E21 E22 E23 E24 E25 E26 E27 E28 E29 E30 E31 E32 E33 E34 E35 E36 E37 E38 E39 E40 E41 E42 E43 E44 E45 E46 E47 E48 E49 E50 E51 E52 E53 E54 E55 E56 E57 E58 E59 E60 E61 E62 F1 F2 F3 F4 F5 F6 F7 F8 F9 F10 F11 F12 F13 F14 F15 F16 F17 F18 F19 F20 F21 F22 F23 F24 F25 F26 F27 F28 F29 F30 F31 F32 F33 F34 F35 F36 F37 F38 F39 F40 F41 F42 F43 F44 F45 F46 F47 F48 F49 F50 F51 F52 F53 F54 F55 F56 F57 F58 F59 F60 F61 F62 G2 G4 G6 G8 G10 G12 G14 G16 G18 G20 G22 G24 G26 G28 G30 G32 G34 G36 G38 G40 G42 G44 G46 G48 G50 G52 G54 G56 G58 G60 Z5 Z7 Z9 Z11 Z13 Z15 Z17 Z19 Z21 Z23 Z25 Z27 Z29 Z31 Z33 Z35 Z37 Z39 Z41 Z43 Z45 Z47 Z49 Z51 Z53 Z55 Z57 Z59 Z61; STIRLING 1; U3 6; U4 6; UNK2K15 7; UNK2K23 7; UNK2K24 7; UNK2U3 6; UNK2U4 6; UNK3K15 7; UNK3K23 7; UNK3K24 7; UNK3U3 6; UNK3U4 6; UNK4K15 7; UNK4K23 7; UNK4K24 7; UNK4U3 6; UNK4U4 6; UNK5K15 7; UNK5K23 7; UNK5K24 7; UNK5U3 6; UNK5U4 6; UNK6K15 7; UNK6K23 7; UNK6K24 7; UNK6U3 6; UNK6U4 6; UNK7K15 7; UNK7K23 7; UNK7K24 7; UNK7U3 6; UNK7U4 6; UNK8K15 7; UNK8K23 7; UNK8K24 7; UNK8U3 6; UNK8U4 6; UNK038K2-26081712Q-A100 1; UNK980K2-260817-1A4- 1

## Via types
v1: diameter 0.457, hole 0.254, TOP to BOTTOM, 1914 vias
v2: diameter 0.3, hole 0.153, TOP to BOTTOM, 376 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND:
  vias: v2(146.65,209.64) v2(146.65,209.24) v2(147.05,209.64) v2(186.65,269.64) v2(186.65,269.24) v2(186.65,209.64) v2(186.65,209.24) v2(187.05,269.64) v2(187.05,209.64) v2(226.65,269.64) v2(226.65,269.24) v2(226.65,209.64) v2(226.65,209.24) v2(227.05,269.64) v2(227.05,209.64) v2(266.65,269.64) v2(266.65,269.24) v2(266.65,209.64) v2(266.65,209.24) v2(267.05,269.64) v2(267.05,209.64)
CBIT_2:
  vias: v1(145.42,281.97) v1(145.42,221.97) v1(225.41,281.97) v1(225.41,221.97)
CBIT_3:
  vias: v1(130.02,274.45) v1(130.02,214.45) v1(210.02,274.45) v1(210.02,214.45)
CBIT_4:
  vias: v1(145.42,295.94) v1(145.42,235.94) v1(225.41,295.94) v1(225.41,235.94)
CBIT_5:
  vias: v1(139.08,269.49) v1(139.08,209.49) v1(219.08,269.49) v1(219.08,209.49)
CBIT_6:
  vias: v1(139.08,266.69) v1(139.08,206.69) v1(219.08,266.69) v1(219.08,206.69)
CBIT_7:
  vias: v1(139.08,264.66) v1(139.08,204.66) v1(219.08,264.66) v1(219.08,204.66)
CBIT_8:
  vias: v1(139.08,262.12) v1(139.08,202.12) v1(219.08,262.12) v1(219.08,202.12)
CBIT_9:
  vias: v1(133.36,262.12) v1(133.36,202.12) v1(213.36,262.12) v1(213.36,202.12)
CBIT_10:
  vias: v1(134.51,264.66) v1(134.51,204.66) v1(214.51,264.66) v1(214.51,204.66)
