# Allegro board 980K2-260817_261117-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL13_DP_71: length 310.3
  L03_DP w0.079: SLOT13.B35 243.42,422.29 244.53,421.17 244.92,421.17 245.59,420.5 246.17,420.5 246.61,420.94 247.14,420.94 247.52,420.56 247.52,420.43 247.69,420.26 248.22,420.26 248.3,420.34 248.3,420.63 248.78,421.12 249.47,421.12 250,420.59 250.76,420.59 251.11,420.94 251.64,420.94 252.11,420.47 253.82,420.47 256.79,417.5 256.79,390.57 251.93,385.72 251.93,366.29 186.84,301.2 186.84,271.04 184.91,269.11 184.91,258.09 184.52,257.7 184.52,254.61 184.17,254.26 183.27,254.26 182.49,253.48 182.49,252.09 178.58,248.18 178.58,244.51 177.49,243.43 171.05,243.43 163.82,236.19 163.82,230.62 163.38,230.19 163.38,229.55 164.28,228.65 165.42,228.65 168.17,225.9 168.17,223.57 167.79,223.19 167.79,219 164.39,215.59 159.09,215.59 158.55,215.05 158.55,210.46 158.04,209.96 156.49,209.96 154.11,207.59 154.11,202.52 154.67,201.96 154.67,189.63 152.74,187.7 152.74,183.91 UNK5K23.2
SL13_DP_72: length 308.2
  L03_DP w0.079: UNK5K24.2 159.44,182.96 158.11,184.28 158.11,191.95 157.64,192.42 156.06,192.42 155.12,193.36 155.12,201.99 154.43,202.68 154.43,206.4 155.6,207.57 155.6,208.31 156.92,209.64 158.86,209.64 159.93,210.7 159.93,214.44 160.76,215.27 164.52,215.27 168.49,219.24 168.49,226.84 164.81,230.52 164.81,235.43 170.69,241.31 177.38,241.31 179.84,243.77 179.84,248.97 181.98,251.11 184.43,251.11 184.89,251.57 184.89,257.5 185.26,257.88 185.26,260.32 186.33,261.38 186.33,269.92 189,272.59 189,302.81 252.28,366.1 252.28,385.63 257.1,390.44 257.1,417.63 252.79,421.94 252.23,421.94 251.75,421.45 251,421.45 250.52,421.94 249.98,421.94 249.46,421.41 248.79,421.41 248.27,421.94 247.73,421.94 247.25,421.46 246.5,421.46 246.02,421.94 244.98,421.94 SLOT13.C35
SL13_DP_73: length 296.8
  L03_DP w0.079: v1(156.47,193.35) 156.47,194.09 155.46,195.1 155.46,202.16 154.79,202.83 154.79,206.25 155.47,206.93 157.63,206.93 158.39,207.69 158.39,208.62 160.24,210.47 160.24,214.3 160.9,214.96 164.64,214.96 168.8,219.12 168.8,227.16 165.13,230.83 165.13,235.24 170.85,240.96 178.74,240.96 181.34,243.57 181.34,248.98 183.1,250.73 184.72,250.73 185.23,251.25 185.23,257.27 185.59,257.63 185.59,260.08 189.13,263.62 191.13,263.62 192.55,265.04 192.55,269.65 189.34,272.86 189.34,302.66 252.63,365.95 252.63,385.53 257.42,390.31 257.42,417.76 253.06,422.12 252.16,422.12 251.67,421.63 251.08,421.63 250.59,422.12 249.91,422.12 249.38,421.59 248.87,421.59 248.17,422.29 SLOT13.D35
SL13_DP_74: length 568.4
  L05_DP w0.079: 222.38,205.54 223.67,204.25 231.06,204.25 237.4,210.59 239.27,210.59 241.24,212.55 246.99,212.55 250.3,215.87 250.3,225.1 251.73,226.53 254.28,226.53 255.12,225.68 263.38,225.68 263.92,226.23 263.92,228.35 265.76,230.18 299.41,230.18 309.52,240.29 309.52,328.73 294.92,343.33 294.92,378.03 279.42,393.53 279.42,407.12 266.69,419.85 254.87,419.85 252.79,421.94 252.23,421.94 251.93,421.64 251.07,421.64 250.57,422.14 249.93,422.14 249.79,422.29 SLOT13.E35 ; 255.01,397.9 255.01,385.68 254.36,385.03 254.36,365.16 194.33,305.13 194.33,271.29 194.71,270.91 194.71,249.22 193.7,248.21 188.34,248.21 187.54,247.41 187.54,246.69 177.84,236.99 171.5,236.99 170.4,235.89 170.4,218.23 167.62,215.45 167.62,210.47 166.39,209.24 166.39,204.42 164.73,202.76 164.73,201.2 164.39,200.87 v1(163.84,200.87)
SL13_DP_75: length 564.5
  L05_DP w0.079: SLOT13.F35 252.04,422.29 252.21,422.12 253.17,422.12 255.11,420.17 266.82,420.17 279.73,407.25 279.73,393.66 295.24,378.16 295.24,343.46 309.83,328.86 309.83,240.16 299.54,229.87 271.98,229.87 271.25,229.14 270.86,229.14 270.14,229.87 265.89,229.87 264.24,228.22 264.24,226.1 263.51,225.37 254.99,225.37 254.15,226.21 251.86,226.21 250.62,224.97 250.62,215.74 247.12,212.24 241.37,212.24 239.4,210.27 237.53,210.27 231.19,203.93 223.54,203.93 222.16,205.32 ; 255.64,397.9 255.64,384.98 255.42,384.76 255.42,364.79 197.09,306.46 197.09,262.12 195.81,260.83 195.81,244.43 194.78,243.4 190.62,243.4 189.97,242.75 185.06,242.75 181.88,239.56 181.88,216.14 170.82,205.08 170.82,202.53 170.56,202.27 169.79,202.27 169.42,201.9 169.42,201.51 168.77,200.87 v1(168.42,200.87)
SL13_DP_76: length 293.3
  L03_DP w0.079: v1(163.84,204.68) 164.81,205.64 164.81,208.67 166.53,210.4 166.53,214.94 170.08,218.49 170.08,233.65 169.41,234.32 169.41,235.63 171.16,237.38 177.61,237.38 183.79,243.56 183.79,244.57 187.1,247.87 187.1,248.37 187.99,249.27 191.64,249.27 192.69,250.31 192.69,258.49 193.98,259.79 193.98,305.27 254.01,365.3 254.01,385.13 258.68,389.79 258.68,418.03 252.77,423.94 252.23,423.94 251.62,423.32 251.13,423.32 250.52,423.94 249.98,423.94 249.41,423.37 249.09,423.37 247.82,424.64 247.7,424.64 247.22,425.12 246.52,425.12 246.4,425.24 246.4,425.56 245.84,426.11 245.84,426.46 246.4,427.02 246.4,427.56 246.02,427.94 245.48,427.94 244.84,427.3 244.41,427.3 243.77,427.94 243.23,427.94 242.59,427.3 242.16,427.3 241.52,427.94 240.98,427.94 240.16,427.12 239.78,427.12 239.3,426.63 239.3,425.91 239.65,425.56 239.65,425.02 239.12,424.49 239.12,424.08 239.65,423.56 239.65,423.02 238.92,422.29 SLOT13.Z35
SL13_DP_77: length 292.5
  L03_DP w0.079: v1(168.42,204.68) 168.96,204.68 169.27,204.98 169.27,205.8 169.7,206.23 169.7,207.21 169.23,207.67 169.23,214.37 171.04,216.17 171.04,229.94 172.69,231.6 172.69,235.82 173.18,236.31 178.12,236.31 186.68,244.87 189.79,244.87 190.5,245.59 194.7,245.59 195.44,246.33 195.44,260.99 196.64,262.19 196.64,306.46 255.11,364.92 255.11,384.89 259.62,389.4 259.62,417.53 253.03,424.12 252.16,424.12 251.54,423.5 251.21,423.5 250.59,424.12 250.21,424.12 249.39,424.94 248.73,424.94 248.65,425.02 248.65,425.56 248.27,425.94 247.73,425.94 247.35,425.56 246.94,425.56 246.86,425.64 246.57,425.64 246.02,426.19 246.02,426.38 246.58,426.94 246.58,427.63 246.09,428.12 245.41,428.12 244.77,427.48 244.48,427.48 243.84,428.12 243.16,428.12 242.52,427.48 242.23,427.48 241.59,428.12 240.91,428.12 240.09,427.3 239.91,427.3 239.27,427.94 238.73,427.94 238.35,427.56 238.35,427.02 238.71,426.66 238.71,425.91 237.88,425.08 SLOT13.Z33
SL13_DP_78: length 234.8
  L05_DP w0.079: v1(163.84,207.72) 164.46,208.34 164.46,208.79 166.21,210.54 166.21,215.17 169.76,218.72 169.76,229.19 168.32,230.63 168.32,235.13 171.01,237.82 177.42,237.82 182.76,243.16 182.76,246.09 183.2,246.53 184.52,246.53 187.64,249.66 189.85,249.66 190.47,250.27 190.47,258.33 193.63,261.49 193.63,305.42 253.66,365.45 253.66,385.22 254.38,385.94 254.38,390.4 254.7,390.71 254.7,397.9
SL13_DP_79: length 233.2
  L05_DP w0.079: v1(168.42,207.72) 167.51,208.63 167.51,209.83 167.96,210.27 167.96,215.23 170.72,217.99 170.72,230.71 171.61,231.6 171.61,235.64 172.63,236.66 177.98,236.66 187.88,246.56 189.44,246.56 190.69,247.82 193.93,247.82 195.11,249 195.11,271.11 194.66,271.55 194.66,304.99 254.69,365.02 254.69,384.92 255.33,385.55 255.33,397.9
SL13_DP_80: length 275.8
  L03_DP w0.079: SLOT13.C33 244.63,423.49 245.48,422.64 246.27,422.64 246.61,422.97 246.61,423.64 246.23,424.02 246.23,424.56 246.61,424.94 247.14,424.94 247.52,424.56 247.52,424.32 247.9,423.94 248.27,423.94 248.65,423.56 248.65,423.19 248.72,423.12 249.47,423.12 249.95,422.63 250.55,422.63 251.03,423.12 251.72,423.12 252.36,422.48 253.59,422.48 258.05,418.02 258.05,390.05 253.34,385.34 253.34,365.68 191.76,304.1 191.76,271.59 193.26,270.1 193.26,262.78 190.06,259.58 190.06,253.32 189.28,252.54 188.32,252.54 187.72,251.94 187.72,250.27 185.57,248.12 182.94,248.12 182.38,247.56 182.38,243.4 179.21,240.23 172.86,240.23 167.21,234.58 167.21,230.33 169.44,228.1 169.44,218.86 165,214.42 165,213.47 164.69,213.16 164.69,211.62 v1(163.84,210.77)
SL13_DP_81: length 268.8
  L03_DP w0.079: v1(163.84,213.41) 164.69,214.26 164.69,214.55 169.12,218.99 169.12,227.31 166.09,230.34 166.09,235.72 170.98,240.6 178.97,240.6 181.71,243.34 181.71,248.26 182.91,249.46 184.64,249.46 185.57,250.38 185.57,256.86 186.04,257.33 186.99,257.33 187.54,257.88 187.54,260.32 188.36,261.15 189.82,261.15 192.89,264.21 192.89,269.85 191.42,271.32 191.42,304.24 253,365.82 253,385.45 257.73,390.18 257.73,417.89 253.33,422.3 252.28,422.3 251.64,422.94 251.11,422.94 250.62,422.45 249.88,422.45 249.39,422.94 248.86,422.94 248.54,422.62 247.75,422.62 246.88,423.49 SLOT13.D33
SL13_DP_82: length 420.2
  L05_DP w0.079: SLOT13.E33 249.28,424.13 250.61,424.13 251.11,423.64 251.64,423.64 252.14,424.13 253.43,424.13 254.42,423.14 254.61,423.14 256.11,421.64 267.25,421.64 281.14,407.75 281.14,394.08 297.05,378.16 297.05,344.34 312.03,329.37 312.03,226.82 298.36,213.16 287.52,213.16 287.06,212.7 280.97,212.7 280.51,213.16 267.01,213.16 265.43,211.58 261.86,211.58 260.62,212.82 256.26,212.82 254.09,210.65 248.92,210.65 247.6,209.33 247.6,207.18 246.86,206.45 235.82,206.45 231.96,202.59 212.27,202.59 211.5,203.36 197.26,203.36 196.5,202.61 184.84,202.61 181.72,199.49 160.62,199.49 158.38,197.25 156.07,197.25 155.17,198.14 155.17,209.22 156.08,210.13 v1(156.08,212.18)
SL13_DP_83: length 426
  L05_DP w0.079: v1(156.08,216.75) 156.08,216.19 156,216.11 155.97,216.11 154.48,214.62 154.48,210.58 154.86,210.2 154.86,198.01 155.94,196.93 158.51,196.93 160.75,199.17 181.85,199.17 184.97,202.29 197.44,202.29 197.54,202.19 197.93,202.19 198.78,203.05 208.34,203.05 209.95,201.44 214.08,201.44 214.63,201.99 216.86,201.99 217.59,201.25 220.2,201.25 220.63,201.69 222.44,201.69 222.87,201.25 231.53,201.25 235.57,205.29 238.78,205.29 239.21,204.86 240.54,204.86 241.81,206.14 246.99,206.14 247.91,207.05 247.91,208.82 248.61,209.52 253.41,209.52 256.39,212.5 260.49,212.5 261.73,211.26 265.56,211.26 266.75,212.45 271.43,212.45 271.82,212.84 280.38,212.84 280.83,212.39 287.19,212.39 287.65,212.84 298.49,212.84 312.34,226.69 312.34,329.5 297.37,344.47 297.37,378.29 281.45,394.21 281.45,407.88 267.38,421.96 256.5,421.96 254.04,424.42 251.99,424.42 251.86,424.29 SLOT13.F33
SL13_DP_84: length 269.9
  L03_DP w0.079: SLOT13.A31 241.46,426.29 242.11,426.94 242.64,426.94 243.29,426.29 243.71,426.29 244.36,426.94 244.89,426.94 245.27,426.56 245.27,425.98 244.92,425.63 244.92,425.27 244.76,425.12 244.28,425.12 243.8,424.63 243.8,424.19 243.54,423.94 243.23,423.94 242.85,423.56 242.85,423.25 242.72,423.12 242.03,423.12 241.44,422.53 241.44,422.01 242.52,420.94 242.64,420.94 243.02,420.56 243.02,420.43 243.52,419.94 243.77,419.94 244.15,419.56 244.15,419.31 244.52,418.94 244.89,418.94 245.27,418.56 245.27,418.18 245.52,417.94 246.02,417.94 246.66,417.3 246.84,417.3 247.66,418.12 248.34,418.12 248.97,417.49 249.25,417.49 249.87,418.12 250.59,418.12 251.15,417.56 251.85,417.56 252.23,417.94 253.62,417.94 255.21,416.34 255.21,391.23 249.95,385.96 249.95,367.11 184.05,301.22 184.05,273.32 180.35,269.62 180.35,260.41 179.02,259.07 174.56,259.07 170.74,255.25 170.74,245.56 159.72,234.55 159.72,226.89 156.67,223.83 156.67,221.91 v1(156.08,221.32)
SL13_DP_85: length 280
  L03_DP w0.079: SLOT13.B31 242.1,426.02 242.1,425.31 241.9,425.11 241.9,424.98 241.55,424.63 241.55,424.35 241.31,424.12 240.91,424.12 240.42,423.63 240.42,422.94 240.87,422.49 240.87,422.12 240.74,421.98 240.74,421.95 240.5,421.71 240.5,421.71 240.42,421.63 240.42,420.94 240.91,420.46 241.03,420.46 242.03,419.46 242.5,419.46 242.67,419.28 242.67,418.94 243.16,418.46 243.5,418.46 243.8,418.16 243.8,417.94 244.28,417.46 244.5,417.46 244.92,417.03 244.92,416.94 245.41,416.46 245.5,416.46 245.52,416.44 246.08,416.44 246.57,416.94 247.14,416.94 247.61,416.47 247.84,416.47 247.98,416.6 248.27,416.6 248.78,417.12 249.47,417.12 249.95,416.63 249.95,416.36 250.03,416.28 250.45,416.28 251.11,416.94 251.67,416.94 253.57,415.04 253.57,392.2 248.04,386.66 248.04,368.01 178.8,298.78 178.8,289.88 181.57,287.11 181.57,277.97 179.09,275.49 178.04,275.49 172.53,269.97 172.53,260.61 168.77,256.85 168.77,246.25 168.13,245.61 162.18,245.61 161.16,244.59 161.16,239.32 159.61,237.77 155.3,237.77 154.7,237.17 154.7,236.91 154.7,228.35 154.99,228.07 154.99,226.44 153.75,225.2 153.75,223.74 153.06,223.06 152.06,223.06 151.78,222.78 151.78,222.39 152.06,222.12 152.45,222.12 152.69,221.88 152.69,221.38 152.68,221.37 152.68,219.57 152.69,219.57 152.69,218.25 152.73,218.21 152.73,217.82 152.69,217.79 152.69,216.84 152.73,216.8 152.73,216.41 152.69,216.38 152.69,215.54 152.68,215.53 152.68,213.73 152.69,213.72 152.69,212.64 v1(153.15,212.18)
SL13_DP_86: length 270.6
  L03_DP w0.079: SLOT13.C31 244.27,425.94 243.23,425.94 242.85,425.56 242.85,425.02 243.09,424.77 243.09,424.05 242.68,423.64 241.94,423.64 241.64,423.94 240.98,423.94 240.6,423.56 240.6,423.02 241.05,422.56 241.05,422.04 240.92,421.91 240.92,421.87 240.68,421.64 240.6,421.56 240.6,421.02 240.98,420.64 241.57,420.64 241.73,420.48 241.73,420.02 242.11,419.64 242.57,419.64 242.85,419.36 242.85,419.02 243.23,418.64 243.57,418.64 243.98,418.23 243.98,418.02 244.36,417.64 244.57,417.64 245.1,417.11 245.1,417.02 245.48,416.64 245.57,416.64 245.59,416.62 246,416.62 246.5,417.12 246.91,417.12 247.73,417.94 248.27,417.94 248.91,417.3 249.34,417.3 249.98,417.94 250.52,417.94 251.34,417.12 251.74,417.12 253.9,414.96 253.9,391.95 248.44,386.5 248.44,367.87 181.88,301.32 181.88,277.7 180.19,276.01 180.19,273.88 177.11,270.8 177.11,260.92 176.56,260.37 172.85,260.37 169.17,256.69 169.17,246.12 166.44,243.4 162.26,243.4 161.48,242.62 161.48,239.2 159.74,237.46 155.43,237.46 155.02,237.04 155.02,228.48 156.38,227.12 156.38,226.25 155.93,225.79 154.87,225.79 154.06,224.98 154.06,223.5 v1(153.15,222.59)
SL13_DP_87: length 430.7
  L05_DP w0.079: SLOT13.D31 246.88,425.49 248.73,423.64 249.39,423.64 249.69,423.94 250.52,423.94 251,423.46 251.72,423.46 252.21,423.95 253.36,423.95 255.98,421.33 267.12,421.33 280.82,407.62 280.82,393.94 296.74,378.03 296.74,344.21 311.71,329.24 311.71,226.95 299.65,214.88 277.14,214.88 276.73,214.47 267.88,214.47 265.3,211.89 261.99,211.89 260.75,213.13 256.13,213.13 253.96,210.97 248.79,210.97 247.15,209.33 246.8,209.33 246.49,209.01 246.49,207.74 245.52,206.77 235.69,206.77 231.83,202.91 212.4,202.91 211.63,203.68 197.13,203.68 196.37,202.92 184.71,202.92 182.16,200.38 157.24,200.38 157.16,200.46 157.16,216.99 156.48,217.67 154.76,217.67 154.34,217.26 151.68,217.26 151.42,216.99 151.42,215.14 150.74,214.46 v1(150.74,213.7)
SL13_DP_88: length 457.3
  L05_DP w0.079: SLOT13.E31 250.17,426.29 250.27,426.18 250.56,426.18 251.11,425.64 251.64,425.64 252.19,426.18 253.21,426.18 254.34,425.05 255.31,425.05 257.07,423.29 267.43,423.29 282.86,407.86 282.86,394.33 298.48,378.71 298.48,345.21 313.42,330.27 313.42,224.72 298.14,209.45 279.42,209.45 279.22,209.65 277.19,209.65 276.99,209.45 275.37,209.45 273.57,207.64 273.57,205.49 272.38,204.3 267.02,204.3 265.78,205.55 263.3,205.55 261.63,207.22 255.71,207.22 254.31,205.82 252.6,205.82 252.34,205.82 250.51,203.99 237.35,203.99 233.92,200.56 223.29,200.56 222.61,199.88 213.51,199.88 213.07,200.32 184.19,200.32 181.27,197.4 181.27,192.22 177.7,188.65 165.43,188.65 164.63,189.46 156.07,189.46 152.7,192.83 152.7,193.81 152.28,194.22 152.28,197.44 152.7,197.85 152.7,198.37 153.64,199.31 153.64,199.91 153.45,200.1 153.45,209.47 151.64,211.28 151.29,211.28 149.16,213.41 149.16,223.08 149.51,223.44 149.96,223.44 150.64,224.11 v1(150.74,224.11)
SL13_DP_89: length 448.5
  L05_DP w0.079: SLOT13.F31 251.53,426.45 253.4,426.45 254.41,425.44 265.73,425.44 283.17,407.99 283.17,394.46 298.8,378.84 298.8,345.34 313.74,330.4 313.74,224.59 298.27,209.13 279.29,209.13 279.09,209.33 277.32,209.33 277.12,209.13 275.51,209.13 273.88,207.51 273.88,205.36 272.51,203.99 266.89,203.99 265.67,205.21 257.16,205.21 256.87,205.51 252.47,205.51 250.64,203.68 237.48,203.68 234.05,200.25 223.42,200.25 222.3,199.13 183.45,199.13 182.58,198.26 182.58,193.09 177.78,188.28 155.82,188.28 152.38,191.72 152.38,193.68 151.97,194.09 151.97,197.57 152.38,197.98 152.38,199.59 153.13,200.35 153.13,209.34 151.51,210.96 151.16,210.96 148.33,213.79 v1(148.33,218.27)
SL13_DP_90: length 292.2
  L05_DP w0.079: 255.52,416.04 262.09,416.04 276.56,401.57 276.56,388.49 271.16,383.09 271.16,362.66 306.45,327.38 306.45,246.21 303.7,243.46 278.31,243.46 277.92,243.86 275.83,243.86 275.4,243.43 269.88,243.43 269.42,243.88 267.23,243.88 266.83,243.49 251.13,243.49 242.77,235.13 242.77,233.32 243.04,233.05 243.04,231.23 241.72,229.91 232.02,229.91 231.25,229.14 230.86,229.14 230.14,229.87 228.29,229.87 v1(225.41,226.99)
SL13_DP_91: length 339.2
  L05_DP w0.079: SLOT13.Z29 237.88,427.49 238.73,426.64 238.85,426.64 242.14,423.34 242.27,423.34 243.16,422.46 243.25,422.46 244.15,421.56 245.1,421.56 245.48,421.94 246.02,421.94 246.66,421.3 247.09,421.3 247.73,421.94 248.27,421.94 248.91,421.3 249.34,421.3 249.98,421.94 250.52,421.94 251.34,421.12 251.72,421.12 252.72,420.12 252.84,420.12 253.42,419.54 266.56,419.54 279.1,406.99 279.1,393.4 294.61,377.9 294.61,343.2 309.2,328.61 309.2,240.42 299.28,230.5 264.52,230.5 262.59,228.56 252.29,228.56 249.97,226.24 249.97,216.59 248.2,214.82 240.55,214.82 239.47,213.74 238.82,213.74 236.27,211.19 224.88,211.19 220.83,207.14 v1(220.83,206.69)
SL13_DP_92: length 345.4
  L05_DP w0.079: SLOT13.A29 240.13,427.49 240.98,426.64 241.11,426.64 244.29,423.46 245,423.46 245.48,423.94 246.02,423.94 246.84,423.12 247.22,423.12 247.78,422.56 248.22,422.56 248.78,423.12 249.47,423.12 250.08,422.51 250.42,422.51 251.03,423.12 251.72,423.12 252.29,422.54 254.3,422.54 255.86,420.98 267.01,420.98 280.51,407.49 280.51,393.81 296.42,377.89 296.42,344.08 311.4,329.11 311.4,236.21 302.34,227.15 281.43,227.15 278.17,223.9 274.65,223.9 274.13,223.37 274.13,215.64 273.31,214.83 269.48,214.83 268.93,215.39 257.64,215.39 255.55,213.29 249.52,213.29 248.64,212.41 248.64,211.27 247.02,209.64 237.79,209.64 231.4,203.25 222.24,203.25 v1(220.83,204.66)
SL13_DP_93: length 354.6
  L05_DP w0.079: SLOT13.B29 241.33,428.29 240.68,428.94 239.86,428.94 239.48,428.56 239.48,427.85 241.39,425.94 241.52,425.94 241.9,425.56 241.9,424.73 241.73,424.56 241.73,424.02 242.22,423.52 242.34,423.52 243.23,422.64 243.77,422.64 244.15,423.02 244.15,423.15 244.23,423.23 244.6,423.23 245.39,422.44 246.11,422.44 246.61,422.94 247.14,422.94 247.7,422.38 248.3,422.38 248.86,422.94 249.39,422.94 250.01,422.32 250.49,422.32 251.11,422.94 251.64,422.94 252.22,422.36 253.77,422.36 255.46,420.67 266.88,420.67 280.19,407.36 280.19,393.68 296.11,377.76 296.11,343.95 311.08,328.98 311.08,236.34 302.21,227.47 281.3,227.47 278.95,225.12 271.93,225.12 271.54,224.73 271.54,216.99 270.83,216.29 269.2,216.29 268.61,215.7 257.51,215.7 255.41,213.61 249.39,213.61 248.33,212.54 248.33,211.4 246.89,209.96 237.66,209.96 231.32,203.62 222.54,203.62 221.02,205.13 217.28,205.13 216.81,204.66 v1(216.26,204.66)
SL13_DP_94: length 337.3
  L05_DP w0.079: 254.84,426.64 265.86,426.64 284.12,408.38 284.12,394.85 299.74,379.23 299.74,345.73 314.68,330.79 314.68,223.24 295.34,203.9 276,203.9 274.79,202.69 266.21,202.69 263.9,200.38 235.91,200.38 234.77,199.24 234.77,198.02 233.96,197.21 230.74,197.21 229.31,195.78 226.87,195.78 226.56,195.47 226.56,193.85 v1(226.06,193.35)
SL13_DP_95: length 368.3
  L05_DP w0.079: UNK7K15.2 214.53,182.35 215.7,183.52 226.55,183.52 228.01,184.99 229.96,184.99 230.57,185.59 235.11,185.59 236.01,186.49 237.36,186.49 238.71,187.84 257.66,187.84 259.33,189.51 284.66,189.51 285.96,188.21 296.67,188.21 316.26,207.8 316.26,331.44 301.32,346.38 301.32,379.88 285.69,395.51 285.69,409.71 265.49,429.92 254.58,429.92
SL13_DP_96: length 337.1
  L05_DP w0.079: SLOT13.E29 249.79,428.29 249.94,428.13 250.36,428.13 251.03,427.46 251.41,427.46 252.23,426.64 253.69,426.64 254.39,425.94 265.67,425.94 283.49,408.12 283.49,394.59 299.11,378.97 299.11,345.47 314.05,330.53 314.05,223.97 297.36,207.28 291.8,207.28 291.77,207.25 291.38,207.25 291.35,207.28 290.39,207.28 290.36,207.25 289.97,207.25 289.94,207.28 288.64,207.28 288.61,207.25 288.22,207.25 288.19,207.28 287.23,207.28 287.2,207.25 286.81,207.25 286.78,207.28 285.82,207.28 285.79,207.25 285.4,207.25 285.37,207.28 284.07,207.28 284.04,207.25 283.65,207.25 283.62,207.28 282.66,207.28 282.63,207.25 282.24,207.25 282.21,207.28 281.25,207.28 281.22,207.25 280.83,207.25 280.8,207.28 276.68,207.28 272.76,203.35 261.84,203.35 261.67,203.19 251.29,203.19 251.11,203.36 237.61,203.36 232.38,198.13 232.38,197.75 232.15,197.52 228.87,197.52 v1(228.22,198.18)
SL13_DP_97: length 342.6
  L05_DP w0.079: v1(228.22,193.35) 229.35,194.48 234.71,194.48 235.09,194.86 235.09,198.41 235.82,199.14 238.24,199.14 239.16,200.06 264.03,200.06 266.34,202.38 276.58,202.38 277.67,203.47 299.03,203.47 315,219.44 315,330.92 300.06,345.86 300.06,379.36 284.43,394.98 284.43,408.51 265.99,426.96 254.42,426.96 253.15,428.23 251.44,428.23 SLOT13.F29
SL13_DP_98: length 355.7
  L05_DP w0.079: SLOT13.A27 240.32,430.48 241.36,430.48 241.82,430.94 242.93,430.94 243.23,430.64 243.36,430.64 244.36,429.64 245.18,429.64 245.48,429.94 246.05,429.94 246.53,429.46 246.88,429.46 247.73,428.6 248.25,428.6 248.79,429.15 249.47,429.15 249.98,428.64 250.52,428.64 251.03,429.15 251.46,429.15 252.16,428.46 253.21,428.46 254.34,427.33 266.06,427.33 284.75,408.64 284.75,395.11 300.37,379.49 300.37,345.99 315.31,331.05 315.31,216.98 300.69,202.36 279.1,202.36 278.53,201.78 277.31,201.78 276.44,200.91 265.41,200.91 264.25,199.75 239.29,199.75 238.37,198.82 235.95,198.82 235.4,198.28 235.4,194.73 234.84,194.17 231.83,194.17 v1(231.01,193.35)
SL13_DP_99: length 340.7
  L05_DP w0.079: v1(233.17,198.18) 236.81,201.82 238.13,201.82 238.62,202.31 250.44,202.31 250.72,202.59 261.52,202.59 261.97,203.04 272.89,203.04 275.31,205.47 276.23,205.47 276.95,206.19 296.72,206.19 314.37,223.84 314.37,330.66 299.43,345.6 299.43,379.1 283.8,394.72 283.8,408.25 265.8,426.26 254.63,426.26 252.85,428.05 252.05,428.05 251.64,427.64 251.11,427.64 250.43,428.31 250.02,428.31 249.39,428.94 248.86,428.94 248.23,428.31 247.77,428.31 247.14,428.94 246.61,428.94 246.1,428.43 245.48,428.43 245.45,428.46 245.41,428.46 244.41,429.46 244.28,429.46 243.61,430.13 242.53,430.13 SLOT13.B27
SL13_DP_100: length 348.8
  L05_DP w0.079: v1(233.17,193.35) 233.67,193.85 235.01,193.85 235.72,194.56 235.72,196.76 236.39,197.44 237.43,197.44 239.42,199.43 264.38,199.43 265.54,200.59 280.63,200.59 281.38,199.84 298.75,199.84 315.63,216.72 315.63,331.18 300.69,346.12 300.69,379.62 285.06,395.24 285.06,408.77 266.19,427.64 254.28,427.64 253.29,428.64 252.23,428.64 251.49,429.38 251.08,429.38 250.52,429.94 249.98,429.94 249.43,429.38 248.83,429.38 248.27,429.94 247.44,429.94 247.14,429.64 246.61,429.64 245.96,430.29 SLOT13.C27
SL13_DP_101: length 361.3
  L05_DP w0.079: SLOT13.D27 248.17,430.29 248.82,429.64 249.43,429.64 249.91,430.12 250.29,430.12 251.11,430.94 251.64,430.94 252.25,430.33 253.22,430.33 253.31,430.24 265.62,430.24 286.01,409.84 286.01,395.64 301.63,380.01 301.63,346.51 316.57,331.57 316.57,207.37 294.95,185.75 278.63,185.75 277.87,186.5 276.03,186.5 275.13,185.6 270.91,185.6 269.94,186.57 259.43,186.57 258.57,185.71 242.05,185.71 239.8,183.46 239.03,183.46 238.64,183.85 236.12,183.85 235.8,183.53 233.61,183.53 232.43,182.35 UNK7K23.2
SL13_DP_102: length 350.2
  L05_DP w0.079: UNK7K24.2 240.51,182.35 241.6,183.44 267.01,183.44 267.46,183.89 269.67,183.89 270.12,183.44 275.9,183.44 276.35,183.89 278.47,183.89 278.87,183.5 293.28,183.5 316.89,207.11 316.89,331.7 301.95,346.64 301.95,380.14 286.32,395.77 286.32,409.98 265.75,430.55 252.28,430.55 251.72,431.12 251.03,431.12 250.36,430.44 249.28,430.44 SLOT13.E27
SL13_DP_103: length 339
  L05_DP w0.079: v1(236.47,193.35) 236.47,193.9 236.96,194.39 237.53,194.39 237.96,194.82 237.96,197.52 239.55,199.12 265.49,199.12 265.62,198.99 280.42,198.99 280.97,199.53 298.96,199.53 315.94,216.51 315.94,331.31 301,346.25 301,379.75 285.38,395.38 285.38,408.9 266.32,427.96 255.14,427.96 253.05,430.05 251.61,430.05 SLOT13.F27
SL13_DP_104: length 351.4
  L03_DP w0.079: v1(243.84,200.87) 244.63,200.08 264.14,200.08 265.28,201.22 276.31,201.22 277.18,202.1 278.4,202.1 279.17,202.87 287.96,202.87 288.65,203.55 300.34,203.55 314.33,217.55 314.33,330.64 299.74,345.24 299.74,379.41 284.43,394.72 284.43,407.07 260.74,430.76 260.74,432.71 255.51,437.94 251.94,437.94 251.64,437.64 250.82,437.64 250.52,437.94 249.7,437.94 249.25,437.49 248.72,437.49 248.27,437.94 247.73,437.94 246.93,437.14 246.82,437.14 246.02,437.94 245.48,437.94 244.68,437.14 244.27,437.14 242.77,435.64 241.82,435.64 241.52,435.94 240.98,435.94 240.68,435.64 240.14,435.64 239.98,435.47 239.86,435.47 238.22,437.12 237.53,437.12 237.05,436.63 237.05,431.12 SLOT13.Z27
SL13_DP_105: length 346.1
  L03_DP w0.079: v1(248.42,200.87) 249.23,200.87 249.7,200.39 263.51,200.39 264.7,201.59 275.64,201.59 277.92,203.87 300.21,203.87 314.02,217.68 314.02,330.51 299.43,345.1 299.43,379.28 284.12,394.59 284.12,406.94 260.43,430.63 260.43,432.58 256.53,436.48 252.36,436.48 251.72,437.12 251.03,437.12 250.55,436.64 249.95,436.64 249.47,437.12 248.78,437.12 248.26,436.6 247.48,436.6 247.14,436.94 246.61,436.94 246.27,436.6 245.23,436.6 244.89,436.94 244.36,436.94 243.98,436.56 243.98,436.02 244.15,435.84 244.15,435.02 243.77,434.64 243.2,434.64 242.72,435.12 242,435.12 241.52,434.64 240.98,434.64 240.64,434.98 239.61,434.98 239.27,434.64 238.73,434.64 238.35,435.02 238.35,435.56 238.52,435.73 238.52,436.56 238.14,436.94 237.61,436.94 237.23,436.56 237.23,436.02 237.7,435.55 237.7,435.02 237.23,434.56 237.23,433.6 237.9,432.92 237.9,432.31 SLOT13.Z25
SL13_DP_106: length 331.7
  L03_DP w0.079: v1(243.84,204.68) 246.41,207.24 252.34,207.24 256.04,210.95 269.23,210.95 269.67,211.38 274.56,211.38 275.74,210.21 298.01,210.21 312.12,224.31 312.12,329.73 297.53,344.32 297.53,378.49 282.23,393.79 282.23,407.05 258.85,430.42 258.85,430.55 253.11,436.3 252.28,436.3 251.64,436.94 251.11,436.94 250.47,436.3 250.03,436.3 249.39,436.94 248.86,436.94 248.06,436.14 247.68,436.14 247.18,435.64 246.59,435.64 246.11,436.12 245.41,436.12 244.92,435.63 244.92,434.91 245.3,434.53 245.3,434 243.93,432.64 243.23,432.64 242.83,433.04 241.92,433.04 241.52,432.64 240.48,432.64 SLOT13.A25
SL13_DP_107: length 331.2
  L05_DP w0.079: SLOT13.B25 241.33,432.29 240.42,431.38 240.3,431.38 239.48,430.56 239.48,430.02 239.86,429.64 240.43,429.64 240.91,430.12 241.63,430.12 242.11,429.64 242.55,429.64 242.85,429.34 242.85,429.02 243.23,428.64 243.86,428.64 243.98,428.52 243.98,428.02 244.36,427.64 244.89,427.64 245.43,428.17 246.07,428.17 246.61,427.64 246.73,427.64 247.73,426.64 248.3,426.64 248.48,426.46 248.48,426.02 248.86,425.64 249.39,425.64 249.76,426 250.49,426 251.03,425.46 251.72,425.46 252.26,426 253.13,426 254.17,424.97 254.17,424.92 254.35,424.74 255.18,424.74 256.94,422.98 267.3,422.98 282.54,407.73 282.54,397.07 282.54,394.2 298.17,378.58 298.17,345.08 313.11,330.14 313.11,224.86 298.01,209.76 279.55,209.76 279.35,209.96 277.06,209.96 276.86,209.76 275.24,209.76 273.25,207.77 273.25,207.51 273.25,205.62 272.25,204.63 267.15,204.63 265.19,206.58 262.72,206.58 261.76,207.54 255.58,207.54 254.2,206.16 249.9,206.16 v1(248.42,204.68)
SL13_DP_108: length 324.6
  L03_DP w0.079: v1(243.84,207.72) 245.27,209.15 248.45,209.15 249.95,210.64 254.85,210.64 257.62,213.41 263.04,213.41 263.14,213.31 266.73,213.31 267.4,213.98 268.74,213.98 269.88,212.84 299.76,212.84 311.49,224.57 311.49,329.46 296.9,344.05 296.9,378.23 281.6,393.53 281.6,406.78 258.54,429.85 258.54,430.42 252.84,436.12 252.16,436.12 251.55,435.51 251.2,435.51 250.59,436.12 249.91,436.12 249.36,435.57 248.64,435.57 248.27,435.94 247.73,435.94 247.09,435.3 246.66,435.3 246.02,435.94 245.48,435.94 245.1,435.56 245.1,435.02 245.55,434.57 245.55,434 245.1,433.56 245.1,432.76 SLOT13.C25
SL13_DP_109: length 332.1
  L05_DP w0.079: SLOT13.D25 246.52,431.94 245.19,431.94 244.89,431.64 244.36,431.64 244.06,431.94 243.67,431.94 242.67,432.94 242.11,432.94 241.64,432.47 241.26,432.47 240.43,431.64 240.3,431.64 239.3,430.63 239.3,429.94 239.78,429.46 240.5,429.46 240.98,429.94 241.55,429.94 242.03,429.46 242.48,429.46 242.67,429.26 242.67,428.94 243.16,428.46 243.71,428.46 243.8,428.37 243.8,427.94 244.28,427.46 244.97,427.46 245.45,427.94 246.05,427.94 246.53,427.46 246.66,427.46 247.66,426.46 248.07,426.46 248.3,426.24 248.3,425.94 248.78,425.46 249.07,425.46 249.37,425.16 249.46,425.16 249.98,424.64 250.52,424.64 251.04,425.16 251.45,425.16 251.98,424.63 254.14,424.63 254.35,424.42 255.05,424.42 256.81,422.66 267.17,422.66 282.23,407.6 282.23,397.2 282.23,394.07 297.85,378.45 297.85,344.95 312.79,330.01 312.79,225.43 297.44,210.08 279.68,210.08 279.48,210.28 276.93,210.28 276.73,210.08 272.78,210.08 271.69,211.17 269.01,211.17 268.55,210.71 255.36,210.71 251.85,207.2 248.94,207.2 v1(248.42,207.72)
SL13_DP_110: length 317.6
  L03_DP w0.079: SLOT13.E25 248.95,432.46 247.66,432.46 247.18,432.94 247.05,432.94 246.05,433.94 246.05,434.63 246.53,435.12 247.22,435.12 247.89,434.45 248.13,434.45 248.98,435.29 249.34,435.29 249.98,435.94 250.52,435.94 251.12,435.33 251.63,435.33 252.23,435.94 252.77,435.94 253.15,435.56 253.15,434.93 258.22,429.86 258.22,429.72 280.34,407.6 280.34,393.01 295.64,377.71 295.64,343.53 310.23,328.94 310.23,241 299.41,230.18 269.76,230.18 268.33,228.76 252.27,228.76 251.05,227.54 251.05,217.24 249.33,215.51 249.33,214.44 247.61,212.71 244.9,212.71 244.54,212.36 244.54,211.47 v1(243.84,210.77)
SL13_DP_111: length 316.1
  L03_DP w0.079: SLOT13.F25 251.02,432.64 249.98,432.64 249.56,433.06 248.75,433.06 248.33,432.64 247.73,432.64 247.35,433.02 247.35,433.39 247.1,433.64 246.61,433.64 246.23,434.02 246.23,434.56 246.61,434.94 247.14,434.94 247.96,434.12 248.38,434.12 248.86,433.64 249.39,433.64 249.77,434.02 249.77,434.43 249.98,434.64 250.52,434.64 251,435.12 251.72,435.12 252.72,434.12 253.38,434.12 280.02,407.47 280.02,392.88 295.32,377.58 295.32,343.4 309.91,328.81 309.91,241.13 299.28,230.5 269.63,230.5 268.2,229.07 252.14,229.07 250.67,227.6 250.67,217.3 248.04,214.67 245.1,214.67 v1(243.84,213.41)
SL13_DP_112: length 339.8
  L05_DP w0.079: v1(236.07,212.18) 236.42,212.18 239.48,215.24 248.16,215.24 249.65,216.72 249.65,227.03 252.01,229.39 254.09,229.39 256.01,231.31 264.25,231.31 264.74,230.81 299.15,230.81 308.88,240.55 308.88,328.47 294.29,343.07 294.29,377.77 278.79,393.27 278.79,406.86 266.43,419.22 253.48,419.22 252.77,419.94 252.64,419.94 251.64,420.94 251.11,420.94 250.47,420.3 250.29,420.3 249.47,421.12 248.78,421.12 248.14,420.48 247.86,420.48 247.22,421.12 246.53,421.12 245.95,420.53 245.55,420.53 244.97,421.12 244.25,421.12 243.66,420.53 243.34,420.53 242.75,421.12 242.62,421.12 241.62,422.12 240.91,422.12 240.38,421.59 239.87,421.59 239.34,422.12 238.62,422.12 238.14,421.64 235.91,421.64 234.52,423.03 234.52,431.81 235.64,432.94 238.14,432.94 238.46,432.62 239.25,432.62 240.13,433.49 SLOT13.A23
SL13_DP_113: length 329.9
  L03_DP w0.079: v1(236.07,216.75) 237.86,218.53 237.86,223.24 240.64,226.01 247.52,226.01 249.41,227.91 249.41,229.34 251.65,231.58 251.65,234.89 253.17,236.41 260.33,236.41 261.46,235.28 261.46,235.28 263.5,233.24 268.86,233.24 270.23,234.61 301.61,234.61 308.65,241.65 308.65,328.29 273.36,363.58 273.36,382.18 278.76,387.58 278.76,406.95 255.46,430.25 252.58,430.25 251.72,431.12 251.59,431.12 250.59,432.12 249.87,432.12 249.39,431.64 248.86,431.64 248.38,432.12 247.66,432.12 247.02,431.48 246.73,431.48 246.09,432.12 245.41,432.12 244.77,431.48 244.48,431.48 243.84,432.12 243.16,432.12 242.52,431.48 242.23,431.48 241.59,432.12 240.91,432.12 240.27,431.48 239.98,431.48 239.73,431.73 239.73,431.77 239.48,432.02 239.48,432.56 239.86,432.94 240.52,432.94 240.6,433.02 240.6,433.56 240.98,433.94 241.82,433.94 242.17,434.29 SLOT13.B23
SL13_DP_114: length 328.8
  L03_DP w0.079: SLOT13.C23 243.29,434.29 242.64,434.94 242.11,434.94 241.29,434.12 240.91,434.12 240.42,433.63 240.42,433.19 240.34,433.12 239.78,433.12 239.3,432.63 239.3,431.94 239.49,431.75 239.49,431.72 239.91,431.3 240.34,431.3 240.98,431.94 241.52,431.94 242.16,431.3 242.59,431.3 243.23,431.94 243.77,431.94 244.41,431.3 244.84,431.3 245.48,431.94 246.02,431.94 246.66,431.3 247.09,431.3 247.73,431.94 248.27,431.94 248.91,431.3 249.34,431.3 249.98,431.94 250.52,431.94 250.9,431.56 250.9,431.01 250.97,430.94 251.64,430.94 252.64,429.94 255.33,429.94 278.45,406.82 278.45,387.71 273.05,382.31 273.05,363.45 308.34,328.16 308.34,241.78 301.48,234.93 269.71,234.93 267.21,237.43 260.24,237.43 259.53,236.72 251.43,236.72 250.39,235.69 250.39,230.77 249.1,229.47 249.1,228.04 247.38,226.33 240.51,226.33 236.07,221.89 v1(236.07,221.32)
SL13_DP_115: length 321.3
  L03_DP w0.079: v1(233.15,212.18) 233.91,212.18 234.72,212.98 239.67,212.98 240.15,213.46 240.15,214.57 240.9,215.31 247.79,215.31 250.04,217.56 250.04,229.08 252.13,231.18 253.98,231.18 256.42,233.61 262,233.61 263.43,232.19 300.08,232.19 309.28,241.39 309.28,328.55 294.65,343.18 294.65,377.3 294.58,377.41 285.45,386.54 285.34,386.61 279.39,392.56 279.39,407.21 255.72,430.88 254.35,430.88 253.15,432.08 253.15,433.56 252.77,433.94 252.23,433.94 252.02,434.14 252.02,434.56 251.64,434.94 251.07,434.94 250.59,434.46 250.06,434.46 249.95,434.36 249.95,433.94 249.47,433.46 248.75,433.46 248.27,433.94 247.57,433.94 247.22,434.29 SLOT13.D23
SL13_DP_116: length 347.1
  L05_DP w0.079: v1(233.15,222.59) 233.15,223.34 235,225.19 238.48,225.19 240.25,226.96 241.4,226.96 243.1,228.65 245.44,228.65 247.11,230.32 247.11,234.25 250.22,237.35 259.1,237.35 260.48,238.74 267.28,238.74 268.39,237.63 303.27,237.63 307.71,242.07 307.71,327.9 272.42,363.19 272.42,382.57 277.82,387.97 277.82,406.55 265.79,418.59 252.12,418.59 250.59,420.12 250.21,420.12 249.39,420.94 248.86,420.94 248.22,420.3 247.78,420.3 247.14,420.94 246.61,420.94 246.02,420.35 245.48,420.35 244.89,420.94 244.36,420.94 243.77,420.35 243.23,420.35 242.64,420.94 242.52,420.94 241.52,421.94 240.98,421.94 240.45,421.41 239.8,421.41 239.27,421.94 238.73,421.94 238.07,421.27 235.83,421.27 234.2,422.9 234.2,431.94 235.51,433.25 238.05,433.25 238.87,434.07 239,434.07 239.86,434.94 240.39,434.94 241.26,434.07 241.38,434.07 241.82,433.64 242.93,433.64 243.23,433.94 244.06,433.94 244.36,433.64 245.18,433.64 245.48,433.94 246.31,433.94 246.61,433.64 247.43,433.64 247.73,433.94 248.27,433.94 248.35,433.85 248.69,433.85 SLOT13.E23
SL13_DP_117: length 323.4
  L03_DP w0.079: v1(230.74,213.7) 231.63,213.7 232.18,213.16 234.45,213.16 234.59,213.3 236.11,213.3 236.55,213.73 236.55,214.56 237.62,215.63 247.66,215.63 249.73,217.69 249.73,229.21 252,231.49 253.85,231.49 254.5,232.14 254.5,234.61 255.98,236.09 260.2,236.09 263.37,232.92 300.37,232.92 308.97,241.52 308.97,328.42 273.68,363.71 273.68,382.05 279.08,387.45 279.08,407.08 255.59,430.57 254.2,430.57 251.85,432.92 251.85,433.81 SLOT13.F23
SL13_DP_118: length 325.5
  L03_DP w0.079: v1(230.74,224.11) 231.82,225.19 234.48,225.19 234.8,225.51 238.35,225.51 239.8,226.96 239.8,228.32 240.45,228.97 245.31,228.97 246.12,229.78 246.12,236.17 247.62,237.67 258.97,237.67 260.77,239.48 269.65,239.48 270.44,240.27 275.32,240.27 275.99,239.59 277.98,239.59 278.65,240.26 301.83,240.26 307.39,245.82 307.39,327.77 272.1,363.06 272.1,382.7 277.5,388.1 277.5,406.42 255.99,427.94 251.94,427.94 251.64,427.64 251.08,427.64 250.52,428.2 250.52,428.64 250.9,429.02 250.9,429.56 250.52,429.94 250.39,429.94 249.39,430.94 248.86,430.94 248.48,430.56 248.48,430.44 248.35,430.32 248.24,430.32 248.23,430.31 247.77,430.31 247.14,430.94 246.61,430.94 245.97,430.3 245.53,430.3 244.89,430.94 244.36,430.94 243.84,430.42 243.16,430.42 242.64,430.94 242.11,430.94 241.59,430.42 240.91,430.42 240.39,430.94 239.86,430.94 239.29,430.37 238.71,430.37 238.12,430.96 238.12,431.61 238.52,432.02 238.52,432.56 237.88,433.2 SLOT13.Z23
SL13_DP_119: length 337.4
  L03_DP w0.079: v1(228.33,218.27) 229.05,218.27 229.51,218.73 233.27,218.73 234.05,219.52 234.05,223.09 234.86,223.89 237.63,223.89 240.38,226.64 247.25,226.64 248.28,227.67 248.28,234.97 250.35,237.04 259.23,237.04 260.61,238.43 267.15,238.43 269.3,236.28 302.36,236.28 308.02,241.94 308.02,328.03 272.73,363.32 272.73,382.44 278.13,387.84 278.13,406.68 256.22,428.6 252.11,428.6 250.59,430.12 250.47,430.12 249.47,431.12 248.78,431.12 248.15,430.49 247.85,430.49 247.22,431.12 246.53,431.12 245.89,430.48 245.61,430.48 244.97,431.12 244.28,431.12 243.76,430.6 243.24,430.6 242.72,431.12 242.03,431.12 241.51,430.6 240.99,430.6 240.47,431.12 239.78,431.12 239.3,430.64 238.72,430.64 238.3,431.06 238.3,431.54 238.71,431.94 238.71,432.65 238.32,433.03 238.32,433.81 238.52,434.02 238.52,434.56 237.88,435.2 SLOT13.Z21
SL13_DP_121: length 196.9
  TOP w0.381: TP_OUT+_1.1 v1(126.61,295.54)
  L05_DP w0.079: SLOT13.B21 242.27,436.19 240.94,436.19 240.39,435.64 239.86,435.64 239.31,436.19 238.69,436.19 238.14,435.64 237.61,435.64 236.51,436.74 232.48,436.74 222.24,426.49 222.24,415.64 212.73,406.13 212.73,393.08 126.61,306.96 v1(126.61,295.54)
SL13_DP_122: length 200.3
  TOP w0.381: TP_OUT-_1.1 v1(124.31,295.54)
  L05_DP w0.079: SLOT13.C21 243.58,436.29 242.75,437.12 242.29,437.12 241.76,436.6 240.73,436.6 240.39,436.94 239.86,436.94 239.52,436.6 238.77,436.6 238.32,437.05 232.35,437.05 221.93,426.63 221.93,415.77 212.34,406.18 212.34,393.25 124.31,305.22 v1(124.31,295.54)
SL13_DP_123: length 199.7
  TOP w0.381: TP_OUT+_2.1 v1(133.22,295.54)
  L05_DP w0.079: SLOT13.D21 246.88,435.49 246.02,434.64 245.48,434.64 244.98,435.13 244.27,435.13 243.77,434.64 243.23,434.64 242.73,435.13 242.02,435.13 241.52,434.64 240.98,434.64 240.48,435.13 239.8,435.13 239.3,434.64 238.73,434.64 238.09,435.28 237.46,435.28 236.63,436.11 232.74,436.11 222.87,426.23 222.87,415.38 213.51,406.02 213.51,392.76 133.22,312.47 v1(133.22,295.54)
SL13_DP_124: length 202.5
  TOP w0.381: TP_OUT-_2.1 v1(130.91,295.54)
  L05_DP w0.079: v1(130.91,295.54) 130.91,310.68 213.15,392.91 213.15,406.11 222.56,415.51 222.56,426.36 232.61,436.42 236.57,436.42 237.53,435.46 238.22,435.46 238.72,435.96 239.28,435.96 239.78,435.46 240.5,435.46 240.98,435.94 241.81,435.94 242.11,435.64 242.64,435.64 242.94,435.94 244.06,435.94 244.36,435.64 244.89,435.64 245.19,435.94 245.61,435.94 246.64,436.96 247.4,436.96 248.08,436.29 SLOT13.E21
SL13_DP_125: length 216.4
  L05_DP w0.079: v1(156.79,228.7) 157.72,229.63 157.72,232.75 157.19,233.27 157.19,237.07 157.78,237.66 159.87,237.66 160.73,238.52 160.73,239.83 162.19,241.29 164.93,241.29 169.6,245.96 169.6,256.51 173.15,260.05 177.26,260.05 178.29,261.07 178.29,270.31 181.25,273.27 181.25,276.5 182.33,277.58 182.33,301.13 248.88,367.69 248.88,386.31 253.75,391.19 253.75,397.9
  BOTTOM w0.203: R15.1 156.79,227.38 v1(156.79,228.7)
SL13_DP_126: length 441
  L05_DP w0.079: R17.1 151.76,227.3 151.13,226.66 147.17,226.66 146.85,226.34 146.85,226.32 146.2,225.67 146.2,218.8 146.76,218.24 146.76,210.86 145.87,209.98 145.87,204.6 150.04,200.43 150.04,178.59 150.83,177.8 159.28,177.8 160.7,176.38 160.7,167.3 158.15,164.74 145.32,164.74 129.08,180.99 129.08,203.88 112.6,220.35 112.6,299.07 115.1,301.57 115.1,301.57 208.17,394.64 208.41,394.88 208.41,402.71 221.61,415.9 221.61,426.76 232.22,437.37 238.16,437.37 239.73,438.94 240.68,438.94 241.33,438.29 SLOT13.B19
  BOTTOM w0.203: R17.1 151.71,227.38 v1(151.71,228.7)
SL13_DP_127: length 123.7
  TOP w0.381: UNK3TP_OUT+_1.1 v1(206.61,295.54)
  L05_DP w0.079: v1(206.61,295.54) 206.61,315.09 256.05,364.53 256.05,384.5 256.27,384.72 256.27,397.9
SL13_DP_128: length 345.1
  TOP w0.381: UNK3TP_OUT-_1.1 v1(204.31,295.54)
  L05_DP w0.079: SLOT13.E43 249.82,414.29 249.83,414.3 250.47,414.3 251.11,414.94 251.64,414.94 252.02,414.56 252.02,413.73 252.1,413.66 252.43,413.33 253.82,413.33 254.35,413.86 255.76,413.86 255.76,413.86 256.02,413.86 256.54,413.86 257.39,413.01 258.12,413.01 273.05,398.09 273.05,388.84 266.85,382.64 266.85,360.34 239.45,332.95 239.45,289.22 237.19,286.96 237.19,282.45 236.63,281.88 236.63,279.75 236.21,279.33 235.35,279.33 234.69,278.67 234.69,276.53 234.94,276.28 236.71,276.28 237.26,276.83 237.26,281.62 237.82,282.18 237.82,285.03 239.21,286.41 249.05,286.41 250.48,284.98 250.48,276.39 252.88,273.99 252.88,265.11 252.55,264.78 252.55,258.62 250.85,256.92 250.85,245.44 242.04,236.63 241.58,236.63 240.57,235.61 240.57,234.75 240.34,234.52 230.08,234.52 229.14,233.59 219.29,233.59 215.27,237.61 211.7,237.61 209.93,239.38 209.93,257.5 207.86,259.57 207.86,283.09 208.16,283.4 208.16,288.07 205.09,291.14 205.09,295.21 204.75,295.54 v1(204.31,295.54)
SL13_DP_129: length 478.9
  TOP w0.381: UNK3TP_OUT+_2.1 v1(213.21,295.54)
  L03_DP w0.079: v1(213.21,295.54) 214.89,293.87 214.89,290 213.73,288.84 211.55,288.84 209.94,287.23 209.94,278.71 212.99,275.65 212.99,267.34 211.12,265.46 211.12,260.38 210.54,259.79 210.54,257.67 208.72,255.85 208.72,243.17 203.07,237.52 185.58,237.52 183.86,235.8 183.86,201.33 182.45,199.92 173.64,199.92 169.28,195.56 169.28,187.98 166.06,184.76 166.06,175.9 162.63,172.47 148.59,172.47 145.24,175.82 145.24,209.58 148.9,213.24 148.9,227.34 149.45,227.89 153.12,227.89 154.39,229.16 154.39,236.78 154.39,237.3 155.17,238.09 157.6,238.09 158.05,238.54 158.05,240.24 158.57,240.75 159.92,240.75 160.85,241.68 160.85,247.12 162.03,248.3 166.81,248.3 168.45,249.94 168.45,256.98 171.17,259.69 171.17,262 172.21,263.05 172.21,270.1 177.91,275.81 178.96,275.81 181.25,278.1 181.25,282.65 178.49,285.42 178.49,298.91 247.72,368.14 247.72,386.79 252.41,391.48 252.41,392.15 253.39,393.13 253.39,413.22 252.32,414.29 SLOT13.F43
SL13_DP_130: length 193.6
  TOP w0.381: UNK3TP_OUT-_2.1 v1(210.91,295.54)
  L03_DP w0.079: v1(210.91,295.54) 210.91,318.95 256.37,364.4 256.37,384.37 260.88,388.88 260.88,416.72 253.3,424.3 252.28,424.3 251.64,424.94 251.11,424.94 250.47,424.3 250.29,424.3 249.47,425.12 249.27,425.12 248.83,425.56 248.83,425.63 247.82,426.64 247.44,426.64 247.08,427 247.08,427.57 247.52,428.02 247.52,428.56 247.14,428.94 246.61,428.94 246.23,428.56 246.23,428.55 245.97,428.3 245.53,428.3 244.89,428.94 244.36,428.94 243.72,428.3 243.28,428.3 242.64,428.94 242.11,428.94 241.47,428.3 241.03,428.3 240.39,428.94 239.86,428.94 239.04,428.12 238.66,428.12 238.17,427.63 238.17,426.94 238.52,426.59 238.52,425.98 237.23,424.69 237.23,424.02 237.61,423.64 237.68,423.64 238.2,423.12 238.2,423.01 238.12,422.94 237.61,422.94 237.23,422.56 237.23,422.02 237.61,421.64 238.14,421.64 238.61,422.11 239.21,422.11 239.87,421.44 239.87,420.95 239.48,420.56 239.48,420.02 239.86,419.64 240.39,419.64 240.6,419.43 240.6,419.02 240.98,418.64 241.39,418.64 241.73,418.31 241.73,418.02 241.9,417.84 241.9,417.02 241.52,416.64 241.25,416.64 240.9,416.29 SLOT13.A41
SL13_DP_131: length 304.5
  L05_DP w0.079: SLOT13.B41 242.38,417.08 241.55,417.91 241.55,418.63 242.03,419.12 242.41,419.12 243.03,419.73 243.23,419.94 243.77,419.94 244.25,419.46 244.97,419.46 245.45,419.94 246.31,419.94 246.71,419.53 247.07,419.53 247.66,420.12 248.34,420.12 248.83,419.63 248.83,419.44 248.97,419.3 249.34,419.3 249.98,419.94 250.52,419.94 250.9,419.56 250.9,418.73 250.7,418.53 250.7,418.05 251.11,417.64 251.64,417.64 252.12,418.12 260.91,418.12 277.19,401.83 277.19,388.23 271.79,382.83 271.79,362.92 307.08,327.64 307.08,245.95 302.14,241.02 267.52,241.02 266.3,239.79 260.64,239.79 258.83,237.98 247.21,237.98 245.03,235.8 245.03,229.89 244.42,229.28 237.37,229.28 v1(236.79,228.7)
  BOTTOM w0.203: v1(236.79,228.7) 236.79,227.38 UNK3R15.1
SL13_DP_132: length 307.5
  L05_DP w0.079: SLOT13.C41 244.27,416.64 243.23,416.64 242.85,417.02 242.85,417.24 242.46,417.64 242.11,417.64 241.73,418.02 241.73,418.56 242.11,418.94 242.64,418.94 243.11,418.47 243.6,418.47 244.25,419.12 244.97,419.12 245.47,418.61 246.28,418.61 246.61,418.94 246.73,418.94 247.73,419.94 248.27,419.94 248.65,419.56 248.65,419.36 248.9,419.12 249.47,419.12 249.95,418.63 249.95,418.53 251.03,417.46 251.72,417.46 252.2,417.94 252.77,417.94 254.35,416.35 262.22,416.35 276.87,401.7 276.87,388.36 271.47,382.96 271.47,362.79 306.76,327.51 306.76,246.08 302.01,241.33 249.43,241.33 243.84,235.74 243.84,234.05 243.84,234.04 243.84,231.59 241.85,229.6 232.61,229.6 v1(231.71,228.7)
  BOTTOM w0.203: UNK3R17.1 231.71,227.38 v1(231.71,228.7)
SL13_DP_133: length 261.1
  TOP w0.381: UNK5TP_OUT+_1.1 v1(126.61,235.54)
  L03_DP w0.079: v1(126.61,235.54) 115.73,246.42 115.73,301.31 223.76,409.33 236.04,409.33 236.17,409.2 238.17,409.2 238.73,408.64 239.27,408.64 239.83,409.2 240.39,409.2 241,408.58 241.5,408.58 242.03,409.12 242.41,409.12 243.23,409.94 243.77,409.94 244.25,409.46 245,409.46 245.84,410.29 245.84,410.46 246.4,411.02 246.4,411.56 246.02,411.94 246.02,412.38 246.66,413.02 247.35,413.02 247.73,412.64 248.27,412.64 248.65,413.02 248.65,413.56 248.27,413.94 248.27,414.38 249.18,415.3 249.31,415.42 249.31,415.55 249.77,416.02 249.77,416.56 249.39,416.94 248.86,416.94 248.34,416.42 248.06,416.42 247.92,416.29 SLOT13.D41
SL13_DP_134: length 253.2
  TOP w0.381: UNK5TP_OUT-_1.1 v1(124.31,235.54)
  L03_DP w0.079: SLOT13.E41 249.13,415.49 247.27,413.64 247.02,413.64 244.02,410.64 243.64,410.64 242.47,409.46 241.99,409.46 241.52,409.94 240.98,409.94 240.42,409.38 239.83,409.38 239.27,409.94 238.73,409.94 238.17,409.38 236.31,409.38 236.04,409.65 223.62,409.65 115.42,301.44 115.42,244.44 v1(124.31,235.54)
SL13_DP_135: length 259.8
  TOP w0.381: UNK5TP_OUT+_2.1 v1(133.22,235.54)
  L03_DP w0.079: v1(133.22,235.54) 116.37,252.39 116.37,301.05 224.34,409.02 238.1,409.02 238.66,408.46 239.34,408.46 239.91,409.02 240.31,409.02 241.03,408.3 241.47,408.3 242.11,408.94 242.64,408.94 243.02,408.56 243.02,408.51 243.28,408.25 243.39,408.25 244.15,409.02 245.1,409.02 245.48,408.64 246.02,408.64 246.4,409.02 246.4,409.56 246.02,409.94 246.02,410.38 248.09,412.46 248.34,412.46 251.38,415.49 SLOT13.F41
SL13_DP_136: length 242
  TOP w0.381: UNK5TP_OUT-_2.1 v1(130.91,235.54)
  L05_DP w0.079: v1(130.91,235.54) 126.64,239.81 126.64,284.03 131.63,289.03 140.79,289.03 146.65,294.89 148.38,294.89 157.99,304.49 157.99,330.75 214.97,387.74 214.97,393.17 214.97,393.17 214.97,394.73 219.45,399.21 228.07,399.21 233.11,404.26 233.11,413.68 235.72,416.29 SLOT13.Z41
SL13_DP_137: length 338.7
  L05_DP w0.079: v1(156.79,168.7) 156.79,168.2 156.46,167.88 142.63,167.88 129.39,181.12 129.39,204.01 118.59,214.81 118.59,276.42 130.71,288.55 130.71,290.23 131.8,291.32 142.64,291.32 146.52,295.2 148.25,295.2 157.67,304.62 157.67,330.88 214.66,387.87 214.66,393.04 214.66,394.86 219.32,399.53 227.94,399.53 232.79,404.39 232.79,413.81 236.24,417.25 236.84,417.25 SLOT13.Z39
  BOTTOM w0.203: UNK5R15.1 156.79,167.38 v1(156.79,168.7)
SL13_DP_138: length 340.4
  L03_DP w0.079: SLOT13.A39 240.13,417.46 239.3,416.63 239.3,416.5 238.06,415.26 237.59,415.26 237.22,414.89 237.22,413.92 238.5,412.64 239.56,412.64 239.86,412.94 240.39,412.94 240.77,412.56 240.77,412.02 240.39,411.64 239.57,411.64 239.27,411.94 238.7,411.94 238.22,411.46 223.64,411.46 113.23,301.05 113.23,220.61 129.71,204.14 129.71,181.25 140.66,170.29 151.3,170.29 151.71,169.88 v1(151.71,168.7)
  BOTTOM w0.203: UNK5R17.1 151.71,167.38 v1(151.71,168.7)
SL13_DP_139: length 327.4
  TOP w0.381: UNK7TP_OUT+_1.1 v1(206.61,235.54)
  L05_DP w0.079: v1(206.61,235.54) 208.4,235.54 209.84,236.98 213.96,236.98 215.3,235.64 215.3,229.97 216.15,229.12 221.84,229.12 224.87,232.15 238.87,232.15 241.2,234.48 241.2,235.35 241.84,236 242.3,236 252.34,246.03 252.34,247.3 253.32,248.29 257.68,248.29 259.03,249.64 279.62,249.64 280.94,248.32 301.28,248.32 305.5,252.55 305.5,326.98 270.21,362.27 270.21,383.48 275.61,388.88 275.61,401.18 261.7,415.09 252.25,415.09 251.87,415.48 251.23,415.48 250.59,416.12 250.19,416.12 250.16,416.14 249.9,416.14 249.39,415.64 248.86,415.64 248.48,416.02 248.48,416.56 248.69,416.77 248.69,417.62 248.28,418.02 247.53,418.02 247.14,417.64 246.32,417.64 246.02,417.94 245.48,417.94 245.27,418.14 245.27,418.56 244.89,418.94 244.36,418.94 243.71,418.29 SLOT13.B39
SL13_DP_140: length 323
  TOP w0.381: UNK7TP_OUT-_1.1 v1(204.31,235.54)
  L05_DP w0.079: SLOT13.C39 245.1,417.81 245.1,417.02 245.48,416.64 246.31,416.64 246.61,416.94 247.14,416.94 247.44,416.64 247.6,416.64 248.78,415.46 249.47,415.46 249.95,415.94 250.52,415.94 251.16,415.3 251.79,415.3 252.31,414.78 261.57,414.78 275.3,401.05 275.3,389.01 269.9,383.61 269.9,362.14 305.19,326.85 305.19,252.68 301.15,248.64 281.07,248.64 278.85,250.86 259.8,250.86 257.55,248.6 253.19,248.6 252.02,247.43 252.02,246.16 242.17,236.31 241.71,236.31 240.88,235.48 240.88,234.61 239.27,232.99 225.26,232.99 223.55,231.27 216.56,231.27 215.61,232.23 215.61,235.77 214.09,237.29 207.38,237.29 205.63,235.54 v1(204.31,235.54)
SL13_DP_141: length 317.1
  TOP w0.381: UNK7TP_OUT+_2.1 v1(213.21,235.54)
  L05_DP w0.079: v1(213.21,235.54) 214.67,234.09 214.67,229.71 215.89,228.49 222.1,228.49 223.84,230.23 240.73,230.23 241.83,231.33 241.83,235.09 242.1,235.37 242.56,235.37 252.83,245.63 259.25,245.63 260.19,246.57 269.6,246.57 270.5,245.67 275.14,245.67 276,246.53 278.02,246.53 278.85,245.7 299.54,245.7 306.13,252.29 306.13,327.24 270.84,362.53 270.84,383.22 276.24,388.62 276.24,401.44 261.96,415.72 253.11,415.72 251.72,417.12 251.03,417.12 250.55,416.64 249.95,416.64 249.6,416.98 249.6,417.84 249.77,418.02 249.77,418.56 249.39,418.94 248.57,418.94 247.92,418.29 SLOT13.D39
SL13_DP_142: length 316
  TOP w0.381: UNK7TP_OUT-_2.1 v1(210.91,235.54)
  L05_DP w0.079: v1(210.91,235.54) 211.61,235.54 212.5,236.43 214.06,236.43 214.98,235.51 214.98,229.84 216.02,228.8 221.97,228.8 223.71,230.54 239.33,230.54 240.69,231.9 240.69,233.35 241.51,234.17 241.51,235.22 241.97,235.68 242.43,235.68 252.65,245.9 252.65,247.17 253.46,247.97 257.95,247.97 259.03,246.89 269.49,246.89 270.61,248.01 301.41,248.01 305.82,252.42 305.82,327.11 270.53,362.4 270.53,383.35 275.93,388.75 275.93,401.31 261.83,415.41 253.17,415.41 251.64,416.94 251.11,416.94 250.63,416.46 249.87,416.46 249.13,417.2 SLOT13.E39
SL13_DP_143: length 367.5
  L05_DP w0.079: 255.81,430.87 267.28,430.87 286.61,411.54 286.61,411.02 286.99,410.64 287.51,410.64 287.74,410.41 287.74,410.02 287.91,409.84 287.91,408.73 287.74,408.56 287.74,408.02 287.91,407.84 287.91,407.02 287.53,406.64 287.53,405.94 287.91,405.56 287.91,405.02 287.53,404.64 286.83,404.64 287.91,403.56 287.91,403.02 287.74,402.84 287.74,401.73 287.91,401.56 287.91,401.02 287.53,400.64 287.53,400.08 288.18,399.43 288.43,399.43 291.64,396.22 291.82,396.22 292.91,395.13 293.79,395.13 302.26,386.66 302.26,346.77 317.2,331.83 317.2,189.91 297.12,169.84 271.51,169.84 271.25,170.09 237.67,170.09 236.79,169.21 v1(236.79,168.7)
  BOTTOM w0.203: v1(236.79,168.7) 236.79,167.38 UNK7R15.1
