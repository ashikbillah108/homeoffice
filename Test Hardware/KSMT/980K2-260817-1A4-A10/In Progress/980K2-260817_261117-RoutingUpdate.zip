# Allegro board 980K2-260817_261117-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UNK4K26  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  276.97 252.48 90 bottom
UNK4K27  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  280.15 261.37 180 bottom
UNK4K28  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  284.72 261.37 180 bottom
UNK4K29  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  289.29 261.37 180 bottom
UNK4K30  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  280.15 265.18 180 bottom
UNK4K31  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  284.72 265.18 180 bottom
UNK4K32  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  289.29 265.18 180 bottom
UNK4K33  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  280.15 268.22 180 bottom
UNK4K34  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  284.72 268.22 180 bottom
UNK4K35  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  289.29 268.22 180 bottom
UNK4K36  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  280.15 271.27 180 bottom
UNK4K37  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  284.72 271.27 180 bottom
UNK4K38  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  280.15 273.81 180 bottom
UNK4K39  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  284.72 273.81 180 bottom
UNK4K40  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  275.57 273.05 270 bottom
UNK4K41  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  275.57 277.62 270 bottom
UNK4K42  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  275.57 282.19 270 bottom
UNK4K43  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  272.65 273.05 270 bottom
UNK4K44  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  272.65 278.89 270 bottom
UNK4K45  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  272.65 283.46 270 bottom
UNK4K46  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  270.24 274.57 270 bottom
UNK4K47  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  270.24 280.42 270 bottom
UNK4K48  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  270.24 284.99 270 bottom
UNK4K49  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  267.83 284.99 270 bottom
UNK4K50  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  267.83 279.15 270 bottom
UNK4K51  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  268.72 246.51 270 bottom
UNK4K52  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  268.72 241.17 90 bottom
UNK4K53  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  276.97 246.51 270 bottom
UNK4K54  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  276.97 241.17 90 bottom
UNK4K55  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  243.44 292.35 0 bottom
UNK4K56  G3VM-201DR  [RL_G3VM201DR_200V]  248.4 288.67 90 bottom
UNK4K57  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  278.11 234.57 270 bottom
UNK4K58  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  276.08 234.57 270 bottom
UNK4K59  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  273.03 234.57 270 bottom
UNK4K60  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  271 234.57 270 bottom
UNK4K61  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  250.05 292.35 0 bottom
UNK4R1  10K-0.1-S4  [R0402]  263.76 248.79 0 bottom
UNK4R7  4.7K-1-S4-WA  [R0402]  268.21 243.84 90 bottom
UNK4R8  4.7K-1-S4-WA  [R0402]  276.46 243.84 90 bottom
UNK4R11  5K-1-S4-YA  [R0402]  246.11 293.12 0 bottom
UNK4R14  5K-1-S4-YA  [R0402]  252.71 293.12 0 bottom
UNK4R15  0-0-S2-KOA  [R0201]  277.14 227.33 0 bottom
UNK4R16  5.1-1-S2  [R0201]  277.11 232.54 180 bottom
UNK4R17  0-0-S2-KOA  [R0201]  272.06 227.33 0 bottom
UNK4R18  5.1-1-S2  [R0201]  272.03 232.54 180 bottom
UNK4R19  100K-0.1-S4-YA  [R0402]  246.11 291.95 180 bottom
UNK4R20  100K-0.1-S4-YA  [R0402]  252.71 291.95 180 bottom
UNK4R41  0-5-S6  [R0603]  125.03 -33.82 270 top
UNK4R42  0-5-S6  [R0603]  121.83 -33.82 270 top
UNK4RK2  619-1-S4  [R0402]  260.97 284.23 90 bottom
UNK4RK3  619-1-S4  [R0402]  250.52 269.99 0 bottom
UNK4RK4  619-1-S4  [R0402]  260.97 297.43 90 bottom
UNK4RK5  619-1-S4  [R0402]  257.67 268.99 90 bottom
UNK4RK6  619-1-S4  [R0402]  257.67 266.19 90 bottom
UNK4RK7  619-1-S4  [R0402]  257.67 264.16 90 bottom
UNK4RK8  619-1-S4  [R0402]  257.67 261.62 90 bottom
UNK4RK9  619-1-S4  [R0402]  251.95 261.62 90 bottom
UNK4RK10  619-1-S4  [R0402]  253.1 264.16 90 bottom
UNK4RK11  619-1-S4  [R0402]  263.76 255.02 180 bottom
UNK4RK12  619-1-S4  [R0402]  263.76 250.19 180 bottom
UNK4RK13  619-1-S4  [R0402]  263.76 244.22 180 bottom
UNK4RK14  619-1-S4  [R0402]  266.56 250.19 180 bottom
UNK4RK16  619-1-S4  [R0402]  266.56 255.02 180 bottom
UNK4RK17  619-1-S4  [R0402]  268.72 255.02 180 bottom
UNK4RK18  619-1-S4  [R0402]  268.72 250.19 180 bottom
UNK4RK19  619-1-S4  [R0402]  271.51 255.02 180 bottom
UNK4RK20  619-1-S4  [R0402]  271.51 250.19 180 bottom
UNK4RK21  619-1-S4  [R0402]  273.67 255.02 180 bottom
UNK4RK22  619-1-S4  [R0402]  273.67 250.19 180 bottom
UNK4RK25  619-1-S4  [R0402]  276.97 255.02 180 bottom
UNK4RK26  619-1-S4  [R0402]  276.97 250.19 180 bottom
UNK4RK27  619-1-S4  [R0402]  282.43 261.37 270 bottom
UNK4RK28  619-1-S4  [R0402]  287 261.37 270 bottom
UNK4RK29  619-1-S4  [R0402]  289.67 262.89 180 bottom
UNK4RK30  619-1-S4  [R0402]  282.43 265.18 270 bottom
UNK4RK31  619-1-S4  [R0402]  287 265.18 270 bottom
UNK4RK32  619-1-S4  [R0402]  289.67 266.7 180 bottom
UNK4RK33  619-1-S4  [R0402]  282.43 268.22 270 bottom
UNK4RK34  619-1-S4  [R0402]  287 268.22 270 bottom
UNK4RK35  619-1-S4  [R0402]  291.58 268.22 270 bottom
UNK4RK36  619-1-S4  [R0402]  282.43 271.27 270 bottom
UNK4RK37  619-1-S4  [R0402]  287 271.27 270 bottom
UNK4RK38  619-1-S4  [R0402]  282.43 273.81 270 bottom
UNK4RK39  619-1-S4  [R0402]  287 273.81 270 bottom
UNK4RK40  619-1-S4  [R0402]  275.57 275.34 0 bottom
UNK4RK41  619-1-S4  [R0402]  275.57 279.91 0 bottom
UNK4RK42  619-1-S4  [R0402]  275.57 284.48 0 bottom
UNK4RK43  619-1-S4  [R0402]  272.65 275.34 0 bottom
UNK4RK44  619-1-S4  [R0402]  272.65 281.18 0 bottom
UNK4RK45  619-1-S4  [R0402]  272.65 285.75 0 bottom
UNK4RK46  619-1-S4  [R0402]  270.24 276.86 0 bottom
UNK4RK47  619-1-S4  [R0402]  270.24 282.7 0 bottom
UNK4RK48  619-1-S4  [R0402]  270.24 287.27 0 bottom
UNK4RK49  619-1-S4  [R0402]  267.83 287.27 0 bottom
UNK4RK50  619-1-S4  [R0402]  267.83 281.43 0 bottom
UNK4RK51  619-1-S4  [R0402]  268.72 248.79 0 bottom
UNK4RK52  619-1-S4  [R0402]  268.72 238.89 180 bottom
UNK4RK53  619-1-S4  [R0402]  276.97 248.79 0 bottom
UNK4RK54  619-1-S4  [R0402]  276.97 238.89 180 bottom
UNK4RK55  619-1-S4  [R0402]  278.11 236.86 180 bottom
UNK4RK56  619-1-S4  [R0402]  276.08 236.86 180 bottom
UNK4RK57  619-1-S4  [R0402]  273.03 236.86 180 bottom
UNK4RK58  619-1-S4  [R0402]  271 236.86 180 bottom
UNK4RK59  619-1-S4  [R0402]  241.16 292.35 90 bottom
UNK4RK60  619-1-S4  [R0402]  240.9 287.9 90 bottom
UNK4RK61  619-1-S4  [R0402]  247.76 292.35 90 bottom
UNK4SH1  SHORT  [DEFAULT_SHORT_SMALL]  417.61 -0.6 0 top
UNK4SH2  SHORT  [DEFAULT_SHORT_SMALL]  23.24 -1.79 0 top
UNK4SH3  SHORT  [DEFAULT_SHORT_SMALL]  43.06 -1.79 0 top
UNK4SH4  SHORT  [DEFAULT_SHORT_SMALL]  45.27 -1.79 0 top
UNK4SH5  SHORT  [DEFAULT_SHORT_SMALL]  47.47 -1.79 0 top
UNK4SH6  SHORT  [DEFAULT_SHORT_SMALL]  49.67 -1.79 0 top
UNK4SH7  SHORT  [DEFAULT_SHORT_SMALL]  51.88 -1.79 0 top
UNK4SH8  SHORT  [DEFAULT_SHORT_SMALL]  54.08 -1.79 0 top
UNK4SH9  SHORT  [DEFAULT_SHORT_SMALL]  56.28 -1.79 0 top
UNK4SH10  SHORT  [DEFAULT_SHORT_SMALL]  1.2 -1.79 0 top
UNK4SH11  SHORT  [DEFAULT_SHORT_SMALL]  3.41 -1.79 0 top
UNK4SH12  SHORT  [DEFAULT_SHORT_SMALL]  5.61 -1.79 0 top
UNK4SH13  SHORT  [DEFAULT_SHORT_SMALL]  7.81 -1.79 0 top
UNK4SH14  SHORT  [DEFAULT_SHORT_SMALL]  10.02 -1.79 0 top
UNK4SH15  SHORT  [DEFAULT_SHORT_SMALL]  12.22 -1.79 0 top
UNK4SH16  SHORT  [DEFAULT_SHORT_SMALL]  14.42 -1.79 0 top
UNK4SH17  SHORT  [DEFAULT_SHORT_SMALL]  16.63 -1.79 0 top
UNK4SH18  SHORT  [DEFAULT_SHORT_SMALL]  18.83 -1.79 0 top
UNK4SH19  SHORT  [DEFAULT_SHORT_SMALL]  21.03 -1.79 0 top
UNK4SH20  SHORT  [DEFAULT_SHORT_SMALL]  25.44 -1.79 0 top
UNK4SH21  SHORT  [DEFAULT_SHORT_SMALL]  27.64 -1.79 0 top
UNK4SH22  SHORT  [DEFAULT_SHORT_SMALL]  29.84 -1.79 0 top
UNK4SH23  SHORT  [DEFAULT_SHORT_SMALL]  32.05 -1.79 0 top
UNK4SH24  SHORT  [DEFAULT_SHORT_SMALL]  34.25 -1.79 0 top
UNK4SH25  SHORT  [DEFAULT_SHORT_SMALL]  36.45 -1.79 0 top
UNK4SH26  SHORT  [DEFAULT_SHORT_SMALL]  38.66 -1.79 0 top
UNK4SH27  SHORT  [DEFAULT_SHORT_SMALL]  40.86 -1.79 0 top
UNK4SHORT1  SHORT  [DEFAULT_SHORT_SMALL]  344.9 -1.79 0 top
UNK4SHORT2  SHORT  [DEFAULT_SHORT_SMALL]  351.51 -1.79 0 top
UNK4SHORT3  SHORT  [DEFAULT_SHORT_SMALL]  353.71 -1.79 0 top
UNK4SHORT4  SHORT  [DEFAULT_SHORT_SMALL]  355.92 -1.79 0 top
UNK4SHORT6  SHORT  [DEFAULT_SHORT_SMALL]  358.12 -1.79 0 top
UNK4SHORT7  SHORT  [DEFAULT_SHORT_SMALL]  360.32 -1.79 0 top
UNK4SHORT8  SHORT  [DEFAULT_SHORT_SMALL]  362.53 -1.79 0 top
UNK4SHORT9  SHORT  [DEFAULT_SHORT_SMALL]  364.73 -1.79 0 top
UNK4SHORT10  SHORT  [DEFAULT_SHORT_SMALL]  347.1 -1.79 0 top
UNK4SHORT11  SHORT  [DEFAULT_SHORT_SMALL]  349.31 -1.79 0 top
UNK4TP_ATT_F  TP01  [TP_040_T]  297.64 -3.27 0 top
UNK4TP_ATT_S  TP01  [TP_040_T]  299.62 -3.27 0 top
UNK4TP_C1A_F  TP01  [TP_040_T]  301.6 -3.27 0 top
UNK4TP_C1A_S  TP01  [TP_040_T]  303.58 -3.27 0 top
UNK4TP_C1B_F  TP01  [TP_040_T]  305.56 -3.27 0 top
UNK4TP_C1B_S  TP01  [TP_040_T]  307.55 -3.27 0 top
UNK4TP_C2A_F  TP01  [TP_040_T]  309.53 -3.27 0 top
UNK4TP_C2A_S  TP01  [TP_040_T]  311.51 -3.27 0 top
UNK4TP_C2B_F  TP01  [TP_040_T]  313.49 -3.27 0 top
UNK4TP_C2B_S  TP01  [TP_040_T]  315.47 -3.27 0 top
UNK4TP_C3A_F  TP01  [TP_040_T]  317.45 -3.27 0 top
UNK4TP_C3A_S  TP01  [TP_040_T]  319.43 -3.27 0 top
UNK4TP_C3B_F  TP01  [TP_040_T]  323.39 -3.27 0 top
UNK4TP_C3B_S  TP01  [TP_040_T]  102.13 -5.25 0 top
UNK4TP_GA1_S  TP01  [TP_040_T]  325.38 -3.27 0 top
UNK4TP_GA2_S  TP01  [TP_040_T]  327.36 -3.27 0 top
UNK4TP_GB1_S  TP01  [TP_040_T]  329.34 -3.27 0 top
UNK4TP_GB2_S  TP01  [TP_040_T]  331.32 -3.27 0 top
UNK4TP_IN+_1  TP01  [TP_040_T]  246.61 294.24 0 top
UNK4TP_IN+_2  TP01  [TP_040_T]  253.21 294.24 0 top
UNK4TP_IN+_3  TP01  [TP_040_T]  275.68 233.69 180 top
UNK4TP_IN+_4  TP01  [TP_040_T]  270.6 233.69 180 top
UNK4TP_IN-_1  TP01  [TP_040_T]  244.31 294.24 0 top
UNK4TP_IN-_2  TP01  [TP_040_T]  250.91 294.24 0 top
UNK4TP_IN-_3  TP01  [TP_040_T]  278.51 233.69 180 top
UNK4TP_IN-_4  TP01  [TP_040_T]  273.43 233.69 180 top
UNK4TP_IS1N_F  TP01  [TP_040_T]  333.3 -3.27 0 top
UNK4TP_IS1N_S  TP01  [TP_040_T]  335.28 -3.27 0 top
UNK4TP_IS1P_F  TP01  [TP_040_T]  337.26 -3.27 0 top
UNK4TP_IS2N_F  TP01  [TP_040_T]  339.24 -3.27 0 top
UNK4TP_IS2N_S  TP01  [TP_040_T]  341.23 -3.27 0 top
UNK4TP_IS2P_S  TP01  [TP_040_T]  343.21 -3.27 0 top
UNK4TP_OPTO_F  TP01  [TP_040_T]  345.19 -3.27 0 top
UNK4TP_OPTO_S  TP01  [TP_040_T]  347.17 -3.27 0 top
UNK4TP_OUT+_1  TP01  [TP_040_T]  246.61 296.31 0 top
UNK4TP_OUT+_2  TP01  [TP_040_T]  253.21 296.31 0 top
UNK4TP_OUT-_1  TP01  [TP_040_T]  244.31 296.31 0 top
UNK4TP_OUT-_2  TP01  [TP_040_T]  250.91 296.31 0 top
UNK4TP_OUT_1  TP01  [TP_040_T]  275.49 231.3 180 top
UNK4TP_OUT_2  TP01  [TP_040_T]  270.41 231.3 180 top
UNK4TP_REF_1  TP01  [TP_040_T]  349.15 -3.27 0 top
UNK4TP_REF_2  TP01  [TP_040_T]  271.06 228.7 180 top
UNK4TP_SCL_F  TP01  [TP_040_T]  351.13 -3.27 0 top
UNK4TP_SDA_F  TP01  [TP_040_T]  353.11 -3.27 0 top
UNK4TP_SDA_S  TP01  [TP_040_T]  355.09 -3.27 0 top
UNK4TP_SRD_F  TP01  [TP_040_T]  357.08 -3.27 0 top
UNK4TP_SRD_S  TP01  [TP_040_T]  359.06 -3.27 0 top
UNK4TP_SRG_F  TP01  [TP_040_T]  361.04 -3.27 0 top
UNK4TP_SRG_S  TP01  [TP_040_T]  363.02 -3.27 0 top
UNK4TP_SRS_F  TP01  [TP_040_T]  365 -3.27 0 top
UNK4TP_SRS_S  TP01  [TP_040_T]  366.98 -3.27 0 top
UNK4TP_STB_F  TP01  [TP_040_T]  368.96 -3.27 0 top
UNK4TP_STB_S  TP01  [TP_040_T]  370.94 -3.27 0 top
UNK4TP_VCC_F  TP01  [TP_040_T]  372.92 -3.27 0 top
UNK4TP_VCC_S  TP01  [TP_040_T]  374.91 -3.27 0 top
UNK4TP_VDD0_F  TP01  [TP_040_T]  376.89 -3.27 0 top
UNK4TP_VDD0_S  TP01  [TP_040_T]  378.87 -3.27 0 top
UNK4TP_VDD1_S  TP01  [TP_040_T]  380.85 -3.27 0 top
UNK4TP_VDD2_S  TP01  [TP_040_T]  382.83 -3.27 0 top
UNK4TP_VDDI_F  TP01  [TP_040_T]  384.81 -3.27 0 top
UNK4TP_VDDI_S  TP01  [TP_040_T]  386.79 -3.27 0 top
UNK4TP_VIN_F  TP01  [TP_040_T]  388.77 -3.27 0 top
UNK4TP_VIN_S  TP01  [TP_040_T]  390.76 -3.27 0 top
UNK4TP_VO1_S  TP01  [TP_040_T]  392.74 -3.27 0 top
UNK4TP_VO2_S  TP01  [TP_040_T]  394.72 -3.27 0 top
UNK4TP_VSR_F  TP01  [TP_040_T]  396.7 -3.27 0 top
UNK4TP_VSR_S  TP01  [TP_040_T]  398.68 -3.27 0 top
UNK4U1  TLV3604DCKR-SC70  [SC70]  245.61 294.89 270 bottom
UNK4U2  TLV3604DCKR-SC70  [SC70]  252.21 294.89 270 bottom
UNK4U3  INA186A3QDDFRQ1-SOT23-8  [SOT23_8P_0P65MM_H1P3MM]  276.46 230 180 bottom
UNK4U4  INA186A3QDDFRQ1-SOT23-8  [SOT23_8P_0P65MM_H1P3MM]  271.38 230 180 bottom
UNK5C48  0.01U-100-X7R-S6-MU  [C0603]  147.57 213.87 90 bottom
UNK5C49  0.01U-100-X7R-S6-MU  [C0603]  136.27 208.99 270 bottom
UNK5C50  0.01U-100-X7R-S6-MU  [C0603]  142.28 208.54 270 bottom
UNK5C53  1U-16-X5R-S4-YA  [C0402]  142.24 201.62 270 bottom
UNK5C54  2.2U-16-X-S4-MU  [C0402]  136.53 201.62 270 bottom
UNK5C58  1U-16-X5R-S4-YA  [C0402]  142.11 197.68 270 bottom
UNK5C59  4.7U-100-X-SB-MU  [C1210]  140.59 186.51 270 bottom
UNK5C60  0.01U-100-X7R-S6-MU  [C0603]  147.01 199.72 0 bottom
UNK5C61  0.01U-100-X7R-S6-MU  [C0603]  156.88 204.78 180 bottom
UNK5C62  2.2U-16-X-S4-MU  [C0402]  157.07 199.72 0 bottom
UNK5C63  0.01U-100-X7R-S6-MU  [C0603]  157.73 201.82 90 bottom
UNK5C64  0.01U-100-X7R-S6-MU  [C0603]  156.88 207.82 180 bottom
UNK5C65  0.1U-25-X7R-S4-MU  [C0402]  157.73 211.37 90 bottom
UNK5C66  0.1U-25-X7R-S4-MU  [C0402]  152.65 216.61 180 bottom
UNK5C67  0.1U-25-X7R-S4-MU  [C0402]  150.24 218.13 180 bottom
UNK5C68  0.1U-25-X7R-S4-MU  [C0402]  147.83 222.7 180 bottom
UNK5C69  0.01U-100-X7R-S6-MU  [C0603]  151.96 199.72 0 bottom
UNK5C70  0.1U-25-X7R-S4-MU  [C0402]  122.8 234.89 180 bottom
UNK5C71  0.1U-25-X7R-S4-MU  [C0402]  129.42 234.89 180 bottom
UNK5C72  0.1U-25-X7R-S4-MU  [C0402]  158.75 167.33 0 bottom
UNK5C73  0.1U-25-X7R-S4-MU  [C0402]  153.67 167.33 0 bottom
UNK5C74  0.1U-25-X7R-S4-MU  [C0402]  157.73 213.91 90 bottom
UNK5K1  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  138.43 230.63 270 bottom
UNK5K2  G3VM-201DR  [RL_G3VM201DR_200V]  144.15 217.5 0 bottom
UNK5K3  G3VM-201DR  [RL_G3VM201DR_200V]  134.49 213.18 90 bottom
UNK5K4  G3VM-201DR  [RL_G3VM201DR_200V]  144.15 231.47 0 bottom
UNK5K5  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  139.95 208.99 0 bottom
UNK5K6  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  139.95 206.19 0 bottom
UNK5K7  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  139.95 204.16 0 bottom
UNK5K8  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  139.95 201.62 0 bottom
UNK5K9  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  134.24 201.62 0 bottom
UNK5K10  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  135.38 204.16 0 bottom
UNK5K11  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  143.76 197.3 90 bottom
UNK5K12  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  143.76 192.48 90 bottom
UNK5K13  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  143.76 186.51 90 bottom
UNK5K14  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  146.56 192.48 90 bottom
UNK5K15  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  135.25 182.75 270 bottom
UNK5K16  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  146.56 197.3 90 bottom
UNK5K17  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  148.72 197.3 90 bottom
UNK5K18  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  148.72 192.48 90 bottom
UNK5K19  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  151.51 197.3 90 bottom
UNK5K20  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  151.51 192.48 90 bottom
UNK5K21  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  153.67 197.3 90 bottom
UNK5K22  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  153.67 192.48 90 bottom
UNK5K23  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  152.78 182.75 270 bottom
UNK5K24  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  161.04 182.75 270 bottom
UNK5K25  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  156.97 197.3 90 bottom
UNK5K26  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  156.97 192.48 90 bottom
UNK5K27  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  160.15 201.37 180 bottom
UNK5K28  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  164.72 201.37 180 bottom
UNK5K29  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  169.29 201.37 180 bottom
UNK5K30  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  160.15 205.18 180 bottom
UNK5K31  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  164.72 205.18 180 bottom
UNK5K32  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  169.29 205.18 180 bottom
UNK5K33  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  160.15 208.22 180 bottom
UNK5K34  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  164.72 208.22 180 bottom
UNK5K35  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  169.29 208.22 180 bottom
UNK5K36  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  160.15 211.27 180 bottom
UNK5K37  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  164.72 211.27 180 bottom
UNK5K38  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  160.15 213.81 180 bottom
UNK5K39  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  164.72 213.81 180 bottom
UNK5K40  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  155.58 213.05 270 bottom
UNK5K41  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  155.58 217.62 270 bottom
UNK5K42  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  155.58 222.19 270 bottom
UNK5K43  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  152.65 213.05 270 bottom
UNK5K44  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  152.65 218.89 270 bottom
UNK5K45  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  152.65 223.46 270 bottom
UNK5K46  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  150.24 214.57 270 bottom
UNK5K47  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  150.24 220.42 270 bottom
UNK5K48  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  150.24 224.99 270 bottom
UNK5K49  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  147.83 224.99 270 bottom
UNK5K50  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  147.83 219.15 270 bottom
UNK5K51  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  148.72 186.51 270 bottom
UNK5K52  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  148.72 181.17 90 bottom
UNK5K53  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  156.97 186.51 270 bottom
UNK5K54  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  156.97 181.17 90 bottom
UNK5K55  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  123.44 232.35 0 bottom
UNK5K56  G3VM-201DR  [RL_G3VM201DR_200V]  128.4 228.67 90 bottom
UNK5K57  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  158.12 174.57 270 bottom
UNK5K58  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  156.08 174.57 270 bottom
UNK5K59  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  153.04 174.57 270 bottom
UNK5K60  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  151 174.57 270 bottom
UNK5K61  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  130.05 232.35 0 bottom
UNK5R1  10K-0.1-S4  [R0402]  143.76 188.79 0 bottom
UNK5R7  4.7K-1-S4-WA  [R0402]  148.21 183.84 90 bottom
UNK5R8  4.7K-1-S4-WA  [R0402]  156.46 183.84 90 bottom
UNK5R11  5K-1-S4-YA  [R0402]  126.11 233.12 0 bottom
UNK5R14  5K-1-S4-YA  [R0402]  132.72 233.12 0 bottom
UNK5R15  0-0-S2-KOA  [R0201]  157.14 167.33 0 bottom
UNK5R16  5.1-1-S2  [R0201]  157.11 172.54 180 bottom
UNK5R17  0-0-S2-KOA  [R0201]  152.06 167.33 0 bottom
UNK5R18  5.1-1-S2  [R0201]  152.03 172.54 180 bottom
UNK5R19  100K-0.1-S4-YA  [R0402]  126.11 231.95 180 bottom
UNK5R20  100K-0.1-S4-YA  [R0402]  132.72 231.95 180 bottom
UNK5R41  0-5-S6  [R0603]  118.62 -33.82 270 top
UNK5R42  0-5-S6  [R0603]  115.42 -33.82 270 top
UNK5RK2  619-1-S4  [R0402]  140.97 224.23 90 bottom
UNK5RK3  619-1-S4  [R0402]  130.52 209.99 0 bottom
UNK5RK4  619-1-S4  [R0402]  140.97 237.43 90 bottom
UNK5RK5  619-1-S4  [R0402]  137.67 208.99 90 bottom
UNK5RK6  619-1-S4  [R0402]  137.67 206.19 90 bottom
UNK5RK7  619-1-S4  [R0402]  137.67 204.16 90 bottom
UNK5RK8  619-1-S4  [R0402]  137.67 201.62 90 bottom
UNK5RK9  619-1-S4  [R0402]  131.95 201.62 90 bottom
UNK5RK10  619-1-S4  [R0402]  133.1 204.16 90 bottom
UNK5RK11  619-1-S4  [R0402]  143.76 195.02 180 bottom
UNK5RK12  619-1-S4  [R0402]  143.76 190.19 180 bottom
UNK5RK13  619-1-S4  [R0402]  143.76 184.22 180 bottom
UNK5RK14  619-1-S4  [R0402]  146.56 190.19 180 bottom
UNK5RK16  619-1-S4  [R0402]  146.56 195.02 180 bottom
UNK5RK17  619-1-S4  [R0402]  148.72 195.02 180 bottom
UNK5RK18  619-1-S4  [R0402]  148.72 190.19 180 bottom
UNK5RK19  619-1-S4  [R0402]  151.51 195.02 180 bottom
UNK5RK20  619-1-S4  [R0402]  151.51 190.19 180 bottom
UNK5RK21  619-1-S4  [R0402]  153.67 195.02 180 bottom
UNK5RK22  619-1-S4  [R0402]  153.67 190.19 180 bottom
UNK5RK25  619-1-S4  [R0402]  156.97 195.02 180 bottom
UNK5RK26  619-1-S4  [R0402]  156.97 190.19 180 bottom
UNK5RK27  619-1-S4  [R0402]  162.43 201.37 270 bottom
UNK5RK28  619-1-S4  [R0402]  167 201.37 270 bottom
UNK5RK29  619-1-S4  [R0402]  169.67 202.89 180 bottom
UNK5RK30  619-1-S4  [R0402]  162.43 205.18 270 bottom
UNK5RK31  619-1-S4  [R0402]  167 205.18 270 bottom
UNK5RK32  619-1-S4  [R0402]  169.67 206.7 180 bottom
UNK5RK33  619-1-S4  [R0402]  162.43 208.22 270 bottom
UNK5RK34  619-1-S4  [R0402]  167 208.22 270 bottom
UNK5RK35  619-1-S4  [R0402]  171.58 208.22 270 bottom
UNK5RK36  619-1-S4  [R0402]  162.43 211.27 270 bottom
UNK5RK37  619-1-S4  [R0402]  167 211.27 270 bottom
UNK5RK38  619-1-S4  [R0402]  162.43 213.81 270 bottom
UNK5RK39  619-1-S4  [R0402]  167 213.81 270 bottom
UNK5RK40  619-1-S4  [R0402]  155.58 215.34 0 bottom
UNK5RK41  619-1-S4  [R0402]  155.58 219.91 0 bottom
UNK5RK42  619-1-S4  [R0402]  155.58 224.48 0 bottom
UNK5RK43  619-1-S4  [R0402]  152.65 215.34 0 bottom
UNK5RK44  619-1-S4  [R0402]  152.65 221.18 0 bottom
UNK5RK45  619-1-S4  [R0402]  152.65 225.75 0 bottom
UNK5RK46  619-1-S4  [R0402]  150.24 216.86 0 bottom
UNK5RK47  619-1-S4  [R0402]  150.24 222.7 0 bottom
UNK5RK48  619-1-S4  [R0402]  150.24 227.27 0 bottom
UNK5RK49  619-1-S4  [R0402]  147.83 227.27 0 bottom
UNK5RK50  619-1-S4  [R0402]  147.83 221.43 0 bottom
UNK5RK51  619-1-S4  [R0402]  148.72 188.79 0 bottom
UNK5RK52  619-1-S4  [R0402]  148.72 178.89 180 bottom
UNK5RK53  619-1-S4  [R0402]  156.97 188.79 0 bottom
UNK5RK54  619-1-S4  [R0402]  156.97 178.89 180 bottom
UNK5RK55  619-1-S4  [R0402]  158.12 176.86 180 bottom
UNK5RK56  619-1-S4  [R0402]  156.08 176.86 180 bottom
UNK5RK57  619-1-S4  [R0402]  153.04 176.86 180 bottom
UNK5RK58  619-1-S4  [R0402]  151 176.86 180 bottom
UNK5RK59  619-1-S4  [R0402]  121.16 232.35 90 bottom
UNK5RK60  619-1-S4  [R0402]  120.9 227.9 90 bottom
UNK5RK61  619-1-S4  [R0402]  127.76 232.35 90 bottom
UNK5SH1  SHORT  [DEFAULT_SHORT_SMALL]  58.49 -1.79 0 top
UNK5SH2  SHORT  [DEFAULT_SHORT_SMALL]  82.72 -1.79 0 top
UNK5SH3  SHORT  [DEFAULT_SHORT_SMALL]  102.55 -1.79 0 top
UNK5SH4  SHORT  [DEFAULT_SHORT_SMALL]  104.75 -1.79 0 top
UNK5SH5  SHORT  [DEFAULT_SHORT_SMALL]  106.96 -1.79 0 top
UNK5SH6  SHORT  [DEFAULT_SHORT_SMALL]  109.16 -1.79 0 top
UNK5SH7  SHORT  [DEFAULT_SHORT_SMALL]  111.36 -1.79 0 top
UNK5SH8  SHORT  [DEFAULT_SHORT_SMALL]  113.57 -1.79 0 top
UNK5SH9  SHORT  [DEFAULT_SHORT_SMALL]  115.77 -1.79 0 top
UNK5SH10  SHORT  [DEFAULT_SHORT_SMALL]  60.69 -1.79 0 top
UNK5SH11  SHORT  [DEFAULT_SHORT_SMALL]  62.89 -1.79 0 top
UNK5SH12  SHORT  [DEFAULT_SHORT_SMALL]  65.1 -1.79 0 top
UNK5SH13  SHORT  [DEFAULT_SHORT_SMALL]  67.3 -1.79 0 top
UNK5SH14  SHORT  [DEFAULT_SHORT_SMALL]  69.5 -1.79 0 top
UNK5SH15  SHORT  [DEFAULT_SHORT_SMALL]  71.71 -1.79 0 top
UNK5SH16  SHORT  [DEFAULT_SHORT_SMALL]  73.91 -1.79 0 top
UNK5SH17  SHORT  [DEFAULT_SHORT_SMALL]  76.11 -1.79 0 top
UNK5SH18  SHORT  [DEFAULT_SHORT_SMALL]  78.32 -1.79 0 top
UNK5SH19  SHORT  [DEFAULT_SHORT_SMALL]  80.52 -1.79 0 top
UNK5SH20  SHORT  [DEFAULT_SHORT_SMALL]  84.92 -1.79 0 top
UNK5SH21  SHORT  [DEFAULT_SHORT_SMALL]  87.13 -1.79 0 top
UNK5SH22  SHORT  [DEFAULT_SHORT_SMALL]  89.33 -1.79 0 top
UNK5SH23  SHORT  [DEFAULT_SHORT_SMALL]  91.53 -1.79 0 top
UNK5SH24  SHORT  [DEFAULT_SHORT_SMALL]  93.74 -1.79 0 top
UNK5SH25  SHORT  [DEFAULT_SHORT_SMALL]  95.94 -1.79 0 top
UNK5SH26  SHORT  [DEFAULT_SHORT_SMALL]  98.14 -1.79 0 top
UNK5SH27  SHORT  [DEFAULT_SHORT_SMALL]  100.35 -1.79 0 top
UNK5SHORT1  SHORT  [DEFAULT_SHORT_SMALL]  366.93 -1.79 0 top
UNK5SHORT2  SHORT  [DEFAULT_SHORT_SMALL]  373.54 -1.79 0 top
UNK5SHORT3  SHORT  [DEFAULT_SHORT_SMALL]  375.75 -1.79 0 top
UNK5SHORT4  SHORT  [DEFAULT_SHORT_SMALL]  377.95 -1.79 0 top
UNK5SHORT6  SHORT  [DEFAULT_SHORT_SMALL]  380.15 -1.79 0 top
UNK5SHORT7  SHORT  [DEFAULT_SHORT_SMALL]  382.36 -1.79 0 top
UNK5SHORT8  SHORT  [DEFAULT_SHORT_SMALL]  384.56 -1.79 0 top
UNK5SHORT9  SHORT  [DEFAULT_SHORT_SMALL]  386.76 -1.79 0 top
UNK5SHORT10  SHORT  [DEFAULT_SHORT_SMALL]  369.14 -1.79 0 top
UNK5SHORT11  SHORT  [DEFAULT_SHORT_SMALL]  371.34 -1.79 0 top
UNK5TP_ATT_F  TP01  [TP_040_T]  400.66 -3.27 0 top
UNK5TP_ATT_S  TP01  [TP_040_T]  402.64 -3.27 0 top
UNK5TP_C1A_F  TP01  [TP_040_T]  404.62 -3.27 0 top
UNK5TP_C1A_S  TP01  [TP_040_T]  406.61 -3.27 0 top
UNK5TP_C1B_F  TP01  [TP_040_T]  408.59 -3.27 0 top
UNK5TP_C1B_S  TP01  [TP_040_T]  410.57 -3.27 0 top
UNK5TP_C2A_F  TP01  [TP_040_T]  412.55 -3.27 0 top
UNK5TP_C2A_S  TP01  [TP_040_T]  414.53 -3.27 0 top
UNK5TP_C2B_F  TP01  [TP_040_T]  416.51 -3.27 0 top
UNK5TP_C2B_S  TP01  [TP_040_T]  1.09 -5.25 0 top
UNK5TP_C3A_F  TP01  [TP_040_T]  3.07 -5.25 0 top
UNK5TP_C3A_S  TP01  [TP_040_T]  5.05 -5.25 0 top
UNK5TP_C3B_F  TP01  [TP_040_T]  7.04 -5.25 0 top
UNK5TP_C3B_S  TP01  [TP_040_T]  9.02 -5.25 0 top
UNK5TP_GA1_S  TP01  [TP_040_T]  11 -5.25 0 top
UNK5TP_GA2_S  TP01  [TP_040_T]  12.98 -5.25 0 top
UNK5TP_GB1_S  TP01  [TP_040_T]  14.96 -5.25 0 top
UNK5TP_GB2_S  TP01  [TP_040_T]  16.94 -5.25 0 top
UNK5TP_IN+_1  TP01  [TP_040_T]  126.61 234.24 0 top
UNK5TP_IN+_2  TP01  [TP_040_T]  133.22 234.24 0 top
UNK5TP_IN+_3  TP01  [TP_040_T]  155.68 173.69 180 top
UNK5TP_IN+_4  TP01  [TP_040_T]  150.6 173.69 180 top
UNK5TP_IN-_1  TP01  [TP_040_T]  124.31 234.24 0 top
UNK5TP_IN-_2  TP01  [TP_040_T]  130.91 234.24 0 top
UNK5TP_IN-_3  TP01  [TP_040_T]  158.52 173.69 180 top
UNK5TP_IN-_4  TP01  [TP_040_T]  153.44 173.69 180 top
UNK5TP_IS1N_F  TP01  [TP_040_T]  18.92 -5.25 0 top
UNK5TP_IS1N_S  TP01  [TP_040_T]  20.9 -5.25 0 top
UNK5TP_IS1P_F  TP01  [TP_040_T]  22.89 -5.25 0 top
UNK5TP_IS2N_F  TP01  [TP_040_T]  24.87 -5.25 0 top
UNK5TP_IS2N_S  TP01  [TP_040_T]  26.85 -5.25 0 top
UNK5TP_IS2P_S  TP01  [TP_040_T]  28.83 -5.25 0 top
UNK5TP_OPTO_F  TP01  [TP_040_T]  30.81 -5.25 0 top
UNK5TP_OPTO_S  TP01  [TP_040_T]  32.79 -5.25 0 top
UNK5TP_OUT+_1  TP01  [TP_040_T]  126.61 236.31 0 top
UNK5TP_OUT+_2  TP01  [TP_040_T]  133.22 236.31 0 top
UNK5TP_OUT-_1  TP01  [TP_040_T]  124.31 236.31 0 top
UNK5TP_OUT-_2  TP01  [TP_040_T]  130.91 236.31 0 top
UNK5TP_OUT_1  TP01  [TP_040_T]  155.49 171.3 180 top
UNK5TP_OUT_2  TP01  [TP_040_T]  150.41 171.3 180 top
UNK5TP_REF_1  TP01  [TP_040_T]  34.77 -5.25 0 top
UNK5TP_REF_2  TP01  [TP_040_T]  151.06 168.7 180 top
UNK5TP_SCL_F  TP01  [TP_040_T]  36.75 -5.25 0 top
UNK5TP_SDA_F  TP01  [TP_040_T]  38.74 -5.25 0 top
UNK5TP_SDA_S  TP01  [TP_040_T]  40.72 -5.25 0 top
UNK5TP_SRD_F  TP01  [TP_040_T]  42.7 -5.25 0 top
UNK5TP_SRD_S  TP01  [TP_040_T]  44.68 -5.25 0 top
UNK5TP_SRG_F  TP01  [TP_040_T]  46.66 -5.25 0 top
UNK5TP_SRG_S  TP01  [TP_040_T]  48.64 -5.25 0 top
UNK5TP_SRS_F  TP01  [TP_040_T]  50.62 -5.25 0 top
UNK5TP_SRS_S  TP01  [TP_040_T]  52.6 -5.25 0 top
UNK5TP_STB_F  TP01  [TP_040_T]  54.58 -5.25 0 top
UNK5TP_STB_S  TP01  [TP_040_T]  56.57 -5.25 0 top
UNK5TP_VCC_F  TP01  [TP_040_T]  58.55 -5.25 0 top
UNK5TP_VCC_S  TP01  [TP_040_T]  60.53 -5.25 0 top
UNK5TP_VDD0_F  TP01  [TP_040_T]  62.51 -5.25 0 top
UNK5TP_VDD0_S  TP01  [TP_040_T]  64.49 -5.25 0 top
UNK5TP_VDD1_S  TP01  [TP_040_T]  66.47 -5.25 0 top
UNK5TP_VDD2_S  TP01  [TP_040_T]  68.45 -5.25 0 top
UNK5TP_VDDI_F  TP01  [TP_040_T]  70.43 -5.25 0 top
UNK5TP_VDDI_S  TP01  [TP_040_T]  72.42 -5.25 0 top
UNK5TP_VIN_F  TP01  [TP_040_T]  74.4 -5.25 0 top
UNK5TP_VIN_S  TP01  [TP_040_T]  76.38 -5.25 0 top
UNK5TP_VO1_S  TP01  [TP_040_T]  78.36 -5.25 0 top
UNK5TP_VO2_S  TP01  [TP_040_T]  80.34 -5.25 0 top
UNK5TP_VSR_F  TP01  [TP_040_T]  82.32 -5.25 0 top
UNK5TP_VSR_S  TP01  [TP_040_T]  84.3 -5.25 0 top
UNK5U1  TLV3604DCKR-SC70  [SC70]  125.61 234.89 270 bottom
UNK5U2  TLV3604DCKR-SC70  [SC70]  132.22 234.89 270 bottom
UNK5U3  INA186A3QDDFRQ1-SOT23-8  [SOT23_8P_0P65MM_H1P3MM]  156.46 170 180 bottom
UNK5U4  INA186A3QDDFRQ1-SOT23-8  [SOT23_8P_0P65MM_H1P3MM]  151.38 170 180 bottom
UNK6C48  0.01U-100-X7R-S6-MU  [C0603]  187.57 213.87 90 bottom
UNK6C49  0.01U-100-X7R-S6-MU  [C0603]  176.27 208.99 270 bottom
UNK6C50  0.01U-100-X7R-S6-MU  [C0603]  182.28 208.54 270 bottom
UNK6C53  1U-16-X5R-S4-YA  [C0402]  182.24 201.62 270 bottom
UNK6C54  2.2U-16-X-S4-MU  [C0402]  176.52 201.62 270 bottom
UNK6C58  1U-16-X5R-S4-YA  [C0402]  182.11 197.68 270 bottom
UNK6C59  4.7U-100-X-SB-MU  [C1210]  180.59 186.51 270 bottom
UNK6C60  0.01U-100-X7R-S6-MU  [C0603]  187.01 199.72 0 bottom
UNK6C61  0.01U-100-X7R-S6-MU  [C0603]  196.88 204.78 180 bottom
UNK6C62  2.2U-16-X-S4-MU  [C0402]  197.07 199.72 0 bottom
UNK6C63  0.01U-100-X7R-S6-MU  [C0603]  197.73 201.82 90 bottom
UNK6C64  0.01U-100-X7R-S6-MU  [C0603]  196.88 207.82 180 bottom
UNK6C65  0.1U-25-X7R-S4-MU  [C0402]  197.73 211.37 90 bottom
UNK6C66  0.1U-25-X7R-S4-MU  [C0402]  192.65 216.61 180 bottom
UNK6C67  0.1U-25-X7R-S4-MU  [C0402]  190.24 218.13 180 bottom
UNK6C68  0.1U-25-X7R-S4-MU  [C0402]  187.83 222.7 180 bottom
UNK6C69  0.01U-100-X7R-S6-MU  [C0603]  191.96 199.72 0 bottom
UNK6C70  0.1U-25-X7R-S4-MU  [C0402]  162.8 234.89 180 bottom
UNK6C71  0.1U-25-X7R-S4-MU  [C0402]  169.42 234.89 180 bottom
UNK6C72  0.1U-25-X7R-S4-MU  [C0402]  198.75 167.33 0 bottom
UNK6C73  0.1U-25-X7R-S4-MU  [C0402]  193.67 167.33 0 bottom
UNK6C74  0.1U-25-X7R-S4-MU  [C0402]  197.73 213.91 90 bottom
UNK6K1  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  178.43 230.63 270 bottom
UNK6K2  G3VM-201DR  [RL_G3VM201DR_200V]  184.14 217.5 0 bottom
UNK6K3  G3VM-201DR  [RL_G3VM201DR_200V]  174.49 213.18 90 bottom
UNK6K4  G3VM-201DR  [RL_G3VM201DR_200V]  184.14 231.47 0 bottom
UNK6K5  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  179.95 208.99 0 bottom
UNK6K6  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  179.95 206.19 0 bottom
UNK6K7  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  179.95 204.16 0 bottom
UNK6K8  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  179.95 201.62 0 bottom
UNK6K9  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  174.24 201.62 0 bottom
UNK6K10  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  175.38 204.16 0 bottom
UNK6K11  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  183.76 197.3 90 bottom
UNK6K12  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  183.76 192.48 90 bottom
UNK6K13  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  183.76 186.51 90 bottom
UNK6K14  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  186.56 192.48 90 bottom
UNK6K15  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  175.25 182.75 270 bottom
UNK6K16  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  186.56 197.3 90 bottom
UNK6K17  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  188.72 197.3 90 bottom
UNK6K18  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  188.72 192.48 90 bottom
UNK6K19  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  191.51 197.3 90 bottom
UNK6K20  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  191.51 192.48 90 bottom
UNK6K21  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  193.67 197.3 90 bottom
UNK6K22  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  193.67 192.48 90 bottom
UNK6K23  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  192.78 182.75 270 bottom
UNK6K24  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  201.04 182.75 270 bottom
UNK6K25  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  196.97 197.3 90 bottom
UNK6K26  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  196.97 192.48 90 bottom
UNK6K27  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  200.15 201.37 180 bottom
UNK6K28  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  204.72 201.37 180 bottom
UNK6K29  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  209.29 201.37 180 bottom
UNK6K30  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  200.15 205.18 180 bottom
UNK6K31  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  204.72 205.18 180 bottom
UNK6K32  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  209.29 205.18 180 bottom
UNK6K33  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  200.15 208.22 180 bottom
UNK6K34  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  204.72 208.22 180 bottom
UNK6K35  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  209.29 208.22 180 bottom
UNK6K36  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  200.15 211.27 180 bottom
UNK6K37  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  204.72 211.27 180 bottom
UNK6K38  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  200.15 213.81 180 bottom
UNK6K39  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  204.72 213.81 180 bottom
UNK6K40  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  195.57 213.05 270 bottom
UNK6K41  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  195.57 217.62 270 bottom
UNK6K42  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  195.57 222.19 270 bottom
UNK6K43  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  192.65 213.05 270 bottom
UNK6K44  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  192.65 218.89 270 bottom
UNK6K45  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  192.65 223.46 270 bottom
UNK6K46  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  190.24 214.57 270 bottom
UNK6K47  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  190.24 220.42 270 bottom
UNK6K48  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  190.24 224.99 270 bottom
UNK6K49  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  187.83 224.99 270 bottom
UNK6K50  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  187.83 219.15 270 bottom
UNK6K51  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  188.72 186.51 270 bottom
UNK6K52  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  188.72 181.17 90 bottom
UNK6K53  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  196.97 186.51 270 bottom
UNK6K54  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  196.97 181.17 90 bottom
UNK6K55  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  163.44 232.35 0 bottom
UNK6K56  G3VM-201DR  [RL_G3VM201DR_200V]  168.4 228.67 90 bottom
UNK6K57  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  198.11 174.57 270 bottom
UNK6K58  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  196.08 174.57 270 bottom
UNK6K59  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  193.03 174.57 270 bottom
UNK6K60  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  191 174.57 270 bottom
UNK6K61  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  170.05 232.35 0 bottom
UNK6R1  10K-0.1-S4  [R0402]  183.76 188.79 0 bottom
UNK6R7  4.7K-1-S4-WA  [R0402]  188.21 183.84 90 bottom
UNK6R8  4.7K-1-S4-WA  [R0402]  196.46 183.84 90 bottom
UNK6R11  5K-1-S4-YA  [R0402]  166.11 233.12 0 bottom
UNK6R14  5K-1-S4-YA  [R0402]  172.71 233.12 0 bottom
UNK6R15  0-0-S2-KOA  [R0201]  197.14 167.33 0 bottom
UNK6R16  5.1-1-S2  [R0201]  197.11 172.54 180 bottom
UNK6R17  0-0-S2-KOA  [R0201]  192.06 167.33 0 bottom
UNK6R18  5.1-1-S2  [R0201]  192.03 172.54 180 bottom
UNK6R19  100K-0.1-S4-YA  [R0402]  166.11 231.95 180 bottom
UNK6R20  100K-0.1-S4-YA  [R0402]  172.71 231.95 180 bottom
UNK6R41  0-5-S6  [R0603]  112.22 -33.82 270 top
UNK6R42  0-5-S6  [R0603]  109.01 -33.82 270 top
UNK6RK2  619-1-S4  [R0402]  180.97 224.23 90 bottom
UNK6RK3  619-1-S4  [R0402]  170.52 209.99 0 bottom
UNK6RK4  619-1-S4  [R0402]  180.97 237.43 90 bottom
UNK6RK5  619-1-S4  [R0402]  177.67 208.99 90 bottom
UNK6RK6  619-1-S4  [R0402]  177.67 206.19 90 bottom
UNK6RK7  619-1-S4  [R0402]  177.67 204.16 90 bottom
UNK6RK8  619-1-S4  [R0402]  177.67 201.62 90 bottom
UNK6RK9  619-1-S4  [R0402]  171.95 201.62 90 bottom
UNK6RK10  619-1-S4  [R0402]  173.1 204.16 90 bottom
UNK6RK11  619-1-S4  [R0402]  183.76 195.02 180 bottom
UNK6RK12  619-1-S4  [R0402]  183.76 190.19 180 bottom
UNK6RK13  619-1-S4  [R0402]  183.76 184.22 180 bottom
UNK6RK14  619-1-S4  [R0402]  186.56 190.19 180 bottom
UNK6RK16  619-1-S4  [R0402]  186.56 195.02 180 bottom
UNK6RK17  619-1-S4  [R0402]  188.72 195.02 180 bottom
UNK6RK18  619-1-S4  [R0402]  188.72 190.19 180 bottom
UNK6RK19  619-1-S4  [R0402]  191.51 195.02 180 bottom
UNK6RK20  619-1-S4  [R0402]  191.51 190.19 180 bottom
UNK6RK21  619-1-S4  [R0402]  193.67 195.02 180 bottom
UNK6RK22  619-1-S4  [R0402]  193.67 190.19 180 bottom
UNK6RK25  619-1-S4  [R0402]  196.97 195.02 180 bottom
UNK6RK26  619-1-S4  [R0402]  196.97 190.19 180 bottom
UNK6RK27  619-1-S4  [R0402]  202.43 201.37 270 bottom
UNK6RK28  619-1-S4  [R0402]  207 201.37 270 bottom
UNK6RK29  619-1-S4  [R0402]  209.67 202.89 180 bottom
UNK6RK30  619-1-S4  [R0402]  202.43 205.18 270 bottom
UNK6RK31  619-1-S4  [R0402]  207 205.18 270 bottom
UNK6RK32  619-1-S4  [R0402]  209.67 206.7 180 bottom
UNK6RK33  619-1-S4  [R0402]  202.43 208.22 270 bottom
UNK6RK34  619-1-S4  [R0402]  207 208.22 270 bottom
UNK6RK35  619-1-S4  [R0402]  211.58 208.22 270 bottom
UNK6RK36  619-1-S4  [R0402]  202.43 211.27 270 bottom
UNK6RK37  619-1-S4  [R0402]  207 211.27 270 bottom
UNK6RK38  619-1-S4  [R0402]  202.43 213.81 270 bottom
UNK6RK39  619-1-S4  [R0402]  207 213.81 270 bottom
UNK6RK40  619-1-S4  [R0402]  195.57 215.34 0 bottom
UNK6RK41  619-1-S4  [R0402]  195.57 219.91 0 bottom
UNK6RK42  619-1-S4  [R0402]  195.57 224.48 0 bottom
UNK6RK43  619-1-S4  [R0402]  192.65 215.34 0 bottom
UNK6RK44  619-1-S4  [R0402]  192.65 221.18 0 bottom
UNK6RK45  619-1-S4  [R0402]  192.65 225.75 0 bottom
UNK6RK46  619-1-S4  [R0402]  190.24 216.86 0 bottom
UNK6RK47  619-1-S4  [R0402]  190.24 222.7 0 bottom
UNK6RK48  619-1-S4  [R0402]  190.24 227.27 0 bottom
UNK6RK49  619-1-S4  [R0402]  187.83 227.27 0 bottom
UNK6RK50  619-1-S4  [R0402]  187.83 221.43 0 bottom
UNK6RK51  619-1-S4  [R0402]  188.72 188.79 0 bottom
UNK6RK52  619-1-S4  [R0402]  188.72 178.89 180 bottom
UNK6RK53  619-1-S4  [R0402]  196.97 188.79 0 bottom
UNK6RK54  619-1-S4  [R0402]  196.97 178.89 180 bottom
UNK6RK55  619-1-S4  [R0402]  198.11 176.86 180 bottom
UNK6RK56  619-1-S4  [R0402]  196.08 176.86 180 bottom
UNK6RK57  619-1-S4  [R0402]  193.03 176.86 180 bottom
UNK6RK58  619-1-S4  [R0402]  191 176.86 180 bottom
UNK6RK59  619-1-S4  [R0402]  161.16 232.35 90 bottom
UNK6RK60  619-1-S4  [R0402]  160.9 227.9 90 bottom
UNK6RK61  619-1-S4  [R0402]  167.76 232.35 90 bottom
UNK6SH1  SHORT  [DEFAULT_SHORT_SMALL]  117.97 -1.79 0 top
UNK6SH2  SHORT  [DEFAULT_SHORT_SMALL]  142.21 -1.79 0 top
UNK6SH3  SHORT  [DEFAULT_SHORT_SMALL]  162.04 -1.79 0 top
UNK6SH4  SHORT  [DEFAULT_SHORT_SMALL]  164.24 -1.79 0 top
UNK6SH5  SHORT  [DEFAULT_SHORT_SMALL]  166.44 -1.79 0 top
UNK6SH6  SHORT  [DEFAULT_SHORT_SMALL]  168.65 -1.79 0 top
UNK6SH7  SHORT  [DEFAULT_SHORT_SMALL]  170.85 -1.79 0 top
UNK6SH8  SHORT  [DEFAULT_SHORT_SMALL]  173.05 -1.79 0 top
UNK6SH9  SHORT  [DEFAULT_SHORT_SMALL]  175.26 -1.79 0 top
UNK6SH10  SHORT  [DEFAULT_SHORT_SMALL]  120.18 -1.79 0 top
UNK6SH11  SHORT  [DEFAULT_SHORT_SMALL]  122.38 -1.79 0 top
UNK6SH12  SHORT  [DEFAULT_SHORT_SMALL]  124.58 -1.79 0 top
UNK6SH13  SHORT  [DEFAULT_SHORT_SMALL]  126.79 -1.79 0 top
UNK6SH14  SHORT  [DEFAULT_SHORT_SMALL]  128.99 -1.79 0 top
UNK6SH15  SHORT  [DEFAULT_SHORT_SMALL]  131.19 -1.79 0 top
UNK6SH16  SHORT  [DEFAULT_SHORT_SMALL]  133.39 -1.79 0 top
UNK6SH17  SHORT  [DEFAULT_SHORT_SMALL]  135.6 -1.79 0 top
UNK6SH18  SHORT  [DEFAULT_SHORT_SMALL]  137.8 -1.79 0 top
UNK6SH19  SHORT  [DEFAULT_SHORT_SMALL]  140 -1.79 0 top
UNK6SH20  SHORT  [DEFAULT_SHORT_SMALL]  144.41 -1.79 0 top
UNK6SH21  SHORT  [DEFAULT_SHORT_SMALL]  146.61 -1.79 0 top
UNK6SH22  SHORT  [DEFAULT_SHORT_SMALL]  148.82 -1.79 0 top
UNK6SH23  SHORT  [DEFAULT_SHORT_SMALL]  151.02 -1.79 0 top
UNK6SH24  SHORT  [DEFAULT_SHORT_SMALL]  153.22 -1.79 0 top
UNK6SH25  SHORT  [DEFAULT_SHORT_SMALL]  155.43 -1.79 0 top
UNK6SH26  SHORT  [DEFAULT_SHORT_SMALL]  157.63 -1.79 0 top
UNK6SH27  SHORT  [DEFAULT_SHORT_SMALL]  159.83 -1.79 0 top
UNK6SHORT1  SHORT  [DEFAULT_SHORT_SMALL]  388.97 -1.79 0 top
UNK6SHORT2  SHORT  [DEFAULT_SHORT_SMALL]  395.58 -1.79 0 top
UNK6SHORT3  SHORT  [DEFAULT_SHORT_SMALL]  397.78 -1.79 0 top
UNK6SHORT4  SHORT  [DEFAULT_SHORT_SMALL]  399.98 -1.79 0 top
UNK6SHORT6  SHORT  [DEFAULT_SHORT_SMALL]  402.18 -1.79 0 top
UNK6SHORT7  SHORT  [DEFAULT_SHORT_SMALL]  404.39 -1.79 0 top
UNK6SHORT8  SHORT  [DEFAULT_SHORT_SMALL]  406.59 -1.79 0 top
UNK6SHORT9  SHORT  [DEFAULT_SHORT_SMALL]  408.79 -1.79 0 top
UNK6SHORT10  SHORT  [DEFAULT_SHORT_SMALL]  391.17 -1.79 0 top
UNK6SHORT11  SHORT  [DEFAULT_SHORT_SMALL]  393.37 -1.79 0 top
UNK6TP_ATT_F  TP01  [TP_040_T]  86.28 -5.25 0 top
UNK6TP_ATT_S  TP01  [TP_040_T]  88.27 -5.25 0 top
UNK6TP_C1A_F  TP01  [TP_040_T]  90.25 -5.25 0 top
UNK6TP_C1A_S  TP01  [TP_040_T]  92.23 -5.25 0 top
UNK6TP_C1B_F  TP01  [TP_040_T]  94.21 -5.25 0 top
UNK6TP_C1B_S  TP01  [TP_040_T]  96.19 -5.25 0 top
UNK6TP_C2A_F  TP01  [TP_040_T]  98.17 -5.25 0 top
UNK6TP_C2A_S  TP01  [TP_040_T]  100.15 -5.25 0 top
UNK6TP_C2B_F  TP01  [TP_040_T]  106.1 -5.25 0 top
UNK6TP_C2B_S  TP01  [TP_040_T]  104.11 -5.25 0 top
UNK6TP_C3A_F  TP01  [TP_040_T]  110.06 -7.23 0 top
UNK6TP_C3A_S  TP01  [TP_040_T]  108.08 -5.25 0 top
UNK6TP_C3B_F  TP01  [TP_040_T]  110.06 -5.25 0 top
UNK6TP_C3B_S  TP01  [TP_040_T]  112.04 -5.25 0 top
UNK6TP_GA1_S  TP01  [TP_040_T]  114.02 -5.25 0 top
UNK6TP_GA2_S  TP01  [TP_040_T]  116 -5.25 0 top
UNK6TP_GB1_S  TP01  [TP_040_T]  117.98 -5.25 0 top
UNK6TP_GB2_S  TP01  [TP_040_T]  119.96 -5.25 0 top
UNK6TP_IN+_1  TP01  [TP_040_T]  166.61 234.24 0 top
UNK6TP_IN+_2  TP01  [TP_040_T]  173.22 234.24 0 top
UNK6TP_IN+_3  TP01  [TP_040_T]  195.68 173.69 180 top
UNK6TP_IN+_4  TP01  [TP_040_T]  190.6 173.69 180 top
UNK6TP_IN-_1  TP01  [TP_040_T]  164.31 234.24 0 top
UNK6TP_IN-_2  TP01  [TP_040_T]  170.91 234.24 0 top
UNK6TP_IN-_3  TP01  [TP_040_T]  198.51 173.69 180 top
UNK6TP_IN-_4  TP01  [TP_040_T]  193.43 173.69 180 top
UNK6TP_IS1N_F  TP01  [TP_040_T]  121.95 -5.25 0 top
UNK6TP_IS1N_S  TP01  [TP_040_T]  123.93 -5.25 0 top
UNK6TP_IS1P_F  TP01  [TP_040_T]  125.91 -5.25 0 top
UNK6TP_IS2N_F  TP01  [TP_040_T]  127.89 -5.25 0 top
UNK6TP_IS2N_S  TP01  [TP_040_T]  129.87 -5.25 0 top
UNK6TP_IS2P_S  TP01  [TP_040_T]  131.85 -5.25 0 top
UNK6TP_OPTO_F  TP01  [TP_040_T]  133.83 -5.25 0 top
UNK6TP_OPTO_S  TP01  [TP_040_T]  135.81 -5.25 0 top
UNK6TP_OUT+_1  TP01  [TP_040_T]  166.61 236.31 0 top
UNK6TP_OUT+_2  TP01  [TP_040_T]  173.22 236.31 0 top
UNK6TP_OUT-_1  TP01  [TP_040_T]  164.31 236.31 0 top
UNK6TP_OUT-_2  TP01  [TP_040_T]  170.91 236.31 0 top
UNK6TP_OUT_1  TP01  [TP_040_T]  195.49 171.3 180 top
UNK6TP_OUT_2  TP01  [TP_040_T]  190.41 171.3 180 top
UNK6TP_REF_1  TP01  [TP_040_T]  137.8 -5.25 0 top
UNK6TP_REF_2  TP01  [TP_040_T]  191.06 168.7 180 top
UNK6TP_SCL_F  TP01  [TP_040_T]  139.78 -5.25 0 top
UNK6TP_SDA_F  TP01  [TP_040_T]  141.76 -5.25 0 top
UNK6TP_SDA_S  TP01  [TP_040_T]  143.74 -5.25 0 top
UNK6TP_SRD_F  TP01  [TP_040_T]  145.72 -5.25 0 top
UNK6TP_SRD_S  TP01  [TP_040_T]  147.7 -5.25 0 top
UNK6TP_SRG_F  TP01  [TP_040_T]  149.68 -5.25 0 top
UNK6TP_SRG_S  TP01  [TP_040_T]  151.66 -5.25 0 top
UNK6TP_SRS_F  TP01  [TP_040_T]  153.64 -5.25 0 top
UNK6TP_SRS_S  TP01  [TP_040_T]  155.63 -5.25 0 top
UNK6TP_STB_F  TP01  [TP_040_T]  157.61 -5.25 0 top
UNK6TP_STB_S  TP01  [TP_040_T]  159.59 -5.25 0 top
UNK6TP_VCC_F  TP01  [TP_040_T]  161.57 -5.25 0 top
UNK6TP_VCC_S  TP01  [TP_040_T]  163.55 -5.25 0 top
UNK6TP_VDD0_F  TP01  [TP_040_T]  165.53 -5.25 0 top
UNK6TP_VDD0_S  TP01  [TP_040_T]  167.51 -5.25 0 top
UNK6TP_VDD1_S  TP01  [TP_040_T]  169.49 -5.25 0 top
UNK6TP_VDD2_S  TP01  [TP_040_T]  171.48 -5.25 0 top
UNK6TP_VDDI_F  TP01  [TP_040_T]  173.46 -5.25 0 top
UNK6TP_VDDI_S  TP01  [TP_040_T]  175.44 -5.25 0 top
UNK6TP_VIN_F  TP01  [TP_040_T]  177.42 -5.25 0 top
UNK6TP_VIN_S  TP01  [TP_040_T]  179.4 -5.25 0 top
UNK6TP_VO1_S  TP01  [TP_040_T]  181.38 -5.25 0 top
UNK6TP_VO2_S  TP01  [TP_040_T]  183.36 -5.25 0 top
UNK6TP_VSR_F  TP01  [TP_040_T]  185.34 -5.25 0 top
UNK6TP_VSR_S  TP01  [TP_040_T]  187.33 -5.25 0 top
UNK6U1  TLV3604DCKR-SC70  [SC70]  165.61 234.89 270 bottom
UNK6U2  TLV3604DCKR-SC70  [SC70]  172.22 234.89 270 bottom
UNK6U3  INA186A3QDDFRQ1-SOT23-8  [SOT23_8P_0P65MM_H1P3MM]  196.46 170 180 bottom
UNK6U4  INA186A3QDDFRQ1-SOT23-8  [SOT23_8P_0P65MM_H1P3MM]  191.38 170 180 bottom
UNK7C48  0.01U-100-X7R-S6-MU  [C0603]  227.57 213.87 90 bottom
UNK7C49  0.01U-100-X7R-S6-MU  [C0603]  216.27 208.99 270 bottom
UNK7C50  0.01U-100-X7R-S6-MU  [C0603]  222.28 208.54 270 bottom
UNK7C53  1U-16-X5R-S4-YA  [C0402]  222.24 201.62 270 bottom
UNK7C54  2.2U-16-X-S4-MU  [C0402]  216.52 201.62 270 bottom
UNK7C58  1U-16-X5R-S4-YA  [C0402]  222.11 197.68 270 bottom
UNK7C59  4.7U-100-X-SB-MU  [C1210]  220.59 186.51 270 bottom
UNK7C60  0.01U-100-X7R-S6-MU  [C0603]  227.01 199.72 0 bottom
UNK7C61  0.01U-100-X7R-S6-MU  [C0603]  236.88 204.78 180 bottom
UNK7C62  2.2U-16-X-S4-MU  [C0402]  237.07 199.72 0 bottom
UNK7C63  0.01U-100-X7R-S6-MU  [C0603]  237.73 201.82 90 bottom
UNK7C64  0.01U-100-X7R-S6-MU  [C0603]  236.88 207.82 180 bottom
UNK7C65  0.1U-25-X7R-S4-MU  [C0402]  237.73 211.37 90 bottom
UNK7C66  0.1U-25-X7R-S4-MU  [C0402]  232.65 216.61 180 bottom
UNK7C67  0.1U-25-X7R-S4-MU  [C0402]  230.24 218.13 180 bottom
UNK7C68  0.1U-25-X7R-S4-MU  [C0402]  227.83 222.7 180 bottom
UNK7C69  0.01U-100-X7R-S6-MU  [C0603]  231.96 199.72 0 bottom
UNK7C70  0.1U-25-X7R-S4-MU  [C0402]  202.8 234.89 180 bottom
UNK7C71  0.1U-25-X7R-S4-MU  [C0402]  209.42 234.89 180 bottom
UNK7C72  0.1U-25-X7R-S4-MU  [C0402]  238.75 167.33 0 bottom
UNK7C73  0.1U-25-X7R-S4-MU  [C0402]  233.67 167.33 0 bottom
UNK7C74  0.1U-25-X7R-S4-MU  [C0402]  237.73 213.91 90 bottom
UNK7K1  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  218.43 230.63 270 bottom
UNK7K2  G3VM-201DR  [RL_G3VM201DR_200V]  224.14 217.5 0 bottom
UNK7K3  G3VM-201DR  [RL_G3VM201DR_200V]  214.49 213.18 90 bottom
UNK7K4  G3VM-201DR  [RL_G3VM201DR_200V]  224.14 231.47 0 bottom
UNK7K5  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  219.95 208.99 0 bottom
UNK7K6  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  219.95 206.19 0 bottom
UNK7K7  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  219.95 204.16 0 bottom
UNK7K8  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  219.95 201.62 0 bottom
UNK7K9  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  214.24 201.62 0 bottom
UNK7K10  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  215.38 204.16 0 bottom
UNK7K11  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  223.76 197.3 90 bottom
UNK7K12  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  223.76 192.48 90 bottom
UNK7K13  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  223.76 186.51 90 bottom
UNK7K14  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  226.56 192.48 90 bottom
UNK7K15  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  215.25 182.75 270 bottom
UNK7K16  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  226.56 197.3 90 bottom
UNK7K17  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  228.72 197.3 90 bottom
UNK7K18  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  228.72 192.48 90 bottom
UNK7K19  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  231.51 197.3 90 bottom
UNK7K20  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  231.51 192.48 90 bottom
UNK7K21  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  233.67 197.3 90 bottom
UNK7K22  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  233.67 192.48 90 bottom
UNK7K23  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  232.78 182.75 270 bottom
UNK7K24  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  241.04 182.75 270 bottom
UNK7K25  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  236.97 197.3 90 bottom
UNK7K26  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  236.97 192.48 90 bottom
UNK7K27  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  240.15 201.37 180 bottom
UNK7K28  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  244.72 201.37 180 bottom
UNK7K29  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  249.29 201.37 180 bottom
UNK7K30  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  240.15 205.18 180 bottom
UNK7K31  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  244.72 205.18 180 bottom
UNK7K32  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  249.29 205.18 180 bottom
UNK7K33  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  240.15 208.22 180 bottom
UNK7K34  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  244.72 208.22 180 bottom
UNK7K35  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  249.29 208.22 180 bottom
UNK7K36  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  240.15 211.27 180 bottom
UNK7K37  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  244.72 211.27 180 bottom
UNK7K38  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  240.15 213.81 180 bottom
UNK7K39  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  244.72 213.81 180 bottom
UNK7K40  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  235.57 213.05 270 bottom
UNK7K41  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  235.57 217.62 270 bottom
UNK7K42  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  235.57 222.19 270 bottom
UNK7K43  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  232.65 213.05 270 bottom
UNK7K44  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  232.65 218.89 270 bottom
UNK7K45  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  232.65 223.46 270 bottom
UNK7K46  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  230.24 214.57 270 bottom
UNK7K47  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  230.24 220.42 270 bottom
UNK7K48  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  230.24 224.99 270 bottom
UNK7K49  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  227.83 224.99 270 bottom
UNK7K50  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  227.83 219.15 270 bottom
UNK7K51  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  228.72 186.51 270 bottom
UNK7K52  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  228.72 181.17 90 bottom
UNK7K53  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  236.97 186.51 270 bottom
UNK7K54  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  236.97 181.17 90 bottom
UNK7K55  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  203.44 232.35 0 bottom
UNK7K56  G3VM-201DR  [RL_G3VM201DR_200V]  208.4 228.67 90 bottom
UNK7K57  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  238.11 174.57 270 bottom
UNK7K58  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  236.08 174.57 270 bottom
UNK7K59  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  233.03 174.57 270 bottom
UNK7K60  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  231 174.57 270 bottom
UNK7K61  G3VM-51UR-5V-VSON4  [RL_G3VM_4P_VSON4]  210.05 232.35 0 bottom
UNK7R1  10K-0.1-S4  [R0402]  223.76 188.79 0 bottom
UNK7R7  4.7K-1-S4-WA  [R0402]  228.21 183.84 90 bottom
UNK7R8  4.7K-1-S4-WA  [R0402]  236.46 183.84 90 bottom
UNK7R11  5K-1-S4-YA  [R0402]  206.11 233.12 0 bottom
UNK7R14  5K-1-S4-YA  [R0402]  212.71 233.12 0 bottom
UNK7R15  0-0-S2-KOA  [R0201]  237.14 167.33 0 bottom
UNK7R16  5.1-1-S2  [R0201]  237.11 172.54 180 bottom
UNK7R17  0-0-S2-KOA  [R0201]  232.06 167.33 0 bottom
UNK7R18  5.1-1-S2  [R0201]  232.03 172.54 180 bottom
UNK7R19  100K-0.1-S4-YA  [R0402]  206.11 231.95 180 bottom
UNK7R20  100K-0.1-S4-YA  [R0402]  212.71 231.95 180 bottom
UNK7R41  0-5-S6  [R0603]  105.81 -33.82 270 top
UNK7R42  0-5-S6  [R0603]  102.61 -33.82 270 top
UNK7RK2  619-1-S4  [R0402]  220.97 224.23 90 bottom
UNK7RK3  619-1-S4  [R0402]  210.52 209.99 0 bottom
UNK7RK4  619-1-S4  [R0402]  220.97 237.43 90 bottom
UNK7RK5  619-1-S4  [R0402]  217.67 208.99 90 bottom
UNK7RK6  619-1-S4  [R0402]  217.67 206.19 90 bottom
UNK7RK7  619-1-S4  [R0402]  217.67 204.16 90 bottom
UNK7RK8  619-1-S4  [R0402]  217.67 201.62 90 bottom
UNK7RK9  619-1-S4  [R0402]  211.95 201.62 90 bottom
UNK7RK10  619-1-S4  [R0402]  213.1 204.16 90 bottom
