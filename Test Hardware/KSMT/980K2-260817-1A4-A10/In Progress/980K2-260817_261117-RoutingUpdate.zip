# Allegro board 980K2-260817_261117-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL13_DP_144: length 389.2
  L03_DP w0.079: v1(231.71,168.7) 231.71,169.17 232.99,170.46 297.3,170.46 316.77,189.93 316.77,331.66 301.95,346.48 301.95,378.27 286.26,393.95 286.26,407.92 262.63,431.54 262.63,432.57 256.95,438.25 254.18,438.25 254.04,438.12 252.46,438.12 251.64,438.94 250.99,438.94 250.57,438.52 249.81,438.52 249.39,438.94 248.86,438.94 248.44,438.52 247.56,438.52 247.14,438.94 246.61,438.94 246.19,438.52 245.77,438.52 245.27,438.02 245.27,438.02 244.89,437.64 244.36,437.64 244.02,437.97 242.98,437.97 242.64,437.64 242.11,437.64 241.77,437.97 241.15,437.97 240.91,438.21 240.91,438.71 240.13,439.49 SLOT13.A17
  BOTTOM w0.203: UNK7R17.1 231.71,167.38 v1(231.71,168.7)
SL14_PMVI_10_HF:
  vias: v1(188.21,243.34)
SL14_PMVI_11_HF:
  vias: v1(196.46,243.34)
SL14_PMVI_12_HF: length 0.3
  BOTTOM w0.203: UNK2U1.4 v1(164.31,294.24)
SL14_PMVI_13_HF:
  vias: v1(170.91,294.24)
SL14_PMVI_14_HF:
  vias: v1(195.49,231.3)
SL14_PMVI_15_HF: length 2.2
  BOTTOM w0.203: UNK2C72.1 UNK2R15.2 UNK2U3.1
SL14_PMVI_16_HF: length 2.7
  BOTTOM w0.381: v1(195.49,226.57) 195.94,226.57 196.14,226.77 UNK2U3.3
SL14_PMVI_17_HF:
  vias: v1(190.41,231.3)
SL14_PMVI_18_HF: length 2.2
  BOTTOM w0.203: UNK2C73.1 UNK2R17.2 UNK2U4.1
SL14_PMVI_19_HF: length 0.9
  BOTTOM w0.381: UNK2TP_REF_2.1 v1(191.06,229.62)
SL14_PMVI_20_HF:
  vias: v1(268.21,243.34)
SL14_PMVI_21_HF:
  vias: v1(276.46,243.34)
SL14_PMVI_22_HF: length 0.3
  BOTTOM w0.203: UNK4U1.4 v1(244.31,294.24)
SL14_PMVI_23_HF:
  vias: v1(250.91,294.24)
SL14_PMVI_24_HF:
  vias: v1(275.49,231.3)
SL14_PMVI_25_HF: length 2.2
  BOTTOM w0.203: UNK4U3.1 UNK4R15.2 UNK4C72.1
SL14_PMVI_26_HF: length 2.7
  BOTTOM w0.381: v1(275.49,226.57) 275.94,226.57 276.14,226.77 UNK4U3.3
SL14_PMVI_27_HF:
  vias: v1(270.41,231.3)
SL14_PMVI_28_HF: length 2.2
  BOTTOM w0.203: UNK4U4.1 UNK4R17.2 UNK4C73.1
SL14_PMVI_29_HF: length 0.9
  BOTTOM w0.381: UNK4TP_REF_2.1 v1(271.06,229.62)
SL14_PMVI_30_HF:
  vias: v1(188.21,183.34)
SL14_PMVI_31_HF:
  vias: v1(196.46,183.34)
SL14_PMVI_32_HF: length 0.3
  BOTTOM w0.203: UNK6U1.4 v1(164.31,234.24)
SL14_PMVI_33_HF:
  vias: v1(170.91,234.24)
SL14_PMVI_34_HF:
  vias: v1(195.49,171.3)
SL14_PMVI_35_HF: length 2.2
  BOTTOM w0.203: UNK6U3.1 UNK6R15.2 UNK6C72.1
SL14_PMVI_36_HF: length 2.7
  BOTTOM w0.381: UNK6U3.3 196.14,166.77 195.94,166.57 v1(195.49,166.57)
SL14_PMVI_37_HF:
  vias: v1(190.41,171.3)
SL14_PMVI_38_HF: length 2.2
  BOTTOM w0.203: UNK6C73.1 UNK6R17.2 UNK6U4.1
SL14_PMVI_39_HF: length 0.9
  BOTTOM w0.381: UNK6TP_REF_2.1 v1(191.06,169.62)
SL14_PMVI_40_HF:
  vias: v1(268.21,183.34)
SL14_PMVI_41_HF:
  vias: v1(276.46,183.34)
SL14_PMVI_42_HF: length 0.3
  BOTTOM w0.203: UNK8U1.4 v1(244.31,234.24)
SL14_PMVI_43_HF:
  vias: v1(250.91,234.24)
SL14_PMVI_44_HF:
  vias: v1(275.49,171.3)
SL14_PMVI_45_HF: length 2.2
  BOTTOM w0.203: UNK8C72.1 UNK8R15.2 UNK8U3.1
SL14_PMVI_46_HF: length 2.7
  BOTTOM w0.381: v1(275.49,166.57) 275.94,166.57 276.14,166.77 UNK8U3.3
SL14_PMVI_47_HF:
  vias: v1(270.41,171.3)
SL14_PMVI_48_HF: length 2.2
  BOTTOM w0.203: UNK8U4.1 UNK8R17.2 UNK8C73.1
SL14_PMVI_49_HF: length 0.9
  BOTTOM w0.381: UNK8TP_REF_2.1 v1(271.06,169.62)
SL17_VI100_2_A_HF: length 11.5
  TOP w0.305: SITE5.2_F 146.18,208.74
  TOP w0.635: v1(140.83,208.59) 140.98,208.74 146.18,208.74
  BOTTOM w0.635: v1(140.83,208.59) 139.83,207.59 136.82,207.59 UNK5C49.2
SL17_VI100_2_A_HS: length 7.8
  BOTTOM w0.203: v2(147.45,208.74) 144.92,208.74 141.97,205.79 v1(140.83,205.79)
SL17_VI100_2_B_HF: length 9.3
  TOP w0.305: 149.94,211.84 149.31,211.21 149.31,211.02 149.29,211 149.29,210.58 149.31,210.56 149.31,210.3 149.3,210.29 SITE5.29_F
  TOP w0.635: v1(152.25,218.02) 151.49,217.25 151.49,213.39 149.94,211.84
SL17_VI100_2_B_HS: length 14.3
  BOTTOM w0.203: v2(149.3,209.59) 149.21,209.68 149.21,210.84 151.38,213.02 151.38,221.72 v1(152.25,222.59)
SL17_VI100_3_A_HF: length 16.3
  TOP w0.305: SITE5.5_F 145.45,207.24
  TOP w0.635: v1(140.83,201.22) 143.13,203.52 143.13,204.92 145.45,207.24
  BOTTOM w0.635: v1(135.11,201.22) 135.11,200.93 135.75,200.3 140.19,200.3 140.83,200.93 v1(140.83,201.22)
SL17_VI100_3_A_HS: length 13.4
  BOTTOM w0.203: v2(147.45,207.24) 146.97,207.24 142.62,202.89 137.13,202.89 v1(136.26,203.76)
SL17_VI100_3_B_HS: length 13
  BOTTOM w0.203: v1(149.12,193.35) 149.86,194.09 149.86,200.22 148.3,201.78 v2(148.3,205.39)
SL17_VI100_4_A_HS: length 8.3
  BOTTOM w0.203: v1(140.83,203.76) 141.84,203.76 145.82,207.74 v2(147.45,207.74)
SL17_VI100_4_B_HS: length 13.8
  BOTTOM w0.203: v2(151.65,205.74) 153.98,203.42 162.2,203.42 v1(163.84,201.77)
SL17_VI100_5_A_HF: length 23.1
  TOP w0.305: SITE5.6_F 146.47,206.74 146.18,206.45
  TOP w0.635: 146.18,206.45 144.16,204.43 v1(144.16,198.18)
  BOTTOM w0.508: 144.39,193.35 UNK5K12.4
  BOTTOM w0.635: 145.18,193.35 145.18,197.54 144.54,198.18 v1(144.16,198.18) ; 145.18,193.35 144.39,193.35 ; 145.18,193.35 145.18,188.1 144.45,187.38 144.21,187.38
SL17_VI100_5_A_HS:
  vias: v2(147.45,206.74)
SL17_VI100_6_A_HF:
  vias: v2(147.05,206.24)
SL17_VI100_6_A_HS:
  vias: v1(146.96,193.35) v2(147.45,206.24)
SL17_VI100_6_B_HF: length 1.7
  TOP w0.305: SITE5.30_F v2(148.8,211.66)
SL17_VI100_6_B_HS: length 4.5
  BOTTOM w0.203: UNK5K46.4 149.84,212.05 148.8,211.01 v2(148.8,209.59)
SL17_VI100_7_A_HF:
  vias: v2(149.8,204.99)
SL17_VI100_7_A_HS:
  vias: v1(154.07,193.35) v2(149.8,205.39)
SL17_VI100_7_B_HF: length 10.4
  TOP w0.305: 148.07,211.04 148.29,210.82 148.29,210.3 148.3,210.29 SITE5.31_F
  TOP w0.635: v1(149.84,219.54) 149.08,218.78 149.08,213.58 148.07,212.57 148.07,211.04
SL17_VI100_7_B_HS: length 15.2
  BOTTOM w0.203: v2(148.3,209.59) 148.3,211.84 149.05,212.6 149.05,223.33 v1(149.84,224.11)
SL17_VI100_8_B_HF: length 5.7
  TOP w0.305: SITE5.20_F 154.73,207.24 155.04,206.93
  TOP w0.635: v1(156.03,205.94) 155.04,206.93
  BOTTOM w0.635: v1(156.03,205.94) UNK5C61.2
SL17_VI100_8_B_HS: length 17.5
  BOTTOM w0.203: v2(151.65,207.24) 154.53,207.24 154.7,207.06 166.93,207.06 v1(168.42,205.58)
SL17_VI100_9_B_HF: length 7.6
  TOP w0.305: 154.28,207.99 154.03,207.74 SITE5.21_F
  TOP w0.635: v1(159.27,208.62) 158.64,207.99 154.28,207.99
SL17_VI100_9_B_HS: length 13.3
  BOTTOM w0.203: v2(151.65,207.74) 154.58,207.74 156.34,209.49 162.97,209.49 v1(163.84,208.62)
SL17_VI100_10_A_HF: length 9.6
  TOP w0.305: 151.98,204.74 151.55,204.74 SITE5.16_F
  TOP w0.635: 151.98,204.74 156.72,200.01 156.72,198.83 v1(157.37,198.18)
SL17_VI100_10_A_HS: length 15.2
  BOTTOM w0.203: v1(157.37,193.35) 157.37,194.05 157.17,194.25 156.08,194.25 155.83,194.51 155.83,200.6 151.3,205.13 v2(151.3,205.39)
SL17_VI100_10_B_HF: length 0.4
  TOP w0.305: SITE5.25_F v2(151.3,210.39)
SL17_VI100_10_B_HS: length 5.7
  BOTTOM w0.203: v1(155.17,212.18) 155.17,210.87 153.95,209.65 151.36,209.65 v2(151.3,209.59)
SL17_VI100_11_A_HF: length 7.2
  TOP w0.305: 153.62,205.67 153.05,206.24 SITE5.18_F
  TOP w0.635: 153.62,205.67 156.62,202.67 v1(157.73,202.67)
SL17_VI100_11_A_HS: length 18.6
  BOTTOM w0.203: v2(151.65,206.24) 151.97,206.24 154.31,203.91 166.28,203.91 v1(168.42,201.77)
SL17_VI100_11_B_HF: length 0.4
  TOP w0.305: SITE5.26_F v2(150.8,210.39)
SL17_VI100_11_B_HS: length 10.5
  BOTTOM w0.203: v1(155.17,216.75) 154.43,216 154.43,210.7 153.88,210.16 151.7,210.16 151.57,210.03 151.16,210.03 150.8,209.67 v2(150.8,209.59)
SL17_VI100_12_A_HF: length 8.2
  TOP w0.305: 154.31,206.19 154.13,206.19 153.59,206.74 SITE5.19_F
  TOP w0.635: 154.31,206.19 155.58,204.92 158.62,204.92 v1(159.27,205.58)
SL17_VI100_12_A_HS: length 12.7
  BOTTOM w0.203: v2(151.65,206.74) 154.27,206.74 154.43,206.58 162.84,206.58 v1(163.84,205.58)
SL17_VI100_12_B_HF: length 1.1
  TOP w0.305: v2(149.8,210.79) 150,210.79 150.3,210.49 SITE5.27_F
SL17_VI100_12_B_HS: length 15.4
  BOTTOM w0.152: v2(150.3,209.59) 150.44,209.73 150.44,210.53 150.71,210.8
  BOTTOM w0.203: v1(155.17,221.32) 154.05,220.2 154.05,216.2 154.03,216.17 154.03,211.32 153.5,210.8 150.71,210.8
SL17_VI100_13_A_HF: length 8.4
  TOP w0.305: 153.66,208.65 153.26,208.25 152.44,208.25 152.44,208.24 SITE5.22_F
  TOP w0.635: v1(157.73,208.86) 157.62,208.98 153.99,208.98 153.66,208.65
  BOTTOM w0.635: v1(157.73,208.86) 156.67,208.86 156.03,208.22 UNK5C64.2
SL17_VI100_13_A_HS: length 18.1
  BOTTOM w0.203: v2(151.65,208.24) 154.45,208.24 156.21,210 167.04,210 v1(168.42,208.62)
SL17_VI100_13_B_HF: length 0.4
  TOP w0.305: SITE5.32_F v2(147.8,210.39)
  vias: v1(147.43,224.11)
SL17_VI100_13_B_HS: length 9.9
  BOTTOM w0.203: v2(147.8,209.59) 147.8,209.86 147.33,210.33 147.33,211.45 148.59,212.71 148.59,215.84 147.43,217.01 v1(147.43,218.27)
SL17_VI100_14_A_HF: length 8.4
  TOP w0.305: 152.97,209.19 152.52,208.74 SITE5.23_F
  TOP w0.635: v1(159.27,211.67) 157.57,209.97 153.75,209.97 152.97,209.19
SL17_VI100_14_A_HS: length 14.9
  BOTTOM w0.203: v1(163.84,211.67) 162.85,212.67 157.43,212.67 157.12,212.36 157.12,211.23 156.59,210.7 156.27,210.7 154.31,208.74 v2(151.65,208.74)
SL17_VI100_14_B_HS: length 9.2
  BOTTOM w0.203: v1(154.07,198.18) 154.07,199.95 149.3,204.72 v2(149.3,205.39)
SL17_VI100_15_A_HF: length 10
  TOP w0.305: 152.28,209.81 152.05,209.58 SITE5.24_F
  TOP w0.635: 152.28,209.81 153.39,210.92 155.98,210.92 156.98,211.92 156.98,212.77 157.62,213.41 158.47,213.41 v1(159.27,214.21)
SL17_VI100_15_A_HS: length 17.3
  BOTTOM w0.203: v2(151.65,209.24) 154.18,209.24 156.08,211.15 156.46,211.15 156.72,211.4 156.72,215.08 156.97,215.34 162.72,215.34 v1(163.84,214.21)
SL17_VI100_15_B_HS: length 13.9
  BOTTOM w0.203: v1(151.91,193.35) 151.91,193.85 151.51,194.25 150.57,194.25 150.36,194.46 150.36,200.61 148.8,202.17 v2(148.8,205.39)
SL17_VI100_16_A_HF: length 0.4
  TOP w0.305: SITE5.28_F v2(149.8,210.39)
SL17_VI100_16_A_HS: length 4.1
  BOTTOM w0.152: 150.25,210.97 150.14,210.86 150.14,210.08 149.8,209.74 v2(149.8,209.59)
  BOTTOM w0.203: v1(152.25,212.18) 151.28,211.2 150.49,211.2 150.25,210.97
SL17_VI100_16_B_HS: length 7.8
  BOTTOM w0.203: v1(149.12,198.18) 149.12,200.08 147.8,201.39 v2(147.8,205.39)
SL17_VI100_18_A_HF: length 11.5
  TOP w0.305: SITE7.2_F 226.18,208.74
  TOP w0.635: v1(220.83,208.59) 220.98,208.74 226.18,208.74
  BOTTOM w0.635: UNK7C49.2 216.82,207.59 219.83,207.59 v1(220.83,208.59)
SL17_VI100_18_A_HS: length 7.8
  BOTTOM w0.203: v2(227.45,208.74) 224.92,208.74 221.97,205.79 v1(220.83,205.79)
SL17_VI100_18_B_HF: length 9.3
  TOP w0.305: 229.94,211.84 229.31,211.21 229.31,211.02 229.29,211 229.29,210.58 229.31,210.56 229.31,210.3 229.3,210.29 SITE7.29_F
  TOP w0.635: 229.94,211.84 231.49,213.39 231.49,217.25 v1(232.25,218.02)
SL17_VI100_18_B_HS: length 14.3
  BOTTOM w0.203: v2(229.3,209.59) 229.21,209.68 229.21,210.84 231.38,213.02 231.38,221.72 v1(232.25,222.59)
SL17_VI100_19_A_HF: length 16.3
  TOP w0.305: SITE7.5_F 225.45,207.24
  TOP w0.635: v1(220.83,201.22) 223.13,203.52 223.13,204.92 225.45,207.24
  BOTTOM w0.635: v1(215.11,201.22) 215.11,200.93 215.75,200.3 220.19,200.3 220.83,200.93 v1(220.83,201.22)
SL17_VI100_19_A_HS: length 13.4
  BOTTOM w0.203: v1(216.26,203.76) 217.13,202.89 222.62,202.89 226.97,207.24 v2(227.45,207.24)
SL17_VI100_19_B_HS: length 13
  BOTTOM w0.203: v1(229.12,193.35) 229.86,194.09 229.86,200.22 228.3,201.78 v2(228.3,205.39)
SL17_VI100_20_A_HS: length 8.3
  BOTTOM w0.203: v1(220.83,203.76) 221.84,203.76 225.82,207.74 v2(227.45,207.74)
SL17_VI100_20_B_HS: length 13.8
  BOTTOM w0.203: v2(231.65,205.74) 233.97,203.42 242.19,203.42 v1(243.84,201.77)
SL17_VI100_21_A_HF: length 23.1
  TOP w0.305: 226.18,206.45 226.47,206.74 SITE7.6_F
  TOP w0.635: 226.18,206.45 224.16,204.43 v1(224.16,198.18)
  BOTTOM w0.508: 224.38,193.35 UNK7K12.4
  BOTTOM w0.635: 225.18,193.35 225.18,188.1 224.45,187.38 224.21,187.38 ; 225.18,193.35 225.18,197.54 224.54,198.18 v1(224.16,198.18) ; 225.18,193.35 224.38,193.35
SL17_VI100_21_A_HS:
  vias: v2(227.45,206.74)
SL17_VI100_22_A_HF:
  vias: v2(227.05,206.24)
SL17_VI100_22_A_HS:
  vias: v1(226.96,193.35) v2(227.45,206.24)
SL17_VI100_22_B_HF: length 1.7
  TOP w0.305: SITE7.30_F v2(228.8,211.66)
SL17_VI100_22_B_HS: length 4.5
  BOTTOM w0.203: v2(228.8,209.59) 228.8,211.01 229.84,212.05 UNK7K46.4
SL17_VI100_23_A_HF:
  vias: v2(229.8,204.99)
SL17_VI100_23_A_HS:
  vias: v1(234.07,193.35) v2(229.8,205.39)
SL17_VI100_23_B_HF: length 10.4
  TOP w0.305: 228.07,211.04 228.29,210.82 228.29,210.3 228.3,210.29 SITE7.31_F
  TOP w0.635: v1(229.84,219.54) 229.08,218.78 229.08,213.58 228.07,212.57 228.07,211.04
SL17_VI100_23_B_HS: length 15.2
  BOTTOM w0.203: v1(229.84,224.11) 229.05,223.33 229.05,212.6 228.3,211.84 v2(228.3,209.59)
SL17_VI100_24_B_HF: length 5.7
  TOP w0.305: 235.04,206.93 234.73,207.24 SITE7.20_F
  TOP w0.635: v1(236.03,205.94) 235.04,206.93
  BOTTOM w0.635: v1(236.03,205.94) UNK7C61.2
SL17_VI100_24_B_HS: length 17.5
  BOTTOM w0.203: v1(248.42,205.58) 246.93,207.06 234.7,207.06 234.53,207.24 v2(231.65,207.24)
SL17_VI100_25_B_HF: length 7.6
  TOP w0.305: 234.28,207.99 234.03,207.74 SITE7.21_F
  TOP w0.635: v1(239.27,208.62) 238.64,207.99 234.28,207.99
SL17_VI100_25_B_HS: length 13.3
  BOTTOM w0.203: v1(243.84,208.62) 242.97,209.49 236.34,209.49 234.58,207.74 v2(231.65,207.74)
SL17_VI100_26_A_HF: length 9.6
  TOP w0.305: 231.98,204.74 231.55,204.74 SITE7.16_F
  TOP w0.635: 231.98,204.74 236.72,200.01 236.72,198.83 v1(237.37,198.18)
SL17_VI100_26_A_HS: length 15.2
  BOTTOM w0.203: v2(231.3,205.39) 231.3,205.13 235.83,200.6 235.83,194.51 236.08,194.25 237.17,194.25 237.37,194.05 v1(237.37,193.35)
SL17_VI100_26_B_HF: length 0.4
  TOP w0.305: SITE7.25_F v2(231.3,210.39)
SL17_VI100_26_B_HS: length 5.7
  BOTTOM w0.203: v2(231.3,209.59) 231.36,209.65 233.95,209.65 235.17,210.87 v1(235.17,212.18)
SL17_VI100_27_A_HF: length 7.2
  TOP w0.305: SITE7.18_F 233.05,206.24 233.62,205.67
  TOP w0.635: 233.62,205.67 236.62,202.67 v1(237.73,202.67)
SL17_VI100_27_A_HS: length 18.6
  BOTTOM w0.203: v2(231.65,206.24) 231.97,206.24 234.3,203.91 246.28,203.91 v1(248.42,201.77)
SL17_VI100_27_B_HF: length 0.4
  TOP w0.305: SITE7.26_F v2(230.8,210.39)
SL17_VI100_27_B_HS: length 10.5
  BOTTOM w0.203: v1(235.17,216.75) 234.43,216 234.43,210.7 233.88,210.16 231.7,210.16 231.57,210.03 231.16,210.03 230.8,209.67 v2(230.8,209.59)
SL17_VI100_28_A_HF: length 8.2
  TOP w0.305: SITE7.19_F 233.59,206.74 234.13,206.19 234.3,206.19
  TOP w0.635: v1(239.27,205.58) 238.62,204.92 235.57,204.92 234.3,206.19
SL17_VI100_28_A_HS: length 12.7
  BOTTOM w0.203: v2(231.65,206.74) 234.27,206.74 234.43,206.58 242.84,206.58 v1(243.84,205.58)
SL17_VI100_28_B_HF: length 1.1
  TOP w0.305: SITE7.27_F 230.3,210.49 230,210.79 v2(229.8,210.79)
SL17_VI100_28_B_HS: length 15.4
  BOTTOM w0.152: 230.71,210.8 230.44,210.53 230.44,209.73 v2(230.3,209.59)
  BOTTOM w0.203: 230.71,210.8 233.5,210.8 234.03,211.32 234.03,216.17 234.05,216.2 234.05,220.2 v1(235.17,221.32)
SL17_VI100_29_A_HF: length 8.4
  TOP w0.305: 233.66,208.65 233.26,208.25 232.44,208.25 232.44,208.24 SITE7.22_F
  TOP w0.635: v1(237.73,208.86) 237.62,208.98 233.99,208.98 233.66,208.65
  BOTTOM w0.635: UNK7C64.2 236.03,208.22 236.67,208.86 v1(237.73,208.86)
SL17_VI100_29_A_HS: length 18.1
  BOTTOM w0.203: v2(231.65,208.24) 234.45,208.24 236.21,210 247.04,210 v1(248.42,208.62)
SL17_VI100_29_B_HF: length 0.4
  TOP w0.305: SITE7.32_F v2(227.8,210.39)
  vias: v1(227.43,224.11)
SL17_VI100_29_B_HS: length 9.9
  BOTTOM w0.203: v2(227.8,209.59) 227.8,209.86 227.33,210.33 227.33,211.45 228.59,212.71 228.59,215.84 227.43,217.01 v1(227.43,218.27)
SL17_VI100_30_A_HF: length 8.4
  TOP w0.305: 232.97,209.19 232.52,208.74 SITE7.23_F
  TOP w0.635: v1(239.27,211.67) 237.57,209.97 233.75,209.97 232.97,209.19
SL17_VI100_30_A_HS: length 14.9
  BOTTOM w0.203: v2(231.65,208.74) 234.31,208.74 236.27,210.7 236.59,210.7 237.12,211.23 237.12,212.36 237.43,212.67 242.85,212.67 v1(243.84,211.67)
SL17_VI100_30_B_HS: length 9.2
  BOTTOM w0.203: v1(234.07,198.18) 234.07,199.95 229.3,204.72 v2(229.3,205.39)
SL17_VI100_31_A_HF: length 10
  TOP w0.305: SITE7.24_F 232.05,209.58 232.28,209.81
  TOP w0.635: 232.28,209.81 233.39,210.92 235.98,210.92 236.98,211.92 236.98,212.77 237.62,213.41 238.47,213.41 v1(239.27,214.21)
SL17_VI100_31_A_HS: length 17.3
  BOTTOM w0.203: v1(243.84,214.21) 242.72,215.34 236.97,215.34 236.72,215.08 236.72,211.4 236.46,211.15 236.08,211.15 234.18,209.24 v2(231.65,209.24)
SL17_VI100_31_B_HS: length 13.9
  BOTTOM w0.203: v2(228.8,205.39) 228.8,202.17 230.36,200.61 230.36,194.46 230.57,194.25 231.51,194.25 231.91,193.85 v1(231.91,193.35)
SL17_VI100_32_A_HF: length 0.4
  TOP w0.305: SITE7.28_F v2(229.8,210.39)
SL17_VI100_32_A_HS: length 4.1
  BOTTOM w0.152: 230.25,210.97 230.14,210.86 230.14,210.08 229.8,209.74 v2(229.8,209.59)
  BOTTOM w0.203: v1(232.25,212.18) 231.28,211.2 230.49,211.2 230.25,210.97
SL17_VI100_32_B_HS: length 7.8
  BOTTOM w0.203: v1(229.12,198.18) 229.12,200.08 227.8,201.39 v2(227.8,205.39)
SL18_VI100_2_A_HF: length 11.5
  TOP w0.305: SITE6.2_F 186.18,208.74
  TOP w0.635: 186.18,208.74 180.98,208.74 v1(180.83,208.59)
  BOTTOM w0.635: v1(180.83,208.59) 179.83,207.59 176.82,207.59 UNK6C49.2
SL18_VI100_2_A_HS: length 7.8
  BOTTOM w0.203: v1(180.83,205.79) 181.97,205.79 184.92,208.74 v2(187.45,208.74)
SL18_VI100_2_B_HF: length 9.3
  TOP w0.305: 189.94,211.84 189.31,211.21 189.31,211.02 189.29,211 189.29,210.58 189.31,210.56 189.31,210.3 189.3,210.29 SITE6.29_F
  TOP w0.635: 189.94,211.84 191.49,213.39 191.49,217.25 v1(192.25,218.02)
SL18_VI100_2_B_HS: length 14.3
  BOTTOM w0.203: v1(192.25,222.59) 191.38,221.72 191.38,213.02 189.21,210.84 189.21,209.68 v2(189.3,209.59)
SL18_VI100_3_A_HF: length 16.3
  TOP w0.305: SITE6.5_F 185.45,207.24
  TOP w0.635: v1(180.83,201.22) 183.13,203.52 183.13,204.92 185.45,207.24
  BOTTOM w0.635: v1(175.11,201.22) 175.11,200.93 175.75,200.3 180.19,200.3 180.83,200.93 v1(180.83,201.22)
SL18_VI100_3_A_HS: length 13.4
  BOTTOM w0.203: v2(187.45,207.24) 186.97,207.24 182.62,202.89 177.13,202.89 v1(176.26,203.76)
SL18_VI100_3_B_HS: length 13
  BOTTOM w0.203: v2(188.3,205.39) 188.3,201.78 189.86,200.22 189.86,194.09 v1(189.12,193.35)
SL18_VI100_4_A_HS: length 8.3
  BOTTOM w0.203: v1(180.83,203.76) 181.84,203.76 185.82,207.74 v2(187.45,207.74)
SL18_VI100_4_B_HS: length 13.8
  BOTTOM w0.203: v2(191.65,205.74) 193.97,203.42 202.19,203.42 v1(203.84,201.77)
SL18_VI100_5_A_HF: length 23.1
  TOP w0.305: SITE6.6_F 186.47,206.74 186.18,206.45
  TOP w0.635: 186.18,206.45 184.16,204.43 v1(184.16,198.18)
  BOTTOM w0.508: 184.38,193.35 UNK6K12.4
  BOTTOM w0.635: 185.18,193.35 185.18,188.1 184.45,187.38 184.21,187.38 ; 185.18,193.35 185.18,197.54 184.54,198.18 v1(184.16,198.18) ; 185.18,193.35 184.38,193.35
SL18_VI100_5_A_HS:
  vias: v2(187.45,206.74)
SL18_VI100_6_A_HF:
  vias: v2(187.05,206.24)
SL18_VI100_6_A_HS:
  vias: v1(186.96,193.35) v2(187.45,206.24)
SL18_VI100_6_B_HF: length 1.7
  TOP w0.305: SITE6.30_F v2(188.8,211.66)
SL18_VI100_6_B_HS: length 4.5
  BOTTOM w0.203: v2(188.8,209.59) 188.8,211.01 189.84,212.05 UNK6K46.4
SL18_VI100_7_A_HF:
  vias: v2(189.8,204.99)
SL18_VI100_7_A_HS:
  vias: v1(194.07,193.35) v2(189.8,205.39)
SL18_VI100_7_B_HF: length 10.4
  TOP w0.305: 188.07,211.04 188.29,210.82 188.29,210.3 188.3,210.29 SITE6.31_F
  TOP w0.635: v1(189.84,219.54) 189.08,218.78 189.08,213.58 188.07,212.57 188.07,211.04
SL18_VI100_7_B_HS: length 15.2
  BOTTOM w0.203: v1(189.84,224.11) 189.05,223.33 189.05,212.6 188.3,211.84 v2(188.3,209.59)
SL18_VI100_8_B_HF: length 5.7
  TOP w0.305: SITE6.20_F 194.73,207.24 195.04,206.93
  TOP w0.635: v1(196.03,205.94) 195.04,206.93
  BOTTOM w0.635: v1(196.03,205.94) UNK6C61.2
SL18_VI100_8_B_HS: length 17.5
  BOTTOM w0.203: v2(191.65,207.24) 194.53,207.24 194.7,207.06 206.93,207.06 v1(208.42,205.58)
SL18_VI100_9_B_HF: length 7.6
  TOP w0.305: 194.28,207.99 194.03,207.74 SITE6.21_F
  TOP w0.635: v1(199.27,208.62) 198.64,207.99 194.28,207.99
SL18_VI100_9_B_HS: length 13.3
  BOTTOM w0.203: v2(191.65,207.74) 194.58,207.74 196.34,209.49 202.97,209.49 v1(203.84,208.62)
SL18_VI100_10_A_HF: length 9.6
  TOP w0.305: 191.98,204.74 191.55,204.74 SITE6.16_F
  TOP w0.635: 191.98,204.74 196.72,200.01 196.72,198.83 v1(197.37,198.18)
SL18_VI100_10_A_HS: length 15.2
  BOTTOM w0.203: v2(191.3,205.39) 191.3,205.13 195.83,200.6 195.83,194.51 196.08,194.25 197.17,194.25 197.37,194.05 v1(197.37,193.35)
SL18_VI100_10_B_HF: length 0.4
  TOP w0.305: SITE6.25_F v2(191.3,210.39)
SL18_VI100_10_B_HS: length 5.7
  BOTTOM w0.203: v1(195.17,212.18) 195.17,210.87 193.95,209.65 191.36,209.65 v2(191.3,209.59)
SL18_VI100_11_A_HF: length 7.2
  TOP w0.305: 193.62,205.67 193.05,206.24 SITE6.18_F
  TOP w0.635: v1(197.73,202.67) 196.62,202.67 193.62,205.67
SL18_VI100_11_A_HS: length 18.6
  BOTTOM w0.203: v1(208.42,201.77) 206.28,203.91 194.3,203.91 191.97,206.24 v2(191.65,206.24)
SL18_VI100_11_B_HF: length 0.4
  TOP w0.305: SITE6.26_F v2(190.8,210.39)
SL18_VI100_11_B_HS: length 10.5
  BOTTOM w0.203: v2(190.8,209.59) 190.8,209.67 191.16,210.03 191.57,210.03 191.7,210.16 193.88,210.16 194.43,210.7 194.43,216 v1(195.17,216.75)
SL18_VI100_12_A_HF: length 8.2
  TOP w0.305: SITE6.19_F 193.59,206.74 194.13,206.19 194.3,206.19
  TOP w0.635: v1(199.27,205.58) 198.62,204.92 195.57,204.92 194.3,206.19
SL18_VI100_12_A_HS: length 12.7
  BOTTOM w0.203: v1(203.84,205.58) 202.84,206.58 194.43,206.58 194.27,206.74 v2(191.65,206.74)
SL18_VI100_12_B_HF: length 1.1
  TOP w0.305: v2(189.8,210.79) 190,210.79 190.3,210.49 SITE6.27_F
SL18_VI100_12_B_HS: length 15.4
  BOTTOM w0.152: 190.71,210.8 190.44,210.53 190.44,209.73 v2(190.3,209.59)
  BOTTOM w0.203: v1(195.17,221.32) 194.05,220.2 194.05,216.2 194.03,216.17 194.03,211.32 193.5,210.8 190.71,210.8
SL18_VI100_13_A_HF: length 8.4
  TOP w0.305: 193.66,208.65 193.26,208.25 192.44,208.25 192.44,208.24 SITE6.22_F
  TOP w0.635: 193.66,208.65 193.99,208.98 197.62,208.98 v1(197.73,208.86)
  BOTTOM w0.635: UNK6C64.2 196.03,208.22 196.67,208.86 v1(197.73,208.86)
SL18_VI100_13_A_HS: length 18.1
  BOTTOM w0.203: v1(208.42,208.62) 207.04,210 196.21,210 194.45,208.24 v2(191.65,208.24)
SL18_VI100_13_B_HF: length 0.4
  TOP w0.305: SITE6.32_F v2(187.8,210.39)
  vias: v1(187.43,224.11)
SL18_VI100_13_B_HS: length 9.9
  BOTTOM w0.203: v1(187.43,218.27) 187.43,217.01 188.59,215.84 188.59,212.71 187.33,211.45 187.33,210.33 187.8,209.86 v2(187.8,209.59)
SL18_VI100_14_A_HF: length 8.4
  TOP w0.305: SITE6.23_F 192.52,208.74 192.97,209.19
  TOP w0.635: 192.97,209.19 193.75,209.97 197.57,209.97 v1(199.27,211.67)
SL18_VI100_14_A_HS: length 14.9
  BOTTOM w0.203: v1(203.84,211.67) 202.85,212.67 197.43,212.67 197.12,212.36 197.12,211.23 196.59,210.7 196.27,210.7 194.31,208.74 v2(191.65,208.74)
SL18_VI100_14_B_HS: length 9.2
  BOTTOM w0.203: v2(189.3,205.39) 189.3,204.72 194.07,199.95 v1(194.07,198.18)
SL18_VI100_15_A_HF: length 10
  TOP w0.305: SITE6.24_F 192.05,209.58 192.28,209.81
  TOP w0.635: 192.28,209.81 193.39,210.92 195.98,210.92 196.98,211.92 196.98,212.77 197.62,213.41 198.47,213.41 v1(199.27,214.21)
SL18_VI100_15_A_HS: length 17.3
  BOTTOM w0.203: v1(203.84,214.21) 202.72,215.34 196.97,215.34 196.72,215.08 196.72,211.4 196.46,211.15 196.08,211.15 194.18,209.24 v2(191.65,209.24)
SL18_VI100_15_B_HS: length 13.9
  BOTTOM w0.203: v1(191.91,193.35) 191.91,193.85 191.51,194.25 190.57,194.25 190.36,194.46 190.36,200.61 188.8,202.17 v2(188.8,205.39)
SL18_VI100_16_A_HF: length 0.4
  TOP w0.305: SITE6.28_F v2(189.8,210.39)
SL18_VI100_16_A_HS: length 4.1
  BOTTOM w0.152: v2(189.8,209.59) 189.8,209.74 190.14,210.08 190.14,210.86 190.25,210.97
  BOTTOM w0.203: 190.25,210.97 190.49,211.2 191.28,211.2 v1(192.25,212.18)
SL18_VI100_16_B_HS: length 7.8
  BOTTOM w0.203: v1(189.12,198.18) 189.12,200.08 187.8,201.39 v2(187.8,205.39)
SL18_VI100_18_A_HF: length 11.5
  TOP w0.305: SITE8.2_F 266.18,208.74
  TOP w0.635: v1(260.83,208.59) 260.98,208.74 266.18,208.74
  BOTTOM w0.635: v1(260.83,208.59) 259.83,207.59 256.82,207.59 UNK8C49.2
SL18_VI100_18_A_HS: length 7.8
  BOTTOM w0.203: v2(267.45,208.74) 264.92,208.74 261.97,205.79 v1(260.83,205.79)
SL18_VI100_18_B_HF: length 9.3
  TOP w0.305: 269.94,211.84 269.31,211.21 269.31,211.02 269.29,211 269.29,210.58 269.31,210.56 269.31,210.3 269.3,210.29 SITE8.29_F
  TOP w0.635: 269.94,211.84 271.49,213.39 271.49,217.25 v1(272.25,218.02)
SL18_VI100_18_B_HS: length 14.3
  BOTTOM w0.203: v1(272.25,222.59) 271.38,221.72 271.38,213.02 269.21,210.84 269.21,209.68 v2(269.3,209.59)
SL18_VI100_19_A_HF: length 16.3
  TOP w0.305: SITE8.5_F 265.45,207.24
  TOP w0.635: 265.45,207.24 263.13,204.92 263.13,203.52 v1(260.83,201.22)
  BOTTOM w0.635: v1(255.11,201.22) 255.11,200.93 255.75,200.3 260.19,200.3 260.83,200.93 v1(260.83,201.22)
SL18_VI100_19_A_HS: length 13.4
  BOTTOM w0.203: v2(267.45,207.24) 266.97,207.24 262.62,202.89 257.13,202.89 v1(256.26,203.76)
SL18_VI100_19_B_HS: length 13
  BOTTOM w0.203: v1(269.12,193.35) 269.86,194.09 269.86,200.22 268.3,201.78 v2(268.3,205.39)
SL18_VI100_20_A_HS: length 8.3
  BOTTOM w0.203: v1(260.83,203.76) 261.84,203.76 265.82,207.74 v2(267.45,207.74)
SL18_VI100_20_B_HS: length 13.8
  BOTTOM w0.203: v2(271.65,205.74) 273.97,203.42 282.19,203.42 v1(283.84,201.77)
SL18_VI100_21_A_HF: length 23.1
  TOP w0.305: SITE8.6_F 266.47,206.74 266.18,206.45
  TOP w0.635: v1(264.16,198.18) 264.16,204.43 266.18,206.45
  BOTTOM w0.508: 264.38,193.35 UNK8K12.4
  BOTTOM w0.635: 265.17,193.35 265.17,188.1 264.45,187.38 264.21,187.38 ; 265.17,193.35 265.17,197.54 264.54,198.18 v1(264.16,198.18) ; 265.17,193.35 264.38,193.35
SL18_VI100_21_A_HS:
  vias: v2(267.45,206.74)
SL18_VI100_22_A_HF:
  vias: v2(267.05,206.24)
SL18_VI100_22_A_HS:
  vias: v1(266.96,193.35) v2(267.45,206.24)
SL18_VI100_22_B_HF: length 1.7
  TOP w0.305: SITE8.30_F v2(268.8,211.66)
SL18_VI100_22_B_HS: length 4.5
  BOTTOM w0.203: UNK8K46.4 269.84,212.05 268.8,211.01 v2(268.8,209.59)
SL18_VI100_23_A_HF:
  vias: v2(269.8,204.99)
SL18_VI100_23_A_HS:
  vias: v1(274.07,193.35) v2(269.8,205.39)
SL18_VI100_23_B_HF: length 10.4
  TOP w0.305: 268.07,211.04 268.29,210.82 268.29,210.3 268.3,210.29 SITE8.31_F
  TOP w0.635: 268.07,211.04 268.07,212.57 269.08,213.58 269.08,218.78 v1(269.84,219.54)
SL18_VI100_23_B_HS: length 15.2
  BOTTOM w0.203: v1(269.84,224.11) 269.05,223.33 269.05,212.6 268.3,211.84 v2(268.3,209.59)
SL18_VI100_24_B_HF: length 5.7
  TOP w0.305: 275.04,206.93 274.73,207.24 SITE8.20_F
  TOP w0.635: v1(276.03,205.94) 275.04,206.93
  BOTTOM w0.635: v1(276.03,205.94) UNK8C61.2
SL18_VI100_24_B_HS: length 17.5
  BOTTOM w0.203: v1(288.42,205.58) 286.93,207.06 274.7,207.06 274.53,207.24 v2(271.65,207.24)
SL18_VI100_25_B_HF: length 7.6
  TOP w0.305: SITE8.21_F 274.03,207.74 274.28,207.99
  TOP w0.635: v1(279.27,208.62) 278.64,207.99 274.28,207.99
SL18_VI100_25_B_HS: length 13.3
  BOTTOM w0.203: v1(283.84,208.62) 282.97,209.49 276.34,209.49 274.58,207.74 v2(271.65,207.74)
SL18_VI100_26_A_HF: length 9.6
  TOP w0.305: 271.98,204.74 271.55,204.74 SITE8.16_F
  TOP w0.635: 271.98,204.74 276.72,200.01 276.72,198.83 v1(277.37,198.18)
SL18_VI100_26_A_HS: length 15.2
  BOTTOM w0.203: v2(271.3,205.39) 271.3,205.13 275.83,200.6 275.83,194.51 276.08,194.25 277.17,194.25 277.37,194.05 v1(277.37,193.35)
SL18_VI100_26_B_HF: length 0.4
  TOP w0.305: SITE8.25_F v2(271.3,210.39)
SL18_VI100_26_B_HS: length 5.7
  BOTTOM w0.203: v1(275.17,212.18) 275.17,210.87 273.95,209.65 271.36,209.65 v2(271.3,209.59)
SL18_VI100_27_A_HF: length 7.2
  TOP w0.305: SITE8.18_F 273.05,206.24 273.62,205.67
  TOP w0.635: v1(277.73,202.67) 276.62,202.67 273.62,205.67
SL18_VI100_27_A_HS: length 18.6
  BOTTOM w0.203: v1(288.42,201.77) 286.28,203.91 274.3,203.91 271.97,206.24 v2(271.65,206.24)
SL18_VI100_27_B_HF: length 0.4
  TOP w0.305: SITE8.26_F v2(270.8,210.39)
SL18_VI100_27_B_HS: length 10.5
  BOTTOM w0.203: v2(270.8,209.59) 270.8,209.67 271.16,210.03 271.57,210.03 271.7,210.16 273.88,210.16 274.43,210.7 274.43,216 v1(275.17,216.75)
SL18_VI100_28_A_HF: length 8.2
  TOP w0.305: SITE8.19_F 273.59,206.74 274.13,206.19 274.3,206.19
  TOP w0.635: v1(279.27,205.58) 278.62,204.92 275.57,204.92 274.3,206.19
SL18_VI100_28_A_HS: length 12.7
  BOTTOM w0.203: v1(283.84,205.58) 282.84,206.58 274.43,206.58 274.27,206.74 v2(271.65,206.74)
SL18_VI100_28_B_HF: length 1.1
  TOP w0.305: v2(269.8,210.79) 270,210.79 270.3,210.49 SITE8.27_F
SL18_VI100_28_B_HS: length 15.4
  BOTTOM w0.152: 270.71,210.8 270.44,210.53 270.44,209.73 v2(270.3,209.59)
  BOTTOM w0.203: 270.71,210.8 273.5,210.8 274.03,211.32 274.03,216.17 274.05,216.2 274.05,220.2 v1(275.17,221.32)
SL18_VI100_29_A_HF: length 8.4
  TOP w0.305: SITE8.22_F 272.44,208.24 272.44,208.25 273.26,208.25 273.66,208.65
  TOP w0.635: 273.66,208.65 273.99,208.98 277.62,208.98 v1(277.73,208.86)
  BOTTOM w0.635: v1(277.73,208.86) 276.67,208.86 276.03,208.22 UNK8C64.2
SL18_VI100_29_A_HS: length 18.1
  BOTTOM w0.203: v1(288.42,208.62) 287.04,210 276.21,210 274.45,208.24 v2(271.65,208.24)
SL18_VI100_29_B_HF: length 0.4
  TOP w0.305: SITE8.32_F v2(267.8,210.39)
  vias: v1(267.43,224.11)
SL18_VI100_29_B_HS: length 9.9
  BOTTOM w0.203: v2(267.8,209.59) 267.8,209.86 267.33,210.33 267.33,211.45 268.59,212.71 268.59,215.84 267.43,217.01 v1(267.43,218.27)
SL18_VI100_30_A_HF: length 8.4
  TOP w0.305: 272.97,209.19 272.52,208.74 SITE8.23_F
  TOP w0.635: 272.97,209.19 273.75,209.97 277.57,209.97 v1(279.27,211.67)
SL18_VI100_30_A_HS: length 14.9
  BOTTOM w0.203: v2(271.65,208.74) 274.31,208.74 276.27,210.7 276.59,210.7 277.12,211.23 277.12,212.36 277.43,212.67 282.85,212.67 v1(283.84,211.67)
SL18_VI100_30_B_HS: length 9.2
  BOTTOM w0.203: v2(269.3,205.39) 269.3,204.72 274.07,199.95 v1(274.07,198.18)
SL18_VI100_31_A_HF: length 10
  TOP w0.305: SITE8.24_F 272.05,209.58 272.28,209.81
  TOP w0.635: v1(279.27,214.21) 278.47,213.41 277.62,213.41 276.98,212.77 276.98,211.92 275.98,210.92 273.39,210.92 272.28,209.81
SL18_VI100_31_A_HS: length 17.3
  BOTTOM w0.203: v1(283.84,214.21) 282.72,215.34 276.97,215.34 276.72,215.08 276.72,211.4 276.46,211.15 276.08,211.15 274.18,209.24 v2(271.65,209.24)
SL18_VI100_31_B_HS: length 13.9
  BOTTOM w0.203: v2(268.8,205.39) 268.8,202.17 270.36,200.61 270.36,194.46 270.57,194.25 271.51,194.25 271.91,193.85 v1(271.91,193.35)
SL18_VI100_32_A_HF: length 0.4
  TOP w0.305: SITE8.28_F v2(269.8,210.39)
SL18_VI100_32_A_HS: length 4.1
  BOTTOM w0.152: 270.25,210.97 270.14,210.86 270.14,210.08 269.8,209.74 v2(269.8,209.59)
  BOTTOM w0.203: 270.25,210.97 270.49,211.2 271.28,211.2 v1(272.25,212.18)
SL18_VI100_32_B_HS: length 7.8
  BOTTOM w0.203: v2(267.8,205.39) 267.8,201.39 269.12,200.08 v1(269.12,198.18)
N17260776: length 2.2
  BOTTOM w0.635: C48.1 K2.3
N17261204: length 6.9
  BOTTOM w0.635: C49.1 136.27,273.81 136.91,274.45 K3.3
N17261720: length 1.5
  BOTTOM w0.508: C50.1 K5.3
N17263068: length 1.5
  BOTTOM w0.203: RK7.1 137.77,263.76 K7.1
N17264482: length 1.5
  BOTTOM w0.203: C53.1 142.14,262.02 K8.3
N17264547: length 1.5
  BOTTOM w0.203: K9.3 136.42,262.02 C54.1
N17266096: length 6.9
  BOTTOM w0.508: 142.67,253.35 K12.3
  BOTTOM w0.635: 142.67,253.35 142.22,252.9 142.22,250.8 140.59,249.17 C59.1
N17266582: length 1.5
  BOTTOM w0.203: R1.1 143.36,248.69 K13.3
N17267238: length 25.6
  BOTTOM w0.203: v2(147.45,265.74) 143.32,261.61 143.32,260.79 141.35,258.83 141.35,251.59 138.34,248.58 138.34,246.04 K15.6
N17270245: length 1.5
  BOTTOM w0.203: C69.1 K19.3
N17493363: length 1.5
  BOTTOM w0.203: RK5.1 137.77,268.59 K5.1
N17493593: length 1.5
  BOTTOM w0.203: K6.1 137.77,265.79 RK6.1
N17493900: length 1.5
  BOTTOM w0.203: K8.1 137.77,261.22 RK8.1
N17494047: length 1.5
  BOTTOM w0.203: RK9.1 132.05,261.22 K9.1
N17494316: length 1.5
  BOTTOM w0.203: RK10.1 133.2,263.76 K10.1
N17494507: length 1.5
  BOTTOM w0.203: RK11.1 144.16,255.12 K11.1
N17494587: length 1.3
  BOTTOM w0.508: C58.1 K11.3
N17494912: length 1.5
  BOTTOM w0.203: RK12.1 144.16,250.29 K12.1
N17495143: length 1.5
  BOTTOM w0.203: RK13.1 144.16,244.32 K13.1
N17495451: length 1.5
  BOTTOM w0.203: RK14.1 146.96,250.29 K14.1
N17495920: length 1.5
  BOTTOM w0.203: RK19.1 151.91,255.12 K19.1
N17496065: length 1.5
  BOTTOM w0.203: RK20.1 151.91,250.29 K20.1
N17496168: length 1.5
  BOTTOM w0.203: RK21.1 154.07,255.12 K21.1
N17508143: length 3.4
  BOTTOM w0.203: K2.1 142.88,283.32 142.47,283.73 RK2.1
N17508406: length 1.9
  BOTTOM w0.203: K3.1 RK3.1
N17508530: length 2.4
  BOTTOM w0.203: RK4.1 142.04,296.93 142.88,296.1 K4.1
N17654577: length 1.3
  BOTTOM w0.203: R7.2 148.32,244.45 K51.4
N17654648: length 1.3
  BOTTOM w0.203: K53.4 156.57,244.45 R8.2
N17654652: length 1.5
  BOTTOM w0.203: K53.1 156.57,248.69 RK53.1
N17654805: length 2.3
  BOTTOM w0.203: v1(126.61,294.24) R11.2 R19.1
N17654898: length 2.3
  BOTTOM w0.203: R20.1 R14.2 v1(133.22,294.24)
N17655019: length 1.5
  BOTTOM w0.203: K55.1 121.26,291.95 RK59.1
N17655025: length 1.3
  BOTTOM w0.508: R19.2 K55.4
N17655029: length 3
  BOTTOM w0.305: RK60.1 123.92,287.4
N17655138: length 3.4
  BOTTOM w0.203: TP_IN-_3.1 158.52,232.74 158.31,232.54 R16.1 157.41,231.32 U3.8
N17655140: length 3.4
  BOTTOM w0.203: TP_IN+_3.1 155.68,232.74 155.89,232.54 R16.2 156.81,231.32 U3.7
N17655324: length 3.4
  BOTTOM w0.203: U4.7 151.73,231.32 R18.2 150.81,232.54 150.6,232.74 TP_IN+_4.1
N17655339: length 3.4
  BOTTOM w0.203: TP_IN-_4.1 153.44,232.74 153.23,232.54 R18.1 152.33,231.32 U4.8
N17655440: length 7.5
  BOTTOM w0.508: R20.2 K61.4 130.92,287.91 131.43,287.4 132.87,287.4
N17655462: length 1.5
  BOTTOM w0.203: RK54.1 157.37,238.99 K54.1
N17655480: length 1.5
  BOTTOM w0.203: RK51.1 148.32,248.69 K51.1
N17655494: length 1.5
  BOTTOM w0.203: RK52.1 149.12,238.99 K52.1
N17702527: length 27.9
  TOP w0.305: SITE1.8_F 146.71,265.4
  TOP w0.635: 146.71,265.4 145.16,263.85 145.16,255.65 137.92,248.41 135.89,248.41 135.29,247.82 135.29,246.19 K15.3
N18407736: length 1.5
  BOTTOM w0.203: C60.1 K16.3
N18407764: length 1.5
  BOTTOM w0.203: K17.1 149.12,255.12 RK17.1
N18407893: length 1.5
  BOTTOM w0.203: RK16.1 146.96,255.12 K16.1
N18407930: length 1.5
  BOTTOM w0.203: RK18.1 149.12,250.29 K18.1
N18409262: length 1.5
  BOTTOM w0.203: K22.1 154.07,250.29 RK22.1
N18420672: length 24.1
  BOTTOM w0.203: 154.38,244.3 153.24,245.44 153.24,247.49 154.81,249.07 154.81,259.97 150.3,264.48 v2(150.3,265.39)
N18420953: length 28.6
  BOTTOM w0.203: 162.64,244.3 161.15,245.78 161.15,248.53 160.21,249.48 155.8,249.48 155.32,249.96 155.32,260.22 150.8,264.74 v2(150.8,265.39)
N18432405: length 1.5
  BOTTOM w0.203: C62.1 K25.3
N18432504: length 1.5
  BOTTOM w0.203: RK25.1 157.37,255.12 K25.1
N18432522: length 1.5
  BOTTOM w0.203: RK26.1 157.37,250.29 K26.1
N18432973: length 1.5
  BOTTOM w0.203: C63.1 K27.3
N18433005: length 1.5
  BOTTOM w0.203: K28.1 166.9,261.77 RK28.1
N18433172: length 1.5
  BOTTOM w0.203: RK27.1 162.33,261.77 K27.1
N18433200: length 1.1
  BOTTOM w0.203: RK29.1 K29.1
N18433570: length 1.5
  BOTTOM w0.203: C61.1 K30.3
N18433598: length 1.5
  BOTTOM w0.203: K31.1 166.9,265.58 RK31.1
N18433748: length 1.5
  BOTTOM w0.203: RK30.1 162.33,265.58 K30.1
N18433778: length 1.1
  BOTTOM w0.203: RK32.1 K32.1
N18434722: length 1.5
  BOTTOM w0.203: RK39.1 166.9,274.21 K39.1
N18434762: length 1.5
  BOTTOM w0.203: K38.1 162.33,274.21 RK38.1
N18434888: length 1.5
  BOTTOM w0.203: C74.1 K38.3
N18465960: length 1.5
  BOTTOM w0.203: K35.1 171.48,268.62 RK35.1
N18465976: length 1.5
  BOTTOM w0.203: K34.1 166.9,268.62 RK34.1
N18465984: length 1.5
  BOTTOM w0.203: RK33.1 162.33,268.62 K33.1
N18466028: length 1.5
  BOTTOM w0.203: C64.1 K33.3
N18511830: length 1.5
  BOTTOM w0.203: RK37.1 166.9,271.67 K37.1
N18511832: length 1.5
  BOTTOM w0.203: RK36.1 162.33,271.67 K36.1
N18511862: length 1.5
  BOTTOM w0.203: C65.1 K36.3
N18556624: length 1.5
  BOTTOM w0.203: RK40.1 155.17,275.24 K40.1
N18556932: length 1.5
  BOTTOM w0.203: K41.1 155.17,279.81 RK41.1
N18557107: length 1.5
  BOTTOM w0.203: K42.1 155.17,284.38 RK42.1
N18557324: length 1.5
  BOTTOM w0.203: RK43.1 152.25,275.24 K43.1
N18568668: length 1.5
  BOTTOM w0.203: K45.1 152.25,285.65 RK45.1
N18568680: length 1.5
  BOTTOM w0.203: RK44.1 152.25,281.08 K44.1
N18568712: length 1.5
  BOTTOM w0.203: K44.3 153.05,276.71 C66.1
N18580009: length 1.5
  BOTTOM w0.203: RK46.1 149.84,276.76 K46.1
N18580265: length 1.5
  BOTTOM w0.203: C67.1 150.64,278.23 K47.3
N18580347: length 1.5
  BOTTOM w0.203: K48.1 149.84,287.17 RK48.1
N18580359: length 1.5
  BOTTOM w0.203: K47.1 149.84,282.6 RK47.1
N18580906: length 1.5
  BOTTOM w0.203: K49.3 148.23,282.8 C68.1
N18580988: length 1.5
  BOTTOM w0.203: K50.1 147.43,281.33 RK50.1
N18581000: length 1.5
  BOTTOM w0.203: K49.1 147.43,287.17 RK49.1
N18705535: length 1.5
  BOTTOM w0.203: 157.61,236.86 157.71,236.75 K57.1
N18705626: length 1.5
  BOTTOM w0.203: K58.1 155.68,236.75 155.58,236.86
N18705736: length 1.5
  BOTTOM w0.203: 152.53,236.86 152.63,236.75 K59.1
N18705861: length 1.5
  BOTTOM w0.203: K60.1 150.6,236.75 150.5,236.86
N18706153: length 1.5
  BOTTOM w0.203: RK61.1 127.86,291.95 K61.1
N18706312: length 2.2
  BOTTOM w0.635: UNK2C48.1 UNK2K2.3
N18706321: length 6.9
  BOTTOM w0.635: UNK2C49.1 176.27,273.81 176.91,274.45 UNK2K3.3
N18706330: length 1.5
  BOTTOM w0.508: UNK2C50.1 UNK2K5.3
N18706363: length 1.5
  BOTTOM w0.203: UNK2K7.1 177.77,263.76 UNK2RK7.1
N18706370: length 1.5
  BOTTOM w0.203: UNK2K8.3 182.14,262.02 UNK2C53.1
N18706379: length 1.5
  BOTTOM w0.203: UNK2K9.3 176.42,262.02 UNK2C54.1
N18706409: length 6.9
  BOTTOM w0.508: 182.67,253.35 UNK2K12.3
  BOTTOM w0.635: UNK2C59.1 180.59,249.17 182.22,250.8 182.22,252.9 182.67,253.35
N18706416: length 1.5
  BOTTOM w0.203: UNK2R1.1 183.36,248.69 UNK2K13.3
N18706434: length 25.6
  BOTTOM w0.203: v2(187.45,265.74) 183.32,261.61 183.32,260.79 181.35,258.83 181.35,251.59 178.34,248.58 178.34,246.04 UNK2K15.6
N18706452: length 1.5
  BOTTOM w0.203: UNK2K5.1 177.77,268.59 UNK2RK5.1
N18706454: length 1.5
  BOTTOM w0.203: UNK2K6.1 177.77,265.79 UNK2RK6.1
N18706456: length 1.5
  BOTTOM w0.203: UNK2K8.1 177.77,261.22 UNK2RK8.1
N18706457: length 1.5
  BOTTOM w0.203: UNK2RK9.1 172.05,261.22 UNK2K9.1
N18706458: length 1.5
  BOTTOM w0.203: UNK2K10.1 173.2,263.76 UNK2RK10.1
N18706459: length 1.5
  BOTTOM w0.203: UNK2K11.1 184.16,255.12 UNK2RK11.1
N18706462: length 1.3
  BOTTOM w0.508: UNK2C58.1 UNK2K11.3
N18706465: length 1.5
  BOTTOM w0.203: UNK2K12.1 184.16,250.29 UNK2RK12.1
N18706467: length 1.5
  BOTTOM w0.203: UNK2RK13.1 184.16,244.32 UNK2K13.1
N18706470: length 1.5
  BOTTOM w0.203: UNK2RK14.1 186.96,250.29 UNK2K14.1
N18706472: length 3.4
  BOTTOM w0.203: UNK2RK2.1 182.47,283.73 182.87,283.32 UNK2K2.1
N18706473: length 1.9
  BOTTOM w0.203: UNK2K3.1 UNK2RK3.1
N18706474: length 2.4
  BOTTOM w0.203: UNK2RK4.1 182.04,296.93 182.87,296.1 UNK2K4.1
N18706494: length 27.9
  TOP w0.305: SITE2.8_F 186.71,265.4
  TOP w0.635: UNK2K15.3 175.29,246.19 175.29,247.82 175.89,248.41 177.92,248.41 185.16,255.65 185.16,263.85 186.71,265.4
N18706506: length 1.5
  BOTTOM w0.203: UNK2C60.1 UNK2K16.3
N18706519: length 1.5
  BOTTOM w0.203: UNK2RK17.1 189.12,255.12 UNK2K17.1
N18706533: length 1.5
  BOTTOM w0.203: UNK2RK16.1 186.96,255.12 UNK2K16.1
N18706537: length 1.5
  BOTTOM w0.203: UNK2K18.1 189.12,250.29 UNK2RK18.1
N18707687: length 1.5
  BOTTOM w0.203: UNK2C69.1 UNK2K19.3
N18707714: length 1.5
  BOTTOM w0.203: UNK2K19.1 191.91,255.12 UNK2RK19.1
N18707716: length 1.5
  BOTTOM w0.203: UNK2RK20.1 191.91,250.29 UNK2K20.1
N18707717: length 1.5
  BOTTOM w0.203: UNK2K21.1 194.07,255.12 UNK2RK21.1
N18707742: length 1.5
  BOTTOM w0.203: UNK2RK22.1 194.07,250.29 UNK2K22.1
N18707748: length 24.1
  BOTTOM w0.203: 194.38,244.3 193.24,245.44 193.24,247.49 194.81,249.07 194.81,259.97 190.3,264.48 v2(190.3,265.39)
N18707762: length 28.6
  BOTTOM w0.203: v2(190.8,265.39) 190.8,264.74 195.32,260.22 195.32,249.96 195.8,249.48 200.21,249.48 201.15,248.53 201.15,245.78 202.64,244.3
N18707772: length 1.5
  BOTTOM w0.203: UNK2C62.1 UNK2K25.3
N18707790: length 1.5
  BOTTOM w0.203: UNK2RK25.1 197.37,255.12 UNK2K25.1
N18707794: length 1.5
  BOTTOM w0.203: UNK2RK26.1 197.37,250.29 UNK2K26.1
N18707799: length 1.5
  BOTTOM w0.203: UNK2C63.1 UNK2K27.3
N18707815: length 1.5
  BOTTOM w0.203: UNK2K28.1 206.9,261.77 UNK2RK28.1
N18707836: length 1.5
  BOTTOM w0.203: UNK2RK27.1 202.33,261.77 UNK2K27.1
N18707838: length 1.1
  BOTTOM w0.203: UNK2RK29.1 UNK2K29.1
N18707843: length 1.5
  BOTTOM w0.203: UNK2C61.1 UNK2K30.3
N18707857: length 1.5
  BOTTOM w0.203: UNK2RK31.1 206.9,265.58 UNK2K31.1
N18707877: length 1.5
  BOTTOM w0.203: UNK2RK30.1 202.33,265.58 UNK2K30.1
N18707880: length 1.1
  BOTTOM w0.203: UNK2RK32.1 UNK2K32.1
N18707882: length 1.5
  BOTTOM w0.203: UNK2K35.1 211.48,268.62 UNK2RK35.1
N18707884: length 1.5
  BOTTOM w0.203: UNK2K34.1 206.9,268.62 UNK2RK34.1
N18707886: length 1.5
  BOTTOM w0.203: UNK2RK33.1 202.33,268.62 UNK2K33.1
N18707889: length 1.5
  BOTTOM w0.203: UNK2C64.1 UNK2K33.3
N18707924: length 1.5
  BOTTOM w0.203: UNK2RK37.1 206.9,271.67 UNK2K37.1
N18707925: length 1.5
  BOTTOM w0.203: UNK2RK36.1 202.33,271.67 UNK2K36.1
N18707931: length 1.5
  BOTTOM w0.203: UNK2C65.1 UNK2K36.3
N18709217: length 1.5
  BOTTOM w0.203: UNK2K39.1 206.9,274.21 UNK2RK39.1
N18709218: length 1.5
  BOTTOM w0.203: UNK2K38.1 202.33,274.21 UNK2RK38.1
N18709224: length 1.5
  BOTTOM w0.203: UNK2C74.1 UNK2K38.3
N18709243: length 1.5
  BOTTOM w0.203: UNK2K40.1 195.17,275.24 UNK2RK40.1
N18709256: length 1.5
  BOTTOM w0.203: UNK2K41.1 195.17,279.81 UNK2RK41.1
N18709269: length 1.5
  BOTTOM w0.203: UNK2K42.1 195.17,284.38 UNK2RK42.1
N18709281: length 1.5
  BOTTOM w0.203: UNK2RK43.1 192.25,275.24 UNK2K43.1
N18709294: length 1.5
  BOTTOM w0.203: UNK2RK45.1 192.25,285.65 UNK2K45.1
N18709295: length 1.5
  BOTTOM w0.203: UNK2K44.1 192.25,281.08 UNK2RK44.1
N18709305: length 1.5
  BOTTOM w0.203: UNK2C66.1 193.05,276.71 UNK2K44.3
N18709323: length 1.5
  BOTTOM w0.203: UNK2RK46.1 189.84,276.76 UNK2K46.1
N18709339: length 1.5
  BOTTOM w0.203: UNK2K47.3 190.64,278.23 UNK2C67.1
N18709352: length 1.5
  BOTTOM w0.203: UNK2K48.1 189.84,287.17 UNK2RK48.1
N18709353: length 1.5
  BOTTOM w0.203: UNK2K47.1 189.84,282.6 UNK2RK47.1
N18709363: length 1.5
  BOTTOM w0.203: UNK2K49.3 188.23,282.8 UNK2C68.1
N18709376: length 1.5
  BOTTOM w0.203: UNK2K50.1 187.43,281.33 UNK2RK50.1
N18709377: length 1.5
  BOTTOM w0.203: UNK2K49.1 187.43,287.17 UNK2RK49.1
N18710191: length 1.3
  BOTTOM w0.203: UNK2R7.2 188.32,244.45 UNK2K51.4
N18710203: length 1.3
  BOTTOM w0.203: UNK2R8.2 196.57,244.45 UNK2K53.4
N18710205: length 1.5
  BOTTOM w0.203: UNK2K53.1 196.57,248.69 UNK2RK53.1
N18710227: length 2.3
  BOTTOM w0.203: v1(166.61,294.24) UNK2R11.2 UNK2R19.1
N18710239: length 2.3
  BOTTOM w0.203: v1(173.22,294.24) UNK2R14.2 UNK2R20.1
N18710249: length 1.5
  BOTTOM w0.203: UNK2RK59.1 161.26,291.95 UNK2K55.1
N18710252: length 1.3
  BOTTOM w0.508: UNK2R19.2 UNK2K55.4
N18710254: length 3
  BOTTOM w0.305: UNK2RK60.1 163.92,287.4
N18710271: length 3.4
  BOTTOM w0.203: UNK2TP_IN-_3.1 198.51,232.74 198.31,232.54 UNK2R16.1 197.41,231.32 UNK2U3.8
N18710272: length 3.4
  BOTTOM w0.203: UNK2TP_IN+_3.1 195.68,232.74 195.89,232.54 UNK2R16.2 196.81,231.32 UNK2U3.7
N18710300: length 3.4
  BOTTOM w0.203: UNK2TP_IN+_4.1 190.6,232.74 190.81,232.54 UNK2R18.2 191.73,231.32 UNK2U4.7
N18710304: length 3.4
  BOTTOM w0.203: UNK2U4.8 192.33,231.32 UNK2R18.1 193.23,232.54 193.43,232.74 UNK2TP_IN-_4.1
N18710315: length 7.5
  BOTTOM w0.508: 172.87,287.4 171.43,287.4 170.92,287.91 UNK2K61.4 UNK2R20.2
N18710316: length 1.5
  BOTTOM w0.203: UNK2K54.1 197.37,238.99 UNK2RK54.1
N18710320: length 1.5
  BOTTOM w0.203: UNK2K51.1 188.32,248.69 UNK2RK51.1
N18710322: length 1.5
  BOTTOM w0.203: UNK2K52.1 189.12,238.99 UNK2RK52.1
N18710386: length 1.5
  BOTTOM w0.203: UNK2K57.1 197.71,236.75 197.61,236.86
N18710387: length 1.5
  BOTTOM w0.203: UNK2K58.1 195.68,236.75 195.58,236.86
N18710388: length 1.5
  BOTTOM w0.203: UNK2K59.1 192.63,236.75 192.53,236.86
N18710389: length 1.5
  BOTTOM w0.203: 190.5,236.86 190.6,236.75 UNK2K60.1
N18710392: length 1.5
  BOTTOM w0.203: UNK2RK61.1 167.86,291.95 UNK2K61.1
N18711523: length 2.2
  BOTTOM w0.635: UNK3C48.1 UNK3K2.3
N18711532: length 6.9
  BOTTOM w0.635: UNK3K3.3 216.91,274.45 216.27,273.81 UNK3C49.1
N18711541: length 1.5
  BOTTOM w0.508: UNK3C50.1 UNK3K5.3
N18711574: length 1.5
  BOTTOM w0.203: UNK3RK7.1 217.77,263.76 UNK3K7.1
N18711581: length 1.5
  BOTTOM w0.203: UNK3K8.3 222.14,262.02 UNK3C53.1
N18711590: length 1.5
  BOTTOM w0.203: UNK3C54.1 216.42,262.02 UNK3K9.3
N18711620: length 6.9
  BOTTOM w0.508: 222.67,253.35 UNK3K12.3
  BOTTOM w0.635: 222.67,253.35 222.22,252.9 222.22,250.8 220.59,249.17 UNK3C59.1
N18711627: length 1.5
  BOTTOM w0.203: UNK3K13.3 223.36,248.69 UNK3R1.1
N18711645: length 25.6
  BOTTOM w0.203: UNK3K15.6 218.34,246.04 218.34,248.58 221.35,251.59 221.35,258.83 223.32,260.79 223.32,261.61 v2(227.45,265.74)
N18711663: length 1.5
  BOTTOM w0.203: UNK3K5.1 217.77,268.59 UNK3RK5.1
N18711665: length 1.5
  BOTTOM w0.203: UNK3K6.1 217.77,265.79 UNK3RK6.1
N18711667: length 1.5
  BOTTOM w0.203: UNK3RK8.1 217.77,261.22 UNK3K8.1
N18711668: length 1.5
  BOTTOM w0.203: UNK3K9.1 212.05,261.22 UNK3RK9.1
N18711669: length 1.5
  BOTTOM w0.203: UNK3K10.1 213.2,263.76 UNK3RK10.1
N18711670: length 1.5
  BOTTOM w0.203: UNK3K11.1 224.16,255.12 UNK3RK11.1
N18711673: length 1.3
  BOTTOM w0.508: UNK3C58.1 UNK3K11.3
N18711676: length 1.5
  BOTTOM w0.203: UNK3K12.1 224.16,250.29 UNK3RK12.1
N18711678: length 1.5
  BOTTOM w0.203: UNK3RK13.1 224.16,244.32 UNK3K13.1
N18711681: length 1.5
  BOTTOM w0.203: UNK3RK14.1 226.96,250.29 UNK3K14.1
N18711683: length 3.4
  BOTTOM w0.203: UNK3K2.1 222.87,283.32 222.47,283.73 UNK3RK2.1
N18711684: length 1.9
  BOTTOM w0.203: UNK3K3.1 UNK3RK3.1
N18711685: length 2.4
  BOTTOM w0.203: UNK3K4.1 222.87,296.1 222.04,296.93 UNK3RK4.1
N18711705: length 27.9
  TOP w0.305: SITE3.8_F 226.71,265.4
  TOP w0.635: 226.71,265.4 225.16,263.85 225.16,255.65 217.92,248.41 215.89,248.41 215.29,247.82 215.29,246.19 UNK3K15.3
N18711717: length 1.5
  BOTTOM w0.203: UNK3C60.1 UNK3K16.3
N18711730: length 1.5
  BOTTOM w0.203: UNK3K17.1 229.12,255.12 UNK3RK17.1
N18711744: length 1.5
  BOTTOM w0.203: UNK3RK16.1 226.96,255.12 UNK3K16.1
N18711748: length 1.5
  BOTTOM w0.203: UNK3RK18.1 229.12,250.29 UNK3K18.1
N18712898: length 1.5
  BOTTOM w0.203: UNK3C69.1 UNK3K19.3
N18712925: length 1.5
  BOTTOM w0.203: UNK3K19.1 231.91,255.12 UNK3RK19.1
N18712927: length 1.5
  BOTTOM w0.203: UNK3K20.1 231.91,250.29 UNK3RK20.1
N18712928: length 1.5
  BOTTOM w0.203: UNK3K21.1 234.07,255.12 UNK3RK21.1
N18712953: length 1.5
  BOTTOM w0.203: UNK3K22.1 234.07,250.29 UNK3RK22.1
N18712959: length 24.1
  BOTTOM w0.203: v2(230.3,265.39) 230.3,264.48 234.81,259.97 234.81,249.07 233.24,247.49 233.24,245.44 234.38,244.3
N18712973: length 28.6
  BOTTOM w0.203: v2(230.8,265.39) 230.8,264.74 235.32,260.22 235.32,249.96 235.8,249.48 240.21,249.48 241.15,248.53 241.15,245.78 242.64,244.3
N18712983: length 1.5
  BOTTOM w0.203: UNK3C62.1 UNK3K25.3
N18713001: length 1.5
  BOTTOM w0.203: UNK3RK25.1 237.37,255.12 UNK3K25.1
N18713005: length 1.5
  BOTTOM w0.203: UNK3RK26.1 237.37,250.29 UNK3K26.1
N18713010: length 1.5
  BOTTOM w0.203: UNK3C63.1 UNK3K27.3
N18713026: length 1.5
  BOTTOM w0.203: UNK3RK28.1 246.9,261.77 UNK3K28.1
N18713047: length 1.5
  BOTTOM w0.203: UNK3RK27.1 242.33,261.77 UNK3K27.1
N18713049: length 1.1
  BOTTOM w0.203: UNK3RK29.1 UNK3K29.1
N18713054: length 1.5
  BOTTOM w0.203: UNK3C61.1 UNK3K30.3
N18713068: length 1.5
  BOTTOM w0.203: UNK3RK31.1 246.9,265.58 UNK3K31.1
N18713088: length 1.5
  BOTTOM w0.203: UNK3K30.1 242.33,265.58 UNK3RK30.1
N18713091: length 1.1
  BOTTOM w0.203: UNK3RK32.1 UNK3K32.1
N18713093: length 1.5
  BOTTOM w0.203: UNK3K35.1 251.48,268.62 UNK3RK35.1
N18713095: length 1.5
  BOTTOM w0.203: UNK3RK34.1 246.9,268.62 UNK3K34.1
N18713097: length 1.5
  BOTTOM w0.203: UNK3RK33.1 242.33,268.62 UNK3K33.1
N18713100: length 1.5
  BOTTOM w0.203: UNK3C64.1 UNK3K33.3
N18713135: length 1.5
  BOTTOM w0.203: UNK3K37.1 246.9,271.67 UNK3RK37.1
N18713136: length 1.5
  BOTTOM w0.203: UNK3K36.1 242.33,271.67 UNK3RK36.1
N18713142: length 1.5
  BOTTOM w0.203: UNK3C65.1 UNK3K36.3
N18714428: length 1.5
  BOTTOM w0.203: UNK3RK39.1 246.9,274.21 UNK3K39.1
N18714429: length 1.5
  BOTTOM w0.203: UNK3K38.1 242.33,274.21 UNK3RK38.1
N18714435: length 1.5
  BOTTOM w0.203: UNK3C74.1 UNK3K38.3
N18714454: length 1.5
  BOTTOM w0.203: UNK3RK40.1 235.17,275.24 UNK3K40.1
N18714467: length 1.5
  BOTTOM w0.203: UNK3K41.1 235.17,279.81 UNK3RK41.1
N18714480: length 1.5
  BOTTOM w0.203: UNK3RK42.1 235.17,284.38 UNK3K42.1
N18714492: length 1.5
  BOTTOM w0.203: UNK3RK43.1 232.25,275.24 UNK3K43.1
N18714505: length 1.5
  BOTTOM w0.203: UNK3RK45.1 232.25,285.65 UNK3K45.1
N18714506: length 1.5
  BOTTOM w0.203: UNK3RK44.1 232.25,281.08 UNK3K44.1
N18714516: length 1.5
  BOTTOM w0.203: UNK3K44.3 233.05,276.71 UNK3C66.1
N18714534: length 1.5
  BOTTOM w0.203: UNK3RK46.1 229.84,276.76 UNK3K46.1
N18714550: length 1.5
  BOTTOM w0.203: UNK3K47.3 230.64,278.23 UNK3C67.1
N18714563: length 1.5
  BOTTOM w0.203: UNK3K48.1 229.84,287.17 UNK3RK48.1
N18714564: length 1.5
  BOTTOM w0.203: UNK3K47.1 229.84,282.6 UNK3RK47.1
N18714574: length 1.5
  BOTTOM w0.203: UNK3K49.3 228.23,282.8 UNK3C68.1
N18714587: length 1.5
  BOTTOM w0.203: UNK3RK50.1 227.43,281.33 UNK3K50.1
N18714588: length 1.5
  BOTTOM w0.203: UNK3K49.1 227.43,287.17 UNK3RK49.1
N18715402: length 1.3
  BOTTOM w0.203: UNK3R7.2 228.32,244.45 UNK3K51.4
N18715414: length 1.3
  BOTTOM w0.203: UNK3R8.2 236.57,244.45 UNK3K53.4
N18715416: length 1.5
  BOTTOM w0.203: UNK3RK53.1 236.57,248.69 UNK3K53.1
N18715438: length 2.3
  BOTTOM w0.203: v1(206.61,294.24) UNK3R11.2 UNK3R19.1
N18715450: length 2.3
  BOTTOM w0.203: UNK3R20.1 UNK3R14.2 v1(213.21,294.24)
N18715460: length 1.5
  BOTTOM w0.203: UNK3RK59.1 201.26,291.95 UNK3K55.1
N18715463: length 1.3
  BOTTOM w0.508: UNK3R19.2 UNK3K55.4
N18715465: length 3
  BOTTOM w0.305: UNK3RK60.1 203.92,287.4
N18715482: length 3.4
  BOTTOM w0.203: UNK3U3.8 237.41,231.32 UNK3R16.1 238.31,232.54 238.51,232.74 UNK3TP_IN-_3.1
N18715483: length 3.4
  BOTTOM w0.203: UNK3TP_IN+_3.1 235.68,232.74 235.89,232.54 UNK3R16.2 236.81,231.32 UNK3U3.7
