# Allegro board 980K2-260817_261117-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL01_VI100_28_B_HS: length 15.4
  BOTTOM w0.152: v2(230.3,269.59) 230.44,269.73 230.44,270.53 230.71,270.8
  BOTTOM w0.203: 230.71,270.8 233.5,270.8 234.03,271.32 234.03,276.17 234.05,276.2 234.05,280.2 v1(235.17,281.32)
SL01_VI100_29_A_HF: length 8.4
  TOP w0.305: 233.66,268.65 233.26,268.25 232.44,268.25 232.44,268.24 SITE3.22_F
  TOP w0.635: 233.66,268.65 233.99,268.98 237.62,268.98 v1(237.73,268.86)
  BOTTOM w0.635: UNK3C64.2 236.03,268.22 236.67,268.86 v1(237.73,268.86)
SL01_VI100_29_A_HS: length 18.1
  BOTTOM w0.203: v2(231.65,268.24) 234.45,268.24 236.21,270 247.04,270 v1(248.42,268.62)
SL01_VI100_29_B_HF: length 0.4
  TOP w0.305: SITE3.32_F v2(227.8,270.39)
  vias: v1(227.43,284.11)
SL01_VI100_29_B_HS: length 9.9
  BOTTOM w0.203: v1(227.43,278.27) 227.43,277.01 228.59,275.84 228.59,272.71 227.33,271.45 227.33,270.33 227.8,269.86 v2(227.8,269.59)
SL01_VI100_30_A_HF: length 8.4
  TOP w0.305: SITE3.23_F 232.52,268.74 232.97,269.19
  TOP w0.635: v1(239.27,271.67) 237.57,269.97 233.75,269.97 232.97,269.19
SL01_VI100_30_A_HS: length 14.9
  BOTTOM w0.203: v2(231.65,268.74) 234.31,268.74 236.27,270.7 236.59,270.7 237.12,271.23 237.12,272.36 237.43,272.67 242.85,272.67 v1(243.84,271.67)
SL01_VI100_30_B_HS: length 9.2
  BOTTOM w0.203: v2(229.3,265.39) 229.3,264.72 234.07,259.95 v1(234.07,258.18)
SL01_VI100_31_A_HF: length 10
  TOP w0.305: SITE3.24_F 232.05,269.58 232.28,269.81
  TOP w0.635: v1(239.27,274.21) 238.47,273.41 237.62,273.41 236.98,272.77 236.98,271.92 235.98,270.92 233.39,270.92 232.28,269.81
SL01_VI100_31_A_HS: length 17.3
  BOTTOM w0.203: v1(243.84,274.21) 242.72,275.34 236.97,275.34 236.72,275.08 236.72,271.4 236.46,271.14 236.08,271.14 234.18,269.24 v2(231.65,269.24)
SL01_VI100_31_B_HS: length 13.9
  BOTTOM w0.203: v2(228.8,265.39) 228.8,262.17 230.36,260.61 230.36,254.46 230.57,254.25 231.51,254.25 231.91,253.85 v1(231.91,253.35)
SL01_VI100_32_A_HF: length 0.4
  TOP w0.305: SITE3.28_F v2(229.8,270.39)
SL01_VI100_32_A_HS: length 4.1
  BOTTOM w0.152: v2(229.8,269.59) 229.8,269.74 230.14,270.08 230.14,270.86 230.25,270.97
  BOTTOM w0.203: v1(232.25,272.17) 231.28,271.2 230.49,271.2 230.25,270.97
SL01_VI100_32_B_HS: length 7.8
  BOTTOM w0.203: v2(227.8,265.39) 227.8,261.39 229.12,260.08 v1(229.12,258.18)
SL02_VI100_2_A_HF: length 11.5
  TOP w0.305: SITE2.2_F 186.18,268.74
  TOP w0.635: 186.18,268.74 180.98,268.74 v1(180.83,268.59)
  BOTTOM w0.635: v1(180.83,268.59) 179.83,267.59 176.82,267.59 UNK2C49.2
SL02_VI100_2_A_HS: length 7.8
  BOTTOM w0.203: v2(187.45,268.74) 184.92,268.74 181.97,265.79 v1(180.83,265.79)
SL02_VI100_2_B_HF: length 9.3
  TOP w0.305: SITE2.29_F 189.3,270.29 189.31,270.3 189.31,270.56 189.29,270.58 189.29,271 189.31,271.02 189.31,271.21 189.94,271.84
  TOP w0.635: v1(192.25,278.02) 191.49,277.25 191.49,273.39 189.94,271.84
SL02_VI100_2_B_HS: length 14.3
  BOTTOM w0.203: v2(189.3,269.59) 189.21,269.68 189.21,270.84 191.38,273.02 191.38,281.72 v1(192.25,282.59)
SL02_VI100_3_A_HF: length 16.3
  TOP w0.305: SITE2.5_F 185.45,267.24
  TOP w0.635: v1(180.83,261.22) 183.13,263.52 183.13,264.92 185.45,267.24
  BOTTOM w0.635: v1(175.11,261.22) 175.11,260.93 175.75,260.3 180.19,260.3 180.83,260.93 v1(180.83,261.22)
SL02_VI100_3_A_HS: length 13.4
  BOTTOM w0.203: v1(176.26,263.76) 177.13,262.89 182.62,262.89 186.97,267.24 v2(187.45,267.24)
SL02_VI100_3_B_HS: length 13
  BOTTOM w0.203: v2(188.3,265.39) 188.3,261.78 189.86,260.22 189.86,254.09 v1(189.12,253.35)
SL02_VI100_4_A_HS: length 8.3
  BOTTOM w0.203: v2(187.45,267.74) 185.82,267.74 181.84,263.76 v1(180.83,263.76)
SL02_VI100_4_B_HS: length 13.8
  BOTTOM w0.203: v2(191.65,265.74) 193.97,263.42 202.19,263.42 v1(203.84,261.77)
SL02_VI100_5_A_HF: length 23.1
  TOP w0.305: 186.18,266.45 186.47,266.74 SITE2.6_F
  TOP w0.635: 186.18,266.45 184.16,264.43 v1(184.16,258.18)
  BOTTOM w0.508: 184.38,253.35 UNK2K12.4
  BOTTOM w0.635: 185.18,253.35 184.38,253.35 ; 185.18,253.35 185.18,257.54 184.54,258.18 v1(184.16,258.18) ; 185.18,253.35 185.18,248.1 184.45,247.38 184.21,247.38
SL02_VI100_5_A_HS:
  vias: v2(187.45,266.74)
SL02_VI100_6_A_HF:
  vias: v2(187.05,266.24)
SL02_VI100_6_A_HS:
  vias: v1(186.96,253.35) v2(187.45,266.24)
SL02_VI100_6_B_HF: length 1.7
  TOP w0.305: SITE2.30_F v2(188.8,271.66)
SL02_VI100_6_B_HS: length 4.5
  BOTTOM w0.203: v2(188.8,269.59) 188.8,271.01 189.84,272.05 UNK2K46.4
SL02_VI100_7_A_HF:
  vias: v2(189.8,264.99)
SL02_VI100_7_A_HS:
  vias: v1(194.07,253.35) v2(189.8,265.39)
SL02_VI100_7_B_HF: length 10.4
  TOP w0.305: SITE2.31_F 188.3,270.29 188.29,270.3 188.29,270.82 188.07,271.04
  TOP w0.635: 188.07,271.04 188.07,272.57 189.08,273.58 189.08,278.78 v1(189.84,279.54)
SL02_VI100_7_B_HS: length 15.2
  BOTTOM w0.203: v2(188.3,269.59) 188.3,271.84 189.05,272.6 189.05,283.33 v1(189.84,284.11)
SL02_VI100_8_B_HF: length 5.7
  TOP w0.305: SITE2.20_F 194.73,267.24 195.04,266.93
  TOP w0.635: v1(196.03,265.94) 195.04,266.93
  BOTTOM w0.635: v1(196.03,265.94) UNK2C61.2
SL02_VI100_8_B_HS: length 17.5
  BOTTOM w0.203: v2(191.65,267.24) 194.53,267.24 194.7,267.06 206.93,267.06 v1(208.42,265.58)
SL02_VI100_9_B_HF: length 7.6
  TOP w0.305: SITE2.21_F 194.03,267.74 194.28,267.99
  TOP w0.635: 194.28,267.99 198.64,267.99 v1(199.27,268.62)
SL02_VI100_9_B_HS: length 13.3
  BOTTOM w0.203: v2(191.65,267.74) 194.58,267.74 196.34,269.49 202.97,269.49 v1(203.84,268.62)
SL02_VI100_10_A_HF: length 9.6
  TOP w0.305: 191.98,264.74 191.55,264.74 SITE2.16_F
  TOP w0.635: v1(197.37,258.18) 196.72,258.83 196.72,260.01 191.98,264.74
SL02_VI100_10_A_HS: length 15.2
  BOTTOM w0.203: v1(197.37,253.35) 197.37,254.05 197.17,254.25 196.08,254.25 195.83,254.51 195.83,260.6 191.3,265.13 v2(191.3,265.39)
SL02_VI100_10_B_HF: length 0.4
  TOP w0.305: SITE2.25_F v2(191.3,270.39)
SL02_VI100_10_B_HS: length 5.7
  BOTTOM w0.203: v1(195.17,272.17) 195.17,270.87 193.95,269.65 191.36,269.65 v2(191.3,269.59)
SL02_VI100_11_A_HF: length 7.2
  TOP w0.305: 193.62,265.67 193.05,266.24 SITE2.18_F
  TOP w0.635: 193.62,265.67 196.62,262.67 v1(197.73,262.67)
SL02_VI100_11_A_HS: length 18.6
  BOTTOM w0.203: v1(208.42,261.77) 206.28,263.91 194.3,263.91 191.97,266.24 v2(191.65,266.24)
SL02_VI100_11_B_HF: length 0.4
  TOP w0.305: SITE2.26_F v2(190.8,270.39)
SL02_VI100_11_B_HS: length 10.5
  BOTTOM w0.203: v2(190.8,269.59) 190.8,269.67 191.16,270.03 191.57,270.03 191.7,270.16 193.88,270.16 194.43,270.7 194.43,276 v1(195.17,276.75)
SL02_VI100_12_A_HF: length 8.2
  TOP w0.305: SITE2.19_F 193.59,266.74 194.13,266.19 194.3,266.19
  TOP w0.635: v1(199.27,265.58) 198.62,264.92 195.57,264.92 194.3,266.19
SL02_VI100_12_A_HS: length 12.7
  BOTTOM w0.203: v1(203.84,265.58) 202.84,266.58 194.43,266.58 194.27,266.74 v2(191.65,266.74)
SL02_VI100_12_B_HF: length 1.1
  TOP w0.305: v2(189.8,270.79) 190,270.79 190.3,270.49 SITE2.27_F
SL02_VI100_12_B_HS: length 15.4
  BOTTOM w0.152: 190.71,270.8 190.44,270.53 190.44,269.73 v2(190.3,269.59)
  BOTTOM w0.203: 190.71,270.8 193.5,270.8 194.03,271.32 194.03,276.17 194.05,276.2 194.05,280.2 v1(195.17,281.32)
SL02_VI100_13_A_HF: length 8.4
  TOP w0.305: SITE2.22_F 192.44,268.24 192.44,268.25 193.26,268.25 193.66,268.65
  TOP w0.635: v1(197.73,268.86) 197.62,268.98 193.99,268.98 193.66,268.65
  BOTTOM w0.635: v1(197.73,268.86) 196.67,268.86 196.03,268.22 UNK2C64.2
SL02_VI100_13_A_HS: length 18.1
  BOTTOM w0.203: v2(191.65,268.24) 194.45,268.24 196.21,270 207.04,270 v1(208.42,268.62)
SL02_VI100_13_B_HF: length 0.4
  TOP w0.305: SITE2.32_F v2(187.8,270.39)
  vias: v1(187.43,284.11)
SL02_VI100_13_B_HS: length 9.9
  BOTTOM w0.203: v2(187.8,269.59) 187.8,269.86 187.33,270.33 187.33,271.45 188.59,272.71 188.59,275.84 187.43,277.01 v1(187.43,278.27)
SL02_VI100_14_A_HF: length 8.4
  TOP w0.305: 192.97,269.19 192.52,268.74 SITE2.23_F
  TOP w0.635: v1(199.27,271.67) 197.57,269.97 193.75,269.97 192.97,269.19
SL02_VI100_14_A_HS: length 14.9
  BOTTOM w0.203: v2(191.65,268.74) 194.31,268.74 196.27,270.7 196.59,270.7 197.12,271.23 197.12,272.36 197.43,272.67 202.85,272.67 v1(203.84,271.67)
SL02_VI100_14_B_HS: length 9.2
  BOTTOM w0.203: v2(189.3,265.39) 189.3,264.72 194.07,259.95 v1(194.07,258.18)
SL02_VI100_15_A_HF: length 10
  TOP w0.305: SITE2.24_F 192.05,269.58 192.28,269.81
  TOP w0.635: 192.28,269.81 193.39,270.92 195.98,270.92 196.98,271.92 196.98,272.77 197.62,273.41 198.47,273.41 v1(199.27,274.21)
SL02_VI100_15_A_HS: length 17.3
  BOTTOM w0.203: v2(191.65,269.24) 194.18,269.24 196.08,271.14 196.46,271.14 196.72,271.4 196.72,275.08 196.97,275.34 202.72,275.34 v1(203.84,274.21)
SL02_VI100_15_B_HS: length 13.9
  BOTTOM w0.203: v1(191.91,253.35) 191.91,253.85 191.51,254.25 190.57,254.25 190.36,254.46 190.36,260.61 188.8,262.17 v2(188.8,265.39)
SL02_VI100_16_A_HF: length 0.4
  TOP w0.305: SITE2.28_F v2(189.8,270.39)
SL02_VI100_16_A_HS: length 4.1
  BOTTOM w0.152: 190.25,270.97 190.14,270.86 190.14,270.08 189.8,269.74 v2(189.8,269.59)
  BOTTOM w0.203: v1(192.25,272.17) 191.28,271.2 190.49,271.2 190.25,270.97
SL02_VI100_16_B_HS: length 7.8
  BOTTOM w0.203: v1(189.12,258.18) 189.12,260.08 187.8,261.39 v2(187.8,265.39)
SL02_VI100_18_A_HF: length 11.5
  TOP w0.305: SITE4.2_F 266.18,268.74
  TOP w0.635: v1(260.83,268.59) 260.98,268.74 266.18,268.74
  BOTTOM w0.635: v1(260.83,268.59) 259.83,267.59 256.82,267.59 UNK4C49.2
SL02_VI100_18_A_HS: length 7.8
  BOTTOM w0.203: v2(267.45,268.74) 264.92,268.74 261.97,265.79 v1(260.83,265.79)
SL02_VI100_18_B_HF: length 9.3
  TOP w0.305: 269.94,271.84 269.31,271.21 269.31,271.02 269.29,271 269.29,270.58 269.31,270.56 269.31,270.3 269.3,270.29 SITE4.29_F
  TOP w0.635: 269.94,271.84 271.49,273.39 271.49,277.25 v1(272.25,278.02)
SL02_VI100_18_B_HS: length 14.3
  BOTTOM w0.203: v1(272.25,282.59) 271.38,281.72 271.38,273.02 269.21,270.84 269.21,269.68 v2(269.3,269.59)
SL02_VI100_19_A_HF: length 16.3
  TOP w0.305: SITE4.5_F 265.45,267.24
  TOP w0.635: v1(260.83,261.22) 263.13,263.52 263.13,264.92 265.45,267.24
  BOTTOM w0.635: v1(255.11,261.22) 255.11,260.93 255.75,260.3 260.19,260.3 260.83,260.93 v1(260.83,261.22)
SL02_VI100_19_A_HS: length 13.4
  BOTTOM w0.203: v2(267.45,267.24) 266.97,267.24 262.62,262.89 257.13,262.89 v1(256.26,263.76)
SL02_VI100_19_B_HS: length 13
  BOTTOM w0.203: v2(268.3,265.39) 268.3,261.78 269.86,260.22 269.86,254.09 v1(269.12,253.35)
SL02_VI100_20_A_HS: length 8.3
  BOTTOM w0.203: v1(260.83,263.76) 261.84,263.76 265.82,267.74 v2(267.45,267.74)
SL02_VI100_20_B_HS: length 13.8
  BOTTOM w0.203: v2(271.65,265.74) 273.97,263.42 282.19,263.42 v1(283.84,261.77)
SL02_VI100_21_A_HF: length 23.1
  TOP w0.305: SITE4.6_F 266.47,266.74 266.18,266.45
  TOP w0.635: v1(264.16,258.18) 264.16,264.43 266.18,266.45
  BOTTOM w0.508: 264.38,253.35 UNK4K12.4
  BOTTOM w0.635: 265.17,253.35 264.38,253.35 ; 265.17,253.35 265.17,248.1 264.45,247.38 264.21,247.38 ; 265.17,253.35 265.17,257.54 264.54,258.18 v1(264.16,258.18)
SL02_VI100_21_A_HS:
  vias: v2(267.45,266.74)
SL02_VI100_22_A_HF:
  vias: v2(267.05,266.24)
SL02_VI100_22_A_HS:
  vias: v1(266.96,253.35) v2(267.45,266.24)
SL02_VI100_22_B_HF: length 1.7
  TOP w0.305: SITE4.30_F v2(268.8,271.66)
SL02_VI100_22_B_HS: length 4.5
  BOTTOM w0.203: v2(268.8,269.59) 268.8,271.01 269.84,272.05 UNK4K46.4
SL02_VI100_23_A_HF:
  vias: v2(269.8,264.99)
SL02_VI100_23_A_HS:
  vias: v1(274.07,253.35) v2(269.8,265.39)
SL02_VI100_23_B_HF: length 10.4
  TOP w0.305: SITE4.31_F 268.3,270.29 268.29,270.3 268.29,270.82 268.07,271.04
  TOP w0.635: 268.07,271.04 268.07,272.57 269.08,273.58 269.08,278.78 v1(269.84,279.54)
SL02_VI100_23_B_HS: length 15.2
  BOTTOM w0.203: v2(268.3,269.59) 268.3,271.84 269.05,272.6 269.05,283.33 v1(269.84,284.11)
SL02_VI100_24_B_HF: length 5.7
  TOP w0.305: SITE4.20_F 274.73,267.24 275.04,266.93
  TOP w0.635: v1(276.03,265.94) 275.04,266.93
  BOTTOM w0.635: v1(276.03,265.94) UNK4C61.2
SL02_VI100_24_B_HS: length 17.5
  BOTTOM w0.203: v1(288.42,265.58) 286.93,267.06 274.7,267.06 274.53,267.24 v2(271.65,267.24)
SL02_VI100_25_B_HF: length 7.6
  TOP w0.305: 274.28,267.99 274.03,267.74 SITE4.21_F
  TOP w0.635: 274.28,267.99 278.64,267.99 v1(279.27,268.62)
SL02_VI100_25_B_HS: length 13.3
  BOTTOM w0.203: v2(271.65,267.74) 274.58,267.74 276.34,269.49 282.97,269.49 v1(283.84,268.62)
SL02_VI100_26_A_HF: length 9.6
  TOP w0.305: SITE4.16_F 271.55,264.74 271.98,264.74
  TOP w0.635: v1(277.37,258.18) 276.72,258.83 276.72,260.01 271.98,264.74
SL02_VI100_26_A_HS: length 15.2
  BOTTOM w0.203: v1(277.37,253.35) 277.37,254.05 277.17,254.25 276.08,254.25 275.83,254.51 275.83,260.6 271.3,265.13 v2(271.3,265.39)
SL02_VI100_26_B_HF: length 0.4
  TOP w0.305: SITE4.25_F v2(271.3,270.39)
SL02_VI100_26_B_HS: length 5.7
  BOTTOM w0.203: v2(271.3,269.59) 271.36,269.65 273.95,269.65 275.17,270.87 v1(275.17,272.17)
SL02_VI100_27_A_HF: length 7.2
  TOP w0.305: SITE4.18_F 273.05,266.24 273.62,265.67
  TOP w0.635: v1(277.73,262.67) 276.62,262.67 273.62,265.67
SL02_VI100_27_A_HS: length 18.6
  BOTTOM w0.203: v1(288.42,261.77) 286.28,263.91 274.3,263.91 271.97,266.24 v2(271.65,266.24)
SL02_VI100_27_B_HF: length 0.4
  TOP w0.305: SITE4.26_F v2(270.8,270.39)
SL02_VI100_27_B_HS: length 10.5
  BOTTOM w0.203: v2(270.8,269.59) 270.8,269.67 271.16,270.03 271.57,270.03 271.7,270.16 273.88,270.16 274.43,270.7 274.43,276 v1(275.17,276.75)
SL02_VI100_28_A_HF: length 8.2
  TOP w0.305: 274.3,266.19 274.13,266.19 273.59,266.74 SITE4.19_F
  TOP w0.635: v1(279.27,265.58) 278.62,264.92 275.57,264.92 274.3,266.19
SL02_VI100_28_A_HS: length 12.7
  BOTTOM w0.203: v2(271.65,266.74) 274.27,266.74 274.43,266.58 282.84,266.58 v1(283.84,265.58)
SL02_VI100_28_B_HF: length 1.1
  TOP w0.305: v2(269.8,270.79) 270,270.79 270.3,270.49 SITE4.27_F
SL02_VI100_28_B_HS: length 15.4
  BOTTOM w0.152: 270.71,270.8 270.44,270.53 270.44,269.73 v2(270.3,269.59)
  BOTTOM w0.203: 270.71,270.8 273.5,270.8 274.03,271.32 274.03,276.17 274.05,276.2 274.05,280.2 v1(275.17,281.32)
SL02_VI100_29_A_HF: length 8.4
  TOP w0.305: SITE4.22_F 272.44,268.24 272.44,268.25 273.26,268.25 273.66,268.65
  TOP w0.635: 273.66,268.65 273.99,268.98 277.62,268.98 v1(277.73,268.86)
  BOTTOM w0.635: v1(277.73,268.86) 276.67,268.86 276.03,268.22 UNK4C64.2
SL02_VI100_29_A_HS: length 18.1
  BOTTOM w0.203: v1(288.42,268.62) 287.04,270 276.21,270 274.45,268.24 v2(271.65,268.24)
SL02_VI100_29_B_HF: length 0.4
  TOP w0.305: SITE4.32_F v2(267.8,270.39)
  vias: v1(267.43,284.11)
SL02_VI100_29_B_HS: length 9.9
  BOTTOM w0.203: v1(267.43,278.27) 267.43,277.01 268.59,275.84 268.59,272.71 267.33,271.45 267.33,270.33 267.8,269.86 v2(267.8,269.59)
SL02_VI100_30_A_HF: length 8.4
  TOP w0.305: 272.97,269.19 272.52,268.74 SITE4.23_F
  TOP w0.635: 272.97,269.19 273.75,269.97 277.57,269.97 v1(279.27,271.67)
SL02_VI100_30_A_HS: length 14.9
  BOTTOM w0.203: v1(283.84,271.67) 282.85,272.67 277.43,272.67 277.12,272.36 277.12,271.23 276.59,270.7 276.27,270.7 274.31,268.74 v2(271.65,268.74)
SL02_VI100_30_B_HS: length 9.2
  BOTTOM w0.203: v1(274.07,258.18) 274.07,259.95 269.3,264.72 v2(269.3,265.39)
SL02_VI100_31_A_HF: length 10
  TOP w0.305: SITE4.24_F 272.05,269.58 272.28,269.81
  TOP w0.635: v1(279.27,274.21) 278.47,273.41 277.62,273.41 276.98,272.77 276.98,271.92 275.98,270.92 273.39,270.92 272.28,269.81
SL02_VI100_31_A_HS: length 17.3
  BOTTOM w0.203: v2(271.65,269.24) 274.18,269.24 276.08,271.14 276.46,271.14 276.72,271.4 276.72,275.08 276.97,275.34 282.72,275.34 v1(283.84,274.21)
SL02_VI100_31_B_HS: length 13.9
  BOTTOM w0.203: v2(268.8,265.39) 268.8,262.17 270.36,260.61 270.36,254.46 270.57,254.25 271.51,254.25 271.91,253.85 v1(271.91,253.35)
SL02_VI100_32_A_HF: length 0.4
  TOP w0.305: SITE4.28_F v2(269.8,270.39)
SL02_VI100_32_A_HS: length 4.1
  BOTTOM w0.152: 270.25,270.97 270.14,270.86 270.14,270.08 269.8,269.74 v2(269.8,269.59)
  BOTTOM w0.203: 270.25,270.97 270.49,271.2 271.28,271.2 v1(272.25,272.17)
SL02_VI100_32_B_HS: length 7.8
  BOTTOM w0.203: v1(269.12,258.18) 269.12,260.08 267.8,261.39 v2(267.8,265.39)
SL05_PMVI_10_HF:
  vias: v1(148.21,243.34)
SL05_PMVI_11_HF:
  vias: v1(156.46,243.34)
SL05_PMVI_12_HF: length 0.3
  BOTTOM w0.203: U1.4 v1(124.31,294.24)
SL05_PMVI_13_HF:
  vias: v1(130.91,294.24)
SL05_PMVI_14_HF:
  vias: v1(155.49,231.3)
SL05_PMVI_15_HF: length 2.2
  BOTTOM w0.203: C72.1 R15.2 U3.1
SL05_PMVI_16_HF: length 2.7
  BOTTOM w0.381: U3.3 156.14,226.77 155.94,226.57 v1(155.49,226.57)
SL05_PMVI_17_HF:
  vias: v1(150.41,231.3)
SL05_PMVI_18_HF: length 2.2
  BOTTOM w0.203: U4.1 R17.2 C73.1
SL05_PMVI_19_HF: length 0.9
  BOTTOM w0.381: TP_REF_2.1 v1(151.06,229.62)
SL05_PMVI_20_HF:
  vias: v1(228.21,243.34)
SL05_PMVI_21_HF:
  vias: v1(236.46,243.34)
SL05_PMVI_22_HF: length 0.3
  BOTTOM w0.203: UNK3U1.4 v1(204.31,294.24)
SL05_PMVI_23_HF:
  vias: v1(210.91,294.24)
SL05_PMVI_24_HF:
  vias: v1(235.49,231.3)
SL05_PMVI_25_HF: length 2.2
  BOTTOM w0.203: UNK3U3.1 UNK3R15.2 UNK3C72.1
SL05_PMVI_26_HF: length 2.7
  BOTTOM w0.381: UNK3U3.3 236.14,226.77 235.94,226.57 v1(235.49,226.57)
SL05_PMVI_27_HF:
  vias: v1(230.41,231.3)
SL05_PMVI_28_HF: length 2.2
  BOTTOM w0.203: UNK3C73.1 UNK3R17.2 UNK3U4.1
SL05_PMVI_29_HF: length 0.9
  BOTTOM w0.381: UNK3TP_REF_2.1 v1(231.06,229.62)
SL05_PMVI_30_HF:
  vias: v1(148.21,183.34)
SL05_PMVI_31_HF:
  vias: v1(156.46,183.34)
SL05_PMVI_32_HF: length 0.3
  BOTTOM w0.203: UNK5U1.4 v1(124.31,234.24)
SL05_PMVI_33_HF:
  vias: v1(130.91,234.24)
SL05_PMVI_34_HF:
  vias: v1(155.49,171.3)
SL05_PMVI_35_HF: length 2.2
  BOTTOM w0.203: UNK5C72.1 UNK5R15.2 UNK5U3.1
SL05_PMVI_36_HF: length 2.7
  BOTTOM w0.381: UNK5U3.3 156.14,166.77 155.94,166.57 v1(155.49,166.57)
SL05_PMVI_37_HF:
  vias: v1(150.41,171.3)
SL05_PMVI_38_HF: length 2.2
  BOTTOM w0.203: UNK5U4.1 UNK5R17.2 UNK5C73.1
SL05_PMVI_39_HF: length 0.9
  BOTTOM w0.381: UNK5TP_REF_2.1 v1(151.06,169.62)
SL05_PMVI_40_HF:
  vias: v1(228.21,183.34)
SL05_PMVI_41_HF:
  vias: v1(236.46,183.34)
SL05_PMVI_42_HF: length 0.3
  BOTTOM w0.203: UNK7U1.4 v1(204.31,234.24)
SL05_PMVI_43_HF:
  vias: v1(210.91,234.24)
SL05_PMVI_44_HF:
  vias: v1(235.49,171.3)
SL05_PMVI_45_HF: length 2.2
  BOTTOM w0.203: UNK7U3.1 UNK7R15.2 UNK7C72.1
SL05_PMVI_46_HF: length 2.7
  BOTTOM w0.381: UNK7U3.3 236.14,166.77 235.94,166.57 v1(235.49,166.57)
SL05_PMVI_47_HF:
  vias: v1(230.41,171.3)
SL05_PMVI_48_HF: length 2.2
  BOTTOM w0.203: UNK7U4.1 UNK7R17.2 UNK7C73.1
SL05_PMVI_49_HF: length 0.9
  BOTTOM w0.381: UNK7TP_REF_2.1 v1(231.06,169.62)
SL06_DP_0: length 327
  L28_DP w0.079: SLOT06.C61 174,78.22 174,77.42 173.62,77.04 173.08,77.04 172.57,77.56 171.88,77.56 171.37,77.04 170.83,77.04 170.52,77.35 169.68,77.35 169.19,76.86 168.81,76.86 167.54,75.6 162.47,75.6 100.13,137.93 100.13,266.7 122.31,288.88 184.17,288.88 185.41,287.63 v1(185.41,286.99)
SL06_DP_1: length 229.8
  L28_DP w0.079: v1(180.83,266.69) 180.42,266.69 175.42,261.69 173.6,261.69 173.56,261.65 173.17,261.65 168.79,257.27 168.79,249.32 167.78,248.31 159.58,248.31 158.43,247.17 158.43,246.74 155.61,243.92 155.17,243.92 154.8,243.55 153.96,243.55 153.6,243.92 151.97,243.92 151.6,243.55 150.76,243.55 150.4,243.92 147.79,243.92 141.81,237.94 141.81,207.89 141.81,207.88 141.81,207.49 141.81,207.49 141.81,201.46 141.77,201.42 141.77,201.02 141.81,200.98 141.81,197.54 141.64,197.37 141.64,196.98 141.81,196.81 141.81,170.63 140.17,168.98 140.17,111.96 172.22,79.9 SLOT06.D61
SL06_DP_2: length 218.6
  L30_DP w0.079: SLOT06.E61 169.97,79.19 140.95,108.22 140.95,168.75 149.72,177.53 149.72,201.21 154.34,205.83 154.34,221.47 154.72,221.85 154.72,227.43 156.68,229.39 157.13,229.39 160.47,232.73 160.47,234.02 164.03,237.58 167.13,237.58 169.82,240.27 169.82,254.29 175.17,259.63 178.52,259.63 180.28,261.39 180.28,264.11 v1(180.83,264.66)
SL06_DP_3: length 232.9
  L28_DP w0.079: v1(176.26,264.66) 175.79,264.19 174.07,264.19 172.42,262.54 172.42,261.92 172.15,261.65 171.53,261.65 170.64,260.75 170.64,260.67 170.36,260.39 170.28,260.39 168.41,258.53 168.41,249.34 167.67,248.6 159.2,248.6 157.94,247.33 157.94,247.19 157.67,246.91 157.52,246.91 156.37,245.76 154.81,245.76 154.8,245.75 150.76,245.75 150.75,245.76 147.52,245.76 141.11,239.35 141.11,238.46 141.44,238.13 141.44,237.74 141.11,237.41 141.11,225.25 141.44,224.92 141.44,224.53 141.11,224.2 141.11,220.04 140.94,219.16 140.59,218.33 140.09,217.58 139.46,216.95 138.71,216.45 129.98,207.71 129.98,120.5 167.72,82.75 SLOT06.F61
SL06_DP_4: length 306.6
  L30_DP w0.079: SLOT06.A59 178.82,76.85 177.8,76.85 176.99,76.04 176.46,76.04 175.65,76.85 175.53,76.85 174.95,77.42 174.95,77.71 174.62,78.04 174.21,78.04 173.91,78.34 173.08,78.34 172.74,78 171.71,78 171.37,78.34 170.83,78.34 170.53,78.04 169.71,78.04 169.33,78.42 169.33,79 108.78,139.54 108.78,254.36 117.19,262.77 141.16,262.77 141.8,263.41 172.53,263.41 176.28,267.16 181.28,267.16 182.75,265.7 182.75,256.23 185.63,253.35 v1(186.06,253.35)
SL06_DP_5: length 172.9
  L30_DP w0.079: SLOT06.B59 176.72,77.49 176.05,78.17 176.05,78.93 176.62,79.51 176.62,82.42 176.62,82.65 176.62,87.78 169.02,95.38 169.02,199.01 170.94,200.93 170.94,208.6 170.52,209.01 170.52,230.47 175.17,235.12 175.17,240.83 UNK2K15.2
SL06_DP_6: length 306.7
  L30_DP w0.079: SLOT06.C59 174.12,77.04 173.49,77.04 172.49,76.04 171.96,76.04 171.17,76.83 170.79,76.83 170.09,77.53 169.6,77.53 169.12,77.04 168.46,77.04 167.08,78.42 167.08,79.02 106.99,139.11 106.99,254.95 117.27,265.23 141.09,265.23 142.26,264.06 158.96,264.06 161.07,266.17 172.91,266.17 176.74,270 180.78,270 187.62,263.15 187.62,258.77 v1(188.22,258.18)
SL06_DP_7: length 301.4
  L30_DP w0.079: v1(188.22,253.35) 188.22,253.54 185.04,256.72 185.04,264.01 181.09,267.95 175.68,267.95 171.42,263.7 141.67,263.7 141.06,263.09 116.75,263.09 108.16,254.5 108.16,139.18 168.37,78.96 168.37,78.92 168.95,78.34 169.12,78.34 169.52,77.95 169.55,77.95 169.63,77.86 170.01,77.86 170.83,77.04 171.37,77.04 171.48,77.16 171.76,77.16 SLOT06.D59
SL06_DP_8: length 342.7
  L28_DP w0.079: SLOT06.E59 171.27,76.69 171.92,77.34 172.53,77.34 173.01,76.86 173.69,76.86 175.19,78.36 176.14,78.36 176.46,78.04 176.99,78.04 177.31,78.36 178.39,78.36 180.77,75.98 181.43,75.98 181.87,76.42 181.87,78.96 181.08,79.76 174.2,79.76 172.87,78.43 172.87,78.42 172.49,78.04 172.48,78.04 172.39,77.95 172.04,77.95 171.41,78.58 170.79,78.58 170.04,77.83 169.86,77.83 169.34,78.34 168.51,78.34 168.07,77.9 164.49,77.9 106.41,135.97 106.41,255.67 118.06,267.31 140.98,267.31 143.91,264.38 152.09,264.38 154.25,266.54 163.56,266.54 167.6,270.58 180.9,270.58 189.65,261.83 189.65,254.92 191.01,253.56 v1(191.01,253.35)
SL06_DP_9: length 316.9
  L28_DP w0.079: v1(193.17,258.18) 193.17,258.21 192.43,258.96 192.43,269.73 190.94,271.21 181.72,271.21 180.59,272.34 170.04,272.34 169.6,271.9 165.94,271.9 163.5,269.46 152.83,269.46 151.06,271.23 119.71,271.23 105.19,256.71 105.19,134.27 162.77,76.69 SLOT06.F59
SL06_DP_10: length 330.6
  L28_DP w0.079: SLOT06.Z59 181.22,77.56 179.39,79.4 174.13,79.4 172.48,77.74 171.97,77.74 171.37,78.34 170.83,78.34 170.02,77.53 169.61,77.53 169.12,77.04 168.58,77.04 168.28,77.35 163.71,77.35 105.79,135.27 105.79,256.19 117.36,267.76 140.99,267.76 144.08,264.67 151.96,264.67 154.69,267.41 160.02,267.41 161.72,269.11 164.65,269.11 166.84,271.3 181.03,271.3 190.44,261.88 190.44,256.3 193.17,253.58 v1(193.17,253.35)
SL06_DP_11: length 215.9
  L28_DP w0.079: UNK2K23.2 188.58,242.35 188.41,242.52 178.11,242.52 177.27,243.36 170.67,243.36 166.85,239.54 165.01,237.69 161.89,237.69 158.5,234.3 158.5,226.77 156.55,224.82 156.55,224.28 156.27,224.01 155.73,224.01 153.63,221.9 153.63,211.98 152.95,211.31 152.95,200.6 153.64,199.91 153.64,199.31 152.7,198.37 152.7,197.56 153.64,196.62 153.64,194.49 152.7,193.55 152.7,192.74 153.64,191.8 153.64,189.99 152.81,189.17 152.81,182.1 154.76,180.16 154.8,180.16 155.39,179.57 155.39,178.73 155.26,178.61 155.26,177.39 157.84,174.81 160.19,174.81 165.61,169.4 165.61,96.32 182.83,79.11 182.83,76.3 SLOT06.Z57
SL06_DP_12: length 264.8
  L28_DP w0.079: UNK2K24.2 200.44,241.35 200.44,229.52 197.59,226.67 196.25,226.67 195.68,226.1 195.29,226.1 194.72,226.67 194.57,226.67 194.48,226.58 193.86,226.58 193.77,226.67 192.16,226.67 192.07,226.58 191.11,226.58 191.05,226.52 190.43,226.52 188.88,228.07 188.88,229.03 191.69,231.83 191.69,233.31 191.97,233.6 191.97,238.52 192.19,238.73 192.19,239.57 191.69,240.06 191.69,241.44 192.19,241.93 192.19,242.77 191.6,243.36 189.33,243.36 188.76,243.93 183.64,243.93 183.46,243.75 178.35,243.75 177.86,244.24 177.86,244.97 177.27,245.56 176.55,245.56 176.19,245.91 174.23,245.91 174.07,245.75 173.24,245.75 173.08,245.91 172.72,245.91 170.42,243.6 164.95,238.14 161.93,238.14 158.19,234.39 158.19,233.5 158.17,233.48 158.17,226.94 156.18,224.95 155.88,224.95 153.63,222.7 153.63,222.39 151.13,219.89 151.13,217.14 151.21,217.06 151.21,212.55 152.66,211.1 152.66,198.73 152.42,198.49 152.42,182.1 153.38,181.14 153.38,177.8 156.72,174.46 160.15,174.46 165.33,169.28 165.33,96.21 182.43,79.1 182.43,76.59 181.96,76.11 181.82,76.11 181.5,75.8 181.12,75.8 180.37,75.04 180,75.04 179.65,74.69 SLOT06.A57
SL06_DP_13: length 335.7
  L30_DP w0.079: v1(196.47,253.35) 196.46,253.35 195.4,254.41 195.4,267.45 190.63,272.21 181.43,272.21 180.76,272.88 170.01,272.88 169.61,272.49 159.41,272.49 157.03,270.1 153.11,270.1 150.85,272.37 119.69,272.37 104.6,257.27 104.6,140.56 167.24,77.92 167.24,77.13 167.08,76.96 167.08,76.42 167.46,76.04 167.99,76.04 168.6,76.66 169.09,76.66 169.71,76.04 170.24,76.04 170.76,76.56 171.19,76.56 171.88,75.86 172.57,75.86 173.42,76.72 173.72,76.72 173.83,76.61 173.83,76.42 174.21,76.04 174.74,76.04 174.97,76.27 175.25,76.27 175.33,76.34 175.87,76.34 176.17,76.04 176.2,76.04 176.38,75.86 176.51,75.86 176.72,75.65 SLOT06.B57
SL06_DP_14: length 459.7
  L30_DP w0.079: v1(203.84,260.87) 203.84,260.87 206.5,263.52 206.5,274.66 210.51,278.67 210.51,290.84 207.28,294.07 207.28,297.32 198.09,306.51 120.68,306.51 93.39,279.22 93.39,119.02 143.8,68.61 166.63,68.61 167.38,67.86 167.76,67.86 168.58,67.04 169.12,67.04 169.68,67.6 170.19,67.6 170.27,67.52 170.27,67.35 170.76,66.86 171.44,66.86 171.86,67.28 171.89,67.28 171.96,67.34 172.53,67.34 173.01,66.86 173.69,66.86 174.22,67.39 174.73,67.39 175.26,66.86 175.94,66.86 176.43,67.35 176.43,67.49 176.62,67.68 176.94,67.68 177.58,67.04 178.12,67.04 178.76,67.68 179.19,67.68 179.83,67.04 180.37,67.04 180.75,67.42 180.75,67.86 180.94,68.04 181.49,68.04 182.72,69.27 182.72,70.07 182.72,70.07 182.72,70.78 182.72,70.78 182.72,71.68 182.84,71.79 183,71.96 183,73.84 181.49,75.34 180.96,75.34 180.82,75.2 180.56,75.2 180.49,75.13 180.45,75.13 180.37,75.04 179.83,75.04 179.75,75.13 179.46,75.13 179.24,75.34 178.71,75.34 177.71,74.34 177.58,74.34 177.07,73.83 176.94,73.83 176.93,73.84 176.79,73.84 176.76,73.86 176.38,73.86 175.9,74.35 175.9,74.62 175.82,74.69 SLOT06.C57
SL06_DP_15: length 287
  L28_DP w0.079: v1(208.42,260.87) 208.42,248.32 203.45,243.36 202.22,243.36 201.42,242.56 201.42,233.26 201.63,233.05 201.63,229.78 200.72,228.87 200.71,228.87 200.43,228.6 200.43,228.58 199.72,227.87 199.72,227.13 198.4,225.81 195.18,225.81 194.73,226.26 191.8,226.26 190.94,225.39 190.55,225.39 188.8,227.14 188.8,227.47 188.6,227.67 188.6,238.61 188.69,238.69 188.69,240.67 187.86,241.5 177.42,241.5 177.27,241.35 171.36,241.35 171.21,241.5 169.34,241.5 168.52,240.68 168.52,240.68 167.22,239.38 165.25,237.41 162.01,237.41 158.96,234.36 158.96,227.7 158.78,227.53 158.78,227.13 158.96,226.96 158.96,225.93 156.57,223.54 155.88,223.54 154.14,221.8 154.14,221.11 153.93,220.9 153.93,198.98 154.54,198.37 154.54,197.98 153.93,197.37 153.93,194.15 154.54,193.55 154.54,193.16 153.93,192.55 153.93,188.12 153.09,187.28 153.09,182.22 154.87,180.44 154.91,180.44 155.67,179.68 155.67,179.64 155.73,179.58 155.73,178.84 158.65,175.92 158.71,175.92 158.99,175.64 158.99,175.58 159.47,175.09 160.31,175.09 165.89,169.51 165.89,96.44 183.2,79.13 183.2,75.58 181.44,73.83 180.88,73.83 180.37,74.34 179.83,74.34 179.32,73.83 178.63,73.83 177,75.46 176.29,75.46 175.87,75.04 175.33,75.04 174.91,75.46 174.04,75.46 173.62,75.04 172.58,75.04 SLOT06.D57
SL06_DP_16: length 456.3
  L30_DP w0.079: SLOT06.E57 171.51,74.69 171.58,74.63 171.58,74.42 171.96,74.04 172.49,74.04 172.87,74.42 172.87,74.61 173.04,74.78 173.75,74.78 173.83,74.7 173.83,74.42 174.21,74.04 174.87,74.04 174.95,73.96 174.95,73.42 175.33,73.04 175.87,73.04 176.51,73.68 176.69,73.68 176.71,73.66 176.85,73.66 176.87,73.65 176.94,73.65 177.47,73.12 177.51,73.12 177.58,73.04 178.12,73.04 178.19,73.12 178.35,73.12 179.76,74.52 180.44,74.52 180.85,74.11 180.89,74.11 181.01,73.99 182.04,73.99 182.72,73.31 182.72,72.07 182.44,71.79 182.44,70.66 182.44,70.19 181.96,69.71 181.67,69.71 181.64,69.68 181.3,69.68 180.41,68.8 180.25,68.8 179.32,67.86 178.63,67.86 177.99,68.5 177.71,68.5 177.07,67.86 176.55,67.86 176.25,67.57 176.25,67.42 175.87,67.04 175.33,67.04 174.81,67.57 174.14,67.57 173.62,67.04 173.08,67.04 172.56,67.57 171.89,67.57 171.37,67.04 170.83,67.04 170.45,67.42 170.45,67.6 170.27,67.78 169.98,67.78 169.9,67.86 169.63,67.86 169.15,68.35 169.15,68.39 168.98,68.56 168.47,68.56 168.37,68.46 168.37,68.42 167.99,68.04 167.46,68.04 166.6,68.9 144.68,68.9 144.59,68.99 144.2,68.99 93.86,119.33 93.86,278.53 121.01,305.69 197.88,305.69 206.06,297.51 206.06,293.71 209.93,289.84 209.93,278.91 206.08,275.06 206.08,266.79 203.96,264.68 v1(203.84,264.68)
SL06_DP_17: length 294.6
  L28_DP w0.079: SLOT06.F57 168.77,74.69 169.55,75.47 170.36,75.47 172.79,73.04 173.62,73.04 173.92,73.34 174.74,73.34 175.04,73.04 175.87,73.04 176.17,73.34 176.99,73.34 177.29,73.04 178.12,73.04 178.42,73.34 179.24,73.34 179.54,73.04 180.37,73.04 180.67,73.34 181.49,73.34 181.6,73.23 181.95,73.23 184.63,75.91 184.63,78.1 166.17,96.56 166.17,169.91 159.09,177 159.09,177.05 158.81,177.33 158.76,177.33 155.39,180.7 155.39,184.97 154.8,185.56 154.16,185.56 153.38,186.33 153.38,187.17 154.34,188.13 154.34,192.55 154.82,193.04 154.82,193.66 154.38,194.1 154.38,197.42 154.82,197.86 154.82,198.49 154.34,198.98 154.34,220.66 154.7,221.03 154.7,221.51 154.98,221.79 155.46,221.79 159.77,226.09 159.77,234.61 162.17,237.01 165.42,237.01 167.63,239.22 168.81,240.4 185.23,240.4 187.7,237.92 187.7,227.01 188.38,226.33 188.52,226.33 188.8,226.06 188.8,225.91 189.6,225.11 195.64,225.11 195.76,225.23 196.39,225.23 196.51,225.11 198.6,225.11 201.91,228.42 201.91,233.17 201.78,233.3 201.78,236.87 203.95,239.04 203.95,242.79 209.28,248.11 209.28,261.74 208.42,262.6 v1(208.42,264.68)
SL06_DP_18: length 437.8
  L30_DP w0.079: v1(203.84,267.72) 204.15,267.72 205.08,268.65 205.08,274.81 209.34,279.07 209.34,289.82 205.72,293.44 205.72,297.05 197.6,305.17 121.59,305.17 94.44,278.03 94.44,119.54 144.8,69.19 167.3,69.19 167.6,69.49 167.88,69.49 168.51,68.86 168.93,68.86 169.33,68.47 169.33,68.42 169.71,68.04 170.24,68.04 170.77,68.57 171.18,68.57 171.88,67.86 172.57,67.86 172.99,68.29 173.03,68.29 173.08,68.34 173.62,68.34 173.67,68.29 173.71,68.29 174.13,67.86 174.82,67.86 175.24,68.29 175.28,68.29 175.35,68.36 176.14,68.36 176.46,68.04 176.99,68.04 177.63,68.68 178.07,68.68 178.71,68.04 179.24,68.04 180.18,68.98 180.3,68.98 181.19,69.86 181.57,69.86 181.61,69.9 181.75,69.9 182.16,70.31 182.16,70.54 182.16,71.91 182.44,72.19 182.44,73.2 181.93,73.71 181.73,73.71 181.72,73.71 181,73.71 180.37,74.34 179.83,74.34 178.97,73.49 SLOT06.A55
SL06_DP_19: length 289.2
  L28_DP w0.079: v1(208.42,267.72) 208.42,266.42 209.16,265.67 209.16,263.57 210.99,261.74 210.99,249.22 204.23,242.46 204.23,238.55 202.77,237.09 202.77,234.89 202.83,234.83 202.83,234.7 203.04,234.49 203.04,232.46 202.19,231.61 202.19,228.3 198.72,224.83 196.39,224.83 196.27,224.95 195.88,224.95 195.76,224.83 189.49,224.83 188.92,225.39 188.13,225.39 187.86,225.67 187.86,225.85 187.78,225.93 187.59,225.93 187.21,226.32 187.21,236.66 184.16,239.71 178.83,239.71 177.27,238.15 176.44,238.15 175.85,238.73 174.66,238.73 174.07,238.15 173.24,238.15 171.68,239.71 168.7,239.71 165.59,236.6 162.34,236.6 160.18,234.44 160.18,225.48 157.31,222.62 157.31,221.82 154.7,219.22 154.7,216.55 154.74,216.51 154.74,212.41 154.7,212.37 154.7,199.01 155.11,198.61 155.11,197.75 154.74,197.39 154.74,194.14 155.11,193.78 155.11,192.92 154.74,192.56 154.74,187.81 155.67,186.89 155.67,182.12 156.94,180.84 156.94,179.89 166.45,170.38 166.45,96.67 185.18,77.95 185.18,75.6 181.48,71.91 180.81,71.91 180.37,72.34 179.83,72.34 179.39,71.91 178.56,71.91 177.77,72.69 SLOT06.B55
SL06_DP_20: length 435.3
  L30_DP w0.079: v1(203.84,270.77) 203.92,270.77 204.66,271.52 204.66,275 208.78,279.11 208.78,289.02 205.05,292.75 205.05,296.99 197.56,304.48 122.04,304.48 95.08,277.52 95.08,119.72 144.97,69.83 167.16,69.83 167.31,69.68 167.94,69.68 168.58,69.04 169.12,69.04 169.76,69.68 170.11,69.68 170.27,69.52 170.27,69.35 170.76,68.86 171.14,68.86 171.96,68.04 172.49,68.04 173.13,68.68 173.57,68.68 174.21,68.04 174.74,68.04 175.45,68.75 175.48,68.75 175.6,68.86 175.94,68.86 176.44,69.36 177.01,69.36 177.51,68.86 178.19,68.86 179.19,69.86 179.32,69.86 180.14,70.68 180.32,70.68 180.96,70.04 181.49,70.04 181.87,70.42 181.87,72.03 182.16,72.31 182.16,73.08 181.71,73.52 180.88,73.52 179.88,72.52 179.69,72.52 179.62,72.46 179.62,72.42 179.24,72.04 179.21,72.04 179.1,71.93 178.79,71.93 178.19,72.52 177.81,72.52 176.99,73.34 176.46,73.34 175.82,72.7 175.18,72.7 175.17,72.69 SLOT06.C55
SL06_DP_21: length 430.5
  L30_DP w0.079: v1(203.84,273.41) 203.9,273.41 204.34,273.85 204.34,275.46 208.25,279.37 208.25,288.04 203.78,292.51 203.78,297.48 197.71,303.56 122.19,303.56 95.83,277.19 95.83,119.68 145.36,70.15 167.1,70.15 167.38,69.86 168.1,69.86 168.58,70.34 169.12,70.34 169.6,69.86 170.27,69.86 170.45,69.69 170.45,69.42 170.83,69.04 171.37,69.04 171.96,69.63 172.2,69.63 172.97,68.86 173.69,68.86 174.34,69.51 174.86,69.51 175.33,69.04 175.87,69.04 176.36,69.54 177.09,69.54 177.58,69.04 178.12,69.04 178.5,69.42 178.5,69.88 178.66,70.04 179.24,70.04 180.06,70.86 180.44,70.86 181.4,71.83 181.4,71.96 181.87,72.42 181.87,72.96 181.49,73.34 180.96,73.34 179.96,72.34 179.83,72.34 179.45,71.96 179.45,71.84 179.25,71.64 178.82,71.64 178.12,72.34 177.58,72.34 177.2,71.96 177.2,71.67 177.06,71.53 176.51,71.53 176.43,71.6 176.43,72.04 175.94,72.52 175.26,72.52 174.78,72.04 174.17,72.04 173.52,72.69 SLOT06.D55
SL06_DP_22: length 364.1
  L28_DP w0.079: v1(196.08,272.17) 197.16,273.26 197.16,285.05 188.75,293.46 123.41,293.46 123.04,293.09 123.04,292.66 122.76,292.38 122.33,292.38 98.83,268.89 98.83,121.98 146.95,73.86 167.84,73.86 168.2,73.51 168.2,73.42 168.58,73.04 169.12,73.04 169.14,73.07 169.6,73.07 SLOT06.E55
SL06_DP_23: length 314.8
  L30_DP w0.079: SLOT06.F55 165.98,74.44 165.98,77.96 103.97,139.97 103.97,257.57 119.36,272.96 137.71,272.96 140.17,275.42 148.08,275.42 148.71,274.79 153.35,274.79 154.57,273.57 155.59,273.57 156.33,272.83 169.45,272.83 170.82,274.2 182.61,274.2 184.15,272.66 191.12,272.66 193.18,274.71 193.87,274.71 195.9,276.75 v1(196.08,276.75)
SL06_DP_24: length 337.8
  L30_DP w0.079: SLOT06.Z55 181.22,71.9 180.37,71.04 179.54,71.04 179.24,71.34 178.71,71.34 178.33,70.96 178.33,70.77 178.09,70.54 177.61,70.54 177.37,70.78 177.37,70.96 176.99,71.34 176.58,71.34 176.58,71.35 176.43,71.35 176.25,71.53 176.25,71.96 175.87,72.34 175.33,72.34 174.69,71.7 174.56,71.7 174.52,71.74 174.22,71.74 173.62,72.34 172.88,72.34 172.58,72.04 171.96,72.04 171.78,72.23 171.74,72.23 171.44,72.52 170.89,72.52 170.62,72.79 170.62,72.96 170.24,73.34 170.07,73.34 170.06,73.35 169.43,73.35 168.91,72.84 168.79,72.84 167.99,72.04 167.46,72.04 167.08,72.42 167.08,72.6 165.26,74.42 165.26,77.44 103.29,139.4 103.29,258.09 118.65,273.45 137.66,273.45 140.18,275.98 156.12,275.98 157.17,274.93 170.46,274.93 170.73,274.65 182.75,274.65 184.4,273.01 190.91,273.01 191.84,273.93 191.84,274.78 193.07,276.02 193.07,278.2 196.08,281.21 v1(196.08,281.32)
SL06_DP_25: length 375.4
  L28_DP w0.079: v1(193.15,272.17) 193.15,273.09 196.61,276.54 196.61,284.73 190.7,290.64 181.4,290.64 180.62,291.42 123.21,291.42 99.51,267.72 99.51,122.8 132.45,89.86 133.44,88.38 147.16,74.66 166.84,74.66 167.46,74.04 167.99,74.04 168.43,74.48 168.98,74.48 170.12,73.34 170.24,73.34 170.62,72.96 170.62,72.42 170.45,72.25 170.45,71.42 170.83,71.04 171.37,71.04 171.84,71.52 172.61,71.52 173.08,71.04 173.62,71.04 174.09,71.52 174.86,71.52 175.33,71.04 175.87,71.04 176.34,71.52 177.11,71.52 177.58,71.04 177.93,71.04 178.33,70.65 178.33,70.42 178.71,70.04 179.24,70.04 179.89,70.69 SLOT06.Z53
SL06_DP_26: length 341.7
  L30_DP w0.079: v1(193.15,282.59) 193.07,282.59 192.26,283.4 183.44,283.4 180.85,285.99 154.07,285.99 152.31,287.76 142.4,287.76 140.64,285.99 139.38,285.99 137.28,288.09 124.33,288.09 101.31,265.08 101.31,137.71 164.07,74.96 164.07,73.13 166.11,71.09 167.21,71.09 167.46,71.34 167.99,71.34 168.24,71.09 168.28,71.09 168.51,70.86 169.19,70.86 169.42,71.09 169.46,71.09 169.71,71.34 170.24,71.34 170.49,71.09 170.53,71.09 170.76,70.86 171.14,70.86 171.96,70.04 172.66,70.04 173.46,70.84 173.71,70.84 174.21,71.34 174.74,71.34 175.12,70.96 175.12,70.62 175.4,70.34 175.87,70.34 176.49,69.72 177.06,69.72 177.2,69.86 177.2,69.96 177.58,70.34 178.12,70.34 178.14,70.32 178.6,70.32 SLOT06.A53
SL06_DP_27: length 324.9
  L30_DP w0.079: v1(190.74,273.7) 184.38,273.7 182.76,275.32 158.46,275.32 153.28,280.5 143.7,280.5 137.17,273.98 118.18,273.98 102.7,258.49 102.7,138.8 164.8,76.69 164.8,73.57 165.55,72.81 165.7,72.81 166.65,71.86 168.08,71.86 168.64,72.42 169.33,72.42 169.71,72.04 170.53,72.04 170.83,72.34 171.37,72.34 171.67,72.04 171.7,72.04 171.88,71.86 172.26,71.86 173.08,71.04 173.62,71.04 174.02,71.45 174.06,71.45 174.13,71.52 174.82,71.52 175.65,70.69 SLOT06.B53
SL06_DP_28: length 334.7
  L30_DP w0.079: SLOT06.C53 174.47,69.9 173.62,69.04 173.08,69.04 172.26,69.86 171.88,69.86 171.32,70.43 170.63,70.43 170.24,70.04 169.71,70.04 169.33,70.42 169.33,70.55 169.2,70.67 168.62,70.67 167.99,70.04 167.46,70.04 166.83,70.67 165.95,70.67 163.79,72.84 163.79,73.86 100.77,136.88 100.77,265.69 123.47,288.4 157.23,288.4 157.92,287.71 161.22,287.71 161.55,288.04 182.64,288.04 185.85,284.83 190.06,284.83 190.74,284.15 v1(190.74,284.11)
SL06_DP_29: length 326.9
  L30_DP w0.079: SLOT06.D53 171.87,71.04 170.83,71.04 170.25,71.63 169.63,71.63 169.5,71.5 169.5,71.42 169.12,71.04 168.58,71.04 167.99,71.63 166.26,71.63 164.35,73.54 164.35,75.89 102,138.24 102,264.46 123.51,285.98 138.63,285.98 141.25,283.36 145.06,283.36 146.38,282.05 153.24,282.05 159.59,275.7 185.84,275.7 188.33,278.18 v1(188.33,278.27)
SL06_DP_30: length 494.3
  L28_DP w0.079: v1(265.41,286.99) 274.23,295.8 305.13,295.8 331.69,269.25 331.69,126.06 291.6,85.97 221.95,85.97 214.07,78.09 214.07,48.55 207.89,42.36 182.35,42.36 180.37,44.34 179.83,44.34 179.35,43.86 178.6,43.86 178.12,44.34 177.58,44.34 177.1,43.87 177.07,43.87 177.07,43.86 176.35,43.86 175.87,44.34 175.33,44.34 174.76,43.78 174.18,43.78 174,43.96 174,43.96 173.62,44.34 173.08,44.34 172.7,43.96 172.7,43.88 172.52,43.7 172.01,43.7 171.37,44.34 170.83,44.34 170.32,43.83 169.63,43.83 169.12,44.34 169,44.34 168.91,44.44 168.8,44.44 168.7,44.34 168.58,44.34 168.07,43.83 167.38,43.83 166.87,44.34 166.33,44.34 166.26,44.28 165.32,44.28 155.42,54.18 155.42,69.94 159.06,73.58 165.76,73.58 165.83,73.65 167.72,73.65 168.51,72.86 169,72.86 169.33,72.54 169.33,72.42 169.71,72.04 169.82,72.04 170.27,71.6 170.27,71.35 170.45,71.17 170.45,71.17 SLOT06.E53
SL06_DP_31: length 316.9
  L28_DP w0.079: SLOT06.F53 166.9,70.69 160.03,63.82 160.03,51.6 165.28,46.34 166.87,46.34 167.51,45.7 167.94,45.7 168.58,46.34 169.12,46.34 169.76,45.7 170.19,45.7 170.83,46.34 171.37,46.34 172.01,45.7 172.44,45.7 173.08,46.34 173.62,46.34 174.26,45.7 174.69,45.7 175.33,46.34 175.87,46.34 176.51,45.7 176.94,45.7 177.58,46.34 178.12,46.34 178.76,45.7 179.19,45.7 179.83,46.34 180.37,46.34 181.01,45.7 181.52,45.7 181.73,45.91 194.98,45.91 200.84,51.77 200.84,131.44 230.2,160.8 230.2,168.89 229.94,169.16 229.94,198.93 233.7,202.7 233.7,221.12 234.65,222.07 234.65,229.52 250.04,244.91 250.04,259.9 251.48,261.34 251.48,262.32 251.76,262.59 252.7,262.59 254.04,263.93 254.04,264.86 254.97,265.79 260.1,265.79 260.57,265.32 261.02,265.32 261.3,265.6 261.3,266.22 v1(260.83,266.69)
SL06_DP_32: length 339.3
  L28_DP w0.079: v1(260.83,264.66) 259.98,265.51 256.04,265.51 250.32,259.78 250.32,244.79 234.93,229.41 234.93,221.95 234.46,221.48 234.46,215.06 233.99,214.59 233.99,202.58 230.36,198.95 230.36,189.52 232.37,187.51 232.37,178.91 236,175.28 236,165.59 201.63,131.21 201.63,51.43 195.82,45.62 181.73,45.62 181.62,45.52 180.88,45.52 180.37,45.01 179.83,45.01 179.32,45.52 178.63,45.52 178.13,45.02 177.57,45.02 177.07,45.52 176.38,45.52 175.74,44.88 175.46,44.88 174.82,45.52 174.13,45.52 173.49,44.88 173.21,44.88 172.57,45.52 171.88,45.52 171.24,44.88 170.96,44.88 170.32,45.52 169.63,45.52 169.09,44.98 168.61,44.98 168.07,45.52 167.38,45.52 166.87,45.01 166.21,45.01 159.52,51.71 159.52,69.11 161.99,71.58 165.76,71.58 165.86,71.68 167.94,71.68 168.02,71.6 168.02,71.35 168.51,70.86 168.7,70.86 168.78,70.79 168.78,70.54 168.2,69.96 168.2,69.42 168.58,69.04 169.28,69.04 169.58,69.34 170.24,69.34 170.45,69.34 170.85,68.93 171.55,68.93 171.96,69.34 172.53,69.34 173.01,68.86 173.69,68.86 174.29,69.46 174.69,69.46 174.77,69.38 174.77,69.35 175.26,68.86 175.94,68.86 176.46,69.38 176.99,69.38 177.51,68.86 178.8,68.86 SLOT06.A51
SL06_DP_33: length 241.1
  L30_DP w0.079: v1(256.26,264.66) 255.65,264.06 255.65,263.42 250.79,258.56 250.79,244.33 240.65,234.18 240.65,231.87 236.3,227.53 235.96,227.53 235.68,227.8 235.29,227.8 235.02,227.53 235.02,226.25 233.87,225.1 233.87,201.96 232.48,200.57 232.48,189.43 233.05,188.85 233.05,178.9 234.23,177.73 234.88,177.73 241.54,171.08 241.54,161.87 200.8,121.13 200.8,88.78 203.23,86.35 203.23,79.84 199.55,76.16 199.55,67.2 193.02,60.67
SL06_DP_34: length 333.6
  L30_DP w0.079: 259.34,71.23 259.34,82.1 329.52,152.28 329.52,262.97 297.42,295.06 276.85,295.06 266.78,285 266.78,271.83 265.24,270.3 265.24,254.16 v1(266.06,253.35)
SL06_DP_35: length 209.9
  L30_DP w0.079: 201.16,68.06 201.16,75.2 204.97,78.98 204.97,87.53 202.32,90.18 202.32,119.91 247.99,165.58 247.99,190.16 248.03,190.34 248.03,190.64 247.99,190.82 247.99,200.01 247.48,200.53 247.48,202.81 246.07,204.22 246.07,204.87 245.79,205.15 245.13,205.15 243.37,206.91 243.37,211.05 238.51,218.33 238.16,219.16 237.99,220.04 237.99,220.94 238.16,221.82 238.51,222.65 239.01,223.4 239.64,224.03 240.39,224.53 241.22,224.88 242.1,225.05 243,225.05 243.88,224.88 244.95,224.88 245.22,225.14 245.24,225.19 245.4,225.43 245.61,225.64 245.85,225.8 245.9,225.82 255.26,235.19 255.26,240.74 UNK4K15.2
SL06_DP_36:
  vias: v1(268.22,258.18)
SL06_DP_37: length 543
  L28_DP w0.079: SLOT06.F51 168.03,68.39 169.07,68.39 169.67,67.79 170.28,67.79 170.83,68.34 171.37,68.34 171.89,67.82 172.56,67.82 173.08,68.34 173.62,68.34 174.24,67.72 174.71,67.72 175.33,68.34 175.87,68.34 176.57,67.65 177.01,67.65 177.2,67.84 177.2,67.96 177.58,68.34 178.12,68.34 178.5,67.96 178.5,67.86 178.65,67.71 179.32,67.71 179.45,67.84 179.45,67.96 179.85,68.36 179.85,69.02 179.01,69.86 178.63,69.86 178.15,70.34 177.29,70.34 176.99,70.04 176.46,70.04 176.16,70.34 175.04,70.34 174.74,70.04 174.21,70.04 173.91,70.34 172.79,70.34 172.49,70.04 171.96,70.04 171.39,70.61 170.8,70.61 170.24,70.04 169.71,70.04 169.33,70.42 169.33,71.06 169.58,71.32 169.58,71.91 169.15,72.35 169.15,72.44 169.01,72.58 168.58,72.58 168.12,72.12 168.06,72.12 167.99,72.04 167.46,72.04 167.08,72.42 167.08,72.62 166.47,73.23 160.18,73.23 157,70.05 157,53.31 165.79,44.52 166.94,44.52 167.32,44.15 167.35,44.15 167.46,44.04 167.99,44.04 168.1,44.15 168.13,44.15 168.51,44.52 168.62,44.52 168.72,44.62 168.98,44.62 169.08,44.52 169.19,44.52 169.57,44.15 169.6,44.15 169.74,44.01 170.24,44.01 170.76,44.52 171.44,44.52 172.09,43.88 172.44,43.88 172.52,43.96 172.52,44.04 173.01,44.52 173.69,44.52 174.18,44.04 174.18,44.04 174.26,43.96 174.69,43.96 175.26,44.52 175.94,44.52 176.42,44.05 176.45,44.05 176.46,44.04 176.99,44.04 176.99,44.05 177.03,44.05 177.51,44.52 178.19,44.52 178.68,44.04 179.27,44.04 179.76,44.52 179.91,44.52 180.44,44.52 180.85,44.11 180.89,44.11 182.35,42.65 207.54,42.65 213.33,48.43 213.33,77.95 221.94,86.56 290.69,86.56 330.14,126 330.14,264.46 300.57,294.02 278.22,294.02 269.24,285.04 269.24,278.42 268.79,277.96 268.79,272.97 265.73,269.91 265.73,265.62 267.01,264.34 267.01,259.35 267.61,258.75 267.61,254.72 268.22,254.11 v1(268.22,253.35)
SL06_DP_38: length 242.1
  L28_DP w0.079: 204.98,48.63 204.98,110.15 258.18,163.35 258.18,189.2 261.12,192.14 261.12,200.65 261.02,200.75 260.63,200.75 260.36,201.02 260.36,201.42 260.63,201.69 261.02,201.69 261.12,201.79 261.12,203.39 261.3,203.56 261.3,203.96 261.12,204.13 261.12,204.29 261.3,204.46 261.3,204.86 261.12,205.03 261.12,205.42 261.3,205.6 261.3,205.99 261.12,206.16 261.12,206.32 261.3,206.5 261.3,206.89 261.02,207.16 259.98,207.16 259.4,207.74 259.4,209.14 259.55,209.29 259.55,209.68 259.4,209.83 259.4,210.91 261.11,212.63 261.11,224.17 261.55,224.6 261.55,234.91 259.02,237.44 259.02,248.33 263.57,252.88 270.54,252.88 v1(271.01,253.35)
SL06_DP_39: length 250.6
  L28_DP w0.079: v1(273.17,258.18) 272.4,257.41 272.4,254.82 273.39,253.82 274.27,253.82 274.54,253.55 274.54,253.16 273.73,252.34 273.42,252.34 273.39,252.32 266.07,252.32 259.87,246.12 259.87,237.79 262.11,235.55 262.11,224.19 261.67,223.76 261.67,212 260.24,210.57 260.24,207.99 260.51,207.73 261.26,207.73 261.86,207.12 261.86,202.26 262.71,201.42 262.71,201.02 261.82,200.13 261.82,197.75 261.92,197.65 262.31,197.65 262.58,197.37 262.58,196.98 262.31,196.71 261.92,196.71 261.82,196.6 261.82,192.03 258.75,188.97 258.75,162.72 205.75,109.72 205.75,47.67
SL06_DP_40: length 241.1
  L28_DP w0.079: v1(273.17,253.35) 272.42,252.6 264.95,252.6 259.47,247.12 259.47,237.63 261.83,235.27 261.83,224.42 261.39,223.99 261.39,212.31 259.79,210.71 259.79,209.84 259.83,209.8 259.83,209.17 259.79,209.13 259.79,207.75 260.1,207.45 261.14,207.45 261.58,207 261.58,205.48 261.4,205.3 261.4,205.15 261.58,204.97 261.58,203.45 261.4,203.27 261.4,192.02 258.47,189.08 258.47,163.01 205.34,109.88 205.34,48.99
SL06_DP_41: length 298.2
  L30_DP w0.079: SLOT06.D49 172.23,66.68 173.57,66.68 174.21,66.04 174.74,66.04 175.38,66.68 175.82,66.68 176.46,66.04 176.99,66.04 177.73,66.78 178.11,66.78 178.67,67.34 179.24,67.34 179.72,66.86 180.44,66.86 180.92,67.34 181.49,67.34 181.67,67.17 182.45,67.17 192.32,77.04 192.32,91.96 192.33,92.03 192.33,93.39 192.32,93.46 192.32,167.84 192.16,167.99 192.16,173.89 192.24,173.96 192.24,184.92 191.6,185.56 190.66,185.56 189.88,186.33 189.88,199.14 184.82,204.2 184.82,215.55 186.83,217.55 190.21,217.55 195.6,222.95 195.6,223.26 195.88,223.54 196.2,223.54 200.59,227.93 201.1,227.93 201.38,228.21 201.38,228.72 205.14,232.48 205.14,233.05 205.42,233.33 206.36,233.33 216.58,243.55 217.27,243.55 217.86,244.13 217.86,245.45 225.59,253.18 225.59,253.55 225.86,253.82 226.36,253.82 228.02,255.49 228.14,255.49 240.55,267.89 240.55,267.92 241.69,269.06 243.61,269.06 243.65,269.1 248.61,269.1 248.69,269.01 259.17,269.01 264.77,263.41 264.77,250.76 270.18,245.35 270.18,243.36 UNK4K23.2
SL06_DP_42: length 342.7
  L30_DP w0.079: SLOT06.E49 170.67,66.69 170.68,66.68 171.32,66.68 171.96,66.04 172.49,66.04 172.95,66.5 173.49,66.5 174.13,65.86 174.82,65.86 175.46,66.5 175.74,66.5 176.38,65.86 177.07,65.86 177.78,66.57 178.18,66.57 178.71,66.04 179.24,66.04 179.8,66.61 179.84,66.61 179.84,66.61 180.36,66.61 180.36,66.61 180.39,66.61 180.96,66.04 181.49,66.04 181.53,66.08 181.66,66.08 181.73,66.15 182.26,66.15 192.91,76.79 192.91,173.3 193.11,173.5 193.11,173.89 192.52,174.48 192.52,186.84 191.6,187.76 191.06,187.76 190.26,188.56 190.26,196.74 190.3,196.78 190.3,199.49 185.16,204.63 185.16,214.68 187.75,217.27 190.33,217.27 190.57,217.52 191.09,217.52 192.06,218.49 192.54,218.49 193.63,219.57 193.63,220.44 194.98,221.79 195.46,221.79 203.45,229.78 203.45,230.14 203.73,230.41 204.05,230.41 208.06,234.42 209.12,234.42 209.39,234.7 209.39,235.48 212.06,238.15 214.07,238.15 214.66,238.73 214.66,240.74 215.26,241.35 217.27,241.35 218.14,242.22 218.14,244.4 226.62,252.88 227.15,252.88 227.43,253.16 227.43,253.56 228.69,254.82 228.69,255.62 231.72,258.65 232.77,258.65 233.64,259.52 233.64,260 237.54,263.9 238.26,263.9 239.74,265.38 239.74,265.73 240.97,266.96 242.91,266.96 242.99,267.04 242.99,267.07 243.09,267.17 258.3,267.17 258.41,267.07 258.41,266.7 259.97,265.13 261.02,265.13 261.3,264.86 261.3,261.02 261.11,260.84 261.11,253.09 263.07,251.13 263.59,251.13 268.98,245.74 268.98,228.28 270.92,226.33 270.94,226.33 271.21,226.06 271.21,226.05 272.49,224.77 272.92,224.77 272.96,224.81 273.35,224.81 273.39,224.77 275.38,224.77 277.38,226.77 277.38,231.33 277.12,231.59 277.12,234.07 277.38,234.33 277.38,240.3 UNK4K24.2
SL06_DP_43: length 461.9
  L28_DP w0.079: SLOT06.F49 166.81,67.61 166.81,68.91 167.19,69.3 167.41,69.3 167.46,69.34 167.99,69.34 168.04,69.3 168.07,69.3 168.5,68.86 168.85,68.86 169.67,68.04 170.28,68.04 170.76,68.52 171.44,68.52 171.92,68.04 172.49,68.04 172.97,68.52 173.69,68.52 174.31,67.91 174.64,67.91 175.26,68.52 175.94,68.52 176.56,67.91 176.89,67.91 177.51,68.52 178.19,68.52 178.67,68.04 179.27,68.04 179.62,68.4 179.62,68.96 179.24,69.34 178.42,69.34 178.12,69.04 177.58,69.04 177.06,69.57 176.39,69.57 175.87,69.04 175.33,69.04 174.95,69.42 174.95,69.48 174.87,69.56 174.85,69.56 174.77,69.64 174.22,69.64 173.62,69.04 173.08,69.04 172.7,69.42 172.7,69.46 172.64,69.52 172.22,69.52 171.32,70.43 170.88,70.43 170.32,69.86 169.63,69.86 169.15,70.35 169.15,70.87 168.97,71.04 168.58,71.04 168.2,71.42 168.2,71.81 168.16,71.86 161.6,71.86 157.67,67.93 157.67,53.04 166.01,44.7 166.82,44.7 167.46,45.34 167.99,45.34 168.54,44.8 169.25,44.8 169.33,44.88 169.33,44.96 169.71,45.34 170.24,45.34 170.88,44.7 171.32,44.7 171.96,45.34 172.49,45.34 173.13,44.7 173.57,44.7 174.21,45.34 174.74,45.34 175.38,44.7 175.94,44.7 176.08,44.84 176.08,44.96 176.46,45.34 176.99,45.34 177.5,44.84 178.2,44.84 178.71,45.34 179.24,45.34 179.65,44.93 203.88,44.93 212.98,54.03 212.98,89.28 231.37,107.67 282.53,107.67 320.21,145.35 320.21,250.66 300.6,270.27 288.48,270.27 286.53,268.32 286.53,267.12 286.85,266.81 286.85,265.58 286.25,264.99 286.25,264.36 287.1,263.52 287.1,263.04 284.19,260.13 281.35,260.13 281.33,260.11 280.59,260.11 277.54,257.07 277.54,254.42 v1(276.47,253.35)
