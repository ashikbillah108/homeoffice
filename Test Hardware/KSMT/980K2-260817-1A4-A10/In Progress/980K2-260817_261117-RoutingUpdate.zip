# Allegro board 980K2-260817_261117-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N18715511: length 3.4
  BOTTOM w0.203: UNK3U4.7 231.73,231.32 UNK3R18.2 230.81,232.54 230.6,232.74 UNK3TP_IN+_4.1
N18715515: length 3.4
  BOTTOM w0.203: UNK3TP_IN-_4.1 233.43,232.74 233.23,232.54 UNK3R18.1 232.33,231.32 UNK3U4.8
N18715526: length 7.5
  BOTTOM w0.508: 212.87,287.4 211.43,287.4 210.92,287.91 UNK3K61.4 UNK3R20.2
N18715527: length 1.5
  BOTTOM w0.203: UNK3RK54.1 237.37,238.99 UNK3K54.1
N18715531: length 1.5
  BOTTOM w0.203: UNK3RK51.1 228.32,248.69 UNK3K51.1
N18715533: length 1.5
  BOTTOM w0.203: UNK3RK52.1 229.12,238.99 UNK3K52.1
N18715597: length 1.5
  BOTTOM w0.203: UNK3K57.1 237.71,236.75 237.61,236.86
N18715598: length 1.5
  BOTTOM w0.203: 235.58,236.86 235.68,236.75 UNK3K58.1
N18715599: length 1.5
  BOTTOM w0.203: UNK3K59.1 232.63,236.75 232.53,236.86
N18715600: length 1.5
  BOTTOM w0.203: 230.5,236.86 230.6,236.75 UNK3K60.1
N18715603: length 1.5
  BOTTOM w0.203: UNK3RK61.1 207.86,291.95 UNK3K61.1
N18716734: length 2.2
  BOTTOM w0.635: UNK4C48.1 UNK4K2.3
N18716743: length 6.9
  BOTTOM w0.635: UNK4K3.3 256.91,274.45 256.27,273.81 UNK4C49.1
N18716752: length 1.5
  BOTTOM w0.508: UNK4C50.1 UNK4K5.3
N18716785: length 1.5
  BOTTOM w0.203: UNK4K7.1 257.77,263.76 UNK4RK7.1
N18716792: length 1.5
  BOTTOM w0.203: UNK4C53.1 262.14,262.02 UNK4K8.3
N18716801: length 1.5
  BOTTOM w0.203: UNK4C54.1 256.42,262.02 UNK4K9.3
N18716831: length 6.9
  BOTTOM w0.508: 262.67,253.35 UNK4K12.3
  BOTTOM w0.635: UNK4C59.1 260.59,249.17 262.22,250.8 262.22,252.9 262.67,253.35
N18716838: length 1.5
  BOTTOM w0.203: UNK4R1.1 263.36,248.69 UNK4K13.3
N18716856: length 25.6
  BOTTOM w0.203: v2(267.45,265.74) 263.32,261.61 263.32,260.79 261.35,258.83 261.35,251.59 258.34,248.58 258.34,246.04 UNK4K15.6
N18716874: length 1.5
  BOTTOM w0.203: UNK4RK5.1 257.77,268.59 UNK4K5.1
N18716876: length 1.5
  BOTTOM w0.203: UNK4K6.1 257.77,265.79 UNK4RK6.1
N18716878: length 1.5
  BOTTOM w0.203: UNK4RK8.1 257.77,261.22 UNK4K8.1
N18716879: length 1.5
  BOTTOM w0.203: UNK4RK9.1 252.05,261.22 UNK4K9.1
N18716880: length 1.5
  BOTTOM w0.203: UNK4RK10.1 253.2,263.76 UNK4K10.1
N18716881: length 1.5
  BOTTOM w0.203: UNK4K11.1 264.16,255.12 UNK4RK11.1
N18716884: length 1.3
  BOTTOM w0.508: UNK4C58.1 UNK4K11.3
N18716887: length 1.5
  BOTTOM w0.203: UNK4K12.1 264.16,250.29 UNK4RK12.1
N18716889: length 1.5
  BOTTOM w0.203: UNK4K13.1 264.16,244.32 UNK4RK13.1
N18716892: length 1.5
  BOTTOM w0.203: UNK4K14.1 266.96,250.29 UNK4RK14.1
N18716894: length 3.4
  BOTTOM w0.203: UNK4RK2.1 262.47,283.73 262.87,283.32 UNK4K2.1
N18716895: length 1.9
  BOTTOM w0.203: UNK4K3.1 UNK4RK3.1
N18716896: length 2.4
  BOTTOM w0.203: UNK4RK4.1 262.04,296.93 262.87,296.1 UNK4K4.1
N18716916: length 27.9
  TOP w0.305: SITE4.8_F 266.71,265.4
  TOP w0.635: UNK4K15.3 255.29,246.19 255.29,247.82 255.89,248.41 257.92,248.41 265.16,255.65 265.16,263.85 266.71,265.4
N18716928: length 1.5
  BOTTOM w0.203: UNK4C60.1 UNK4K16.3
N18716941: length 1.5
  BOTTOM w0.203: UNK4RK17.1 269.12,255.12 UNK4K17.1
N18716955: length 1.5
  BOTTOM w0.203: UNK4K16.1 266.96,255.12 UNK4RK16.1
N18716959: length 1.5
  BOTTOM w0.203: UNK4K18.1 269.12,250.29 UNK4RK18.1
N18718109: length 1.5
  BOTTOM w0.203: UNK4C69.1 UNK4K19.3
N18718136: length 1.5
  BOTTOM w0.203: UNK4RK19.1 271.91,255.12 UNK4K19.1
N18718138: length 1.5
  BOTTOM w0.203: UNK4RK20.1 271.91,250.29 UNK4K20.1
N18718139: length 1.5
  BOTTOM w0.203: UNK4K21.1 274.07,255.12 UNK4RK21.1
N18718164: length 1.5
  BOTTOM w0.203: UNK4RK22.1 274.07,250.29 UNK4K22.1
N18718170: length 24.1
  BOTTOM w0.203: 274.38,244.3 273.24,245.44 273.24,247.49 274.81,249.07 274.81,259.97 270.3,264.48 v2(270.3,265.39)
N18718184: length 28.6
  BOTTOM w0.203: 282.64,244.3 281.15,245.78 281.15,248.53 280.21,249.48 275.8,249.48 275.32,249.96 275.32,260.22 270.8,264.74 v2(270.8,265.39)
N18718194: length 1.5
  BOTTOM w0.203: UNK4C62.1 UNK4K25.3
N18718212: length 1.5
  BOTTOM w0.203: UNK4K25.1 277.37,255.12 UNK4RK25.1
N18718216: length 1.5
  BOTTOM w0.203: UNK4RK26.1 277.37,250.29 UNK4K26.1
N18718221: length 1.5
  BOTTOM w0.203: UNK4C63.1 UNK4K27.3
N18718237: length 1.5
  BOTTOM w0.203: UNK4K28.1 286.9,261.77 UNK4RK28.1
N18718258: length 1.5
  BOTTOM w0.203: UNK4K27.1 282.33,261.77 UNK4RK27.1
N18718260: length 1.1
  BOTTOM w0.203: UNK4RK29.1 UNK4K29.1
N18718265: length 1.5
  BOTTOM w0.203: UNK4C61.1 UNK4K30.3
N18718279: length 1.5
  BOTTOM w0.203: UNK4RK31.1 286.9,265.58 UNK4K31.1
N18718299: length 1.5
  BOTTOM w0.203: UNK4RK30.1 282.33,265.58 UNK4K30.1
N18718302: length 1.1
  BOTTOM w0.203: UNK4RK32.1 UNK4K32.1
N18718304: length 1.5
  BOTTOM w0.203: UNK4K35.1 291.48,268.62 UNK4RK35.1
N18718306: length 1.5
  BOTTOM w0.203: UNK4K34.1 286.9,268.62 UNK4RK34.1
N18718308: length 1.5
  BOTTOM w0.203: UNK4K33.1 282.33,268.62 UNK4RK33.1
N18718311: length 1.5
  BOTTOM w0.203: UNK4C64.1 UNK4K33.3
N18718346: length 1.5
  BOTTOM w0.203: UNK4K37.1 286.9,271.67 UNK4RK37.1
N18718347: length 1.5
  BOTTOM w0.203: UNK4RK36.1 282.33,271.67 UNK4K36.1
N18718353: length 1.5
  BOTTOM w0.203: UNK4C65.1 UNK4K36.3
N18719639: length 1.5
  BOTTOM w0.203: UNK4K39.1 286.9,274.21 UNK4RK39.1
N18719640: length 1.5
  BOTTOM w0.203: UNK4K38.1 282.33,274.21 UNK4RK38.1
N18719646: length 1.5
  BOTTOM w0.203: UNK4C74.1 UNK4K38.3
N18719665: length 1.5
  BOTTOM w0.203: UNK4RK40.1 275.17,275.24 UNK4K40.1
N18719678: length 1.5
  BOTTOM w0.203: UNK4K41.1 275.17,279.81 UNK4RK41.1
N18719691: length 1.5
  BOTTOM w0.203: UNK4K42.1 275.17,284.38 UNK4RK42.1
N18719703: length 1.5
  BOTTOM w0.203: UNK4K43.1 272.25,275.24 UNK4RK43.1
N18719716: length 1.5
  BOTTOM w0.203: UNK4K45.1 272.25,285.65 UNK4RK45.1
N18719717: length 1.5
  BOTTOM w0.203: UNK4RK44.1 272.25,281.08 UNK4K44.1
N18719727: length 1.5
  BOTTOM w0.203: UNK4C66.1 273.05,276.71 UNK4K44.3
N18719745: length 1.5
  BOTTOM w0.203: UNK4RK46.1 269.84,276.76 UNK4K46.1
N18719761: length 1.5
  BOTTOM w0.203: UNK4C67.1 270.64,278.23 UNK4K47.3
N18719774: length 1.5
  BOTTOM w0.203: UNK4K48.1 269.84,287.17 UNK4RK48.1
N18719775: length 1.5
  BOTTOM w0.203: UNK4RK47.1 269.84,282.6 UNK4K47.1
N18719785: length 1.5
  BOTTOM w0.203: UNK4K49.3 268.23,282.8 UNK4C68.1
N18719798: length 1.5
  BOTTOM w0.203: UNK4RK50.1 267.43,281.33 UNK4K50.1
N18719799: length 1.5
  BOTTOM w0.203: UNK4K49.1 267.43,287.17 UNK4RK49.1
N18720613: length 1.3
  BOTTOM w0.203: UNK4R7.2 268.32,244.45 UNK4K51.4
N18720625: length 1.3
  BOTTOM w0.203: UNK4K53.4 276.57,244.45 UNK4R8.2
N18720627: length 1.5
  BOTTOM w0.203: UNK4RK53.1 276.57,248.69 UNK4K53.1
N18720649: length 2.3
  BOTTOM w0.203: UNK4R19.1 UNK4R11.2 v1(246.61,294.24)
N18720661: length 2.3
  BOTTOM w0.203: v1(253.21,294.24) UNK4R14.2 UNK4R20.1
N18720671: length 1.5
  BOTTOM w0.203: UNK4RK59.1 241.26,291.95 UNK4K55.1
N18720674: length 1.3
  BOTTOM w0.508: UNK4R19.2 UNK4K55.4
N18720676: length 3
  BOTTOM w0.305: UNK4RK60.1 243.92,287.4
N18720693: length 3.4
  BOTTOM w0.203: UNK4TP_IN-_3.1 278.51,232.74 278.31,232.54 UNK4R16.1 277.41,231.32 UNK4U3.8
N18720694: length 3.4
  BOTTOM w0.203: UNK4U3.7 276.81,231.32 UNK4R16.2 275.89,232.54 275.68,232.74 UNK4TP_IN+_3.1
N18720722: length 3.4
  BOTTOM w0.203: UNK4TP_IN+_4.1 270.6,232.74 270.81,232.54 UNK4R18.2 271.73,231.32 UNK4U4.7
N18720726: length 3.4
  BOTTOM w0.203: UNK4TP_IN-_4.1 273.43,232.74 273.23,232.54 UNK4R18.1 272.33,231.32 UNK4U4.8
N18720737: length 7.5
  BOTTOM w0.508: 252.87,287.4 251.43,287.4 250.92,287.91 UNK4K61.4 UNK4R20.2
N18720738: length 1.5
  BOTTOM w0.203: UNK4K54.1 277.37,238.99 UNK4RK54.1
N18720742: length 1.5
  BOTTOM w0.203: UNK4RK51.1 268.32,248.69 UNK4K51.1
N18720744: length 1.5
  BOTTOM w0.203: UNK4K52.1 269.12,238.99 UNK4RK52.1
N18720808: length 1.5
  BOTTOM w0.203: 277.61,236.86 277.71,236.75 UNK4K57.1
N18720809: length 1.5
  BOTTOM w0.203: UNK4K58.1 275.68,236.75 275.58,236.86
N18720810: length 1.5
  BOTTOM w0.203: UNK4K59.1 272.63,236.75 272.53,236.86
N18720811: length 1.5
  BOTTOM w0.203: 270.5,236.86 270.6,236.75 UNK4K60.1
N18720814: length 1.5
  BOTTOM w0.203: UNK4K61.1 247.86,291.95 UNK4RK61.1
N18721945: length 2.2
  BOTTOM w0.635: UNK5C48.1 UNK5K2.3
N18721954: length 6.9
  BOTTOM w0.635: UNK5K3.3 136.91,214.45 136.27,213.81 UNK5C49.1
N18721963: length 1.5
  BOTTOM w0.508: UNK5C50.1 UNK5K5.3
N18721996: length 1.5
  BOTTOM w0.203: UNK5K7.1 137.77,203.76 UNK5RK7.1
N18722003: length 1.5
  BOTTOM w0.203: UNK5C53.1 142.14,202.02 UNK5K8.3
N18722012: length 1.5
  BOTTOM w0.203: UNK5C54.1 136.42,202.02 UNK5K9.3
N18722042: length 6.9
  BOTTOM w0.508: 142.67,193.35 UNK5K12.3
  BOTTOM w0.635: 142.67,193.35 142.22,192.9 142.22,190.8 140.59,189.17 UNK5C59.1
N18722049: length 1.5
  BOTTOM w0.203: UNK5K13.3 143.36,188.69 UNK5R1.1
N18722067: length 25.6
  BOTTOM w0.203: v2(147.45,205.74) 143.32,201.61 143.32,200.79 141.35,198.83 141.35,191.59 138.34,188.58 138.34,186.04 UNK5K15.6
N18722085: length 1.5
  BOTTOM w0.203: UNK5K5.1 137.77,208.59 UNK5RK5.1
N18722087: length 1.5
  BOTTOM w0.203: UNK5K6.1 137.77,205.79 UNK5RK6.1
N18722089: length 1.5
  BOTTOM w0.203: UNK5K8.1 137.77,201.22 UNK5RK8.1
N18722090: length 1.5
  BOTTOM w0.203: UNK5RK9.1 132.05,201.22 UNK5K9.1
N18722091: length 1.5
  BOTTOM w0.203: UNK5RK10.1 133.2,203.76 UNK5K10.1
N18722092: length 1.5
  BOTTOM w0.203: UNK5K11.1 144.16,195.12 UNK5RK11.1
N18722095: length 1.3
  BOTTOM w0.508: UNK5C58.1 UNK5K11.3
N18722098: length 1.5
  BOTTOM w0.203: UNK5RK12.1 144.16,190.29 UNK5K12.1
N18722100: length 1.5
  BOTTOM w0.203: UNK5K13.1 144.16,184.32 UNK5RK13.1
N18722103: length 1.5
  BOTTOM w0.203: UNK5RK14.1 146.96,190.29 UNK5K14.1
N18722105: length 3.4
  BOTTOM w0.203: UNK5K2.1 142.88,223.32 142.47,223.73 UNK5RK2.1
N18722106: length 1.9
  BOTTOM w0.203: UNK5K3.1 UNK5RK3.1
N18722107: length 2.4
  BOTTOM w0.203: UNK5K4.1 142.88,236.1 142.04,236.93 UNK5RK4.1
N18722127: length 27.9
  TOP w0.305: SITE5.8_F 146.71,205.4
  TOP w0.635: 146.71,205.4 145.16,203.85 145.16,195.65 137.92,188.41 135.89,188.41 135.29,187.82 135.29,186.19 UNK5K15.3
N18722139: length 1.5
  BOTTOM w0.203: UNK5C60.1 UNK5K16.3
N18722152: length 1.5
  BOTTOM w0.203: UNK5K17.1 149.12,195.12 UNK5RK17.1
N18722166: length 1.5
  BOTTOM w0.203: UNK5K16.1 146.96,195.12 UNK5RK16.1
N18722170: length 1.5
  BOTTOM w0.203: UNK5RK18.1 149.12,190.29 UNK5K18.1
N18723320: length 1.5
  BOTTOM w0.203: UNK5C69.1 UNK5K19.3
N18723347: length 1.5
  BOTTOM w0.203: UNK5K19.1 151.91,195.12 UNK5RK19.1
N18723349: length 1.5
  BOTTOM w0.203: UNK5K20.1 151.91,190.29 UNK5RK20.1
N18723350: length 1.5
  BOTTOM w0.203: UNK5K21.1 154.07,195.12 UNK5RK21.1
N18723375: length 1.5
  BOTTOM w0.203: UNK5RK22.1 154.07,190.29 UNK5K22.1
N18723381: length 24.1
  BOTTOM w0.203: v2(150.3,205.39) 150.3,204.48 154.81,199.97 154.81,189.07 153.24,187.49 153.24,185.44 154.38,184.3
N18723395: length 28.6
  BOTTOM w0.203: v2(150.8,205.39) 150.8,204.74 155.32,200.22 155.32,189.96 155.8,189.48 160.21,189.48 161.15,188.53 161.15,185.78 162.64,184.3
N18723405: length 1.5
  BOTTOM w0.203: UNK5C62.1 UNK5K25.3
N18723423: length 1.5
  BOTTOM w0.203: UNK5RK25.1 157.37,195.12 UNK5K25.1
N18723427: length 1.5
  BOTTOM w0.203: UNK5K26.1 157.37,190.29 UNK5RK26.1
N18723432: length 1.5
  BOTTOM w0.203: UNK5C63.1 UNK5K27.3
N18723448: length 1.5
  BOTTOM w0.203: UNK5K28.1 166.9,201.77 UNK5RK28.1
N18723469: length 1.5
  BOTTOM w0.203: UNK5RK27.1 162.33,201.77 UNK5K27.1
N18723471: length 1.1
  BOTTOM w0.203: UNK5RK29.1 UNK5K29.1
N18723476: length 1.5
  BOTTOM w0.203: UNK5C61.1 UNK5K30.3
N18723490: length 1.5
  BOTTOM w0.203: UNK5K31.1 166.9,205.58 UNK5RK31.1
N18723510: length 1.5
  BOTTOM w0.203: UNK5RK30.1 162.33,205.58 UNK5K30.1
N18723513: length 1.1
  BOTTOM w0.203: UNK5RK32.1 UNK5K32.1
N18723515: length 1.5
  BOTTOM w0.203: UNK5RK35.1 171.48,208.62 UNK5K35.1
N18723517: length 1.5
  BOTTOM w0.203: UNK5RK34.1 166.9,208.62 UNK5K34.1
N18723519: length 1.5
  BOTTOM w0.203: UNK5RK33.1 162.33,208.62 UNK5K33.1
N18723522: length 1.5
  BOTTOM w0.203: UNK5C64.1 UNK5K33.3
N18723557: length 1.5
  BOTTOM w0.203: UNK5RK37.1 166.9,211.67 UNK5K37.1
N18723558: length 1.5
  BOTTOM w0.203: UNK5K36.1 162.33,211.67 UNK5RK36.1
N18723564: length 1.5
  BOTTOM w0.203: UNK5C65.1 UNK5K36.3
N18724850: length 1.5
  BOTTOM w0.203: UNK5K39.1 166.9,214.21 UNK5RK39.1
N18724851: length 1.5
  BOTTOM w0.203: UNK5RK38.1 162.33,214.21 UNK5K38.1
N18724857: length 1.5
  BOTTOM w0.203: UNK5C74.1 UNK5K38.3
N18724876: length 1.5
  BOTTOM w0.203: UNK5RK40.1 155.17,215.24 UNK5K40.1
N18724889: length 1.5
  BOTTOM w0.203: UNK5RK41.1 155.17,219.81 UNK5K41.1
N18724902: length 1.5
  BOTTOM w0.203: UNK5K42.1 155.17,224.38 UNK5RK42.1
N18724914: length 1.5
  BOTTOM w0.203: UNK5K43.1 152.25,215.24 UNK5RK43.1
N18724927: length 1.5
  BOTTOM w0.203: UNK5K45.1 152.25,225.65 UNK5RK45.1
N18724928: length 1.5
  BOTTOM w0.203: UNK5K44.1 152.25,221.08 UNK5RK44.1
N18724938: length 1.5
  BOTTOM w0.203: UNK5K44.3 153.05,216.71 UNK5C66.1
N18724956: length 1.5
  BOTTOM w0.203: UNK5K46.1 149.84,216.76 UNK5RK46.1
N18724972: length 1.5
  BOTTOM w0.203: UNK5K47.3 150.64,218.23 UNK5C67.1
N18724985: length 1.5
  BOTTOM w0.203: UNK5RK48.1 149.84,227.17 UNK5K48.1
N18724986: length 1.5
  BOTTOM w0.203: UNK5K47.1 149.84,222.6 UNK5RK47.1
N18724996: length 1.5
  BOTTOM w0.203: UNK5C68.1 148.23,222.8 UNK5K49.3
N18725009: length 1.5
  BOTTOM w0.203: UNK5RK50.1 147.43,221.33 UNK5K50.1
N18725010: length 1.5
  BOTTOM w0.203: UNK5K49.1 147.43,227.17 UNK5RK49.1
N18725824: length 1.3
  BOTTOM w0.203: UNK5R7.2 148.32,184.45 UNK5K51.4
N18725836: length 1.3
  BOTTOM w0.203: UNK5R8.2 156.57,184.45 UNK5K53.4
N18725838: length 1.5
  BOTTOM w0.203: UNK5RK53.1 156.57,188.69 UNK5K53.1
N18725860: length 2.3
  BOTTOM w0.203: v1(126.61,234.24) UNK5R11.2 UNK5R19.1
N18725872: length 2.3
  BOTTOM w0.203: UNK5R20.1 UNK5R14.2 v1(133.22,234.24)
N18725882: length 1.5
  BOTTOM w0.203: UNK5RK59.1 121.26,231.95 UNK5K55.1
N18725885: length 1.3
  BOTTOM w0.508: UNK5R19.2 UNK5K55.4
N18725887: length 3
  BOTTOM w0.305: UNK5RK60.1 UNK5K56.1
N18725904: length 3.4
  BOTTOM w0.203: UNK5U3.8 157.41,171.32 UNK5R16.1 158.31,172.54 158.52,172.74 UNK5TP_IN-_3.1
N18725905: length 3.4
  BOTTOM w0.203: UNK5U3.7 156.81,171.32 UNK5R16.2 155.89,172.54 155.68,172.74 UNK5TP_IN+_3.1
N18725933: length 3.4
  BOTTOM w0.203: UNK5U4.7 151.73,171.32 UNK5R18.2 150.81,172.54 150.6,172.74 UNK5TP_IN+_4.1
N18725937: length 3.4
  BOTTOM w0.203: UNK5TP_IN-_4.1 153.44,172.74 153.23,172.54 UNK5R18.1 152.33,171.32 UNK5U4.8
N18725948: length 7.5
  BOTTOM w0.508: UNK5R20.2 UNK5K61.4 130.92,227.91 131.43,227.4 UNK5K56.4
N18725949: length 1.5
  BOTTOM w0.203: UNK5RK54.1 157.37,178.99 UNK5K54.1
N18725953: length 1.5
  BOTTOM w0.203: UNK5K51.1 148.32,188.69 UNK5RK51.1
N18725955: length 1.5
  BOTTOM w0.203: UNK5RK52.1 149.12,178.99 UNK5K52.1
N18726019: length 1.5
  BOTTOM w0.203: UNK5K57.1 157.71,176.76 UNK5RK55.2
N18726020: length 1.5
  BOTTOM w0.203: UNK5RK56.2 155.68,176.76 UNK5K58.1
N18726021: length 1.5
  BOTTOM w0.203: UNK5K59.1 152.63,176.76 UNK5RK57.2
N18726022: length 1.5
  BOTTOM w0.203: UNK5RK58.2 150.6,176.76 UNK5K60.1
N18726025: length 1.5
  BOTTOM w0.203: UNK5K61.1 127.86,231.95 UNK5RK61.1
N18727156: length 2.2
  BOTTOM w0.635: UNK6C48.1 UNK6K2.3
N18727165: length 6.9
  BOTTOM w0.635: UNK6C49.1 176.27,213.81 176.91,214.45 UNK6K3.3
N18727174: length 1.5
  BOTTOM w0.508: UNK6C50.1 UNK6K5.3
N18727207: length 1.5
  BOTTOM w0.203: UNK6K7.1 177.77,203.76 UNK6RK7.1
N18727214: length 1.5
  BOTTOM w0.203: UNK6C53.1 182.14,202.02 UNK6K8.3
N18727223: length 1.5
  BOTTOM w0.203: UNK6K9.3 176.42,202.02 UNK6C54.1
N18727253: length 6.9
  BOTTOM w0.508: 182.67,193.35 UNK6K12.3
  BOTTOM w0.635: UNK6C59.1 180.59,189.17 182.22,190.8 182.22,192.9 182.67,193.35
N18727260: length 1.5
  BOTTOM w0.203: UNK6R1.1 183.36,188.69 UNK6K13.3
N18727278: length 25.6
  BOTTOM w0.203: v2(187.45,205.74) 183.32,201.61 183.32,200.79 181.35,198.83 181.35,191.59 178.34,188.58 178.34,186.04 UNK6K15.6
N18727296: length 1.5
  BOTTOM w0.203: UNK6RK5.1 177.77,208.59 UNK6K5.1
N18727298: length 1.5
  BOTTOM w0.203: UNK6RK6.1 177.77,205.79 UNK6K6.1
N18727300: length 1.5
  BOTTOM w0.203: UNK6K8.1 177.77,201.22 UNK6RK8.1
N18727301: length 1.5
  BOTTOM w0.203: UNK6K9.1 172.05,201.22 UNK6RK9.1
N18727302: length 1.5
  BOTTOM w0.203: UNK6RK10.1 173.2,203.76 UNK6K10.1
N18727303: length 1.5
  BOTTOM w0.203: UNK6RK11.1 184.16,195.12 UNK6K11.1
N18727306: length 1.3
  BOTTOM w0.508: UNK6C58.1 UNK6K11.3
N18727309: length 1.5
  BOTTOM w0.203: UNK6RK12.1 184.16,190.29 UNK6K12.1
N18727311: length 1.5
  BOTTOM w0.203: UNK6RK13.1 184.16,184.32 UNK6K13.1
N18727314: length 1.5
  BOTTOM w0.203: UNK6K14.1 186.96,190.29 UNK6RK14.1
N18727316: length 3.4
  BOTTOM w0.203: UNK6RK2.1 182.47,223.73 182.87,223.32 UNK6K2.1
N18727317: length 1.9
  BOTTOM w0.203: UNK6K3.1 UNK6RK3.1
N18727318: length 2.4
  BOTTOM w0.203: UNK6K4.1 182.87,236.1 182.04,236.93 UNK6RK4.1
N18727338: length 27.9
  TOP w0.305: SITE6.8_F 186.71,205.4
  TOP w0.635: 186.71,205.4 185.16,203.85 185.16,195.65 177.92,188.41 175.89,188.41 175.29,187.82 175.29,186.19 UNK6K15.3
N18727350: length 1.5
  BOTTOM w0.203: UNK6C60.1 UNK6K16.3
N18727363: length 1.5
  BOTTOM w0.203: UNK6K17.1 189.12,195.12 UNK6RK17.1
N18727377: length 1.5
  BOTTOM w0.203: UNK6RK16.1 186.96,195.12 UNK6K16.1
N18727381: length 1.5
  BOTTOM w0.203: UNK6RK18.1 189.12,190.29 UNK6K18.1
N18728531: length 1.5
  BOTTOM w0.203: UNK6C69.1 UNK6K19.3
N18728558: length 1.5
  BOTTOM w0.203: UNK6K19.1 191.91,195.12 UNK6RK19.1
N18728560: length 1.5
  BOTTOM w0.203: UNK6K20.1 191.91,190.29 UNK6RK20.1
N18728561: length 1.5
  BOTTOM w0.203: UNK6K21.1 194.07,195.12 UNK6RK21.1
N18728586: length 1.5
  BOTTOM w0.203: UNK6RK22.1 194.07,190.29 UNK6K22.1
N18728592: length 24.1
  BOTTOM w0.203: v2(190.3,205.39) 190.3,204.48 194.81,199.97 194.81,189.07 193.24,187.49 193.24,185.44 194.38,184.3
N18728606: length 28.6
  BOTTOM w0.203: v2(190.8,205.39) 190.8,204.74 195.32,200.22 195.32,189.96 195.8,189.48 200.21,189.48 201.15,188.53 201.15,185.78 202.64,184.3
N18728616: length 1.5
  BOTTOM w0.203: UNK6C62.1 UNK6K25.3
N18728634: length 1.5
  BOTTOM w0.203: UNK6RK25.1 197.37,195.12 UNK6K25.1
N18728638: length 1.5
  BOTTOM w0.203: UNK6RK26.1 197.37,190.29 UNK6K26.1
N18728643: length 1.5
  BOTTOM w0.203: UNK6C63.1 UNK6K27.3
N18728659: length 1.5
  BOTTOM w0.203: UNK6K28.1 206.9,201.77 UNK6RK28.1
N18728680: length 1.5
  BOTTOM w0.203: UNK6K27.1 202.33,201.77 UNK6RK27.1
N18728682: length 1.1
  BOTTOM w0.203: UNK6RK29.1 UNK6K29.1
N18728687: length 1.5
  BOTTOM w0.203: UNK6C61.1 UNK6K30.3
N18728701: length 1.5
  BOTTOM w0.203: UNK6K31.1 206.9,205.58 UNK6RK31.1
N18728721: length 1.5
  BOTTOM w0.203: UNK6K30.1 202.33,205.58 UNK6RK30.1
N18728724: length 1.1
  BOTTOM w0.203: UNK6RK32.1 UNK6K32.1
N18728726: length 1.5
  BOTTOM w0.203: UNK6K35.1 211.48,208.62 UNK6RK35.1
N18728728: length 1.5
  BOTTOM w0.203: UNK6K34.1 206.9,208.62 UNK6RK34.1
N18728730: length 1.5
  BOTTOM w0.203: UNK6K33.1 202.33,208.62 UNK6RK33.1
N18728733: length 1.5
  BOTTOM w0.203: UNK6C64.1 UNK6K33.3
N18728768: length 1.5
  BOTTOM w0.203: UNK6K37.1 206.9,211.67 UNK6RK37.1
N18728769: length 1.5
  BOTTOM w0.203: UNK6K36.1 202.33,211.67 UNK6RK36.1
N18728775: length 1.5
  BOTTOM w0.203: UNK6C65.1 UNK6K36.3
N18730061: length 1.5
  BOTTOM w0.203: UNK6RK39.1 206.9,214.21 UNK6K39.1
N18730062: length 1.5
  BOTTOM w0.203: UNK6RK38.1 202.33,214.21 UNK6K38.1
N18730068: length 1.5
  BOTTOM w0.203: UNK6C74.1 UNK6K38.3
N18730087: length 1.5
  BOTTOM w0.203: UNK6K40.1 195.17,215.24 UNK6RK40.1
N18730100: length 1.5
  BOTTOM w0.203: UNK6RK41.1 195.17,219.81 UNK6K41.1
N18730113: length 1.5
  BOTTOM w0.203: UNK6RK42.1 195.17,224.38 UNK6K42.1
N18730125: length 1.5
  BOTTOM w0.203: UNK6RK43.1 192.25,215.24 UNK6K43.1
N18730138: length 1.5
  BOTTOM w0.203: UNK6K45.1 192.25,225.65 UNK6RK45.1
N18730139: length 1.5
  BOTTOM w0.203: UNK6K44.1 192.25,221.08 UNK6RK44.1
N18730149: length 1.5
  BOTTOM w0.203: UNK6K44.3 193.05,216.71 UNK6C66.1
N18730167: length 1.5
  BOTTOM w0.203: UNK6K46.1 189.84,216.76 UNK6RK46.1
N18730183: length 1.5
  BOTTOM w0.203: UNK6C67.1 190.64,218.23 UNK6K47.3
N18730196: length 1.5
  BOTTOM w0.203: UNK6K48.1 189.84,227.17 UNK6RK48.1
N18730197: length 1.5
  BOTTOM w0.203: UNK6K47.1 189.84,222.6 UNK6RK47.1
N18730207: length 1.5
  BOTTOM w0.203: UNK6K49.3 188.23,222.8 UNK6C68.1
N18730220: length 1.5
  BOTTOM w0.203: UNK6K50.1 187.43,221.33 UNK6RK50.1
N18730221: length 1.5
  BOTTOM w0.203: UNK6RK49.1 187.43,227.17 UNK6K49.1
N18731035: length 1.3
  BOTTOM w0.203: UNK6R7.2 188.32,184.45 UNK6K51.4
N18731047: length 1.3
  BOTTOM w0.203: UNK6R8.2 196.57,184.45 UNK6K53.4
N18731049: length 1.5
  BOTTOM w0.203: UNK6RK53.1 196.57,188.69 UNK6K53.1
N18731071: length 2.3
  BOTTOM w0.203: UNK6R19.1 UNK6R11.2 v1(166.61,234.24)
N18731083: length 2.3
  BOTTOM w0.203: v1(173.22,234.24) UNK6R14.2 UNK6R20.1
N18731093: length 1.5
  BOTTOM w0.203: UNK6RK59.1 161.26,231.95 UNK6K55.1
N18731096: length 1.3
  BOTTOM w0.508: UNK6R19.2 UNK6K55.4
N18731098: length 3
  BOTTOM w0.305: UNK6RK60.1 UNK6K56.1
N18731115: length 3.4
  BOTTOM w0.203: UNK6TP_IN-_3.1 198.51,172.74 198.31,172.54 UNK6R16.1 197.41,171.32 UNK6U3.8
N18731116: length 3.4
  BOTTOM w0.203: UNK6TP_IN+_3.1 195.68,172.74 195.89,172.54 UNK6R16.2 196.81,171.32 UNK6U3.7
N18731144: length 3.4
  BOTTOM w0.203: UNK6TP_IN+_4.1 190.6,172.74 190.81,172.54 UNK6R18.2 191.73,171.32 UNK6U4.7
N18731148: length 3.4
  BOTTOM w0.203: UNK6TP_IN-_4.1 193.43,172.74 193.23,172.54 UNK6R18.1 192.33,171.32 UNK6U4.8
N18731159: length 7.5
  BOTTOM w0.508: UNK6K56.4 171.43,227.4 170.92,227.91 UNK6K61.4 UNK6R20.2
N18731160: length 1.5
  BOTTOM w0.203: UNK6RK54.1 197.37,178.99 UNK6K54.1
N18731164: length 1.5
  BOTTOM w0.203: UNK6K51.1 188.32,188.69 UNK6RK51.1
N18731166: length 1.5
  BOTTOM w0.203: UNK6RK52.1 189.12,178.99 UNK6K52.1
N18731230: length 1.5
  BOTTOM w0.203: UNK6K57.1 197.71,176.76 UNK6RK55.2
N18731231: length 1.5
  BOTTOM w0.203: UNK6RK56.2 195.68,176.76 UNK6K58.1
N18731232: length 1.5
  BOTTOM w0.203: UNK6RK57.2 192.63,176.76 UNK6K59.1
N18731233: length 1.5
  BOTTOM w0.203: UNK6RK58.2 190.6,176.76 UNK6K60.1
N18731236: length 1.5
  BOTTOM w0.203: UNK6RK61.1 167.86,231.95 UNK6K61.1
N18732367: length 2.2
  BOTTOM w0.635: UNK7C48.1 UNK7K2.3
N18732376: length 6.9
  BOTTOM w0.635: UNK7C49.1 216.27,213.81 216.91,214.45 UNK7K3.3
N18732385: length 1.5
  BOTTOM w0.508: UNK7C50.1 UNK7K5.3
N18732418: length 1.5
  BOTTOM w0.203: UNK7RK7.1 217.77,203.76 UNK7K7.1
N18732425: length 1.5
  BOTTOM w0.203: UNK7K8.3 222.14,202.02 UNK7C53.1
N18732434: length 1.5
  BOTTOM w0.203: UNK7C54.1 216.42,202.02 UNK7K9.3
N18732464: length 6.9
  BOTTOM w0.508: 222.67,193.35 UNK7K12.3
  BOTTOM w0.635: UNK7C59.1 220.59,189.17 222.22,190.8 222.22,192.9 222.67,193.35
N18732471: length 1.5
  BOTTOM w0.203: UNK7R1.1 223.36,188.69 UNK7K13.3
N18732489: length 25.6
  BOTTOM w0.203: UNK7K15.6 218.34,186.04 218.34,188.58 221.35,191.59 221.35,198.83 223.32,200.79 223.32,201.61 v2(227.45,205.74)
N18732507: length 1.5
  BOTTOM w0.203: UNK7RK5.1 217.77,208.59 UNK7K5.1
N18732509: length 1.5
  BOTTOM w0.203: UNK7RK6.1 217.77,205.79 UNK7K6.1
N18732511: length 1.5
  BOTTOM w0.203: UNK7RK8.1 217.77,201.22 UNK7K8.1
N18732512: length 1.5
  BOTTOM w0.203: UNK7RK9.1 212.05,201.22 UNK7K9.1
N18732513: length 1.5
  BOTTOM w0.203: UNK7RK10.1 213.2,203.76 UNK7K10.1
N18732514: length 1.5
  BOTTOM w0.203: UNK7K11.1 224.16,195.12 UNK7RK11.1
N18732517: length 1.3
  BOTTOM w0.508: UNK7C58.1 UNK7K11.3
N18732520: length 1.5
  BOTTOM w0.203: UNK7RK12.1 224.16,190.29 UNK7K12.1
N18732522: length 1.5
  BOTTOM w0.203: UNK7RK13.1 224.16,184.32 UNK7K13.1
N18732525: length 1.5
  BOTTOM w0.203: UNK7K14.1 226.96,190.29 UNK7RK14.1
N18732527: length 3.4
  BOTTOM w0.203: UNK7RK2.1 222.47,223.73 222.87,223.32 UNK7K2.1
N18732528: length 1.9
  BOTTOM w0.203: UNK7K3.1 UNK7RK3.1
N18732529: length 2.4
  BOTTOM w0.203: UNK7RK4.1 222.04,236.93 222.87,236.1 UNK7K4.1
N18732549: length 27.9
  TOP w0.305: SITE7.8_F 226.71,205.4
  TOP w0.635: 226.71,205.4 225.16,203.85 225.16,195.65 217.92,188.41 215.89,188.41 215.29,187.82 215.29,186.19 UNK7K15.3
N18732561: length 1.5
  BOTTOM w0.203: UNK7C60.1 UNK7K16.3
N18732574: length 1.5
  BOTTOM w0.203: UNK7RK17.1 229.12,195.12 UNK7K17.1
N18732588: length 1.5
  BOTTOM w0.203: UNK7K16.1 226.96,195.12 UNK7RK16.1
N18732592: length 1.5
  BOTTOM w0.203: UNK7K18.1 229.12,190.29 UNK7RK18.1
N18733742: length 1.5
  BOTTOM w0.203: UNK7C69.1 UNK7K19.3
N18733769: length 1.5
  BOTTOM w0.203: UNK7K19.1 231.91,195.12 UNK7RK19.1
N18733771: length 1.5
  BOTTOM w0.203: UNK7K20.1 231.91,190.29 UNK7RK20.1
N18733772: length 1.5
  BOTTOM w0.203: UNK7K21.1 234.07,195.12 UNK7RK21.1
N18733797: length 1.5
  BOTTOM w0.203: UNK7RK22.1 234.07,190.29 UNK7K22.1
N18733803: length 24.1
  BOTTOM w0.203: v2(230.3,205.39) 230.3,204.48 234.81,199.97 234.81,189.07 233.24,187.49 233.24,185.44 234.38,184.3
N18733817: length 28.6
  BOTTOM w0.203: 242.64,184.3 241.15,185.78 241.15,188.53 240.21,189.48 235.8,189.48 235.32,189.96 235.32,200.22 230.8,204.74 v2(230.8,205.39)
N18733827: length 1.5
  BOTTOM w0.203: UNK7C62.1 UNK7K25.3
N18733845: length 1.5
  BOTTOM w0.203: UNK7RK25.1 237.37,195.12 UNK7K25.1
N18733849: length 1.5
  BOTTOM w0.203: UNK7K26.1 237.37,190.29 UNK7RK26.1
N18733854: length 1.5
  BOTTOM w0.203: UNK7C63.1 UNK7K27.3
N18733870: length 1.5
  BOTTOM w0.203: UNK7K28.1 246.9,201.77 UNK7RK28.1
N18733891: length 1.5
  BOTTOM w0.203: UNK7K27.1 242.33,201.77 UNK7RK27.1
N18733893: length 1.1
  BOTTOM w0.203: UNK7RK29.1 UNK7K29.1
N18733898: length 1.5
  BOTTOM w0.203: UNK7C61.1 UNK7K30.3
N18733912: length 1.5
  BOTTOM w0.203: UNK7RK31.1 246.9,205.58 UNK7K31.1
N18733932: length 1.5
  BOTTOM w0.203: UNK7K30.1 242.33,205.58 UNK7RK30.1
N18733935: length 1.1
  BOTTOM w0.203: UNK7RK32.1 UNK7K32.1
N18733937: length 1.5
  BOTTOM w0.203: UNK7K35.1 251.48,208.62 UNK7RK35.1
N18733939: length 1.5
  BOTTOM w0.203: UNK7K34.1 246.9,208.62 UNK7RK34.1
N18733941: length 1.5
  BOTTOM w0.203: UNK7RK33.1 242.33,208.62 UNK7K33.1
N18733944: length 1.5
  BOTTOM w0.203: UNK7C64.1 UNK7K33.3
N18733979: length 1.5
  BOTTOM w0.203: UNK7K37.1 246.9,211.67 UNK7RK37.1
N18733980: length 1.5
  BOTTOM w0.203: UNK7RK36.1 242.33,211.67 UNK7K36.1
N18733986: length 1.5
  BOTTOM w0.203: UNK7C65.1 UNK7K36.3
N18735272: length 1.5
  BOTTOM w0.203: UNK7RK39.1 246.9,214.21 UNK7K39.1
N18735273: length 1.5
  BOTTOM w0.203: UNK7RK38.1 242.33,214.21 UNK7K38.1
N18735279: length 1.5
  BOTTOM w0.203: UNK7C74.1 UNK7K38.3
N18735298: length 1.5
  BOTTOM w0.203: UNK7RK40.1 235.17,215.24 UNK7K40.1
N18735311: length 1.5
  BOTTOM w0.203: UNK7RK41.1 235.17,219.81 UNK7K41.1
N18735324: length 1.5
  BOTTOM w0.203: UNK7K42.1 235.17,224.38 UNK7RK42.1
N18735336: length 1.5
  BOTTOM w0.203: UNK7K43.1 232.25,215.24 UNK7RK43.1
N18735349: length 1.5
  BOTTOM w0.203: UNK7RK45.1 232.25,225.65 UNK7K45.1
N18735350: length 1.5
  BOTTOM w0.203: UNK7RK44.1 232.25,221.08 UNK7K44.1
N18735360: length 1.5
  BOTTOM w0.203: UNK7C66.1 233.05,216.71 UNK7K44.3
N18735378: length 1.5
  BOTTOM w0.203: UNK7K46.1 229.84,216.76 UNK7RK46.1
N18735394: length 1.5
  BOTTOM w0.203: UNK7C67.1 230.64,218.23 UNK7K47.3
N18735407: length 1.5
  BOTTOM w0.203: UNK7K48.1 229.84,227.17 UNK7RK48.1
N18735408: length 1.5
  BOTTOM w0.203: UNK7K47.1 229.84,222.6 UNK7RK47.1
N18735418: length 1.5
  BOTTOM w0.203: UNK7C68.1 228.23,222.8 UNK7K49.3
N18735431: length 1.5
  BOTTOM w0.203: UNK7RK50.1 227.43,221.33 UNK7K50.1
N18735432: length 1.5
  BOTTOM w0.203: UNK7RK49.1 227.43,227.17 UNK7K49.1
N18736246: length 1.3
  BOTTOM w0.203: UNK7K51.4 228.32,184.45 UNK7R7.2
N18736258: length 1.3
  BOTTOM w0.203: UNK7R8.2 236.57,184.45 UNK7K53.4
N18736260: length 1.5
  BOTTOM w0.203: UNK7RK53.1 236.57,188.69 UNK7K53.1
N18736282: length 2.3
  BOTTOM w0.203: v1(206.61,234.24) UNK7R11.2 UNK7R19.1
N18736294: length 2.3
  BOTTOM w0.203: v1(213.21,234.24) UNK7R14.2 UNK7R20.1
N18736304: length 1.5
  BOTTOM w0.203: UNK7K55.1 201.26,231.95 UNK7RK59.1
N18736307: length 1.3
  BOTTOM w0.508: UNK7R19.2 UNK7K55.4
N18736309: length 3
  BOTTOM w0.305: UNK7RK60.1 UNK7K56.1
N18736326: length 3.4
  BOTTOM w0.203: UNK7U3.8 237.41,171.32 UNK7R16.1 238.31,172.54 238.51,172.74 UNK7TP_IN-_3.1
N18736327: length 3.4
  BOTTOM w0.203: UNK7TP_IN+_3.1 235.68,172.74 235.89,172.54 UNK7R16.2 236.81,171.32 UNK7U3.7
N18736355: length 3.4
  BOTTOM w0.203: UNK7U4.7 231.73,171.32 UNK7R18.2 230.81,172.54 230.6,172.74 UNK7TP_IN+_4.1
N18736359: length 3.4
  BOTTOM w0.203: UNK7TP_IN-_4.1 233.43,172.74 233.23,172.54 UNK7R18.1 232.33,171.32 UNK7U4.8
N18736370: length 7.5
  BOTTOM w0.508: UNK7R20.2 UNK7K61.4 210.92,227.91 211.43,227.4 UNK7K56.4
N18736371: length 1.5
  BOTTOM w0.203: UNK7K54.1 237.37,178.99 UNK7RK54.1
N18736375: length 1.5
  BOTTOM w0.203: UNK7RK51.1 228.32,188.69 UNK7K51.1
N18736377: length 1.5
  BOTTOM w0.203: UNK7K52.1 229.12,178.99 UNK7RK52.1
N18736441: length 1.5
  BOTTOM w0.203: UNK7K57.1 237.71,176.76 UNK7RK55.2
N18736442: length 1.5
  BOTTOM w0.203: UNK7K58.1 235.68,176.76 UNK7RK56.2
N18736443: length 1.5
  BOTTOM w0.203: UNK7RK57.2 232.63,176.76 UNK7K59.1
N18736444: length 1.5
  BOTTOM w0.203: UNK7RK58.2 230.6,176.76 UNK7K60.1
N18736447: length 1.5
  BOTTOM w0.203: UNK7K61.1 207.86,231.95 UNK7RK61.1
N18737578: length 2.2
  BOTTOM w0.635: UNK8C48.1 UNK8K2.3
N18737587: length 6.9
  BOTTOM w0.635: UNK8K3.3 256.91,214.45 256.27,213.81 UNK8C49.1
N18737596: length 1.5
  BOTTOM w0.508: UNK8C50.1 UNK8K5.3
N18737629: length 1.5
  BOTTOM w0.203: UNK8RK7.1 257.77,203.76 UNK8K7.1
N18737636: length 1.5
  BOTTOM w0.203: UNK8C53.1 262.14,202.02 UNK8K8.3
N18737645: length 1.5
  BOTTOM w0.203: UNK8C54.1 256.42,202.02 UNK8K9.3
N18737675: length 6.9
  BOTTOM w0.508: 262.67,193.35 UNK8K12.3
  BOTTOM w0.635: UNK8C59.1 260.59,189.17 262.22,190.8 262.22,192.9 262.67,193.35
N18737682: length 1.5
  BOTTOM w0.203: UNK8R1.1 263.36,188.69 UNK8K13.3
N18737700: length 25.6
  BOTTOM w0.203: UNK8K15.6 258.34,186.04 258.34,188.58 261.35,191.59 261.35,198.83 263.32,200.79 263.32,201.61 v2(267.45,205.74)
N18737718: length 1.5
  BOTTOM w0.203: UNK8RK5.1 257.77,208.59 UNK8K5.1
N18737720: length 1.5
  BOTTOM w0.203: UNK8K6.1 257.77,205.79 UNK8RK6.1
N18737722: length 1.5
  BOTTOM w0.203: UNK8K8.1 257.77,201.22 UNK8RK8.1
N18737723: length 1.5
  BOTTOM w0.203: UNK8K9.1 252.05,201.22 UNK8RK9.1
N18737724: length 1.5
  BOTTOM w0.203: UNK8K10.1 253.2,203.76 UNK8RK10.1
N18737725: length 1.5
  BOTTOM w0.203: UNK8RK11.1 264.16,195.12 UNK8K11.1
N18737728: length 1.3
  BOTTOM w0.508: UNK8C58.1 UNK8K11.3
N18737731: length 1.5
  BOTTOM w0.203: UNK8RK12.1 264.16,190.29 UNK8K12.1
N18737733: length 1.5
  BOTTOM w0.203: UNK8K13.1 264.16,184.32 UNK8RK13.1
N18737736: length 1.5
  BOTTOM w0.203: UNK8K14.1 266.96,190.29 UNK8RK14.1
N18737738: length 3.4
  BOTTOM w0.203: UNK8K2.1 262.87,223.32 262.47,223.73 UNK8RK2.1
N18737739: length 1.9
  BOTTOM w0.203: UNK8K3.1 UNK8RK3.1
N18737740: length 2.4
  BOTTOM w0.203: UNK8K4.1 262.87,236.1 262.04,236.93 UNK8RK4.1
N18737760: length 27.9
  TOP w0.305: SITE8.8_F 266.71,205.4
  TOP w0.635: UNK8K15.3 255.29,186.19 255.29,187.82 255.89,188.41 257.92,188.41 265.16,195.65 265.16,203.85 266.71,205.4
N18737772: length 1.5
  BOTTOM w0.203: UNK8C60.1 UNK8K16.3
N18737785: length 1.5
  BOTTOM w0.203: UNK8RK17.1 269.12,195.12 UNK8K17.1
N18737799: length 1.5
  BOTTOM w0.203: UNK8K16.1 266.96,195.12 UNK8RK16.1
N18737803: length 1.5
  BOTTOM w0.203: UNK8K18.1 269.12,190.29 UNK8RK18.1
N18738953: length 1.5
  BOTTOM w0.203: UNK8C69.1 UNK8K19.3
N18738980: length 1.5
  BOTTOM w0.203: UNK8RK19.1 271.91,195.12 UNK8K19.1
N18738982: length 1.5
  BOTTOM w0.203: UNK8K20.1 271.91,190.29 UNK8RK20.1
N18738983: length 1.5
  BOTTOM w0.203: UNK8K21.1 274.07,195.12 UNK8RK21.1
N18739008: length 1.5
  BOTTOM w0.203: UNK8K22.1 274.07,190.29 UNK8RK22.1
N18739014: length 24.1
  BOTTOM w0.203: 274.38,184.3 273.24,185.44 273.24,187.49 274.81,189.07 274.81,199.97 270.3,204.48 v2(270.3,205.39)
N18739028: length 28.6
  BOTTOM w0.203: 282.64,184.3 281.15,185.78 281.15,188.53 280.21,189.48 275.8,189.48 275.32,189.96 275.32,200.22 270.8,204.74 v2(270.8,205.39)
N18739038: length 1.5
  BOTTOM w0.203: UNK8C62.1 UNK8K25.3
N18739056: length 1.5
  BOTTOM w0.203: UNK8K25.1 277.37,195.12 UNK8RK25.1
N18739060: length 1.5
  BOTTOM w0.203: UNK8RK26.1 277.37,190.29 UNK8K26.1
N18739065: length 1.5
  BOTTOM w0.203: UNK8C63.1 UNK8K27.3
N18739081: length 1.5
  BOTTOM w0.203: UNK8RK28.1 286.9,201.77 UNK8K28.1
N18739102: length 1.5
  BOTTOM w0.203: UNK8K27.1 282.33,201.77 UNK8RK27.1
N18739104: length 1.1
  BOTTOM w0.203: UNK8RK29.1 UNK8K29.1
N18739109: length 1.5
  BOTTOM w0.203: UNK8C61.1 UNK8K30.3
N18739123: length 1.5
  BOTTOM w0.203: UNK8RK31.1 286.9,205.58 UNK8K31.1
N18739143: length 1.5
  BOTTOM w0.203: UNK8RK30.1 282.33,205.58 UNK8K30.1
N18739146: length 1.1
  BOTTOM w0.203: UNK8RK32.1 UNK8K32.1
N18739148: length 1.5
  BOTTOM w0.203: UNK8RK35.1 291.48,208.62 UNK8K35.1
N18739150: length 1.5
  BOTTOM w0.203: UNK8K34.1 286.9,208.62 UNK8RK34.1
N18739152: length 1.5
  BOTTOM w0.203: UNK8RK33.1 282.33,208.62 UNK8K33.1
N18739155: length 1.5
  BOTTOM w0.203: UNK8C64.1 UNK8K33.3
N18739190: length 1.5
  BOTTOM w0.203: UNK8RK37.1 286.9,211.67 UNK8K37.1
N18739191: length 1.5
  BOTTOM w0.203: UNK8K36.1 282.33,211.67 UNK8RK36.1
N18739197: length 1.5
  BOTTOM w0.203: UNK8C65.1 UNK8K36.3
N18740483: length 1.5
  BOTTOM w0.203: UNK8K39.1 286.9,214.21 UNK8RK39.1
N18740484: length 1.5
  BOTTOM w0.203: UNK8RK38.1 282.33,214.21 UNK8K38.1
N18740490: length 1.5
  BOTTOM w0.203: UNK8C74.1 UNK8K38.3
N18740509: length 1.5
  BOTTOM w0.203: UNK8RK40.1 275.17,215.24 UNK8K40.1
N18740522: length 1.5
  BOTTOM w0.203: UNK8RK41.1 275.17,219.81 UNK8K41.1
N18740535: length 1.5
  BOTTOM w0.203: UNK8RK42.1 275.17,224.38 UNK8K42.1
N18740547: length 1.5
  BOTTOM w0.203: UNK8K43.1 272.25,215.24 UNK8RK43.1
N18740560: length 1.5
  BOTTOM w0.203: UNK8K45.1 272.25,225.65 UNK8RK45.1
N18740561: length 1.5
  BOTTOM w0.203: UNK8RK44.1 272.25,221.08 UNK8K44.1
N18740571: length 1.5
  BOTTOM w0.203: UNK8K44.3 273.05,216.71 UNK8C66.1
N18740589: length 1.5
  BOTTOM w0.203: UNK8RK46.1 269.84,216.76 UNK8K46.1
N18740605: length 1.5
  BOTTOM w0.203: UNK8C67.1 270.64,218.23 UNK8K47.3
N18740618: length 1.5
  BOTTOM w0.203: UNK8K48.1 269.84,227.17 UNK8RK48.1
N18740619: length 1.5
  BOTTOM w0.203: UNK8K47.1 269.84,222.6 UNK8RK47.1
N18740629: length 1.5
  BOTTOM w0.203: UNK8C68.1 268.23,222.8 UNK8K49.3
N18740642: length 1.5
  BOTTOM w0.203: UNK8RK50.1 267.43,221.33 UNK8K50.1
N18740643: length 1.5
  BOTTOM w0.203: UNK8K49.1 267.43,227.17 UNK8RK49.1
N18741457: length 1.3
  BOTTOM w0.203: UNK8R7.2 268.32,184.45 UNK8K51.4
N18741469: length 1.3
  BOTTOM w0.203: UNK8K53.4 276.57,184.45 UNK8R8.2
N18741471: length 1.5
  BOTTOM w0.203: UNK8K53.1 276.57,188.69 UNK8RK53.1
N18741493: length 2.3
  BOTTOM w0.203: UNK8R19.1 UNK8R11.2 v1(246.61,234.24)
N18741505: length 2.3
  BOTTOM w0.203: UNK8R20.1 UNK8R14.2 v1(253.21,234.24)
N18741515: length 1.5
  BOTTOM w0.203: UNK8K55.1 241.26,231.95 UNK8RK59.1
N18741518: length 1.3
  BOTTOM w0.508: UNK8R19.2 UNK8K55.4
N18741520: length 3
  BOTTOM w0.305: UNK8RK60.1 UNK8K56.1
N18741537: length 3.4
  BOTTOM w0.203: UNK8TP_IN-_3.1 278.51,172.74 278.31,172.54 UNK8R16.1 277.41,171.32 UNK8U3.8
N18741538: length 3.4
  BOTTOM w0.203: UNK8U3.7 276.81,171.32 UNK8R16.2 275.89,172.54 275.68,172.74 UNK8TP_IN+_3.1
N18741566: length 3.4
  BOTTOM w0.203: UNK8U4.7 271.73,171.32 UNK8R18.2 270.81,172.54 270.6,172.74 UNK8TP_IN+_4.1
N18741570: length 3.4
  BOTTOM w0.203: UNK8TP_IN-_4.1 273.43,172.74 273.23,172.54 UNK8R18.1 272.33,171.32 UNK8U4.8
N18741581: length 7.5
  BOTTOM w0.508: UNK8K56.4 251.43,227.4 250.92,227.91 UNK8K61.4 UNK8R20.2
N18741582: length 1.5
  BOTTOM w0.203: UNK8K54.1 277.37,178.99 UNK8RK54.1
N18741586: length 1.5
  BOTTOM w0.203: UNK8RK51.1 268.32,188.69 UNK8K51.1
N18741588: length 1.5
  BOTTOM w0.203: UNK8K52.1 269.12,178.99 UNK8RK52.1
N18741652: length 1.5
  BOTTOM w0.203: UNK8RK55.2 277.71,176.76 UNK8K57.1
N18741653: length 1.5
  BOTTOM w0.203: UNK8K58.1 275.68,176.76 UNK8RK56.2
N18741654: length 1.5
  BOTTOM w0.203: UNK8RK57.2 272.63,176.76 UNK8K59.1
N18741655: length 1.5
  BOTTOM w0.203: UNK8RK58.2 270.6,176.76 UNK8K60.1
N18741658: length 1.5
  BOTTOM w0.203: UNK8RK61.1 247.86,231.95 UNK8K61.1

## Copper pours and planes (outline as drawn)
GND on L02_GND: 74.68,440.23 75.62,441.6 75.95,443.23 75.95,471.81 76.58,473.33 78.11,473.96 341,473.96 342.52,473.33 343.15,471.81 343.15,443.23 343.48,441.6 344.42,440.23 354.58,430.35 354.58,405.13 359.72,392.74 372.11,387.6 412.75,387.6 416.52,386.04 418.08,382.27 418.08,92.71 416.52,88.94 412.75,87.38 372.11,87.38 359.72,82.24 354.58,69.85 354.58,44.63 344.42,34.76 343.48,33.38 343.15,31.75 343.15,3.18 342.52,1.65 341,1.02 78.11,1.02 76.58,1.65 75.95,3.18 75.95,31.75 75.62,33.38 74.68,34.76 64.52,44.63 64.52,69.85 59.38,82.24 46.99,87.38 6.35,87.38 2.58,88.94 1.02,92.71 1.02,382.27 2.58,386.04 6.35,387.6 46.99,387.6 59.38,392.74 64.52,405.13 64.52,430.35
S1_SRD_F on BOTTOM: 144.15,273.94 142.11,273.94 140.97,272.8 138.18,272.8 138.05,272.67 138.05,270.38 138.18,270.26 143.13,270.26 144.29,269.09 147.12,269.09 147.2,269.17 147.2,269.75 146.93,270.02 146.93,271.03 146.18,271.78 144.53,271.78 144.3,272 144.3,273.79
