# Allegro board 980K2-260817_261117-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SL06_DP_44: length 85.1
  L28_DP w0.079: v1(283.84,260.87) 282.45,262.26 277.99,262.26 277.93,262.19 277.41,262.19 275.67,260.45 275.67,258.22 275.67,257.46 274.92,256.71 274.92,255.16 275.46,254.63 275.62,254.46 275.95,254.13 275.95,252.57 274.78,251.4 274.78,250.34 272.77,248.32 268.03,248.32 263.11,243.4 263.11,238.57 263.56,238.11 263.56,238.03 263.63,237.96 263.63,233.07 268.42,228.29 268.42,228.15 268.87,227.69 268.87,225.68 268.58,225.39 267.42,225.39 266.57,224.55 265.21,224.55 264.97,224.55 264.38,223.95 264.38,223.71 264.31,223.63 264.31,222.62 264.31,222.16 264.38,222.08 264.38,221.54 264.38,221.54 264.38,202.14 264.4,202.12 264.4,200.32 264.06,199.98 264.06,199.73
SL06_DP_45: length 91.7
  L28_DP w0.079: v1(288.42,260.87) 290.08,259.2 290.08,249.75 288.52,248.19 277.24,248.19 274.8,245.75 273.96,245.75 271.72,243.5 270.81,243.5 269.94,244.37 265.41,244.37 263.96,242.91 263.96,239.31 264.41,238.85 264.41,238.38 264.47,238.31 264.47,233.61 269.24,228.84 269.26,228.82 269.26,228.5 269.54,228.23 269.59,228.23 269.93,227.89 269.93,225.54 267.75,223.36 265.23,223.36 265.15,223.28 265.15,222.51 265.22,222.44 265.61,222.44 265.89,222.17 265.89,221.77 265.61,221.5 265.29,221.5 265.23,221.43 265.23,202.49 265.25,202.47 265.25,199.97 265.03,199.76
SL06_DP_46: length 86
  L28_DP w0.079: 263.78,199.73 263.78,200.1 264.12,200.44 264.12,202 264.1,202.02 264.1,221.42 264.1,221.42 264.1,221.97 264.03,222.04 264.03,222.74 264.03,223.75 264.1,223.82 264.1,224.15 264.78,224.83 264.86,224.83 266.31,224.83 266.64,225.16 267.72,226.24 267.72,228.45 263.35,232.83 263.35,237.85 262.73,238.46 262.73,244.36 263.07,244.69 263.36,244.69 263.54,244.88 263.58,244.88 264.02,245.32 264.02,245.35 267.93,249.26 273.31,249.26 274.5,250.45 274.5,251.52 275.67,252.69 275.67,254.01 275.5,254.18 275.34,254.34 274.73,254.95 274.72,254.95 274.64,255.03 274.64,256.88 275.39,257.63 275.39,258.1 275.39,258.1 275.39,261.44 278.62,264.68 280.36,264.68 280.83,264.2 282.63,264.2 283.1,264.68 v1(283.84,264.68)
SL06_DP_47: length 95.6
  L28_DP w0.079: v1(288.42,264.68) 287.94,264.2 287.94,260.67 289.8,258.82 289.8,249.87 288.62,248.69 278.25,248.69 277.67,249.26 277.05,249.26 276.61,248.82 275.12,248.82 274.06,247.76 273.96,247.76 273.38,247.17 273.02,247.17 271.6,245.75 270.76,245.75 269.6,246.91 267.56,246.91 263.67,243.03 263.67,239.08 264.13,238.62 264.13,238.26 264.19,238.2 264.19,233.49 268.98,228.71 268.98,228.39 269.42,227.94 269.47,227.94 269.65,227.77 269.65,225.66 267.63,223.64 265.02,223.64 264.95,223.56 264.95,223.47 264.87,223.4 264.87,222.39 264.95,222.32 264.95,222.17 264.94,222.17 264.94,221.77 264.95,221.77 264.95,202.37 264.97,202.35 264.97,200.09 264.66,199.79
SL06_DP_48: length 257.8
  L28_DP w0.079: 207.61,54.74 207.61,107.9 259.91,160.2 259.91,184.07 259.89,184.09 259.89,187.85 263.17,191.13 263.46,191.13 263.73,191.41 263.73,191.7 264.34,192.3 264.34,197.34 263.53,198.14 263.53,199.58 263.49,199.62 263.49,200.21 263.84,200.56 263.84,201.88 263.82,201.9 263.82,221.31 263.82,221.31 263.82,221.85 263.74,221.92 263.74,222.86 263.74,223.87 263.82,223.94 263.82,224.58 264.35,225.11 264.74,225.11 266.19,225.11 266.36,225.27 267.35,226.26 267.35,228.22 263.05,232.52 263.05,237.59 262.42,238.22 262.42,244.48 263.1,245.16 263.46,245.16 263.73,245.44 263.73,245.8 267.53,249.59 273.24,249.59 274.22,250.57 274.22,251.64 275.39,252.81 275.39,253.9 275.22,254.06 274.62,254.67 274.6,254.67 274.36,254.91 274.36,257 275.11,257.75 275.11,257.98 275.1,257.98 275.1,262.88 279.95,267.72 280.36,267.72 280.83,268.2 282.63,268.2 283.1,267.72 v1(283.84,267.72)
SL06_DP_49: length 96.3
  L28_DP w0.079: v1(288.42,267.72) 287.94,267.25 287.94,264.6 287.66,264.32 287.66,260.55 288.82,259.4 288.82,252.21 287.97,251.37 287.97,250.92 288.03,250.64 288.03,250.34 287.97,250.06 287.86,249.79 287.7,249.55 287.49,249.34 286.96,248.99 278.35,248.99 277.78,249.55 276.94,249.55 276.73,249.34 274.88,249.34 273.53,247.99 268.23,247.99 263.39,243.15 263.39,238.85 263.85,238.4 263.85,238.14 263.91,238.08 263.91,233.33 268.7,228.54 268.7,228.27 269.19,227.78 269.19,225.6 268.7,225.11 267.54,225.11 266.69,224.26 265.09,224.26 264.66,223.84 264.66,223.59 264.59,223.51 264.59,222.51 264.59,222.27 264.66,222.2 264.66,221.66 264.66,221.66 264.66,202.25 264.68,202.23 264.68,200.21 264.34,199.86 264.34,199.73
SL06_DP_50: length 255.6
  L28_DP w0.079: 206.89,55.06 206.89,109.11 259.34,161.57 259.34,183.83 259.33,183.85 259.33,188.09 259.34,188.11 259.34,188.76 262.43,191.85 262.43,193.71 262.77,194.05 262.77,195.26 263.77,196.27 263.77,197.1 262.48,198.39 262.48,200 263.27,200.79 263.27,201.65 263.21,201.71 263.21,204.51 263.17,204.55 263.17,207.86 262.39,208.64 262.39,209.57 262.39,212.81 262.24,212.96 262.24,223.52 262.71,223.99 262.71,237.53 261.82,238.42 261.82,244.99 267.63,250.8 272.76,250.8 272.8,250.83 273.01,250.83 273.03,250.85 273.48,250.85 273.92,251.29 273.92,251.74 275.1,252.92 275.1,253.78 274.5,254.39 274.34,254.39 274.08,254.65 274.08,257.12 274.82,257.86 274.82,263.42 281.71,270.3 282.63,270.3 283.1,270.77 v1(283.84,270.77)
SL06_DP_51: length 267.7
  L28_DP w0.079: 206.25,46.54 206.25,109.38 259.06,162.19 259.06,183.72 259.04,183.74 259.04,188.2 259.06,188.22 259.06,188.88 262.15,191.96 262.15,196.14 262.87,196.86 262.87,197.49 262.2,198.16 262.2,200.11 262.99,200.91 262.99,201.53 262.93,201.59 262.93,204.39 262.83,204.49 262.83,207.8 262.11,208.52 262.11,209.69 262.11,212.69 261.96,212.85 261.96,223.64 262.43,224.11 262.43,237.23 261.3,238.36 261.3,246.72 265.69,251.11 272.9,251.11 272.91,251.13 273.36,251.13 273.64,251.41 273.64,251.86 274.82,253.04 274.82,253.66 274.38,254.1 274.22,254.1 273.66,254.67 273.66,257.1 274.54,257.98 274.54,264.11 275.9,265.47 276.23,265.47 276.51,265.74 276.51,266.07 278.8,268.37 278.8,268.82 279.08,269.1 279.53,269.1 280.73,270.3 281.22,270.3 281.49,270.58 281.49,271.06 v1(283.84,273.41)
SL06_DP_52: length 285.5
  L28_DP w0.079: v1(276.07,272.17) 274.28,273.97 274.28,284.13 281.23,291.09 296.08,291.09 327.44,259.73 327.44,128.6 299.9,101.06 266.21,101.06
SL06_DP_53: length 276.1
  L28_DP w0.079: v1(276.07,276.75) 274.59,278.23 274.59,283.78 281.37,290.55 294.91,290.55 326.19,259.28 326.19,129.12 299.7,102.64 266.21,102.64
SL06_DP_54: length 297.7
  L30_DP w0.079: 255.35,57.73 255.35,83.57 325.47,153.69 325.47,258.47 293.81,290.12 281.84,290.12 276.58,284.86 276.58,282.7 276.07,282.19 v1(276.07,281.32)
SL06_DP_55: length 298.8
  L30_DP w0.079: 256.22,71.23 256.22,83.39 326.4,153.57 326.4,259.45 294.38,291.47 280.42,291.47 273.96,285.01 273.96,272.98 v1(273.15,272.17)
SL06_DP_56: length 290.8
  L30_DP w0.079: v1(273.15,282.59) 273.15,283.34 273.64,283.82 273.64,285.54 280.15,292.06 295.55,292.06 327.33,260.27 327.33,153.18 257.15,83.01 257.15,71.23
SL06_DP_57: length 303.4
  L30_DP w0.079: v1(270.74,273.7) 271.55,274.51 271.55,284.97 279.24,292.66 296.59,292.66 328.15,261.1 328.15,152.84 257.98,82.66 257.98,71.23
SL06_DP_58: length 284.3
  L28_DP w0.079: v1(270.74,284.11) 271.22,284.6 271.22,285.26 279.23,293.27 299.51,293.27 328.62,264.16 328.62,128.11 300.38,99.87 266.21,99.87
SL06_DP_59: length 304.7
  L30_DP w0.079: 258.78,71.23 258.78,82.33 328.96,152.51 328.96,262.03 296.82,294.16 276.93,294.16 268.87,286.09 268.87,278.81 v1(268.33,278.27)
SL06_DP_60: length 152.7
  L30_DP w0.079: 182.02,77.28 182.02,88.37 181.91,88.44 181.15,89.2 180.55,90.1 180.13,91.11 179.92,92.17 179.92,93.25 180.13,94.31 180.55,95.32 181.15,96.22 181.38,96.45 181.38,195.41 183.36,197.39 183.36,213.34 183.02,213.68 183.02,224.59 v1(185.41,226.99)
SL06_DP_61: length 202.2
  L28_DP w0.079: v1(180.83,206.69) 180.41,206.69 175.59,201.87 174.89,201.87 170.21,197.19 170.21,98.19 189.25,79.15 189.25,60.33 184.51,55.58 180.91,55.58 180.37,55.04 179.83,55.04 179.33,55.55 178.62,55.55 178.12,55.04 177.58,55.04 177.08,55.55 176.37,55.55 175.87,55.04 175.33,55.04 174.83,55.55 174.12,55.55 173.62,55.04 173.08,55.04 172.58,55.55 171.87,55.55 171.37,55.04 170.83,55.04 170.19,55.68 170.01,55.68 169.19,54.86 168.51,54.86 165.95,57.42 165.95,58.12 167.35,59.52 167.51,59.52 168.02,60.03 168.02,60.04 168.51,60.52 169.19,60.52 169.69,60.03 170.26,60.03 170.78,60.55 171.16,60.55 171.96,61.34 172.49,61.34 173.49,60.34 173.62,60.34 173.94,60.02 175.01,60.02 175.68,60.69 SLOT06.B43
SL06_DP_62: length 202.4
  L28_DP w0.079: SLOT06.C43 173.43,60.69 172.6,61.52 171.88,61.52 171.09,60.73 170.86,60.73 170.24,61.34 169.71,61.34 169.07,60.7 168.63,60.7 167.99,61.34 167.46,61.34 165.69,59.58 165.69,55.91 165.95,55.65 165.95,55.42 166.33,55.04 166.56,55.04 167.08,54.53 167.08,54.42 167.46,54.04 167.99,54.04 168.63,54.68 169.07,54.68 169.71,54.04 170.24,54.04 171.06,54.86 171.44,54.86 171.95,55.37 172.5,55.37 173.01,54.86 173.69,54.86 174.2,55.37 174.75,55.37 175.26,54.86 175.94,54.86 176.45,55.37 177,55.37 177.51,54.86 178.19,54.86 178.7,55.37 179.25,55.37 179.76,54.86 180.44,54.86 180.72,55.14 180.76,55.14 180.96,55.34 181.49,55.34 181.69,55.14 184.99,55.14 189.87,60.02 189.87,79.52 170.82,98.57 170.82,195.65 175.86,200.68 175.86,201.53 177.94,203.61 179.78,203.61 v1(180.83,204.66)
SL06_DP_63: length 191.6
  L28_DP w0.079: v1(176.26,204.66) 174.25,202.66 173.2,202.66 169.55,199 169.55,97.92 188.59,78.88 188.59,60.06 184.39,55.87 181.73,55.87 181.73,55.86 180.88,55.86 180.83,55.91 180.8,55.91 180.37,56.34 179.83,56.34 179.21,55.73 178.73,55.73 178.12,56.34 177.58,56.34 176.97,55.73 176.48,55.73 175.87,56.34 175.33,56.34 174.72,55.73 174.23,55.73 173.62,56.34 173.08,56.34 172.47,55.73 171.98,55.73 171.37,56.34 170.83,56.34 170.35,55.86 169.94,55.86 169.12,55.04 168.58,55.04 168.2,55.42 168.2,55.96 168.58,56.34 168.58,56.79 167.01,58.36 167.01,58.89 167.46,59.34 167.6,59.34 168.2,59.94 168.2,59.96 168.58,60.34 169.12,60.34 169.66,59.8 170.29,59.8 170.84,60.35 171.88,60.35 SLOT06.D43
SL06_DP_64: length 128.5
  L30_DP w0.079: 182.54,77.1 182.54,86.62 183.34,87.42 183.82,87.42 184.88,87.21 185.96,87.21 187.02,87.42 188.03,87.84 188.93,88.44 189.69,89.2 190.29,90.1 190.71,91.11 190.92,92.17 190.92,93.25 190.71,94.31 190.29,95.32 189.69,96.22 188.93,96.98 188.03,97.58 187.02,98 185.96,98.21 184.88,98.21 184.67,98.17 182.54,100.3 182.54,189.83 182.79,190.09 182.79,190.39 183.07,190.66 183.37,190.66 v1(186.06,193.35)
SL06_DP_65: length 147.9
  L28_DP w0.079: SLOT06.B37 176.73,54.68 178.07,54.68 178.71,54.04 179.24,54.04 179.81,54.61 180.39,54.61 180.96,54.04 181.49,54.04 182.31,54.86 185.3,54.86 190.54,60.09 190.54,79.54 171.73,98.34 171.73,180.43 UNK6K15.2
SL06_DP_66: length 133.5
  L30_DP w0.079: 185,76.78 185,86.57 185.08,86.65 186.02,86.65 187.19,86.88 188.29,87.34 189.29,88 190.13,88.84 190.79,89.84 191.25,90.94 191.48,92.11 191.48,93.31 191.25,94.48 190.79,95.58 190.13,96.58 189.29,97.42 188.29,98.08 187.19,98.54 186.44,98.69 185,100.13 185,164.73 187.9,167.62 187.9,178.54 187.75,178.69 187.75,179.08 187.9,179.23 187.9,179.95 187.75,180.1 187.75,180.49 187.9,180.64 187.9,181.7 187.75,181.85 187.75,182.24 187.9,182.39 187.9,182.99 187.74,183.14 187.74,183.54 187.9,183.69 187.9,189.85 187.75,189.99 187.75,190.39 187.9,190.54 187.9,191.26 187.75,191.41 187.75,191.8 187.9,191.95 187.9,192.63 188.14,192.88 189.31,192.88 189.59,193.16 189.59,193.55 189.31,193.82 188.02,193.82 187.68,194.16 187.68,197.64 v1(188.22,198.18)
SL06_DP_67: length 127.5
  L30_DP w0.079: v1(188.22,193.35) 186.53,191.66 186.53,191.41 186.25,191.13 186,191.13 185.06,190.19 185.06,186 183.73,184.67 183.73,184.42 183.73,184.42 183.73,184.03 183.73,184.02 183.73,100.28 185.52,98.49 185.99,98.49 187.11,98.27 188.16,97.83 189.11,97.2 189.91,96.4 190.54,95.45 190.98,94.4 191.2,93.28 191.2,92.14 190.98,91.02 190.54,89.97 189.91,89.02 189.11,88.22 188.16,87.59 187.11,87.15 185.99,86.93 183.81,86.93 183.73,86.85 183.73,76.78
SL06_DP_68: length 120.1
  L30_DP w0.079: v1(191.01,193.35) 191.01,192.54 192.03,191.51 192.03,188.22 193.09,187.16 193.09,186.22 193.6,185.71 193.6,185.59 193.09,185.08 193.09,184.02 193.6,183.51 193.6,183.39 193.09,182.88 193.09,181.82 193.6,181.31 193.6,180.19 193.09,179.68 193.09,178.62 194.49,177.23 194.49,168.31 193.7,167.53 193.7,76.32
SL06_DP_69: length 224
  L30_DP w0.079: SLOT06.F37 167.72,55.49 167.05,56.16 167.05,57.22 167.25,57.42 167.25,57.96 167.05,58.16 167.05,58.93 167.46,59.34 167.99,59.34 168.29,59.04 169.15,59.04 169.63,59.52 170.35,59.52 170.83,59.04 171.37,59.04 171.85,59.52 172.6,59.52 173.08,59.04 173.62,59.04 174.1,59.52 174.82,59.52 175.3,59.04 175.87,59.04 176.17,59.34 176.99,59.34 177.47,58.86 178.23,58.86 178.71,59.34 179.24,59.34 179.54,59.04 180.37,59.04 180.95,59.62 187.18,59.62 197.8,70.24 197.8,76.36 201.93,80.49 201.93,85.1 199.46,87.58 199.46,164.94 210.65,176.13 210.65,191.19 210.94,191.48 210.94,199.65 210.19,200.39 209.97,200.39 209.69,200.67 209.69,201.15 206.07,204.78 206.07,209.63 205.97,209.72 205.12,210.58 205.12,211.29 200.14,216.28 196.17,216.28 193.63,213.73 193.63,206.03 192.7,205.1 192.7,198.65 v1(193.17,198.18)
SL06_DP_70: length 203.1
  L30_DP w0.079: SLOT06.A35 179.38,52.29 179.78,52.29 179.83,52.34 180.37,52.34 180.75,51.96 180.75,51.55 180.96,51.34 181.49,51.34 181.53,51.31 181.92,51.31 182.14,51.08 182.14,50.18 181.51,49.55 180.83,49.55 180.75,49.47 180.75,49.42 180.16,48.83 179.75,48.83 179.24,49.34 178.71,49.34 178.2,48.83 177.5,48.83 176.99,49.34 176.46,49.34 175.95,48.83 175.25,48.83 174.74,49.34 174.21,49.34 173.7,48.83 173,48.83 172.49,49.34 171.96,49.34 171.66,49.04 170.8,49.04 170.32,49.52 169.63,49.52 169.5,49.39 169.47,49.39 168.96,48.89 168.74,48.89 168.48,49.14 168.45,49.14 168.07,49.52 167.38,49.52 167,49.14 166.97,49.14 166.87,49.04 166.2,49.04 162.48,52.76 162.48,61.6 166.12,65.23 166.44,65.23 167,65.79 167.84,65.79 168.58,65.04 169.12,65.04 169.79,65.72 170.16,65.72 170.83,65.04 171.37,65.04 171.91,65.59 172.28,65.59 173.01,64.86 173.69,64.86 174.32,65.49 174.6,65.49 175.01,65.08 175.04,65.08 175.26,64.86 175.98,64.86 176.62,65.5 176.87,65.5 177.51,64.86 178.19,64.86 178.94,65.61 179.23,65.61 179.8,65.04 180.37,65.04 181.01,65.68 181.62,65.68 181.73,65.58 182.5,65.58 182.6,65.68 184.39,65.68 194.37,75.66 194.37,164.38 196.24,166.26 196.24,166.33 196.77,166.86 197.03,166.86 197.31,167.13 197.31,167.53 197.03,167.8 196.64,167.8 196.37,167.53 195.96,167.53 195.6,167.88 195.6,170.75 195.96,171.1 195.96,171.49 195.6,171.85 195.6,175.7 194.93,176.37 194.93,177.18 193.38,178.73 193.38,179.57 193.89,180.08 193.89,181.42 193.38,181.93 193.38,182.77 193.89,183.28 193.89,183.62 193.38,184.14 193.38,184.97 193.89,185.48 193.89,185.82 193.38,186.33 193.38,187.39 192.64,188.12 192.64,192.83 193.16,193.35 v1(193.17,193.35)
SL06_DP_71: length 114.4
  L30_DP w0.079: 185.73,75.92 185.73,85.46 186.77,86.51 187.27,86.61 188.43,87.09 189.47,87.78 190.35,88.66 191.04,89.7 191.52,90.86 191.77,92.08 191.77,93.34 191.52,94.56 191.04,95.72 190.35,96.76 189.47,97.64 188.43,98.33 187.27,98.81 185.73,100.35 185.73,161.7 186.01,161.98 186.01,165.34 188.18,167.5 188.18,176.48 188.82,177.12 188.82,180.38 190.79,182.35 UNK6K23.2
SL06_DP_72: length 171.2
  L30_DP w0.079: UNK6K24.2 198.16,181.07 198.16,177.06 198.14,177.05 198.14,176.66 198.16,176.65 198.16,175.75 198.04,175.64 198.04,175.25 198.16,175.14 198.16,173.92 198.19,173.89 198.19,173.5 198.16,173.47 198.16,166.78 197.38,166.01 197.2,166.01 196.26,165.08 196.26,84.85 196.05,84.64 195.71,84.13 195.47,83.56 195.35,82.96 195.35,82.34 195.47,81.74 195.71,81.17 195.96,80.79 195.96,80.01 195.6,79.65 195.6,75.05 182.38,61.83 180.88,61.83 180.37,62.34 179.83,62.34 179.32,61.83 178.63,61.83 178.12,62.34 177.58,62.34 177.12,61.89 176.33,61.89 175.87,62.34 175.33,62.34 174.87,61.89 174.08,61.89 173.62,62.34 173.08,62.34 172.62,61.89 171.83,61.89 171.37,62.34 170.83,62.34 170.37,61.89 169.83,61.89 169.45,62.27 169.2,62.27 169.12,62.34 168.58,62.34 167.94,61.7 167.31,61.7 166.71,61.11 166.71,61.06 163.65,57.99 163.65,53.33 165.04,51.93 165.05,51.93 166.11,50.86 166.94,50.86 167.43,51.35 168.02,51.35 168.51,50.86 169.25,50.86 169.33,50.79 169.33,50.42 169.71,50.04 170.24,50.04 170.62,50.42 170.62,50.96 170.38,51.21 170.38,51.89 170.83,52.34 170.96,52.34 172.01,53.4 172.47,53.4 173.18,52.69 SLOT06.C35
SL06_DP_73: length 182.4
  L30_DP w0.079: SLOT06.D35 172.22,52.15 171.75,51.67 171.75,51.42 171.37,51.04 171.12,51.04 170.8,50.72 170.8,50.35 170.32,49.86 169.78,49.86 169.63,49.86 169.15,50.35 169.15,50.61 169.07,50.68 168.45,50.68 168.37,50.61 168.37,50.42 167.99,50.04 167.46,50.04 166.82,50.68 165.72,50.68 163.25,53.16 163.25,59.01 167.08,62.84 167.08,62.96 167.46,63.34 167.58,63.34 168.58,64.34 169.12,64.34 169.81,63.66 170.14,63.66 170.83,64.34 171.37,64.34 172.11,63.6 172.34,63.6 173.08,64.34 173.62,64.34 174.27,63.69 174.68,63.69 175.33,64.34 175.87,64.34 176.38,63.84 177.07,63.84 177.58,64.34 178.12,64.34 178.71,63.75 179.24,63.75 179.83,64.34 180.37,64.34 180.79,63.92 181.37,63.92 181.66,64.21 183.85,64.21 195.15,75.51 195.31,75.67 195.31,79.76 195.55,80 195.55,80.81 195.46,81.04 195.46,81.04 195.27,81.5 195.2,81.66 195.07,82.31 195.07,82.98 195.2,83.64 195.46,84.26 195.83,84.82 195.92,84.91 195.92,165.14 196.81,166.02 196.81,166.1 197,166.3 197.27,166.3 197.87,166.9 197.87,172.87 197.24,173.5 197.24,173.89 197.72,174.37 197.72,185.23 194.63,188.32 194.63,191.51 v1(196.47,193.35)
SL06_DP_74: length 188.2
  L30_DP w0.079: SLOT06.E35 168.93,52.69 168.05,51.82 167.39,51.82 166.72,52.49 166.11,52.49 164.21,54.39 164.21,57.63 165.92,59.34 165.92,59.38 167.08,60.54 167.08,60.96 167.46,61.34 167.99,61.34 168.63,60.7 169.07,60.7 169.71,61.34 170.24,61.34 170.88,60.71 171.32,60.71 171.96,61.34 172.49,61.34 173.13,60.71 173.7,60.71 173.83,60.84 173.83,60.96 174.21,61.34 174.74,61.34 175.38,60.7 175.82,60.7 176.46,61.34 176.99,61.34 177.81,60.52 178.08,60.52 178.33,60.77 178.33,60.96 178.71,61.34 179.24,61.34 179.82,60.77 180.51,60.77 180.58,60.83 180.58,60.96 180.96,61.34 181.49,61.34 181.91,60.93 182.53,60.93 183.39,61.79 183.44,61.79 183.68,62.03 184.64,62.03 196.16,73.54 196.16,79.41 196.68,79.93 196.68,80.83 196.49,81.02 196.21,81.44 196.02,81.9 195.92,82.4 195.92,82.9 196.02,83.39 196.21,83.86 196.49,84.28 196.84,84.63 196.95,84.71 196.95,164.97 197.43,165.45 197.62,165.45 198.72,166.55 198.72,171.04 208.41,180.74 208.41,196.79 204.34,200.87 v1(203.84,200.87)
SL06_DP_75: length 186.1
  L30_DP w0.079: SLOT06.F35 167.72,53.28 167.25,53.75 167.25,53.96 166.87,54.34 166.66,54.34 165.76,55.24 165.76,58.23 167.05,59.52 167.73,59.52 167.78,59.57 167.81,59.57 168.58,60.34 169.12,60.34 169.76,59.7 170.19,59.7 170.83,60.34 171.37,60.34 172.01,59.7 172.44,59.7 173.09,60.35 173.65,60.35 174.13,59.86 174.82,59.86 175.3,60.34 175.87,60.34 176.25,59.96 176.25,59.6 176.33,59.52 177.07,59.52 177.45,59.14 177.49,59.14 177.58,59.04 178.12,59.04 178.21,59.14 178.25,59.14 178.63,59.52 179.14,59.52 179.45,59.84 179.45,59.96 179.83,60.34 180.37,60.34 180.85,59.86 181.52,59.86 181.57,59.91 186.82,59.91 197.48,70.56 197.48,79.13 198.15,79.81 198.75,79.81 199.3,79.92 199.82,80.13 200.28,80.44 200.68,80.84 200.99,81.3 201.2,81.82 201.31,82.37 201.31,82.65 201.31,82.93 201.18,83.62 200.99,83.99 200.74,84.36 200.74,84.39 200.28,84.85 199.57,85.33 199.01,85.56 199.01,165.25 199.78,166.01 199.8,166.01 200.57,166.78 200.57,167.88 199.85,168.6 199.85,168.93 210.18,179.27 210.18,199.1 v1(208.42,200.87)
SL06_DP_76: length 140.3
  L30_DP w0.079: v1(203.84,204.68) 203.84,202.86 204.89,201.82 204.89,200.76 208.8,196.84 208.8,180.34 199,170.54 199,168.24 199.72,167.53 199.72,167.13 199.45,166.86 199.43,166.86 197.74,165.17 197.55,165.17 197.25,164.87 197.25,84.57 197.02,84.41 196.71,84.1 196.46,83.73 196.29,83.31 196.2,82.87 196.2,82.42 196.29,81.98 196.46,81.57 196.71,81.2 196.96,80.95 196.96,79.81 196.44,79.29 196.44,72.7
SL06_DP_77: length 219.7
  L30_DP w0.079: v1(208.42,204.68) 208.42,204.49 213.83,199.08 218.85,199.08 221.15,196.77 221.15,192.43 218.44,189.72 214.15,189.72 211.84,187.41 211.84,176.16 200.16,164.49 200.16,88.22 202.65,85.74 202.65,80.3 198.85,76.51 198.85,68.81 187.67,57.62 181.73,57.62 181.69,57.59 181.12,57.59 180.37,58.34 179.83,58.34 179.01,57.52 178.94,57.52 178.12,58.34 177.58,58.34 176.94,57.7 176.51,57.7 175.87,58.34 175.33,58.34 174.63,57.64 174.32,57.64 173.62,58.34 173.08,58.34 172.53,57.79 172.18,57.79 171.44,58.52 170.76,58.52 170.02,57.79 169.67,57.79 169.12,58.34 168.58,58.34 168.2,57.96 168.2,57.42 168.82,56.8 168.82,56.59 168.2,55.96 168.2,55.42 168.58,55.04 169.13,55.04 169.21,54.96 169.33,54.96 169.71,55.34 170.24,55.34 170.78,54.81 171.19,54.81 171.96,54.04 172.53,54.04 173.17,54.69 173.56,54.69 174.21,54.04 174.74,54.04 175.22,54.52 175.72,54.52 176.46,53.79 176.46,53.34 176.08,52.96 176.08,52.17 176.46,51.79 176.46,51.34 176.08,50.96 176.08,50.42 176.75,49.75 176.99,49.75 177.58,50.34 178.12,50.34 178.2,50.26 178.49,50.26 178.71,50.04 179.24,50.04 179.54,50.34 180.37,50.34 180.42,50.29 180.82,50.29 SLOT06.Z33
SL06_DP_78: length 374.1
  L30_DP w0.079: 168.65,50.41 168.1,49.86 167.38,49.86 166.9,50.34 165.3,50.34 162.76,52.88 162.76,59.35 167.46,64.04 168.03,64.04 168.51,64.52 169.19,64.52 169.67,64.04 170.28,64.04 170.76,64.52 171.44,64.52 171.92,64.04 172.53,64.04 173.01,64.52 173.69,64.52 174.17,64.04 174.78,64.04 175.26,64.52 175.94,64.52 176.42,64.04 177.03,64.04 177.51,64.52 178.19,64.52 178.78,63.93 179.17,63.93 179.76,64.52 180.1,64.52 180.95,65.38 181.65,65.38 181.73,65.3 182.62,65.3 182.69,65.38 184.53,65.38 194.76,75.61 194.76,84.33 195.64,85.22 195.64,165.26 196.52,166.14 196.52,166.22 196.88,166.58 197.15,166.58 197.59,167.02 197.59,167.64 197.15,168.08 196.53,168.08 196.25,167.81 196.08,167.81 195.89,168 195.89,170.63 196.24,170.98 196.24,171.61 195.89,171.96 195.89,175.82 195.39,176.32 195.39,187.17 194.07,188.49 194.07,192.68 194.54,193.16 194.54,193.55 194.07,194.02 194.07,197.51 194.54,197.98 194.54,198.37 194.07,198.85 194.07,213.03 194.79,213.75 195.24,213.75 195.82,213.17 195.83,213.17 195.91,213.09 195.91,213.03 197.54,211.4 198.01,211.4 202.16,207.25 203.37,207.25 v1(203.84,207.72) 204.5,207.07 204.5,202.68 209.27,197.9 209.27,180.05 199.28,170.06 199.28,168.36 200,167.64 200,167.02 199.56,166.58 199.54,166.58 198.4,165.44 198.4,85.05 198.48,84.97 199.14,84.84 199.55,84.66 199.92,84.42 200.24,84.1 200.49,83.73 200.66,83.31 200.75,82.87 200.75,82.65 200.75,82.42 200.66,81.98 200.49,81.57 200.24,81.2 199.92,80.88 199.55,80.63 199.14,80.46 198.7,80.37 198.25,80.37 197.97,80.43 196.72,79.18 196.72,72.59 185.16,61.02 183.59,61.02
SL06_DP_79: length 211.8
  L30_DP w0.079: SLOT06.B33 176.72,51.49 177.37,52.14 177.37,53.25 176.58,54.04 176.46,54.04 175.8,54.7 175.29,54.7 175.12,54.87 175.12,54.96 174.74,55.34 174.65,55.34 174.53,55.46 174.04,55.46 173.62,55.04 172.79,55.04 172.49,55.34 171.96,55.34 171.6,54.99 170.85,54.99 170.32,55.52 169.97,55.52 169.15,56.35 169.15,56.89 169.15,57.04 169.63,57.52 170.01,57.52 170.83,58.34 171.37,58.34 171.75,57.96 171.75,57.42 171.84,57.34 171.95,57.34 171.96,57.34 172.49,57.34 172.5,57.34 172.79,57.34 173.08,57.04 173.62,57.04 173.98,57.41 174.55,57.41 174.62,57.34 174.74,57.34 174.85,57.23 175.14,57.23 175.39,56.99 175.85,56.99 176.38,57.52 177.07,57.52 177.13,57.46 177.16,57.46 177.79,56.83 177.91,56.83 178.42,57.34 179.24,57.34 179.66,56.92 180.25,56.92 180.38,57.06 180.67,57.06 180.96,57.34 188.62,57.34 199.2,67.93 199.2,76.31 202.94,80.05 202.94,86.01 200.52,88.43 200.52,164.28 214.9,178.66 214.9,187.58 216.53,189.21 218.64,189.21 221.58,192.15 221.58,197.02 219.05,199.55 213.78,199.55 209.12,204.21 209.12,205.84 208.42,206.54 v1(208.42,207.72)
SL06_DP_80: length 210.4
  L30_DP w0.079: v1(203.84,210.77) 204.97,209.64 204.97,203.57 209.73,198.81 209.73,179.72 199.57,169.56 199.57,168.48 200.29,167.76 200.29,166.9 199.68,166.3 199.66,166.3 198.73,165.37 198.73,85.31 199.69,84.91 200.1,84.63 200.46,84.28 200.74,83.86 200.93,83.39 201.03,82.9 201.03,82.65 201.03,82.4 200.93,81.9 200.74,81.44 200.46,81.02 200.1,80.66 199.69,80.38 199.22,80.19 198.73,80.09 198.04,80.09 197.05,79.11 197.05,71.54 185.7,60.19 181.73,60.19 181.62,60.09 181.49,60.09 181.45,60.04 180.92,60.04 180.44,60.52 179.76,60.52 179.14,59.91 178.55,59.91 178.12,60.34 177.58,60.34 177.21,59.97 176.92,59.97 176.86,59.91 176.51,59.91 176.43,59.99 176.43,60.04 175.94,60.52 175.22,60.52 174.74,60.04 174.21,60.04 173.72,60.53 173.01,60.53 172.62,60.14 172.59,60.14 172.49,60.04 171.96,60.04 171.86,60.14 171.83,60.14 171.44,60.52 170.76,60.52 170.37,60.14 170.34,60.14 170.24,60.04 169.67,60.04 169.19,60.52 168.47,60.52 167.65,59.7 166.69,59.7 164.54,57.55 164.54,54.84 166.33,53.04 166.63,53.04 167.08,52.6 167.08,52.42 167.46,52.04 167.99,52.04 168.37,52.42 168.37,52.84 168.58,53.04 169.12,53.04 169.94,53.86 170.27,53.86 170.45,53.69 170.45,53.42 170.83,53.04 171.37,53.04 171.9,53.58 172.55,53.58 173.08,53.04 173.62,53.04 173.75,53.18 174.04,53.18 174.21,53.34 174.74,53.34 175.12,52.96 175.12,52.39 174.47,51.74 SLOT06.C33
SL06_DP_81: length 213
  L30_DP w0.079: SLOT06.D33 173.56,50.69 174.21,50.04 174.74,50.04 175.12,50.42 175.12,50.96 175.02,51.06 175.02,51.35 174.95,51.42 174.95,51.96 175.41,52.42 175.41,52.97 174.95,53.42 174.95,53.59 174.68,53.86 174.13,53.86 173.49,54.51 173.25,54.51 172.7,53.96 172.7,53.92 172.64,53.86 171.88,53.86 171.35,54.4 171.33,54.4 171.21,54.52 170.71,54.52 170.24,54.04 169.71,54.04 169.33,54.42 169.33,54.59 169.05,54.86 168.51,54.86 168.02,55.35 168.02,56.04 168.64,56.65 168.64,56.73 168.02,57.35 168.02,58.04 168.51,58.52 168.89,58.52 169.71,59.34 170.24,59.34 170.88,58.7 171.32,58.7 171.96,59.34 172.49,59.34 173.27,58.56 173.43,58.56 174.21,59.34 174.74,59.34 175.56,58.52 175.94,58.52 176.58,57.88 176.87,57.88 177.51,58.52 178.19,58.52 178.97,57.74 179.76,58.52 180.44,58.52 181.2,57.77 181.59,57.77 181.73,57.91 186.87,57.91 198.57,69.6 198.57,76.65 202.28,80.36 202.28,85.52 199.88,87.91 199.88,164.71 211.03,175.86 211.03,191.17 211.97,192.11 211.97,199.98 209.53,202.42 208.97,202.42 208.69,202.69 208.69,203.25 207.51,204.44 207.51,209.75 206.96,210.3 206.81,210.3 206.53,210.58 206.53,210.72 v1(203.84,213.41)
SL06_DP_82: length 202.4
  L30_DP w0.079: SLOT06.E33 169.62,51.05 169.12,51.05 169.12,51.04 168.58,51.04 168.09,51.53 167.36,51.53 166.87,51.04 166.33,51.04 163.93,53.45 163.93,57.74 166.9,60.71 166.9,61.04 167.38,61.52 168.07,61.52 168.39,61.2 168.42,61.2 168.58,61.04 169.12,61.04 169.5,61.42 169.5,61.45 169.57,61.52 170.32,61.52 170.8,61.04 171.37,61.04 171.85,61.52 172.57,61.52 173.05,61.04 173.62,61.04 174.1,61.52 174.82,61.52 175.3,61.04 175.87,61.04 176.35,61.52 177.07,61.52 177.55,61.04 178.12,61.04 178.6,61.52 179.32,61.52 179.8,61.04 180.37,61.04 180.57,61.24 180.6,61.24 180.88,61.52 181.57,61.52 181.82,61.27 181.96,61.27 181.99,61.24 182.19,61.24 183.35,62.4 183.97,62.4 195.88,74.31 195.88,79.53 196.33,79.98 196.33,80.78 196.27,80.84 195.96,81.3 195.74,81.82 195.64,82.37 195.64,82.93 195.74,83.48 195.96,83.99 196.27,84.46 196.6,84.78 196.6,165.02 197.31,165.73 197.5,165.73 198.44,166.67 198.44,172.11 208.05,181.72 208.05,195.47 203.38,200.13 202.43,200.13 196.58,205.98 196.58,211.67 v1(196.08,212.18)
SL06_DP_83: length 182
  L30_DP w0.079: v1(196.08,216.75) 195.84,216.75 195.37,216.28 194.98,216.28 194.51,216.75 193.82,216.75 191.78,214.71 191.78,211.98 192.58,211.18 192.58,205.61 190.58,203.61 190.58,196.67 190.54,196.62 190.54,196.23 190.58,196.19 190.58,195.26 190.54,195.21 190.54,194.82 190.58,194.78 190.58,193.59 190.54,193.55 190.54,193.16 190.58,193.11 190.58,191.84 190.54,191.8 190.54,191.41 190.58,191.36 190.58,190.43 190.54,190.39 190.54,189.99 190.58,189.95 190.58,189.2 192.81,186.97 192.81,186.1 193.13,185.78 193.13,185.52 192.81,185.2 192.81,183.9 193.13,183.58 193.13,183.32 192.81,183 192.81,181.7 193.13,181.38 193.13,180.12 192.81,179.8 192.81,178.5 194.05,177.27 194.05,168.27 193.28,167.51 193.28,76.77 182.38,65.86 180.88,65.86 180.67,66.07 180.64,66.07 180.28,66.43 179.92,66.43 179.56,66.07 179.53,66.07 179.32,65.86 178.94,65.86 178.12,65.04 177.58,65.04 176.94,65.68 176.51,65.68 175.87,65.04 175.33,65.04 174.69,65.68 174.26,65.68 173.62,65.04 173.08,65.04 172.26,65.86 171.88,65.86 171.33,66.42 170.62,66.42 170.24,66.04 169.71,66.04 169.33,66.42 168.37,66.42 167.99,66.04 167,66.04 166.37,65.41
SL06_DP_84: length 197.8
  L28_DP w0.079: v1(196.08,221.32) 196.08,221.07 192.36,217.36 191.59,217.36 191.45,217.23 191.04,217.23 190.94,217.33 190.55,217.33 190.27,217.06 190.27,216.71 189.5,215.94 186.94,215.94 186.07,215.07 186.07,197.86 186.91,197.01 186.91,194.37 186.37,193.82 185.86,193.82 185.59,193.55 185.59,193.04 184.84,192.3 184.84,189.28 185.02,189.11 185.02,188.48 184.84,188.3 184.84,105.75 192.96,97.64 192.96,51.14 190.12,48.3 182.53,48.3 181.49,49.34 180.96,49.34 180.32,48.7 179.65,48.7 179.64,48.69 SLOT06.A31
SL06_DP_85: length 215.7
  L28_DP w0.079: v1(193.15,212.18) 192.1,213.23 190.55,213.23 189.84,213.93 189.84,215.22 191.7,217.08 192.59,217.08 195.6,220.09 195.6,220.1 196.55,221.05 196.55,221.6 196.29,221.86 194.97,221.86 193.63,220.51 193.63,219.57 193.35,219.3 192.34,219.3 190.7,217.66 188.78,217.66 188.64,217.52 187.87,217.52 185.72,215.37 185.72,196.75 185.3,196.34 185.3,193.16 184.21,192.07 184.21,189.51 184.74,188.99 184.74,188.6 184.21,188.08 184.21,105.53 192.61,97.14 192.61,51.26 190.1,48.75 182.48,48.75 181.71,49.52 180.88,49.52 180.31,48.95 179.64,48.95 179.24,49.34 178.71,49.34 178.07,48.7 177.4,48.7 177.39,48.69 SLOT06.B31
SL06_DP_86: length 204
  L28_DP w0.079: SLOT06.C31 174.51,48.66 175.1,48.66 175.15,48.7 175.82,48.7 176.46,49.34 176.99,49.34 177.33,49.01 178.12,49.01 178.97,49.86 179.32,49.86 179.44,49.99 179.47,49.99 179.83,50.34 180.37,50.34 180.86,49.85 181.56,49.85 181.7,49.7 181.79,49.7 181.82,49.67 181.96,49.67 182.05,49.58 190.53,49.58 192.33,51.38 192.33,96.71 183.47,105.57 183.47,183.76 183.73,184.03 183.73,184.42 183.47,184.68 183.47,185.17 183.73,185.44 183.73,185.83 183.47,186.09 183.47,189.73 183.73,189.99 183.73,190.39 183.47,190.65 183.47,191.14 183.73,191.41 183.73,191.8 183.47,192.06 183.47,192.36 185.01,193.91 185.01,198.62 184.37,199.26 184.37,219.54 185.79,220.96 188.86,220.96 190.16,222.27 190.51,222.27 190.55,222.23 190.94,222.23 191.77,223.07 192.68,223.07 v1(193.15,222.59)
SL06_DP_87: length 239.1
  L28_DP w0.079: v1(190.74,213.7) 190.74,214.14 195.57,218.97 195.9,218.97 197.01,220.08 197.01,221.74 196.58,222.17 194.82,222.17 191.37,218.73 189.45,218.73 188.52,217.8 187.23,217.8 186.96,218.08 186.96,219.32 188.31,220.67 189.45,220.67 190.71,221.93 193.22,221.93 194.02,222.73 194.02,223.14 193.81,223.35 190.38,223.35 189.15,222.13 186.56,222.13 183.69,219.26 183.69,197.98 183.87,197.8 183.87,194.31 182.79,193.22 182.79,105.06 191.95,95.91 191.95,51.75 190.23,50.03 180.93,50.03 180.44,50.52 179.76,50.52 179.4,50.17 179.37,50.17 179.24,50.04 178.42,50.04 178.12,50.34 177.58,50.34 177.2,49.96 177.2,49.87 176.85,49.52 176.38,49.52 175.75,48.89 175.19,48.89 174.74,49.34 174.21,49.34 173.57,48.7 172.9,48.7 172.89,48.69 SLOT06.D31
SL06_DP_88: length 206.9
  L28_DP w0.079: v1(190.74,224.11) 190.11,223.49 185.51,223.49 183.38,221.36 183.38,197.7 182.05,196.38 182.05,104.86 191.58,95.34 191.58,51.78 190.82,51.02 181.94,51.02 181.58,51.38 180.7,51.38 180.37,51.04 179.83,51.04 179.5,51.38 178.45,51.38 178.12,51.04 178.03,51.04 177.02,50.04 177.02,49.95 176.78,49.7 176.51,49.7 175.87,50.34 175.33,50.34 174.51,49.52 174.13,49.52 173.64,49.03 172.8,49.03 172.49,49.34 171.96,49.34 171.39,48.78 170.72,48.78 170.64,48.69 SLOT06.E31
SL06_DP_89: length 221.9
  L28_DP w0.079: v1(188.33,218.27) 188.33,218.97 189.94,220.58 191.89,220.58 192.96,221.65 193.34,221.65 194.28,222.59 196.77,222.59 197.29,222.07 197.29,214.64 197.09,214.43 197.09,198.56 196.9,198.37 196.9,197.98 197.84,197.04 197.84,189.83 195.39,187.37 195.39,186.33 194.8,185.75 193.76,185.75 192.19,184.17 192.19,184.14 191.6,183.55 191.56,183.55 191.37,183.36 190.76,183.36 190.18,182.77 190.18,182.16 188.69,180.68 188.69,180.1 188.41,179.83 187.84,179.83 185.65,177.64 185.65,105.85 193.24,98.27 193.24,51.02 190.24,48.02 184.78,48.02 184.58,47.83 182.21,47.83 182.19,47.84 181.76,47.84 181.72,47.88 181.54,47.88 181.38,48.04 180.96,48.04 180.58,48.42 180.58,48.57 180.44,48.57 180.39,48.52 179.72,48.52 179.71,48.51 179.62,48.51 179.62,48.42 179.24,48.04 178.67,48.04 178.19,48.52 177.47,48.52 176.99,48.04 176.42,48.04 175.94,48.52 175.22,48.52 174.74,48.04 174.17,48.04 173.69,48.52 172.97,48.52 172.49,48.04 171.92,48.04 171.37,48.6 170.79,48.6 170.24,48.04 169.71,48.04 169.06,48.69 SLOT06.F31
SL06_DP_90:
  vias: v1(265.41,226.99)
SL06_DP_91: length 208
  L28_DP w0.079: v1(260.83,206.69) 260.41,206.69 255.59,201.87 254.89,201.87 250.2,197.18 250.2,177.45 203.13,130.38 203.13,45.87 202.7,45.44 182.48,45.44 SLOT06.Z29
SL06_DP_92: length 211.1
  L28_DP w0.079: SLOT06.A29 180.04,46.69 180.69,46.04 181.28,46.04 183.53,43.8 203.01,43.8 203.91,44.7 203.91,130.01 251.01,177.11 251.01,195.84 255.86,200.68 255.86,201.53 257.94,203.61 259.78,203.61 v1(260.83,204.66)
SL06_DP_93: length 208.4
  L28_DP w0.079: v1(256.26,204.66) 255.79,204.19 255.79,203.68 249.77,197.66 249.77,178.75 202.44,131.42 202.44,46.12 202.14,45.82 183.35,45.82 181.13,48.04 180.96,48.04 180.61,48.39 179.75,48.39 178.06,46.69 SLOT06.B29
SL06_DP_94: length 255
  L30_DP w0.079: v1(266.06,193.35) 266.29,193.35 266.76,193.82 267.15,193.82 267.62,193.35 267.67,193.35 267.75,193.27 267.75,193.16 268.02,192.88 268.29,192.88 268.57,192.6 272.46,192.6 272.74,192.32 273.28,192.32 275.44,190.16 275.44,189.76 276.03,189.16 276.03,184.37 275.43,183.77 275.43,182.91 275.44,182.9 275.44,181.62 275.67,181.38 275.67,180.96 275.44,180.73 275.44,178.53 275.25,178.34 275.25,172.52 273.13,170.41 273.13,164.26 272.12,163.24 268.88,163.24 267.58,162.98 267.16,162.81 266.93,162.81 266.77,162.64 266.59,162.57 266.5,162.57 266.35,162.47 266.17,162.35 265.17,161.68 265.17,161.68 260.64,158.66 207.99,106.01 207.99,42.52 200.98,35.51 182.68,35.51 181.87,34.7 181.87,34.42 181.49,34.04 180.96,34.04 180.32,34.68 179.88,34.68 179.24,34.04 178.71,34.04 178.21,34.54 177.49,34.54 176.99,34.04 176.46,34.04 176.08,34.42 176.08,34.57 175.61,35.04 175.33,35.04 174.69,35.68 174.26,35.68 173.62,35.04 173.08,35.04 172.44,35.68 172.01,35.68 171.37,35.04 170.83,35.04 170.45,35.42 170.45,35.7 170.11,36.04 169.71,36.04 169.33,36.42 169.33,36.77 169.05,37.04 168.58,37.04 168.2,37.42 168.2,37.82 167.97,38.04 167.46,38.04 167.08,38.42 167.08,38.96 167.33,39.21 167.33,39.92 166.9,40.35 166.9,41.04 167.38,41.52 168.12,41.52 168.2,41.6 168.2,41.96 168.58,42.34 169.12,42.34 169.42,42.04 170.07,42.04 170.08,42.04 170.24,42.04 170.62,42.42 170.62,42.84 170.83,43.04 171.37,43.04 171.75,43.42 171.75,43.96 171.83,44.04 172.49,44.04 172.87,44.42 172.87,44.96 172.73,45.11 172.73,45.4 172.7,45.42 172.7,45.96 173.43,46.69 SLOT06.C29
SL06_DP_95: length 193.5
  L28_DP w0.079: UNK8K15.2 252.07,180.76 252.07,176.76 204.54,129.24 204.54,44.28 203.77,43.51 183.32,43.51 181.49,45.34 180.96,45.34 180.62,45.01 179.7,45.01 178.31,46.4 177.35,46.4 176.99,46.04 176.17,46.04 175.87,46.34 175.86,46.34 174.85,47.35 173.93,47.35 173.27,46.69 SLOT06.D29
SL06_DP_96: length 269
  L30_DP w0.079: SLOT06.E29 168.64,46.69 167.99,47.34 167.46,47.34 167.08,46.96 167.08,46.94 166.89,46.76 166.63,46.76 163.02,43.15 163.02,30.94 165.64,28.31 166.3,28.31 166.33,28.34 166.87,28.34 167.36,27.85 168.09,27.85 168.58,28.34 169.12,28.34 169.73,27.73 170.22,27.73 170.83,28.34 171.37,28.34 171.98,27.73 172.47,27.73 173.08,28.34 173.62,28.34 174.23,27.73 174.72,27.73 175.33,28.34 175.87,28.34 176.48,27.73 176.97,27.73 177.58,28.34 178.12,28.34 178.73,27.73 179.34,27.73 179.45,27.84 179.45,27.96 179.83,28.34 180.37,28.34 180.88,27.83 194.61,27.83 208.97,42.19 208.97,104.69 254.23,149.95 255.1,150.07 263.8,158.76 263.8,158.87 263.87,158.95 264.07,159.42 264.74,160.43 265.61,161.3 266.62,161.97 267.09,162.17 267.17,162.24 267.28,162.24 267.75,162.44 268.94,162.68 270.16,162.68 271.99,162.31 273.7,164.02 273.7,170.17 275.81,172.29 275.81,178.11 276,178.3 276,180.49 276.29,180.78 276.29,181.56 276,181.85 276,183.14 275.99,183.14 275.99,183.54 276.6,184.14 276.6,189.4 276,189.99 276,190.39 273.51,192.88 272.97,192.88 272.7,193.16 272.7,193.7 271.48,194.91 271.48,195.21 271.21,195.49 270.91,195.49 v1(268.22,198.18)
SL06_DP_97: length 259.9
  L30_DP w0.079: v1(268.22,193.35) 268.69,192.88 272.58,192.88 272.86,192.6 273.4,192.6 275.72,190.28 275.72,189.88 276.32,189.28 276.32,184.26 275.71,183.65 275.71,183.03 275.72,183.02 275.72,181.74 275.95,181.5 275.95,180.85 275.72,180.61 275.72,178.41 275.53,178.22 275.53,172.4 273.42,170.29 273.42,164.14 272.24,162.96 268.91,162.96 267.66,162.71 267.22,162.53 267.05,162.53 266.93,162.41 266.59,162.27 266.55,162.27 266.49,162.22 266.41,162.17 265.43,161.51 265.43,161.51 261.85,159.12 208.58,105.85 208.58,42.51 194.18,28.11 181.73,28.11 181.62,28.01 180.95,28.01 180.44,28.52 179.76,28.52 179.14,27.91 178.84,27.91 178.53,28.22 178.49,28.22 178.19,28.52 177.51,28.52 177.21,28.22 177.17,28.22 176.99,28.04 176.42,28.04 175.94,28.52 175.26,28.52 174.78,28.04 174.17,28.04 173.69,28.52 173.01,28.52 172.53,28.04 171.92,28.04 171.44,28.52 170.76,28.52 170.28,28.04 169.71,28.04 169.55,28.2 169.51,28.2 169.19,28.52 168.51,28.52 168.19,28.2 168.15,28.2 167.99,28.04 167.46,28.04 167.3,28.2 167.26,28.2 166.94,28.52 166.63,28.52 164.03,31.12 164.03,42.41 166.67,45.04 166.87,45.04 167.72,45.9 SLOT06.F29
SL06_DP_98: length 14.2
  L30_DP w0.079: v1(271.01,193.35) 270.56,193.35 266.49,197.43 266.49,198.81 270.77,203.09 270.77,203.64
SL06_DP_99: length 38.9
  L30_DP w0.079: 294.03,208.22 286.51,215.73 283.44,215.73 283.03,215.65 282.07,215.65 281.66,215.73 281.46,215.73 279.47,213.74 279.08,213.74 279.03,213.78 278.67,213.78 277.26,212.37 277.26,208.66 277.51,208.41 277.51,205.72 276.68,204.89 274.77,204.89 272.7,202.81 272.7,198.65 v1(273.17,198.18)
SL06_DP_100: length 44.8
  L30_DP w0.079: v1(273.17,193.35) 273.17,194.35 272.7,194.82 272.7,195.56 272.47,195.79 272.47,198.47 272.42,198.53 272.42,202.93 274.66,205.17 276.56,205.17 276.77,205.37 276.77,212.53 280.34,216.1 281.22,216.1 282.1,215.93 283,215.93 283.88,216.1 284.71,216.45 284.79,216.5 286.14,216.5 294.22,208.42
SL06_DP_101: length 27.3
  L30_DP w0.079: UNK8K23.2 270.18,183.36 270.18,186.41 269.68,186.91 269.02,186.91 266.53,189.4 266.53,190.39 265.52,191.4 265.52,197.27 265.87,197.62 265.87,200.46 266.51,201.1 268.38,201.1 270.24,202.96 270.24,203.86
SL06_DP_102: length 389.2
  L30_DP w0.079: UNK8K24.2 279.43,182.35 277.73,184.05 277.73,186.97 277.94,187.19 277.94,191.08 275.83,193.2 275.83,203.63 277.79,205.6 277.79,208.25 281.21,211.67 282.28,211.67 283.65,210.3 284.04,210.3 284.31,210.58 284.31,211.87 283.19,213 283.19,214.22 283.65,214.68 285.41,214.68 286.53,213.56 286.53,213.12 286.81,212.84 287.26,212.84 292.98,207.12 292.98,161.89 277.6,146.51 252.37,146.51 212.26,106.4 212.26,35.73 190.6,14.07 159.5,14.07 156.17,17.39 156.17,40.63 162.68,47.14 163.84,47.14 163.86,47.16 165.41,47.16 165.52,47.28 165.67,47.28 165.77,47.38 165.77,48.04 166.26,48.52 166.94,48.52 167.01,48.46 167.04,48.46 167.56,47.94 167.92,47.94 168.51,48.52 169.19,48.52 170.01,47.7 170.19,47.7 170.83,48.34 171.37,48.34 171.75,47.96 171.75,47.42 171.33,47.01 171.33,46.38 171.75,45.96 171.75,45.42 171.37,45.04 170.33,45.04 SLOT06.E27
SL06_DP_103: length 335.5
  L30_DP w0.079: v1(276.47,193.35) 277.51,194.39 277.51,196.83 280.22,199.55 287.04,199.55 292.12,194.46 292.12,162.24 277.25,147.36 252.14,147.36 211.41,106.63 211.41,36.08 206.87,31.55 206.87,31.37 190.19,14.69 161.01,14.69 157.38,18.32 157.38,39.89 164.1,46.6 166.21,46.6 166.55,46.94 166.82,46.94 166.9,47.02 166.9,47.04 167.38,47.52 168.07,47.52 168.65,46.94 169.31,46.94 169.71,47.34 170.24,47.34 170.62,46.96 170.62,46.42 169.72,45.52 169.63,45.52 169.15,45.04 169.15,44.95 168.89,44.69 SLOT06.F27
SL06_DP_104:
  vias: v1(283.84,200.87)
SL06_DP_105:
  vias: v1(288.42,200.87)
SL06_DP_106:
  vias: v1(283.84,204.68)
SL06_DP_107:
  vias: v1(288.42,204.68)
SL06_DP_108:
  vias: v1(283.84,207.72)
SL06_DP_109:
  vias: v1(288.42,207.72)
SL06_DP_110: length 358.7
  L30_DP w0.079: SLOT06.E25 169.97,43.78 171.06,44.86 171.44,44.86 172.04,45.46 172.04,45.96 171.54,46.46 171.54,46.92 171.93,47.32 171.93,47.89 171.93,48.04 171.44,48.52 171.06,48.52 170.24,49.34 169.71,49.34 169.07,48.7 168.63,48.7 167.99,49.34 167.46,49.34 166.82,48.7 166.18,48.7 165.16,47.69 162.21,47.69 155.88,41.36 155.88,16.85 159.18,13.55 191.04,13.55 212.78,35.28 212.78,106.52 252.25,145.99 277.82,145.99 293.5,161.67 293.5,207.88 285.93,215.45 283.47,215.45 283.21,215.4 282.83,215.02 282.83,213.58 282.9,213.51 282.9,213.12 282.83,213.05 282.83,211.78 v1(283.84,210.77)
SL06_DP_111: length 344.1
  L30_DP w0.079: SLOT06.F25 168.82,42.69 169.58,43.46 169.58,44.17 169.33,44.42 169.33,44.96 169.71,45.34 169.83,45.34 170.48,46 170.48,46.03 170.8,46.35 170.8,47.04 170.32,47.52 169.94,47.52 169.12,48.34 168.58,48.34 167.94,47.7 167.51,47.7 166.87,48.34 166.33,48.34 165.95,47.96 165.95,47.31 165.52,46.88 163.98,46.88 163.94,46.84 163.23,46.84 156.75,40.36 156.75,17.4 159.8,14.35 190.48,14.35 211.98,35.84 211.98,106.8 251.96,146.79 277.48,146.79 292.7,162 292.7,205.91 289.51,209.1 289.36,209.1 285.97,212.49 284.76,212.49 v1(283.84,213.41)
SL06_DP_112: length 46.2
  L30_DP w0.079: 294.68,207.33 294.68,219.91 287.25,227.34 281.52,227.34 277.72,223.54 277.72,215.33 277.26,214.87 277.26,213.68 276.07,212.49 v1(276.07,212.18)
SL06_DP_113: length 257.4
  L30_DP w0.079: SLOT06.B23 177.77,40.69 178.74,39.72 179.12,39.72 179.79,39.04 180.37,39.04 180.75,39.42 180.75,39.96 180.37,40.34 180.37,40.88 180.85,41.36 181.89,41.36 182.28,40.97 182.28,40.36 182.84,39.8 202.69,39.8 205.4,42.5 205.4,110.66 263.49,168.76 263.49,183.32 262.79,184.03 262.79,190.39 262.88,190.47 262.88,191.32 262.79,191.41 262.79,191.8 263.68,192.69 263.68,194.77 263.73,194.82 263.73,195.21 263.68,195.26 263.68,196.18 263.73,196.23 263.73,196.62 263.68,196.67 263.68,197.59 263.41,197.86 263.41,198.49 264.18,199.26 264.18,212.01 264.46,212.29 264.46,218.23 264.63,218.4 264.63,218.7 266.48,220.54 266.48,220.78 269.37,223.68 269.37,224.31 269.65,224.58 270.28,224.58 270.77,225.07 271.33,225.07 273.63,222.78 273.63,222.61 273.94,222.29 275.81,222.29 276.83,221.27 276.83,217.5 v1(276.07,216.75)
SL06_DP_114: length 267.7
  L30_DP w0.079: v1(276.07,221.32) 276.55,220.85 276.55,217.64 276.26,217.36 275.12,217.36 274.53,216.77 274.53,216.13 273.63,215.23 273.63,215.14 273.35,214.86 273.26,214.86 270.7,212.3 268.91,212.3 268.66,212.05 268.64,212.05 268.41,211.82 268.41,211.8 265.59,208.98 265.59,198.67 265.48,198.57 265.48,197.63 265.23,197.38 265.23,190.35 265.37,190.21 265.37,188.21 265.4,188.18 265.4,168.14 265.37,168.11 265.37,166.86 207.47,108.96 207.47,42.4 200.86,35.79 182.57,35.79 182.08,35.3 181.73,35.3 181.55,35.47 181.05,35.47 180.44,34.86 179.76,34.86 179.15,35.47 178.8,35.47 178.19,34.86 177.51,34.86 176.51,35.86 176.38,35.86 175.99,36.26 175.96,36.26 175.87,36.34 175.33,36.34 175.24,36.26 175.21,36.26 174.82,35.86 174.13,35.86 173.74,36.26 173.71,36.26 173.62,36.34 173.08,36.34 172.99,36.26 172.96,36.26 172.57,35.86 171.88,35.86 171.49,36.26 171.46,36.26 171.37,36.34 171.28,36.34 170.27,37.35 170.27,37.78 170.19,37.86 169.63,37.86 168.63,38.86 168.51,38.86 168.02,39.35 168.02,39.47 167.8,39.69 167.8,39.7 167.08,40.42 167.08,40.96 167.46,41.34 167.99,41.34 168.4,40.93 169.04,40.93 169.63,41.52 170.01,41.52 170.83,42.34 171.37,42.34 171.94,41.77 172.51,41.77 173.08,42.34 173.62,42.34 174.15,41.82 174.15,41.02 SLOT06.C23
SL06_DP_115: length 49.5
  L30_DP w0.079: 294.96,207.33 294.96,220.09 287.39,227.66 281.39,227.66 277.4,223.67 277.4,215.41 276.98,214.99 276.98,214.11 275.52,212.65 274.98,212.65 274.51,212.18 v1(273.15,212.18)
SL06_DP_116: length 253.4
  L30_DP w0.079: SLOT06.E23 170.45,40.22 170.45,39.42 170.83,39.04 171.37,39.04 171.58,38.84 171.58,38.42 171.93,38.07 171.93,37.61 172.01,37.52 172.57,37.52 173.05,37.04 173.62,37.04 173.72,37.14 173.75,37.14 174.13,37.52 174.82,37.52 175.3,37.04 175.9,37.04 176.38,37.52 177.07,37.52 177.15,37.44 177.18,37.44 178.1,36.52 178.19,36.52 178.64,36.07 178.68,36.07 178.74,36.01 179.24,36.01 179.76,36.52 180.44,36.52 180.95,36.01 181.59,36.01 182.22,36.64 200.51,36.64 206.11,42.23 206.11,110.04 264.56,168.49 264.56,187.83 263.79,188.6 263.79,188.99 264.36,189.55 264.36,197.7 264.63,197.98 264.63,198.92 264.74,199.02 264.74,211.77 266.96,213.99 266.96,214.92 267.04,215 267.04,217.99 266.96,218.08 266.96,218.47 267.23,218.74 268.52,218.74 268.8,218.47 269.03,218.47 269.63,219.07 270.04,219.07 270.31,219.35 270.31,219.75 v1(273.15,222.59)
SL06_DP_117: length 246.6
  L30_DP w0.079: v1(270.74,213.7) 267.46,213.7 265.3,211.54 265.3,198.79 265.2,198.68 265.2,197.75 264.95,197.5 264.95,189.17 265.02,189.11 265.02,188.17 265.12,188.07 265.12,168.26 264.95,168.09 264.95,167.23 206.99,109.26 206.99,42.32 200.74,36.07 182.45,36.07 181.96,35.58 181.73,35.58 181.66,35.65 180.98,35.65 180.37,35.04 179.83,35.04 179.22,35.65 178.73,35.65 178.12,35.04 177.58,35.04 176.58,36.04 176.46,36.04 176.06,36.44 176.03,36.44 175.94,36.52 175.26,36.52 175.17,36.44 175.13,36.44 174.74,36.04 174.21,36.04 173.7,36.55 173,36.55 172.49,36.04 171.96,36.04 171.57,36.44 171.53,36.44 171.44,36.52 171.35,36.52 170.45,37.42 170.45,37.86 170.26,38.04 169.71,38.04 168.71,39.04 168.58,39.04 168.2,39.42 168.2,40.22 SLOT06.F23
SL06_DP_118: length 235.7
  L30_DP w0.079: v1(270.74,224.11) 268.53,221.9 268.13,221.9 267.86,221.63 267.86,221.23 264.74,218.12 264.74,212.18 264.46,211.89 264.46,199.14 263.69,198.37 263.69,197.98 264.04,197.64 264.04,189.63 263.51,189.11 263.51,188.48 264,187.99 264,185.22 263.78,185 263.78,168.64 205.83,110.69 205.83,42.53 202.81,39.51 182.4,39.51 SLOT06.Z23
SL06_DP_119: length 261.3
  L30_DP w0.079: v1(268.33,218.27) 268.33,214.29 268.01,213.98 267.35,213.98 265.02,211.66 265.02,198.9 264.92,198.8 264.92,197.86 264.64,197.59 264.64,189.09 264.74,188.99 264.74,188.05 264.84,187.95 264.84,168.37 264.43,167.96 264.43,167.45 206.47,109.49 206.47,42.2 200.63,36.36 182.33,36.36 181.81,35.83 180.88,35.83 180.37,36.34 179.83,36.34 179.32,35.83 178.63,35.83 178.12,36.34 177.99,36.34 176.99,37.34 176.46,37.34 175.96,36.85 175.24,36.85 174.74,37.34 174.21,37.34 173.69,36.83 173,36.83 172.49,37.34 171.93,37.34 171.75,37.52 171.75,38 171.4,38.35 171.4,38.76 171.29,38.86 170.76,38.86 170.27,39.35 170.27,39.48 169.33,40.42 169.33,40.96 169.71,41.34 170.24,41.34 170.62,40.96 170.62,40.53 170.81,40.34 171.37,40.34 172.27,39.44 172.69,39.44 173.08,39.04 173.62,39.04 174.27,39.69 174.68,39.69 175.33,39.04 175.87,39.04 176.43,39.6 176.9,39.6 178.46,38.04 179.53,38.04 180.18,38.69 SLOT06.Z21
SL06_DP_121: length 359.7
  TOP w0.381: UNK2TP_OUT+_1.1 v1(166.61,295.54)
  L28_DP w0.079: v1(166.61,295.54) 162.68,299.48 125.95,299.48 97.51,271.03 97.51,121.28 148.07,70.72 148.07,51.68 161.1,38.66 166.77,38.66 167.46,39.34 167.99,39.34 168.59,38.75 169.11,38.75 169.71,39.34 170.24,39.34 170.86,38.73 171.34,38.73 171.96,39.34 172.49,39.34 173.13,38.7 173.57,38.7 174.21,39.34 174.74,39.34 175.39,38.69 SLOT06.B21
SL06_DP_122: length 360.3
  TOP w0.381: UNK2TP_OUT-_1.1 v1(164.31,295.54)
  L28_DP w0.079: SLOT06.C21 174.72,38.45 175.76,38.45 176.27,37.94 177.06,37.94 177.42,38.3 177.42,39.11 177.19,39.34 176.17,39.34 175.87,39.04 175.33,39.04 174.85,39.52 174.13,39.52 173.56,38.95 173.14,38.95 172.57,39.52 171.88,39.52 171.31,38.95 171.28,38.95 171.23,38.91 170.94,38.91 170.32,39.52 169.78,39.52 169.63,39.52 169.03,38.93 168.66,38.93 168.07,39.52 167.38,39.52 166.8,38.94 161.43,38.94 148.75,51.62 148.75,71.07 140.16,79.67 140.13,79.67 98.17,121.62 98.17,270.07 120.69,292.58 120.69,293.05 120.96,293.33 121.43,293.33 122.83,294.72 122.83,295.09 123.1,295.37 123.47,295.37 123.84,295.73 123.84,295.74 124.11,296.02 124.12,296.02 126.85,298.75 161.1,298.75 v1(164.31,295.54)
SL06_DP_123: length 372.2
  TOP w0.381: UNK2TP_OUT+_2.1 v1(173.22,295.54)
  L28_DP w0.079: SLOT06.D21 171.93,38.39 170.88,38.39 169.83,37.34 169.71,37.34 169.33,36.96 169.33,36.84 169.01,36.52 168.47,36.52 167.99,36.04 167.46,36.04 166.98,36.52 159.44,36.52 145.67,50.3 145.67,70.56 95.78,120.45 95.78,278.1 118.85,301.17 167.59,301.17 v1(173.22,295.54)
SL06_DP_124: length 365.7
  TOP w0.381: UNK2TP_OUT-_2.1 v1(170.91,295.54)
  L28_DP w0.079: SLOT06.E21 169.5,38.22 169.5,37.42 169.12,37.04 168.58,37.04 168.45,37.17 168.16,37.17 167.99,37.34 167.46,37.34 166.82,36.71 165.85,36.71 165.76,36.81 159.71,36.81 146.23,50.29 146.23,70.79 96.13,120.89 96.13,277.27 119.12,300.26 166.2,300.26 v1(170.91,295.54)
SL06_DP_125: length 468.2
  L28_DP w0.079: UNK2R15.1 196.16,227.33 195.68,227.8 195.29,227.8 195.02,227.53 195.02,227.51 194.37,226.86 193.97,226.86 193.7,227.13 192.23,227.13 191.95,226.86 190.99,226.86 190.94,226.8 190.55,226.8 189.17,228.18 189.17,228.71 189.26,228.81 189.26,228.89 189.54,229.17 189.62,229.17 194.57,234.11 194.57,237.54 193.38,238.73 193.38,239.57 193.98,240.17 193.98,241.33 193.38,241.93 193.38,242.77 193.96,243.36 193.96,243.55 193.38,244.13 193.38,244.97 193.96,245.56 193.96,245.75 193.38,246.33 193.38,247.17 194.57,248.36 194.57,269.73 198.27,273.43 198.27,277.29 197.54,278.02 197.54,287.3 184.06,300.78 179.43,300.78 173.63,294.98 170.74,294.98 170.12,295.59 169.57,295.59 165.23,299.93 121.7,299.93 96.92,275.15 96.92,121.1 98.53,119.49 98.53,119.25 147.46,70.32 147.46,50.3 159.39,38.38 167.41,38.38 SLOT06.F21
  BOTTOM w0.203: UNK2R15.1 196.79,227.38 v1(196.79,228.7)
SL06_DP_126: length 474.4
  L28_DP w0.079: UNK2R17.1 191.76,230.37 195.1,233.7 195.1,238.44 195.39,238.73 195.39,239.57 195.1,239.86 195.1,241.64 195.39,241.93 195.39,242.77 195.1,243.06 195.1,243.84 195.39,244.13 195.39,244.97 195.1,245.26 195.1,246.04 195.39,246.33 195.39,247.17 195.1,247.46 195.1,256.57 197.18,258.65 197.49,258.65 198.56,259.72 198.56,277.54 197.86,278.25 197.86,290.46 187.17,301.15 187.11,301.15 186.12,302.15 121.32,302.15 120.62,301.45 118.74,301.45 108.23,290.94 107.86,290.94 95.41,278.49 95.41,119.94 145.05,70.3 145.05,50.25 159.91,35.39 165.99,35.39 166.33,35.04 166.87,35.04 167.21,35.39 168.24,35.39 168.58,35.04 169.12,35.04 169.46,35.39 170.49,35.39 170.83,35.04 171.37,35.04 171.9,35.57 172.02,35.57 173.14,36.69 173.56,36.69 174.21,37.34 174.74,37.34 175.39,36.69 SLOT06.B19
  BOTTOM w0.203: v1(191.71,228.7) 191.71,227.38 UNK2R17.1
