# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#3333  -  []  97.24 183 90 top
NOREF#3334  -  []  344.09 232.66 0 top
NOREF#3335  -  []  304.96 136.89 0 top
NOREF#3336  -  []  83.29 186.2 0 top
NOREF#3337  -  []  222.49 297.25 90 top
NOREF#3338  -  []  508.58 227.1 0 top
NOREF#3339  -  []  315.44 254.76 90 top
NOREF#3340  -  []  325.64 136.62 90 top
NOREF#3341  -  []  350.5 183.72 90 top
NOREF#3342  -  []  357.44 193.76 90 top
NOREF#3343  -  []  473.08 228.45 90 top
NOREF#3344  -  []  212.01 254.76 0 top
NOREF#3345  -  []  212.66 193.56 0 top
NOREF#3346  -  []  485.26 238.38 0 top
NOREF#3347  -  []  534.42 483.75 90 top
NOREF#3348  -  []  349.04 261.34 90 top
NOREF#3349  -  []  351.78 183.92 90 top
NOREF#3350  -  []  341.62 297 90 top
NOREF#3351  -  []  266.85 250.05 0 top
NOREF#3352  -  []  308.01 234.3 90 top
NOREF#3353  -  []  351.11 296.5 90 top
NOREF#3354  -  []  242.33 233.13 90 top
NOREF#3355  -  []  376.33 462.48 90 top
NOREF#3356  -  []  312.23 227.99 90 top
NOREF#3357  -  []  311.6 181.11 90 top
NOREF#3358  -  []  242.68 272.85 0 top
NOREF#3359  -  []  267.25 484.4 0 top
NOREF#3360  -  []  112.42 200.32 0 top
NOREF#3361  -  []  265.14 299.77 0 top
NOREF#3362  -  []  346.71 245.85 0 top
NOREF#3363  -  []  354.1 286.98 90 top
NOREF#3364  -  []  348.62 185.61 0 top
NOREF#3365  -  []  309.53 241.46 90 top
NOREF#3366  -  []  257.23 483.75 90 top
NOREF#3367  -  []  351.21 185.61 0 top
NOREF#3368  -  []  102.38 202.18 0 top
NOREF#3369  -  []  222.56 290.08 90 top
NOREF#3370  -  []  269.23 268.44 0 top
NOREF#3371  -  []  462.68 221.76 0 top
NOREF#3372  -  []  468.6 169.67 0 top
NOREF#3373  -  []  317.44 193.76 90 top
NOREF#3374  -  []  456.13 160.91 90 top
NOREF#3375  -  []  334.3 179.37 90 top
NOREF#3376  -  []  228.67 181.3 0 top
NOREF#3377  -  []  458.37 212.88 0 top
NOREF#3378  -  []  227.05 135.09 90 top
NOREF#3379  -  []  214.36 253.12 0 top
NOREF#3380  -  []  369.83 203.63 90 top
NOREF#3381  -  []  89.64 186.2 0 top
NOREF#3382  -  []  263.27 235.18 0 top
NOREF#3383  -  []  116.42 159.47 90 top
NOREF#3384  -  []  225.14 298.99 90 top
NOREF#3385  -  []  89.64 186.2 0 top
NOREF#3386  -  []  85 290.19 0 top
NOREF#3387  -  []  329.83 203.63 90 top
NOREF#3388  -  []  372.22 484.08 0 top
NOREF#3389  -  []  215.01 242 90 top
NOREF#3390  -  []  249.83 263.63 90 top
NOREF#3391  -  []  103.64 166.09 0 top
NOREF#3392  -  []  328.42 484.4 0 top
NOREF#3393  -  []  350.57 210.84 0 top
NOREF#3394  -  []  308.03 292.21 0 top
NOREF#3395  -  []  306.84 190.05 0 top
NOREF#3396  -  []  152.47 484.32 0 top
NOREF#3397  -  []  238.82 261.5 0 top
NOREF#3398  -  []  303.27 234.62 0 top
NOREF#3399  -  []  214.66 241.23 0 top
NOREF#3400  -  []  419.55 462.48 90 top
NOREF#3401  -  []  353.63 146.07 0 top
NOREF#3402  -  []  234.95 182.76 0 top
NOREF#3403  -  []  218.44 299.07 0 top
NOREF#3404  -  []  212.43 13.4 0 top
NOREF#3405  -  []  548.65 417.57 90 top
NOREF#3406  -  []  334.66 181.23 0 top
NOREF#3407  -  []  304.52 294.3 0 top
NOREF#3408  -  []  343.95 233.9 90 top
NOREF#3409  -  []  293.64 484.08 0 top
NOREF#3410  -  []  408.19 483.75 90 top
NOREF#3411  -  []  122.18 141.22 0 top
NOREF#3412  -  []  463.17 169.27 90 top
NOREF#3413  -  []  312.35 289.79 90 top
NOREF#3414  -  []  225.29 232.02 90 top
NOREF#3415  -  []  294.31 253.56 0 top
NOREF#3416  -  []  349.3 185.2 0 top
NOREF#3417  -  []  271.89 244.88 90 top
NOREF#3418  -  []  311.27 185.2 0 top
NOREF#3419  -  []  408.4 484.4 0 top
NOREF#3420  -  []  321.2 483.75 90 top
NOREF#3421  -  []  333.22 190.39 0 top
NOREF#3422  -  []  298.95 484.4 0 top
NOREF#3423  -  []  277.95 138.45 90 top
NOREF#3424  -  []  271.6 189.57 90 top
NOREF#3425  -  []  344.96 136.89 0 top
NOREF#3426  -  []  19.04 295.46 90 top
NOREF#3427  -  []  468.08 155.06 90 top
NOREF#3428  -  []  300.36 484.4 0 top
NOREF#3429  -  []  87.69 186.2 0 top
NOREF#3430  -  []  456.33 158.26 0 top
NOREF#3431  -  []  17.84 483.76 90 top
NOREF#3432  -  []  270.47 244.57 90 top
NOREF#3433  -  []  468.6 201.42 0 top
NOREF#3434  -  []  232.13 244.72 90 top
NOREF#3435  -  []  86.2 290.99 90 top
NOREF#3436  -  []  307.9 244.41 90 top
NOREF#3437  -  []  308.62 184.96 0 top
NOREF#3438  -  []  334.68 255.18 0 top
NOREF#3439  -  []  274.27 484.4 0 top
NOREF#3440  -  []  305.94 203.76 0 top
NOREF#3441  -  []  237.79 484.4 0 top
NOREF#3442  -  []  111.99 189 0 top
NOREF#3443  -  []  473.08 196.7 90 top
NOREF#3444  -  []  351.08 209.73 0 top
NOREF#3445  -  []  333.54 239.12 90 top
NOREF#3446  -  []  539.45 192.94 0 top
NOREF#3447  -  []  334.36 253.12 0 top
NOREF#3448  -  []  293.29 242.3 90 top
NOREF#3449  -  []  277.14 144.1 90 top
NOREF#3450  -  []  323.11 484.08 0 top
NOREF#3451  -  []  302.56 290.86 0 top
NOREF#3452  -  []  231.48 246.66 90 top
NOREF#3453  -  []  296.91 241.35 90 top
NOREF#3454  -  []  311.71 244.72 0 top
NOREF#3455  -  []  307.41 134.7 0 top
NOREF#3456  -  []  483.93 221.76 0 top
NOREF#3457  -  []  457.43 192.81 0 top
NOREF#3458  -  []  405.89 484.08 0 top
NOREF#3459  -  []  314.44 144.1 0 top
NOREF#3460  -  []  227.03 181.43 90 top
NOREF#3461  -  []  313.08 242.62 90 top
NOREF#3462  -  []  230.59 180.4 0 top
NOREF#3463  -  []  451.08 192.81 0 top
NOREF#3464  -  []  307.99 241.7 0 top
NOREF#3465  -  []  281.04 135.78 0 top
NOREF#3466  -  []  124.28 233.61 90 top
NOREF#3467  -  []  549.44 223.75 90 top
NOREF#3468  -  []  314.91 164.78 0 top
NOREF#3469  -  []  36.08 483.76 90 top
NOREF#3470  -  []  461.17 134.17 0 top
NOREF#3471  -  []  320.3 484.08 0 top
NOREF#3472  -  []  120.64 219.95 0 top
NOREF#3473  -  []  354.61 298.99 90 top
NOREF#3474  -  []  117.24 186.2 0 top
NOREF#3475  -  []  322.6 483.75 90 top
NOREF#3476  -  []  82.01 288.17 0 top
NOREF#3477  -  []  309.53 180.81 90 top
NOREF#3478  -  []  271.48 186.02 90 top
NOREF#3479  -  []  570.88 417.57 90 top
NOREF#3480  -  []  317.11 224.14 90 top
NOREF#3481  -  []  299.25 484.08 0 top
NOREF#3482  -  []  469.03 221.76 0 top
NOREF#3483  -  []  272.05 238.99 0 top
NOREF#3484  -  []  349.28 241.06 0 top
NOREF#3485  -  []  103.16 162.03 0 top
NOREF#3486  -  []  350.91 184.4 0 top
NOREF#3487  -  []  384.54 484.4 0 top
NOREF#3488  -  []  66.31 248.1 0 top
NOREF#3489  -  []  351.48 245.37 90 top
NOREF#3490  -  []  104.54 249.7 0 top
NOREF#3491  -  []  308.93 208.11 0 top
NOREF#3492  -  []  343.27 292.05 0 top
NOREF#3493  -  []  470.13 256.31 0 top
NOREF#3494  -  []  307.7 189.57 90 top
NOREF#3495  -  []  355.12 299.77 90 top
NOREF#3496  -  []  315.48 298.37 0 top
NOREF#3497  -  []  312.87 184.43 0 top
NOREF#3498  -  []  483.26 204.13 0 top
NOREF#3499  -  []  83.29 249.7 0 top
NOREF#3500  -  []  533.93 209.21 0 top
NOREF#3501  -  []  473.18 221.76 0 top
NOREF#3502  -  []  311.03 185.37 0 top
NOREF#3503  -  []  271.21 185.61 0 top
NOREF#3504  -  []  307.37 484.4 0 top
NOREF#3505  -  []  237.14 144.1 90 top
NOREF#3506  -  []  266.61 190.23 90 top
NOREF#3507  -  []  331.64 253.86 90 top
NOREF#3508  -  []  354.95 242.76 0 top
NOREF#3509  -  []  269.53 181.46 90 top
NOREF#3510  -  []  345.88 175.27 0 top
NOREF#3511  -  []  353.56 249.57 90 top
NOREF#3512  -  []  228.03 294.87 0 top
NOREF#3513  -  []  307.05 134.86 0 top
NOREF#3514  -  []  358.71 140.12 90 top
NOREF#3515  -  []  212.13 13.07 0 top
NOREF#3516  -  []  251.16 240.15 0 top
NOREF#3517  -  []  299.33 196.13 0 top
NOREF#3518  -  []  254.68 255.18 0 top
NOREF#3519  -  []  126.59 484.08 0 top
NOREF#3520  -  []  263.09 234.94 0 top
NOREF#3521  -  []  309.3 245.85 0 top
NOREF#3522  -  []  92.94 157.25 0 top
NOREF#3523  -  []  340.67 292.95 0 top
NOREF#3524  -  []  275.21 285.21 90 top
NOREF#3525  -  []  109.42 197.22 90 top
NOREF#3526  -  []  313.11 183.76 90 top
NOREF#3527  -  []  344.52 285.16 90 top
NOREF#3528  -  []  270.55 134.62 0 top
NOREF#3529  -  []  46.1 484.4 0 top
NOREF#3530  -  []  256.21 241.35 90 top
NOREF#3531  -  []  212.54 182.65 90 top
NOREF#3532  -  []  275.44 254.76 90 top
NOREF#3533  -  []  267.66 185.09 0 top
NOREF#3534  -  []  307.05 134.08 90 top
NOREF#3535  -  []  226.63 241.83 90 top
NOREF#3536  -  []  568.42 166.3 0 top
NOREF#3537  -  []  237.49 261.06 90 top
NOREF#3538  -  []  240.79 273.43 0 top
NOREF#3539  -  []  83.29 154.45 0 top
NOREF#3540  -  []  114.29 251.7 0 top
NOREF#3541  -  []  463.78 192.81 0 top
NOREF#3542  -  []  235.23 223.88 90 top
NOREF#3543  -  []  224.96 136.11 90 top
NOREF#3544  -  []  97.76 134.11 0 top
NOREF#3545  -  []  544.41 166.3 90 top
NOREF#3546  -  []  196.91 286.85 0 top
NOREF#3547  -  []  356.28 483.75 90 top
NOREF#3548  -  []  112.42 232.07 0 top
NOREF#3549  -  []  468.08 186.81 90 top
NOREF#3550  -  []  269.17 238.73 90 top
NOREF#3551  -  []  297.83 252.37 0 top
NOREF#3552  -  []  352.23 170.19 90 top
NOREF#3553  -  []  412.91 484.08 0 top
NOREF#3554  -  []  214.38 194.86 0 top
NOREF#3555  -  []  347.9 244.41 90 top
NOREF#3556  -  []  267.57 185.37 90 top
NOREF#3557  -  []  460.48 221.76 0 top
NOREF#3558  -  []  223.95 174.46 90 top
NOREF#3559  -  []  213.61 193.56 0 top
NOREF#3560  -  []  142.65 484.32 0 top
NOREF#3561  -  []  322.81 484.4 0 top
NOREF#3562  -  []  254.42 249.74 90 top
NOREF#3563  -  []  103.59 214.75 90 top
NOREF#3564  -  []  251.16 251.72 0 top
NOREF#3565  -  []  85 293.09 0 top
NOREF#3566  -  []  354.88 483.75 90 top
NOREF#3567  -  []  300.96 175.55 90 top
NOREF#3568  -  []  350.16 244.72 90 top
NOREF#3569  -  []  223.95 172.42 90 top
NOREF#3570  -  []  130.8 484.08 0 top
NOREF#3571  -  []  305.48 233.73 90 top
NOREF#3572  -  []  535.51 233.45 90 top
NOREF#3573  -  []  314.23 187.83 0 top
NOREF#3574  -  []  239.1 143.77 0 top
NOREF#3575  -  []  393.34 466.58 90 top
NOREF#3576  -  []  485.88 253.51 0 top
NOREF#3577  -  []  116.29 183 90 top
NOREF#3578  -  []  65.15 253.55 90 top
NOREF#3579  -  []  349.77 484.08 0 top
NOREF#3580  -  []  349.94 245.61 0 top
NOREF#3581  -  []  80 262.28 90 top
NOREF#3582  -  []  88.89 188.2 0 top
NOREF#3583  -  []  274.82 285.62 0 top
NOREF#3584  -  []  490.86 167.88 90 top
NOREF#3585  -  []  269.11 172.64 90 top
NOREF#3586  -  []  332.43 483.75 90 top
NOREF#3587  -  []  72.69 279.53 0 top
NOREF#3588  -  []  296.91 252.91 90 top
NOREF#3589  -  []  67.52 249.13 90 top
NOREF#3590  -  []  33.01 2.28 90 top
NOREF#3591  -  []  275.33 293.17 0 top
NOREF#3592  -  []  334.66 192.79 0 top
NOREF#3593  -  []  223.09 173.82 0 top
NOREF#3594  -  []  346.6 250.23 90 top
NOREF#3595  -  []  83.2 276.6 90 top
NOREF#3596  -  []  309.53 240.81 90 top
NOREF#3597  -  []  414.95 467.08 0 top
NOREF#3598  -  []  309.3 245.2 0 top
NOREF#3599  -  []  546.77 154.21 90 top
NOREF#3600  -  []  235.81 242.28 90 top
NOREF#3601  -  []  214.66 192.79 0 top
NOREF#3602  -  []  371.73 467.08 0 top
NOREF#3603  -  []  266.54 134.31 90 top
NOREF#3604  -  []  535.13 204.37 90 top
NOREF#3605  -  []  264.52 293.03 90 top
NOREF#3606  -  []  353.47 483.75 90 top
NOREF#3607  -  []  227.67 245.09 0 top
NOREF#3608  -  []  312.46 180.47 90 top
NOREF#3609  -  []  84.1 279.05 0 top
NOREF#3610  -  []  309.5 270 0 top
NOREF#3611  -  []  232.8 187.32 90 top
NOREF#3612  -  []  311.48 246.66 90 top
NOREF#3613  -  []  335.01 253.56 0 top
NOREF#3614  -  []  251.34 194.86 0 top
NOREF#3615  -  []  317.14 144.1 90 top
NOREF#3616  -  []  267.9 182.43 90 top
NOREF#3617  -  []  311.16 183.72 90 top
NOREF#3618  -  []  485.88 221.76 0 top
NOREF#3619  -  []  273.81 183.65 0 top
NOREF#3620  -  []  109.42 143.57 0 top
NOREF#3621  -  []  223.09 174.38 0 top
NOREF#3622  -  []  120.64 156.45 0 top
NOREF#3623  -  []  335.51 181.35 90 top
NOREF#3624  -  []  351.71 244.72 0 top
NOREF#3625  -  []  84.1 292.77 0 top
NOREF#3626  -  []  386.53 463.08 90 top
NOREF#3627  -  []  374.52 483.75 90 top
NOREF#3628  -  []  232.05 178.99 0 top
NOREF#3629  -  []  97.42 134.59 0 top
NOREF#3630  -  []  103.28 141.55 0 top
NOREF#3631  -  []  482.26 195.03 0 top
NOREF#3632  -  []  253.54 239.12 90 top
NOREF#3633  -  []  389.95 483.75 90 top
NOREF#3634  -  []  316.61 287.27 90 top
NOREF#3635  -  []  233.07 243.95 90 top
NOREF#3636  -  []  493.92 208.86 0 top
NOREF#3637  -  []  303.09 172.9 0 top
NOREF#3638  -  []  473.22 208.53 0 top
NOREF#3639  -  []  349 241.77 90 top
NOREF#3640  -  []  351.15 183.72 90 top
NOREF#3641  -  []  263.27 233.14 0 top
NOREF#3642  -  []  229.46 145.44 90 top
NOREF#3643  -  []  221.84 204.24 0 top
NOREF#3644  -  []  106.69 417.57 90 top
NOREF#3645  -  []  227.57 245.37 90 top
NOREF#3646  -  []  239.77 259.98 0 top
NOREF#3647  -  []  215.49 194.86 90 top
NOREF#3648  -  []  311.16 186.31 90 top
NOREF#3649  -  []  275.44 254.76 90 top
NOREF#3650  -  []  94.33 285.82 0 top
NOREF#3651  -  []  497.6 230.88 0 top
NOREF#3652  -  []  263.27 175.18 0 top
NOREF#3653  -  []  272.21 244.43 0 top
NOREF#3654  -  []  220.83 211.63 0 top
NOREF#3655  -  []  271.69 209.1 0 top
NOREF#3656  -  []  315.48 297.35 0 top
NOREF#3657  -  []  312.26 241.11 90 top
NOREF#3658  -  []  349.94 246.26 0 top
NOREF#3659  -  []  509.02 230.4 0 top
NOREF#3660  -  []  251.62 483.75 90 top
NOREF#3661  -  []  59.22 255.11 0 top
NOREF#3662  -  []  309.08 484.08 0 top
NOREF#3663  -  []  255.09 201.99 90 top
NOREF#3664  -  []  370.88 462.53 90 top
NOREF#3665  -  []  272.91 238.51 90 top
NOREF#3666  -  []  212.78 239.12 90 top
NOREF#3667  -  []  269.94 246.91 0 top
NOREF#3668  -  []  344.41 231.76 90 top
NOREF#3669  -  []  311.6 249.57 90 top
NOREF#3670  -  []  110.69 220.6 90 top
NOREF#3671  -  []  353.63 138.2 0 top
NOREF#3672  -  []  269.23 208.44 0 top
NOREF#3673  -  []  42.19 484.08 0 top
NOREF#3674  -  []  312.25 249.57 90 top
NOREF#3675  -  []  311.4 246.12 0 top
NOREF#3676  -  []  229.3 245.85 0 top
NOREF#3677  -  []  301.29 297.9 0 top
NOREF#3678  -  []  210.56 247.12 90 top
NOREF#3679  -  []  251.16 187.72 90 top
NOREF#3680  -  []  314.82 285.62 0 top
NOREF#3681  -  []  488.08 190.01 0 top
NOREF#3682  -  []  40.29 483.76 90 top
NOREF#3683  -  []  534.31 219.75 0 top
NOREF#3684  -  []  308.14 182.25 0 top
NOREF#3685  -  []  304.52 285.16 90 top
NOREF#3686  -  []  334.36 181.55 0 top
NOREF#3687  -  []  272.23 227.99 90 top
NOREF#3688  -  []  483.93 190.01 0 top
NOREF#3689  -  []  351.15 186.31 90 top
NOREF#3690  -  []  266.74 298.45 0 top
NOREF#3691  -  []  341.84 204.24 0 top
NOREF#3692  -  []  252.12 484.08 0 top
NOREF#3693  -  []  99.29 189 0 top
NOREF#3694  -  []  357.68 483.75 90 top
NOREF#3695  -  []  234.49 182.93 90 top
NOREF#3696  -  []  290.33 483.75 90 top
NOREF#3697  -  []  508.58 208.94 0 top
NOREF#3698  -  []  477.58 158.26 0 top
NOREF#3699  -  []  343.09 172.9 0 top
NOREF#3700  -  []  239.02 259.8 90 top
NOREF#3701  -  []  254.68 195.18 0 top
NOREF#3702  -  []  539.45 207.04 0 top
NOREF#3703  -  []  524.27 484.08 0 top
NOREF#3704  -  []  235.12 300.55 0 top
NOREF#3705  -  []  230.59 184.96 0 top
NOREF#3706  -  []  348.67 181.3 0 top
NOREF#3707  -  []  352.21 243.1 0 top
NOREF#3708  -  []  232.05 250.05 0 top
NOREF#3709  -  []  319.73 246.59 0 top
NOREF#3710  -  []  360.49 483.75 90 top
NOREF#3711  -  []  475.32 237.42 90 top
NOREF#3712  -  []  214.68 242.3 90 top
NOREF#3713  -  []  233.4 299.38 0 top
NOREF#3714  -  []  355.48 299.38 0 top
NOREF#3715  -  []  470.13 256.31 0 top
NOREF#3716  -  []  63.94 254.72 0 top
NOREF#3717  -  []  368.01 484.08 0 top
NOREF#3718  -  []  269.53 180.81 90 top
NOREF#3719  -  []  94.04 217.95 0 top
NOREF#3720  -  []  333.39 243.61 0 top
NOREF#3721  -  []  52.92 483.76 90 top
NOREF#3722  -  []  237.95 141.12 90 top
NOREF#3723  -  []  87.81 145.57 0 top
NOREF#3724  -  []  82.32 262.5 90 top
NOREF#3725  -  []  350.55 134.62 90 top
NOREF#3726  -  []  293.39 195.18 0 top
NOREF#3727  -  []  289.83 222.63 90 top
NOREF#3728  -  []  249.83 162.63 90 top
NOREF#3729  -  []  215.09 201.99 90 top
NOREF#3730  -  []  350.26 244.4 0 top
NOREF#3731  -  []  311.21 245.61 0 top
NOREF#3732  -  []  83.21 260.09 90 top
NOREF#3733  -  []  226.74 298.45 0 top
NOREF#3734  -  []  333.61 182 0 top
NOREF#3735  -  []  50.11 483.76 90 top
NOREF#3736  -  []  466.83 190.01 0 top
NOREF#3737  -  []  534.23 208.14 0 top
NOREF#3738  -  []  294.68 182.3 90 top
NOREF#3739  -  []  312.7 190.05 0 top
NOREF#3740  -  []  224.78 261.82 0 top
NOREF#3741  -  []  92.94 189 0 top
NOREF#3742  -  []  271.46 484.4 0 top
NOREF#3743  -  []  351.8 241.77 90 top
NOREF#3744  -  []  329.83 162.63 90 top
NOREF#3745  -  []  113.09 186.2 0 top
NOREF#3746  -  []  387.94 466.58 90 top
NOREF#3747  -  []  523.77 483.76 90 top
NOREF#3748  -  []  308.01 233.3 90 top
NOREF#3749  -  []  306.63 241.83 90 top
NOREF#3750  -  []  87.91 137.16 90 top
NOREF#3751  -  []  300.96 247.12 90 top
NOREF#3752  -  []  271.8 250.23 90 top
NOREF#3753  -  []  229.27 260.08 90 top
NOREF#3754  -  []  336.21 252.91 90 top
NOREF#3755  -  []  343.09 234.94 0 top
NOREF#3756  -  []  355.05 250.23 90 top
NOREF#3757  -  []  198.32 286.85 0 top
NOREF#3758  -  []  227.91 242.43 90 top
NOREF#3759  -  []  310.13 267.46 90 top
NOREF#3760  -  []  213.22 190.39 0 top
NOREF#3761  -  []  211.16 176.15 90 top
NOREF#3762  -  []  312.57 184.24 90 top
NOREF#3763  -  []  151.06 484.32 0 top
NOREF#3764  -  []  276.52 134.86 0 top
NOREF#3765  -  []  99.29 252.5 0 top
NOREF#3766  -  []  295.09 201.99 90 top
NOREF#3767  -  []  260.54 484.08 0 top
NOREF#3768  -  []  451.08 161.06 0 top
NOREF#3769  -  []  378.73 483.75 90 top
NOREF#3770  -  []  117.04 252.35 90 top
NOREF#3771  -  []  495.12 144.71 90 top
NOREF#3772  -  []  18.04 484.4 0 top
NOREF#3773  -  []  344.52 290.37 90 top
NOREF#3774  -  []  350.57 270.84 0 top
NOREF#3775  -  []  267.99 241.7 0 top
NOREF#3776  -  []  253.39 183.61 0 top
NOREF#3777  -  []  295.38 253.86 90 top
NOREF#3778  -  []  458.65 136.37 0 top
NOREF#3779  -  []  480.26 242.63 0 top
NOREF#3780  -  []  313.56 249.57 90 top
NOREF#3781  -  []  311.12 243.92 90 top
NOREF#3782  -  []  560.92 166.3 90 top
NOREF#3783  -  []  83.2 276.6 90 top
NOREF#3784  -  []  297.35 483.75 90 top
NOREF#3785  -  []  310.7 209.35 90 top
NOREF#3786  -  []  267.9 244.41 90 top
NOREF#3787  -  []  317.95 135.78 90 top
NOREF#3788  -  []  334.42 238.17 90 top
NOREF#3789  -  []  103.16 130.28 0 top
NOREF#3790  -  []  265.88 235.27 0 top
NOREF#3791  -  []  240.76 259.88 0 top
NOREF#3792  -  []  99.29 189 0 top
NOREF#3793  -  []  333.86 181.35 90 top
NOREF#3794  -  []  346.63 181.83 90 top
NOREF#3795  -  []  309 181.77 90 top
NOREF#3796  -  []  236.22 286.06 90 top
NOREF#3797  -  []  349.85 244.37 90 top
NOREF#3798  -  []  360.04 140.12 0 top
NOREF#3799  -  []  553.49 149.01 90 top
NOREF#3800  -  []  352.35 292.46 90 top
NOREF#3801  -  []  237.11 224.14 90 top
NOREF#3802  -  []  87.81 227.81 90 top
NOREF#3803  -  []  265.29 232.02 90 top
NOREF#3804  -  []  104.66 130.4 0 top
NOREF#3805  -  []  276.22 286.06 90 top
NOREF#3806  -  []  60.62 272.5 90 top
NOREF#3807  -  []  546.96 198.04 0 top
NOREF#3808  -  []  334.38 243.29 0 top
NOREF#3809  -  []  211.83 230.23 315 top
NOREF#3810  -  []  230.16 244.72 90 top
NOREF#3811  -  []  307.99 181.7 0 top
NOREF#3812  -  []  230.62 247.15 0 top
NOREF#3813  -  []  567.63 153.43 90 top
NOREF#3814  -  []  58.25 265.88 90 top
NOREF#3815  -  []  253.54 190.69 90 top
NOREF#3816  -  []  331.83 266.63 0 top
NOREF#3817  -  []  33.27 483.76 90 top
NOREF#3818  -  []  220.83 271.63 0 top
NOREF#3819  -  []  557.52 295.46 90 top
NOREF#3820  -  []  229.01 181.77 90 top
NOREF#3821  -  []  349.3 185.85 0 top
NOREF#3822  -  []  275.12 298.76 90 top
NOREF#3823  -  []  488.08 221.76 0 top
NOREF#3824  -  []  227 261.5 0 top
NOREF#3825  -  []  139.84 484.32 0 top
NOREF#3826  -  []  311.89 186.26 0 top
NOREF#3827  -  []  493.92 206.32 0 top
NOREF#3828  -  []  315.59 483.75 90 top
NOREF#3829  -  []  254.81 252.91 90 top
NOREF#3830  -  []  268.15 182.25 0 top
NOREF#3831  -  []  123.08 141.55 0 top
NOREF#3832  -  []  483.26 172.38 90 top
NOREF#3833  -  []  269.61 185.05 0 top
NOREF#3834  -  []  233.17 296.17 0 top
NOREF#3835  -  []  73.51 294.22 90 top
NOREF#3836  -  []  367.71 484.4 0 top
NOREF#3837  -  []  312.35 292.46 90 top
NOREF#3838  -  []  212.66 182 0 top
NOREF#3839  -  []  344.24 267.14 0 top
NOREF#3840  -  []  231.89 244.96 0 top
NOREF#3841  -  []  239.19 484.4 0 top
NOREF#3842  -  []  232.46 182.42 90 top
NOREF#3843  -  []  351.6 241.11 90 top
NOREF#3844  -  []  276.23 223.88 90 top
NOREF#3845  -  []  360.37 135.17 0 top
NOREF#3846  -  []  348.17 137.2 90 top
NOREF#3847  -  []  289.83 263.63 90 top
NOREF#3848  -  []  291.64 242.3 90 top
NOREF#3849  -  []  231.89 246.26 0 top
NOREF#3850  -  []  125.87 483.84 90 top
NOREF#3851  -  []  493.92 177.11 0 top
NOREF#3852  -  []  343.34 262.36 90 top
NOREF#3853  -  []  285.64 136.62 90 top
NOREF#3854  -  []  229.04 201.34 90 top
NOREF#3855  -  []  462.48 224.41 90 top
NOREF#3856  -  []  116.77 484.08 0 top
NOREF#3857  -  []  539.65 207.34 0 top
NOREF#3858  -  []  213.16 192.91 90 top
NOREF#3859  -  []  254.38 194.86 0 top
NOREF#3860  -  []  307.05 135.09 90 top
NOREF#3861  -  []  357.14 146.64 90 top
NOREF#3862  -  []  302.45 231.5 0 top
NOREF#3863  -  []  349.46 145.44 90 top
NOREF#3864  -  []  356.11 224.14 90 top
NOREF#3865  -  []  309.94 246.91 0 top
NOREF#3866  -  []  269.85 184.37 90 top
NOREF#3867  -  []  229.27 261.38 90 top
NOREF#3868  -  []  221.81 264.2 0 top
NOREF#3869  -  []  304.52 293.03 90 top
NOREF#3870  -  []  352.23 227.99 0 top
NOREF#3871  -  []  239.47 260.55 90 top
NOREF#3872  -  []  91.64 188.85 90 top
NOREF#3873  -  []  268.67 181.95 0 top
NOREF#3874  -  []  306.27 484.08 0 top
NOREF#3875  -  []  269.94 186.91 0 top
NOREF#3876  -  []  295.56 240.9 90 top
NOREF#3877  -  []  111.99 157.25 0 top
NOREF#3878  -  []  102.34 217.95 0 top
NOREF#3879  -  []  364.92 463.08 90 top
NOREF#3880  -  []  154.05 484.08 0 top
NOREF#3881  -  []  264.52 291.64 0 top
NOREF#3882  -  []  375.92 483.75 90 top
NOREF#3883  -  []  255.01 253.56 0 top
NOREF#3884  -  []  268.01 173.3 90 top
NOREF#3885  -  []  350.59 180.4 0 top
NOREF#3886  -  []  456.67 147.4 90 top
NOREF#3887  -  []  313.62 243.41 0 top
NOREF#3888  -  []  495.12 205.67 90 top
NOREF#3889  -  []  299.33 256.13 0 top
NOREF#3890  -  []  232.35 287.13 90 top
NOREF#3891  -  []  102.34 154.45 0 top
NOREF#3892  -  []  295.56 180.9 90 top
NOREF#3893  -  []  548.24 223 0 top
NOREF#3894  -  []  213.99 242.3 90 top
NOREF#3895  -  []  487.88 160.91 90 top
NOREF#3896  -  []  485.88 190.01 0 top
NOREF#3897  -  []  462.48 192.66 90 top
NOREF#3898  -  []  255.58 254.22 90 top
NOREF#3899  -  []  264.09 172.66 0 top
NOREF#3900  -  []  307.7 249.57 90 top
NOREF#3901  -  []  295.01 242 0 top
NOREF#3902  -  []  232.91 189.57 90 top
NOREF#3903  -  []  454.13 253.51 0 top
NOREF#3904  -  []  349.5 210 0 top
NOREF#3905  -  []  307.25 174.3 90 top
NOREF#3906  -  []  365.83 229.63 90 top
NOREF#3907  -  []  359.08 483.75 90 top
NOREF#3908  -  []  239.73 186.59 0 top
NOREF#3909  -  []  45.79 254.33 0 top
NOREF#3910  -  []  311.58 484.4 0 top
NOREF#3911  -  []  231.8 190.23 90 top
NOREF#3912  -  []  232.23 230.19 90 top
NOREF#3913  -  []  228.31 262.82 0 top
NOREF#3914  -  []  255.01 193.56 0 top
NOREF#3915  -  []  211.83 266.63 0 top
NOREF#3916  -  []  305.42 2.28 90 top
NOREF#3917  -  []  229.94 185.61 0 top
NOREF#3918  -  []  483.26 235.88 90 top
NOREF#3919  -  []  225.03 261.06 0 top
NOREF#3920  -  []  270.55 134.62 90 top
NOREF#3921  -  []  312.78 483.75 90 top
NOREF#3922  -  []  226.91 141.04 90 top
NOREF#3923  -  []  337.83 192.37 0 top
NOREF#3924  -  []  485.13 255.51 0 top
NOREF#3925  -  []  342.95 292.35 90 top
NOREF#3926  -  []  355.21 285.21 90 top
NOREF#3927  -  []  295.71 192.27 0 top
NOREF#3928  -  []  271.94 247.8 0 top
NOREF#3929  -  []  227 259.85 0 top
NOREF#3930  -  []  275.67 484.4 0 top
NOREF#3931  -  []  260.62 297.29 0 top
NOREF#3932  -  []  116.75 229.07 90 top
NOREF#3933  -  []  483.26 140.63 90 top
NOREF#3934  -  []  146.31 483.84 90 top
NOREF#3935  -  []  107.85 194.05 90 top
NOREF#3936  -  []  232.57 186.5 0 top
NOREF#3937  -  []  355.44 194.76 90 top
NOREF#3938  -  []  468.83 160.91 90 top
NOREF#3939  -  []  231.48 245.37 90 top
NOREF#3940  -  []  235.13 183 0 top
NOREF#3941  -  []  267.99 181.06 0 top
NOREF#3942  -  []  272.87 244.43 0 top
NOREF#3943  -  []  350.74 181.59 0 top
NOREF#3944  -  []  313.99 268.8 0 top
NOREF#3945  -  []  80.24 220.75 0 top
NOREF#3946  -  []  267.03 241.43 90 top
NOREF#3947  -  []  348.25 234.12 0 top
NOREF#3948  -  []  231.89 184.89 90 top
NOREF#3949  -  []  215.71 193.56 0 top
NOREF#3950  -  []  255.16 191.22 90 top
NOREF#3951  -  []  125.01 484.32 0 top
NOREF#3952  -  []  307.56 144.79 90 top
NOREF#3953  -  []  353.3 208.63 90 top
NOREF#3954  -  []  348.55 238.53 90 top
NOREF#3955  -  []  264.47 291.41 90 top
NOREF#3956  -  []  231.81 181.77 90 top
NOREF#3957  -  []  543.98 171.11 0 top
NOREF#3958  -  []  360.12 462.48 90 top
NOREF#3959  -  []  232.05 190.05 0 top
NOREF#3960  -  []  255.71 240.7 0 top
NOREF#3961  -  []  274.44 144.1 0 top
NOREF#3962  -  []  292.54 242.65 90 top
NOREF#3963  -  []  335.49 254.86 90 top
NOREF#3964  -  []  313.08 180.67 90 top
NOREF#3965  -  []  387.65 484.08 0 top
NOREF#3966  -  []  559.34 148.37 0 top
NOREF#3967  -  []  464.88 158.26 0 top
NOREF#3968  -  []  251.64 253.86 90 top
NOREF#3969  -  []  231.89 244.88 90 top
NOREF#3970  -  []  347.9 184.41 90 top
NOREF#3971  -  []  99.29 157.25 0 top
NOREF#3972  -  []  345.14 298.99 90 top
NOREF#3973  -  []  356.61 287.27 90 top
NOREF#3974  -  []  542.34 223.67 90 top
NOREF#3975  -  []  458.47 204.47 0 top
NOREF#3976  -  []  149.84 484.08 0 top
NOREF#3977  -  []  305.88 175.27 0 top
NOREF#3978  -  []  213.29 193.86 90 top
NOREF#3979  -  []  267.41 134.7 0 top
NOREF#3980  -  []  310.48 484.08 0 top
NOREF#3981  -  []  234.75 285.63 90 top
NOREF#3982  -  []  350.5 181.77 90 top
NOREF#3983  -  []  522.5 149.61 0 top
NOREF#3984  -  []  534.31 232.71 0 top
NOREF#3985  -  []  104.66 225.65 0 top
NOREF#3986  -  []  234.37 295.53 90 top
NOREF#3987  -  []  307.25 234.3 90 top
NOREF#3988  -  []  344.52 291.64 0 top
NOREF#3989  -  []  239.77 263.03 0 top
NOREF#3990  -  []  242.43 269.89 0 top
NOREF#3991  -  []  313.3 208.63 90 top
NOREF#3992  -  []  312.9 189.57 90 top
NOREF#3993  -  []  119.44 154.45 0 top
NOREF#3994  -  []  365.2 484.08 0 top
NOREF#3995  -  []  376.42 484.08 0 top
NOREF#3996  -  []  100.39 249.7 0 top
NOREF#3997  -  []  380.33 484.4 0 top
NOREF#3998  -  []  83.2 290.32 90 top
NOREF#3999  -  []  311.19 269.1 90 top
NOREF#4000  -  []  341.82 296.65 90 top
NOREF#4001  -  []  47.81 484.08 0 top
NOREF#4002  -  []  307.99 181.06 0 top
NOREF#4003  -  []  480.78 250.31 90 top
NOREF#4004  -  []  272.91 178.51 90 top
NOREF#4005  -  []  233.07 183.95 90 top
NOREF#4006  -  []  309.3 185.85 0 top
NOREF#4007  -  []  491.48 160.26 0 top
NOREF#4008  -  []  214.36 181.55 0 top
NOREF#4009  -  []  95.24 219.95 0 top
NOREF#4010  -  []  473.18 158.26 0 top
NOREF#4011  -  []  305.44 146.16 90 top
NOREF#4012  -  []  350.74 241.59 0 top
NOREF#4013  -  []  294.68 193.86 90 top
NOREF#4014  -  []  352.45 250.23 90 top
NOREF#4015  -  []  236.61 288.05 0 top
NOREF#4016  -  []  254.31 242 0 top
NOREF#4017  -  []  292.66 193.56 0 top
NOREF#4018  -  []  267.03 181.43 90 top
NOREF#4019  -  []  143.51 483.84 90 top
NOREF#4020  -  []  348.62 184.96 0 top
NOREF#4021  -  []  303.34 202.36 90 top
NOREF#4022  -  []  124.28 236.15 90 top
NOREF#4023  -  []  387.39 467.63 0 top
NOREF#4024  -  []  320.04 140.12 0 top
NOREF#4025  -  []  294.36 241.55 0 top
NOREF#4026  -  []  265.48 175.27 0 top
NOREF#4027  -  []  123.19 280.67 90 top
NOREF#4028  -  []  260.81 247.17 90 top
NOREF#4029  -  []  47.51 484.4 0 top
NOREF#4030  -  []  356.61 288.05 0 top
NOREF#4031  -  []  271.39 250.05 0 top
NOREF#4032  -  []  213.99 253.86 90 top
NOREF#4033  -  []  276.11 164.14 90 top
NOREF#4034  -  []  479.53 253.51 0 top
NOREF#4035  -  []  316.11 164.14 90 top
NOREF#4036  -  []  242.13 268.37 90 top
NOREF#4037  -  []  362.24 135.14 90 top
NOREF#4038  -  []  405.59 484.4 0 top
NOREF#4039  -  []  91.64 252.35 90 top
NOREF#4040  -  []  95.99 249.7 0 top
NOREF#4041  -  []  362.09 484.4 0 top
NOREF#4042  -  []  316.23 130.83 90 top
NOREF#4043  -  []  228.95 259.78 90 top
NOREF#4044  -  []  160.89 484.32 0 top
NOREF#4045  -  []  44.7 484.4 0 top
NOREF#4046  -  []  113.24 483.84 90 top
NOREF#4047  -  []  349.11 232.64 90 top
NOREF#4048  -  []  278.71 141.78 90 top
NOREF#4049  -  []  549.06 196.31 90 top
NOREF#4050  -  []  312.25 189.57 90 top
NOREF#4051  -  []  313.73 183.95 90 top
NOREF#4052  -  []  478.78 255.51 0 top
NOREF#4053  -  []  91.64 157.1 90 top
NOREF#4054  -  []  481.53 224.41 90 top
NOREF#4055  -  []  105.64 220.75 0 top
NOREF#4056  -  []  482.83 256.31 0 top
NOREF#4057  -  []  214.31 253.56 90 top
NOREF#4058  -  []  83.29 217.95 0 top
NOREF#4059  -  []  237.14 146.64 90 top
NOREF#4060  -  []  254.31 193.56 0 top
NOREF#4061  -  []  238.82 262.2 0 top
NOREF#4062  -  []  112.42 136.82 0 top
NOREF#4063  -  []  146.86 484.32 0 top
NOREF#4064  -  []  313.35 250.05 0 top
NOREF#4065  -  []  307.25 173.9 90 top
NOREF#4066  -  []  272.46 240.47 90 top
NOREF#4067  -  []  325.83 229.63 90 top
NOREF#4068  -  []  227.05 135.87 0 top
NOREF#4069  -  []  548.24 237.35 0 top
NOREF#4070  -  []  473.22 142.49 0 top
NOREF#4071  -  []  316.89 133.69 0 top
NOREF#4072  -  []  224.52 286.43 0 top
NOREF#4073  -  []  270.26 244.4 0 top
NOREF#4074  -  []  235.81 182.28 90 top
NOREF#4075  -  []  123.08 139.01 0 top
NOREF#4076  -  []  264.41 171.76 90 top
NOREF#4077  -  []  346.54 134.31 90 top
NOREF#4078  -  []  334.68 253.86 90 top
NOREF#4079  -  []  85 262.76 0 top
NOREF#4080  -  []  488.26 180.93 90 top
NOREF#4081  -  []  342.45 171.5 0 top
NOREF#4082  -  []  343.09 234.38 0 top
NOREF#4083  -  []  314.61 298.76 0 top
NOREF#4084  -  []  85.87 281.51 0 top
NOREF#4085  -  []  226.03 245.61 0 top
NOREF#4086  -  []  270.7 209.35 90 top
NOREF#4087  -  []  79.1 263.26 0 top
NOREF#4088  -  []  296.91 192.91 90 top
NOREF#4089  -  []  235.48 299.38 0 top
NOREF#4090  -  []  466.08 255.51 0 top
NOREF#4091  -  []  83.2 262.88 90 top
NOREF#4092  -  []  231.8 250.23 90 top
NOREF#4093  -  []  255.71 192.27 0 top
NOREF#4094  -  []  458.65 136.37 90 top
NOREF#4095  -  []  291.34 194.86 0 top
NOREF#4096  -  []  239.77 262.07 0 top
NOREF#4097  -  []  263.09 173.82 0 top
NOREF#4098  -  []  273.56 249.57 90 top
NOREF#4099  -  []  289.83 263.63 90 top
NOREF#4100  -  []  336.91 192.91 90 top
NOREF#4101  -  []  255.71 180.7 0 top
NOREF#4102  -  []  353.49 295.27 90 top
NOREF#4103  -  []  58.43 247.71 90 top
NOREF#4104  -  []  570 163.32 90 top
NOREF#4105  -  []  349.11 173.64 90 top
NOREF#4106  -  []  117.24 217.95 0 top
NOREF#4107  -  []  266.15 484.08 0 top
NOREF#4108  -  []  296.21 181.35 90 top
NOREF#4109  -  []  215.51 192.91 90 top
NOREF#4110  -  []  405.39 483.75 90 top
NOREF#4111  -  []  568.42 147.59 0 top
NOREF#4112  -  []  112.38 484.32 0 top
NOREF#4113  -  []  268.31 239.21 0 top
NOREF#4114  -  []  352.26 181.11 90 top
NOREF#4115  -  []  223.27 175.18 0 top
NOREF#4116  -  []  302.95 290.44 90 top
NOREF#4117  -  []  270.5 181.77 90 top
NOREF#4118  -  []  270.41 240.16 0 top
NOREF#4119  -  []  228.67 181.95 0 top
NOREF#4120  -  []  387.94 467.08 0 top
NOREF#4121  -  []  319.8 483.75 90 top
NOREF#4122  -  []  408.95 467.68 0 top
NOREF#4123  -  []  547.86 209.66 0 top
NOREF#4124  -  []  294.66 181.23 0 top
NOREF#4125  -  []  116.75 197.32 90 top
NOREF#4126  -  []  213.16 181.35 90 top
NOREF#4127  -  []  229.83 209.1 90 top
NOREF#4128  -  []  232.26 189.57 90 top
NOREF#4129  -  []  148.44 484.08 0 top
NOREF#4130  -  []  313.07 243.95 90 top
NOREF#4131  -  []  87.69 217.95 0 top
NOREF#4132  -  []  266.71 185.85 0 top
NOREF#4133  -  []  291.64 255.18 0 top
NOREF#4134  -  []  352.91 238.51 90 top
NOREF#4135  -  []  352.04 190.05 0 top
NOREF#4136  -  []  215.16 239.65 90 top
NOREF#4137  -  []  343.27 234.06 0 top
NOREF#4138  -  []  311.39 190.05 0 top
NOREF#4139  -  []  20.74 133.8 90 top
NOREF#4140  -  []  110.89 249.7 0 top
NOREF#4141  -  []  312.26 185.65 90 top
NOREF#4142  -  []  252.54 254.22 90 top
NOREF#4143  -  []  411.5 484.08 0 top
NOREF#4144  -  []  236.29 260.94 90 top
NOREF#4145  -  []  51.51 483.76 90 top
NOREF#4146  -  []  315.05 190.23 90 top
NOREF#4147  -  []  228.01 234.3 90 top
NOREF#4148  -  []  227.95 262.07 0 top
NOREF#4149  -  []  274.49 242.93 90 top
NOREF#4150  -  []  114.29 219.95 0 top
NOREF#4151  -  []  231.48 246.02 90 top
NOREF#4152  -  []  103.64 134.34 0 top
NOREF#4153  -  []  37.68 484.4 0 top
NOREF#4154  -  []  270.7 269.35 90 top
NOREF#4155  -  []  78.8 262.93 0 top
NOREF#4156  -  []  325.41 483.75 90 top
NOREF#4157  -  []  265.33 134.7 0 top
NOREF#4158  -  []  314.37 295.53 90 top
NOREF#4159  -  []  213.54 239.12 90 top
NOREF#4160  -  []  291.74 483.75 90 top
NOREF#4161  -  []  194.11 286.85 0 top
NOREF#4162  -  []  26.76 484.08 0 top
NOREF#4163  -  []  87.81 145.57 0 top
NOREF#4164  -  []  271.16 246.31 90 top
NOREF#4165  -  []  117.04 188.85 90 top
NOREF#4166  -  []  289.83 203.63 90 top
NOREF#4167  -  []  325.83 169.63 90 top
NOREF#4168  -  []  272.91 181.11 90 top
NOREF#4169  -  []  352.05 238.99 0 top
NOREF#4170  -  []  215.56 240.9 90 top
NOREF#4171  -  []  254.68 243.61 0 top
NOREF#4172  -  []  255.56 180.9 90 top
NOREF#4173  -  []  319.73 186.59 0 top
NOREF#4174  -  []  235.64 260.94 0 top
NOREF#4175  -  []  349.83 209.1 90 top
NOREF#4176  -  []  232.2 288.28 0 top
NOREF#4177  -  []  97.24 151.25 90 top
NOREF#4178  -  []  310.62 186.5 0 top
NOREF#4179  -  []  535.51 234.85 90 top
NOREF#4180  -  []  535.51 232.06 90 top
NOREF#4181  -  []  223.95 233.34 90 top
NOREF#4182  -  []  244.8 484.4 0 top
NOREF#4183  -  []  292.54 254.22 90 top
NOREF#4184  -  []  334.38 183.29 0 top
NOREF#4185  -  []  269.96 241.3 0 top
NOREF#4186  -  []  355.48 298.37 0 top
NOREF#4187  -  []  331.16 247.72 90 top
NOREF#4188  -  []  310.74 241.59 0 top
NOREF#4189  -  []  16.64 484.4 0 top
NOREF#4190  -  []  309.94 185.61 0 top
NOREF#4191  -  []  227 260.55 0 top
NOREF#4192  -  []  333.54 250.69 90 top
NOREF#4193  -  []  351.4 186.13 0 top
NOREF#4194  -  []  352.04 250.05 0 top
NOREF#4195  -  []  335.76 192.32 0 top
NOREF#4196  -  []  310.16 244.72 90 top
NOREF#4197  -  []  312.57 244.23 90 top
NOREF#4198  -  []  73.51 266.79 90 top
NOREF#4199  -  []  274.91 224.78 0 top
NOREF#4200  -  []  235.91 164.78 0 top
NOREF#4201  -  []  348.14 182.25 0 top
NOREF#4202  -  []  272.7 190.05 0 top
NOREF#4203  -  []  213.54 179.12 90 top
NOREF#4204  -  []  480.26 210.88 0 top
NOREF#4205  -  []  351.15 246.31 90 top
NOREF#4206  -  []  335.09 206.49 0 top
NOREF#4207  -  []  366.6 484.08 0 top
NOREF#4208  -  []  241.44 273.43 90 top
NOREF#4209  -  []  351.17 484.08 0 top
NOREF#4210  -  []  277.14 141.43 90 top
NOREF#4211  -  []  22.25 484.4 0 top
NOREF#4212  -  []  130.05 284.16 90 top
NOREF#4213  -  []  318.71 140.12 90 top
NOREF#4214  -  []  463.78 161.06 0 top
NOREF#4215  -  []  232.91 238.51 90 top
NOREF#4216  -  []  48.71 483.76 90 top
NOREF#4217  -  []  23.65 484.4 0 top
NOREF#4218  -  []  102.38 204.72 0 top
NOREF#4219  -  []  355.13 243 0 top
NOREF#4220  -  []  41.69 483.76 90 top
NOREF#4221  -  []  311.88 484.08 0 top
NOREF#4222  -  []  120.02 227.57 90 top
NOREF#4223  -  []  233.43 246.02 90 top
NOREF#4224  -  []  346.03 245.61 0 top
NOREF#4225  -  []  266.03 185.61 0 top
NOREF#4226  -  []  40.05 272.89 0 top
NOREF#4227  -  []  303.34 262.36 90 top
NOREF#4228  -  []  224.96 136.89 0 top
NOREF#4229  -  []  269.69 136.26 90 top
NOREF#4230  -  []  226.89 260.1 90 top
NOREF#4231  -  []  123.19 255.27 90 top
NOREF#4232  -  []  45 484.08 0 top
NOREF#4233  -  []  311.12 183.92 90 top
NOREF#4234  -  []  231.03 245.37 0 top
NOREF#4235  -  []  112.56 484.08 0 top
NOREF#4236  -  []  343.27 234.62 0 top
NOREF#4237  -  []  526.28 144.71 90 top
NOREF#4238  -  []  306.03 245.61 0 top
NOREF#4239  -  []  349.5 270 0 top
NOREF#4240  -  []  566.06 154.21 0 top
NOREF#4241  -  []  413.81 483.75 90 top
NOREF#4242  -  []  275.91 224.78 0 top
NOREF#4243  -  []  271.27 245.2 0 top
NOREF#4244  -  []  253.86 252.91 90 top
NOREF#4245  -  []  263.09 233.82 0 top
NOREF#4246  -  []  82.32 276.22 90 top
NOREF#4247  -  []  215.38 193.86 90 top
NOREF#4248  -  []  272.35 289.79 90 top
NOREF#4249  -  []  84.1 277.6 0 top
NOREF#4250  -  []  340.81 175.6 90 top
NOREF#4251  -  []  264.24 483.75 90 top
NOREF#4252  -  []  312.2 288.28 0 top
NOREF#4253  -  []  310.41 240.16 0 top
NOREF#4254  -  []  354.37 295.53 90 top
NOREF#4255  -  []  271.89 246.26 0 top
NOREF#4256  -  []  508.11 209.79 90 top
NOREF#4257  -  []  232.35 289.79 90 top
NOREF#4258  -  []  86.2 289.54 90 top
NOREF#4259  -  []  474.12 174.57 0 top
NOREF#4260  -  []  299.12 300.75 0 top
NOREF#4261  -  []  253.61 182 0 top
NOREF#4262  -  []  335.76 252.32 0 top
NOREF#4263  -  []  213.1 180.02 0 top
NOREF#4264  -  []  311.15 190.23 90 top
NOREF#4265  -  []  91.22 289.18 90 top
NOREF#4266  -  []  300.96 235.55 90 top
NOREF#4267  -  []  263.27 174.62 0 top
NOREF#4268  -  []  272.05 181.59 0 top
NOREF#4269  -  []  105.64 252.5 0 top
NOREF#4270  -  []  234.44 138.77 0 top
NOREF#4271  -  []  309.17 238.73 90 top
NOREF#4272  -  []  345.48 235.27 0 top
NOREF#4273  -  []  340.96 247.12 90 top
NOREF#4274  -  []  48.35 268.47 0 top
NOREF#4275  -  []  398.14 467.68 0 top
NOREF#4276  -  []  295.51 241.35 90 top
NOREF#4277  -  []  65.94 249.91 0 top
NOREF#4278  -  []  251.23 236.59 90 top
NOREF#4279  -  []  120.02 195.82 90 top
NOREF#4280  -  []  306.6 250.23 90 top
NOREF#4281  -  []  540.55 206.94 90 top
NOREF#4282  -  []  294.68 253.86 90 top
NOREF#4283  -  []  251.64 255.18 0 top
NOREF#4284  -  []  369.83 203.63 90 top
NOREF#4285  -  []  549.44 235.3 90 top
NOREF#4286  -  []  263.09 174.94 0 top
NOREF#4287  -  []  291.16 247.72 90 top
NOREF#4288  -  []  276.23 163.88 90 top
NOREF#4289  -  []  269.5 270 0 top
NOREF#4290  -  []  311.27 245.2 0 top
NOREF#4291  -  []  43.6 484.08 0 top
NOREF#4292  -  []  213.1 250.39 90 top
NOREF#4293  -  []  253.86 241.35 90 top
NOREF#4294  -  []  274.1 286.98 90 top
NOREF#4295  -  []  333.54 179.12 90 top
NOREF#4296  -  []  215.71 192.27 0 top
NOREF#4297  -  []  253.52 484.08 0 top
NOREF#4298  -  []  214.68 183.61 0 top
NOREF#4299  -  []  239.59 140.38 90 top
NOREF#4300  -  []  275.3 250.05 0 top
NOREF#4301  -  []  84.1 276.15 0 top
NOREF#4302  -  []  80.24 189 0 top
NOREF#4303  -  []  311.69 269.1 0 top
NOREF#4304  -  []  312.2 286.98 90 top
NOREF#4305  -  []  466.83 221.76 0 top
NOREF#4306  -  []  469.03 158.26 0 top
NOREF#4307  -  []  232.23 172.39 90 top
NOREF#4308  -  []  234.75 286.43 0 top
NOREF#4309  -  []  130.05 258.76 90 top
NOREF#4310  -  []  261.64 484.4 0 top
NOREF#4311  -  []  348.52 244.61 90 top
NOREF#4312  -  []  487.26 131.53 90 top
NOREF#4313  -  []  295.76 192.32 0 top
NOREF#4314  -  []  552.28 166.69 0 top
NOREF#4315  -  []  123.79 484.08 0 top
NOREF#4316  -  []  570 149.01 90 top
NOREF#4317  -  []  351.4 181.59 0 top
NOREF#4318  -  []  468.6 233.17 0 top
NOREF#4319  -  []  351.27 245.2 0 top
NOREF#4320  -  []  115.04 249.7 0 top
NOREF#4321  -  []  234.61 298.99 90 top
NOREF#4322  -  []  266.54 135.09 0 top
NOREF#4323  -  []  124.28 170.11 90 top
NOREF#4324  -  []  320 484.4 0 top
NOREF#4325  -  []  351.11 297.8 90 top
NOREF#4326  -  []  46.16 254.72 0 top
NOREF#4327  -  []  271.11 297.8 90 top
NOREF#4328  -  []  454.13 221.76 0 top
NOREF#4329  -  []  304.52 290.37 90 top
NOREF#4330  -  []  352.23 172.39 90 top
NOREF#4331  -  []  458.65 149.38 0 top
NOREF#4332  -  []  474.43 186.81 90 top
NOREF#4333  -  []  314.95 242.76 0 top
NOREF#4334  -  []  40.47 265.88 90 top
NOREF#4335  -  []  560.92 149.79 90 top
NOREF#4336  -  []  35.18 484.08 0 top
NOREF#4337  -  []  482.26 131.53 0 top
NOREF#4338  -  []  263.95 233.9 90 top
NOREF#4339  -  []  214.42 189.74 90 top
NOREF#4340  -  []  373.12 483.75 90 top
NOREF#4341  -  []  255.71 242 0 top
NOREF#4342  -  []  560.92 164.1 90 top
NOREF#4343  -  []  272.45 183.76 90 top
NOREF#4344  -  []  274.23 187.83 0 top
NOREF#4345  -  []  263.95 233.34 90 top
NOREF#4346  -  []  214.68 195.18 0 top
NOREF#4347  -  []  398.19 467.63 0 top
NOREF#4348  -  []  272.35 287.13 90 top
NOREF#4349  -  []  275.48 298.37 0 top
NOREF#4350  -  []  272.87 184.43 0 top
NOREF#4351  -  []  342.45 231.5 0 top
NOREF#4352  -  []  81.69 274.76 90 top
NOREF#4353  -  []  272.13 184.72 90 top
NOREF#4354  -  []  542.83 164.88 0 top
NOREF#4355  -  []  312.05 238.99 0 top
NOREF#4356  -  []  349.33 270.27 0 top
NOREF#4357  -  []  301.56 483.75 90 top
NOREF#4358  -  []  39.07 248.49 0 top
NOREF#4359  -  []  275.19 208.15 90 top
NOREF#4360  -  []  476.48 256.31 0 top
NOREF#4361  -  []  566.42 154.6 0 top
NOREF#4362  -  []  103.16 193.78 0 top
NOREF#4363  -  []  553.49 165.52 90 top
NOREF#4364  -  []  158.1 2.28 90 top
NOREF#4365  -  []  79.1 264.51 0 top
NOREF#4366  -  []  295.16 179.65 90 top
NOREF#4367  -  []  307.9 184.41 90 top
NOREF#4368  -  []  87.91 233.68 90 top
NOREF#4369  -  []  456.33 221.76 0 top
NOREF#4370  -  []  126.41 484.32 0 top
NOREF#4371  -  []  109.94 246.5 90 top
NOREF#4372  -  []  102.34 186.2 0 top
NOREF#4373  -  []  80 277.25 90 top
NOREF#4374  -  []  86.59 157.25 0 top
NOREF#4375  -  []  547.34 224.07 0 top
NOREF#4376  -  []  270.59 180.4 0 top
NOREF#4377  -  []  316.52 134.08 90 top
NOREF#4378  -  []  15.03 483.76 90 top
NOREF#4379  -  []  305.33 133.69 0 top
NOREF#4380  -  []  558.12 166.69 0 top
NOREF#4381  -  []  347.57 185.37 90 top
NOREF#4382  -  []  137.89 483.84 90 top
NOREF#4383  -  []  151.92 483.84 90 top
NOREF#4384  -  []  534.31 221.15 0 top
NOREF#4385  -  []  534.61 221.48 0 top
NOREF#4386  -  []  313.43 246.02 90 top
NOREF#4387  -  []  268.67 181.3 0 top
NOREF#4388  -  []  265.65 483.75 90 top
NOREF#4389  -  []  228.56 178.53 90 top
NOREF#4390  -  []  308.25 174.12 0 top
NOREF#4391  -  []  42.76 297.45 90 top
NOREF#4392  -  []  249.83 225.63 90 top
NOREF#4393  -  []  304.42 176.56 0 top
NOREF#4394  -  []  255.71 182 0 top
NOREF#4395  -  []  253.29 242.3 90 top
NOREF#4396  -  []  507.23 209.41 90 top
NOREF#4397  -  []  231.94 187.8 0 top
NOREF#4398  -  []  241.04 135.78 0 top
NOREF#4399  -  []  272.26 181.11 90 top
NOREF#4400  -  []  355.08 484.4 0 top
NOREF#4401  -  []  294.3 239.37 90 top
NOREF#4402  -  []  269.3 245.2 0 top
NOREF#4403  -  []  545.19 171.5 0 top
NOREF#4404  -  []  415.96 133.8 90 top
NOREF#4405  -  []  460.48 190.01 0 top
NOREF#4406  -  []  506.73 212.18 0 top
NOREF#4407  -  []  95.99 154.45 0 top
NOREF#4408  -  []  275.81 242.28 90 top
NOREF#4409  -  []  350.7 269.35 90 top
NOREF#4410  -  []  273.43 246.02 90 top
NOREF#4411  -  []  269.3 185.2 0 top
NOREF#4412  -  []  232.05 241.59 0 top
NOREF#4413  -  []  80 263.54 90 top
NOREF#4414  -  []  412.4 483.75 90 top
NOREF#4415  -  []  334.29 243.93 0 top
NOREF#4416  -  []  547.34 237.02 0 top
NOREF#4417  -  []  307.03 181.43 90 top
NOREF#4418  -  []  517.31 146.13 90 top
NOREF#4419  -  []  228.53 244.61 90 top
NOREF#4420  -  []  211.16 187.72 90 top
NOREF#4421  -  []  67.34 267.3 90 top
NOREF#4422  -  []  349.3 245.85 0 top
NOREF#4423  -  []  504.91 228.6 90 top
NOREF#4424  -  []  358.71 141.78 90 top
NOREF#4425  -  []  522.87 484.08 0 top
NOREF#4426  -  []  313.07 183.95 90 top
NOREF#4427  -  []  120.98 484.08 0 top
NOREF#4428  -  []  213.22 238.82 90 top
NOREF#4429  -  []  473.08 164.95 90 top
NOREF#4430  -  []  529.88 484.08 0 top
NOREF#4431  -  []  463.78 192.81 0 top
NOREF#4432  -  []  233.08 180.67 90 top
NOREF#4433  -  []  215.06 254.76 0 top
NOREF#4434  -  []  87.91 138.43 90 top
NOREF#4435  -  []  331.64 182.3 90 top
NOREF#4436  -  []  47.19 271.72 90 top
NOREF#4437  -  []  312.22 181.15 0 top
NOREF#4438  -  []  334.3 239.37 90 top
NOREF#4439  -  []  295.49 194.86 90 top
NOREF#4440  -  []  516.13 226.82 90 top
NOREF#4441  -  []  335.76 240.75 0 top
NOREF#4442  -  []  78.8 291.62 0 top
NOREF#4443  -  []  130.05 285.46 90 top
NOREF#4444  -  []  474.12 206.32 0 top
NOREF#4445  -  []  334.42 178.17 90 top
NOREF#4446  -  []  355.12 299.54 0 top
NOREF#4447  -  []  312.91 181.11 90 top
NOREF#4448  -  []  140.7 483.84 90 top
NOREF#4449  -  []  254.68 193.86 90 top
NOREF#4450  -  []  546.96 196.64 0 top
NOREF#4451  -  []  468.08 250.31 90 top
NOREF#4452  -  []  311.89 184.96 0 top
NOREF#4453  -  []  266.33 150.83 0 top
NOREF#4454  -  []  295.71 180.7 0 top
NOREF#4455  -  []  97.24 214.75 90 top
NOREF#4456  -  []  117.04 220.6 90 top
NOREF#4457  -  []  212.13 14.79 0 top
NOREF#4458  -  []  83.2 290.32 90 top
NOREF#4459  -  []  269.11 173.64 90 top
NOREF#4460  -  []  308.55 178.53 90 top
NOREF#4461  -  []  253.16 241.35 90 top
NOREF#4462  -  []  309.83 209.1 90 top
NOREF#4463  -  []  349.11 233.64 90 top
NOREF#4464  -  []  334.81 241.35 90 top
NOREF#4465  -  []  240.04 140.12 0 top
NOREF#4466  -  []  542.34 236.63 90 top
NOREF#4467  -  []  294.31 182 0 top
NOREF#4468  -  []  327.32 484.08 0 top
NOREF#4469  -  []  458.75 140.97 90 top
NOREF#4470  -  []  548.24 235.95 0 top
NOREF#4471  -  []  490.28 221.76 0 top
NOREF#4472  -  []  311.27 179.68 90 top
NOREF#4473  -  []  474 229.34 0 top
NOREF#4474  -  []  351.27 179.68 90 top
NOREF#4475  -  []  115.04 154.45 0 top
NOREF#4476  -  []  270.01 270.51 0 top
NOREF#4477  -  []  334.31 193.56 0 top
NOREF#4478  -  []  245.64 136.62 90 top
NOREF#4479  -  []  473.08 133.2 90 top
NOREF#4480  -  []  457.43 256.31 0 top
NOREF#4481  -  []  291.34 243.29 0 top
NOREF#4482  -  []  124.28 140.9 90 top
NOREF#4483  -  []  333.29 193.86 90 top
NOREF#4484  -  []  238.17 254.55 90 top
NOREF#4485  -  []  349.61 185.05 0 top
NOREF#4486  -  []  233.08 240.67 90 top
NOREF#4487  -  []  384.84 484.08 0 top
NOREF#4488  -  []  475.18 224.41 90 top
NOREF#4489  -  []  264.52 287.7 90 top
NOREF#4490  -  []  483.93 253.51 0 top
NOREF#4491  -  []  231.71 244.72 0 top
NOREF#4492  -  []  140.02 484.08 0 top
NOREF#4493  -  []  308.44 262.36 0 top
NOREF#4494  -  []  230.5 250.23 90 top
NOREF#4495  -  []  312.91 238.51 90 top
NOREF#4496  -  []  409.8 484.4 0 top
NOREF#4497  -  []  294.3 179.37 90 top
NOREF#4498  -  []  232.26 185.65 90 top
NOREF#4499  -  []  278.71 140.12 90 top
NOREF#4500  -  []  312.23 170.19 90 top
NOREF#4501  -  []  251.83 230.23 315 top
NOREF#4502  -  []  293.99 193.86 90 top
NOREF#4503  -  []  112.42 168.57 90 top
NOREF#4504  -  []  102.36 193.37 90 top
NOREF#4505  -  []  271.6 241.11 90 top
NOREF#4506  -  []  359.73 186.59 0 top
NOREF#4507  -  []  214.68 253.86 90 top
NOREF#4508  -  []  293.16 192.91 90 top
NOREF#4509  -  []  233.63 243.41 0 top
NOREF#4510  -  []  332.66 193.56 0 top
NOREF#4511  -  []  252.54 242.65 90 top
NOREF#4512  -  []  123.08 236.8 0 top
NOREF#4513  -  []  215.71 180.7 0 top
NOREF#4514  -  []  237.95 135.78 90 top
NOREF#4515  -  []  349.17 178.73 90 top
NOREF#4516  -  []  108.69 154.45 0 top
NOREF#4517  -  []  253.99 182.3 90 top
NOREF#4518  -  []  535.51 221.9 90 top
NOREF#4519  -  []  264.91 233.9 0 top
NOREF#4520  -  []  19.44 484.4 0 top
NOREF#4521  -  []  270.87 270.03 90 top
NOREF#4522  -  []  214.3 190.94 90 top
NOREF#4523  -  []  228.25 173.12 0 top
NOREF#4524  -  []  281.29 484.4 0 top
NOREF#4525  -  []  322.24 135.14 90 top
NOREF#4526  -  []  231.89 184.96 0 top
NOREF#4527  -  []  350.01 210.51 0 top
NOREF#4528  -  []  231.21 245.61 0 top
NOREF#4529  -  []  483.26 172.38 0 top
NOREF#4530  -  []  275.19 268.15 90 top
NOREF#4531  -  []  293.99 182.3 90 top
NOREF#4532  -  []  269.94 245.61 0 top
NOREF#4533  -  []  476.48 192.81 0 top
NOREF#4534  -  []  351.26 187.56 0 top
NOREF#4535  -  []  211.31 254.76 0 top
NOREF#4536  -  []  315.05 250.23 90 top
NOREF#4537  -  []  331.16 176.15 90 top
NOREF#4538  -  []  213.22 250.39 90 top
NOREF#4539  -  []  264.96 136.89 0 top
NOREF#4540  -  []  366.32 466.58 90 top
NOREF#4541  -  []  270.62 245.85 0 top
NOREF#4542  -  []  213.39 243.61 0 top
NOREF#4543  -  []  454.13 158.26 0 top
NOREF#4544  -  []  473.18 253.51 0 top
NOREF#4545  -  []  213.1 238.82 90 top
NOREF#4546  -  []  266.03 245.61 0 top
NOREF#4547  -  []  293.22 190.39 0 top
NOREF#4548  -  []  309.33 210.27 0 top
NOREF#4549  -  []  504.01 210.17 0 top
NOREF#4550  -  []  265.05 145.8 90 top
NOREF#4551  -  []  14.13 484.08 0 top
NOREF#4552  -  []  332.33 242.3 90 top
NOREF#4553  -  []  539.84 233.03 90 top
NOREF#4554  -  []  353.43 186.02 90 top
NOREF#4555  -  []  534.31 234.1 0 top
NOREF#4556  -  []  377.53 484.4 0 top
NOREF#4557  -  []  479.53 190.01 0 top
NOREF#4558  -  []  290.84 484.08 0 top
NOREF#4559  -  []  230.55 134.62 0 top
NOREF#4560  -  []  232.46 242.42 90 top
NOREF#4561  -  []  421.61 290.38 90 top
NOREF#4562  -  []  90.33 130.36 0 top
NOREF#4563  -  []  356.52 134.86 0 top
NOREF#4564  -  []  303.09 173.82 0 top
NOREF#4565  -  []  80.24 252.5 0 top
NOREF#4566  -  []  230.82 180.82 90 top
NOREF#4567  -  []  238.82 260.55 0 top
NOREF#4568  -  []  282.33 233.13 90 top
NOREF#4569  -  []  313.08 182.62 90 top
NOREF#4570  -  []  225.88 235.27 0 top
NOREF#4571  -  []  315.12 298.76 90 top
NOREF#4572  -  []  263.95 174.46 90 top
NOREF#4573  -  []  409 467.63 0 top
NOREF#4574  -  []  78.8 276.65 0 top
NOREF#4575  -  []  351.15 243.72 90 top
NOREF#4576  -  []  333.39 195.18 0 top
NOREF#4577  -  []  384.34 483.75 90 top
NOREF#4578  -  []  89.64 249.7 0 top
NOREF#4579  -  []  360.32 467.68 0 top
NOREF#4580  -  []  357.11 224.14 90 top
NOREF#4581  -  []  544.41 147.59 90 top
NOREF#4582  -  []  460.48 253.51 0 top
NOREF#4583  -  []  495.12 237.42 90 top
NOREF#4584  -  []  354.44 141.43 0 top
NOREF#4585  -  []  230.62 245.85 0 top
NOREF#4586  -  []  293.1 251.59 0 top
NOREF#4587  -  []  120.64 188.2 0 top
NOREF#4588  -  []  266.54 134.08 0 top
NOREF#4589  -  []  267.25 174.3 90 top
NOREF#4590  -  []  311.81 179.17 90 top
NOREF#4591  -  []  228.62 244.96 0 top
NOREF#4592  -  []  293.22 250.39 0 top
NOREF#4593  -  []  226.71 185.85 0 top
NOREF#4594  -  []  294.68 255.18 0 top
NOREF#4595  -  []  311.69 209.1 0 top
NOREF#4596  -  []  271.94 187.8 0 top
NOREF#4597  -  []  272.04 250.05 0 top
NOREF#4598  -  []  16.94 484.08 0 top
NOREF#4599  -  []  473.2 228.93 90 top
NOREF#4600  -  []  349.96 241.3 0 top
NOREF#4601  -  []  92.94 252.5 0 top
NOREF#4602  -  []  305.29 232.02 90 top
NOREF#4603  -  []  329.83 222.63 90 top
NOREF#4604  -  []  356.23 130.83 90 top
NOREF#4605  -  []  86.2 275.82 90 top
NOREF#4606  -  []  235.23 163.88 90 top
NOREF#4607  -  []  282.49 483.75 90 top
NOREF#4608  -  []  119.44 186.2 0 top
NOREF#4609  -  []  253.1 180.02 0 top
