# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
Net_86 on BOTTOM: 81.43,261.16 81.43,260.93 81.53,260.83 84.02,260.83 84.12,260.93 84.12,261.42 84,261.54 82.33,261.54 82,261.21 81.48,261.21
Net_87 on BOTTOM: 81.43,274.88 81.43,274.65 81.53,274.55 84.02,274.55 84.12,274.65 84.12,275.13 84,275.26 82.33,275.26 82,274.93 81.48,274.93
Net_88 on BOTTOM: 81.43,288.59 81.43,288.37 81.53,288.26 84.02,288.26 84.12,288.37 84.12,288.85 84,288.98 82.33,288.98 82,288.65 81.48,288.65
S1_CON1_0V8 on BOTTOM: 35.18,177.29 35.18,169.54 35.88,168.85 40.32,168.85 41.15,169.67 41.15,177.29 40.64,177.8 35.69,177.8
S1_CON1_0V8 on BOTTOM: 35.18,203.96 35.18,196.22 35.88,195.52 40.32,195.52 41.15,196.34 41.15,203.96 40.64,204.47 35.69,204.47
S1_CON1_1V8 on BOTTOM: 63.11,206.22 63.11,213.97 62.41,214.67 57.97,214.67 57.14,213.84 57.14,206.22 57.65,205.71 62.6,205.71
S1_CON1_A3V3 on BOTTOM: 57.91,188.44 57.15,187.68 57.15,169.14 57.66,168.63 62.61,168.63 63.25,169.27 63.25,187.43 62.23,188.44
S1_CON1_B3V3 on BOTTOM: 63.11,196.06 63.11,203.81 62.41,204.51 57.97,204.51 57.14,203.68 57.14,196.06 57.65,195.55 62.6,195.55
S1_CON1_CORE_0V9 on BOTTOM: 35.18,214.12 35.18,206.38 35.88,205.68 40.32,205.68 41.15,206.5 41.15,214.12 40.64,214.63 35.69,214.63
S1_CON1_CORE_0V9 on BOTTOM: 35.18,187.45 35.18,179.7 35.88,179.01 40.32,179.01 41.15,179.83 41.15,187.45 40.64,187.96 35.69,187.96
S1_DPS4 on BOTTOM: 72.52,179.55 72.52,187.3 71.82,188 67.37,188 66.55,187.17 66.55,179.55 67.06,179.04 72.01,179.04
S1_PWR_F001 on BOTTOM: 49.78,195.07 50.55,195.83 50.55,214.38 50.04,214.88 45.08,214.88 44.45,214.25 44.45,196.09 45.47,195.07
S1_PWR_F004 on BOTTOM: 72.52,169.39 72.52,177.14 71.82,177.84 67.37,177.84 66.55,177.01 66.55,169.39 67.06,168.88 72.01,168.88
S1_PWR_F005 on BOTTOM: 72.52,196.06 72.52,203.81 71.82,204.51 67.37,204.51 66.55,203.68 66.55,196.06 67.06,195.55 72.01,195.55
S1_PWR_F005 on BOTTOM: 72.52,206.22 72.52,213.97 71.82,214.67 67.37,214.67 66.55,213.84 66.55,206.22 67.06,205.71 72.01,205.71
S1_PWR_M_F001 on BOTTOM: 49.78,168.4 50.55,169.16 50.55,187.71 50.04,188.21 45.08,188.21 44.45,187.58 44.45,169.42 45.47,168.4
