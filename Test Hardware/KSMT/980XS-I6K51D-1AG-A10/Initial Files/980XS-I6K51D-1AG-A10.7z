# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UNK3C477  10U-25-X-S6-MU  [C0603]  300.32 268.76 90 bottom
UNK3C478  22U-16-X5R-SA-SS  [C1206]  303.32 268.5 0 bottom
UNK3C922  0.1U-16-X-S4-MU  [C0402]  293.16 246.46 0 bottom
UNK3C923  0.1U-16-X-S4-MU  [C0402]  293.16 234.89 0 bottom
UNK3C924  10P-50-N-S2-MU  [C0201]  291.94 243.61 0 bottom
UNK3C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  309.58 270.27 180 bottom
UNK3C1086  10P-50-N-S2-MU  [C0201]  279.08 484.08 0 top
UNK3C1087  10P-50-N-S2-MU  [C0201]  36.88 484.08 0 top
UNK3C1088  10P-50-N-S2-MU  [C0201]  14.43 484.08 0 top
UNK3C1089  0.1U-16-X-S4-MU  [C0402]  66.94 484.22 0 top
UNK3C1090  0.1U-16-X-S4-MU  [C0402]  132.85 484.22 0 top
UNK3C1091  10P-50-N-S2-MU  [C0201]  15.84 484.08 0 top
UNK3C1093  10P-50-N-S2-MU  [C0201]  17.24 484.08 0 top
UNK3CA1  0.1U-16-X-S4-MU  [C0402]  365.34 294.64 0 bottom
UNK3CA2  10U-25-X7R-SA  [C1206]  365.34 296.67 0 bottom
UNK3CA7  10U-25-X7R-SA  [C1206]  325.12 285.5 0 bottom
UNK3CA8  0.1U-16-X-S4-MU  [C0402]  325.12 283.46 0 bottom
UNK3CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  377.1 293.29 0 bottom
UNK3CA20  10U-25-X7R-SA  [C1206]  296.67 285.5 0 bottom
UNK3CA21  0.1U-16-X-S4-MU  [C0402]  296.67 283.46 0 bottom
UNK3CA22  10U-25-X7R-SA  [C1206]  302.76 281.43 0 bottom
UNK3CA23  0.1U-16-X-S4-MU  [C0402]  302.76 279.4 0 bottom
UNK3CA24  10U-25-X7R-SA  [C1206]  296.67 281.43 0 bottom
UNK3CA25  0.1U-16-X-S4-MU  [C0402]  296.67 279.4 0 bottom
UNK3CA26  10U-25-X7R-SA  [C1206]  315.18 281.43 0 bottom
UNK3CA27  0.1U-16-X-S4-MU  [C0402]  315.18 279.4 0 bottom
UNK3CA34  10U-25-X7R-SA  [C1206]  325.12 281.43 0 bottom
UNK3CA35  0.1U-16-X-S4-MU  [C0402]  325.12 279.4 0 bottom
UNK3CA36  0.1U-16-X-S4-MU  [C0402]  308.85 279.4 0 bottom
UNK3CA37  10U-25-X7R-SA  [C1206]  308.85 281.43 0 bottom
UNK3CA38  10U-25-X7R-SA  [C1206]  206.37 484.92 0 top
UNK3CA39  0.1U-16-X-S4-MU  [C0402]  71.35 484.22 0 top
UNK3CC1  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.19 246.91 180 bottom
UNK3CC2  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.5 250.48 90 bottom
UNK3CC3  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.87 245.61 180 bottom
UNK3CC4  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.19 246.26 180 bottom
UNK3CC5  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.16 246.56 90 bottom
UNK3CC6  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.87 244.96 180 bottom
UNK3CC7  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.14 244.96 0 bottom
UNK3CC8  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.5 243.97 270 bottom
UNK3CC9  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.16 243.97 270 bottom
UNK3CC12  0.1U-16-X7S-S2-MU  [C0201_MINI]  309.85 244.62 270 bottom
UNK3CC13  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.24 241.05 180 bottom
UNK3CC14  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.46 245.61 0 bottom
UNK3CC15  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.19 245.61 180 bottom
UNK3CC16  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.84 244.96 180 bottom
UNK3CC70  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.46 242.67 270 bottom
UNK3CC71  0.1U-16-X7S-S2-MU  [C0201_MINI]  315.38 243 0 bottom
UNK3CC73  0.1U-16-X7S-S2-MU  [C0201_MINI]  307.9 242.68 90 bottom
UNK3CC84  0.1U-16-X7S-S2-MU  [C0201_MINI]  313.11 250.48 90 bottom
UNK3CC85  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.15 250.48 90 bottom
UNK3CC86  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.46 250.48 90 bottom
UNK3CC87  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.14 246.26 180 bottom
UNK3CC88  0.1U-16-X7S-S2-MU  [C0201_MINI]  313.11 244 270 bottom
UNK3CC89  0.1U-16-X7S-S2-MU  [C0201_MINI]  307.9 244.66 270 bottom
UNK3CC90  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.8 250.48 90 bottom
UNK3CC91  0.1U-16-X7S-S2-MU  [C0201_MINI]  314.05 243.65 0 bottom
UNK3CC92  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.45 244 270 bottom
UNK3CC96  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.51 247.56 180 bottom
UNK3CC101  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.84 240.4 0 bottom
UNK3CC103  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.81 242.02 90 bottom
UNK3CC105  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.46 240.72 270 bottom
UNK3CC112  0.1U-16-X7S-S2-MU  [C0201_MINI]  315.05 250.48 90 bottom
UNK3CC130  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.24 241.7 180 bottom
UNK3CC182  0.1U-16-X7S-S2-MU  [C0201_MINI]  306.6 250.48 90 bottom
UNK3CC195  4.7U-25-X7R-S8-TY  [C0805]  174.74 484.67 0 top
UNK3CC202  0.1U-16-X7S-S2-MU  [C0201_MINI]  306.28 245.61 180 bottom
UNK3CC211  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.5 242.02 90 bottom
UNK3CC212  0.1U-16-X7S-S2-MU  [C0201_MINI]  309.53 241.06 180 bottom
UNK3CC213  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.16 242.02 90 bottom
UNK3CC214  0.1U-16-X7S-S2-MU  [C0201_MINI]  119.83 484.08 0 top
UNK3CC215  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.81 239.42 90 bottom
UNK3CC216  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.55 238.78 270 bottom
UNK3CC217  0.1U-16-X7S-S2-MU  [C0201_MINI]  121.23 484.08 0 top
UNK3CC218  0.1U-16-X7S-S2-MU  [C0201_MINI]  122.63 484.08 0 top
UNK3CC219  0.1U-16-X7S-S2-MU  [C0201_MINI]  124.04 484.08 0 top
UNK3CC220  0.1U-16-X7S-S2-MU  [C0201_MINI]  125.44 484.08 0 top
UNK3K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  489.88 220.16 90 bottom
UNK3K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  483.53 220.16 90 bottom
UNK3K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  477.18 220.16 90 bottom
UNK3K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  470.83 220.16 90 bottom
UNK3K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  464.48 220.16 90 bottom
UNK3K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  458.13 220.16 90 bottom
UNK3K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  311.94 258.56 90 bottom
UNK3K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  315.73 231.79 270 bottom
UNK3K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  186.18 269.24 90 bottom
UNK3K96  EC2-5NJ  [RL_NECEC2_10P_5V]  375.6 279.19 270 bottom
UNK3MBD1  BD120-1.5A-S4-MU  [FB0402]  302.95 294.3 270 bottom
UNK3MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  305.87 288.33 180 bottom
UNK3MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  305.87 293.67 180 bottom
UNK3MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  305.87 285.79 180 bottom
UNK3MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  305.87 291 180 bottom
UNK3MR1  1M-1-S4  [R0402_UNBGA_V2]  316.22 286.48 270 bottom
UNK3MR2  1K-0.01-S4  [R0402_UNBGA_V2]  315.91 297.35 180 bottom
UNK3MR3  1K-0.01-S4  [R0402_UNBGA_V2]  313.82 298.37 180 bottom
UNK3MR4  1K-0.01-S4  [R0402_UNBGA_V2]  313.82 299.38 180 bottom
UNK3MR5  1K-0.01-S4  [R0402_UNBGA_V2]  315.91 299.38 0 bottom
UNK3MR6  1K-0.01-S4  [R0402_UNBGA_V2]  315.91 298.37 0 bottom
UNK3MR7  332K-1-S4  [R0402_UNBGA_V2]  315.21 285.63 90 bottom
UNK3MR8  1K-0.01-S4  [R0402_UNBGA_V2]  304.35 299.38 180 bottom
UNK3MR9  499-0.1-S4  [R0402]  304.35 298.27 180 bottom
UNK3MR10  0-5-S4  [R0402]  304.35 297.15 0 bottom
UNK3MR11  750-1-S4  [R0402]  309.3 288.97 180 bottom
UNK3MR12  360-1-S6  [R0603]  309.68 287.7 180 bottom
UNK3MR13  750-1-S4  [R0402]  309.3 294.3 180 bottom
UNK3MR14  1.2K-1-S4  [R0402]  309.05 286.43 0 bottom
UNK3MR15  360-1-S6  [R0603]  309.68 293.03 180 bottom
UNK3MR16  750-1-S4  [R0402]  309.3 291.64 180 bottom
UNK3MR17  360-1-S6  [R0603]  309.68 290.37 180 bottom
UNK3MR18  11K-0.1-S4  [R0402]  301.81 290.87 270 bottom
UNK3MR19  1K-0.01-S4  [R0402_UNBGA_V2]  302.95 290.87 90 bottom
UNK3MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  313.15 287.63 90 bottom
UNK3MU2  KSMT004-SO8  [SO8_244X127MM]  318.06 292.02 90 bottom
UNK3MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  308.92 297.48 180 bottom
UNK3MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  300.67 294.3 0 bottom
UNK3R135  0-5-S4  [R0402]  318.73 225.44 180 bottom
UNK3R136  1M-1-S4  [R0402]  315.73 225.44 0 bottom
UNK3R137  0-5-S4  [R0402]  312.73 225.44 0 bottom
UNK3R160  38.3-1-S2  [R0201_MINI]  303.52 235.18 0 bottom
UNK3R161  38.3-1-S2  [R0201_MINI]  303.52 234.62 0 bottom
UNK3R162  4.7K-1-S2  [R0201_MINI]  308.01 234.55 90 bottom
UNK3R163  0-5-S2  [R0201_MINI]  303.52 233.14 0 bottom
UNK3R164  0-5-S2  [R0201_MINI]  303.52 234.06 0 bottom
UNK3R165  0-5-S2  [R0201_MINI]  308.01 233.55 90 bottom
UNK3R168  42.2-1-S2  [R0201]  293.99 254.16 90 bottom
UNK3R170  42.2-1-S2  [R0201]  293.29 254.16 90 bottom
UNK3R172  0-5-S2  [R0201]  294.96 252.79 0 top
UNK3R176  42.2-1-S2  [R0201]  291.64 254.16 90 bottom
UNK3R178  42.2-1-S2  [R0201]  292.33 254.16 90 bottom
UNK3R180  42.2-1-S2  [R0201]  293.99 242.6 90 bottom
UNK3R182  42.2-1-S2  [R0201]  293.29 242.6 90 bottom
UNK3R200  4.7K-1-S2  [R0201]  473.52 208.53 180 bottom
UNK3R201  0-5-S4  [R0402]  458.44 208.53 180 bottom
UNK3R202  NC/4.7K-1-S4  [R0402]  458.44 207.26 180 bottom
UNK3R203  4.7K-1-S2  [R0201]  473.52 205.99 180 bottom
UNK3R204  0-5-S4  [R0402]  477.12 208.53 180 bottom
UNK3R205  4.7K-1-S2  [R0201]  493.32 208.53 180 bottom
UNK3R206  NC/4.7K-1-S4  [R0402]  477.12 207.26 180 bottom
UNK3R207  4.7K-1-S2  [R0201]  493.32 205.99 180 bottom
UNK3R234  0-1-S4-YA  [R0402]  433.24 484.22 0 top
UNK3R331  10K-1-S2-WA  [R0201]  301.62 297.3 270 bottom
UNK3R509  0-5-S4  [R0402]  299 264.31 90 bottom
UNK3R510  1.2K-1-S4  [R0402]  304.69 265.11 270 bottom
UNK3R511  523-1-S4  [R0402]  305.19 262.36 0 bottom
UNK3R512  0-5-S8  [R0805]  307.48 266.24 270 bottom
UNK3R646  42.2-1-S2  [R0201]  294.68 254.16 90 bottom
UNK3R647  42.2-1-S2  [R0201]  295.38 254.16 90 bottom
UNK3R652  NC/100K-1-S4  [R0402]  310.84 273.67 90 bottom
UNK3R659  10K-1-S2-WA  [R0201]  293.54 250.99 90 top
UNK3R661  4.7K-1-S2  [R0201]  292.78 250.99 270 top
UNK3R662  0-5-S2  [R0201]  294.96 241.23 0 top
UNK3R663  4.7K-1-S2  [R0201]  292.78 239.42 270 top
UNK3R664  42.2-1-S2  [R0201]  292.33 242.6 90 bottom
UNK3R666  42.2-1-S2  [R0201]  291.64 242.6 90 bottom
UNK3R672  10K-1-S2-WA  [R0201]  293.54 239.42 90 top
UNK3R923  100K-1-S4  [R0402]  312 273.67 90 bottom
UNK3R973  0-5-S4  [R0402]  311.42 272.04 0 bottom
UNK3R980  10K-1-S2-WA  [R0201]  313.66 269.4 90 bottom
UNK3R981  NC/4.7K-1-S2  [R0201]  309.83 269.4 270 bottom
UNK3R982  0-5-S2  [R0201]  309.53 268.44 0 bottom
UNK3R1088  42.2-1-S2  [R0201]  294.68 242.6 90 bottom
UNK3R1089  42.2-1-S2  [R0201]  295.38 242.6 90 bottom
UNK3R1098  4.7K-1-S2  [R0201]  352.87 484.08 0 top
UNK3R1099  42.2-1-S2  [R0201]  251.02 484.08 0 top
UNK3R1100  42.2-1-S2  [R0201]  252.42 484.08 0 top
UNK3R1101  4.7K-1-S2  [R0201]  354.28 484.08 0 top
UNK3R1102  0-5-S2  [R0201]  375.32 484.08 0 top
UNK3R1103  42.2-1-S2  [R0201]  253.82 484.08 0 top
UNK3R1104  0-5-S2  [R0201]  376.72 484.08 0 top
UNK3R1105  10K-1-S2-WA  [R0201]  397.77 484.08 0 top
UNK3R1106  42.2-1-S2  [R0201]  255.23 484.08 0 top
UNK3R1107  42.2-1-S2  [R0201]  256.63 484.08 0 top
UNK3R1108  10K-1-S2-WA  [R0201]  399.17 484.08 0 top
UNK3R1109  42.2-1-S2  [R0201]  258.03 484.08 0 top
UNK3R1110  42.2-1-S2  [R0201]  259.44 484.08 0 top
UNK3R1111  42.2-1-S2  [R0201]  260.84 484.08 0 top
UNK3R1114  42.2-1-S2  [R0201]  262.24 484.08 0 top
UNK3R1115  42.2-1-S2  [R0201]  263.64 484.08 0 top
UNK3R1117  0-1-S4-YA  [R0402]  426.63 484.22 0 top
UNK3R1118  0-1-S4-YA  [R0402]  428.83 484.22 0 top
UNK3R1119  0-1-S4-YA  [R0402]  431.03 484.22 0 top
UNK3SA1  SHORT  [DEFAULT_SHORT_SMALL]  305.71 251.64 180 top
UNK3SA2  SHORT  [DEFAULT_SHORT_SMALL]  305.71 252.15 180 top
UNK3SA7  SHORT  [DEFAULT_SHORT_SMALL]  304.03 245.86 90 top
UNK3SA8  SHORT  [DEFAULT_SHORT_SMALL]  305.3 245.86 90 top
UNK3SA9  SHORT  [DEFAULT_SHORT_SMALL]  306.07 238 180 top
UNK3SA10  SHORT  [DEFAULT_SHORT_SMALL]  306.07 237.49 180 top
UNK3SA15  SHORT  [DEFAULT_SHORT_SMALL]  317.49 250.16 90 top
UNK3SA16  SHORT  [DEFAULT_SHORT_SMALL]  316.98 250.16 90 top
UNK3SA17  SHORT  [DEFAULT_SHORT_SMALL]  313.21 238.53 0 top
UNK3SA18  SHORT  [DEFAULT_SHORT_SMALL]  313.21 237.92 0 top
UNK3SA19  SHORT  [DEFAULT_SHORT_SMALL]  304.08 243.68 270 top
UNK3SA20  SHORT  [DEFAULT_SHORT_SMALL]  303.49 243.68 270 top
UNK3SA21  SHORT  [DEFAULT_SHORT_SMALL]  319.27 250.18 90 top
UNK3SA22  SHORT  [DEFAULT_SHORT_SMALL]  320.54 250.2 90 top
UNK3SA23  SHORT  [DEFAULT_SHORT_SMALL]  313.41 237.52 270 top
UNK3SA24  SHORT  [DEFAULT_SHORT_SMALL]  314.06 237.52 270 top
UNK3SA25  SHORT  [DEFAULT_SHORT_SMALL]  492.72 484.3 0 top
UNK3SA26  SHORT  [DEFAULT_SHORT_SMALL]  494.93 484.3 0 top
UNK3TP_DPS1  TP01  [TP_040_T]  364.09 296.67 0 top
UNK3TP_DPS2  TP01  [TP_040_T]  313.93 281.43 0 top
UNK3TP_DPS3  TP01  [TP_040_T]  295.42 285.5 0 top
UNK3TP_DPS4  TP01  [TP_040_T]  323.87 281.43 0 top
UNK3TP_DPS5  TP01  [TP_040_T]  301.51 281.43 0 top
UNK3TP_DPS6  TP01  [TP_040_T]  323.87 285.5 0 top
UNK3TP_DPS7  TP01  [TP_040_T]  295.42 281.43 0 top
UNK3TP_DPS8  TP01  [TP_040_T]  307.6 281.43 180 top
UNK3TP_DPS9  TP01  [TP_040_T]  574.15 484.56 0 top
UNK3TP_MUX_3V3  TP01  [TP_040_T]  295.65 269.49 180 top
UNK3U17  XC6203E-0.4A-33-SOT89  [SOT89]  475.5 199.3 180 bottom
UNK3U18  SK-SO8-1.27-DEDIPROG-V3  [SK_SO8_1P27MM_DEDIPROG_V3]  462.89 206.38 270 bottom
UNK3U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  485.26 206.63 270 bottom
UNK3U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  306.08 234.5 90 bottom
UNK3U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  301.84 264.24 180 bottom
UNK3U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  293.16 249.72 180 bottom
UNK3U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  293.16 238.15 180 bottom
UNK3U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  311.94 269.73 270 bottom
UNK3U455  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  406.15 465.08 0 top
UNK3U456  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  400.74 465.08 0 top
UNK3Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  314.01 221.07 0 bottom
UNK3Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  311.94 265.49 180 bottom
UNK4BD9  BD120-1.5A-S4-MU  [FB0402]  344.65 243.83 270 bottom
UNK4BD21  BD120-1.5A-S4-MU  [FB0402]  342.95 232.36 0 bottom
UNK4BD1728  BD120-1.5A-S4-MU  [FB0402]  349.83 271.82 270 bottom
UNK4BDB5  BD120-1.5A-S4-MU  [FB0402]  331.03 246.46 0 bottom
UNK4BDB6  BD120-1.5A-S4-MU  [FB0402]  331.03 234.89 0 bottom
UNK4BDB7  BD120-1.5A-S4-MU  [FB0402]  550.46 484.17 0 top
UNK4BDB8  BD120-1.5A-S4-MU  [FB0402]  566.1 484.17 0 top
UNK4C262  0.1U-16-X7S-S2-MU  [C0201]  344.41 232.06 270 bottom
UNK4C264  NC/10U-16-X7R-S8-SS  [C0805]  347.48 269.95 90 bottom
UNK4C267  33P-50-N-S2-MU  [C0201]  356.23 224.18 270 bottom
UNK4C268  33P-50-N-S2-MU  [C0201]  355.23 224.18 270 bottom
UNK4C271  12P-50-N-S4-MU  [C0402]  352.95 267.19 180 bottom
UNK4C272  12P-50-N-S4-MU  [C0402]  350.93 267.19 0 bottom
UNK4C278  1U-10-X7S-S4-TDK  [C0402]  352.87 293.11 0 bottom
UNK4C279  1U-10-X7S-S4-TDK  [C0402]  352.87 291.92 0 bottom
UNK4C280  0.1U-16-X-S4-MU  [C0402]  352.87 290.72 0 bottom
UNK4C281  0.1U-16-X-S4-MU  [C0402]  352.87 289.53 0 bottom
UNK4C282  1U-10-X7S-S4-TDK  [C0402]  358.7 286.48 270 bottom
UNK4C283  0.1U-16-X-S4-MU  [C0402]  357.54 286.48 270 bottom
UNK4C284  1U-10-X7S-S4-TDK  [C0402]  357.62 297.85 90 bottom
UNK4C285  0.1U-16-X-S4-MU  [C0402]  358.81 297.85 90 bottom
UNK4C286  0.1U-16-X-S4-MU  [C0402]  353.82 297.35 180 bottom
UNK4C288  1000P-50-X7R-S2-MU  [C0201]  353.49 295.57 270 bottom
UNK4C289  0.1U-16-X-S4-MU  [C0402]  351.21 294.81 270 bottom
UNK4C290  NC/0.1U-16-X7R-S4-TY  [C0402]  344.35 296.03 180 bottom
UNK4C298  0.1U-16-X7S-S2-MU  [C0201]  342.95 292.65 90 bottom
UNK4C299  0.1U-16-X7S-S2-MU  [C0201]  340.02 296.97 180 bottom
UNK4C300  0.1U-16-X-S4-MU  [C0402]  340.67 290.87 270 bottom
UNK4C301  1U-10-X7S-S4-TDK  [C0402]  339.51 290.87 270 bottom
UNK4C302  10P-50-N-S2-MU  [C0201]  334.98 243.61 0 bottom
UNK4C309  10P-50-N-S2-MU  [C0201]  334.98 255.18 0 bottom
UNK4C310  10P-50-N-S2-MU  [C0201]  333.69 255.18 180 bottom
UNK4C318  10P-50-N-S2-MU  [C0201]  331.94 255.18 0 bottom
UNK4C320  10P-50-N-S2-MU  [C0201]  333.69 243.61 180 bottom
UNK4C332  2.2U-16-X7R-S6-TY  [C0603]  479.94 230.46 270 bottom
UNK4C333  0.1U-16-X-S4-MU  [C0402]  478.54 230.64 270 bottom
UNK4C334  10U-16-X7R-S8-SS  [C0805]  470.92 230.34 90 bottom
UNK4C335  0.1U-16-X-S4-MU  [C0402]  472.58 230.16 90 bottom
UNK4C336  4.7U-25-X7R-S8-TY  [C0805]  458.42 244.1 270 bottom
UNK4C337  0.1U-16-X-S4-MU  [C0402]  458.44 241.55 180 bottom
UNK4C338  4.7U-25-X7R-S8-TY  [C0805]  476.84 244.1 270 bottom
UNK4C339  0.1U-16-X-S4-MU  [C0402]  476.87 241.55 180 bottom
UNK4C475  4.7U-6.3-X-S4-MU  [C0402]  345.86 265.11 270 bottom
UNK4C476  1U-10-X7S-S4-TDK  [C0402]  339 268.25 90 bottom
UNK4C477  10U-25-X-S6-MU  [C0603]  340.32 268.76 90 bottom
UNK4C478  22U-16-X5R-SA-SS  [C1206]  343.32 268.5 0 bottom
UNK4C922  0.1U-16-X-S4-MU  [C0402]  333.16 246.46 0 bottom
UNK4C923  0.1U-16-X-S4-MU  [C0402]  333.16 234.89 0 bottom
UNK4C924  10P-50-N-S2-MU  [C0201]  331.94 243.61 0 bottom
UNK4C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  349.58 270.27 180 bottom
UNK4C1086  10P-50-N-S2-MU  [C0201]  18.64 484.08 0 top
UNK4C1087  10P-50-N-S2-MU  [C0201]  20.04 484.08 0 top
UNK4C1088  10P-50-N-S2-MU  [C0201]  21.45 484.08 0 top
UNK4C1089  0.1U-16-X-S4-MU  [C0402]  73.55 484.22 0 top
UNK4C1090  0.1U-16-X-S4-MU  [C0402]  75.76 484.22 0 top
UNK4C1091  10P-50-N-S2-MU  [C0201]  22.85 484.08 0 top
UNK4C1093  10P-50-N-S2-MU  [C0201]  25.66 484.08 0 top
UNK4CA1  0.1U-16-X-S4-MU  [C0402]  378.44 245.11 0 bottom
UNK4CA2  10U-25-X7R-SA  [C1206]  378.44 247.65 0 bottom
UNK4CA7  10U-25-X7R-SA  [C1206]  365.12 285.5 0 bottom
UNK4CA8  0.1U-16-X-S4-MU  [C0402]  365.12 283.46 0 bottom
UNK4CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  391.97 236.27 270 bottom
UNK4CA20  10U-25-X7R-SA  [C1206]  336.67 285.5 0 bottom
UNK4CA21  0.1U-16-X-S4-MU  [C0402]  336.67 283.46 0 bottom
UNK4CA22  10U-25-X7R-SA  [C1206]  342.76 281.43 0 bottom
UNK4CA23  0.1U-16-X-S4-MU  [C0402]  342.76 279.4 0 bottom
UNK4CA24  10U-25-X7R-SA  [C1206]  336.67 281.43 0 bottom
UNK4CA25  0.1U-16-X-S4-MU  [C0402]  336.67 279.4 0 bottom
UNK4CA26  10U-25-X7R-SA  [C1206]  355.18 281.43 0 bottom
UNK4CA27  0.1U-16-X-S4-MU  [C0402]  355.18 279.4 0 bottom
UNK4CA34  10U-25-X7R-SA  [C1206]  365.12 281.43 0 bottom
UNK4CA35  0.1U-16-X-S4-MU  [C0402]  365.12 279.4 0 bottom
UNK4CA36  0.1U-16-X-S4-MU  [C0402]  348.85 279.4 0 bottom
UNK4CA37  10U-25-X7R-SA  [C1206]  348.85 281.43 0 bottom
UNK4CA38  10U-25-X7R-SA  [C1206]  210.97 484.92 0 top
UNK4CA39  0.1U-16-X-S4-MU  [C0402]  77.96 484.22 0 top
UNK4CC1  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.19 246.91 180 bottom
UNK4CC2  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.5 250.48 90 bottom
UNK4CC3  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.87 245.61 180 bottom
UNK4CC4  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.19 246.26 180 bottom
UNK4CC5  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.15 246.56 90 bottom
UNK4CC6  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.87 244.96 180 bottom
UNK4CC7  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.14 244.96 0 bottom
UNK4CC8  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.5 243.97 270 bottom
UNK4CC9  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.15 243.97 270 bottom
UNK4CC12  0.1U-16-X7S-S2-MU  [C0201_MINI]  349.85 244.62 270 bottom
UNK4CC13  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.24 241.05 180 bottom
UNK4CC14  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.45 245.61 0 bottom
UNK4CC15  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.19 245.61 180 bottom
UNK4CC16  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.84 244.96 180 bottom
UNK4CC70  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.45 242.67 270 bottom
UNK4CC71  0.1U-16-X7S-S2-MU  [C0201_MINI]  355.38 243 0 bottom
UNK4CC73  0.1U-16-X7S-S2-MU  [C0201_MINI]  347.9 242.68 90 bottom
UNK4CC84  0.1U-16-X7S-S2-MU  [C0201_MINI]  353.1 250.48 90 bottom
UNK4CC85  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.15 250.48 90 bottom
UNK4CC86  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.45 250.48 90 bottom
UNK4CC87  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.14 246.26 180 bottom
UNK4CC88  0.1U-16-X7S-S2-MU  [C0201_MINI]  353.1 244 270 bottom
UNK4CC89  0.1U-16-X7S-S2-MU  [C0201_MINI]  347.9 244.66 270 bottom
UNK4CC90  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.8 250.48 90 bottom
UNK4CC91  0.1U-16-X7S-S2-MU  [C0201_MINI]  354.05 243.65 0 bottom
UNK4CC92  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.45 244 270 bottom
UNK4CC96  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.51 247.56 180 bottom
UNK4CC101  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.84 240.4 0 bottom
UNK4CC103  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.8 242.02 90 bottom
UNK4CC105  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.45 240.72 270 bottom
UNK4CC112  0.1U-16-X7S-S2-MU  [C0201_MINI]  355.05 250.48 90 bottom
UNK4CC130  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.24 241.7 180 bottom
UNK4CC182  0.1U-16-X7S-S2-MU  [C0201_MINI]  346.6 250.48 90 bottom
UNK4CC195  4.7U-25-X7R-S8-TY  [C0805]  178.54 484.67 0 top
UNK4CC202  0.1U-16-X7S-S2-MU  [C0201_MINI]  346.28 245.61 180 bottom
UNK4CC211  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.5 242.02 90 bottom
UNK4CC212  0.1U-16-X7S-S2-MU  [C0201_MINI]  349.53 241.06 180 bottom
UNK4CC213  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.15 242.02 90 bottom
UNK4CC214  0.1U-16-X7S-S2-MU  [C0201_MINI]  126.84 484.08 0 top
UNK4CC215  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.8 239.42 90 bottom
UNK4CC216  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.55 238.78 270 bottom
UNK4CC217  0.1U-16-X7S-S2-MU  [C0201_MINI]  128.25 484.08 0 top
UNK4CC218  0.1U-16-X7S-S2-MU  [C0201_MINI]  129.65 484.08 0 top
UNK4CC219  0.1U-16-X7S-S2-MU  [C0201_MINI]  141.67 484.08 0 top
UNK4CC220  0.1U-16-X7S-S2-MU  [C0201_MINI]  131.05 484.08 0 top
UNK4K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  489.88 251.91 90 bottom
UNK4K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  483.53 251.91 90 bottom
UNK4K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  477.18 251.91 90 bottom
UNK4K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  470.83 251.91 90 bottom
UNK4K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  464.48 251.91 90 bottom
UNK4K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  458.13 251.91 90 bottom
UNK4K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  351.94 258.56 90 bottom
UNK4K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  355.73 231.79 270 bottom
UNK4K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  195.83 269.24 90 bottom
UNK4K96  EC2-5NJ  [RL_NECEC2_10P_5V]  377.87 237.77 180 bottom
UNK4MBD1  BD120-1.5A-S4-MU  [FB0402]  342.95 294.3 270 bottom
UNK4MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  345.87 288.33 180 bottom
UNK4MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  345.87 293.67 180 bottom
UNK4MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  345.87 285.79 180 bottom
UNK4MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  345.87 291 180 bottom
UNK4MR1  1M-1-S4  [R0402_UNBGA_V2]  356.22 286.48 270 bottom
UNK4MR2  1K-0.01-S4  [R0402_UNBGA_V2]  355.91 297.35 180 bottom
UNK4MR3  1K-0.01-S4  [R0402_UNBGA_V2]  353.82 298.37 180 bottom
UNK4MR4  1K-0.01-S4  [R0402_UNBGA_V2]  353.82 299.38 180 bottom
UNK4MR5  1K-0.01-S4  [R0402_UNBGA_V2]  355.91 299.38 0 bottom
UNK4MR6  1K-0.01-S4  [R0402_UNBGA_V2]  355.91 298.37 0 bottom
UNK4MR7  332K-1-S4  [R0402_UNBGA_V2]  355.21 285.63 90 bottom
UNK4MR8  1K-0.01-S4  [R0402_UNBGA_V2]  344.35 299.38 180 bottom
UNK4MR9  499-0.1-S4  [R0402]  344.35 298.27 180 bottom
UNK4MR10  0-5-S4  [R0402]  344.35 297.15 0 bottom
UNK4MR11  750-1-S4  [R0402]  349.3 288.97 180 bottom
UNK4MR12  360-1-S6  [R0603]  349.68 287.7 180 bottom
UNK4MR13  750-1-S4  [R0402]  349.3 294.3 180 bottom
UNK4MR14  1.2K-1-S4  [R0402]  349.05 286.43 0 bottom
UNK4MR15  360-1-S6  [R0603]  349.68 293.03 180 bottom
UNK4MR16  750-1-S4  [R0402]  349.3 291.64 180 bottom
UNK4MR17  360-1-S6  [R0603]  349.68 290.37 180 bottom
UNK4MR18  11K-0.1-S4  [R0402]  341.81 290.87 270 bottom
UNK4MR19  1K-0.01-S4  [R0402_UNBGA_V2]  342.95 290.87 90 bottom
UNK4MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  353.15 287.63 90 bottom
UNK4MU2  KSMT004-SO8  [SO8_244X127MM]  358.06 292.02 90 bottom
UNK4MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  348.92 297.48 180 bottom
UNK4MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  340.67 294.3 0 bottom
UNK4R135  0-5-S4  [R0402]  358.73 225.44 180 bottom
UNK4R136  1M-1-S4  [R0402]  355.73 225.44 0 bottom
UNK4R137  0-5-S4  [R0402]  352.73 225.44 0 bottom
UNK4R160  38.3-1-S2  [R0201_MINI]  343.52 235.18 0 bottom
UNK4R161  38.3-1-S2  [R0201_MINI]  343.52 234.62 0 bottom
UNK4R162  4.7K-1-S2  [R0201_MINI]  348.01 234.55 90 bottom
UNK4R163  0-5-S2  [R0201_MINI]  343.52 233.14 0 bottom
UNK4R164  0-5-S2  [R0201_MINI]  343.52 234.06 0 bottom
UNK4R165  0-5-S2  [R0201_MINI]  348.01 233.55 90 bottom
UNK4R168  42.2-1-S2  [R0201]  333.99 254.16 90 bottom
UNK4R170  42.2-1-S2  [R0201]  333.29 254.16 90 bottom
UNK4R172  0-5-S2  [R0201]  334.96 252.79 0 top
UNK4R176  42.2-1-S2  [R0201]  331.64 254.16 90 bottom
UNK4R178  42.2-1-S2  [R0201]  332.33 254.16 90 bottom
UNK4R180  42.2-1-S2  [R0201]  333.99 242.6 90 bottom
UNK4R182  42.2-1-S2  [R0201]  333.29 242.6 90 bottom
UNK4R200  4.7K-1-S2  [R0201]  473.52 240.28 180 bottom
UNK4R201  0-5-S4  [R0402]  458.44 240.28 180 bottom
UNK4R202  NC/4.7K-1-S4  [R0402]  458.44 239.01 180 bottom
UNK4R203  4.7K-1-S2  [R0201]  473.52 237.74 180 bottom
UNK4R204  0-5-S4  [R0402]  477.12 240.28 180 bottom
UNK4R205  4.7K-1-S2  [R0201]  493.32 240.28 180 bottom
UNK4R206  NC/4.7K-1-S4  [R0402]  477.12 239.01 180 bottom
UNK4R207  4.7K-1-S2  [R0201]  493.32 237.74 180 bottom
UNK4R234  0-1-S4-YA  [R0402]  442.05 484.22 0 top
UNK4R331  10K-1-S2-WA  [R0201]  341.62 297.3 270 bottom
UNK4R509  0-5-S4  [R0402]  339 264.31 90 bottom
UNK4R510  1.2K-1-S4  [R0402]  344.69 265.11 270 bottom
UNK4R511  523-1-S4  [R0402]  345.19 262.36 0 bottom
UNK4R512  0-5-S8  [R0805]  347.48 266.24 270 bottom
UNK4R646  42.2-1-S2  [R0201]  334.68 254.16 90 bottom
UNK4R647  42.2-1-S2  [R0201]  335.38 254.16 90 bottom
UNK4R652  NC/100K-1-S4  [R0402]  350.84 273.67 90 bottom
UNK4R659  10K-1-S2-WA  [R0201]  333.54 250.99 90 top
UNK4R661  4.7K-1-S2  [R0201]  332.78 250.99 270 top
UNK4R662  0-5-S2  [R0201]  334.96 241.23 0 top
UNK4R663  4.7K-1-S2  [R0201]  332.78 239.42 270 top
UNK4R664  42.2-1-S2  [R0201]  332.33 242.6 90 bottom
UNK4R666  42.2-1-S2  [R0201]  331.64 242.6 90 bottom
UNK4R672  10K-1-S2-WA  [R0201]  333.54 239.42 90 top
UNK4R923  100K-1-S4  [R0402]  352 273.67 90 bottom
UNK4R973  0-5-S4  [R0402]  351.42 272.04 0 bottom
UNK4R980  10K-1-S2-WA  [R0201]  353.66 269.4 90 bottom
UNK4R981  NC/4.7K-1-S2  [R0201]  349.83 269.4 270 bottom
UNK4R982  0-5-S2  [R0201]  349.53 268.44 0 bottom
UNK4R1088  42.2-1-S2  [R0201]  334.68 242.6 90 bottom
UNK4R1089  42.2-1-S2  [R0201]  335.38 242.6 90 bottom
UNK4R1098  4.7K-1-S2  [R0201]  355.68 484.08 0 top
UNK4R1099  42.2-1-S2  [R0201]  265.05 484.08 0 top
UNK4R1100  42.2-1-S2  [R0201]  266.45 484.08 0 top
UNK4R1101  4.7K-1-S2  [R0201]  357.08 484.08 0 top
UNK4R1102  0-5-S2  [R0201]  378.13 484.08 0 top
UNK4R1103  42.2-1-S2  [R0201]  267.85 484.08 0 top
UNK4R1104  0-5-S2  [R0201]  379.53 484.08 0 top
UNK4R1105  10K-1-S2-WA  [R0201]  400.58 484.08 0 top
UNK4R1106  42.2-1-S2  [R0201]  269.26 484.08 0 top
UNK4R1107  42.2-1-S2  [R0201]  270.66 484.08 0 top
UNK4R1108  10K-1-S2-WA  [R0201]  401.98 484.08 0 top
UNK4R1109  42.2-1-S2  [R0201]  272.06 484.08 0 top
UNK4R1110  42.2-1-S2  [R0201]  273.47 484.08 0 top
UNK4R1111  42.2-1-S2  [R0201]  274.87 484.08 0 top
UNK4R1114  42.2-1-S2  [R0201]  276.27 484.08 0 top
UNK4R1115  42.2-1-S2  [R0201]  277.68 484.08 0 top
UNK4R1117  0-1-S4-YA  [R0402]  435.44 484.22 0 top
UNK4R1118  0-1-S4-YA  [R0402]  437.64 484.22 0 top
UNK4R1119  0-1-S4-YA  [R0402]  439.85 484.22 0 top
UNK4SA1  SHORT  [DEFAULT_SHORT_SMALL]  345.71 251.64 180 top
UNK4SA2  SHORT  [DEFAULT_SHORT_SMALL]  345.71 252.15 180 top
UNK4SA7  SHORT  [DEFAULT_SHORT_SMALL]  344.03 245.86 90 top
UNK4SA8  SHORT  [DEFAULT_SHORT_SMALL]  345.3 245.86 90 top
UNK4SA9  SHORT  [DEFAULT_SHORT_SMALL]  346.07 238 180 top
UNK4SA10  SHORT  [DEFAULT_SHORT_SMALL]  346.07 237.49 180 top
UNK4SA15  SHORT  [DEFAULT_SHORT_SMALL]  357.49 250.16 90 top
UNK4SA16  SHORT  [DEFAULT_SHORT_SMALL]  356.98 250.16 90 top
UNK4SA17  SHORT  [DEFAULT_SHORT_SMALL]  353.21 238.53 0 top
UNK4SA18  SHORT  [DEFAULT_SHORT_SMALL]  353.21 237.92 0 top
UNK4SA19  SHORT  [DEFAULT_SHORT_SMALL]  344.08 243.68 270 top
UNK4SA20  SHORT  [DEFAULT_SHORT_SMALL]  343.49 243.68 270 top
UNK4SA21  SHORT  [DEFAULT_SHORT_SMALL]  359.27 250.18 90 top
UNK4SA22  SHORT  [DEFAULT_SHORT_SMALL]  360.54 250.2 90 top
UNK4SA23  SHORT  [DEFAULT_SHORT_SMALL]  353.41 237.52 270 top
UNK4SA24  SHORT  [DEFAULT_SHORT_SMALL]  354.06 237.52 270 top
UNK4SA25  SHORT  [DEFAULT_SHORT_SMALL]  497.13 484.3 0 top
UNK4SA26  SHORT  [DEFAULT_SHORT_SMALL]  499.33 484.3 0 top
UNK4TP_DPS1  TP01  [TP_040_T]  377.19 247.65 0 top
UNK4TP_DPS2  TP01  [TP_040_T]  353.93 281.43 0 top
UNK4TP_DPS3  TP01  [TP_040_T]  335.42 285.5 0 top
UNK4TP_DPS4  TP01  [TP_040_T]  363.87 281.43 0 top
UNK4TP_DPS5  TP01  [TP_040_T]  341.51 281.43 0 top
UNK4TP_DPS6  TP01  [TP_040_T]  363.87 285.5 0 top
UNK4TP_DPS7  TP01  [TP_040_T]  335.42 281.43 0 top
UNK4TP_DPS8  TP01  [TP_040_T]  347.6 281.43 180 top
UNK4TP_DPS9  TP01  [TP_040_T]  576.13 484.56 0 top
UNK4TP_MUX_3V3  TP01  [TP_040_T]  335.65 269.49 180 top
UNK4U17  XC6203E-0.4A-33-SOT89  [SOT89]  475.5 231.05 180 bottom
UNK4U18  SK-SO8-1.27-DEDIPROG-V3  [SK_SO8_1P27MM_DEDIPROG_V3]  462.89 238.12 270 bottom
UNK4U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  485.26 238.38 270 bottom
UNK4U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  346.08 234.5 90 bottom
UNK4U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  341.84 264.24 180 bottom
UNK4U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  333.16 249.72 180 bottom
UNK4U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  333.16 238.15 180 bottom
UNK4U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  351.94 269.73 270 bottom
UNK4U455  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  395.34 465.08 0 top
UNK4U456  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  389.94 465.08 0 top
UNK4Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  354.01 221.07 0 bottom
UNK4Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  351.94 265.49 180 bottom
UNK5BD9  BD120-1.5A-S4-MU  [FB0402]  224.66 183.84 270 bottom
UNK5BD21  BD120-1.5A-S4-MU  [FB0402]  222.95 172.36 0 bottom
UNK5BD1728  BD120-1.5A-S4-MU  [FB0402]  229.83 211.82 270 bottom
UNK5BDB5  BD120-1.5A-S4-MU  [FB0402]  211.03 186.46 0 bottom
UNK5BDB6  BD120-1.5A-S4-MU  [FB0402]  211.03 174.89 0 bottom
UNK5BDB7  BD120-1.5A-S4-MU  [FB0402]  563.87 484.17 0 top
UNK5BDB8  BD120-1.5A-S4-MU  [FB0402]  535.64 484.17 0 top
UNK5C262  0.1U-16-X7S-S2-MU  [C0201]  224.41 172.06 270 bottom
UNK5C264  NC/10U-16-X7R-S8-SS  [C0805]  227.48 209.95 90 bottom
UNK5C267  33P-50-N-S2-MU  [C0201]  236.23 164.18 270 bottom
UNK5C268  33P-50-N-S2-MU  [C0201]  235.23 164.18 270 bottom
UNK5C271  12P-50-N-S4-MU  [C0402]  232.95 207.19 180 bottom
UNK5C272  12P-50-N-S4-MU  [C0402]  230.93 207.19 0 bottom
UNK5C278  1U-10-X7S-S4-TDK  [C0402]  228.79 139.96 180 bottom
UNK5C279  1U-10-X7S-S4-TDK  [C0402]  228.79 141.15 180 bottom
UNK5C280  0.1U-16-X-S4-MU  [C0402]  228.79 142.35 180 bottom
UNK5C281  0.1U-16-X-S4-MU  [C0402]  228.79 143.54 180 bottom
UNK5C282  1U-10-X7S-S4-TDK  [C0402]  222.96 146.59 90 bottom
UNK5C283  0.1U-16-X-S4-MU  [C0402]  224.12 146.59 90 bottom
UNK5C284  1U-10-X7S-S4-TDK  [C0402]  224.04 135.22 270 bottom
UNK5C285  0.1U-16-X-S4-MU  [C0402]  222.85 135.22 270 bottom
UNK5C286  0.1U-16-X-S4-MU  [C0402]  227.84 135.72 0 bottom
UNK5C288  1000P-50-X7R-S2-MU  [C0201]  228.17 137.5 90 bottom
UNK5C289  0.1U-16-X-S4-MU  [C0402]  230.45 138.26 90 bottom
UNK5C290  NC/0.1U-16-X7R-S4-TY  [C0402]  237.31 137.04 0 bottom
UNK5C298  0.1U-16-X7S-S2-MU  [C0201]  238.71 140.42 270 bottom
UNK5C299  0.1U-16-X7S-S2-MU  [C0201]  241.64 136.1 0 bottom
UNK5C300  0.1U-16-X-S4-MU  [C0402]  240.99 142.2 90 bottom
UNK5C301  1U-10-X7S-S4-TDK  [C0402]  242.15 142.2 90 bottom
UNK5C302  10P-50-N-S2-MU  [C0201]  214.98 183.61 0 bottom
UNK5C309  10P-50-N-S2-MU  [C0201]  214.98 195.18 0 bottom
UNK5C310  10P-50-N-S2-MU  [C0201]  213.69 195.18 180 bottom
UNK5C318  10P-50-N-S2-MU  [C0201]  211.94 195.18 0 bottom
UNK5C320  10P-50-N-S2-MU  [C0201]  213.69 183.61 180 bottom
UNK5C332  2.2U-16-X7R-S6-TY  [C0603]  109.1 163.15 270 bottom
UNK5C333  0.1U-16-X-S4-MU  [C0402]  107.7 163.33 270 bottom
UNK5C334  10U-16-X7R-S8-SS  [C0805]  100.08 163.03 90 bottom
UNK5C335  0.1U-16-X-S4-MU  [C0402]  101.74 162.85 90 bottom
UNK5C336  4.7U-25-X7R-S8-TY  [C0805]  87.58 176.79 270 bottom
UNK5C337  0.1U-16-X-S4-MU  [C0402]  87.6 174.24 180 bottom
UNK5C338  4.7U-25-X7R-S8-TY  [C0805]  106 176.79 270 bottom
UNK5C339  0.1U-16-X-S4-MU  [C0402]  106.03 174.24 180 bottom
UNK5C475  4.7U-6.3-X-S4-MU  [C0402]  225.86 205.11 270 bottom
UNK5C476  1U-10-X7S-S4-TDK  [C0402]  219 208.25 90 bottom
UNK5C477  10U-25-X-S6-MU  [C0603]  220.32 208.76 90 bottom
UNK5C478  22U-16-X5R-SA-SS  [C1206]  223.32 208.5 0 bottom
UNK5C922  0.1U-16-X-S4-MU  [C0402]  213.16 186.46 0 bottom
UNK5C923  0.1U-16-X-S4-MU  [C0402]  213.16 174.89 0 bottom
UNK5C924  10P-50-N-S2-MU  [C0201]  211.94 183.61 0 bottom
UNK5C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  229.58 210.27 180 bottom
UNK5C1086  10P-50-N-S2-MU  [C0201]  24.25 484.08 0 top
UNK5C1087  10P-50-N-S2-MU  [C0201]  27.06 484.08 0 top
UNK5C1088  10P-50-N-S2-MU  [C0201]  28.46 484.08 0 top
UNK5C1089  0.1U-16-X-S4-MU  [C0402]  80.16 484.22 0 top
UNK5C1090  0.1U-16-X-S4-MU  [C0402]  82.37 484.22 0 top
UNK5C1091  10P-50-N-S2-MU  [C0201]  29.87 484.08 0 top
UNK5C1093  10P-50-N-S2-MU  [C0201]  31.27 484.08 0 top
UNK5CA1  0.1U-16-X-S4-MU  [C0402]  221.73 155.04 0 bottom
UNK5CA2  10U-25-X7R-SA  [C1206]  221.73 157.07 0 bottom
UNK5CA7  10U-25-X7R-SA  [C1206]  241 154.53 0 bottom
UNK5CA8  0.1U-16-X-S4-MU  [C0402]  241 152.5 0 bottom
UNK5CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  214.88 143.83 180 bottom
UNK5CA20  10U-25-X7R-SA  [C1206]  231.37 153.01 0 bottom
UNK5CA21  0.1U-16-X-S4-MU  [C0402]  231.37 150.98 0 bottom
UNK5CA22  10U-25-X7R-SA  [C1206]  241 149.86 0 bottom
UNK5CA23  0.1U-16-X-S4-MU  [C0402]  241 147.83 0 bottom
UNK5CA24  10U-25-X7R-SA  [C1206]  221.73 153.01 0 bottom
UNK5CA25  0.1U-16-X-S4-MU  [C0402]  221.73 150.98 0 bottom
UNK5CA26  10U-25-X7R-SA  [C1206]  226.55 157.07 0 bottom
UNK5CA27  0.1U-16-X-S4-MU  [C0402]  226.55 155.04 0 bottom
UNK5CA34  10U-25-X7R-SA  [C1206]  245.82 154.53 0 bottom
UNK5CA35  0.1U-16-X-S4-MU  [C0402]  245.82 152.5 0 bottom
UNK5CA36  0.1U-16-X-S4-MU  [C0402]  226.55 150.98 0 bottom
UNK5CA37  10U-25-X7R-SA  [C1206]  226.55 153.01 0 bottom
UNK5CA38  10U-25-X7R-SA  [C1206]  215.57 484.92 0 top
UNK5CA39  0.1U-16-X-S4-MU  [C0402]  84.57 484.22 0 top
UNK5CC1  0.1U-16-X7S-S2-MU  [C0201_MINI]  230.19 186.91 180 bottom
UNK5CC2  0.1U-16-X7S-S2-MU  [C0201_MINI]  230.5 190.48 90 bottom
UNK5CC3  0.1U-16-X7S-S2-MU  [C0201_MINI]  228.87 185.61 180 bottom
UNK5CC4  0.1U-16-X7S-S2-MU  [C0201_MINI]  230.19 186.26 180 bottom
UNK5CC5  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.16 186.56 90 bottom
UNK5CC6  0.1U-16-X7S-S2-MU  [C0201_MINI]  228.87 184.96 180 bottom
UNK5CC7  0.1U-16-X7S-S2-MU  [C0201_MINI]  232.14 184.96 0 bottom
UNK5CC8  0.1U-16-X7S-S2-MU  [C0201_MINI]  230.5 183.97 270 bottom
UNK5CC9  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.16 183.97 270 bottom
UNK5CC12  0.1U-16-X7S-S2-MU  [C0201_MINI]  229.86 184.62 270 bottom
UNK5CC13  0.1U-16-X7S-S2-MU  [C0201_MINI]  228.24 181.06 180 bottom
UNK5CC14  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.46 185.61 0 bottom
UNK5CC15  0.1U-16-X7S-S2-MU  [C0201_MINI]  230.19 185.61 180 bottom
UNK5CC16  0.1U-16-X7S-S2-MU  [C0201_MINI]  230.84 184.96 180 bottom
UNK5CC70  0.1U-16-X7S-S2-MU  [C0201_MINI]  232.46 182.67 270 bottom
UNK5CC71  0.1U-16-X7S-S2-MU  [C0201_MINI]  235.38 183 0 bottom
UNK5CC73  0.1U-16-X7S-S2-MU  [C0201_MINI]  227.91 182.68 90 bottom
UNK5CC84  0.1U-16-X7S-S2-MU  [C0201_MINI]  233.11 190.48 90 bottom
UNK5CC85  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.15 190.48 90 bottom
UNK5CC86  0.1U-16-X7S-S2-MU  [C0201_MINI]  232.46 190.48 90 bottom
UNK5CC87  0.1U-16-X7S-S2-MU  [C0201_MINI]  232.14 186.26 180 bottom
UNK5CC88  0.1U-16-X7S-S2-MU  [C0201_MINI]  233.11 184 270 bottom
UNK5CC89  0.1U-16-X7S-S2-MU  [C0201_MINI]  227.91 184.66 270 bottom
UNK5CC90  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.8 190.48 90 bottom
UNK5CC91  0.1U-16-X7S-S2-MU  [C0201_MINI]  234.06 183.65 0 bottom
UNK5CC92  0.1U-16-X7S-S2-MU  [C0201_MINI]  232.45 184 270 bottom
UNK5CC96  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.51 187.56 180 bottom
UNK5CC101  0.1U-16-X7S-S2-MU  [C0201_MINI]  230.84 180.4 0 bottom
UNK5CC103  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.81 182.02 90 bottom
UNK5CC105  0.1U-16-X7S-S2-MU  [C0201_MINI]  232.46 180.72 270 bottom
UNK5CC112  0.1U-16-X7S-S2-MU  [C0201_MINI]  235.06 190.48 90 bottom
UNK5CC130  0.1U-16-X7S-S2-MU  [C0201_MINI]  228.24 181.7 180 bottom
UNK5CC182  0.1U-16-X7S-S2-MU  [C0201_MINI]  226.61 190.48 90 bottom
UNK5CC195  4.7U-25-X7R-S8-TY  [C0805]  182.35 484.67 0 top
UNK5CC202  0.1U-16-X7S-S2-MU  [C0201_MINI]  226.28 185.61 180 bottom
UNK5CC211  0.1U-16-X7S-S2-MU  [C0201_MINI]  230.5 182.02 90 bottom
UNK5CC212  0.1U-16-X7S-S2-MU  [C0201_MINI]  229.53 181.06 180 bottom
UNK5CC213  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.16 182.02 90 bottom
UNK5CC214  0.1U-16-X7S-S2-MU  [C0201_MINI]  134.66 484.08 0 top
UNK5CC215  0.1U-16-X7S-S2-MU  [C0201_MINI]  231.81 179.42 90 bottom
UNK5CC216  0.1U-16-X7S-S2-MU  [C0201_MINI]  228.56 178.78 270 bottom
UNK5CC217  0.1U-16-X7S-S2-MU  [C0201_MINI]  136.06 484.08 0 top
UNK5CC218  0.1U-16-X7S-S2-MU  [C0201_MINI]  137.46 484.08 0 top
UNK5CC219  0.1U-16-X7S-S2-MU  [C0201_MINI]  138.87 484.08 0 top
UNK5CC220  0.1U-16-X7S-S2-MU  [C0201_MINI]  140.27 484.08 0 top
UNK5K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  119.04 184.6 90 bottom
UNK5K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  112.69 184.6 90 bottom
UNK5K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  106.34 184.6 90 bottom
UNK5K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  99.99 184.6 90 bottom
UNK5K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  93.64 184.6 90 bottom
UNK5K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  87.29 184.6 90 bottom
UNK5K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  231.94 198.56 90 bottom
UNK5K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  235.73 171.79 270 bottom
UNK5K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  166.88 244.86 90 bottom
UNK5K96  EC2-5NJ  [RL_NECEC2_10P_5V]  215.03 157.73 90 bottom
UNK5MBD1  BD120-1.5A-S4-MU  [FB0402]  238.71 138.77 90 bottom
UNK5MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  235.79 144.74 0 bottom
UNK5MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  235.79 139.4 0 bottom
UNK5MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  235.79 147.28 0 bottom
UNK5MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  235.79 142.07 0 bottom
UNK5MR1  1M-1-S4  [R0402_UNBGA_V2]  225.44 146.59 90 bottom
UNK5MR2  1K-0.01-S4  [R0402_UNBGA_V2]  225.75 135.72 0 bottom
UNK5MR3  1K-0.01-S4  [R0402_UNBGA_V2]  227.84 134.7 0 bottom
UNK5MR4  1K-0.01-S4  [R0402_UNBGA_V2]  227.84 133.69 0 bottom
UNK5MR5  1K-0.01-S4  [R0402_UNBGA_V2]  225.75 133.69 180 bottom
UNK5MR6  1K-0.01-S4  [R0402_UNBGA_V2]  225.75 134.7 180 bottom
UNK5MR7  332K-1-S4  [R0402_UNBGA_V2]  226.45 147.44 270 bottom
UNK5MR8  1K-0.01-S4  [R0402_UNBGA_V2]  237.31 133.69 0 bottom
UNK5MR9  499-0.1-S4  [R0402]  237.31 134.8 0 bottom
UNK5MR10  0-5-S4  [R0402]  237.31 135.92 180 bottom
UNK5MR11  750-1-S4  [R0402]  232.36 144.1 0 bottom
UNK5MR12  360-1-S6  [R0603]  231.98 145.37 0 bottom
UNK5MR13  750-1-S4  [R0402]  232.36 138.77 0 bottom
UNK5MR14  1.2K-1-S4  [R0402]  232.61 146.64 180 bottom
UNK5MR15  360-1-S6  [R0603]  231.98 140.04 0 bottom
UNK5MR16  750-1-S4  [R0402]  232.36 141.43 0 bottom
UNK5MR17  360-1-S6  [R0603]  231.98 142.7 0 bottom
UNK5MR18  11K-0.1-S4  [R0402]  239.85 142.2 90 bottom
UNK5MR19  1K-0.01-S4  [R0402_UNBGA_V2]  238.71 142.2 270 bottom
UNK5MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  228.51 145.44 270 bottom
UNK5MU2  KSMT004-SO8  [SO8_244X127MM]  223.6 141.05 270 bottom
UNK5MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  232.74 135.59 0 bottom
UNK5MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  240.99 138.77 180 bottom
UNK5R135  0-5-S4  [R0402]  238.73 165.44 180 bottom
UNK5R136  1M-1-S4  [R0402]  235.73 165.44 0 bottom
UNK5R137  0-5-S4  [R0402]  232.73 165.44 0 bottom
UNK5R160  38.3-1-S2  [R0201_MINI]  223.52 175.18 0 bottom
UNK5R161  38.3-1-S2  [R0201_MINI]  223.52 174.62 0 bottom
UNK5R162  4.7K-1-S2  [R0201_MINI]  228.01 174.55 90 bottom
UNK5R163  0-5-S2  [R0201_MINI]  223.52 173.14 0 bottom
UNK5R164  0-5-S2  [R0201_MINI]  223.52 174.06 0 bottom
UNK5R165  0-5-S2  [R0201_MINI]  228.01 173.55 90 bottom
UNK5R168  42.2-1-S2  [R0201]  213.99 194.16 90 bottom
UNK5R170  42.2-1-S2  [R0201]  213.29 194.16 90 bottom
UNK5R172  0-5-S2  [R0201]  214.96 192.79 0 top
UNK5R176  42.2-1-S2  [R0201]  211.64 194.16 90 bottom
UNK5R178  42.2-1-S2  [R0201]  212.33 194.16 90 bottom
UNK5R180  42.2-1-S2  [R0201]  213.99 182.6 90 bottom
UNK5R182  42.2-1-S2  [R0201]  213.29 182.6 90 bottom
UNK5R200  4.7K-1-S2  [R0201]  102.68 172.97 180 bottom
UNK5R201  0-5-S4  [R0402]  87.6 172.97 180 bottom
UNK5R202  NC/4.7K-1-S4  [R0402]  87.6 171.7 180 bottom
UNK5R203  4.7K-1-S2  [R0201]  102.68 170.43 180 bottom
UNK5R204  0-5-S4  [R0402]  106.28 172.97 180 bottom
UNK5R205  4.7K-1-S2  [R0201]  122.48 172.97 180 bottom
UNK5R206  NC/4.7K-1-S4  [R0402]  106.28 171.7 180 bottom
UNK5R207  4.7K-1-S2  [R0201]  122.48 170.43 180 bottom
UNK5R234  0-1-S4-YA  [R0402]  450.86 484.22 0 top
UNK5R331  10K-1-S2-WA  [R0201]  240.04 135.77 90 bottom
UNK5R509  0-5-S4  [R0402]  219 204.31 90 bottom
UNK5R510  1.2K-1-S4  [R0402]  224.69 205.11 270 bottom
UNK5R511  523-1-S4  [R0402]  225.19 202.36 0 bottom
UNK5R512  0-5-S8  [R0805]  227.48 206.24 270 bottom
UNK5R646  42.2-1-S2  [R0201]  214.68 194.16 90 bottom
UNK5R647  42.2-1-S2  [R0201]  215.38 194.16 90 bottom
UNK5R652  NC/100K-1-S4  [R0402]  230.85 213.67 90 bottom
UNK5R659  10K-1-S2-WA  [R0201]  213.54 190.99 90 top
UNK5R661  4.7K-1-S2  [R0201]  212.78 190.99 270 top
UNK5R662  0-5-S2  [R0201]  214.96 181.23 0 top
UNK5R663  4.7K-1-S2  [R0201]  212.78 179.42 270 top
UNK5R664  42.2-1-S2  [R0201]  212.33 182.6 90 bottom
UNK5R666  42.2-1-S2  [R0201]  211.64 182.6 90 bottom
UNK5R672  10K-1-S2-WA  [R0201]  213.54 179.42 90 top
UNK5R923  100K-1-S4  [R0402]  232 213.67 90 bottom
UNK5R973  0-5-S4  [R0402]  231.42 212.04 0 bottom
UNK5R980  10K-1-S2-WA  [R0201]  233.66 209.4 90 bottom
UNK5R981  NC/4.7K-1-S2  [R0201]  229.83 209.4 270 bottom
UNK5R982  0-5-S2  [R0201]  229.53 208.44 0 bottom
UNK5R1088  42.2-1-S2  [R0201]  214.68 182.6 90 bottom
UNK5R1089  42.2-1-S2  [R0201]  215.38 182.6 90 bottom
UNK5R1098  4.7K-1-S2  [R0201]  358.48 484.08 0 top
UNK5R1099  42.2-1-S2  [R0201]  300.96 484.08 0 top
UNK5R1100  42.2-1-S2  [R0201]  530.18 484.08 0 top
UNK5R1101  4.7K-1-S2  [R0201]  359.89 484.08 0 top
UNK5R1102  0-5-S2  [R0201]  380.93 484.08 0 top
UNK5R1103  42.2-1-S2  [R0201]  281.89 484.08 0 top
UNK5R1104  0-5-S2  [R0201]  382.34 484.08 0 top
UNK5R1105  10K-1-S2-WA  [R0201]  403.38 484.08 0 top
UNK5R1106  42.2-1-S2  [R0201]  537.46 484.08 0 top
UNK5R1107  42.2-1-S2  [R0201]  285.52 484.08 0 top
UNK5R1108  10K-1-S2-WA  [R0201]  404.79 484.08 0 top
UNK5R1109  42.2-1-S2  [R0201]  286.93 484.08 0 top
UNK5R1110  42.2-1-S2  [R0201]  288.33 484.08 0 top
UNK5R1111  42.2-1-S2  [R0201]  289.73 484.08 0 top
UNK5R1114  42.2-1-S2  [R0201]  291.14 484.08 0 top
UNK5R1115  42.2-1-S2  [R0201]  292.54 484.08 0 top
UNK5R1117  0-1-S4-YA  [R0402]  444.25 484.22 0 top
UNK5R1118  0-1-S4-YA  [R0402]  446.46 484.22 0 top
UNK5R1119  0-1-S4-YA  [R0402]  448.66 484.22 0 top
UNK5SA1  SHORT  [DEFAULT_SHORT_SMALL]  236.06 191.36 0 top
UNK5SA2  SHORT  [DEFAULT_SHORT_SMALL]  236.06 191.87 0 top
UNK5SA7  SHORT  [DEFAULT_SHORT_SMALL]  223.4 185.16 90 top
UNK5SA8  SHORT  [DEFAULT_SHORT_SMALL]  223.91 185.16 90 top
UNK5SA9  SHORT  [DEFAULT_SHORT_SMALL]  234.24 174.5 270 top
UNK5SA10  SHORT  [DEFAULT_SHORT_SMALL]  235.03 174.5 270 top
UNK5SA15  SHORT  [DEFAULT_SHORT_SMALL]  239.49 193.83 90 top
UNK5SA16  SHORT  [DEFAULT_SHORT_SMALL]  238.98 193.83 90 top
UNK5SA17  SHORT  [DEFAULT_SHORT_SMALL]  235.98 191.77 0 top
UNK5SA18  SHORT  [DEFAULT_SHORT_SMALL]  235.98 192.46 0 top
UNK5SA19  SHORT  [DEFAULT_SHORT_SMALL]  224.08 183.68 270 top
UNK5SA20  SHORT  [DEFAULT_SHORT_SMALL]  223.49 183.68 270 top
UNK5SA21  SHORT  [DEFAULT_SHORT_SMALL]  234.54 193.95 0 top
UNK5SA22  SHORT  [DEFAULT_SHORT_SMALL]  234.54 195.43 0 top
UNK5SA23  SHORT  [DEFAULT_SHORT_SMALL]  233.04 174.51 270 top
UNK5SA24  SHORT  [DEFAULT_SHORT_SMALL]  234.32 174.51 270 top
UNK5SA25  SHORT  [DEFAULT_SHORT_SMALL]  501.54 484.3 0 top
UNK5SA26  SHORT  [DEFAULT_SHORT_SMALL]  503.74 484.3 0 top
UNK5TP_DPS1  TP01  [TP_040_T]  220.48 157.07 0 top
UNK5TP_DPS2  TP01  [TP_040_T]  225.3 157.07 180 top
UNK5TP_DPS3  TP01  [TP_040_T]  230.12 153.01 180 top
UNK5TP_DPS4  TP01  [TP_040_T]  244.57 154.53 0 top
UNK5TP_DPS5  TP01  [TP_040_T]  239.75 149.86 0 top
UNK5TP_DPS6  TP01  [TP_040_T]  239.75 154.53 0 top
UNK5TP_DPS7  TP01  [TP_040_T]  220.48 153.01 0 top
UNK5TP_DPS8  TP01  [TP_040_T]  225.3 153.01 180 top
UNK5TP_DPS9  TP01  [TP_040_T]  578.12 484.56 0 top
UNK5TP_MUX_3V3  TP01  [TP_040_T]  215.65 209.49 180 top
UNK5U17  XC6203E-0.4A-33-SOT89  [SOT89]  104.66 163.74 180 bottom
UNK5U18  SK-SO8-1.27-DEDIPROG-V3  [SK_SO8_1P27MM_DEDIPROG_V3]  92.33 170.81 270 bottom
UNK5U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  114.42 171.07 270 bottom
UNK5U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  226.08 174.5 90 bottom
UNK5U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  221.84 204.24 180 bottom
UNK5U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  213.16 189.72 180 bottom
UNK5U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  213.16 178.15 180 bottom
UNK5U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  231.94 209.73 270 bottom
UNK5U455  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  384.53 465.08 0 top
UNK5U456  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  379.13 465.08 0 top
UNK5Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  234.01 161.07 0 bottom
UNK5Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  231.94 205.49 180 bottom
UNK6BD9  BD120-1.5A-S4-MU  [FB0402]  264.66 183.84 270 bottom
UNK6BD21  BD120-1.5A-S4-MU  [FB0402]  262.95 172.36 0 bottom
UNK6BD1728  BD120-1.5A-S4-MU  [FB0402]  269.83 211.82 270 bottom
UNK6BDB5  BD120-1.5A-S4-MU  [FB0402]  251.03 186.46 0 bottom
UNK6BDB6  BD120-1.5A-S4-MU  [FB0402]  251.03 174.89 0 bottom
UNK6BDB7  BD120-1.5A-S4-MU  [FB0402]  559.4 484.17 0 top
UNK6BDB8  BD120-1.5A-S4-MU  [FB0402]  541.51 484.17 0 top
UNK6C262  0.1U-16-X7S-S2-MU  [C0201]  264.41 172.06 270 bottom
UNK6C264  NC/10U-16-X7R-S8-SS  [C0805]  267.48 209.95 90 bottom
UNK6C267  33P-50-N-S2-MU  [C0201]  276.23 164.18 270 bottom
UNK6C268  33P-50-N-S2-MU  [C0201]  275.23 164.18 270 bottom
UNK6C271  12P-50-N-S4-MU  [C0402]  272.95 207.19 180 bottom
UNK6C272  12P-50-N-S4-MU  [C0402]  270.93 207.19 0 bottom
UNK6C278  1U-10-X7S-S4-TDK  [C0402]  268.79 139.96 180 bottom
UNK6C279  1U-10-X7S-S4-TDK  [C0402]  268.79 141.15 180 bottom
UNK6C280  0.1U-16-X-S4-MU  [C0402]  268.79 142.35 180 bottom
UNK6C281  0.1U-16-X-S4-MU  [C0402]  268.79 143.54 180 bottom
UNK6C282  1U-10-X7S-S4-TDK  [C0402]  262.96 146.59 90 bottom
UNK6C283  0.1U-16-X-S4-MU  [C0402]  264.12 146.59 90 bottom
UNK6C284  1U-10-X7S-S4-TDK  [C0402]  264.04 135.22 270 bottom
UNK6C285  0.1U-16-X-S4-MU  [C0402]  262.85 135.22 270 bottom
UNK6C286  0.1U-16-X-S4-MU  [C0402]  267.84 135.72 0 bottom
UNK6C288  1000P-50-X7R-S2-MU  [C0201]  268.17 137.5 90 bottom
UNK6C289  0.1U-16-X-S4-MU  [C0402]  270.45 138.26 90 bottom
UNK6C290  NC/0.1U-16-X7R-S4-TY  [C0402]  277.31 137.04 0 bottom
UNK6C298  0.1U-16-X7S-S2-MU  [C0201]  278.71 140.42 270 bottom
UNK6C299  0.1U-16-X7S-S2-MU  [C0201]  281.64 136.1 0 bottom
UNK6C300  0.1U-16-X-S4-MU  [C0402]  280.99 142.2 90 bottom
UNK6C301  1U-10-X7S-S4-TDK  [C0402]  282.15 142.2 90 bottom
UNK6C302  10P-50-N-S2-MU  [C0201]  254.98 183.61 0 bottom
UNK6C309  10P-50-N-S2-MU  [C0201]  254.98 195.18 0 bottom
UNK6C310  10P-50-N-S2-MU  [C0201]  253.69 195.18 180 bottom
UNK6C318  10P-50-N-S2-MU  [C0201]  251.94 195.18 0 bottom
UNK6C320  10P-50-N-S2-MU  [C0201]  253.69 183.61 180 bottom
UNK6C332  2.2U-16-X7R-S6-TY  [C0603]  109.1 131.4 270 bottom
UNK6C333  0.1U-16-X-S4-MU  [C0402]  107.7 131.58 270 bottom
UNK6C334  10U-16-X7R-S8-SS  [C0805]  100.08 131.28 90 bottom
UNK6C335  0.1U-16-X-S4-MU  [C0402]  101.74 131.1 90 bottom
UNK6C336  4.7U-25-X7R-S8-TY  [C0805]  87.58 145.04 270 bottom
UNK6C337  0.1U-16-X-S4-MU  [C0402]  87.6 142.49 180 bottom
UNK6C338  4.7U-25-X7R-S8-TY  [C0805]  106 145.04 270 bottom
UNK6C339  0.1U-16-X-S4-MU  [C0402]  106.03 142.49 180 bottom
UNK6C475  4.7U-6.3-X-S4-MU  [C0402]  265.86 205.11 270 bottom
UNK6C476  1U-10-X7S-S4-TDK  [C0402]  259 208.25 90 bottom
UNK6C477  10U-25-X-S6-MU  [C0603]  260.32 208.76 90 bottom
UNK6C478  22U-16-X5R-SA-SS  [C1206]  263.32 208.5 0 bottom
UNK6C922  0.1U-16-X-S4-MU  [C0402]  253.16 186.46 0 bottom
UNK6C923  0.1U-16-X-S4-MU  [C0402]  253.16 174.89 0 bottom
UNK6C924  10P-50-N-S2-MU  [C0201]  251.94 183.61 0 bottom
UNK6C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  269.58 210.27 180 bottom
UNK6C1086  10P-50-N-S2-MU  [C0201]  32.67 484.08 0 top
UNK6C1087  10P-50-N-S2-MU  [C0201]  34.08 484.08 0 top
UNK6C1088  10P-50-N-S2-MU  [C0201]  35.48 484.08 0 top
UNK6C1089  0.1U-16-X-S4-MU  [C0402]  86.77 484.22 0 top
UNK6C1090  0.1U-16-X-S4-MU  [C0402]  88.98 484.22 0 top
UNK6C1091  10P-50-N-S2-MU  [C0201]  38.28 484.08 0 top
UNK6C1093  10P-50-N-S2-MU  [C0201]  62.94 484.08 0 top
UNK6CA1  0.1U-16-X-S4-MU  [C0402]  261.73 155.04 0 bottom
UNK6CA2  10U-25-X7R-SA  [C1206]  261.73 157.07 0 bottom
UNK6CA7  10U-25-X7R-SA  [C1206]  281 154.53 0 bottom
UNK6CA8  0.1U-16-X-S4-MU  [C0402]  281 152.5 0 bottom
UNK6CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  254.88 143.83 180 bottom
UNK6CA20  10U-25-X7R-SA  [C1206]  271.37 153.01 0 bottom
UNK6CA21  0.1U-16-X-S4-MU  [C0402]  271.37 150.98 0 bottom
UNK6CA22  10U-25-X7R-SA  [C1206]  281 149.86 0 bottom
UNK6CA23  0.1U-16-X-S4-MU  [C0402]  281 147.83 0 bottom
UNK6CA24  10U-25-X7R-SA  [C1206]  261.73 153.01 0 bottom
UNK6CA25  0.1U-16-X-S4-MU  [C0402]  261.73 150.98 0 bottom
UNK6CA26  10U-25-X7R-SA  [C1206]  266.55 157.07 0 bottom
UNK6CA27  0.1U-16-X-S4-MU  [C0402]  266.55 155.04 0 bottom
UNK6CA34  10U-25-X7R-SA  [C1206]  285.82 154.53 0 bottom
UNK6CA35  0.1U-16-X-S4-MU  [C0402]  285.82 152.5 0 bottom
UNK6CA36  0.1U-16-X-S4-MU  [C0402]  266.55 150.98 0 bottom
UNK6CA37  10U-25-X7R-SA  [C1206]  266.55 153.01 0 bottom
UNK6CA38  10U-25-X7R-SA  [C1206]  220.17 484.92 0 top
UNK6CA39  0.1U-16-X-S4-MU  [C0402]  91.18 484.22 0 top
UNK6CC1  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.19 186.91 180 bottom
UNK6CC2  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.5 190.48 90 bottom
UNK6CC3  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.87 185.61 180 bottom
