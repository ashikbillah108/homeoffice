# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S6_OUT_TX0_CH1_ABC_CASE+:
  vias: v2(266.61,186.91)
S6_OUT_TX0_CH2_ABC_CASE-:
  vias: v2(266.61,186.26)
S6_PM_SAR_GPIO0:
  vias: v1(277.14,146.64)
S6_PWR_F001: length 0.7
  BOTTOM w0.508: UNK6CA27.1 v1(265.3,155.04)
  vias: v1(265.3,157.07) v2(275.06,190.16)
S6_PWR_F004: length 0.7
  BOTTOM w0.508: UNK6CA23.1 v1(279.75,147.83)
  vias: v1(279.75,149.86) v2(271.81,187.56)
S6_PWR_F005: length 0.7
  BOTTOM w0.508: UNK6CA8.1 v1(279.75,152.5)
  vias: v1(279.75,154.53) v2(272.46,183) v2(273.11,183.01) v2(275.06,183)
S6_PWR_F006: length 0.7
  BOTTOM w0.508: UNK6CA25.1 v1(260.48,150.98)
  vias: v1(260.48,153.01) v2(270.5,180.41) v2(271.81,181.7) v2(272.46,181.06)
S6_PWR_F007: length 0.7
  BOTTOM w0.508: UNK6CA36.1 v1(265.3,150.98)
  vias: v1(265.3,153.01) v2(269.85,181.06) v2(270.5,181.7) v2(271.16,181.7)
S6_PWR_F008:
  vias: v2(273.76,184.31)
S6_PWR_M_F001: length 0.7
  BOTTOM w0.508: UNK6CA1.1 v1(260.48,155.04)
  vias: v1(260.48,157.07) v2(268.55,181.7) v2(268.55,181.06) v2(268.55,179.11) v2(269.2,185.61) v2(269.2,184.96) v2(269.85,184.96) v2(270.5,190.16) v2(270.5,186.91) v2(270.5,186.26) v2(270.5,185.61) v2(270.5,184.3) v2(271.16,186.26) v2(271.16,185.61) v2(271.16,184.96) v2(271.16,184.3) v2(271.81,184.96) v2(271.81,179.11)
S6_SPI_CK_ABCD_CASE:
  vias: v2(275.06,181.7)
S6_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK6K3.7 109.49,154.85 94.78,154.85 93.64,153.71 93.64,147.15 95.07,145.72 95.07,140.77 92.99,138.68 90.88,138.68
S6_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK6K3.5 111.09,139.16 110.61,138.68 UNK6U19.6
S6_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: v1(102.24,141.22) 96.81,146.64 96.81,153.84 97.82,154.85 112.69,154.85 UNK6K3.2
  BOTTOM w0.16: v1(102.24,141.22) 99.73,141.22
S6_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK6R205.2 UNK6U19.1 116.21,141.22 114.29,143.14 UNK6K3.4
S6_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: 90.88,137.41 93.11,137.41 96.81,141.11 96.81,151.67 UNK6K5.7
S6_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v1(107.75,137.41) 107.75,142.31 106.77,143.29 103.94,143.29 UNK6K5.5
  BOTTOM w0.16: UNK6U19.5 v1(107.75,137.41)
S6_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: UNK6K5.2 103.16,151.67 103.16,147.52 104.86,145.82 104.86,140.72 104.09,139.95 99.73,139.95
S6_SPI_DO_D_CASE: length 24.7
  TOP w0.16: UNK6K5.4 103.25,147.19 108.45,147.19 115.69,139.95 v1(121.06,139.95)
  BOTTOM w0.16: UNK6U19.2 v1(121.06,139.95)
S6_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK6R202.1 93.11,139.95 93.73,140.56 93.73,143.76 90.46,147.03 90.46,151.67 UNK6K7.2
S6_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: v1(106.78,139.95) 106.14,140.59 97.15,140.59 UNK6K7.4
  BOTTOM w0.16: UNK6U19.7 v1(106.78,139.95)
S6_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v1(102.24,138.68) 97.05,138.68 87.29,148.44 87.29,151.65 UNK6K7.7
  BOTTOM w0.16: v1(102.24,138.68) 99.73,138.68
S6_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: UNK6K7.5 99.28,135.25 117.63,135.25 v1(121.06,138.68)
  BOTTOM w0.16: UNK6U19.3 v1(121.06,138.68) UNK6R207.2
S6_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK6U31.6 264.19,174.3 263.94,174.06 UNK6R164.2
S6_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK6U31.5 264.6,173.9 263.84,173.14 UNK6R163.2
S6_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK6R165.2 267.91,173.9 UNK6U31.16
S6_USB_D_AB_CASE+: length 1.3
  BOTTOM w0.165: UNK6U31.10 265.88,176.36 v2(266.01,176.49)
S6_USB_D_AB_CASE-: length 1.3
  BOTTOM w0.165: UNK6U31.9 265.48,176.36 v2(265.35,176.49)
S6_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK6R160.2 263.85,175.1 UNK6U31.8
S6_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK6U31.7 263.85,174.7 UNK6R161.2
S6_USER_3V3: length 2.6
  BOTTOM w0.305: UNK6R203.1 v1(103.63,138.68) ; UNK6R200.1 v1(103.63,141.22) ; UNK6R205.1 v1(123.44,141.22) ; UNK6R207.1 v1(123.44,138.68)
  vias: v1(87.1,142.49) v1(87.1,141.22) v1(87.1,139.95) v1(87.58,144.09) v1(100.08,130.33) v1(101.74,130.6) v1(105.53,142.49) v1(105.78,141.22) v1(105.78,139.95) v1(106,144.09)
S6_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(275.06,183.65) 275.35,183.95 275.57,184.17 278.02,184.17 279.01,183.18 279.01,178.84 276.33,176.15 276.33,170.9 277.03,170.19 UNK6K32.3
S6_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK6K32.4 UNK6R135.1
S6_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK6Y1.3 276.93,159.93 277.49,160.49 277.49,163.54 276.55,164.48 UNK6C267.1 UNK6R136.2 UNK6R135.2
S6_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: v2(275.71,183.65) 277.01,183.65 277.6,183.06 277.6,179.33 274.98,176.7 274.98,170.89 274.28,170.19 UNK6K32.6
S6_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK6K32.5 UNK6R137.1
S6_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK6R137.2 UNK6R136.1 UNK6C268.1 271.69,164.48 271.29,164.07 271.29,162.72 UNK6Y1.1
S6_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(272.49,208.29) 273.31,208.29 274.04,207.56 v2(274.04,197.96)
  BOTTOM w0.16: v2(272.49,208.29) 272.19,208.59 UNK6U449.7 ; UNK6K29.7 v2(274.04,197.96)
S6_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 269.6,189.25 v2(269.2,188.86)
  BOTTOM w0.16: 269.6,189.25 269.85,189.51 269.85,191.04 270.61,191.79 271.11,191.79 272.71,193.39 272.71,199.49 273.38,200.16 UNK6K29.6
S6_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK6C271.1 273.19,206.93 UNK6Y2.1 273.19,203.05 273.88,202.36 UNK6K29.5
S6_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK6R923.1 271.92,213.09 UNK6R973.2 271.69,211.81 UNK6U449.2
S6_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(271.38,208.29) 270.56,208.29 269.84,207.56 v2(269.84,197.96)
  BOTTOM w0.16: UNK6K29.2 v2(269.84,197.96) ; v2(271.38,208.29) 271.69,208.59 UNK6U449.8
S6_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: UNK6K29.3 270.64,200.16 271.34,199.45 271.34,194.01 269.2,191.87 v2(269.2,189.51)
S6_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK6K29.4 269.99,202.36 270.69,203.05 UNK6Y2.2 270.69,206.93 UNK6C272.1
S6_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK6R652.1 270.92,213.09 UNK6R973.1 271.19,211.78 UNK6U449.1
S7_0V5: length 41.7
  BOTTOM w0.305: 308.42,137 308.22,137.2 UNK7C288.1 308.17,137.18 307.99,137
  BOTTOM w0.381: 309.37,136.04 309.49,135.92 UNK7MU3.3
  BOTTOM w0.508: UNK7MK1.4 322.48,144.1 323.37,143.22 323.37,136.06 320.15,132.84 307.87,132.84 307.41,133.3 UNK7MR4.1 ; UNK7MR4.1 UNK7MR3.1 307.34,134.78 UNK7C286.1 307.34,136.35 307.99,137 ; UNK7MR4.1 UNK7MR5.1 UNK7MR6.1 UNK7MR2.2 ; 309.37,136.04 309.37,136.05 308.42,137
S7_0V25: length 2.8
  BOTTOM w0.508: UNK7MR18.2 319.78,142.63 UNK7MR19.1 317.21,142.63 UNK7MK4.3
S7_0V75: length 4.9
  BOTTOM w0.381: UNK7MU3.6 UNK7MR10.2
  BOTTOM w0.508: UNK7MK2.4 316.81,138.44 UNK7C290.1 UNK7MR10.2
S7_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v4(293.66,187.72) 293.12,187.72 292.78,188.06 UNK7R661.2
  TOP w0.381: v4(294.66,191.72) 294.87,191.5 294.87,188.23 294.36,187.72 v4(293.66,187.72)
  BOTTOM w0.381: v4(293.66,187.72) UNK7C922.2
  BOTTOM w0.508: UNK7C922.2 293.66,185.95 293.3,185.59 291.82,185.59 291.5,185.91 UNK7BDB5.2
S7_3V3_RX1_MIPI: length 13.4
  TOP w0.305: v4(293.66,176.15) 293.12,176.15 292.78,176.49 UNK7R663.2
  TOP w0.381: v4(294.66,180.15) 294.87,179.94 294.87,176.66 294.36,176.15 v4(293.66,176.15)
  BOTTOM w0.381: v4(293.66,176.15) UNK7C923.2
  BOTTOM w0.508: UNK7C923.2 293.66,174.38 293.3,174.02 291.82,174.02 291.5,174.35 UNK7BDB6.2
S7_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK7U31.4 305.48,173.24 304.6,172.36 UNK7C262.1
  BOTTOM w0.305: UNK7BD21.2 UNK7C262.1
S7_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 309.83,210.83 UNK7C1074.1 UNK7R981.1
  BOTTOM w0.356: UNK7R981.1 309.86,209.73 UNK7U449.10
  BOTTOM w0.508: UNK7BD1728.2 309.83,210.83
S7_DCH015:
  vias: v2(306.6,183)
S7_DCH016:
  vias: v2(306.6,183.65)
S7_DCH018:
  vias: v2(307.9,183.66)
S7_DCH069:
  vias: v2(313.76,187.56)
S7_DCH089:
  vias: v2(314.41,184.96)
S7_DCH108: length 1.4
  BOTTOM w0.16: UNK7K32.2 v2(317.83,172.39)
S7_DCH109: length 1.4
  BOTTOM w0.16: UNK7K32.7 v2(313.63,172.39)
S7_DCH110: length 0.7
  BOTTOM w0.16: UNK7U449.3 v2(312.19,211.11)
S7_DCH111: length 0.9
  BOTTOM w0.16: UNK7U449.4 312.69,210.61 v2(313.18,211.1)
S7_DPS3: length 0.7
  BOTTOM w0.508: UNK7CA21.1 v1(310.12,150.98)
  vias: v1(310.12,153.01) v2(307.9,184.96) v2(311.15,190.16) v2(311.8,190.16) v2(312.46,190.16) v2(312.46,186.26) v2(312.46,184.3) v2(313.11,190.16) v2(313.76,183.65)
S7_DPS4: length 0.7
  BOTTOM w0.508: UNK7CA35.1 v1(324.57,152.5)
  vias: v1(324.57,154.53) v2(306.6,190.16) v2(306.6,185.61) v2(313.76,184.96)
S7_M_2V5: length 4.8
  BOTTOM w0.508: UNK7MR2.1 UNK7C284.1 ; UNK7C284.1 UNK7C285.1 ; UNK7C284.1 304.24,135.91 UNK7MU2.6
S7_M_3V2: length 24.3
  BOTTOM w0.381: UNK7MU3.7 313.83,135.27 313.7,135.39
  BOTTOM w0.508: UNK7MU2.2 302.97,146.08 UNK7C282.1 UNK7C283.1 304.2,146.16 UNK7MR1.1 307.48,146.16 UNK7MU1.5 306.52,145.05 306.52,139.7 307.37,138.85 309.04,138.85 310.13,137.76 UNK7C289.1 312.41,137.76 313.18,136.99 313.18,135.91 313.7,135.39
S7_MPDCH03+: length 1.3
  BOTTOM w0.165: UNK7U31.2 306.28,172.65 v2(306.41,172.52)
S7_MPDCH03-: length 1.3
  BOTTOM w0.165: UNK7U31.3 305.88,172.65 v2(305.75,172.52)
S7_MPDCH05:
  vias: v2(309.2,186.26)
S7_MPDCH25:
  vias: v2(306.6,182.35)
S7_MPDCH26:
  vias: v2(306.6,181.7)
S7_MPDCH34:
  vias: v2(307.1,209) v2(307.86,209)
S7_MPDCH37+:
  vias: v4(291.66,191.22)
S7_MPDCH37-:
  vias: v4(291.16,191.22)
S7_MPDCH39+:
  vias: v4(291.66,190.22)
S7_MPDCH39-:
  vias: v4(291.16,190.22)
S7_MPDCH41+: length 0.5
  BOTTOM w0.16: UNK7U408.E8 v4(292.16,189.72)
S7_MPDCH41-: length 0.5
  BOTTOM w0.16: UNK7U408.E9 v4(290.66,189.72)
S7_MPDCH43+:
  vias: v4(291.66,179.65)
S7_MPDCH43-:
  vias: v4(291.16,179.65)
S7_MPDCH45+:
  vias: v4(291.66,178.65)
S7_MPDCH45-:
  vias: v4(291.16,178.65)
S7_MPDCH47+: length 0.5
  BOTTOM w0.16: UNK7U409.E8 v4(292.16,178.15)
S7_MPDCH47-: length 0.5
  BOTTOM w0.16: UNK7U409.E9 v4(290.66,178.15)
S7_MPDCH52:
  vias: v2(313.76,181.71)
S7_MPDCH53:
  vias: v2(307.9,182.35)
S7_MPDCH56:
  vias: v2(307.9,186.26)
S7_MPDCH57:
  vias: v2(313.76,183)
S7_MPDCH59:
  vias: v2(313.76,182.36)
S7_MPDCH62:
  vias: v2(315.05,184.96)
S7_MPDCH63:
  vias: v2(313.76,186.91)
S7_MPDCH65:
  vias: v2(315.05,187.56)
S7_MPDCH66:
  vias: v2(315.05,186.91)
S7_MPDCH75:
  vias: v2(315.05,186.26)
S7_MPDCH77:
  vias: v2(313.76,186.26)
S7_MPDCH85:
  vias: v2(313.11,186.26)
S7_MUX_3V3: length 1.5
  TOP w0.508: v2(307.1,207.19) v2(307.86,207.19)
  BOTTOM w0.508: v2(307.1,207.19) UNK7R512.1 v2(307.86,207.19)
  vias: v2(302.6,172.36) v2(309.83,212.29)
S7_OUT_RX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(297.22,192.07) 297.06,191.91 297.06,191.37 296.57,190.88 295,190.88 UNK7U408.B2
S7_OUT_RX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK7U408.B1 295.19,191.25 296.41,191.25 296.68,191.52 296.68,191.9 v2(296.51,192.07)
S7_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK7R647.1 295.3,193.77 295.3,193.05 294.94,192.7 294.44,192.7 294.15,192.41 294.15,191.71 UNK7U408.B4
S7_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK7U408.A4 293.78,191.83 293.78,192.57 294.28,193.07 294.79,193.07 294.92,193.21 294.92,193.38 294.81,193.5 294.45,193.5 294.38,193.57 294.38,193.78 294.46,193.86 UNK7R646.1
S7_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK7R647.2 UNK7R646.2 UNK7C309.1
S7_OUT_RX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK7U408.D2 295.02,190.57 296.56,190.57 297.05,190.08 297.05,189.53 v2(297.22,189.36)
  vias: v2(309.85,187.56)
S7_OUT_RX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK7U408.D1 295.18,190.2 296.41,190.2 296.68,189.93 296.68,189.53 v2(296.51,189.36)
S7_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 293.41,191.97 293.41,191.47 UNK7U408.B5
  BOTTOM w0.132: UNK7R168.1 293.82,193.7 293.82,193.24 293.41,192.83 293.41,191.97
S7_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK7R170.1 293.45,193.7 293.45,193.39 293.2,193.14 292.82,193.14 292.69,193.01 292.69,192.82 292.82,192.69 292.91,192.69 293.04,192.56 293.04,191.84 UNK7U408.A5
S7_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK7R170.2 UNK7R168.2 UNK7C310.1
S7_OUT_RX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK7U408.E2 v2(294.16,189.72)
S7_OUT_RX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK7U408.E1 v2(295.66,189.72)
S7_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK7U408.B6 292.28,191.59 292.28,192.14 291.8,192.62 291.8,193.7 UNK7R176.1
S7_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK7U408.A6 292.66,191.72 292.66,191.73 292.66,192.29 292.17,192.78 292.17,193.1 292.47,193.4 292.66,193.4 292.77,193.51 292.77,193.73 292.64,193.86 UNK7R178.1
S7_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK7C318.1 UNK7R176.2 UNK7R178.2
S7_OUT_RX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK7U409.B2 295,179.31 296.57,179.31 297.06,179.8 297.06,180.34 v2(297.22,180.5)
  vias: v2(308.55,187.56)
S7_OUT_RX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK7U409.B1 295.19,179.69 296.41,179.69 296.68,179.96 296.68,180.34 v2(296.51,180.5)
S7_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK7U409.B4 294.15,180.14 294.15,180.85 294.44,181.13 294.94,181.13 295.3,181.48 295.3,182.21 UNK7R1089.1
S7_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK7U409.A4 293.78,180.27 293.78,181 294.28,181.51 294.79,181.51 294.92,181.64 294.92,181.81 294.81,181.93 294.45,181.93 294.38,182 294.38,182.21 294.46,182.3 UNK7R1088.1
S7_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK7C302.1 UNK7R1088.2 UNK7R1089.2
S7_OUT_RX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK7U409.D2 295.02,179.01 296.56,179.01 297.05,178.51 297.05,177.97 v2(297.22,177.8)
S7_OUT_RX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK7U409.D1 295.18,178.63 296.41,178.63 296.68,178.36 296.68,177.96 v2(296.51,177.8)
  vias: v2(307.9,187.56)
S7_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: 293.41,180.41 293.41,179.9 UNK7U409.B5
  BOTTOM w0.132: 293.41,180.41 293.41,181.26 293.82,181.67 293.82,182.13 UNK7R180.1
S7_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK7U409.A5 293.04,180.27 293.04,181 292.91,181.12 292.82,181.12 292.69,181.25 292.69,181.44 292.82,181.57 293.2,181.57 293.45,181.83 293.45,182.13 UNK7R182.1
S7_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK7C320.1 UNK7R180.2 UNK7R182.2
S7_OUT_RX0_CH5_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK7U409.E2 v2(294.16,178.15)
S7_OUT_RX0_CH5_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK7U409.E1 v2(295.66,178.15)
S7_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK7U409.B6 292.28,180.03 292.28,180.57 291.8,181.06 291.8,182.13 UNK7R666.1
S7_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK7R664.1 292.64,182.3 292.77,182.17 292.77,181.94 292.66,181.84 292.47,181.84 292.17,181.53 292.17,181.21 292.66,180.72 292.66,180.15 UNK7U409.A6
S7_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK7R664.2 UNK7R666.2 UNK7C924.1
S7_OUT_TX0_CH0_ABC_CASE-:
  vias: v2(306.6,187.56)
S7_OUT_TX0_CH1_ABC_CASE+:
  vias: v2(306.6,186.91)
S7_OUT_TX0_CH2_ABC_CASE-:
  vias: v2(306.6,186.26)
S7_PM_SAR_GPIO0:
  vias: v1(317.14,146.64)
S7_PWR_F001: length 0.7
  BOTTOM w0.508: UNK7CA27.1 v1(305.3,155.04)
  vias: v1(305.3,157.07) v2(315.05,190.16)
S7_PWR_F004: length 0.7
  BOTTOM w0.508: UNK7CA23.1 v1(319.75,147.83)
  vias: v1(319.75,149.86) v2(311.81,187.56)
S7_PWR_F005: length 0.7
  BOTTOM w0.508: UNK7CA8.1 v1(319.75,152.5)
  vias: v1(319.75,154.53) v2(312.46,183) v2(313.11,183.01) v2(315.05,183)
S7_PWR_F006: length 0.7
  BOTTOM w0.508: UNK7CA25.1 v1(300.48,150.98)
  vias: v1(300.48,153.01) v2(310.5,180.41) v2(311.81,181.7) v2(312.46,181.06)
S7_PWR_F007: length 0.7
  BOTTOM w0.508: UNK7CA36.1 v1(305.3,150.98)
  vias: v1(305.3,153.01) v2(309.85,181.06) v2(310.5,181.7) v2(311.16,181.7)
S7_PWR_F008:
  vias: v2(313.76,184.31)
S7_PWR_M_F001: length 0.7
  BOTTOM w0.508: UNK7CA1.1 v1(300.48,155.04)
  vias: v1(300.48,157.07) v2(308.55,181.7) v2(308.55,181.06) v2(308.55,179.11) v2(309.2,185.61) v2(309.2,184.96) v2(309.85,184.96) v2(310.5,190.16) v2(310.5,186.91) v2(310.5,186.26) v2(310.5,185.61) v2(310.5,184.3) v2(311.16,186.26) v2(311.16,185.61) v2(311.16,184.96) v2(311.16,184.3) v2(311.81,184.96) v2(311.81,179.11)
S7_SPI_CK_ABCD_CASE:
  vias: v2(315.05,181.7)
S7_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK7K3.7 480.33,158.66 465.62,158.66 464.48,157.52 464.48,150.96 465.91,149.53 465.91,144.58 463.83,142.49 461.72,142.49
  vias: v1(457.94,143.76)
S7_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK7U19.6 481.45,142.49 481.93,142.97 UNK7K3.5
S7_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: v1(473.08,145.03) 467.65,150.45 467.65,157.65 468.66,158.66 483.53,158.66 UNK7K3.2
  BOTTOM w0.16: v1(473.08,145.03) 470.57,145.03
S7_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK7R205.2 UNK7U19.1 487.05,145.03 485.13,146.95 UNK7K3.4
S7_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: 461.72,141.22 463.95,141.22 467.65,144.92 467.65,155.48 UNK7K5.7
S7_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v1(478.59,141.22) 478.59,146.12 477.61,147.1 474.78,147.1 UNK7K5.5
  BOTTOM w0.16: UNK7U19.5 v1(478.59,141.22)
S7_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: 470.57,143.76 474.93,143.76 475.7,144.53 475.7,147.68 474,149.38 474,155.48 UNK7K5.2
S7_SPI_DO_D_CASE: length 24.7
  TOP w0.16: v1(491.9,143.76) 486.53,143.76 479.29,151 474.09,151 UNK7K5.4
  BOTTOM w0.16: UNK7U19.2 v1(491.9,143.76)
S7_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK7K7.2 461.3,155.48 461.3,150.84 464.57,147.57 464.57,144.37 463.95,143.76 UNK7R202.1
S7_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: v1(477.62,143.76) 476.98,144.4 467.99,144.4 UNK7K7.4
  BOTTOM w0.16: UNK7U19.7 v1(477.62,143.76)
S7_SPI_WPZ_C_CASE: length 27
  TOP w0.16: UNK7K7.7 458.13,155.46 458.13,152.25 467.89,142.49 v1(473.08,142.49)
  BOTTOM w0.16: v1(473.08,142.49) 470.57,142.49
S7_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: UNK7K7.5 470.12,139.06 488.47,139.06 v1(491.9,142.49)
  BOTTOM w0.16: UNK7R207.2 v1(491.9,142.49) UNK7U19.3
S7_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK7R164.2 303.94,174.06 304.19,174.3 UNK7U31.6
S7_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK7R163.2 303.84,173.14 304.6,173.9 UNK7U31.5
S7_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK7R165.2 307.91,173.9 UNK7U31.16
S7_USB_D_AB_CASE+: length 1.3
  BOTTOM w0.165: v2(306.01,176.49) 305.88,176.36 UNK7U31.10
S7_USB_D_AB_CASE-: length 1.3
  BOTTOM w0.165: v2(305.35,176.49) 305.48,176.36 UNK7U31.9
S7_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK7U31.8 303.85,175.1 UNK7R160.2
S7_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK7U31.7 303.85,174.7 UNK7R161.2
S7_USER_3V3: length 2.6
  BOTTOM w0.305: UNK7R200.1 v1(474.47,145.03) ; UNK7R205.1 v1(494.28,145.03) ; UNK7R207.1 v1(494.28,142.49) ; UNK7R203.1 v1(474.47,142.49)
  vias: v1(457.94,146.3) v1(458.42,147.9) v1(470.92,134.14) v1(472.58,134.41) v1(476.37,146.3) v1(476.62,145.03) v1(476.62,143.76) v1(476.84,147.9)
S7_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: UNK7K32.3 317.03,170.19 316.33,170.9 316.33,176.15 319.01,178.84 319.01,183.18 318.02,184.17 315.57,184.17 315.35,183.95 v2(315.05,183.65)
S7_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK7K32.4 UNK7R135.1
S7_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK7R135.2 UNK7R136.2 UNK7C267.1 316.55,164.48 317.49,163.54 317.49,160.49 316.93,159.93 UNK7Y1.3
S7_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: v2(315.7,183.65) 317,183.65 317.6,183.06 317.6,179.33 314.98,176.7 314.98,170.89 314.28,170.19 UNK7K32.6
S7_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK7K32.5 UNK7R137.1
S7_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK7Y1.1 311.29,162.72 311.29,164.07 311.69,164.48 UNK7C268.1 UNK7R136.1 UNK7R137.2
S7_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(312.49,208.29) 313.31,208.29 314.03,207.56 v2(314.03,197.96)
  BOTTOM w0.16: UNK7K29.7 v2(314.03,197.96) ; v2(312.49,208.29) 312.19,208.59 UNK7U449.7
S7_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 309.6,189.25 v2(309.2,188.86)
  BOTTOM w0.16: UNK7K29.6 313.38,200.16 312.71,199.49 312.71,193.39 311.11,191.79 310.61,191.79 309.85,191.04 309.85,189.51 309.6,189.25
S7_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK7K29.5 313.88,202.36 313.19,203.05 UNK7Y2.1 313.19,206.93 UNK7C271.1
S7_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK7U449.2 311.69,211.81 UNK7R973.2 311.92,213.09 UNK7R923.1
S7_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(311.38,208.29) 310.56,208.29 309.84,207.56 v2(309.84,197.96)
  BOTTOM w0.16: UNK7U449.8 311.69,208.59 v2(311.38,208.29) ; UNK7K29.2 v2(309.84,197.96)
S7_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: v2(309.2,189.51) 309.2,191.87 311.34,194.01 311.34,199.45 310.64,200.16 UNK7K29.3
S7_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK7C272.1 310.69,206.93 UNK7Y2.2 310.69,203.05 309.99,202.36 UNK7K29.4
S7_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK7R652.1 310.92,213.09 UNK7R973.1 311.19,211.78 UNK7U449.1
S8_0V5: length 41.7
  BOTTOM w0.305: 348.42,137 348.22,137.2 UNK8C288.1 348.17,137.18 347.99,137
  BOTTOM w0.381: UNK8MU3.3 349.49,135.92 349.37,136.04
  BOTTOM w0.508: UNK8MR2.2 UNK8MR6.1 UNK8MR5.1 UNK8MR4.1 ; UNK8MR4.1 347.41,133.3 347.87,132.84 360.15,132.84 363.37,136.06 363.37,143.22 362.48,144.1 UNK8MK1.4 ; UNK8MR4.1 UNK8MR3.1 347.34,134.78 UNK8C286.1 347.34,136.35 347.99,137 ; 349.37,136.04 349.37,136.05 348.42,137
S8_0V25: length 2.8
  BOTTOM w0.508: UNK8MK4.3 357.21,142.63 UNK8MR19.1 359.78,142.63 UNK8MR18.2
S8_0V75: length 4.9
  BOTTOM w0.381: UNK8MU3.6 UNK8MR10.2
  BOTTOM w0.508: UNK8MR10.2 UNK8C290.1 356.81,138.44 UNK8MK2.4
S8_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v4(333.66,187.72) 333.12,187.72 332.78,188.06 UNK8R661.2
  TOP w0.381: v4(334.66,191.72) 334.87,191.5 334.87,188.23 334.36,187.72 v4(333.66,187.72)
  BOTTOM w0.381: v4(333.66,187.72) UNK8C922.2
  BOTTOM w0.508: UNK8C922.2 333.66,185.95 333.3,185.59 331.82,185.59 331.5,185.91 UNK8BDB5.2
S8_3V3_RX1_MIPI: length 13.4
  TOP w0.305: v4(333.66,176.15) 333.12,176.15 332.78,176.49 UNK8R663.2
  TOP w0.381: v4(334.66,180.15) 334.87,179.94 334.87,176.66 334.36,176.15 v4(333.66,176.15)
  BOTTOM w0.381: v4(333.66,176.15) UNK8C923.2
  BOTTOM w0.508: UNK8BDB6.2 331.5,174.35 331.82,174.02 333.3,174.02 333.66,174.38 UNK8C923.2
S8_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK8C262.1 344.6,172.36 345.48,173.24 UNK8U31.4
  BOTTOM w0.305: UNK8BD21.2 UNK8C262.1
S8_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 349.83,210.83 UNK8C1074.1 UNK8R981.1
  BOTTOM w0.356: UNK8R981.1 349.86,209.73 UNK8U449.10
  BOTTOM w0.508: UNK8BD1728.2 349.83,210.83
S8_DCH015:
  vias: v2(346.6,183)
S8_DCH016:
  vias: v2(346.6,183.65)
S8_DCH018:
  vias: v2(347.9,183.66)
S8_DCH069:
  vias: v2(353.75,187.56)
S8_DCH089:
  vias: v2(354.4,184.96)
S8_DCH108: length 1.4
  BOTTOM w0.16: UNK8K32.2 v2(357.83,172.39)
S8_DCH109: length 1.4
  BOTTOM w0.16: UNK8K32.7 v2(353.63,172.39)
S8_DCH110: length 0.7
  BOTTOM w0.16: UNK8U449.3 v2(352.19,211.11)
S8_DCH111: length 0.9
  BOTTOM w0.16: UNK8U449.4 352.69,210.61 v2(353.18,211.1)
S8_DPS3: length 0.7
  BOTTOM w0.508: UNK8CA21.1 v1(350.12,150.98)
  vias: v1(350.12,153.01) v2(347.9,184.96) v2(351.15,190.16) v2(351.8,190.16) v2(352.45,190.16) v2(352.45,186.26) v2(352.45,184.3) v2(353.1,190.16) v2(353.1,184.3) v2(353.75,183.65)
S8_DPS4: length 0.7
  BOTTOM w0.508: UNK8CA35.1 v1(364.57,152.5)
  vias: v1(364.57,154.53) v2(346.6,190.16) v2(346.6,185.61) v2(353.75,184.96)
S8_M_2V5: length 4.8
  BOTTOM w0.508: UNK8MR2.1 UNK8C284.1 ; UNK8C284.1 UNK8C285.1 ; UNK8C284.1 344.24,135.91 UNK8MU2.6
S8_M_3V2: length 24.3
  BOTTOM w0.381: 353.7,135.39 353.83,135.27 UNK8MU3.7
  BOTTOM w0.508: 353.7,135.39 353.18,135.91 353.18,136.99 352.41,137.76 UNK8C289.1 350.13,137.76 349.04,138.85 347.37,138.85 346.52,139.7 346.52,145.05 UNK8MU1.5 347.48,146.16 UNK8MR1.1 344.2,146.16 UNK8C283.1 UNK8C282.1 342.97,146.08 UNK8MU2.2
S8_MPDCH03+: length 1.3
  BOTTOM w0.165: v2(346.41,172.52) 346.28,172.65 UNK8U31.2
S8_MPDCH03-: length 1.3
  BOTTOM w0.165: UNK8U31.3 345.88,172.65 v2(345.75,172.52)
S8_MPDCH05:
  vias: v2(349.2,186.26)
S8_MPDCH25:
  vias: v2(346.6,182.35)
S8_MPDCH26:
  vias: v2(346.6,181.7)
S8_MPDCH34:
  vias: v2(347.1,209) v2(347.86,209)
S8_MPDCH37+:
  vias: v4(331.66,191.22)
S8_MPDCH37-:
  vias: v4(331.16,191.22)
S8_MPDCH39+:
  vias: v4(331.66,190.22)
S8_MPDCH39-:
  vias: v4(331.16,190.22)
S8_MPDCH41+: length 0.5
  BOTTOM w0.16: UNK8U408.E8 v4(332.16,189.72)
S8_MPDCH41-: length 0.5
  BOTTOM w0.16: UNK8U408.E9 v4(330.66,189.72)
S8_MPDCH43+:
  vias: v4(331.66,179.65)
S8_MPDCH43-:
  vias: v4(331.16,179.65)
S8_MPDCH45+:
  vias: v4(331.66,178.65)
S8_MPDCH45-:
  vias: v4(331.16,178.65)
S8_MPDCH47+: length 0.5
  BOTTOM w0.16: UNK8U409.E8 v4(332.16,178.15)
S8_MPDCH47-: length 0.5
  BOTTOM w0.16: UNK8U409.E9 v4(330.66,178.15)
S8_MPDCH52:
  vias: v2(353.75,181.71)
S8_MPDCH53:
  vias: v2(347.9,182.35)
S8_MPDCH56:
  vias: v2(347.9,186.26)
S8_MPDCH57:
  vias: v2(353.75,183)
S8_MPDCH59:
  vias: v2(353.75,182.36)
S8_MPDCH62:
  vias: v2(355.05,184.96)
S8_MPDCH63:
  vias: v2(353.75,186.91)
S8_MPDCH65:
  vias: v2(355.05,187.56)
S8_MPDCH66:
  vias: v2(355.05,186.91)
S8_MPDCH75:
  vias: v2(355.05,186.26)
S8_MPDCH77:
  vias: v2(353.75,186.26)
S8_MPDCH85:
  vias: v2(353.1,186.26)
S8_MUX_3V3: length 1.5
  TOP w0.508: v2(347.1,207.19) v2(347.86,207.19)
  BOTTOM w0.508: v2(347.86,207.19) UNK8R512.1 v2(347.1,207.19)
  vias: v2(342.6,172.36) v2(349.83,212.29)
S8_OUT_RX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK8U408.B2 335,190.88 336.57,190.88 337.06,191.37 337.06,191.91 v2(337.22,192.07)
S8_OUT_RX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(336.51,192.07) 336.68,191.9 336.68,191.52 336.41,191.25 335.19,191.25 UNK8U408.B1
S8_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK8R647.1 335.29,193.77 335.29,193.05 334.94,192.7 334.44,192.7 334.15,192.41 334.15,191.71 UNK8U408.B4
S8_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK8U408.A4 333.78,191.83 333.78,192.57 334.28,193.07 334.79,193.07 334.92,193.21 334.92,193.38 334.81,193.5 334.45,193.5 334.38,193.57 334.38,193.78 334.46,193.86 UNK8R646.1
S8_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK8C309.1 UNK8R646.2 UNK8R647.2
S8_OUT_RX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(337.22,189.36) 337.05,189.53 337.05,190.08 336.56,190.57 335.02,190.57 UNK8U408.D2
  vias: v2(349.85,187.56)
S8_OUT_RX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(336.51,189.36) 336.68,189.53 336.68,189.93 336.4,190.2 335.18,190.2 UNK8U408.D1
S8_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 333.41,191.97 333.41,191.47 UNK8U408.B5
  BOTTOM w0.132: 333.41,191.97 333.41,192.83 333.82,193.24 333.82,193.7 UNK8R168.1
S8_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK8R170.1 333.45,193.7 333.45,193.39 333.2,193.14 332.82,193.14 332.69,193.01 332.69,192.82 332.82,192.69 332.91,192.69 333.04,192.56 333.04,191.84 UNK8U408.A5
S8_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK8C310.1 UNK8R168.2 UNK8R170.2
S8_OUT_RX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK8U408.E2 v2(334.16,189.72)
S8_OUT_RX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK8U408.E1 v2(335.66,189.72)
S8_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK8R176.1 331.8,193.7 331.8,192.62 332.28,192.14 332.28,191.59 UNK8U408.B6
S8_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK8R178.1 332.64,193.86 332.77,193.73 332.77,193.51 332.66,193.4 332.47,193.4 332.17,193.1 332.17,192.78 332.66,192.29 332.66,191.72 UNK8U408.A6
S8_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK8R178.2 UNK8R176.2 UNK8C318.1
S8_OUT_RX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK8U409.B2 335,179.31 336.57,179.31 337.06,179.8 337.06,180.34 v2(337.22,180.5)
  vias: v2(348.55,187.56)
S8_OUT_RX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(336.51,180.5) 336.68,180.34 336.68,179.96 336.41,179.69 335.19,179.69 UNK8U409.B1
S8_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK8R1089.1 335.29,182.21 335.29,181.48 334.94,181.13 334.44,181.13 334.15,180.85 334.15,180.14 UNK8U409.B4
S8_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK8R1088.1 334.46,182.3 334.38,182.21 334.38,182 334.45,181.93 334.81,181.93 334.92,181.81 334.92,181.64 334.79,181.51 334.28,181.51 333.78,181 333.78,180.27 UNK8U409.A4
S8_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK8R1089.2 UNK8R1088.2 UNK8C302.1
S8_OUT_RX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(337.22,177.8) 337.05,177.97 337.05,178.51 336.56,179.01 335.02,179.01 UNK8U409.D2
S8_OUT_RX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK8U409.D1 335.18,178.63 336.4,178.63 336.68,178.36 336.68,177.96 v2(336.51,177.8)
  vias: v2(347.9,187.56)
S8_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK8U409.B5 333.41,179.9 333.41,180.41
  BOTTOM w0.132: UNK8R180.1 333.82,182.13 333.82,181.67 333.41,181.26 333.41,180.41
S8_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK8U409.A5 333.04,180.27 333.04,181 332.91,181.12 332.82,181.12 332.69,181.25 332.69,181.44 332.82,181.57 333.2,181.57 333.45,181.83 333.45,182.13 UNK8R182.1
S8_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK8C320.1 UNK8R180.2 UNK8R182.2
S8_OUT_RX0_CH5_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK8U409.E2 v2(334.16,178.15)
S8_OUT_RX0_CH5_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK8U409.E1 v2(335.66,178.15)
S8_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK8R666.1 331.8,182.13 331.8,181.06 332.28,180.57 332.28,180.03 UNK8U409.B6
S8_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK8U409.A6 332.66,180.15 332.66,180.16 332.66,180.72 332.17,181.21 332.17,181.53 332.47,181.84 332.66,181.84 332.77,181.94 332.77,182.17 332.64,182.3 UNK8R664.1
S8_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK8C924.1 UNK8R666.2 UNK8R664.2
S8_OUT_TX0_CH0_ABC_CASE-:
  vias: v2(346.6,187.56)
S8_OUT_TX0_CH1_ABC_CASE+:
  vias: v2(346.6,186.91)
S8_OUT_TX0_CH2_ABC_CASE-:
  vias: v2(346.6,186.26)
S8_PM_SAR_GPIO0:
  vias: v1(357.14,146.64)
S8_PWR_F001: length 0.7
  BOTTOM w0.508: UNK8CA27.1 v1(345.3,155.04)
  vias: v1(345.3,157.07) v2(355.05,190.16)
S8_PWR_F004: length 0.7
  BOTTOM w0.508: UNK8CA23.1 v1(359.75,147.83)
  vias: v1(359.75,149.86) v2(351.8,187.56)
S8_PWR_F005: length 0.7
  BOTTOM w0.508: UNK8CA8.1 v1(359.75,152.5)
  vias: v1(359.75,154.53) v2(352.45,183) v2(353.1,183.01) v2(355.05,183)
S8_PWR_F006: length 0.7
  BOTTOM w0.508: UNK8CA25.1 v1(340.48,150.98)
  vias: v1(340.48,153.01) v2(350.5,180.41) v2(351.8,181.7) v2(352.45,181.06)
S8_PWR_F007: length 0.7
  BOTTOM w0.508: UNK8CA36.1 v1(345.3,150.98)
  vias: v1(345.3,153.01) v2(349.85,181.06) v2(350.5,181.7) v2(351.15,181.7)
S8_PWR_F008:
  vias: v2(353.75,184.31)
S8_PWR_M_F001: length 0.7
  BOTTOM w0.508: UNK8CA1.1 v1(340.48,155.04)
  vias: v1(340.48,157.07) v2(348.55,181.7) v2(348.55,181.06) v2(348.55,179.11) v2(349.2,185.61) v2(349.2,184.96) v2(349.85,184.96) v2(350.5,190.16) v2(350.5,186.91) v2(350.5,186.26) v2(350.5,185.61) v2(350.5,184.3) v2(351.15,186.26) v2(351.15,185.61) v2(351.15,184.96) v2(351.15,184.3) v2(351.8,184.96) v2(351.8,179.11)
S8_SPI_CK_ABCD_CASE:
  vias: v2(355.05,181.7)
S8_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: 461.72,174.24 463.83,174.24 465.91,176.33 465.91,181.28 464.48,182.71 464.48,189.27 465.62,190.41 480.33,190.41 UNK8K3.7
  vias: v1(457.94,175.51)
S8_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK8U19.6 481.45,174.24 481.93,174.72 UNK8K3.5
S8_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: v1(473.08,176.78) 467.65,182.2 467.65,189.4 468.66,190.41 483.53,190.41 UNK8K3.2
  BOTTOM w0.16: v1(473.08,176.78) 470.57,176.78
S8_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK8K3.4 485.13,178.7 487.05,176.78 UNK8U19.1 UNK8R205.2
S8_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: 461.72,172.97 463.95,172.97 467.65,176.67 467.65,187.23 UNK8K5.7
S8_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v1(478.59,172.97) 478.59,177.87 477.61,178.85 474.78,178.85 UNK8K5.5
  BOTTOM w0.16: UNK8U19.5 v1(478.59,172.97)
S8_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: 470.57,175.51 474.93,175.51 475.7,176.28 475.7,179.43 474,181.13 474,187.23 UNK8K5.2
S8_SPI_DO_D_CASE: length 24.7
  TOP w0.16: v1(491.9,175.51) 486.53,175.51 479.29,182.75 474.09,182.75 UNK8K5.4
  BOTTOM w0.16: UNK8U19.2 v1(491.9,175.51)
S8_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK8R202.1 463.95,175.51 464.57,176.12 464.57,179.32 461.3,182.59 461.3,187.23 UNK8K7.2
S8_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK8K7.4 467.99,176.15 476.98,176.15 v1(477.62,175.51)
  BOTTOM w0.16: UNK8U19.7 v1(477.62,175.51)
S8_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v1(473.08,174.24) 467.89,174.24 458.13,184 458.13,187.21 UNK8K7.7
  BOTTOM w0.16: v1(473.08,174.24) 470.57,174.24
S8_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: UNK8K7.5 470.12,170.81 488.47,170.81 v1(491.9,174.24)
  BOTTOM w0.16: UNK8R207.2 v1(491.9,174.24) UNK8U19.3
S8_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK8U31.6 344.19,174.3 343.94,174.06 UNK8R164.2
S8_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK8R163.2 343.84,173.14 344.6,173.9 UNK8U31.5
S8_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK8U31.16 347.91,173.9 UNK8R165.2
S8_USB_D_AB_CASE+: length 1.3
  BOTTOM w0.165: v2(346.01,176.49) 345.88,176.36 UNK8U31.10
S8_USB_D_AB_CASE-: length 1.3
  BOTTOM w0.165: v2(345.35,176.49) 345.48,176.36 UNK8U31.9
S8_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK8R160.2 343.85,175.1 UNK8U31.8
S8_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK8U31.7 343.85,174.7 UNK8R161.2
S8_USER_3V3: length 2.6
  BOTTOM w0.305: UNK8R203.1 v1(474.47,174.24) ; UNK8R205.1 v1(494.28,176.78) ; UNK8R207.1 v1(494.28,174.24) ; UNK8R200.1 v1(474.47,176.78)
  vias: v1(457.94,178.05) v1(458.42,179.65) v1(470.92,165.89) v1(472.58,166.16) v1(476.37,178.05) v1(476.62,176.78) v1(476.62,175.51) v1(476.84,179.65)
S8_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: UNK8K32.3 357.03,170.19 356.33,170.9 356.33,176.15 359.01,178.84 359.01,183.18 358.02,184.17 355.57,184.17 355.35,183.95 v2(355.05,183.65)
S8_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK8K32.4 UNK8R135.1
S8_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK8Y1.3 356.93,159.93 357.49,160.49 357.49,163.54 356.55,164.48 UNK8C267.1 UNK8R136.2 UNK8R135.2
S8_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: UNK8K32.6 354.28,170.19 354.98,170.89 354.98,176.7 357.6,179.33 357.6,183.06 357,183.65 v2(355.7,183.65)
S8_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK8K32.5 UNK8R137.1
S8_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK8Y1.1 351.29,162.72 351.29,164.07 351.69,164.48 UNK8C268.1 UNK8R136.1 UNK8R137.2
S8_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(354.03,197.96) 354.03,207.56 353.31,208.29 v2(352.49,208.29)
  BOTTOM w0.16: UNK8K29.7 v2(354.03,197.96) ; UNK8U449.7 352.19,208.59 v2(352.49,208.29)
S8_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 349.6,189.25 v2(349.2,188.86)
  BOTTOM w0.16: UNK8K29.6 353.38,200.16 352.71,199.49 352.71,193.39 351.11,191.79 350.61,191.79 349.85,191.04 349.85,189.51 349.6,189.25
S8_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK8C271.1 353.19,206.93 UNK8Y2.1 353.19,203.05 353.88,202.36 UNK8K29.5
S8_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK8U449.2 351.69,211.81 UNK8R973.2 351.92,213.09 UNK8R923.1
S8_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(349.84,197.96) 349.84,207.56 350.56,208.29 v2(351.38,208.29)
  BOTTOM w0.16: v2(351.38,208.29) 351.69,208.59 UNK8U449.8 ; UNK8K29.2 v2(349.84,197.96)
S8_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: UNK8K29.3 350.64,200.16 351.34,199.45 351.34,194.01 349.2,191.87 v2(349.2,189.51)
S8_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK8C272.1 350.69,206.93 UNK8Y2.2 350.69,203.05 349.99,202.36 UNK8K29.4
S8_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK8U449.1 351.19,211.78 UNK8R973.1 350.92,213.09 UNK8R652.1
SA_CBIT_R32: length 1.4
  BOTTOM w0.203: K32.8 v2(233.63,235.59)
SA_CBIT_S01:
  vias: v2(223.24,233.14)
SA_CBIT_S02:
  vias: v2(223.24,234.06)
SA_CBIT_S03:
  vias: v2(228.01,233.28)
SA_CBIT_S20: length 1.1
  TOP w0.203: R1102.2 v2(215.82,241.23) ; R662.2 v2(226.89,259.54)
SA_CBIT_S25: length 1.6
  BOTTOM w0.508: MR12.2 v1(227.22,287.7)
SA_CBIT_S26: length 1.6
  BOTTOM w0.508: MR15.2 v1(227.22,293.03)
SA_CBIT_S27: length 1.6
  BOTTOM w0.508: MR17.2 v1(227.22,290.37)
SA_CBIT_S28:
  vias: v1(227.22,285.16)
SA_CBIT_S29: length 1.1
  TOP w0.203: R172.2 v2(238.7,259.54) ; R1104.2 v2(215.82,252.79)
SA_RCBIT_01: length 1.7
  BOTTOM w0.203: v1(78.49,295.82) 77.97,295.3 U74.16
SA_RCBIT_02: length 1.7
  BOTTOM w0.203: U80.14 76.57,281.48 v1(75.95,282.1)
SA_RCBIT_03: length 1.7
  BOTTOM w0.203: v1(513.1,225.47) 512.48,226.09 U75.14
SA_RCBIT_04: length 1.5
  BOTTOM w0.203: U72.15 v1(86.92,287.83)
SA_RCBIT_05: length 1.5
  BOTTOM w0.203: v1(511.83,225.47) U75.15
SA_RCBIT_06: length 1.7
  BOTTOM w0.203: U80.16 77.97,281.58 v1(78.49,282.1)
SA_RCBIT_07: length 1.5
  BOTTOM w0.203: U74.15 v1(77.22,295.82)
SA_RCBIT_08: length 1.5
  BOTTOM w0.203: U80.15 v1(77.22,282.1)
SA_RCBIT_09: length 1.7
  BOTTOM w0.203: v1(510.56,225.47) 511.08,225.99 U75.16
SA_RCBIT_10: length 1.7
  BOTTOM w0.203: U77.16 502.88,232.93 v1(503.4,233.45)
SA_RCBIT_11: length 1.5
  BOTTOM w0.203: U77.15 v1(502.13,233.45)
SA_RCBIT_12: length 1.7
  BOTTOM w0.203: U77.14 501.48,232.83 v1(500.86,233.45)
SA_RCBIT_13: length 1.7
  BOTTOM w0.203: v1(75.95,295.82) 76.57,295.2 U74.14
SA_SCBIT_01: length 4.7
  BOTTOM w0.203: v1(546.58,237.72) 546.31,237.72 545.61,237.02 543.88,237.02 543.48,236.63 U70.3
SA_SCBIT_02: length 4.5
  BOTTOM w0.203: U70.5 545.61,235.63 546.31,236.33 v1(546.58,236.33)
SA_SCBIT_03: length 4.6
  BOTTOM w0.203: v1(535.97,236.52) 536.25,236.52 536.95,237.22 538.8,237.22 539.39,236.63 U70.18
SA_SCBIT_04: length 4.7
  BOTTOM w0.203: v1(546.58,234.93) 546.31,234.93 545.61,234.23 543.88,234.23 543.48,234.63 U70.7
SA_SCBIT_05: length 4.9
  BOTTOM w0.203: v1(546.58,220.58) 546.31,220.58 545.61,219.88 543.7,219.88 542.9,220.67 U403.9
SA_SCBIT_06: length 4.5
  BOTTOM w0.203: v1(546.58,223.37) 546.31,223.37 545.61,222.67 U403.5
SA_SCBIT_07: length 4.7
  BOTTOM w0.203: v1(546.58,224.77) 546.31,224.77 545.61,224.07 543.88,224.07 543.48,223.67 U403.3
SA_SCBIT_08: length 4.5
  BOTTOM w0.203: U434.5 545.23,209.34 545.93,210.04 v1(546.2,210.04)
SA_SCBIT_09: length 4.9
  BOTTOM w0.203: U434.9 542.52,207.34 543.31,206.54 545.23,206.54 545.93,207.24 v1(546.2,207.24)
SA_SCBIT_10: length 4.7
  BOTTOM w0.203: v1(546.2,208.64) 545.93,208.64 545.23,207.94 543.5,207.94 543.1,208.34 U434.7
SA_SCBIT_11: length 4.7
  BOTTOM w0.203: U434.3 543.1,210.34 543.5,210.74 545.23,210.74 545.93,211.43 v1(546.2,211.43)
SA_SCBIT_12: length 4.9
  BOTTOM w0.203: U70.9 542.9,233.63 543.7,232.83 545.61,232.83 546.31,233.53 v1(546.58,233.53)
SA_SCBIT_13: length 4.7
  BOTTOM w0.203: U403.7 543.48,221.67 543.88,221.28 545.61,221.28 546.31,221.97 v1(546.58,221.97)
UBIT_3V3_UP:
  vias: v1(523.99,153.29) v1(543.09,213.97) v1(543.09,199.88) v1(543.47,240.26) v1(543.47,227.31)
UDBGND: length 3.2
  BOTTOM w0.508: CB5.2 v1(558.82,295.91) ; CB11.2 v1(156.21,290.83) ; CB15.2 v1(20.34,295.91) ; CB7.2 v1(422.91,290.83) ; CB1.2 v1(418.06,133.35) ; CB13.2 v1(22.84,133.35) ; CB9.2 v1(166.1,133.35) ; CB3.2 v1(561.32,133.35)
  vias: v1(20.34,298.45) v1(22.84,130.81) v1(27.67,298.45) v1(27.67,130.81) v1(40.01,298.45) v1(110.49,300.99) v1(128.27,130.81) v1(156.21,293.37) v1(156.98,288.29) v1(166.1,130.81) v1(170.68,130.81) v1(212.48,17.59) v1(411.98,130.81) v1(418.06,130.81) v1(422.91,293.37) v1(424.68,288.29) v1(453.39,298.45) v1(458.47,134.62) v1(554.99,298.45) v1(554.99,130.81) v1(558.82,298.45) v1(561.32,130.81)
UT1_UP5V: length 182.9
  TOP w0.508: v2(342.07,269.01) v2(342.07,268) ; v2(222.07,209.01) v2(222.07,208) ; v2(342.07,209.01) v2(342.07,208) ; v2(302.07,209.01) v2(302.07,208) ; v1(519.61,148.33) v1(520.62,148.33) ; v2(262.07,209.01) v2(262.07,208) ; v2(302.07,269.01) v2(302.07,268) ; v2(262.07,269.01) v2(262.07,268)
  BOTTOM w0.16: 247.65,222.63 C1083.1
  BOTTOM w0.254: UNK7C281.1 309.29,144.63 UNK7MU1.3 ; UNK4MU1.3 352.37,288.44 UNK4C281.1 ; MU1.3 232.37,288.44 C281.1 ; UNK6MU1.3 269.29,144.63 UNK6C281.1 ; UNK5MU1.3 229.29,144.63 UNK5C281.1 ; UNK8C281.1 349.29,144.63 UNK8MU1.3
  BOTTOM w0.305: UNK7R331.1 v1(320.04,135.12) ; UNK6R331.1 v1(280.04,135.12) ; C416.1 82.32,275.16 U79.14 ; C407.1 82.32,288.88 U73.14 ; UNK4R331.1 v1(341.62,297.95) ; R331.1 v1(221.62,297.95) ; C956.1 82.32,261.44 U414.14 ; UNK5R331.1 v1(240.04,135.12) ; UNK8R331.1 v1(360.04,135.12)
  BOTTOM w0.381: RB2.1 v1(211.66,13.4) ; RB1.1 v1(211.66,15.11)
  BOTTOM w0.457: UNK7MU1.1 309.65,146.09 v1(310.07,146.51) ; v1(351.59,286.56) 352.01,286.98 UNK4MU1.1 ; MU1.1 232.01,286.98 v1(231.59,286.56) ; UNK8MU1.1 349.65,146.09 v1(350.07,146.51) ; v1(230.07,146.51) 229.65,146.09 UNK5MU1.1 ; UNK6MU1.1 269.65,146.09 v1(270.07,146.51)
  BOTTOM w0.508: UNK6MR14.2 271.64,146.64 271.13,146.13 UNK6MR12.1 271.13,144.08 ; MR13.1 230.53,293.57 MR15.1 ; UNK4K32.1 v2(357.83,235.59) ; 230.53,288.99 MR17.1 230.53,291.65 ; 230.53,288.99 MR12.1 230.53,286.94 230.02,286.43 MR14.2 ; 230.53,288.99 230.52,288.97 MR11.1 ; UNK8MR14.2 351.64,146.64 351.13,146.13 UNK8MR12.1 351.13,144.08 ; 230.53,291.65 MR15.1 ; 230.53,291.65 230.52,291.64 MR16.1 ; 231.13,141.42 UNK5MR15.1 ; 231.13,141.42 UNK5MR17.1 231.13,144.08 ; 231.13,141.42 231.15,141.43 UNK5MR16.1 ; UNK5MR15.1 231.05,139.96 v1(229.29,139.96) v1(229.29,141.15) UNK5C280.1 UNK5C281.1 ; UNK5MR15.1 231.13,139.5 UNK5MR13.1 ; C281.1 C280.1 v1(232.37,291.92) v1(232.37,293.11) 230.61,293.11 MR15.1 ; 351.13,141.42 351.14,141.43 UNK8MR16.1 ; 351.13,141.42 UNK8MR17.1 351.13,144.08 ; 351.13,141.42 UNK8MR15.1 ; UNK8C281.1 UNK8C280.1 v1(349.29,141.15) v1(349.29,139.96) 351.05,139.96 UNK8MR15.1 ; UNK6U17.2 104.66,131.68 104.98,132 ; 475.82,135.81 475.5,135.49 UNK7U17.2 ; UNK8MR13.1 351.13,139.5 UNK8MR15.1 ; 231.13,144.08 231.15,144.1 UNK5MR11.1 ; 231.13,144.08 UNK5MR12.1 231.13,146.13 231.64,146.64 UNK5MR14.2 ; 350.53,288.99 350.51,288.97 UNK4MR11.1 ; 350.53,288.99 UNK4MR12.1 350.53,286.94 350.02,286.43 UNK4MR14.2 ; 350.53,288.99 UNK4MR17.1 350.53,291.65 ; UNK6K32.1 v2(277.83,175.59) ; 216.33,17.59 v1(213.48,17.59) ; 351.13,144.08 351.14,144.1 UNK8MR11.1 ; UNK6MR15.1 271.05,139.96 v1(269.29,139.96) v1(269.29,141.15) UNK6C280.1 UNK6C281.1 ; UNK6MR15.1 271.13,141.42 ; UNK6MR15.1 271.13,139.5 UNK6MR13.1 ; UNK8K32.1 v2(357.83,175.59) ; CB3.1 v1(558.82,133.35) ; UNK7C281.1 UNK7C280.1 v1(309.29,141.15) v1(309.29,139.96) 311.05,139.96 UNK7MR15.1 ; CB7.1 v1(425.41,290.83) ; 104.98,227.25 104.66,226.93 U17.2 ; UNK8U17.2 475.5,167.24 475.82,167.56 ; 475.82,199.31 475.5,198.99 UNK3U17.2 ; UNK2U17.2 104.66,195.18 104.98,195.5 ; CB9.1 v1(163.6,133.35) ; UNK4MR16.1 350.51,291.64 350.53,291.65 ; UNK6K29.1 v2(269.84,194.76) ; UNK7MR15.1 311.13,139.5 UNK7MR13.1 ; UNK7MR15.1 311.13,141.42 ; 271.13,141.42 271.14,141.43 UNK6MR16.1 ; 271.13,141.42 UNK6MR17.1 271.13,144.08 ; 475.82,231.06 475.5,230.74 UNK4U17.2 ; CB11.1 v1(158.71,290.83) ; UNK5K32.1 v2(237.83,175.59) ; 311.13,141.42 311.14,141.43 UNK7MR16.1 ; 311.13,141.42 UNK7MR17.1 311.13,144.08 ; 104.98,163.75 104.66,163.43 UNK5U17.2 ; CB1.1 v1(415.56,133.35) ; UNK8K29.1 v2(349.84,194.76) ; CB15.1 v1(22.84,295.91) ; 271.13,144.08 271.14,144.1 UNK6MR11.1 ; UNK7K29.1 v2(309.84,194.76) ; UNK5K29.1 v2(229.84,194.76) ; 311.13,144.08 UNK7MR12.1 311.13,146.13 311.64,146.64 UNK7MR14.2 ; 311.13,144.08 311.14,144.1 UNK7MR11.1 ; UNK4MR15.1 350.61,293.11 v1(352.37,293.11) v1(352.37,291.92) UNK4C280.1 UNK4C281.1 ; UNK4MR15.1 350.53,291.65 ; UNK4MR15.1 350.53,293.57 UNK4MR13.1 ; CB13.1 v1(20.34,133.35) ; CB5.1 v1(561.32,295.91) ; UNK7K32.1 v2(317.83,175.59) ; UNK3K32.1 v2(317.83,235.59) ; UNK3K29.1 v2(309.84,254.76) ; UNK2K32.1 v2(277.83,235.59) ; UNK2K29.1 v2(269.84,254.76) ; UNK4K29.1 v2(349.84,254.76) ; K32.1 v2(237.83,235.59)
  BOTTOM w0.584: v1(90.92,273.81) U405.9 ; U453.9 C1085.1 ; v1(515.83,225.16) U75.9 ; v1(73.21,268.71) U413.9 ; U77.9 v1(498.13,233.78) ; v1(90.92,260.1) U415.9 ; v1(73.21,296.14) U74.9 ; v1(73.21,282.43) U80.9 ; U72.9 v1(90.92,287.53)
  vias: v1(20.34,130.81) v1(22.84,298.45) v1(43.74,298.45) v1(83.74,288.59) v1(83.74,274.88) v1(83.74,261.16) v1(107.7,227.33) v1(107.7,195.58) v1(107.7,163.83) v1(107.7,132.08) v1(109.1,227.5) v1(109.1,195.75) v1(109.1,164) v1(109.1,132.25) v1(158.71,293.37) v1(163.6,130.81) v1(222.95,294.77) v1(238.71,138.3) v1(278.71,138.3) v1(318.71,138.3) v1(342.95,294.77) v1(358.71,138.3) v1(415.56,130.81) v1(425.41,293.37) v1(478.54,231.14) v1(478.54,199.39) v1(478.54,167.64) v1(478.54,135.89) v1(479.94,231.31) v1(479.94,199.56) v1(479.94,167.81) v1(479.94,136.06) v1(498.13,215.62) v1(558.82,130.81) v1(561.32,298.45) v2(79.1,291.94) v2(79.1,290.69) v2(79.1,278.23) v2(79.1,276.97) v2(79.1,264.51) v2(79.1,263.26) v2(84.7,292.77) v2(84.7,291.32) v2(84.7,289.86) v2(84.7,279.05) v2(84.7,277.6) v2(84.7,276.15) v2(84.7,265.34) v2(84.7,263.88) v2(84.7,262.43) v2(504.01,229.58) v2(504.01,228.32) v2(504.01,210.17) v2(509.62,230.4) v2(509.62,228.95) v2(509.62,227.5)
UT1_URW00: length 4.3
  TOP w0.254: UTL1.A01 158.1,13.32 UT1_SW1.8
UT1_URW01: length 6.9
  TOP w0.254: UT1_SW1.7 160.64,13.32 161.29,13.97 161.29,16.51 UTL1.B02
UT1_URW02: length 4.3
  TOP w0.254: UTL1.A03 163.18,13.32 UT1_SW1.6
UT1_URW03: length 6.9
  TOP w0.254: UT1_SW1.5 165.72,13.2 166.37,13.84 166.37,16.51 UTL1.B03
UT1_URW04: length 3.8
  TOP w0.254: UT1_SW1.4 168.26,14.62 UTL1.A04
UT1_URW05: length 6.9
  TOP w0.254: UTL1.B05 171.45,16.51 171.45,13.97 170.8,13.32 UT1_SW1.3
UT1_URW06: length 3.8
  TOP w0.254: UTL1.A06 172.72,13.84 173.34,13.22 UT1_SW1.2
UT1_UW07: length 7.4
  TOP w0.254: UTL1.B06 173.99,16.51 173.99,14.22 175.88,12.33 UT1_SW1.1
UT1_UW08: length 7.2
  TOP w0.254: UT1_SW2.8 180.33,12.84 179.7,13.46 177.04,13.46 UTL1.A07
UT1_UW09: length 11.5
  TOP w0.254: UT1_SW2.7 v1(182.87,10.05)
  L15_SIGNAL w0.203: v1(182.87,10.05) 179.07,13.84 179.07,16.51 UTL1.B08
UT1_UW10: length 7.3
  TOP w0.254: UTL1.A09 181.86,13.72 184.66,13.72 185.41,12.97 UT1_SW2.6
UT1_UW11: length 11.5
  TOP w0.254: UT1_SW2.5 v1(187.95,10.05)
  L15_SIGNAL w0.203: UTL1.B10 184.15,16.51 184.15,13.84 v1(187.95,10.05)
UT1_UW12: length 7.3
  TOP w0.254: UT1_SW2.4 190.49,12.97 189.99,13.46 187.2,13.46 UTL1.A11
UT1_UW13: length 11.5
  TOP w0.254: UT1_SW2.3 v1(193.03,10.05)
  L15_SIGNAL w0.203: UTL1.B12 189.23,16.51 189.23,13.84 v1(193.03,10.05)
UT1_UW14: length 34.2
  TOP w0.254: UT1_SW2.2 195.57,13.09 195.07,13.59 192.15,13.59 UTL1.A13
  L15_SIGNAL w0.203: v1(213.15,15.11) 212.15,14.11 191.63,14.11 UTL1.A13
  BOTTOM w0.203: v1(213.15,15.11) 213.41,14.86 216.33,14.86
UT1_UW15: length 37
  TOP w0.254: UT1_SW2.1 198.11,12.71 196.85,13.97 196.85,15.88 196.21,16.51 194.31,16.51 UTL1.B14
  L15_SIGNAL w0.203: v1(213.15,13.4) 214.07,14.32 214.07,15.59 213.18,16.49 194.33,16.49 UTL1.B14
  BOTTOM w0.203: 216.33,13.4 v1(213.15,13.4)
UT2_URW00: length 4.3
  TOP w0.254: UT2_SW1.8 305.42,13.32 UTL2.A01
UT2_URW01: length 6.9
  TOP w0.254: UT2_SW1.7 307.96,13.32 308.61,13.97 308.61,16.51 UTL2.B02
UT2_URW02: length 4.3
  TOP w0.254: UTL2.A03 310.5,13.32 UT2_SW1.6
UT2_URW03: length 6.9
  TOP w0.254: UTL2.B03 313.69,16.51 313.69,13.84 313.04,13.2 UT2_SW1.5
UT2_URW04: length 3.8
  TOP w0.254: UTL2.A04 315.58,14.62 UT2_SW1.4
UT2_URW05: length 6.9
  TOP w0.254: UT2_SW1.3 318.12,13.32 318.77,13.97 318.77,16.51 UTL2.B05
UT2_URW06: length 3.8
  TOP w0.254: UT2_SW1.2 320.66,13.22 320.04,13.84 UTL2.A06
UT2_UW07: length 7.4
  TOP w0.254: UTL2.B06 321.31,16.51 321.31,14.22 323.2,12.33 UT2_SW1.1
UT2_UW08: length 7.2
  TOP w0.254: UT2_SW2.8 327.65,12.84 327.02,13.46 324.36,13.46 UTL2.A07
UT2_UW09: length 11.5
  TOP w0.254: UT2_SW2.7 v1(330.19,10.05)
  L15_SIGNAL w0.203: UTL2.B08 326.39,16.51 326.39,13.84 v1(330.19,10.05)
UT2_UW10: length 7.3
  TOP w0.254: UT2_SW2.6 332.73,12.97 331.98,13.72 329.18,13.72 UTL2.A09
UT2_UW11: length 11.5
  TOP w0.254: UT2_SW2.5 v1(335.27,10.05)
  L15_SIGNAL w0.203: UTL2.B10 331.47,16.51 331.47,13.84 v1(335.27,10.05)
UT2_UW12: length 7.3
  TOP w0.254: UT2_SW2.4 337.81,12.97 337.31,13.46 334.52,13.46 UTL2.A11
UT2_UW13: length 11.5
  TOP w0.254: UT2_SW2.3 v1(340.35,10.05)
  L15_SIGNAL w0.203: v1(340.35,10.05) 336.55,13.84 336.55,16.51 UTL2.B12
UT2_UW14: length 7.4
  TOP w0.254: UT2_SW2.2 342.89,13.09 342.39,13.59 339.47,13.59 UTL2.A13
UT2_UW15: length 9.3
  TOP w0.254: UTL2.B14 341.63,16.51 343.53,16.51 344.17,15.88 344.17,13.97 345.43,12.71 UT2_SW2.1
UT3_URW00: length 4.3
  TOP w0.254: UTL3.A01 423.56,415.94 UT3_SW1.8
UT3_URW01: length 6.9
  TOP w0.254: UTL3.B02 420.37,412.75 420.37,415.29 421.02,415.94 UT3_SW1.7
UT3_URW02: length 4.3
  TOP w0.254: UT3_SW1.6 418.48,415.94 UTL3.A03
UT3_URW03: length 6.9
  TOP w0.254: UT3_SW1.5 415.94,416.06 415.29,415.42 415.29,412.75 UTL3.B03
UT3_URW04: length 3.8
  TOP w0.254: UTL3.A04 413.4,414.64 UT3_SW1.4
UT3_URW05: length 6.9
  TOP w0.254: UT3_SW1.3 410.86,415.94 410.21,415.29 410.21,412.75 UTL3.B05
UT3_URW06: length 3.8
  TOP w0.254: UT3_SW1.2 408.32,416.04 408.94,415.42 UTL3.A06
UT3_UW07: length 7.4
  TOP w0.254: UTL3.B06 407.67,412.75 407.67,415.04 405.78,416.93 UT3_SW1.1
UT3_UW08: length 7.2
  TOP w0.254: UTL3.A07 404.62,415.8 401.95,415.8 401.33,416.42 UT3_SW2.8
UT3_UW09: length 11.5
  TOP w0.254: UT3_SW2.7 v1(398.79,419.21)
  L15_SIGNAL w0.203: v1(398.79,419.21) 402.59,415.42 402.59,412.75 UTL3.B08
UT3_UW10: length 7.3
  TOP w0.254: UTL3.A09 399.8,415.54 397,415.54 396.25,416.29 UT3_SW2.6
UT3_UW11: length 11.5
  TOP w0.254: UT3_SW2.5 v1(393.71,419.21)
  L15_SIGNAL w0.203: UTL3.B10 397.51,412.75 397.51,415.42 v1(393.71,419.21)
UT3_UW12: length 7.3
  TOP w0.254: UTL3.A11 394.46,415.8 391.67,415.8 391.17,416.29 UT3_SW2.4
UT3_UW13: length 11.5
  TOP w0.254: UT3_SW2.3 v1(388.63,419.21)
  L15_SIGNAL w0.203: v1(388.63,419.21) 392.43,415.42 392.43,412.75 UTL3.B12
UT3_UW14: length 7.4
  TOP w0.254: UTL3.A13 389.51,415.67 386.59,415.67 386.09,416.17 UT3_SW2.2
UT3_UW15: length 9.3
  TOP w0.254: UT3_SW2.1 383.55,416.55 384.81,415.29 384.81,413.38 385.44,412.75 387.35,412.75 UTL3.B14
UT4_URW00: length 4.3
  TOP w0.254: UTL4.A01 276.24,415.94 UT4_SW1.8
UT4_URW01: length 6.9
  TOP w0.254: UT4_SW1.7 273.7,415.94 273.05,415.29 273.05,412.75 UTL4.B02
UT4_URW02: length 4.3
  TOP w0.254: UT4_SW1.6 271.16,415.94 UTL4.A03
UT4_URW03: length 6.9
  TOP w0.254: UT4_SW1.5 268.62,416.06 267.97,415.42 267.97,412.75 UTL4.B03
UT4_URW04: length 3.8
  TOP w0.254: UTL4.A04 266.08,414.64 UT4_SW1.4
UT4_URW05: length 6.9
  TOP w0.254: UTL4.B05 262.89,412.75 262.89,415.29 263.54,415.94 UT4_SW1.3
