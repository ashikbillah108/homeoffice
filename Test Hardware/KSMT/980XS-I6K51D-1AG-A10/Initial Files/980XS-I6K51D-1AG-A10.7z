# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Nets (continued)
S5_OUT_TX0_CH2_B_CASE-: UNK5R1103.1 UNK5U455.A6
S5_OUT_TX0_CH2_C_CASE: UNK5C1088.1 UNK5R1103.2 UNK5R1106.2
S5_OUT_TX0_CH3_ABC_CASE+: SITE5.E2(PAD_OUTP_TX0_CH[3]) UNK5U456.B2
S5_OUT_TX0_CH3_ABC_CASE-: SITE5.F2(PAD_OUTN_TX0_CH[3]) UNK5U456.B1
S5_OUT_TX0_CH3_B_CASE+: UNK5R1115.1 UNK5U456.B4
S5_OUT_TX0_CH3_B_CASE-: UNK5R1114.1 UNK5U456.A4
S5_OUT_TX0_CH3_C_CASE: UNK5C1093.1 UNK5R1114.2 UNK5R1115.2
S5_OUT_TX0_CH4_ABC_CASE+: SITE5.G1(PAD_OUTP_TX0_CH[4]) UNK5U456.D2
S5_OUT_TX0_CH4_ABC_CASE-: SITE5.G2(PAD_OUTN_TX0_CH[4]) UNK5U456.D1
S5_OUT_TX0_CH4_B_CASE+: UNK5R1110.1 UNK5U456.B5
S5_OUT_TX0_CH4_B_CASE-: UNK5R1111.1 UNK5U456.A5
S5_OUT_TX0_CH4_C_CASE: UNK5C1091.1 UNK5R1110.2 UNK5R1111.2
S5_PM_SAR_GPIO0: S5_VREF_OUT.1(TP) SITE5.A20(PAD_PM_SAR_GPIO0) UNK5K34.3 UNK5MK3.4
S5_PWR_F001: SITE5.F15(DVDD_NODIE) UNK5CA26.1 UNK5CA27.1 UNK5CC112.1 UNK5SA16.1 UNK5TP_DPS2.1
S5_PWR_F004: SITE5.E10(AVDD33_RTC) UNK5CA22.1 UNK5CA23.1 UNK5CC96.1 UNK5SA21.1 UNK5TP_DPS5.1
S5_PWR_F005: SITE5.G18(VDDP3318_PM) SITE5.N17(VDDP3318_P0) SITE5.P3(VDDP3318_P2) UNK5CA7.1 UNK5CA8.1 UNK5CC70.1 UNK5CC71.1 UNK5CC73.1 UNK5SA8.1 UNK5TP_DPS6.1
S5_PWR_F006: SITE5.T13(VDD2_DRAM[0]) SITE5.T14(VDD2_DRAM[1]) SITE5.U13(VDD2_DRAM[2]) UNK5CA24.1 UNK5CA25.1 UNK5CC101.1 UNK5CC103.1 UNK5CC105.1 UNK5SA9.1 UNK5TP_DPS7.1
S5_PWR_F007: SITE5.T10(VDDQ_DRAM[0]) SITE5.T11(VDDQ_DRAM[1]) SITE5.U11(VDDQ_DRAM[2]) UNK5CA36.1 UNK5CA37.1 UNK5CC211.1 UNK5CC212.1 UNK5CC213.1 UNK5SA23.1 UNK5TP_DPS8.1
S5_PWR_F008: SITE5.K19(AVDD18_XTAL) UNK5CA38.1 UNK5CA39.1 UNK5CC220.1 UNK5SA25.1 UNK5TP_DPS9.1
S5_PWR_GS001: UNK5SA15.2
S5_PWR_GS002: UNK5SA18.2
S5_PWR_GS003: UNK5SA20.2
S5_PWR_GS004: UNK5SA22.2
S5_PWR_GS005: UNK5SA7.2
S5_PWR_GS006: UNK5SA10.2
S5_PWR_GS007: UNK5SA24.2
S5_PWR_GS008: UNK5SA26.2
S5_PWR_M_F001: SITE5.F6(AVDDL_MIPI_RX) SITE5.F7(VDD_CPU[0]) SITE5.F8(VDD_CPU[1]) SITE5.G6(AVDDL_MIPI_TX) SITE5.G7(VDD_CPU[2]) SITE5.G8(VDD_CPU[3]) SITE5.G10(VDD[0]) SITE5.G11(VDD[1]) SITE5.H7(VDD_CPU[4]) SITE5.H8(VDD_CPU[5]) SITE5.H10(VDD[2]) SITE5.H11(VDD[3]) SITE5.H12(VDD[4]) SITE5.J10(VDD[5]) SITE5.J11(VDD[6]) SITE5.J12(VDD[7]) SITE5.J13(VDD[8]) SITE5.K10(VDD[9]) SITE5.K11(VDD[10]) SITE5.K12(VDD[11]) SITE5.K13(VDD[12]) UNK5CA1.1 UNK5CA2.1 UNK5CC1.1 UNK5CC2.1 UNK5CC3.1 UNK5CC4.1 UNK5CC5.1 UNK5CC6.1 UNK5CC7.1 UNK5CC8.1 UNK5CC9.1 UNK5CC12.1 UNK5CC13.1 UNK5CC14.1 UNK5CC15.1 UNK5CC16.1 UNK5CC130.1 UNK5CC214.1 UNK5CC215.1 UNK5CC216.1 UNK5CC217.1 UNK5CC218.1 UNK5CC219.1 UNK5K96.4 UNK5K96.9 UNK5SA1.1 UNK5TP_DPS1.1
S5_PWR_M_GS001: UNK5SA2.2
S5_PWR_M_S001: UNK5SA1.2
S5_PWR_S001: UNK5SA16.2
S5_PWR_S002: UNK5SA17.2
S5_PWR_S003: UNK5SA19.2
S5_PWR_S004: UNK5SA21.2
S5_PWR_S005: UNK5SA8.2
S5_PWR_S006: UNK5SA9.2
S5_PWR_S007: UNK5SA23.2
S5_PWR_S008: UNK5SA25.2
S5_SPI_CK_ABCD_CASE: SITE5.T22(PAD_SPI_CK) UNK5K2.6
S5_SPI_CK_B_CASE: UNK5K2.5 UNK5K3.6
S5_SPI_CK_C_CASE: UNK5K3.7 UNK5U18.7
S5_SPI_CK_D_CASE: UNK5K3.5 UNK5U19.6
S5_SPI_CZ_ABCD_CASE: SITE5.M21(PAD_SPI_CZ) UNK5K2.3
S5_SPI_CZ_B_CASE: UNK5K2.4 UNK5K3.3
S5_SPI_CZ_C_CASE: UNK5K3.2 UNK5R200.2 UNK5U18.1
S5_SPI_CZ_D_CASE: UNK5K3.4 UNK5R205.2 UNK5U19.1
S5_SPI_DI_ABCD_CASE: SITE5.R21(PAD_SPI_DI) UNK5K4.6
S5_SPI_DI_B_CASE: UNK5K4.5 UNK5K5.6
S5_SPI_DI_C_CASE: UNK5K5.7
S5_SPI_DI_D_CASE: UNK5K5.5 UNK5U19.5
S5_SPI_DO_ABCD_CASE: SITE5.P22(PAD_SPI_DO) UNK5K4.3
S5_SPI_DO_B_CASE: UNK5K4.4 UNK5K5.3
S5_SPI_DO_C_CASE: UNK5K5.2
S5_SPI_DO_D_CASE: UNK5K5.4 UNK5U19.2
S5_SPI_HLD_ABCD_CASE: SITE5.P21(PAD_SPI_HLD) UNK5K6.3
S5_SPI_HLD_B_CASE: UNK5K6.4 UNK5K7.3
S5_SPI_HLD_C_CASE: UNK5K7.2 UNK5R202.1
S5_SPI_HLD_D_CASE: UNK5K7.4 UNK5R206.1 UNK5U19.7
S5_SPI_WPZ_ABCD_CASE: SITE5.N21(PAD_SPI_WPZ) UNK5K6.6
S5_SPI_WPZ_B_CASE: UNK5K6.5 UNK5K7.6
S5_SPI_WPZ_C_CASE: UNK5K7.7 UNK5R203.2 UNK5U18.2
S5_SPI_WPZ_D_CASE: UNK5K7.5 UNK5R207.2 UNK5U19.3
S5_USB2_SEL0: UNK5R164.2 UNK5U31.6
S5_USB2_SEL1: UNK5R163.2 UNK5U31.5
S5_USB2_SELS: UNK5R165.2 UNK5U31.16
S5_USB_D_AB_CASE+: SITE5.J3(PAD_DP_USB) UNK5U31.10
S5_USB_D_AB_CASE-: SITE5.J2(PAD_DM_USB) UNK5U31.9
S5_USB_D_B_CASE+: UNK5R160.2 UNK5U31.8
S5_USB_D_B_CASE-: UNK5R161.2 UNK5U31.7
S5_USER_3V3: S5_USER_3V3.1 UNK5C334.1 UNK5C335.1 UNK5C336.2 UNK5C337.2 UNK5C338.2 UNK5C339.2 UNK5R200.1 UNK5R201.2 UNK5R202.2 UNK5R203.1 UNK5R204.2 UNK5R205.1 UNK5R206.2 UNK5R207.1 UNK5U17.3
S5_XTAL_24M_IN_ABC_CASE: SITE5.L22(PAD_XTAL_IN_24M) UNK5K32.3
S5_XTAL_24M_IN_B_CASE: UNK5K32.4 UNK5R135.1
S5_XTAL_24M_IN_C_CASE: UNK5C267.1 UNK5R135.2 UNK5R136.2 UNK5Y1.3
S5_XTAL_24M_OUT_ABC_CASE: SITE5.K21(PAD_XTAL_OUT_24M) UNK5K32.6
S5_XTAL_24M_OUT_B_CASE: UNK5K32.5 UNK5R137.1
S5_XTAL_24M_OUT_C_CASE: UNK5C268.1 UNK5R136.1 UNK5R137.2 UNK5Y1.1
S5_XTAL_IN_32K_A_CASE: UNK5K29.7 UNK5U449.7
S5_XTAL_IN_32K_ABCD_CASE: SITE5.B13(PAD_XTAL_IN_32K) UNK5K29.6
S5_XTAL_IN_32K_B_CASE: UNK5C271.1 UNK5K29.5 UNK5Y2.1
S5_XTAL_IN_32K_D_CASE: UNK5R923.1 UNK5R973.2 UNK5U449.2
S5_XTAL_OUT_32K_A_CASE: UNK5K29.2 UNK5U449.8
S5_XTAL_OUT_32K_ABCD_CASE: SITE5.A12(PAD_XTAL_OUT_32K) UNK5K29.3
S5_XTAL_OUT_32K_B_CASE: UNK5C272.1 UNK5K29.4 UNK5Y2.2
S5_XTAL_OUT_32K_D_CASE: UNK5R652.1 UNK5R973.1 UNK5U449.1
S6_0V5: UNK6C286.1 UNK6C288.1 UNK6MK1.4 UNK6MR2.2 UNK6MR3.1 UNK6MR4.1 UNK6MR5.1 UNK6MR6.1 UNK6MU3.3
S6_0V25: UNK6MK4.3 UNK6MR18.2 UNK6MR19.1
S6_0V75: UNK6C290.1 UNK6MK2.4 UNK6MR10.2 UNK6MU3.6
S6_1SPI_CK: UNK6K2.7
S6_1SPI_DI: UNK6K4.7
S6_1SPI_DO: UNK6K4.2
S6_1SPI_HLD: UNK6K6.2
S6_1SPI_WPZ: UNK6K6.7
S6_3V3_RX0_MIPI: UNK6BDB5.2 UNK6C922.2 UNK6R661.2 UNK6U408.A2 UNK6U408.J4
S6_3V3_RX1_MIPI: UNK6BDB6.2 UNK6C923.2 UNK6R663.2 UNK6U409.A2 UNK6U409.J4
S6_3V3_TX0_MIPI: UNK6BDB8.2 UNK6C1090.2 UNK6R1101.2 UNK6U455.A2 UNK6U455.J4
S6_3V3_TX1_MIPI: UNK6BDB7.2 UNK6C1089.2 UNK6R1098.2 UNK6U456.A2 UNK6U456.J4
S6_3V3_USB2_MUX: UNK6BD21.2 UNK6C262.1 UNK6U31.4
S6_3V3_XTAL32K: UNK6BD1728.2 UNK6C1074.1 UNK6R981.1 UNK6U449.10
S6_AWG_3SHARE+: K109.5 UNK6K34.4
S6_B_DCH001: SITE6.M18(VDDP18_LDO_P0) UNK6CC195.1
S6_B_DCH105: SITE6.C12(PAD_RTC_IO4)
S6_B_DCH106: SITE6.D13(PAD_RTC_IO5)
S6_DCH015: SITE6.N1(PAD_AUD_MICCM0)
S6_DCH016: SITE6.L1(PAD_AUD_MICCM1)
S6_DCH017: SITE6.L3(PAD_AUD_LINEOUT_RP)
S6_DCH018: SITE6.L4(PAD_AUD_LINEOUT_RN)
S6_DCH063: SITE6.A17(PAD_PM_SDIO_CLK)
S6_DCH064: SITE6.B16(PAD_PM_SDIO_CMD)
S6_DCH065: SITE6.A18(PAD_PM_SDIO_D0)
S6_DCH066: SITE6.B18(PAD_PM_SDIO_D1)
S6_DCH067: SITE6.B15(PAD_PM_SDIO_D2)
S6_DCH068: SITE6.A15(PAD_PM_SDIO_D3)
S6_DCH069: SITE6.B19(PAD_PM_SDIO_INT)
S6_DCH082: SITE6.D15(PAD_PM_FUART_CTS)
S6_DCH083: SITE6.D16(PAD_PM_FUART_RTS)
S6_DCH088: SITE6.G20(PAD_PM_PWM2)
S6_DCH089: SITE6.H20(PAD_PM_PWM3)
S6_DCH090: SITE6.A21(PAD_PM_SAR_GPIO1)
S6_DCH103: SITE6.E12(PAD_RTC_IO0)
S6_DCH104: SITE6.D12(PAD_RTC_IO1)
S6_DCH107: SITE6.E11(PAD_RESET)
S6_DCH108: UNK6K32.2
S6_DCH109: UNK6K32.7
S6_DCH110: UNK6U449.3
S6_DCH111: UNK6U449.4
S6_DPS3: SITE6.F4(VDDP18_P1) SITE6.F17(AVDD18_NODIE) SITE6.G5(AVDD18_MIPI_TX) SITE6.H4(AVDD18_USB) SITE6.J18(AVDD18_OTP) SITE6.L5(AVDD18_AUD) SITE6.R11(AVDD18_PLL_DDR) SITE6.R14(VDD1_DRAM[0]) SITE6.R15(VDD1_DRAM[1]) UNK6CA20.1 UNK6CA21.1 UNK6CC84.1 UNK6CC85.1 UNK6CC86.1 UNK6CC87.1 UNK6CC88.1 UNK6CC89.1 UNK6CC90.1 UNK6CC91.1 UNK6CC92.1 UNK6SA17.1 UNK6TP_DPS3.1
S6_DPS4: SITE6.H19(AVDD33_ETH) SITE6.J5(AVDD33_USB) UNK6CA34.1 UNK6CA35.1 UNK6CC182.1 UNK6CC202.1 UNK6SA19.1 UNK6TP_DPS4.1
S6_M_2V5: UNK6C284.1 UNK6C285.1 UNK6MR2.1 UNK6MU2.6
S6_M_3V2: UNK6C282.1 UNK6C283.1 UNK6C289.1 UNK6MR1.1 UNK6MU1.5 UNK6MU2.2 UNK6MU3.7
S6_MPDCH01: SITE6.D7(PAD_I2C1_SDA)
S6_MPDCH03+: UNK6U31.2
S6_MPDCH03-: UNK6U31.3
S6_MPDCH05: SITE6.E7(PAD_I2C1_SCL)
S6_MPDCH06: SITE6.T4(PAD_SD0_D1)
S6_MPDCH09: SITE6.E8(PAD_SR_RST0)
S6_MPDCH10: SITE6.D8(PAD_SR_MCLK0)
S6_MPDCH11: SITE6.T3(PAD_SD0_CDZ)
S6_MPDCH13: SITE6.U4(PAD_SD0_D0)
S6_MPDCH14: SITE6.U5(PAD_SD0_CLK)
S6_MPDCH15: SITE6.T6(PAD_SD0_CMD)
S6_MPDCH16: SITE6.U7(PAD_SD0_D3)
S6_MPDCH17: SITE6.T7(PAD_SD0_D2)
S6_MPDCH18: SITE6.U20(PAD_FUART_RX)
S6_MPDCH19: SITE6.U21(PAD_FUART_TX)
S6_MPDCH20: SITE6.U18(PAD_FUART_RTS)
S6_MPDCH21: SITE6.R2(PAD_GPIO0)
S6_MPDCH22: SITE6.P6(PAD_GPIO5)
S6_MPDCH23: SITE6.R3(PAD_GPIO1)
S6_MPDCH24: SITE6.T2(PAD_GPIO10)
S6_MPDCH25: SITE6.R1(PAD_GPIO8)
S6_MPDCH26: SITE6.T1(PAD_GPIO9)
S6_MPDCH27: SITE6.P7(PAD_GPIO6)
S6_MPDCH28: SITE6.P4(PAD_GPIO3)
S6_MPDCH29: SITE6.U2(PAD_GPIO11)
S6_MPDCH30: SITE6.R7(PAD_GPIO7)
S6_MPDCH32: UNK6K2.2
S6_MPDCH33: SITE6.L2(PAD_AUD_MICIN1)
S6_MPDCH34: SITE6.M3(PAD_AUD_VAG) UNK6C264.1
S6_MPDCH35: SITE6.N2(PAD_AUD_MICIN0)
S6_MPDCH36: SITE6.L20(PAD_I2C0_SDA)
S6_MPDCH37+: UNK6U408.B8
S6_MPDCH37-: UNK6U408.B9
S6_MPDCH38+: UNK6U455.B8
S6_MPDCH38-: UNK6U455.B9
S6_MPDCH39+: UNK6U408.D8
S6_MPDCH39-: UNK6U408.D9
S6_MPDCH40+: UNK6U455.D8
S6_MPDCH40-: UNK6U455.D9
S6_MPDCH41+: UNK6U408.E8
S6_MPDCH41-: UNK6U408.E9
S6_MPDCH42+: UNK6U455.E8
S6_MPDCH42-: UNK6U455.E9
S6_MPDCH43+: UNK6U409.B8
S6_MPDCH43-: UNK6U409.B9
S6_MPDCH44+: UNK6U456.B8
S6_MPDCH44-: UNK6U456.B9
S6_MPDCH45+: UNK6U409.D8
S6_MPDCH45-: UNK6U409.D9
S6_MPDCH46+: UNK6U456.D8
S6_MPDCH46-: UNK6U456.D9
S6_MPDCH47+: UNK6U409.E8
S6_MPDCH47-: UNK6U409.E9
S6_MPDCH49: SITE6.E5(PAD_SR_RST1)
S6_MPDCH50: SITE6.D5(PAD_SR_MCLK1)
S6_MPDCH51: SITE6.T18(PAD_FUART_CTS)
S6_MPDCH52: SITE6.T19(PAD_MSPI0_CZ)
S6_MPDCH53: SITE6.R4(PAD_GPIO2)
S6_MPDCH54: SITE6.P5(PAD_GPIO4)
S6_MPDCH55: SITE6.D4(PAD_I2C2_SCL)
S6_MPDCH56: SITE6.E4(PAD_I2C2_SDA)
S6_MPDCH57: SITE6.N19(PAD_MSPI0_CK)
S6_MPDCH58: SITE6.P19(PAD_MSPI0_DI)
S6_MPDCH59: SITE6.R19(PAD_MSPI0_DO)
S6_MPDCH60: SITE6.M20(PAD_I2C0_SCL)
S6_MPDCH61: SITE6.G21(PAD_PM_UART_RX)
S6_MPDCH62: SITE6.H22(PAD_PM_UART_TX)
S6_MPDCH63: SITE6.C19(PAD_PM_I2C_SDA)
S6_MPDCH64: SITE6.D19(PAD_PM_I2C_SCL)
S6_MPDCH65: SITE6.B22(PAD_PM_GPIO5)
S6_MPDCH66: SITE6.C22(PAD_PM_GPIO6)
S6_MPDCH68: SITE6.B21(PAD_PM_GPIO4)
S6_MPDCH69: SITE6.F19(PAD_PM_PWM1)
S6_MPDCH71: SITE6.H21(PAD_PM_GPIO11)
S6_MPDCH72: SITE6.E15(PAD_PM_FUART_RX)
S6_MPDCH73: SITE6.E18(PAD_PM_GPIO2)
S6_MPDCH74: SITE6.D18(PAD_PM_GPIO3)
S6_MPDCH75: SITE6.E22(PAD_PM_PSPI0_DO)
S6_MPDCH76: SITE6.F22(PAD_PM_PSPI0_DI)
S6_MPDCH77: SITE6.E19(PAD_PM_PWM0)
S6_MPDCH78: SITE6.C20(PAD_PM_UART2_RX)
S6_MPDCH79: SITE6.D20(PAD_PM_UART2_TX)
S6_MPDCH80: SITE6.E21(PAD_PM_PSPI0_CK)
S6_MPDCH81: SITE6.D21(PAD_PM_PSPI0_CZ)
S6_MPDCH84: SITE6.F21(PAD_PM_PSPI0_INT)
S6_MPDCH85: SITE6.E17(PAD_PM_GPIO1)
S6_MPDCH86: SITE6.C16(PAD_PM_GPIO0)
S6_MPDCH87: SITE6.E14(PAD_PM_FUART_TX)
S6_MPDCH88: UNK6K34.2
S6_MUX_3V3: UNK6BD21.1 UNK6BD1728.1 UNK6R234.2 UNK6R512.1 UNK6R1117.2 UNK6R1118.2 UNK6R1119.2
S6_OUT_RX0_CH0_ABC_CASE+: SITE6.B10(PAD_OUTP_RX0_CH[0]) UNK6U408.B2
S6_OUT_RX0_CH0_ABC_CASE-: SITE6.A10(PAD_OUTN_RX0_CH[0]) UNK6U408.B1
S6_OUT_RX0_CH0_B_CASE+: UNK6R647.1 UNK6U408.B4
S6_OUT_RX0_CH0_B_CASE-: UNK6R646.1 UNK6U408.A4
S6_OUT_RX0_CH0_C_CASE: UNK6C309.1 UNK6R646.2 UNK6R647.2
S6_OUT_RX0_CH1_ABC_CASE+: SITE6.B9(PAD_OUTP_RX0_CH[1]) UNK6U408.D2
S6_OUT_RX0_CH1_ABC_CASE-: SITE6.B8(PAD_OUTN_RX0_CH[1]) UNK6U408.D1
S6_OUT_RX0_CH1_B_CASE+: UNK6R168.1 UNK6U408.B5
S6_OUT_RX0_CH1_B_CASE-: UNK6R170.1 UNK6U408.A5
S6_OUT_RX0_CH1_C_CASE: UNK6C310.1 UNK6R168.2 UNK6R170.2
S6_OUT_RX0_CH2_ABC_CASE+: SITE6.A8(PAD_OUTP_RX0_CH[2]) UNK6U408.E2
S6_OUT_RX0_CH2_ABC_CASE-: SITE6.B7(PAD_OUTN_RX0_CH[2]) UNK6U408.E1
S6_OUT_RX0_CH2_B_CASE+: UNK6R176.1 UNK6U408.B6
S6_OUT_RX0_CH2_B_CASE-: UNK6R178.1 UNK6U408.A6
S6_OUT_RX0_CH2_C_CASE: UNK6C318.1 UNK6R176.2 UNK6R178.2
S6_OUT_RX0_CH3_ABC_CASE+: SITE6.B6(PAD_OUTP_RX0_CH[3]) UNK6U409.B2
S6_OUT_RX0_CH3_ABC_CASE-: SITE6.A6(PAD_OUTN_RX0_CH[3]) UNK6U409.B1
S6_OUT_RX0_CH3_B_CASE+: UNK6R1089.1 UNK6U409.B4
S6_OUT_RX0_CH3_B_CASE-: UNK6R1088.1 UNK6U409.A4
S6_OUT_RX0_CH3_C_CASE: UNK6C302.1 UNK6R1088.2 UNK6R1089.2
S6_OUT_RX0_CH4_ABC_CASE+: SITE6.B5(PAD_OUTP_RX0_CH[4]) UNK6U409.D2
S6_OUT_RX0_CH4_ABC_CASE-: SITE6.B4(PAD_OUTN_RX0_CH[4]) UNK6U409.D1
S6_OUT_RX0_CH4_B_CASE+: UNK6R180.1 UNK6U409.B5
S6_OUT_RX0_CH4_B_CASE-: UNK6R182.1 UNK6U409.A5
S6_OUT_RX0_CH4_C_CASE: UNK6C320.1 UNK6R180.2 UNK6R182.2
S6_OUT_RX0_CH5_ABC_CASE+: SITE6.A4(PAD_OUTP_RX0_CH[5]) UNK6U409.E2
S6_OUT_RX0_CH5_ABC_CASE-: SITE6.B3(PAD_OUTN_RX0_CH[5]) UNK6U409.E1
S6_OUT_RX0_CH5_B_CASE+: UNK6R666.1 UNK6U409.B6
S6_OUT_RX0_CH5_B_CASE-: UNK6R664.1 UNK6U409.A6
S6_OUT_RX0_CH5_C_CASE: UNK6C924.1 UNK6R664.2 UNK6R666.2
S6_OUT_TX0_CH0_ABC_CASE+: SITE6.A2(PAD_OUTP_TX0_CH[0]) UNK6U455.B2
S6_OUT_TX0_CH0_ABC_CASE-: SITE6.B1(PAD_OUTN_TX0_CH[0]) UNK6U455.B1
S6_OUT_TX0_CH0_B_CASE+: UNK6R1109.1 UNK6U455.B4
S6_OUT_TX0_CH0_B_CASE-: UNK6R1107.1 UNK6U455.A4
S6_OUT_TX0_CH0_C_CASE: UNK6C1086.1 UNK6R1107.2 UNK6R1109.2
S6_OUT_TX0_CH1_ABC_CASE+: SITE6.C1(PAD_OUTP_TX0_CH[1]) UNK6U455.D2
S6_OUT_TX0_CH1_ABC_CASE-: SITE6.C2(PAD_OUTN_TX0_CH[1]) UNK6U455.D1
S6_OUT_TX0_CH1_B_CASE+: UNK6R1099.1 UNK6U455.B5
S6_OUT_TX0_CH1_B_CASE-: UNK6R1100.1 UNK6U455.A5
S6_OUT_TX0_CH1_C_CASE: UNK6C1087.1 UNK6R1099.2 UNK6R1100.2
S6_OUT_TX0_CH2_ABC_CASE+: SITE6.D2(PAD_OUTP_TX0_CH[2]) UNK6U455.E2
S6_OUT_TX0_CH2_ABC_CASE-: SITE6.E1(PAD_OUTN_TX0_CH[2]) UNK6U455.E1
S6_OUT_TX0_CH2_B_CASE+: UNK6R1106.1 UNK6U455.B6
S6_OUT_TX0_CH2_B_CASE-: UNK6R1103.1 UNK6U455.A6
S6_OUT_TX0_CH2_C_CASE: UNK6C1088.1 UNK6R1103.2 UNK6R1106.2
S6_OUT_TX0_CH3_ABC_CASE+: SITE6.E2(PAD_OUTP_TX0_CH[3]) UNK6U456.B2
S6_OUT_TX0_CH3_ABC_CASE-: SITE6.F2(PAD_OUTN_TX0_CH[3]) UNK6U456.B1
S6_OUT_TX0_CH3_B_CASE+: UNK6R1115.1 UNK6U456.B4
S6_OUT_TX0_CH3_B_CASE-: UNK6R1114.1 UNK6U456.A4
S6_OUT_TX0_CH3_C_CASE: UNK6C1093.1 UNK6R1114.2 UNK6R1115.2
S6_OUT_TX0_CH4_ABC_CASE+: SITE6.G1(PAD_OUTP_TX0_CH[4]) UNK6U456.D2
S6_OUT_TX0_CH4_ABC_CASE-: SITE6.G2(PAD_OUTN_TX0_CH[4]) UNK6U456.D1
S6_OUT_TX0_CH4_B_CASE+: UNK6R1110.1 UNK6U456.B5
S6_OUT_TX0_CH4_B_CASE-: UNK6R1111.1 UNK6U456.A5
S6_OUT_TX0_CH4_C_CASE: UNK6C1091.1 UNK6R1110.2 UNK6R1111.2
S6_PM_SAR_GPIO0: S6_VREF_OUT.1(TP) SITE6.A20(PAD_PM_SAR_GPIO0) UNK6K34.3 UNK6MK3.4
S6_PWR_F001: SITE6.F15(DVDD_NODIE) UNK6CA26.1 UNK6CA27.1 UNK6CC112.1 UNK6SA16.1 UNK6TP_DPS2.1
S6_PWR_F004: SITE6.E10(AVDD33_RTC) UNK6CA22.1 UNK6CA23.1 UNK6CC96.1 UNK6SA21.1 UNK6TP_DPS5.1
S6_PWR_F005: SITE6.G18(VDDP3318_PM) SITE6.N17(VDDP3318_P0) SITE6.P3(VDDP3318_P2) UNK6CA7.1 UNK6CA8.1 UNK6CC70.1 UNK6CC71.1 UNK6CC73.1 UNK6SA8.1 UNK6TP_DPS6.1
S6_PWR_F006: SITE6.T13(VDD2_DRAM[0]) SITE6.T14(VDD2_DRAM[1]) SITE6.U13(VDD2_DRAM[2]) UNK6CA24.1 UNK6CA25.1 UNK6CC101.1 UNK6CC103.1 UNK6CC105.1 UNK6SA9.1 UNK6TP_DPS7.1
S6_PWR_F007: SITE6.T10(VDDQ_DRAM[0]) SITE6.T11(VDDQ_DRAM[1]) SITE6.U11(VDDQ_DRAM[2]) UNK6CA36.1 UNK6CA37.1 UNK6CC211.1 UNK6CC212.1 UNK6CC213.1 UNK6SA23.1 UNK6TP_DPS8.1
S6_PWR_F008: SITE6.K19(AVDD18_XTAL) UNK6CA38.1 UNK6CA39.1 UNK6CC220.1 UNK6SA25.1 UNK6TP_DPS9.1
S6_PWR_GS001: UNK6SA15.2
S6_PWR_GS002: UNK6SA18.2
S6_PWR_GS003: UNK6SA20.2
S6_PWR_GS004: UNK6SA22.2
S6_PWR_GS005: UNK6SA7.2
S6_PWR_GS006: UNK6SA10.2
S6_PWR_GS007: UNK6SA24.2
S6_PWR_GS008: UNK6SA26.2
S6_PWR_M_F001: SITE6.F6(AVDDL_MIPI_RX) SITE6.F7(VDD_CPU[0]) SITE6.F8(VDD_CPU[1]) SITE6.G6(AVDDL_MIPI_TX) SITE6.G7(VDD_CPU[2]) SITE6.G8(VDD_CPU[3]) SITE6.G10(VDD[0]) SITE6.G11(VDD[1]) SITE6.H7(VDD_CPU[4]) SITE6.H8(VDD_CPU[5]) SITE6.H10(VDD[2]) SITE6.H11(VDD[3]) SITE6.H12(VDD[4]) SITE6.J10(VDD[5]) SITE6.J11(VDD[6]) SITE6.J12(VDD[7]) SITE6.J13(VDD[8]) SITE6.K10(VDD[9]) SITE6.K11(VDD[10]) SITE6.K12(VDD[11]) SITE6.K13(VDD[12]) UNK6CA1.1 UNK6CA2.1 UNK6CC1.1 UNK6CC2.1 UNK6CC3.1 UNK6CC4.1 UNK6CC5.1 UNK6CC6.1 UNK6CC7.1 UNK6CC8.1 UNK6CC9.1 UNK6CC12.1 UNK6CC13.1 UNK6CC14.1 UNK6CC15.1 UNK6CC16.1 UNK6CC130.1 UNK6CC214.1 UNK6CC215.1 UNK6CC216.1 UNK6CC217.1 UNK6CC218.1 UNK6CC219.1 UNK6K96.4 UNK6K96.9 UNK6SA1.1 UNK6TP_DPS1.1
S6_PWR_M_GS001: UNK6SA2.2
S6_PWR_M_S001: UNK6SA1.2
S6_PWR_S001: UNK6SA16.2
S6_PWR_S002: UNK6SA17.2
S6_PWR_S003: UNK6SA19.2
S6_PWR_S004: UNK6SA21.2
S6_PWR_S005: UNK6SA8.2
S6_PWR_S006: UNK6SA9.2
S6_PWR_S007: UNK6SA23.2
S6_PWR_S008: UNK6SA25.2
S6_SPI_CK_ABCD_CASE: SITE6.T22(PAD_SPI_CK) UNK6K2.6
S6_SPI_CK_B_CASE: UNK6K2.5 UNK6K3.6
S6_SPI_CK_C_CASE: UNK6K3.7 UNK6U18.7
S6_SPI_CK_D_CASE: UNK6K3.5 UNK6U19.6
S6_SPI_CZ_ABCD_CASE: SITE6.M21(PAD_SPI_CZ) UNK6K2.3
S6_SPI_CZ_B_CASE: UNK6K2.4 UNK6K3.3
S6_SPI_CZ_C_CASE: UNK6K3.2 UNK6R200.2 UNK6U18.1
S6_SPI_CZ_D_CASE: UNK6K3.4 UNK6R205.2 UNK6U19.1
S6_SPI_DI_ABCD_CASE: SITE6.R21(PAD_SPI_DI) UNK6K4.6
S6_SPI_DI_B_CASE: UNK6K4.5 UNK6K5.6
S6_SPI_DI_C_CASE: UNK6K5.7
S6_SPI_DI_D_CASE: UNK6K5.5 UNK6U19.5
S6_SPI_DO_ABCD_CASE: SITE6.P22(PAD_SPI_DO) UNK6K4.3
S6_SPI_DO_B_CASE: UNK6K4.4 UNK6K5.3
S6_SPI_DO_C_CASE: UNK6K5.2
S6_SPI_DO_D_CASE: UNK6K5.4 UNK6U19.2
S6_SPI_HLD_ABCD_CASE: SITE6.P21(PAD_SPI_HLD) UNK6K6.3
S6_SPI_HLD_B_CASE: UNK6K6.4 UNK6K7.3
S6_SPI_HLD_C_CASE: UNK6K7.2 UNK6R202.1
S6_SPI_HLD_D_CASE: UNK6K7.4 UNK6R206.1 UNK6U19.7
S6_SPI_WPZ_ABCD_CASE: SITE6.N21(PAD_SPI_WPZ) UNK6K6.6
S6_SPI_WPZ_B_CASE: UNK6K6.5 UNK6K7.6
S6_SPI_WPZ_C_CASE: UNK6K7.7 UNK6R203.2 UNK6U18.2
S6_SPI_WPZ_D_CASE: UNK6K7.5 UNK6R207.2 UNK6U19.3
S6_USB2_SEL0: UNK6R164.2 UNK6U31.6
S6_USB2_SEL1: UNK6R163.2 UNK6U31.5
S6_USB2_SELS: UNK6R165.2 UNK6U31.16
S6_USB_D_AB_CASE+: SITE6.J3(PAD_DP_USB) UNK6U31.10
S6_USB_D_AB_CASE-: SITE6.J2(PAD_DM_USB) UNK6U31.9
S6_USB_D_B_CASE+: UNK6R160.2 UNK6U31.8
S6_USB_D_B_CASE-: UNK6R161.2 UNK6U31.7
S6_USER_3V3: S6_USER_3V3.1 UNK6C334.1 UNK6C335.1 UNK6C336.2 UNK6C337.2 UNK6C338.2 UNK6C339.2 UNK6R200.1 UNK6R201.2 UNK6R202.2 UNK6R203.1 UNK6R204.2 UNK6R205.1 UNK6R206.2 UNK6R207.1 UNK6U17.3
S6_XTAL_24M_IN_ABC_CASE: SITE6.L22(PAD_XTAL_IN_24M) UNK6K32.3
S6_XTAL_24M_IN_B_CASE: UNK6K32.4 UNK6R135.1
S6_XTAL_24M_IN_C_CASE: UNK6C267.1 UNK6R135.2 UNK6R136.2 UNK6Y1.3
S6_XTAL_24M_OUT_ABC_CASE: SITE6.K21(PAD_XTAL_OUT_24M) UNK6K32.6
S6_XTAL_24M_OUT_B_CASE: UNK6K32.5 UNK6R137.1
S6_XTAL_24M_OUT_C_CASE: UNK6C268.1 UNK6R136.1 UNK6R137.2 UNK6Y1.1
S6_XTAL_IN_32K_A_CASE: UNK6K29.7 UNK6U449.7
S6_XTAL_IN_32K_ABCD_CASE: SITE6.B13(PAD_XTAL_IN_32K) UNK6K29.6
S6_XTAL_IN_32K_B_CASE: UNK6C271.1 UNK6K29.5 UNK6Y2.1
S6_XTAL_IN_32K_D_CASE: UNK6R923.1 UNK6R973.2 UNK6U449.2
S6_XTAL_OUT_32K_A_CASE: UNK6K29.2 UNK6U449.8
S6_XTAL_OUT_32K_ABCD_CASE: SITE6.A12(PAD_XTAL_OUT_32K) UNK6K29.3
S6_XTAL_OUT_32K_B_CASE: UNK6C272.1 UNK6K29.4 UNK6Y2.2
S6_XTAL_OUT_32K_D_CASE: UNK6R652.1 UNK6R973.1 UNK6U449.1
S7_0V5: UNK7C286.1 UNK7C288.1 UNK7MK1.4 UNK7MR2.2 UNK7MR3.1 UNK7MR4.1 UNK7MR5.1 UNK7MR6.1 UNK7MU3.3
S7_0V25: UNK7MK4.3 UNK7MR18.2 UNK7MR19.1
S7_0V75: UNK7C290.1 UNK7MK2.4 UNK7MR10.2 UNK7MU3.6
S7_1SPI_CK: UNK7K2.7
S7_1SPI_DI: UNK7K4.7
S7_1SPI_DO: UNK7K4.2
S7_1SPI_HLD: UNK7K6.2
S7_1SPI_WPZ: UNK7K6.7
S7_3V3_RX0_MIPI: UNK7BDB5.2 UNK7C922.2 UNK7R661.2 UNK7U408.A2 UNK7U408.J4
S7_3V3_RX1_MIPI: UNK7BDB6.2 UNK7C923.2 UNK7R663.2 UNK7U409.A2 UNK7U409.J4
S7_3V3_TX0_MIPI: UNK7BDB8.2 UNK7C1090.2 UNK7R1101.2 UNK7U455.A2 UNK7U455.J4
S7_3V3_TX1_MIPI: UNK7BDB7.2 UNK7C1089.2 UNK7R1098.2 UNK7U456.A2 UNK7U456.J4
S7_3V3_USB2_MUX: UNK7BD21.2 UNK7C262.1 UNK7U31.4
S7_3V3_XTAL32K: UNK7BD1728.2 UNK7C1074.1 UNK7R981.1 UNK7U449.10
S7_AWG_3SHARE+: K110.4 UNK7K34.4
S7_B_DCH001: SITE7.M18(VDDP18_LDO_P0) UNK7CC195.1
S7_B_DCH105: SITE7.C12(PAD_RTC_IO4)
S7_B_DCH106: SITE7.D13(PAD_RTC_IO5)
S7_DCH015: SITE7.N1(PAD_AUD_MICCM0)
S7_DCH016: SITE7.L1(PAD_AUD_MICCM1)
S7_DCH017: SITE7.L3(PAD_AUD_LINEOUT_RP)
S7_DCH018: SITE7.L4(PAD_AUD_LINEOUT_RN)
S7_DCH063: SITE7.A17(PAD_PM_SDIO_CLK)
S7_DCH064: SITE7.B16(PAD_PM_SDIO_CMD)
S7_DCH065: SITE7.A18(PAD_PM_SDIO_D0)
S7_DCH066: SITE7.B18(PAD_PM_SDIO_D1)
S7_DCH067: SITE7.B15(PAD_PM_SDIO_D2)
S7_DCH068: SITE7.A15(PAD_PM_SDIO_D3)
S7_DCH069: SITE7.B19(PAD_PM_SDIO_INT)
S7_DCH082: SITE7.D15(PAD_PM_FUART_CTS)
S7_DCH083: SITE7.D16(PAD_PM_FUART_RTS)
S7_DCH088: SITE7.G20(PAD_PM_PWM2)
S7_DCH089: SITE7.H20(PAD_PM_PWM3)
S7_DCH090: SITE7.A21(PAD_PM_SAR_GPIO1)
S7_DCH103: SITE7.E12(PAD_RTC_IO0)
S7_DCH104: SITE7.D12(PAD_RTC_IO1)
S7_DCH107: SITE7.E11(PAD_RESET)
S7_DCH108: UNK7K32.2
S7_DCH109: UNK7K32.7
S7_DCH110: UNK7U449.3
S7_DCH111: UNK7U449.4
S7_DPS3: SITE7.F4(VDDP18_P1) SITE7.F17(AVDD18_NODIE) SITE7.G5(AVDD18_MIPI_TX) SITE7.H4(AVDD18_USB) SITE7.J18(AVDD18_OTP) SITE7.L5(AVDD18_AUD) SITE7.R11(AVDD18_PLL_DDR) SITE7.R14(VDD1_DRAM[0]) SITE7.R15(VDD1_DRAM[1]) UNK7CA20.1 UNK7CA21.1 UNK7CC84.1 UNK7CC85.1 UNK7CC86.1 UNK7CC87.1 UNK7CC88.1 UNK7CC89.1 UNK7CC90.1 UNK7CC91.1 UNK7CC92.1 UNK7SA17.1 UNK7TP_DPS3.1
S7_DPS4: SITE7.H19(AVDD33_ETH) SITE7.J5(AVDD33_USB) UNK7CA34.1 UNK7CA35.1 UNK7CC182.1 UNK7CC202.1 UNK7SA19.1 UNK7TP_DPS4.1
S7_M_2V5: UNK7C284.1 UNK7C285.1 UNK7MR2.1 UNK7MU2.6
S7_M_3V2: UNK7C282.1 UNK7C283.1 UNK7C289.1 UNK7MR1.1 UNK7MU1.5 UNK7MU2.2 UNK7MU3.7
S7_MPDCH01: SITE7.D7(PAD_I2C1_SDA)
S7_MPDCH03+: UNK7U31.2
S7_MPDCH03-: UNK7U31.3
S7_MPDCH05: SITE7.E7(PAD_I2C1_SCL)
S7_MPDCH06: SITE7.T4(PAD_SD0_D1)
S7_MPDCH09: SITE7.E8(PAD_SR_RST0)
S7_MPDCH10: SITE7.D8(PAD_SR_MCLK0)
S7_MPDCH11: SITE7.T3(PAD_SD0_CDZ)
S7_MPDCH13: SITE7.U4(PAD_SD0_D0)
S7_MPDCH14: SITE7.U5(PAD_SD0_CLK)
S7_MPDCH15: SITE7.T6(PAD_SD0_CMD)
S7_MPDCH16: SITE7.U7(PAD_SD0_D3)
S7_MPDCH17: SITE7.T7(PAD_SD0_D2)
S7_MPDCH18: SITE7.U20(PAD_FUART_RX)
S7_MPDCH19: SITE7.U21(PAD_FUART_TX)
S7_MPDCH20: SITE7.U18(PAD_FUART_RTS)
S7_MPDCH21: SITE7.R2(PAD_GPIO0)
S7_MPDCH22: SITE7.P6(PAD_GPIO5)
S7_MPDCH23: SITE7.R3(PAD_GPIO1)
S7_MPDCH24: SITE7.T2(PAD_GPIO10)
S7_MPDCH25: SITE7.R1(PAD_GPIO8)
S7_MPDCH26: SITE7.T1(PAD_GPIO9)
S7_MPDCH27: SITE7.P7(PAD_GPIO6)
S7_MPDCH28: SITE7.P4(PAD_GPIO3)
S7_MPDCH29: SITE7.U2(PAD_GPIO11)
S7_MPDCH30: SITE7.R7(PAD_GPIO7)
S7_MPDCH32: UNK7K2.2
S7_MPDCH33: SITE7.L2(PAD_AUD_MICIN1)
S7_MPDCH34: SITE7.M3(PAD_AUD_VAG) UNK7C264.1
S7_MPDCH35: SITE7.N2(PAD_AUD_MICIN0)
S7_MPDCH36: SITE7.L20(PAD_I2C0_SDA)
S7_MPDCH37+: UNK7U408.B8
S7_MPDCH37-: UNK7U408.B9
S7_MPDCH38+: UNK7U455.B8
S7_MPDCH38-: UNK7U455.B9
S7_MPDCH39+: UNK7U408.D8
S7_MPDCH39-: UNK7U408.D9
S7_MPDCH40+: UNK7U455.D8
S7_MPDCH40-: UNK7U455.D9
S7_MPDCH41+: UNK7U408.E8
S7_MPDCH41-: UNK7U408.E9
S7_MPDCH42+: UNK7U455.E8
S7_MPDCH42-: UNK7U455.E9
S7_MPDCH43+: UNK7U409.B8
S7_MPDCH43-: UNK7U409.B9
S7_MPDCH44+: UNK7U456.B8
S7_MPDCH44-: UNK7U456.B9
S7_MPDCH45+: UNK7U409.D8
S7_MPDCH45-: UNK7U409.D9
S7_MPDCH46+: UNK7U456.D8
S7_MPDCH46-: UNK7U456.D9
S7_MPDCH47+: UNK7U409.E8
S7_MPDCH47-: UNK7U409.E9
S7_MPDCH49: SITE7.E5(PAD_SR_RST1)
S7_MPDCH50: SITE7.D5(PAD_SR_MCLK1)
S7_MPDCH51: SITE7.T18(PAD_FUART_CTS)
S7_MPDCH52: SITE7.T19(PAD_MSPI0_CZ)
S7_MPDCH53: SITE7.R4(PAD_GPIO2)
S7_MPDCH54: SITE7.P5(PAD_GPIO4)
S7_MPDCH55: SITE7.D4(PAD_I2C2_SCL)
S7_MPDCH56: SITE7.E4(PAD_I2C2_SDA)
S7_MPDCH57: SITE7.N19(PAD_MSPI0_CK)
S7_MPDCH58: SITE7.P19(PAD_MSPI0_DI)
S7_MPDCH59: SITE7.R19(PAD_MSPI0_DO)
S7_MPDCH60: SITE7.M20(PAD_I2C0_SCL)
S7_MPDCH61: SITE7.G21(PAD_PM_UART_RX)
S7_MPDCH62: SITE7.H22(PAD_PM_UART_TX)
S7_MPDCH63: SITE7.C19(PAD_PM_I2C_SDA)
S7_MPDCH64: SITE7.D19(PAD_PM_I2C_SCL)
S7_MPDCH65: SITE7.B22(PAD_PM_GPIO5)
S7_MPDCH66: SITE7.C22(PAD_PM_GPIO6)
S7_MPDCH68: SITE7.B21(PAD_PM_GPIO4)
S7_MPDCH69: SITE7.F19(PAD_PM_PWM1)
S7_MPDCH71: SITE7.H21(PAD_PM_GPIO11)
S7_MPDCH72: SITE7.E15(PAD_PM_FUART_RX)
S7_MPDCH73: SITE7.E18(PAD_PM_GPIO2)
S7_MPDCH74: SITE7.D18(PAD_PM_GPIO3)
S7_MPDCH75: SITE7.E22(PAD_PM_PSPI0_DO)
S7_MPDCH76: SITE7.F22(PAD_PM_PSPI0_DI)
S7_MPDCH77: SITE7.E19(PAD_PM_PWM0)
S7_MPDCH78: SITE7.C20(PAD_PM_UART2_RX)
S7_MPDCH79: SITE7.D20(PAD_PM_UART2_TX)
S7_MPDCH80: SITE7.E21(PAD_PM_PSPI0_CK)
S7_MPDCH81: SITE7.D21(PAD_PM_PSPI0_CZ)
S7_MPDCH84: SITE7.F21(PAD_PM_PSPI0_INT)
S7_MPDCH85: SITE7.E17(PAD_PM_GPIO1)
S7_MPDCH86: SITE7.C16(PAD_PM_GPIO0)
S7_MPDCH87: SITE7.E14(PAD_PM_FUART_TX)
S7_MPDCH88: UNK7K34.2
S7_MUX_3V3: UNK7BD21.1 UNK7BD1728.1 UNK7R234.2 UNK7R512.1 UNK7R1117.2 UNK7R1118.2 UNK7R1119.2
S7_OUT_RX0_CH0_ABC_CASE+: SITE7.B10(PAD_OUTP_RX0_CH[0]) UNK7U408.B2
S7_OUT_RX0_CH0_ABC_CASE-: SITE7.A10(PAD_OUTN_RX0_CH[0]) UNK7U408.B1
S7_OUT_RX0_CH0_B_CASE+: UNK7R647.1 UNK7U408.B4
S7_OUT_RX0_CH0_B_CASE-: UNK7R646.1 UNK7U408.A4
S7_OUT_RX0_CH0_C_CASE: UNK7C309.1 UNK7R646.2 UNK7R647.2
S7_OUT_RX0_CH1_ABC_CASE+: SITE7.B9(PAD_OUTP_RX0_CH[1]) UNK7U408.D2
S7_OUT_RX0_CH1_ABC_CASE-: SITE7.B8(PAD_OUTN_RX0_CH[1]) UNK7U408.D1
S7_OUT_RX0_CH1_B_CASE+: UNK7R168.1 UNK7U408.B5
S7_OUT_RX0_CH1_B_CASE-: UNK7R170.1 UNK7U408.A5
S7_OUT_RX0_CH1_C_CASE: UNK7C310.1 UNK7R168.2 UNK7R170.2
S7_OUT_RX0_CH2_ABC_CASE+: SITE7.A8(PAD_OUTP_RX0_CH[2]) UNK7U408.E2
S7_OUT_RX0_CH2_ABC_CASE-: SITE7.B7(PAD_OUTN_RX0_CH[2]) UNK7U408.E1
S7_OUT_RX0_CH2_B_CASE+: UNK7R176.1 UNK7U408.B6
S7_OUT_RX0_CH2_B_CASE-: UNK7R178.1 UNK7U408.A6
S7_OUT_RX0_CH2_C_CASE: UNK7C318.1 UNK7R176.2 UNK7R178.2
S7_OUT_RX0_CH3_ABC_CASE+: SITE7.B6(PAD_OUTP_RX0_CH[3]) UNK7U409.B2
S7_OUT_RX0_CH3_ABC_CASE-: SITE7.A6(PAD_OUTN_RX0_CH[3]) UNK7U409.B1
S7_OUT_RX0_CH3_B_CASE+: UNK7R1089.1 UNK7U409.B4
S7_OUT_RX0_CH3_B_CASE-: UNK7R1088.1 UNK7U409.A4
S7_OUT_RX0_CH3_C_CASE: UNK7C302.1 UNK7R1088.2 UNK7R1089.2
S7_OUT_RX0_CH4_ABC_CASE+: SITE7.B5(PAD_OUTP_RX0_CH[4]) UNK7U409.D2
S7_OUT_RX0_CH4_ABC_CASE-: SITE7.B4(PAD_OUTN_RX0_CH[4]) UNK7U409.D1
S7_OUT_RX0_CH4_B_CASE+: UNK7R180.1 UNK7U409.B5
S7_OUT_RX0_CH4_B_CASE-: UNK7R182.1 UNK7U409.A5
S7_OUT_RX0_CH4_C_CASE: UNK7C320.1 UNK7R180.2 UNK7R182.2
S7_OUT_RX0_CH5_ABC_CASE+: SITE7.A4(PAD_OUTP_RX0_CH[5]) UNK7U409.E2
S7_OUT_RX0_CH5_ABC_CASE-: SITE7.B3(PAD_OUTN_RX0_CH[5]) UNK7U409.E1
S7_OUT_RX0_CH5_B_CASE+: UNK7R666.1 UNK7U409.B6
S7_OUT_RX0_CH5_B_CASE-: UNK7R664.1 UNK7U409.A6
S7_OUT_RX0_CH5_C_CASE: UNK7C924.1 UNK7R664.2 UNK7R666.2
S7_OUT_TX0_CH0_ABC_CASE+: SITE7.A2(PAD_OUTP_TX0_CH[0]) UNK7U455.B2
S7_OUT_TX0_CH0_ABC_CASE-: SITE7.B1(PAD_OUTN_TX0_CH[0]) UNK7U455.B1
S7_OUT_TX0_CH0_B_CASE+: UNK7R1109.1 UNK7U455.B4
S7_OUT_TX0_CH0_B_CASE-: UNK7R1107.1 UNK7U455.A4
S7_OUT_TX0_CH0_C_CASE: UNK7C1086.1 UNK7R1107.2 UNK7R1109.2
S7_OUT_TX0_CH1_ABC_CASE+: SITE7.C1(PAD_OUTP_TX0_CH[1]) UNK7U455.D2
S7_OUT_TX0_CH1_ABC_CASE-: SITE7.C2(PAD_OUTN_TX0_CH[1]) UNK7U455.D1
S7_OUT_TX0_CH1_B_CASE+: UNK7R1099.1 UNK7U455.B5
S7_OUT_TX0_CH1_B_CASE-: UNK7R1100.1 UNK7U455.A5
S7_OUT_TX0_CH1_C_CASE: UNK7C1087.1 UNK7R1099.2 UNK7R1100.2
S7_OUT_TX0_CH2_ABC_CASE+: SITE7.D2(PAD_OUTP_TX0_CH[2]) UNK7U455.E2
S7_OUT_TX0_CH2_ABC_CASE-: SITE7.E1(PAD_OUTN_TX0_CH[2]) UNK7U455.E1
S7_OUT_TX0_CH2_B_CASE+: UNK7R1106.1 UNK7U455.B6
S7_OUT_TX0_CH2_B_CASE-: UNK7R1103.1 UNK7U455.A6
S7_OUT_TX0_CH2_C_CASE: UNK7C1088.1 UNK7R1103.2 UNK7R1106.2
S7_OUT_TX0_CH3_ABC_CASE+: SITE7.E2(PAD_OUTP_TX0_CH[3]) UNK7U456.B2
S7_OUT_TX0_CH3_ABC_CASE-: SITE7.F2(PAD_OUTN_TX0_CH[3]) UNK7U456.B1
S7_OUT_TX0_CH3_B_CASE+: UNK7R1115.1 UNK7U456.B4
S7_OUT_TX0_CH3_B_CASE-: UNK7R1114.1 UNK7U456.A4
S7_OUT_TX0_CH3_C_CASE: UNK7C1093.1 UNK7R1114.2 UNK7R1115.2
S7_OUT_TX0_CH4_ABC_CASE+: SITE7.G1(PAD_OUTP_TX0_CH[4]) UNK7U456.D2
S7_OUT_TX0_CH4_ABC_CASE-: SITE7.G2(PAD_OUTN_TX0_CH[4]) UNK7U456.D1
S7_OUT_TX0_CH4_B_CASE+: UNK7R1110.1 UNK7U456.B5
S7_OUT_TX0_CH4_B_CASE-: UNK7R1111.1 UNK7U456.A5
S7_OUT_TX0_CH4_C_CASE: UNK7C1091.1 UNK7R1110.2 UNK7R1111.2
S7_PM_SAR_GPIO0: S7_VREF_OUT.1(TP) SITE7.A20(PAD_PM_SAR_GPIO0) UNK7K34.3 UNK7MK3.4
S7_PWR_F001: SITE7.F15(DVDD_NODIE) UNK7CA26.1 UNK7CA27.1 UNK7CC112.1 UNK7SA16.1 UNK7TP_DPS2.1
S7_PWR_F004: SITE7.E10(AVDD33_RTC) UNK7CA22.1 UNK7CA23.1 UNK7CC96.1 UNK7SA21.1 UNK7TP_DPS5.1
S7_PWR_F005: SITE7.G18(VDDP3318_PM) SITE7.N17(VDDP3318_P0) SITE7.P3(VDDP3318_P2) UNK7CA7.1 UNK7CA8.1 UNK7CC70.1 UNK7CC71.1 UNK7CC73.1 UNK7SA8.1 UNK7TP_DPS6.1
S7_PWR_F006: SITE7.T13(VDD2_DRAM[0]) SITE7.T14(VDD2_DRAM[1]) SITE7.U13(VDD2_DRAM[2]) UNK7CA24.1 UNK7CA25.1 UNK7CC101.1 UNK7CC103.1 UNK7CC105.1 UNK7SA9.1 UNK7TP_DPS7.1
S7_PWR_F007: SITE7.T10(VDDQ_DRAM[0]) SITE7.T11(VDDQ_DRAM[1]) SITE7.U11(VDDQ_DRAM[2]) UNK7CA36.1 UNK7CA37.1 UNK7CC211.1 UNK7CC212.1 UNK7CC213.1 UNK7SA23.1 UNK7TP_DPS8.1
S7_PWR_F008: SITE7.K19(AVDD18_XTAL) UNK7CA38.1 UNK7CA39.1 UNK7CC220.1 UNK7SA25.1 UNK7TP_DPS9.1
S7_PWR_GS001: UNK7SA15.2
S7_PWR_GS002: UNK7SA18.2
S7_PWR_GS003: UNK7SA20.2
S7_PWR_GS004: UNK7SA22.2
S7_PWR_GS005: UNK7SA7.2
S7_PWR_GS006: UNK7SA10.2
S7_PWR_GS007: UNK7SA24.2
S7_PWR_GS008: UNK7SA26.2
S7_PWR_M_F001: SITE7.F6(AVDDL_MIPI_RX) SITE7.F7(VDD_CPU[0]) SITE7.F8(VDD_CPU[1]) SITE7.G6(AVDDL_MIPI_TX) SITE7.G7(VDD_CPU[2]) SITE7.G8(VDD_CPU[3]) SITE7.G10(VDD[0]) SITE7.G11(VDD[1]) SITE7.H7(VDD_CPU[4]) SITE7.H8(VDD_CPU[5]) SITE7.H10(VDD[2]) SITE7.H11(VDD[3]) SITE7.H12(VDD[4]) SITE7.J10(VDD[5]) SITE7.J11(VDD[6]) SITE7.J12(VDD[7]) SITE7.J13(VDD[8]) SITE7.K10(VDD[9]) SITE7.K11(VDD[10]) SITE7.K12(VDD[11]) SITE7.K13(VDD[12]) UNK7CA1.1 UNK7CA2.1 UNK7CC1.1 UNK7CC2.1 UNK7CC3.1 UNK7CC4.1 UNK7CC5.1 UNK7CC6.1 UNK7CC7.1 UNK7CC8.1 UNK7CC9.1 UNK7CC12.1 UNK7CC13.1 UNK7CC14.1 UNK7CC15.1 UNK7CC16.1 UNK7CC130.1 UNK7CC214.1 UNK7CC215.1 UNK7CC216.1 UNK7CC217.1 UNK7CC218.1 UNK7CC219.1 UNK7K96.4 UNK7K96.9 UNK7SA1.1 UNK7TP_DPS1.1
S7_PWR_M_GS001: UNK7SA2.2
S7_PWR_M_S001: UNK7SA1.2
S7_PWR_S001: UNK7SA16.2
S7_PWR_S002: UNK7SA17.2
S7_PWR_S003: UNK7SA19.2
S7_PWR_S004: UNK7SA21.2
S7_PWR_S005: UNK7SA8.2
S7_PWR_S006: UNK7SA9.2
S7_PWR_S007: UNK7SA23.2
S7_PWR_S008: UNK7SA25.2
S7_SPI_CK_ABCD_CASE: SITE7.T22(PAD_SPI_CK) UNK7K2.6
S7_SPI_CK_B_CASE: UNK7K2.5 UNK7K3.6
S7_SPI_CK_C_CASE: UNK7K3.7 UNK7U18.7
S7_SPI_CK_D_CASE: UNK7K3.5 UNK7U19.6
S7_SPI_CZ_ABCD_CASE: SITE7.M21(PAD_SPI_CZ) UNK7K2.3
S7_SPI_CZ_B_CASE: UNK7K2.4 UNK7K3.3
S7_SPI_CZ_C_CASE: UNK7K3.2 UNK7R200.2 UNK7U18.1
S7_SPI_CZ_D_CASE: UNK7K3.4 UNK7R205.2 UNK7U19.1
S7_SPI_DI_ABCD_CASE: SITE7.R21(PAD_SPI_DI) UNK7K4.6
S7_SPI_DI_B_CASE: UNK7K4.5 UNK7K5.6
S7_SPI_DI_C_CASE: UNK7K5.7
S7_SPI_DI_D_CASE: UNK7K5.5 UNK7U19.5
S7_SPI_DO_ABCD_CASE: SITE7.P22(PAD_SPI_DO) UNK7K4.3
S7_SPI_DO_B_CASE: UNK7K4.4 UNK7K5.3
S7_SPI_DO_C_CASE: UNK7K5.2
S7_SPI_DO_D_CASE: UNK7K5.4 UNK7U19.2
S7_SPI_HLD_ABCD_CASE: SITE7.P21(PAD_SPI_HLD) UNK7K6.3
S7_SPI_HLD_B_CASE: UNK7K6.4 UNK7K7.3
S7_SPI_HLD_C_CASE: UNK7K7.2 UNK7R202.1
S7_SPI_HLD_D_CASE: UNK7K7.4 UNK7R206.1 UNK7U19.7
S7_SPI_WPZ_ABCD_CASE: SITE7.N21(PAD_SPI_WPZ) UNK7K6.6
S7_SPI_WPZ_B_CASE: UNK7K6.5 UNK7K7.6
S7_SPI_WPZ_C_CASE: UNK7K7.7 UNK7R203.2 UNK7U18.2
S7_SPI_WPZ_D_CASE: UNK7K7.5 UNK7R207.2 UNK7U19.3
S7_USB2_SEL0: UNK7R164.2 UNK7U31.6
S7_USB2_SEL1: UNK7R163.2 UNK7U31.5
S7_USB2_SELS: UNK7R165.2 UNK7U31.16
S7_USB_D_AB_CASE+: SITE7.J3(PAD_DP_USB) UNK7U31.10
S7_USB_D_AB_CASE-: SITE7.J2(PAD_DM_USB) UNK7U31.9
S7_USB_D_B_CASE+: UNK7R160.2 UNK7U31.8
S7_USB_D_B_CASE-: UNK7R161.2 UNK7U31.7
S7_USER_3V3: S7_USER_3V3.1 UNK7C334.1 UNK7C335.1 UNK7C336.2 UNK7C337.2 UNK7C338.2 UNK7C339.2 UNK7R200.1 UNK7R201.2 UNK7R202.2 UNK7R203.1 UNK7R204.2 UNK7R205.1 UNK7R206.2 UNK7R207.1 UNK7U17.3
S7_XTAL_24M_IN_ABC_CASE: SITE7.L22(PAD_XTAL_IN_24M) UNK7K32.3
S7_XTAL_24M_IN_B_CASE: UNK7K32.4 UNK7R135.1
S7_XTAL_24M_IN_C_CASE: UNK7C267.1 UNK7R135.2 UNK7R136.2 UNK7Y1.3
S7_XTAL_24M_OUT_ABC_CASE: SITE7.K21(PAD_XTAL_OUT_24M) UNK7K32.6
S7_XTAL_24M_OUT_B_CASE: UNK7K32.5 UNK7R137.1
S7_XTAL_24M_OUT_C_CASE: UNK7C268.1 UNK7R136.1 UNK7R137.2 UNK7Y1.1
S7_XTAL_IN_32K_A_CASE: UNK7K29.7 UNK7U449.7
S7_XTAL_IN_32K_ABCD_CASE: SITE7.B13(PAD_XTAL_IN_32K) UNK7K29.6
S7_XTAL_IN_32K_B_CASE: UNK7C271.1 UNK7K29.5 UNK7Y2.1
S7_XTAL_IN_32K_D_CASE: UNK7R923.1 UNK7R973.2 UNK7U449.2
S7_XTAL_OUT_32K_A_CASE: UNK7K29.2 UNK7U449.8
S7_XTAL_OUT_32K_ABCD_CASE: SITE7.A12(PAD_XTAL_OUT_32K) UNK7K29.3
S7_XTAL_OUT_32K_B_CASE: UNK7C272.1 UNK7K29.4 UNK7Y2.2
S7_XTAL_OUT_32K_D_CASE: UNK7R652.1 UNK7R973.1 UNK7U449.1
S8_0V5: UNK8C286.1 UNK8C288.1 UNK8MK1.4 UNK8MR2.2 UNK8MR3.1 UNK8MR4.1 UNK8MR5.1 UNK8MR6.1 UNK8MU3.3
S8_0V25: UNK8MK4.3 UNK8MR18.2 UNK8MR19.1
S8_0V75: UNK8C290.1 UNK8MK2.4 UNK8MR10.2 UNK8MU3.6
S8_1SPI_CK: UNK8K2.7
S8_1SPI_DI: UNK8K4.7
S8_1SPI_DO: UNK8K4.2
S8_1SPI_HLD: UNK8K6.2
S8_1SPI_WPZ: UNK8K6.7
S8_3V3_RX0_MIPI: UNK8BDB5.2 UNK8C922.2 UNK8R661.2 UNK8U408.A2 UNK8U408.J4
S8_3V3_RX1_MIPI: UNK8BDB6.2 UNK8C923.2 UNK8R663.2 UNK8U409.A2 UNK8U409.J4
S8_3V3_TX0_MIPI: UNK8BDB8.2 UNK8C1090.2 UNK8R1101.2 UNK8U455.A2 UNK8U455.J4
S8_3V3_TX1_MIPI: UNK8BDB7.2 UNK8C1089.2 UNK8R1098.2 UNK8U456.A2 UNK8U456.J4
S8_3V3_USB2_MUX: UNK8BD21.2 UNK8C262.1 UNK8U31.4
S8_3V3_XTAL32K: UNK8BD1728.2 UNK8C1074.1 UNK8R981.1 UNK8U449.10
S8_AWG_3SHARE+: K110.5 UNK8K34.4
S8_B_DCH001: SITE8.M18(VDDP18_LDO_P0) UNK8CC195.1
S8_B_DCH105: SITE8.C12(PAD_RTC_IO4)
S8_B_DCH106: SITE8.D13(PAD_RTC_IO5)
S8_DCH015: SITE8.N1(PAD_AUD_MICCM0)
S8_DCH016: SITE8.L1(PAD_AUD_MICCM1)
S8_DCH017: SITE8.L3(PAD_AUD_LINEOUT_RP)
S8_DCH018: SITE8.L4(PAD_AUD_LINEOUT_RN)
S8_DCH063: SITE8.A17(PAD_PM_SDIO_CLK)
S8_DCH064: SITE8.B16(PAD_PM_SDIO_CMD)
S8_DCH065: SITE8.A18(PAD_PM_SDIO_D0)
S8_DCH066: SITE8.B18(PAD_PM_SDIO_D1)
S8_DCH067: SITE8.B15(PAD_PM_SDIO_D2)
S8_DCH068: SITE8.A15(PAD_PM_SDIO_D3)
S8_DCH069: SITE8.B19(PAD_PM_SDIO_INT)
S8_DCH082: SITE8.D15(PAD_PM_FUART_CTS)
S8_DCH083: SITE8.D16(PAD_PM_FUART_RTS)
S8_DCH088: SITE8.G20(PAD_PM_PWM2)
S8_DCH089: SITE8.H20(PAD_PM_PWM3)
S8_DCH090: SITE8.A21(PAD_PM_SAR_GPIO1)
S8_DCH103: SITE8.E12(PAD_RTC_IO0)
S8_DCH104: SITE8.D12(PAD_RTC_IO1)
S8_DCH107: SITE8.E11(PAD_RESET)
S8_DCH108: UNK8K32.2
S8_DCH109: UNK8K32.7
S8_DCH110: UNK8U449.3
S8_DCH111: UNK8U449.4
S8_DPS3: SITE8.F4(VDDP18_P1) SITE8.F17(AVDD18_NODIE) SITE8.G5(AVDD18_MIPI_TX) SITE8.H4(AVDD18_USB) SITE8.J18(AVDD18_OTP) SITE8.L5(AVDD18_AUD) SITE8.R11(AVDD18_PLL_DDR) SITE8.R14(VDD1_DRAM[0]) SITE8.R15(VDD1_DRAM[1]) UNK8CA20.1 UNK8CA21.1 UNK8CC84.1 UNK8CC85.1 UNK8CC86.1 UNK8CC87.1 UNK8CC88.1 UNK8CC89.1 UNK8CC90.1 UNK8CC91.1 UNK8CC92.1 UNK8SA17.1 UNK8TP_DPS3.1
S8_DPS4: SITE8.H19(AVDD33_ETH) SITE8.J5(AVDD33_USB) UNK8CA34.1 UNK8CA35.1 UNK8CC182.1 UNK8CC202.1 UNK8SA19.1 UNK8TP_DPS4.1
S8_M_2V5: UNK8C284.1 UNK8C285.1 UNK8MR2.1 UNK8MU2.6
S8_M_3V2: UNK8C282.1 UNK8C283.1 UNK8C289.1 UNK8MR1.1 UNK8MU1.5 UNK8MU2.2 UNK8MU3.7
S8_MPDCH01: SITE8.D7(PAD_I2C1_SDA)
S8_MPDCH03+: UNK8U31.2
S8_MPDCH03-: UNK8U31.3
S8_MPDCH05: SITE8.E7(PAD_I2C1_SCL)
S8_MPDCH06: SITE8.T4(PAD_SD0_D1)
S8_MPDCH09: SITE8.E8(PAD_SR_RST0)
S8_MPDCH10: SITE8.D8(PAD_SR_MCLK0)
S8_MPDCH11: SITE8.T3(PAD_SD0_CDZ)
S8_MPDCH13: SITE8.U4(PAD_SD0_D0)
S8_MPDCH14: SITE8.U5(PAD_SD0_CLK)
S8_MPDCH15: SITE8.T6(PAD_SD0_CMD)
S8_MPDCH16: SITE8.U7(PAD_SD0_D3)
S8_MPDCH17: SITE8.T7(PAD_SD0_D2)
S8_MPDCH18: SITE8.U20(PAD_FUART_RX)
S8_MPDCH19: SITE8.U21(PAD_FUART_TX)
S8_MPDCH20: SITE8.U18(PAD_FUART_RTS)
S8_MPDCH21: SITE8.R2(PAD_GPIO0)
S8_MPDCH22: SITE8.P6(PAD_GPIO5)
S8_MPDCH23: SITE8.R3(PAD_GPIO1)
S8_MPDCH24: SITE8.T2(PAD_GPIO10)
S8_MPDCH25: SITE8.R1(PAD_GPIO8)
S8_MPDCH26: SITE8.T1(PAD_GPIO9)
S8_MPDCH27: SITE8.P7(PAD_GPIO6)
S8_MPDCH28: SITE8.P4(PAD_GPIO3)
S8_MPDCH29: SITE8.U2(PAD_GPIO11)
S8_MPDCH30: SITE8.R7(PAD_GPIO7)
S8_MPDCH32: UNK8K2.2
S8_MPDCH33: SITE8.L2(PAD_AUD_MICIN1)
S8_MPDCH34: SITE8.M3(PAD_AUD_VAG) UNK8C264.1
S8_MPDCH35: SITE8.N2(PAD_AUD_MICIN0)
S8_MPDCH36: SITE8.L20(PAD_I2C0_SDA)
S8_MPDCH37+: UNK8U408.B8
S8_MPDCH37-: UNK8U408.B9
S8_MPDCH38+: UNK8U455.B8
S8_MPDCH38-: UNK8U455.B9
S8_MPDCH39+: UNK8U408.D8
S8_MPDCH39-: UNK8U408.D9
S8_MPDCH40+: UNK8U455.D8
S8_MPDCH40-: UNK8U455.D9
S8_MPDCH41+: UNK8U408.E8
S8_MPDCH41-: UNK8U408.E9
S8_MPDCH42+: UNK8U455.E8
S8_MPDCH42-: UNK8U455.E9
S8_MPDCH43+: UNK8U409.B8
S8_MPDCH43-: UNK8U409.B9
S8_MPDCH44+: UNK8U456.B8
S8_MPDCH44-: UNK8U456.B9
S8_MPDCH45+: UNK8U409.D8
S8_MPDCH45-: UNK8U409.D9
S8_MPDCH46+: UNK8U456.D8
S8_MPDCH46-: UNK8U456.D9
S8_MPDCH47+: UNK8U409.E8
S8_MPDCH47-: UNK8U409.E9
S8_MPDCH49: SITE8.E5(PAD_SR_RST1)
S8_MPDCH50: SITE8.D5(PAD_SR_MCLK1)
S8_MPDCH51: SITE8.T18(PAD_FUART_CTS)
S8_MPDCH52: SITE8.T19(PAD_MSPI0_CZ)
S8_MPDCH53: SITE8.R4(PAD_GPIO2)
S8_MPDCH54: SITE8.P5(PAD_GPIO4)
S8_MPDCH55: SITE8.D4(PAD_I2C2_SCL)
S8_MPDCH56: SITE8.E4(PAD_I2C2_SDA)
S8_MPDCH57: SITE8.N19(PAD_MSPI0_CK)
S8_MPDCH58: SITE8.P19(PAD_MSPI0_DI)
S8_MPDCH59: SITE8.R19(PAD_MSPI0_DO)
S8_MPDCH60: SITE8.M20(PAD_I2C0_SCL)
S8_MPDCH61: SITE8.G21(PAD_PM_UART_RX)
S8_MPDCH62: SITE8.H22(PAD_PM_UART_TX)
S8_MPDCH63: SITE8.C19(PAD_PM_I2C_SDA)
S8_MPDCH64: SITE8.D19(PAD_PM_I2C_SCL)
S8_MPDCH65: SITE8.B22(PAD_PM_GPIO5)
S8_MPDCH66: SITE8.C22(PAD_PM_GPIO6)
S8_MPDCH68: SITE8.B21(PAD_PM_GPIO4)
S8_MPDCH69: SITE8.F19(PAD_PM_PWM1)
S8_MPDCH71: SITE8.H21(PAD_PM_GPIO11)
S8_MPDCH72: SITE8.E15(PAD_PM_FUART_RX)
S8_MPDCH73: SITE8.E18(PAD_PM_GPIO2)
S8_MPDCH74: SITE8.D18(PAD_PM_GPIO3)
S8_MPDCH75: SITE8.E22(PAD_PM_PSPI0_DO)
S8_MPDCH76: SITE8.F22(PAD_PM_PSPI0_DI)
S8_MPDCH77: SITE8.E19(PAD_PM_PWM0)
S8_MPDCH78: SITE8.C20(PAD_PM_UART2_RX)
S8_MPDCH79: SITE8.D20(PAD_PM_UART2_TX)
S8_MPDCH80: SITE8.E21(PAD_PM_PSPI0_CK)
S8_MPDCH81: SITE8.D21(PAD_PM_PSPI0_CZ)
S8_MPDCH84: SITE8.F21(PAD_PM_PSPI0_INT)
S8_MPDCH85: SITE8.E17(PAD_PM_GPIO1)
S8_MPDCH86: SITE8.C16(PAD_PM_GPIO0)
S8_MPDCH87: SITE8.E14(PAD_PM_FUART_TX)
S8_MPDCH88: UNK8K34.2
S8_MUX_3V3: UNK8BD21.1 UNK8BD1728.1 UNK8R234.2 UNK8R512.1 UNK8R1117.2 UNK8R1118.2 UNK8R1119.2
S8_OUT_RX0_CH0_ABC_CASE+: SITE8.B10(PAD_OUTP_RX0_CH[0]) UNK8U408.B2
S8_OUT_RX0_CH0_ABC_CASE-: SITE8.A10(PAD_OUTN_RX0_CH[0]) UNK8U408.B1
S8_OUT_RX0_CH0_B_CASE+: UNK8R647.1 UNK8U408.B4
S8_OUT_RX0_CH0_B_CASE-: UNK8R646.1 UNK8U408.A4
S8_OUT_RX0_CH0_C_CASE: UNK8C309.1 UNK8R646.2 UNK8R647.2
S8_OUT_RX0_CH1_ABC_CASE+: SITE8.B9(PAD_OUTP_RX0_CH[1]) UNK8U408.D2
S8_OUT_RX0_CH1_ABC_CASE-: SITE8.B8(PAD_OUTN_RX0_CH[1]) UNK8U408.D1
S8_OUT_RX0_CH1_B_CASE+: UNK8R168.1 UNK8U408.B5
S8_OUT_RX0_CH1_B_CASE-: UNK8R170.1 UNK8U408.A5
S8_OUT_RX0_CH1_C_CASE: UNK8C310.1 UNK8R168.2 UNK8R170.2
S8_OUT_RX0_CH2_ABC_CASE+: SITE8.A8(PAD_OUTP_RX0_CH[2]) UNK8U408.E2
S8_OUT_RX0_CH2_ABC_CASE-: SITE8.B7(PAD_OUTN_RX0_CH[2]) UNK8U408.E1
S8_OUT_RX0_CH2_B_CASE+: UNK8R176.1 UNK8U408.B6
S8_OUT_RX0_CH2_B_CASE-: UNK8R178.1 UNK8U408.A6
S8_OUT_RX0_CH2_C_CASE: UNK8C318.1 UNK8R176.2 UNK8R178.2
S8_OUT_RX0_CH3_ABC_CASE+: SITE8.B6(PAD_OUTP_RX0_CH[3]) UNK8U409.B2
S8_OUT_RX0_CH3_ABC_CASE-: SITE8.A6(PAD_OUTN_RX0_CH[3]) UNK8U409.B1
S8_OUT_RX0_CH3_B_CASE+: UNK8R1089.1 UNK8U409.B4
S8_OUT_RX0_CH3_B_CASE-: UNK8R1088.1 UNK8U409.A4
S8_OUT_RX0_CH3_C_CASE: UNK8C302.1 UNK8R1088.2 UNK8R1089.2
S8_OUT_RX0_CH4_ABC_CASE+: SITE8.B5(PAD_OUTP_RX0_CH[4]) UNK8U409.D2
S8_OUT_RX0_CH4_ABC_CASE-: SITE8.B4(PAD_OUTN_RX0_CH[4]) UNK8U409.D1
S8_OUT_RX0_CH4_B_CASE+: UNK8R180.1 UNK8U409.B5
S8_OUT_RX0_CH4_B_CASE-: UNK8R182.1 UNK8U409.A5
S8_OUT_RX0_CH4_C_CASE: UNK8C320.1 UNK8R180.2 UNK8R182.2
S8_OUT_RX0_CH5_ABC_CASE+: SITE8.A4(PAD_OUTP_RX0_CH[5]) UNK8U409.E2
S8_OUT_RX0_CH5_ABC_CASE-: SITE8.B3(PAD_OUTN_RX0_CH[5]) UNK8U409.E1
S8_OUT_RX0_CH5_B_CASE+: UNK8R666.1 UNK8U409.B6
S8_OUT_RX0_CH5_B_CASE-: UNK8R664.1 UNK8U409.A6
S8_OUT_RX0_CH5_C_CASE: UNK8C924.1 UNK8R664.2 UNK8R666.2
S8_OUT_TX0_CH0_ABC_CASE+: SITE8.A2(PAD_OUTP_TX0_CH[0]) UNK8U455.B2
S8_OUT_TX0_CH0_ABC_CASE-: SITE8.B1(PAD_OUTN_TX0_CH[0]) UNK8U455.B1
S8_OUT_TX0_CH0_B_CASE+: UNK8R1109.1 UNK8U455.B4
S8_OUT_TX0_CH0_B_CASE-: UNK8R1107.1 UNK8U455.A4
S8_OUT_TX0_CH0_C_CASE: UNK8C1086.1 UNK8R1107.2 UNK8R1109.2
S8_OUT_TX0_CH1_ABC_CASE+: SITE8.C1(PAD_OUTP_TX0_CH[1]) UNK8U455.D2
S8_OUT_TX0_CH1_ABC_CASE-: SITE8.C2(PAD_OUTN_TX0_CH[1]) UNK8U455.D1
S8_OUT_TX0_CH1_B_CASE+: UNK8R1099.1 UNK8U455.B5
S8_OUT_TX0_CH1_B_CASE-: UNK8R1100.1 UNK8U455.A5
S8_OUT_TX0_CH1_C_CASE: UNK8C1087.1 UNK8R1099.2 UNK8R1100.2
S8_OUT_TX0_CH2_ABC_CASE+: SITE8.D2(PAD_OUTP_TX0_CH[2]) UNK8U455.E2
S8_OUT_TX0_CH2_ABC_CASE-: SITE8.E1(PAD_OUTN_TX0_CH[2]) UNK8U455.E1
S8_OUT_TX0_CH2_B_CASE+: UNK8R1106.1 UNK8U455.B6
S8_OUT_TX0_CH2_B_CASE-: UNK8R1103.1 UNK8U455.A6
S8_OUT_TX0_CH2_C_CASE: UNK8C1088.1 UNK8R1103.2 UNK8R1106.2
S8_OUT_TX0_CH3_ABC_CASE+: SITE8.E2(PAD_OUTP_TX0_CH[3]) UNK8U456.B2
S8_OUT_TX0_CH3_ABC_CASE-: SITE8.F2(PAD_OUTN_TX0_CH[3]) UNK8U456.B1
S8_OUT_TX0_CH3_B_CASE+: UNK8R1115.1 UNK8U456.B4
S8_OUT_TX0_CH3_B_CASE-: UNK8R1114.1 UNK8U456.A4
S8_OUT_TX0_CH3_C_CASE: UNK8C1093.1 UNK8R1114.2 UNK8R1115.2
S8_OUT_TX0_CH4_ABC_CASE+: SITE8.G1(PAD_OUTP_TX0_CH[4]) UNK8U456.D2
S8_OUT_TX0_CH4_ABC_CASE-: SITE8.G2(PAD_OUTN_TX0_CH[4]) UNK8U456.D1
S8_OUT_TX0_CH4_B_CASE+: UNK8R1110.1 UNK8U456.B5
S8_OUT_TX0_CH4_B_CASE-: UNK8R1111.1 UNK8U456.A5
S8_OUT_TX0_CH4_C_CASE: UNK8C1091.1 UNK8R1110.2 UNK8R1111.2
S8_PM_SAR_GPIO0: S8_VREF_OUT.1(TP) SITE8.A20(PAD_PM_SAR_GPIO0) UNK8K34.3 UNK8MK3.4
S8_PWR_F001: SITE8.F15(DVDD_NODIE) UNK8CA26.1 UNK8CA27.1 UNK8CC112.1 UNK8SA16.1 UNK8TP_DPS2.1
S8_PWR_F004: SITE8.E10(AVDD33_RTC) UNK8CA22.1 UNK8CA23.1 UNK8CC96.1 UNK8SA21.1 UNK8TP_DPS5.1
S8_PWR_F005: SITE8.G18(VDDP3318_PM) SITE8.N17(VDDP3318_P0) SITE8.P3(VDDP3318_P2) UNK8CA7.1 UNK8CA8.1 UNK8CC70.1 UNK8CC71.1 UNK8CC73.1 UNK8SA8.1 UNK8TP_DPS6.1
S8_PWR_F006: SITE8.T13(VDD2_DRAM[0]) SITE8.T14(VDD2_DRAM[1]) SITE8.U13(VDD2_DRAM[2]) UNK8CA24.1 UNK8CA25.1 UNK8CC101.1 UNK8CC103.1 UNK8CC105.1 UNK8SA9.1 UNK8TP_DPS7.1
S8_PWR_F007: SITE8.T10(VDDQ_DRAM[0]) SITE8.T11(VDDQ_DRAM[1]) SITE8.U11(VDDQ_DRAM[2]) UNK8CA36.1 UNK8CA37.1 UNK8CC211.1 UNK8CC212.1 UNK8CC213.1 UNK8SA23.1 UNK8TP_DPS8.1
S8_PWR_F008: SITE8.K19(AVDD18_XTAL) UNK8CA38.1 UNK8CA39.1 UNK8CC220.1 UNK8SA25.1 UNK8TP_DPS9.1
S8_PWR_GS001: UNK8SA15.2
S8_PWR_GS002: UNK8SA18.2
S8_PWR_GS003: UNK8SA20.2
S8_PWR_GS004: UNK8SA22.2
S8_PWR_GS005: UNK8SA7.2
S8_PWR_GS006: UNK8SA10.2
S8_PWR_GS007: UNK8SA24.2
S8_PWR_GS008: UNK8SA26.2
S8_PWR_M_F001: SITE8.F6(AVDDL_MIPI_RX) SITE8.F7(VDD_CPU[0]) SITE8.F8(VDD_CPU[1]) SITE8.G6(AVDDL_MIPI_TX) SITE8.G7(VDD_CPU[2]) SITE8.G8(VDD_CPU[3]) SITE8.G10(VDD[0]) SITE8.G11(VDD[1]) SITE8.H7(VDD_CPU[4]) SITE8.H8(VDD_CPU[5]) SITE8.H10(VDD[2]) SITE8.H11(VDD[3]) SITE8.H12(VDD[4]) SITE8.J10(VDD[5]) SITE8.J11(VDD[6]) SITE8.J12(VDD[7]) SITE8.J13(VDD[8]) SITE8.K10(VDD[9]) SITE8.K11(VDD[10]) SITE8.K12(VDD[11]) SITE8.K13(VDD[12]) UNK8CA1.1 UNK8CA2.1 UNK8CC1.1 UNK8CC2.1 UNK8CC3.1 UNK8CC4.1 UNK8CC5.1 UNK8CC6.1 UNK8CC7.1 UNK8CC8.1 UNK8CC9.1 UNK8CC12.1 UNK8CC13.1 UNK8CC14.1 UNK8CC15.1 UNK8CC16.1 UNK8CC130.1 UNK8CC214.1 UNK8CC215.1 UNK8CC216.1 UNK8CC217.1 UNK8CC218.1 UNK8CC219.1 UNK8K96.4 UNK8K96.9 UNK8SA1.1 UNK8TP_DPS1.1
S8_PWR_M_GS001: UNK8SA2.2
S8_PWR_M_S001: UNK8SA1.2
S8_PWR_S001: UNK8SA16.2
S8_PWR_S002: UNK8SA17.2
S8_PWR_S003: UNK8SA19.2
S8_PWR_S004: UNK8SA21.2
S8_PWR_S005: UNK8SA8.2
S8_PWR_S006: UNK8SA9.2
S8_PWR_S007: UNK8SA23.2
S8_PWR_S008: UNK8SA25.2
S8_SPI_CK_ABCD_CASE: SITE8.T22(PAD_SPI_CK) UNK8K2.6
S8_SPI_CK_B_CASE: UNK8K2.5 UNK8K3.6
S8_SPI_CK_C_CASE: UNK8K3.7 UNK8U18.7
S8_SPI_CK_D_CASE: UNK8K3.5 UNK8U19.6
S8_SPI_CZ_ABCD_CASE: SITE8.M21(PAD_SPI_CZ) UNK8K2.3
S8_SPI_CZ_B_CASE: UNK8K2.4 UNK8K3.3
S8_SPI_CZ_C_CASE: UNK8K3.2 UNK8R200.2 UNK8U18.1
S8_SPI_CZ_D_CASE: UNK8K3.4 UNK8R205.2 UNK8U19.1
S8_SPI_DI_ABCD_CASE: SITE8.R21(PAD_SPI_DI) UNK8K4.6
S8_SPI_DI_B_CASE: UNK8K4.5 UNK8K5.6
S8_SPI_DI_C_CASE: UNK8K5.7
S8_SPI_DI_D_CASE: UNK8K5.5 UNK8U19.5
S8_SPI_DO_ABCD_CASE: SITE8.P22(PAD_SPI_DO) UNK8K4.3
S8_SPI_DO_B_CASE: UNK8K4.4 UNK8K5.3
S8_SPI_DO_C_CASE: UNK8K5.2
S8_SPI_DO_D_CASE: UNK8K5.4 UNK8U19.2
S8_SPI_HLD_ABCD_CASE: SITE8.P21(PAD_SPI_HLD) UNK8K6.3
S8_SPI_HLD_B_CASE: UNK8K6.4 UNK8K7.3
S8_SPI_HLD_C_CASE: UNK8K7.2 UNK8R202.1
S8_SPI_HLD_D_CASE: UNK8K7.4 UNK8R206.1 UNK8U19.7
S8_SPI_WPZ_ABCD_CASE: SITE8.N21(PAD_SPI_WPZ) UNK8K6.6
S8_SPI_WPZ_B_CASE: UNK8K6.5 UNK8K7.6
S8_SPI_WPZ_C_CASE: UNK8K7.7 UNK8R203.2 UNK8U18.2
S8_SPI_WPZ_D_CASE: UNK8K7.5 UNK8R207.2 UNK8U19.3
S8_USB2_SEL0: UNK8R164.2 UNK8U31.6
S8_USB2_SEL1: UNK8R163.2 UNK8U31.5
S8_USB2_SELS: UNK8R165.2 UNK8U31.16
S8_USB_D_AB_CASE+: SITE8.J3(PAD_DP_USB) UNK8U31.10
S8_USB_D_AB_CASE-: SITE8.J2(PAD_DM_USB) UNK8U31.9
S8_USB_D_B_CASE+: UNK8R160.2 UNK8U31.8
S8_USB_D_B_CASE-: UNK8R161.2 UNK8U31.7
S8_USER_3V3: S8_USER_3V3.1 UNK8C334.1 UNK8C335.1 UNK8C336.2 UNK8C337.2 UNK8C338.2 UNK8C339.2 UNK8R200.1 UNK8R201.2 UNK8R202.2 UNK8R203.1 UNK8R204.2 UNK8R205.1 UNK8R206.2 UNK8R207.1 UNK8U17.3
S8_XTAL_24M_IN_ABC_CASE: SITE8.L22(PAD_XTAL_IN_24M) UNK8K32.3
S8_XTAL_24M_IN_B_CASE: UNK8K32.4 UNK8R135.1
S8_XTAL_24M_IN_C_CASE: UNK8C267.1 UNK8R135.2 UNK8R136.2 UNK8Y1.3
S8_XTAL_24M_OUT_ABC_CASE: SITE8.K21(PAD_XTAL_OUT_24M) UNK8K32.6
S8_XTAL_24M_OUT_B_CASE: UNK8K32.5 UNK8R137.1
S8_XTAL_24M_OUT_C_CASE: UNK8C268.1 UNK8R136.1 UNK8R137.2 UNK8Y1.1
S8_XTAL_IN_32K_A_CASE: UNK8K29.7 UNK8U449.7
S8_XTAL_IN_32K_ABCD_CASE: SITE8.B13(PAD_XTAL_IN_32K) UNK8K29.6
S8_XTAL_IN_32K_B_CASE: UNK8C271.1 UNK8K29.5 UNK8Y2.1
S8_XTAL_IN_32K_D_CASE: UNK8R923.1 UNK8R973.2 UNK8U449.2
S8_XTAL_OUT_32K_A_CASE: UNK8K29.2 UNK8U449.8
S8_XTAL_OUT_32K_ABCD_CASE: SITE8.A12(PAD_XTAL_OUT_32K) UNK8K29.3
S8_XTAL_OUT_32K_B_CASE: UNK8C272.1 UNK8K29.4 UNK8Y2.2
S8_XTAL_OUT_32K_D_CASE: UNK8R652.1 UNK8R973.1 UNK8U449.1
SA_CBIT_R2: K2.8(V-)
SA_CBIT_R3: K3.8(V-)
SA_CBIT_R4: K4.8(V-)
SA_CBIT_R5: K5.8(V-)
SA_CBIT_R6: K6.8(V-)
SA_CBIT_R7: K7.8(V-)
SA_CBIT_R29: K29.8(V-)
SA_CBIT_R32: K32.8(V-)
SA_CBIT_R34: K34.8(V-)
SA_CBIT_R96: K96.12(V-)
SA_CBIT_S01: R163.1
SA_CBIT_S02: R164.1
SA_CBIT_S03: R165.1
SA_CBIT_S20: R662.2 R1102.2
SA_CBIT_S25: MK1.2(V-) MR12.2
SA_CBIT_S26: MK2.2(V-) MR15.2
SA_CBIT_S27: MK4.2(V-) MR17.2
SA_CBIT_S28: MK3.2(V-)
SA_CBIT_S29: R172.2 R1104.2
SA_CBIT_S97: R982.1
SA_RCBIT_01: U74.16(1C)
SA_RCBIT_02: U80.14(3C)
SA_RCBIT_03: U75.14(3C)
SA_RCBIT_04: U72.15(2C)
SA_RCBIT_05: U75.15(2C)
SA_RCBIT_06: U80.16(1C)
SA_RCBIT_07: U74.15(2C)
SA_RCBIT_08: U80.15(2C)
SA_RCBIT_09: U75.16(1C)
SA_RCBIT_10: U77.16(1C)
SA_RCBIT_11: U77.15(2C)
SA_RCBIT_12: U77.14(3C)
SA_RCBIT_13: U74.14(3C)
SA_SCBIT_01: U70.3(2Y0)
SA_SCBIT_02: U70.5(2Y1)
SA_SCBIT_03: U70.18(1Y0)
SA_SCBIT_04: U70.7(2Y2)
SA_SCBIT_05: U403.9(2Y3)
SA_SCBIT_06: U403.5(2Y1)
SA_SCBIT_07: U403.3(2Y0)
SA_SCBIT_08: U434.5(2Y1)
SA_SCBIT_09: U434.9(2Y3)
SA_SCBIT_10: U434.7(2Y2)
SA_SCBIT_11: U434.3(2Y0)
SA_SCBIT_12: U70.9(2Y3)
SA_SCBIT_13: U403.7(2Y2)
SK_RLY01: SK1.8(V-)
SK_RLY02: SK2.8(V-)
SK_RLY03: SK3.8(V-)
SK_RLY04: SK4.8(V-)
SK_RLY05: SK5.8(V-)
SK_RLY06: SK6.8(V-)
SK_RLY07: SK7.8(V-)
SK_RLY08: SK8.8(V-)
SK_RLY109: K109.8(V-)
SK_RLY110: K110.8(V-)
SX_MCB_01+: K109.3
SX_MCB_02+: K109.6
SX_MCB_03+: K110.3
SX_MCB_04+: K110.6
UBIT_3V3_UP: BD5.1 BD1721.1 BD1722.1 BD1723.1 R403.1
UDBGND: CB1.2 CB2.2 CB3.2 CB4.2 CB5.2 CB6.2 CB7.2 CB8.2 CB9.2 CB10.2 CB11.2 CB12.2 CB13.2 CB14.2 CB15.2 CB16.2 LDB1.2(B) RB501.1 RB502.1 RB507.1 RB508.1 RB509.1 RB510.1 RB511.1 RB512.1 RB513.1 RB514.1 RB515.1 RB516.1 UB1.1(NC) UB1.2(A1/NC) UB1.3(A2) UB1.4(GND) UB1.7(WP) UTL1.A02 UTL1.A08 UTL1.A10 UTL1.A12 UTL1.A14 UTL1.B01 UTL1.B07 UTL1.B09 UTL1.B11 UTL1.B13 UTL2.A02 UTL2.A08 UTL2.A10 UTL2.A12 UTL2.A14 UTL2.B01 UTL2.B07 UTL2.B09 UTL2.B11 UTL2.B13 UTL3.A02 UTL3.A08 UTL3.A10 UTL3.A12 UTL3.A14 UTL3.B01 UTL3.B07 UTL3.B09 UTL3.B11 UTL3.B13 UTL4.A02 UTL4.A08 UTL4.A10 UTL4.A12 UTL4.A14 UTL4.B01 UTL4.B07 UTL4.B09 UTL4.B11 UTL4.B13 UTL5.A02 UTL5.A08 UTL5.A10 UTL5.A12 UTL5.A14 UTL5.B01 UTL5.B07 UTL5.B09 UTL5.B11 UTL5.B13 UTL6.A02 UTL6.A08 UTL6.A10 UTL6.A12 UTL6.A14 UTL6.B01 UTL6.B07 UTL6.B09 UTL6.B11 UTL6.B13 UTL7.A02 UTL7.A08 UTL7.A10 UTL7.A12 UTL7.A14 UTL7.B01 UTL7.B07 UTL7.B09 UTL7.B11 UTL7.B13 UTL8.A02 UTL8.A08 UTL8.A10 UTL8.A12 UTL8.A14 UTL8.B01 UTL8.B07 UTL8.B09 UTL8.B11 UTL8.B13 XC2.1
UT1_PDCF: UTL1.B15
UT1_PDCS: UTL1.A15
UT1_PGDS: UTL1.A16
UT1_PGRD: UTL1.B16
UT1_UP5V: C278.1 C279.1 C280.1 C281.1 C332.1 C333.1 C403.1 C404.1 C405.1 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C413.1 C415.1 C416.1 C417.1 C476.1 C477.1 C478.1 C910.1 C955.1 C956.1 C957.1 C958.1 C1082.1 C1083.1 C1085.1 CB1.1 CB2.1 CB3.1 CB4.1 CB5.1 CB6.1 CB7.1 CB8.1 CB9.1 CB10.1 CB11.1 CB12.1 CB13.1 CB14.1 CB15.1 CB16.1 J1.1 J2.1 K2.1(V+) K3.1(V+) K4.1(V+) K5.1(V+) K6.1(V+) K7.1(V+) K29.1(V+) K32.1(V+) K34.1(V+) K96.1(V+) K109.1(V+) K110.1(V+) LRB1.1 MBD1.1 MR11.1 MR12.1 MR13.1 MR14.2 MR15.1 MR16.1 MR17.1 MU1.1(VIN) MU1.3(EN) R331.1 R404.2 R405.1 R406.1 R407.1 R408.1 R409.1 R410.1 R411.1 R412.1 R413.1 R414.1 R415.1 R416.1 R420.1 R422.1 R509.2 R648.1 R649.1 R650.1 R658.1 R709.1 R710.1 R711.1 R712.1 R713.1 R714.1 R1093.1 R1097.1 RB1.1 RB2.1 SK1.1(V+) SK2.1(V+) SK3.1(V+) SK4.1(V+) SK5.1(V+) SK6.1(V+) SK7.1(V+) SK8.1(V+) U17.2(VIN) U71.4(VDD) U72.9(COM) U73.14(VCC) U74.9(COM) U75.9(COM) U76.14(VCC) U77.9(COM) U79.14(VCC) U80.9(COM) U108.4(VDD) U405.9(COM) U413.9(COM) U414.14(VCC) U415.9(COM) U453.9(COM) U454.14(VCC) UB1.8(VCC) UNK2C278.1 UNK2C279.1 UNK2C280.1 UNK2C281.1 UNK2C332.1 UNK2C333.1 UNK2C476.1 UNK2C477.1 UNK2C478.1 UNK2K2.1 UNK2K3.1 UNK2K4.1 UNK2K5.1 UNK2K6.1 UNK2K7.1 UNK2K29.1 UNK2K32.1 UNK2K34.1 UNK2K96.1 UNK2MBD1.1 UNK2MR11.1 UNK2MR12.1 UNK2MR13.1 UNK2MR14.2 UNK2MR15.1 UNK2MR16.1 UNK2MR17.1 UNK2MU1.1 UNK2MU1.3 UNK2R331.1 UNK2R509.2 UNK2U17.2 UNK2U108.4 UNK3C278.1 UNK3C279.1 UNK3C280.1 UNK3C281.1 UNK3C332.1 UNK3C333.1 UNK3C476.1 UNK3C477.1 UNK3C478.1 UNK3K2.1 UNK3K3.1 UNK3K4.1 UNK3K5.1 UNK3K6.1 UNK3K7.1 UNK3K29.1 UNK3K32.1 UNK3K34.1 UNK3K96.1 UNK3MBD1.1 UNK3MR11.1 UNK3MR12.1 UNK3MR13.1 UNK3MR14.2 UNK3MR15.1 UNK3MR16.1 UNK3MR17.1 UNK3MU1.1 UNK3MU1.3 UNK3R331.1 UNK3R509.2 UNK3U17.2 UNK3U108.4 UNK4C278.1 UNK4C279.1 UNK4C280.1 UNK4C281.1 UNK4C332.1 UNK4C333.1 UNK4C476.1 UNK4C477.1 UNK4C478.1 UNK4K2.1 UNK4K3.1 UNK4K4.1 UNK4K5.1 UNK4K6.1 UNK4K7.1 UNK4K29.1 UNK4K32.1 UNK4K34.1 UNK4K96.1 UNK4MBD1.1 UNK4MR11.1 UNK4MR12.1 UNK4MR13.1 UNK4MR14.2 UNK4MR15.1 UNK4MR16.1 UNK4MR17.1 UNK4MU1.1 UNK4MU1.3 UNK4R331.1 UNK4R509.2 UNK4U17.2 UNK4U108.4 UNK5C278.1 UNK5C279.1 UNK5C280.1 UNK5C281.1 UNK5C332.1 UNK5C333.1 UNK5C476.1 UNK5C477.1 UNK5C478.1 UNK5K2.1 UNK5K3.1 UNK5K4.1 UNK5K5.1 UNK5K6.1 UNK5K7.1 UNK5K29.1 UNK5K32.1 UNK5K34.1 UNK5K96.1 UNK5MBD1.1 UNK5MR11.1 UNK5MR12.1 UNK5MR13.1 UNK5MR14.2 UNK5MR15.1 UNK5MR16.1 UNK5MR17.1 UNK5MU1.1 UNK5MU1.3 UNK5R331.1 UNK5R509.2 UNK5U17.2 UNK5U108.4 UNK6C278.1 UNK6C279.1 UNK6C280.1 UNK6C281.1 UNK6C332.1 UNK6C333.1 UNK6C476.1 UNK6C477.1 UNK6C478.1 UNK6K2.1 UNK6K3.1 UNK6K4.1 UNK6K5.1 UNK6K6.1 UNK6K7.1 UNK6K29.1 UNK6K32.1 UNK6K34.1 UNK6K96.1 UNK6MBD1.1 UNK6MR11.1 UNK6MR12.1 UNK6MR13.1 UNK6MR14.2 UNK6MR15.1 UNK6MR16.1 UNK6MR17.1 UNK6MU1.1 UNK6MU1.3 UNK6R331.1 UNK6R509.2 UNK6U17.2 UNK6U108.4 UNK7C278.1 UNK7C279.1 UNK7C280.1 UNK7C281.1 UNK7C332.1 UNK7C333.1 UNK7C476.1 UNK7C477.1 UNK7C478.1 UNK7K2.1 UNK7K3.1 UNK7K4.1 UNK7K5.1 UNK7K6.1 UNK7K7.1 UNK7K29.1 UNK7K32.1 UNK7K34.1 UNK7K96.1 UNK7MBD1.1 UNK7MR11.1 UNK7MR12.1 UNK7MR13.1 UNK7MR14.2 UNK7MR15.1 UNK7MR16.1 UNK7MR17.1 UNK7MU1.1 UNK7MU1.3 UNK7R331.1 UNK7R509.2 UNK7U17.2 UNK7U108.4 UNK8C278.1 UNK8C279.1 UNK8C280.1 UNK8C281.1 UNK8C332.1 UNK8C333.1 UNK8C476.1 UNK8C477.1 UNK8C478.1 UNK8K2.1 UNK8K3.1 UNK8K4.1 UNK8K5.1 UNK8K6.1 UNK8K7.1 UNK8K29.1 UNK8K32.1 UNK8K34.1 UNK8K96.1 UNK8MBD1.1 UNK8MR11.1 UNK8MR12.1 UNK8MR13.1 UNK8MR14.2 UNK8MR15.1 UNK8MR16.1 UNK8MR17.1 UNK8MU1.1 UNK8MU1.3 UNK8R331.1 UNK8R509.2 UNK8U17.2 UNK8U108.4 UT_UP5V.1(TP) UTL1.A05 UTL1.B04 UTL2.A05 UTL2.B04 UTL3.A05 UTL3.B04 UTL4.A05 UTL4.B04 UTL5.A05 UTL5.B04 UTL6.A05 UTL6.B04 UTL7.A05 UTL7.B04 UTL8.A05 UTL8.B04 XC2.2
UT1_URW00: UT1_SW1.8 UTL1.A01
UT1_URW01: UT1_SW1.7 UTL1.B02
UT1_URW02: UT1_SW1.6 UTL1.A03
UT1_URW03: UT1_SW1.5 UTL1.B03
UT1_URW04: UT1_SW1.4 UTL1.A04
UT1_URW05: UT1_SW1.3 UTL1.B05
UT1_URW06: UT1_SW1.2 UTL1.A06
UT1_UW07: UT1_SW1.1 UTL1.B06
UT1_UW08: UT1_SW2.8 UTL1.A07
UT1_UW09: UT1_SW2.7 UTL1.B08
UT1_UW10: UT1_SW2.6 UTL1.A09
UT1_UW11: UT1_SW2.5 UTL1.B10
UT1_UW12: UT1_SW2.4 UTL1.A11
UT1_UW13: UT1_SW2.3 UTL1.B12
UT1_UW14: RB1.2 UB1.6(SCL) UT1_SW2.2 UTL1.A13
UT1_UW15: RB2.2 UB1.5(SDA) UT1_SW2.1 UTL1.B14
UT2_PDCF: UTL2.B15
UT2_PDCS: UTL2.A15
UT2_PGDS: UTL2.A16
UT2_PGRD: UTL2.B16
UT2_URW00: UT2_SW1.8 UTL2.A01
UT2_URW01: UT2_SW1.7 UTL2.B02
UT2_URW02: UT2_SW1.6 UTL2.A03
UT2_URW03: UT2_SW1.5 UTL2.B03
UT2_URW04: UT2_SW1.4 UTL2.A04
