# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UT4_URW06: length 3.8
  TOP w0.254: UT4_SW1.2 261,416.04 261.62,415.42 UTL4.A06
UT4_UW07: length 7.4
  TOP w0.254: UTL4.B06 260.35,412.75 260.35,415.04 258.46,416.93 UT4_SW1.1
UT4_UW08: length 7.2
  TOP w0.254: UT4_SW2.8 254.01,416.42 254.63,415.8 257.3,415.8 UTL4.A07
UT4_UW09: length 11.5
  TOP w0.254: UT4_SW2.7 v1(251.47,419.21)
  L15_SIGNAL w0.203: v1(251.47,419.21) 255.27,415.42 255.27,412.75 UTL4.B08
UT4_UW10: length 7.3
  TOP w0.254: UTL4.A09 252.48,415.54 249.68,415.54 248.93,416.29 UT4_SW2.6
UT4_UW11: length 11.5
  TOP w0.254: UT4_SW2.5 v1(246.39,419.21)
  L15_SIGNAL w0.203: UTL4.B10 250.19,412.75 250.19,415.42 v1(246.39,419.21)
UT4_UW12: length 7.3
  TOP w0.254: UT4_SW2.4 243.85,416.29 244.35,415.8 247.14,415.8 UTL4.A11
UT4_UW13: length 11.5
  TOP w0.254: UT4_SW2.3 v1(241.31,419.21)
  L15_SIGNAL w0.203: UTL4.B12 245.11,412.75 245.11,415.42 v1(241.31,419.21)
UT4_UW14: length 7.4
  TOP w0.254: UTL4.A13 242.19,415.67 239.27,415.67 238.77,416.17 UT4_SW2.2
UT4_UW15: length 9.3
  TOP w0.254: UT4_SW2.1 236.23,416.55 237.49,415.29 237.49,413.38 238.12,412.75 240.03,412.75 UTL4.B14
UT5_UW00: length 4.3
  TOP w0.254: UT5_SW1.8 10.78,13.32 UTL5.A01
UT5_UW01: length 6.9
  TOP w0.254: UTL5.B02 13.97,16.51 13.97,13.97 13.32,13.32 UT5_SW1.7
UT5_UW02: length 4.3
  TOP w0.254: UT5_SW1.6 15.86,13.32 UTL5.A03
UT5_UW03: length 6.9
  TOP w0.254: UTL5.B03 19.05,16.51 19.05,13.84 18.4,13.2 UT5_SW1.5
UT5_UW04: length 3.8
  TOP w0.254: UT5_SW1.4 20.94,14.62 UTL5.A04
UT5_UW05: length 6.9
  TOP w0.254: UTL5.B05 24.13,16.51 24.13,13.97 23.48,13.32 UT5_SW1.3
UT5_UW06: length 3.8
  TOP w0.254: UTL5.A06 25.4,13.84 26.02,13.22 UT5_SW1.2
UT5_UW07: length 7.4
  TOP w0.254: UT5_SW1.1 28.56,12.33 26.67,14.22 26.67,16.51 UTL5.B06
UT5_UW08: length 7.2
  TOP w0.254: UTL5.A07 29.72,13.46 32.38,13.46 33.01,12.84 UT5_SW2.8
UT5_UW09: length 11.5
  TOP w0.254: UT5_SW2.7 v1(35.55,10.05)
  L15_SIGNAL w0.203: v1(35.55,10.05) 31.75,13.84 31.75,16.51 UTL5.B08
UT5_UW10: length 7.3
  TOP w0.254: UT5_SW2.6 38.09,12.97 37.34,13.72 34.54,13.72 UTL5.A09
UT5_UW11: length 11.5
  TOP w0.254: UT5_SW2.5 v1(40.63,10.05)
  L15_SIGNAL w0.203: v1(40.63,10.05) 36.83,13.84 36.83,16.51 UTL5.B10
UT5_UW12: length 7.3
  TOP w0.254: UTL5.A11 39.88,13.46 42.67,13.46 43.17,12.97 UT5_SW2.4
UT5_UW13: length 11.5
  TOP w0.254: UT5_SW2.3 v1(45.71,10.05)
  L15_SIGNAL w0.203: UTL5.B12 41.91,16.51 41.91,13.84 v1(45.71,10.05)
UT5_UW14: length 7.4
  TOP w0.254: UTL5.A13 44.83,13.59 47.75,13.59 48.25,13.09 UT5_SW2.2
UT5_UW15: length 9.3
  TOP w0.254: UT5_SW2.1 50.79,12.71 49.53,13.97 49.53,15.88 48.89,16.51 46.99,16.51 UTL5.B14
UT6_UW00: length 4.3
  TOP w0.254: UT6_SW1.8 452.74,13.32 UTL6.A01
UT6_UW01: length 6.9
  TOP w0.254: UT6_SW1.7 455.28,13.32 455.93,13.97 455.93,16.51 UTL6.B02
UT6_UW02: length 4.3
  TOP w0.254: UT6_SW1.6 457.82,13.32 UTL6.A03
UT6_UW03: length 6.9
  TOP w0.254: UTL6.B03 461.01,16.51 461.01,13.84 460.36,13.2 UT6_SW1.5
UT6_UW04: length 3.8
  TOP w0.254: UT6_SW1.4 462.9,14.62 UTL6.A04
UT6_UW05: length 6.9
  TOP w0.254: UT6_SW1.3 465.44,13.32 466.09,13.97 466.09,16.51 UTL6.B05
UT6_UW06: length 3.8
  TOP w0.254: UTL6.A06 467.36,13.84 467.98,13.22 UT6_SW1.2
UT6_UW07: length 7.4
  TOP w0.254: UT6_SW1.1 470.52,12.33 468.63,14.22 468.63,16.51 UTL6.B06
UT6_UW08: length 7.2
  TOP w0.254: UT6_SW2.8 474.97,12.84 474.34,13.46 471.68,13.46 UTL6.A07
UT6_UW09: length 11.5
  TOP w0.254: UT6_SW2.7 v1(477.51,10.05)
  L15_SIGNAL w0.203: v1(477.51,10.05) 473.71,13.84 473.71,16.51 UTL6.B08
UT6_UW10: length 7.3
  TOP w0.254: UTL6.A09 476.5,13.72 479.3,13.72 480.05,12.97 UT6_SW2.6
UT6_UW11: length 11.5
  TOP w0.254: UT6_SW2.5 v1(482.59,10.05)
  L15_SIGNAL w0.203: UTL6.B10 478.79,16.51 478.79,13.84 v1(482.59,10.05)
UT6_UW12: length 7.3
  TOP w0.254: UTL6.A11 481.84,13.46 484.63,13.46 485.13,12.97 UT6_SW2.4
UT6_UW13: length 11.5
  TOP w0.254: UT6_SW2.3 v1(487.67,10.05)
  L15_SIGNAL w0.203: UTL6.B12 483.87,16.51 483.87,13.84 v1(487.67,10.05)
UT6_UW14: length 7.4
  TOP w0.254: UTL6.A13 486.79,13.59 489.71,13.59 490.21,13.09 UT6_SW2.2
UT6_UW15: length 9.3
  TOP w0.254: UT6_SW2.1 492.75,12.71 491.49,13.97 491.49,15.88 490.86,16.51 488.95,16.51 UTL6.B14
UT7_UW00: length 4.3
  TOP w0.254: UTL7.A01 570.88,415.94 UT7_SW1.8
UT7_UW01: length 6.9
  TOP w0.254: UTL7.B02 567.69,412.75 567.69,415.29 568.34,415.94 UT7_SW1.7
UT7_UW02: length 4.3
  TOP w0.254: UTL7.A03 565.8,415.94 UT7_SW1.6
UT7_UW03: length 6.9
  TOP w0.254: UTL7.B03 562.61,412.75 562.61,415.42 563.26,416.06 UT7_SW1.5
UT7_UW04: length 3.8
  TOP w0.254: UTL7.A04 560.72,414.64 UT7_SW1.4
UT7_UW05: length 6.9
  TOP w0.254: UT7_SW1.3 558.18,415.94 557.53,415.29 557.53,412.75 UTL7.B05
UT7_UW06: length 3.8
  TOP w0.254: UTL7.A06 556.26,415.42 555.64,416.04 UT7_SW1.2
UT7_UW07: length 7.4
  TOP w0.254: UT7_SW1.1 553.1,416.93 554.99,415.04 554.99,412.75 UTL7.B06
UT7_UW08: length 7.2
  TOP w0.254: UTL7.A07 551.94,415.8 549.27,415.8 548.65,416.42 UT7_SW2.8
UT7_UW09: length 11.5
  TOP w0.254: UT7_SW2.7 v1(546.11,419.21)
  L15_SIGNAL w0.203: UTL7.B08 549.91,412.75 549.91,415.42 v1(546.11,419.21)
UT7_UW10: length 7.3
  TOP w0.254: UT7_SW2.6 543.57,416.29 544.32,415.54 547.12,415.54 UTL7.A09
UT7_UW11: length 11.5
  TOP w0.254: UT7_SW2.5 v1(541.03,419.21)
  L15_SIGNAL w0.203: UTL7.B10 544.83,412.75 544.83,415.42 v1(541.03,419.21)
UT7_UW12: length 7.3
  TOP w0.254: UT7_SW2.4 538.49,416.29 538.99,415.8 541.78,415.8 UTL7.A11
UT7_UW13: length 11.5
  TOP w0.254: UT7_SW2.3 v1(535.95,419.21)
  L15_SIGNAL w0.203: v1(535.95,419.21) 539.75,415.42 539.75,412.75 UTL7.B12
UT7_UW14: length 7.4
  TOP w0.254: UT7_SW2.2 533.41,416.17 533.91,415.67 536.83,415.67 UTL7.A13
UT7_UW15: length 9.3
  TOP w0.254: UTL7.B14 534.67,412.75 532.76,412.75 532.13,413.38 532.13,415.29 530.87,416.55 UT7_SW2.1
UT8_UW00: length 4.3
  TOP w0.254: UTL8.A01 128.92,415.94 UT8_SW1.8
UT8_UW01: length 6.9
  TOP w0.254: UT8_SW1.7 126.38,415.94 125.73,415.29 125.73,412.75 UTL8.B02
UT8_UW02: length 4.3
  TOP w0.254: UT8_SW1.6 123.84,415.94 UTL8.A03
UT8_UW03: length 6.9
  TOP w0.254: UTL8.B03 120.65,412.75 120.65,415.42 121.3,416.06 UT8_SW1.5
UT8_UW04: length 3.8
  TOP w0.254: UT8_SW1.4 118.76,414.64 UTL8.A04
UT8_UW05: length 6.9
  TOP w0.254: UTL8.B05 115.57,412.75 115.57,415.29 116.22,415.94 UT8_SW1.3
UT8_UW06: length 3.8
  TOP w0.254: UT8_SW1.2 113.68,416.04 114.3,415.42 UTL8.A06
UT8_UW07: length 7.4
  TOP w0.254: UT8_SW1.1 111.14,416.93 113.03,415.04 113.03,412.75 UTL8.B06
UT8_UW08: length 7.2
  TOP w0.254: UT8_SW2.8 106.69,416.42 107.31,415.8 109.98,415.8 UTL8.A07
UT8_UW09: length 11.5
  TOP w0.254: UT8_SW2.7 v1(104.15,419.21)
  L15_SIGNAL w0.203: v1(104.15,419.21) 107.95,415.42 107.95,412.75 UTL8.B08
UT8_UW10: length 7.3
  TOP w0.254: UTL8.A09 105.16,415.54 102.36,415.54 101.61,416.29 UT8_SW2.6
UT8_UW11: length 11.5
  TOP w0.254: UT8_SW2.5 v1(99.07,419.21)
  L15_SIGNAL w0.203: v1(99.07,419.21) 102.87,415.42 102.87,412.75 UTL8.B10
UT8_UW12: length 7.3
  TOP w0.254: UTL8.A11 99.82,415.8 97.03,415.8 96.53,416.29 UT8_SW2.4
UT8_UW13: length 11.5
  TOP w0.254: UT8_SW2.3 v1(93.99,419.21)
  L15_SIGNAL w0.203: UTL8.B12 97.79,412.75 97.79,415.42 v1(93.99,419.21)
UT8_UW14: length 7.4
  TOP w0.254: UT8_SW2.2 91.45,416.17 91.95,415.67 94.87,415.67 UTL8.A13
UT8_UW15: length 9.3
  TOP w0.254: UT8_SW2.1 88.91,416.55 90.17,415.29 90.17,413.38 90.8,412.75 92.71,412.75 UTL8.B14
N17578091: length 0.9
  BOTTOM w0.16: SR3.2 v1(37.71,246.09)
N17578095: length 0.9
  BOTTOM w0.16: SR4.2 v1(40.08,256.75)
N17578103: length 0.9
  BOTTOM w0.16: SR5.2 v1(49.53,246.09)
N17578107: length 3.5
  BOTTOM w0.16: SR5.1 SC4.1 SK1.7
N17578109: length 0.9
  BOTTOM w0.16: SR6.2 v1(47.16,256.75)
N17578111: length 3.5
  BOTTOM w0.16: SK1.6 SC1.1 SR2.2
N17578117: length 0.9
  BOTTOM w0.16: SR2.1 v1(49.53,252.31)
N17578119: length 3.5
  BOTTOM w0.16: SK1.2 SC6.1 SR3.1
N17578121: length 3.5
  BOTTOM w0.16: SK1.3 SC2.1 SR1.2
N17578131: length 3.4
  BOTTOM w0.16: SK1.5 SC3.1 SR6.1
N17578138: length 0.9
  BOTTOM w0.16: SR9.2 v1(55.49,246.09)
N17578142: length 0.9
  BOTTOM w0.16: SR10.2 v1(57.86,256.75)
N17578153: length 3.5
  BOTTOM w0.16: SR11.1 SC10.1 SK2.7
N17578155: length 0.9
  BOTTOM w0.16: SR11.2 v1(67.31,246.09)
N17578165: length 0.9
  BOTTOM w0.16: SR12.2 v1(64.94,256.75)
N17578169: length 3.5
  BOTTOM w0.16: SR8.2 SC7.1 SK2.6
N17578175: length 0.9
  BOTTOM w0.16: SR8.1 v1(67.31,252.31)
N17578179: length 3.5
  BOTTOM w0.16: SK2.2 SC12.1 SR9.1
N17578181: length 3.4
  BOTTOM w0.16: SK2.5 SC9.1 SR12.1
N17578183: length 3.5
  BOTTOM w0.16: SR7.2 SC8.1 SK2.3
N17578209: length 0.9
  BOTTOM w0.16: SR7.1 v1(55.49,252.31)
N17578211: length 3.4
  BOTTOM w0.16: SR10.1 SC11.1 SK2.4
N17578235: length 3.4
  BOTTOM w0.16: SK1.4 SC5.1 SR4.1
N17578245: length 0.9
  BOTTOM w0.16: SR1.1 v1(37.71,252.31)
N17578251: length 0.9
  BOTTOM w0.16: SR18.2 v1(57.68,274.92)
N17578253: length 0.9
  BOTTOM w0.16: SR14.2 v1(67.13,264.26)
N17578257: length 3.5
  BOTTOM w0.16: SR14.1 SC17.1 SK3.7
N17578263: length 0.9
  BOTTOM w0.16: SR17.2 v1(55.31,264.26)
N17578267: length 0.9
  BOTTOM w0.16: SR13.1 v1(67.13,270.48)
N17578271: length 3.5
  BOTTOM w0.16: SK3.6 SC14.1 SR13.2
N17578275: length 0.9
  BOTTOM w0.16: SR15.2 v1(64.76,274.92)
N17578283: length 3.4
  BOTTOM w0.16: SK3.5 SC13.1 SR15.1
N17578291: length 3.5
  BOTTOM w0.16: SR16.2 SC15.1 SK3.3
N17578297: length 3.5
  BOTTOM w0.16: SR17.1 SC18.1 SK3.2
N17578299: length 0.9
  BOTTOM w0.16: SR16.1 v1(55.31,270.48)
N17578323: length 3.4
  BOTTOM w0.16: SK3.4 SC16.1 SR18.1
N17578329: length 0.9
  BOTTOM w0.16: SR23.2 v1(37.53,264.26)
N17578337: length 0.9
  BOTTOM w0.16: SR24.2 v1(39.9,274.92)
N17578341: length 0.9
  BOTTOM w0.16: SR20.2 v1(49.35,264.26)
N17578345: length 3.5
  BOTTOM w0.16: SR20.1 SC23.1 SK4.7
N17578351: length 3.4
  BOTTOM w0.16: SK4.5 SC19.1 SR21.1
N17578353: length 3.5
  BOTTOM w0.16: SR23.1 SC24.1 SK4.2
N17578355: length 0.9
  BOTTOM w0.16: SR19.1 v1(49.35,270.48)
N17578359: length 3.5
  BOTTOM w0.16: SK4.6 SC20.1 SR19.2
N17578363: length 0.9
  BOTTOM w0.16: SR21.2 v1(46.98,274.92)
N17578379: length 3.5
  BOTTOM w0.16: SR22.2 SC21.1 SK4.3
N17578383: length 3.4
  BOTTOM w0.16: SR24.1 SC22.1 SK4.4
N17578387: length 0.9
  BOTTOM w0.16: SR22.1 v1(37.53,270.48)
N17981963: length 4.5
  BOTTOM w0.16: U454.2 505.1,209.79 504.77,209.47 503.4,209.47 502.88,208.95 U453.1
N17981973: length 5.9
  BOTTOM w0.16: U453.2 502.13,209.32 503.61,210.79 U454.4
N18477102: length 7.2
  BOTTOM w0.16: U80.3 76.57,276.65 78.71,278.8 80.06,278.8 80.26,278.6 U79.6
N18477108: length 5.6
  BOTTOM w0.16: U80.2 77.22,276.12 78.69,277.6 U79.4
N18477229: length 5.9
  BOTTOM w0.16: U79.10 85.09,278.1 86.92,279.93 U405.2
N18477291: length 5.7
  BOTTOM w0.16: U405.1 86.17,280.35 85.52,279.7 82.65,279.7 82.32,279.37 U79.8
N18477301: length 7.4
  BOTTOM w0.16: U405.3 87.57,279.31 85.36,277.1 U79.12
N18479086: length 5.9
  BOTTOM w0.16: U415.2 86.92,266.22 85.09,264.39 U414.10
N18479100: length 7.2
  BOTTOM w0.16: U413.3 76.57,262.93 78.71,265.08 80.06,265.08 80.26,264.88 U414.6
N18479120: length 4.2
  BOTTOM w0.16: U413.1 77.97,261.94 78.71,262.69 80.06,262.69 80.26,262.88 U414.2
N18479142: length 5.6
  BOTTOM w0.16: U413.2 77.22,262.41 78.69,263.88 U414.4
N18479202: length 5.7
  BOTTOM w0.16: U414.8 82.32,265.65 82.65,265.99 85.52,265.99 86.17,266.63 U415.1
N18479218: length 7.4
  BOTTOM w0.16: U414.12 85.36,263.38 87.57,265.6 U415.3
N18480061: length 2
  BOTTOM w0.16: U403.13 539.15,221.17 538.75,220.78 R601.1
N18480064: length 3.3
  BOTTOM w0.16: U403.11 540.94,219.9 540.41,219.38 R602.1
N18480115: length 26
  BOTTOM w0.305: C895.1 537.49,226.37 534.61,223.49 R940.1 R938.1 R937.1 R939.1 ; C895.1 C894.1 BD1721.2 547.54,226.37 547.94,225.97 R936.1 R934.1 R933.1 R935.1 ; C895.1 U403.20
N18480820: length 26
  BOTTOM w0.305: U434.20 C984.1 ; C984.1 537.11,213.03 534.23,210.16 R948.1 R946.1 R945.1 R947.1 ; C984.1 C983.1 BD1722.2 547.16,213.03 547.56,212.64 R944.1 R942.1 R941.1 R943.1
N18480908: length 2.1
  BOTTOM w0.16: R758.1 543.73,209.84 U434.4
N18480914: length 2.1
  BOTTOM w0.16: R753.1 543.73,208.84 U434.6
N18480920: length 2.2
  BOTTOM w0.16: R755.1 543.41,207.24 542.82,207.84 U434.8
N18480930: length 2
  BOTTOM w0.16: R757.1 538.37,210.24 538.77,209.84 U434.17
N18480954: length 2.2
  BOTTOM w0.16: U434.2 542.82,210.84 543.41,211.43 R751.1
N18480970: length 1.8
  BOTTOM w0.16: U434.15 R752.1
N18480990: length 2
  BOTTOM w0.16: R754.1 538.37,207.44 538.77,207.84 U434.13
N18480996: length 3.3
  BOTTOM w0.16: U434.11 540.55,206.57 540.03,206.04 R756.1
N18482064: length 10.9
  BOTTOM w0.305: U435.20 C986.1 C985.1 BD1723.2 547.16,198.94 547.56,198.54 R952.1 R950.1
N18482160: length 2.1
  BOTTOM w0.16: R766.1 543.73,195.74 U435.4
N18482210: length 2.2
  BOTTOM w0.16: U435.2 542.82,196.74 543.41,197.34 R759.1
N19145542: length 0.9
  BOTTOM w0.16: SR30.2 v1(560.34,173.14)
N19145546: length 0.9
  BOTTOM w0.16: SR26.2 v1(569.79,162.48)
N19145550: length 3.5
  BOTTOM w0.16: SK5.7 SC29.1 SR26.1
N19145556: length 0.9
  BOTTOM w0.16: SR29.2 v1(557.97,162.48)
N19145558: length 3.5
  BOTTOM w0.16: SR29.1 SC30.1 SK5.2
N19145560: length 0.9
  BOTTOM w0.16: SR25.1 v1(569.79,168.7)
N19145564: length 3.5
  BOTTOM w0.16: SK5.6 SC26.1 SR25.2
N19145568: length 0.9
  BOTTOM w0.16: SR27.2 v1(567.42,173.14)
N19145576: length 3.4
  BOTTOM w0.16: SR27.1 SC25.1 SK5.5
N19145584: length 3.5
  BOTTOM w0.16: SR28.2 SC27.1 SK5.3
N19145590: length 3.4
  BOTTOM w0.16: SK5.4 SC28.1 SR30.1
N19145592: length 0.9
  BOTTOM w0.16: SR28.1 v1(557.97,168.7)
N19145780: length 0.9
  BOTTOM w0.16: SR36.2 v1(543.83,173.14)
N19145784: length 0.9
  BOTTOM w0.16: SR35.2 v1(541.46,162.48)
N19145790: length 0.9
  BOTTOM w0.16: SR33.2 v1(550.91,173.14)
N19145800: length 0.9
  BOTTOM w0.16: SR32.2 v1(553.28,162.48)
N19145804: length 3.5
  BOTTOM w0.16: SK6.7 SC35.1 SR32.1
N19145813: length 3.5
  BOTTOM w0.16: SR34.2 SC33.1 SK6.3
N19145817: length 3.4
  BOTTOM w0.16: SK6.5 SC31.1 SR33.1
N19145819: length 3.5
  BOTTOM w0.16: SR35.1 SC36.1 SK6.2
N19145821: length 0.9
  BOTTOM w0.16: SR31.1 v1(553.28,168.7)
N19145825: length 3.5
  BOTTOM w0.16: SK6.6 SC32.1 SR31.2
N19145869: length 3.4
  BOTTOM w0.16: SK6.4 SC34.1 SR36.1
N19145875: length 0.9
  BOTTOM w0.16: SR34.1 v1(541.46,168.7)
N19146153: length 0.9
  BOTTOM w0.16: SR41.2 v1(541.46,145.97)
N19146155: length 0.9
  BOTTOM w0.16: SR39.2 v1(550.91,156.63)
N19146167: length 0.9
  BOTTOM w0.16: SR42.2 v1(543.83,156.63)
N19146177: length 3.4
  BOTTOM w0.16: SK7.5 SC37.1 SR39.1
N19146179: length 3.5
  BOTTOM w0.16: SR40.2 SC39.1 SK7.3
N19146183: length 3.5
  BOTTOM w0.16: SR38.1 SC41.1 SK7.7
N19146185: length 0.9
  BOTTOM w0.16: SR38.2 v1(553.28,145.97)
N19146193: length 3.5
  BOTTOM w0.16: SK7.2 SC42.1 SR41.1
N19146199: length 3.5
  BOTTOM w0.16: SK7.6 SC38.1 SR37.2
N19146205: length 0.9
  BOTTOM w0.16: SR37.1 v1(553.28,152.19)
N19146217: length 3.4
  BOTTOM w0.16: SR42.1 SC40.1 SK7.4
N19146247: length 0.9
  BOTTOM w0.16: SR40.1 v1(541.46,152.19)
N19146496: length 0.9
  BOTTOM w0.16: SR47.2 v1(557.97,145.97)
N19146500: length 0.9
  BOTTOM w0.16: SR48.2 v1(560.34,156.63)
N19146502: length 0.9
  BOTTOM w0.16: SR44.2 v1(569.79,145.97)
N19146512: length 0.9
  BOTTOM w0.16: SR45.2 v1(567.42,156.63)
N19146518: length 3.5
  BOTTOM w0.16: SK8.6 SC44.1 SR43.2
N19146522: length 0.9
  BOTTOM w0.16: SR43.1 v1(569.79,152.19)
N19146524: length 3.5
  BOTTOM w0.16: SR47.1 SC48.1 SK8.2
N19146526: length 3.4
  BOTTOM w0.16: SR45.1 SC43.1 SK8.5
N19146528: length 3.5
  BOTTOM w0.16: SK8.3 SC45.1 SR46.2
N19146532: length 3.5
  BOTTOM w0.16: SR44.1 SC47.1 SK8.7
N19146554: length 0.9
  BOTTOM w0.16: SR46.1 v1(557.97,152.19)
N19146556: length 3.4
  BOTTOM w0.16: SK8.4 SC46.1 SR48.1
N19656281: length 26
  BOTTOM w0.305: C400.1 537.49,239.32 534.61,236.44 R932.1 R930.1 R929.1 R931.1 ; C400.1 U70.20 ; C400.1 C401.1 BD5.2 547.54,239.32 547.94,238.92 R926.1 R927.1 R925.1 R928.1
N21055971: length 0.8
  BOTTOM w0.16: U31.15 R162.1
N21056737:
  vias: v2(255.65,271.53)
N21140049: length 1.3
  BOTTOM w0.305: R331.2 MU4.3
N21140128: length 1.3
  BOTTOM w0.305: MU4.1 C299.2
N21140130: length 5.6
  BOTTOM w0.305: MU4.5 220.67,291.37 C300.1 ; C300.1 MR18.1 ; C300.1 C301.1 219.72,291.58 MU4.6
N21140140: length 2.2
  BOTTOM w0.305: MU4.4 C298.2 MBD1.2
N21140206: length 5.8
  BOTTOM w0.254: MR1.2 MR7.2 233.49,286.06 233.11,286.43 233.11,287.83 233.57,288.28 MU1.4
N21140226: length 8.1
  BOTTOM w0.381: MR8.1 227.59,299.38 229.17,297.8 MU3.2
  BOTTOM w0.508: MR8.1 224.77,298.34 MR9.1
N21140298: length 1.6
  BOTTOM w0.508: MR13.2 MK2.1
N21140308: length 11.2
  BOTTOM w0.508: MK1.3 225.87,287.7 ; 225.87,287.7 225.87,291 225.24,291.64 MK4.4 MK2.3 ; 225.87,287.7 225.87,285.73 225.3,285.16 MK3.3
N21140322: length 1.3
  BOTTOM w0.508: MK3.1 MR14.1
N21140329: length 1.6
  BOTTOM w0.508: MR16.2 MK4.1
N21140374: length 1.1
  BOTTOM w0.508: MR9.2 MR10.1
N21140376: length 1.6
  BOTTOM w0.508: MR11.2 MK1.1
N21251868: length 1.4
  TOP w0.203: R172.1 v4(238.12,260.7)
  BOTTOM w0.16: v4(238.12,260.7) 238.12,260.47 237.85,260.2 U408.A1
N21251873: length 0.6
  TOP w0.305: v4(237.12,263.2) 237.19,263.13 R661.1
N21251881: length 1.4
  TOP w0.203: R662.1 v4(226.31,260.7)
  BOTTOM w0.16: U409.A1 226.04,260.2 226.31,260.47 v4(226.31,260.7)
N21251886: length 0.6
  TOP w0.305: v4(225.31,263.2) 225.38,263.13 R663.1
N21251935: length 1.1
  TOP w0.254: v4(224.81,261.2) 224.78,261.23 R672.1
  BOTTOM w0.16: U409.C2 v4(224.81,261.2)
N21252012: length 1.1
  TOP w0.254: R659.1 236.59,261.23 v4(236.62,261.2)
  BOTTOM w0.16: U408.C2 v4(236.62,261.2)
N21253598: length 1.4
  TOP w0.203: R1104.1 v4(214.66,252.22)
  BOTTOM w0.16: U455.A1 215.16,251.95 214.9,252.22 v4(214.66,252.22)
N21253603: length 0.6
  TOP w0.305: v4(212.16,251.22) 212.23,251.29 R1101.1
N21253611: length 1.4
  TOP w0.16: R1102.1 v4(214.66,240.65)
  BOTTOM w0.16: v4(214.66,240.65) 214.9,240.65 215.16,240.39 U456.A1
N21253616: length 0.6
  TOP w0.305: R1098.1 212.23,239.72 v4(212.16,239.65)
N21253665: length 1.1
  TOP w0.254: R1108.1 214.13,239.12 v4(214.16,239.15)
  BOTTOM w0.16: U456.C2 v4(214.16,239.15)
N21253742: length 1.1
  TOP w0.254: v4(214.16,250.72) 214.13,250.69 R1105.1
  BOTTOM w0.16: U455.C2 v4(214.16,250.72)
N21593930: length 2.5
  BOTTOM w0.16: U19.8 R204.1
N21594042: length 2.8
  BOTTOM w0.16: 90.88,236.47 R201.1
N21924858: length 1.1
  BOTTOM w0.16: BDB5.1 R234.1
N21924889: length 1.1
  BOTTOM w0.16: BDB6.1 R1117.1
N21924929: length 1.1
  BOTTOM w0.16: v2(210.56,246.46) R1118.1
N21924997: length 1.1
  BOTTOM w0.16: v2(210.56,234.89) R1119.1
N22558345: length 0.8
  BOTTOM w0.16: UNK2U31.15 UNK2R162.1
N22558370: length 3.6
  BOTTOM w0.508: UNK2U108.1 UNK2R511.1 UNK2R510.2
N22558376: length 0.8
  TOP w0.508: v2(267.86,265.29) v2(267.1,265.29)
N22558377: length 2.5
  BOTTOM w0.508: UNK2U108.3 260.34,263.27 259.8,263.81 UNK2R509.1
N22558607: length 2.2
  BOTTOM w0.16: U70.2 543.2,237.13 543.79,237.72 R400.1
N22558620: length 2.5
  BOTTOM w0.508: R404.1 524.81,146.07 525.35,146.61 U71.3
N22558621:
  vias: v1(522.99,153.29)
N22558623: length 3.6
  BOTTOM w0.508: U71.1 R401.1 R402.2
N22558731:
  vias: v2(264.66,244.3) v2(267.25,243)
N22559057: length 1
  BOTTOM w0.16: UNK2U449.6 UNK2R980.1
N22559068: length 2
  BOTTOM w0.16: UNK2U449.9 UNK2R981.2 UNK2R982.2
N22559190: length 2.5
  BOTTOM w0.16: UNK2U19.8 UNK2R204.1
N22559210: length 2.8
  BOTTOM w0.16: 90.88,204.72 UNK2R201.1
N22562598: length 1.4
  TOP w0.203: UNK2R172.1 v4(254.66,252.22)
  BOTTOM w0.16: v4(254.66,252.22) 254.9,252.22 255.16,251.95 UNK2U408.A1
N22562601: length 0.6
  TOP w0.305: UNK2R661.1 252.23,251.29 v4(252.16,251.22)
N22562605: length 1.4
  TOP w0.16: UNK2R662.1 v4(254.66,240.65)
  BOTTOM w0.16: UNK2U409.A1 255.16,240.39 254.9,240.65 v4(254.66,240.65)
N22562608: length 0.6
  TOP w0.305: v4(252.16,239.65) 252.23,239.72 UNK2R663.1
N22562632: length 1.1
  TOP w0.254: UNK2R672.1 254.13,239.12 v4(254.16,239.15)
  BOTTOM w0.16: UNK2U409.C2 v4(254.16,239.15)
N22562670: length 1.1
  TOP w0.254: v4(254.16,250.72) 254.13,250.69 UNK2R659.1
  BOTTOM w0.16: UNK2U408.C2 v4(254.16,250.72)
N22562958:
  vias: v2(250.56,246.46)
N22562960:
  vias: v2(250.56,234.89)
N22566266: length 0.8
  BOTTOM w0.16: UNK3U31.15 UNK3R162.1
N22566291: length 3.6
  BOTTOM w0.508: UNK3U108.1 UNK3R511.1 UNK3R510.2
N22566297: length 14
  TOP w0.508: UNK3TP_MUX_3V3.1 299.85,265.29 v2(307.1,265.29) v2(307.86,265.29)
N22566298: length 2.5
  BOTTOM w0.508: UNK3U108.3 300.34,263.27 299.8,263.81 UNK3R509.1
N22566594:
  vias: v2(304.65,244.3) v2(307.25,243)
N22566920: length 1
  BOTTOM w0.16: UNK3U449.6 UNK3R980.1
N22566931: length 2
  BOTTOM w0.16: UNK3R982.2 UNK3R981.2 UNK3U449.9
N22567053: length 2.5
  BOTTOM w0.16: UNK3U19.8 UNK3R204.1
N22567073: length 2.8
  BOTTOM w0.16: 461.72,208.53 UNK3R201.1
N22570460: length 1.4
  TOP w0.203: UNK3R172.1 v4(294.66,252.22)
  BOTTOM w0.16: UNK3U408.A1 295.16,251.95 294.9,252.22 v4(294.66,252.22)
N22570463: length 0.6
  TOP w0.305: v4(292.16,251.22) 292.23,251.29 UNK3R661.1
N22570467: length 1.4
  TOP w0.16: UNK3R662.1 v4(294.66,240.65)
  BOTTOM w0.16: UNK3U409.A1 295.16,240.39 294.9,240.65 v4(294.66,240.65)
N22570470: length 0.6
  TOP w0.305: UNK3R663.1 292.23,239.72 v4(292.16,239.65)
N22570494: length 1.1
  TOP w0.254: v4(294.16,239.15) 294.13,239.12 UNK3R672.1
  BOTTOM w0.16: UNK3U409.C2 v4(294.16,239.15)
N22570532: length 1.1
  TOP w0.254: UNK3R659.1 294.13,250.69 v4(294.16,250.72)
  BOTTOM w0.16: UNK3U408.C2 v4(294.16,250.72)
N22570820:
  vias: v2(290.56,246.46)
N22570822:
  vias: v2(290.56,234.89)
N22574128: length 0.8
  BOTTOM w0.16: UNK4U31.15 UNK4R162.1
N22574153: length 3.6
  BOTTOM w0.508: UNK4R510.2 UNK4R511.1 UNK4U108.1
N22574159: length 14
  TOP w0.508: v2(347.86,265.29) v2(347.1,265.29) 339.85,265.29 UNK4TP_MUX_3V3.1
N22574160: length 2.5
  BOTTOM w0.508: UNK4R509.1 339.8,263.81 340.34,263.27 UNK4U108.3
N22574456:
  vias: v2(344.65,244.3) v2(347.25,243)
N22574460: length 1.3
  BOTTOM w0.305: UNK4R331.2 UNK4MU4.3
N22574494: length 1.3
  BOTTOM w0.305: UNK4MU4.1 UNK4C299.2
N22574495: length 5.6
  BOTTOM w0.305: UNK4C300.1 340.67,291.37 UNK4MU4.5 ; UNK4C300.1 UNK4C301.1 339.72,291.58 UNK4MU4.6 ; UNK4C300.1 UNK4MR18.1
N22574500: length 2.2
  BOTTOM w0.305: UNK4MU4.4 342.95,292.95 UNK4C298.2 UNK4MBD1.2
N22574529: length 5.8
  BOTTOM w0.254: UNK4MR1.2 UNK4MR7.2 353.48,286.06 353.11,286.43 353.11,287.83 353.57,288.28 UNK4MU1.4
N22574539: length 8.1
  BOTTOM w0.381: UNK4MR8.1 347.59,299.38 349.17,297.8 UNK4MU3.2
  BOTTOM w0.508: UNK4MR8.1 344.77,298.34 UNK4MR9.1
N22574576: length 1.6
  BOTTOM w0.508: UNK4MR13.2 UNK4MK2.1
N22574581: length 11.2
  BOTTOM w0.508: UNK4MK1.3 345.87,287.7 ; 345.87,287.7 345.87,285.73 345.3,285.16 UNK4MK3.3 ; 345.87,287.7 345.87,291 345.24,291.64 UNK4MK4.4 UNK4MK2.3
N22574588: length 1.3
  BOTTOM w0.508: UNK4MK3.1 UNK4MR14.1
N22574592: length 1.6
  BOTTOM w0.508: UNK4MR16.2 UNK4MK4.1
N22574613: length 1.1
  BOTTOM w0.508: UNK4MR9.2 UNK4MR10.1
N22574614: length 1.6
  BOTTOM w0.508: UNK4MR11.2 UNK4MK1.1
N22574782: length 1
  BOTTOM w0.16: UNK4U449.6 UNK4R980.1
N22574793: length 2
  BOTTOM w0.16: UNK4U449.9 UNK4R981.2 UNK4R982.2
N22574915: length 2.5
  BOTTOM w0.16: UNK4U19.8 UNK4R204.1
N22574935: length 2.8
  BOTTOM w0.16: 461.72,240.28 UNK4R201.1
N22578322: length 1.4
  TOP w0.203: UNK4R172.1 v4(334.66,252.22)
  BOTTOM w0.16: UNK4U408.A1 335.16,251.95 334.89,252.22 v4(334.66,252.22)
N22578325: length 0.6
  TOP w0.305: UNK4R661.1 332.23,251.29 v4(332.16,251.22)
N22578329: length 1.4
  TOP w0.16: UNK4R662.1 v4(334.66,240.65)
  BOTTOM w0.16: UNK4U409.A1 335.16,240.39 334.89,240.65 v4(334.66,240.65)
N22578332: length 0.6
  TOP w0.305: UNK4R663.1 332.23,239.72 v4(332.16,239.65)
N22578356: length 1.1
  TOP w0.254: v4(334.16,239.15) 334.13,239.12 UNK4R672.1
  BOTTOM w0.16: UNK4U409.C2 v4(334.16,239.15)
N22578394: length 1.1
  TOP w0.254: UNK4R659.1 334.13,250.69 v4(334.16,250.72)
  BOTTOM w0.16: UNK4U408.C2 v4(334.16,250.72)
N22578682:
  vias: v2(330.56,246.46)
N22578684:
  vias: v2(330.56,234.89)
N22581990: length 0.8
  BOTTOM w0.16: UNK5U31.15 UNK5R162.1
N22582015: length 3.6
  BOTTOM w0.508: UNK5U108.1 UNK5R511.1 UNK5R510.2
N22582021: length 14
  TOP w0.508: v2(227.86,205.29) v2(227.1,205.29) 219.85,205.29 UNK5TP_MUX_3V3.1
N22582022: length 2.5
  BOTTOM w0.508: UNK5U108.3 220.34,203.27 219.8,203.81 UNK5R509.1
N22582318:
  vias: v2(224.66,184.3) v2(227.26,183)
N22582322: length 1.3
  BOTTOM w0.305: UNK5R331.2 UNK5MU4.3
N22582356: length 1.3
  BOTTOM w0.305: UNK5MU4.1 UNK5C299.2
N22582357: length 5.6
  BOTTOM w0.305: UNK5C300.1 240.99,141.7 UNK5MU4.5 ; UNK5C300.1 UNK5C301.1 241.94,141.49 UNK5MU4.6 ; UNK5C300.1 UNK5MR18.1
N22582362: length 2.2
  BOTTOM w0.305: UNK5MBD1.2 UNK5C298.2 238.71,140.12 UNK5MU4.4
N22582391: length 5.8
  BOTTOM w0.254: UNK5MU1.4 228.09,144.79 228.55,145.24 228.55,146.64 228.18,147.01 UNK5MR7.2 UNK5MR1.2
N22582401: length 8.1
  BOTTOM w0.381: UNK5MU3.2 232.49,135.27 234.07,133.69 UNK5MR8.1
  BOTTOM w0.508: UNK5MR8.1 236.89,134.73 UNK5MR9.1
N22582438: length 1.6
  BOTTOM w0.508: UNK5MR13.2 UNK5MK2.1
N22582443: length 11.2
  BOTTOM w0.508: 235.79,145.37 235.79,147.34 236.36,147.91 UNK5MK3.3 ; 235.79,145.37 UNK5MK1.3 ; 235.79,145.37 235.79,142.07 236.42,141.43 UNK5MK4.4 UNK5MK2.3
N22582450: length 1.3
  BOTTOM w0.508: UNK5MK3.1 UNK5MR14.1
N22582454: length 1.6
  BOTTOM w0.508: UNK5MR16.2 UNK5MK4.1
N22582475: length 1.1
  BOTTOM w0.508: UNK5MR9.2 UNK5MR10.1
N22582476: length 1.6
  BOTTOM w0.508: UNK5MR11.2 UNK5MK1.1
N22582644: length 1
  BOTTOM w0.16: UNK5U449.6 UNK5R980.1
N22582655: length 2
  BOTTOM w0.16: UNK5U449.9 UNK5R981.2 UNK5R982.2
N22582777: length 2.5
  BOTTOM w0.16: UNK5U19.8 UNK5R204.1
N22582797: length 2.8
  BOTTOM w0.16: 90.88,172.97 UNK5R201.1
N22586184: length 1.4
  TOP w0.203: UNK5R172.1 v4(214.66,192.22)
  BOTTOM w0.16: v4(214.66,192.22) 214.9,192.22 215.16,191.95 UNK5U408.A1
N22586187: length 0.6
  TOP w0.305: v4(212.16,191.22) 212.23,191.29 UNK5R661.1
N22586191: length 1.4
  TOP w0.16: UNK5R662.1 v4(214.66,180.65)
  BOTTOM w0.16: UNK5U409.A1 215.16,180.39 214.9,180.65 v4(214.66,180.65)
N22586194: length 0.6
  TOP w0.305: UNK5R663.1 212.23,179.72 v4(212.16,179.65)
N22586218: length 1.1
  TOP w0.254: v4(214.16,179.15) 214.13,179.12 UNK5R672.1
  BOTTOM w0.16: UNK5U409.C2 v4(214.16,179.15)
N22586256: length 1.1
  TOP w0.254: UNK5R659.1 214.13,190.69 v4(214.16,190.72)
  BOTTOM w0.16: UNK5U408.C2 v4(214.16,190.72)
N22586544:
  vias: v2(210.56,186.46)
N22586546:
  vias: v2(210.56,174.89)
N22589852: length 0.8
  BOTTOM w0.16: UNK6U31.15 UNK6R162.1
N22589877: length 3.6
  BOTTOM w0.508: UNK6R510.2 UNK6R511.1 UNK6U108.1
N22589883: length 14
  TOP w0.508: v2(267.86,205.29) v2(267.1,205.29) 259.85,205.29 UNK6TP_MUX_3V3.1
N22589884: length 2.5
  BOTTOM w0.508: UNK6R509.1 259.8,203.81 260.34,203.27 UNK6U108.3
N22590180:
  vias: v2(264.66,184.3) v2(267.25,183)
N22590184: length 1.3
  BOTTOM w0.305: UNK6R331.2 UNK6MU4.3
N22590218: length 1.3
  BOTTOM w0.305: UNK6MU4.1 UNK6C299.2
N22590219: length 5.6
  BOTTOM w0.305: UNK6C300.1 UNK6MR18.1 ; UNK6C300.1 UNK6C301.1 281.94,141.49 UNK6MU4.6 ; UNK6C300.1 280.99,141.7 UNK6MU4.5
N22590224: length 2.2
  BOTTOM w0.305: UNK6MBD1.2 UNK6C298.2 278.71,140.12 UNK6MU4.4
N22590253: length 5.8
  BOTTOM w0.254: UNK6MU1.4 268.09,144.79 268.55,145.24 268.55,146.64 268.17,147.01 UNK6MR7.2 UNK6MR1.2
N22590263: length 8.1
  BOTTOM w0.381: UNK6MR8.1 274.07,133.69 272.49,135.27 UNK6MU3.2
  BOTTOM w0.508: UNK6MR8.1 276.89,134.73 UNK6MR9.1
N22590300: length 1.6
  BOTTOM w0.508: UNK6MR13.2 UNK6MK2.1
N22590305: length 11.2
  BOTTOM w0.508: 275.79,145.37 275.79,147.34 276.36,147.91 UNK6MK3.3 ; 275.79,145.37 UNK6MK1.3 ; 275.79,145.37 275.79,142.07 276.42,141.43 UNK6MK4.4 UNK6MK2.3
N22590312: length 1.3
  BOTTOM w0.508: UNK6MK3.1 UNK6MR14.1
N22590316: length 1.6
  BOTTOM w0.508: UNK6MR16.2 UNK6MK4.1
N22590337: length 1.1
  BOTTOM w0.508: UNK6MR9.2 UNK6MR10.1
N22590338: length 1.6
  BOTTOM w0.508: UNK6MR11.2 UNK6MK1.1
N22590506: length 1
  BOTTOM w0.16: UNK6U449.6 UNK6R980.1
N22590517: length 2
  BOTTOM w0.16: UNK6R982.2 UNK6R981.2 UNK6U449.9
N22590639: length 2.5
  BOTTOM w0.16: UNK6U19.8 UNK6R204.1
N22590659: length 2.8
  BOTTOM w0.16: 90.88,141.22 UNK6R201.1
N22594046: length 1.4
  TOP w0.203: UNK6R172.1 v4(254.66,192.22)
  BOTTOM w0.16: UNK6U408.A1 255.16,191.95 254.9,192.22 v4(254.66,192.22)
N22594049: length 0.6
  TOP w0.305: UNK6R661.1 252.23,191.29 v4(252.16,191.22)
N22594053: length 1.4
  TOP w0.16: UNK6R662.1 v4(254.66,180.65)
  BOTTOM w0.16: UNK6U409.A1 255.16,180.39 254.9,180.65 v4(254.66,180.65)
N22594056: length 0.6
  TOP w0.305: v4(252.16,179.65) 252.23,179.72 UNK6R663.1
N22594080: length 1.1
  TOP w0.254: UNK6R672.1 254.13,179.12 v4(254.16,179.15)
  BOTTOM w0.16: UNK6U409.C2 v4(254.16,179.15)
N22594118: length 1.1
  TOP w0.254: UNK6R659.1 254.13,190.69 v4(254.16,190.72)
  BOTTOM w0.16: UNK6U408.C2 v4(254.16,190.72)
N22594406:
  vias: v2(250.56,186.46)
N22594408:
  vias: v2(250.56,174.89)
N22597714: length 0.8
  BOTTOM w0.16: UNK7U31.15 UNK7R162.1
N22597739: length 3.6
  BOTTOM w0.508: UNK7R510.2 UNK7R511.1 UNK7U108.1
N22597745: length 14
  TOP w0.508: v2(307.86,205.29) v2(307.1,205.29) 299.85,205.29 UNK7TP_MUX_3V3.1
N22597746: length 2.5
  BOTTOM w0.508: UNK7U108.3 300.34,203.27 299.8,203.81 UNK7R509.1
N22598042:
  vias: v2(304.65,184.3) v2(307.25,183)
N22598046: length 1.3
  BOTTOM w0.305: UNK7R331.2 UNK7MU4.3
N22598080: length 1.3
  BOTTOM w0.305: UNK7MU4.1 UNK7C299.2
N22598081: length 5.6
  BOTTOM w0.305: UNK7MU4.5 320.99,141.7 UNK7C300.1 ; UNK7C300.1 UNK7MR18.1 ; UNK7C300.1 UNK7C301.1 321.94,141.49 UNK7MU4.6
N22598086: length 2.2
  BOTTOM w0.305: UNK7MBD1.2 UNK7C298.2 318.71,140.12 UNK7MU4.4
N22598115: length 5.8
  BOTTOM w0.254: UNK7MU1.4 308.09,144.79 308.55,145.24 308.55,146.64 308.17,147.01 UNK7MR7.2 UNK7MR1.2
N22598125: length 8.1
  BOTTOM w0.381: UNK7MU3.2 312.49,135.27 314.07,133.69 UNK7MR8.1
  BOTTOM w0.508: UNK7MR8.1 316.89,134.73 UNK7MR9.1
N22598162: length 1.6
  BOTTOM w0.508: UNK7MR13.2 UNK7MK2.1
N22598167: length 11.2
  BOTTOM w0.508: UNK7MK1.3 315.79,145.37 ; 315.79,145.37 315.79,142.07 316.42,141.43 UNK7MK4.4 UNK7MK2.3 ; 315.79,145.37 315.79,147.34 316.36,147.91 UNK7MK3.3
N22598174: length 1.3
  BOTTOM w0.508: UNK7MK3.1 UNK7MR14.1
N22598178: length 1.6
  BOTTOM w0.508: UNK7MR16.2 UNK7MK4.1
N22598199: length 1.1
  BOTTOM w0.508: UNK7MR9.2 UNK7MR10.1
N22598200: length 1.6
  BOTTOM w0.508: UNK7MR11.2 UNK7MK1.1
N22598368: length 1
  BOTTOM w0.16: UNK7U449.6 UNK7R980.1
N22598379: length 2
  BOTTOM w0.16: UNK7U449.9 UNK7R981.2 UNK7R982.2
N22598501: length 2.5
  BOTTOM w0.16: UNK7U19.8 UNK7R204.1
N22598521: length 2.8
  BOTTOM w0.16: 461.72,145.03 UNK7R201.1
  vias: v1(457.94,145.03)
N22601908: length 1.4
  TOP w0.203: UNK7R172.1 v4(294.66,192.22)
  BOTTOM w0.16: UNK7U408.A1 295.16,191.95 294.9,192.22 v4(294.66,192.22)
N22601911: length 0.6
  TOP w0.305: v4(292.16,191.22) 292.23,191.29 UNK7R661.1
N22601915: length 1.4
  TOP w0.16: UNK7R662.1 v4(294.66,180.65)
  BOTTOM w0.16: UNK7U409.A1 295.16,180.39 294.9,180.65 v4(294.66,180.65)
N22601918: length 0.6
  TOP w0.305: v4(292.16,179.65) 292.23,179.72 UNK7R663.1
N22601942: length 1.1
  TOP w0.254: v4(294.16,179.15) 294.13,179.12 UNK7R672.1
  BOTTOM w0.16: UNK7U409.C2 v4(294.16,179.15)
N22601980: length 1.1
  TOP w0.254: v4(294.16,190.72) 294.13,190.69 UNK7R659.1
  BOTTOM w0.16: UNK7U408.C2 v4(294.16,190.72)
N22602268:
  vias: v2(290.56,186.46)
N22602270:
  vias: v2(290.56,174.89)
N22605576: length 0.8
  BOTTOM w0.16: UNK8U31.15 UNK8R162.1
N22605601: length 3.6
  BOTTOM w0.508: UNK8U108.1 UNK8R511.1 UNK8R510.2
N22605607: length 14
  TOP w0.508: v2(347.86,205.29) v2(347.1,205.29) 339.85,205.29 UNK8TP_MUX_3V3.1
N22605608: length 2.5
  BOTTOM w0.508: UNK8R509.1 339.8,203.81 340.34,203.27 UNK8U108.3
N22605904:
  vias: v2(344.65,184.3) v2(347.25,183)
N22605908: length 1.3
  BOTTOM w0.305: UNK8R331.2 UNK8MU4.3
N22605942: length 1.3
  BOTTOM w0.305: UNK8MU4.1 UNK8C299.2
N22605943: length 5.6
  BOTTOM w0.305: UNK8C300.1 360.99,141.7 UNK8MU4.5 ; UNK8C300.1 UNK8C301.1 361.94,141.49 UNK8MU4.6 ; UNK8C300.1 UNK8MR18.1
N22605948: length 2.2
  BOTTOM w0.305: UNK8MBD1.2 UNK8C298.2 UNK8MU4.4
N22605977: length 5.8
  BOTTOM w0.254: UNK8MR1.2 UNK8MR7.2 348.17,147.01 348.55,146.64 348.55,145.24 348.09,144.79 UNK8MU1.4
N22605987: length 8.1
  BOTTOM w0.381: UNK8MU3.2 352.49,135.27 354.07,133.69 UNK8MR8.1
  BOTTOM w0.508: UNK8MR9.1 356.89,134.73 UNK8MR8.1
N22606024: length 1.6
  BOTTOM w0.508: UNK8MR13.2 UNK8MK2.1
N22606029: length 11.2
  BOTTOM w0.508: 355.79,145.37 355.79,147.34 356.36,147.91 UNK8MK3.3 ; 355.79,145.37 355.79,142.07 356.42,141.43 UNK8MK4.4 UNK8MK2.3 ; 355.79,145.37 UNK8MK1.3
N22606036: length 1.3
  BOTTOM w0.508: UNK8MK3.1 UNK8MR14.1
N22606040: length 1.6
  BOTTOM w0.508: UNK8MR16.2 UNK8MK4.1
N22606061: length 1.1
  BOTTOM w0.508: UNK8MR9.2 UNK8MR10.1
N22606062: length 1.6
  BOTTOM w0.508: UNK8MR11.2 UNK8MK1.1
N22606230: length 1
  BOTTOM w0.16: UNK8U449.6 UNK8R980.1
N22606241: length 2
  BOTTOM w0.16: UNK8R982.2 UNK8R981.2 UNK8U449.9
N22606363: length 2.5
  BOTTOM w0.16: UNK8U19.8 UNK8R204.1
N22606383: length 2.8
  BOTTOM w0.16: 461.72,176.78 UNK8R201.1
  vias: v1(457.94,176.78)
N22609770: length 1.4
  TOP w0.203: UNK8R172.1 v4(334.66,192.22)
  BOTTOM w0.16: v4(334.66,192.22) 334.89,192.22 335.16,191.95 UNK8U408.A1
N22609773: length 0.6
  TOP w0.305: UNK8R661.1 332.23,191.29 v4(332.16,191.22)
N22609777: length 1.4
  TOP w0.16: UNK8R662.1 v4(334.66,180.65)
  BOTTOM w0.16: UNK8U409.A1 335.16,180.39 334.89,180.65 v4(334.66,180.65)
N22609780: length 0.6
  TOP w0.305: UNK8R663.1 332.23,179.72 v4(332.16,179.65)
N22609804: length 1.1
  TOP w0.254: UNK8R672.1 334.13,179.12 v4(334.16,179.15)
  BOTTOM w0.16: UNK8U409.C2 v4(334.16,179.15)
N22609842: length 1.1
  TOP w0.254: UNK8R659.1 334.13,190.69 v4(334.16,190.72)
  BOTTOM w0.16: UNK8U408.C2 v4(334.16,190.72)
N22610130:
  vias: v2(330.56,186.46)
N22610132:
  vias: v2(330.56,174.89)
N22614163: length 8
  TOP w0.508: CON1.2 J2.2
N22614200: length 16.1
  TOP w0.508: CON1.1 22.21,147.83 13.32,147.83 J1.2
N23535319:
  vias: v1(41.91,298.45)
N23799274: length 4.2
  BOTTOM w0.16: U74.1 77.97,289.37 78.71,290.12 80.06,290.12 80.26,290.32 U73.2
N23799277: length 5.6
  BOTTOM w0.16: U74.2 77.22,289.84 78.69,291.32 U73.4
N23799280: length 7.2
  BOTTOM w0.16: U74.3 76.57,290.37 78.71,292.52 80.06,292.52 80.26,292.32 U73.6
N23799283: length 5.7
  BOTTOM w0.16: U73.8 82.32,293.09 82.65,293.42 85.52,293.42 86.17,294.07 U72.1
N23799286: length 5.9
  BOTTOM w0.16: U72.2 86.92,293.65 85.09,291.82 U73.10
N23799289: length 7.4
  BOTTOM w0.16: U73.12 85.36,290.82 87.57,293.03 U72.3
N23799348: length 4.2
  BOTTOM w0.16: U77.1 502.88,227.01 503.63,227.75 504.97,227.75 505.17,227.95 U76.2
N23799351: length 5.6
  BOTTOM w0.16: U77.2 502.13,227.47 503.61,228.95 U76.4
N23799354: length 7.2
  BOTTOM w0.16: U77.3 501.48,228 503.63,230.15 504.97,230.15 505.17,229.95 U76.6
N23799357: length 5.7
  BOTTOM w0.16: U75.1 511.08,231.7 510.44,231.06 507.56,231.06 507.23,230.72 U76.8
N23799360: length 5.9
  BOTTOM w0.16: U75.2 511.83,231.28 510,229.45 U76.10
N23799363: length 7.4
  BOTTOM w0.16: U76.12 510.27,228.45 512.48,230.66 U75.3
N30783219: length 4.2
  BOTTOM w0.16: U80.1 77.97,275.66 78.71,276.4 80.06,276.4 80.26,276.6 U79.2
N31842551: length 2.1
  BOTTOM w0.16: R589.1 544.11,236.13 U70.4
N31842593: length 2.1
  BOTTOM w0.16: R590.1 544.11,235.13 U70.6
N31842638: length 2.2
  BOTTOM w0.16: R591.1 543.79,233.53 543.2,234.13 U70.8
N31842671: length 2
  BOTTOM w0.16: U70.17 539.15,236.13 538.75,236.52 R592.1
N31842704: length 1.8
  BOTTOM w0.16: U70.15 R593.1
N31842737: length 2
  BOTTOM w0.16: U70.13 539.15,234.13 538.75,233.73 R594.1
N31842770: length 3.3
  BOTTOM w0.16: R595.1 540.41,232.33 540.94,232.86 U70.11
N31842787: length 2.1
  BOTTOM w0.16: U403.4 544.11,223.17 R596.1
N31842830: length 2.1
  BOTTOM w0.16: R597.1 544.11,222.17 U403.6
N31842855: length 2.2
  BOTTOM w0.16: R598.1 543.79,220.58 543.2,221.17 U403.8
N31842884: length 2
  BOTTOM w0.16: U403.17 539.15,223.17 538.75,223.57 R599.1
N31842923: length 2.2
  BOTTOM w0.16: U403.2 543.2,224.17 543.79,224.77 R603.1
N31842948: length 1.8
  BOTTOM w0.16: U403.15 R600.1

## Copper pours and planes (outline as drawn)
DGND on L02_GND: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02
Net_5 on BOTTOM: 522.61,151.1 521.64,150.14 521.64,149.38 521.87,149.15 523.27,149.15 523.37,149.25 523.37,153.57 523.24,153.7 522.76,153.7 522.61,153.54
Net_6 on BOTTOM: 520.87,149.07 519.18,149.07 519.07,148.97 519.07,147.73 519.53,147.27 520.01,147.27 520.22,147.07 520.22,145.95 520.52,145.64 520.52,145.01 520.65,144.88 524.05,144.88 524.15,144.98 524.15,146.58 523.72,147.02 522,147.02 521.31,147.7 521.31,148.63
Net_7 on BOTTOM: 506.35,226.23 506.35,226 506.45,225.9 508.94,225.9 509.04,226 509.04,226.48 508.91,226.61 507.24,226.61 506.91,226.28 506.4,226.28
Net_8 on BOTTOM: 506.35,208.07 506.35,207.84 506.45,207.74 508.94,207.74 509.04,207.84 509.04,208.33 508.91,208.45 507.24,208.45 506.91,208.12 506.4,208.12
Net_9 on BOTTOM: 480.64,230.94 480.64,233.1 480.26,233.48 474.55,233.48 474.29,233.22 474.29,230.81 474.8,230.3 476.07,230.3 476.58,230.81 480.52,230.81
Net_10 on BOTTOM: 480.64,199.19 480.64,201.35 480.26,201.73 474.55,201.73 474.29,201.47 474.29,199.06 474.8,198.55 476.07,198.55 476.58,199.06 480.52,199.06
Net_11 on BOTTOM: 480.64,167.44 480.64,169.6 480.26,169.98 474.55,169.98 474.29,169.72 474.29,167.31 474.8,166.8 476.07,166.8 476.58,167.31 480.52,167.31
Net_12 on BOTTOM: 480.64,135.69 480.64,137.85 480.26,138.23 474.55,138.23 474.29,137.97 474.29,135.56 474.8,135.05 476.07,135.05 476.58,135.56 480.52,135.56
Net_13 on BOTTOM: 474.29,229.92 469.34,229.92 468.45,229.03 468.45,225.98 468.83,225.6 470.61,225.6 470.99,225.98 470.99,227.63 471.5,228.14 473.91,228.14 474.42,228.65 474.42,229.79
Net_14 on BOTTOM: 474.29,198.17 469.34,198.17 468.45,197.28 468.45,194.23 468.83,193.85 470.61,193.85 470.99,194.23 470.99,195.88 471.5,196.39 473.91,196.39 474.42,196.9 474.42,198.04
Net_15 on BOTTOM: 474.29,166.42 469.34,166.42 468.45,165.53 468.45,162.48 468.83,162.1 470.61,162.1 470.99,162.48 470.99,164.13 471.5,164.64 473.91,164.64 474.42,165.15 474.42,166.29
Net_16 on BOTTOM: 474.29,134.67 469.34,134.67 468.45,133.78 468.45,130.73 468.83,130.35 470.61,130.35 470.99,130.73 470.99,132.38 471.5,132.89 473.91,132.89 474.42,133.4 474.42,134.54
Net_17 on BOTTOM: 389.72,234.63 389.72,241.01 389.16,241.57 380.88,241.57 380.51,241.2 380.51,234.54 381.04,234.02 389.11,234.02
Net_18 on BOTTOM: 378.74,291.04 372.36,291.04 371.8,290.48 371.8,282.2 372.17,281.83 378.82,281.83 379.35,282.36 379.35,290.43
Net_19 on BOTTOM: 356.78,243.1 356.78,239.52 355.41,238.15 351.17,238.15 349.69,236.68 349.69,218.41 350.23,217.88 357.87,217.88 358.89,218.9 358.89,223.06 360.73,224.91 360.73,245.04 360.33,245.45 359.28,245.45 358.89,245.05 358.89,243.47 358.61,243.2 356.87,243.2 ; 1 cut-out
Net_20 on BOTTOM: 356.78,183.1 356.78,179.52 355.41,178.15 351.17,178.15 349.69,176.68 349.69,158.41 350.23,157.88 357.87,157.88 358.89,158.9 358.89,163.06 360.73,164.91 360.73,185.04 360.33,185.45 359.28,185.45 358.89,185.05 358.89,183.47 358.61,183.2 356.87,183.2 ; 1 cut-out
Net_21 on BOTTOM: 348.27,265.86 348.22,265.91 346.8,265.91 346.69,266.01 344.84,266.01 343.88,266.98 343.11,266.98 342.88,266.75 342.88,265.35 342.99,265.25 346.16,265.25 346.8,264.62 348.19,264.62 348.27,264.69
Net_22 on BOTTOM: 346.94,252.04 346.94,263.11 347.68,263.85 348.51,263.85 349.03,264.38 349.03,267.46 348.6,267.89 348.6,273.74 349.72,274.85 354.01,274.85 354.64,274.22 354.64,267.04 356.94,264.75 356.94,253.6 355.94,252.6 353.93,252.6 351.9,250.57 349.23,250.57 349.11,250.7 349.11,250.95 349.48,251.33 351.31,251.33 351.39,251.42 351.39,251.92 350.38,251.92 350.37,251.91 350.36,251.92 347.06,251.92 ; 2 cut-outs
Net_23 on BOTTOM: 348.27,205.86 348.22,205.91 346.8,205.91 346.69,206.01 344.84,206.01 343.88,206.98 343.11,206.98 342.88,206.75 342.88,205.35 342.99,205.25 346.16,205.25 346.8,204.62 348.19,204.62 348.27,204.69
Net_24 on BOTTOM: 346.94,192.04 346.94,203.11 347.68,203.85 348.51,203.85 349.03,204.38 349.03,207.46 348.6,207.89 348.6,213.74 349.72,214.85 354.01,214.85 354.64,214.22 354.64,207.04 356.94,204.75 356.94,193.6 355.94,192.6 353.93,192.6 351.9,190.57 349.23,190.57 349.11,190.7 349.11,190.95 349.48,191.33 351.31,191.33 351.39,191.42 351.39,191.92 350.38,191.92 350.37,191.91 350.36,191.92 347.06,191.92 ; 2 cut-outs
Net_25 on BOTTOM: 342.81,267.75 342.81,269.44 342.71,269.54 341.46,269.54 341.01,269.09 341.01,268.61 340.8,268.4 339.68,268.4 339.38,268.1 338.74,268.1 338.62,267.97 338.62,264.57 338.72,264.46 340.32,264.46 340.75,264.9 340.75,266.62 341.44,267.31 342.37,267.31
Net_26 on BOTTOM: 342.81,207.75 342.81,209.44 342.71,209.54 341.46,209.54 341.01,209.09 341.01,208.61 340.8,208.4 339.68,208.4 339.38,208.1 338.74,208.1 338.62,207.97 338.62,204.57 338.72,204.46 340.32,204.46 340.75,204.9 340.75,206.62 341.44,207.31 342.37,207.31
Net_27 on BOTTOM: 331.89,145.89 338.27,145.89 338.82,146.44 338.82,154.72 338.45,155.09 331.8,155.09 331.28,154.57 331.28,146.5
Net_28 on BOTTOM: 306.94,252.04 306.94,263.11 307.68,263.85 308.51,263.85 309.03,264.38 309.03,267.46 308.6,267.89 308.6,273.74 309.72,274.85 314.01,274.85 314.65,274.22 314.65,267.04 316.94,264.75 316.94,253.6 315.94,252.6 313.93,252.6 311.9,250.57 309.23,250.57 309.11,250.7 309.11,250.95 309.48,251.33 311.31,251.33 311.39,251.42 311.39,251.92 310.38,251.92 310.37,251.91 310.36,251.92 307.06,251.92 ; 2 cut-outs
Net_29 on BOTTOM: 316.78,243.1 316.78,239.52 315.41,238.15 311.17,238.15 309.69,236.68 309.69,218.41 310.23,217.88 317.87,217.88 318.89,218.9 318.89,223.06 320.73,224.91 320.73,245.04 320.33,245.45 319.28,245.45 318.89,245.05 318.89,243.47 318.61,243.2 316.87,243.2 ; 1 cut-out
Net_30 on BOTTOM: 306.94,192.04 306.94,203.11 307.68,203.85 308.51,203.85 309.03,204.38 309.03,207.46 308.6,207.89 308.6,213.74 309.72,214.85 314.01,214.85 314.65,214.22 314.65,207.04 316.94,204.75 316.94,193.6 315.94,192.6 313.93,192.6 311.9,190.57 309.23,190.57 309.11,190.7 309.11,190.95 309.48,191.33 311.31,191.33 311.39,191.42 311.39,191.92 310.38,191.92 310.37,191.91 310.36,191.92 307.06,191.92 ; 2 cut-outs
Net_31 on BOTTOM: 316.78,183.1 316.78,179.52 315.41,178.15 311.17,178.15 309.69,176.68 309.69,158.41 310.23,157.88 317.87,157.88 318.89,158.9 318.89,163.06 320.73,164.91 320.73,185.04 320.33,185.45 319.28,185.45 318.89,185.05 318.89,183.47 318.61,183.2 316.87,183.2 ; 1 cut-out
Net_32 on BOTTOM: 308.27,265.86 308.22,265.91 306.8,265.91 306.69,266.01 304.84,266.01 303.88,266.98 303.11,266.98 302.88,266.75 302.88,265.35 302.99,265.25 306.16,265.25 306.8,264.62 308.19,264.62 308.27,264.69
Net_33 on BOTTOM: 308.27,205.86 308.22,205.91 306.8,205.91 306.69,206.01 304.84,206.01 303.88,206.98 303.11,206.98 302.88,206.75 302.88,205.35 302.99,205.25 306.16,205.25 306.8,204.62 308.19,204.62 308.27,204.69
Net_34 on BOTTOM: 302.81,267.75 302.81,269.44 302.71,269.54 301.46,269.54 301.01,269.09 301.01,268.61 300.8,268.4 299.68,268.4 299.38,268.1 298.74,268.1 298.62,267.97 298.62,264.57 298.72,264.46 300.32,264.46 300.75,264.9 300.75,266.62 301.44,267.31 302.37,267.31
Net_35 on BOTTOM: 302.81,207.75 302.81,209.44 302.71,209.54 301.46,209.54 301.01,209.09 301.01,208.61 300.8,208.4 299.68,208.4 299.38,208.1 298.74,208.1 298.62,207.97 298.62,204.57 298.72,204.46 300.32,204.46 300.75,204.9 300.75,206.62 301.44,207.31 302.37,207.31
Net_36 on BOTTOM: 291.89,145.89 298.27,145.89 298.82,146.44 298.82,154.72 298.46,155.09 291.8,155.09 291.28,154.57 291.28,146.5
Net_37 on BOTTOM: 266.94,252.04 266.94,263.11 267.69,263.85 268.51,263.85 269.03,264.38 269.03,267.46 268.6,267.89 268.6,273.74 269.72,274.85 274.01,274.85 274.65,274.22 274.65,267.04 276.94,264.75 276.94,253.6 275.94,252.6 273.93,252.6 271.9,250.57 269.23,250.57 269.11,250.7 269.11,250.95 269.48,251.33 271.31,251.33 271.39,251.42 271.39,251.92 270.38,251.92 270.37,251.91 270.36,251.92 267.06,251.92 ; 2 cut-outs
Net_38 on BOTTOM: 276.78,243.1 276.78,239.52 275.41,238.15 271.17,238.15 269.69,236.68 269.69,218.41 270.23,217.88 277.87,217.88 278.89,218.9 278.89,223.06 280.73,224.91 280.73,245.04 280.33,245.45 279.28,245.45 278.89,245.05 278.89,243.47 278.61,243.2 276.87,243.2 ; 1 cut-out
Net_39 on BOTTOM: 266.94,192.04 266.94,203.11 267.69,203.85 268.51,203.85 269.03,204.38 269.03,207.46 268.6,207.89 268.6,213.74 269.72,214.85 274.01,214.85 274.65,214.22 274.65,207.04 276.94,204.75 276.94,193.6 275.94,192.6 273.93,192.6 271.9,190.57 269.23,190.57 269.11,190.7 269.11,190.95 269.48,191.33 271.31,191.33 271.39,191.42 271.39,191.92 270.38,191.92 270.37,191.91 270.36,191.92 267.06,191.92 ; 2 cut-outs
Net_40 on BOTTOM: 276.78,183.1 276.78,179.52 275.41,178.15 271.17,178.15 269.69,176.68 269.69,158.41 270.23,157.88 277.87,157.88 278.89,158.9 278.89,163.06 280.73,164.91 280.73,185.04 280.33,185.45 279.28,185.45 278.89,185.05 278.89,183.47 278.61,183.2 276.87,183.2 ; 1 cut-out
Net_41 on BOTTOM: 268.27,265.86 268.22,265.91 266.8,265.91 266.69,266.01 264.84,266.01 263.88,266.98 263.11,266.98 262.88,266.75 262.88,265.35 262.99,265.25 266.16,265.25 266.8,264.62 268.19,264.62 268.27,264.69
Net_42 on BOTTOM: 268.27,205.86 268.22,205.91 266.8,205.91 266.69,206.01 264.84,206.01 263.88,206.98 263.11,206.98 262.88,206.75 262.88,205.35 262.99,205.25 266.16,205.25 266.8,204.62 268.19,204.62 268.27,204.69
Net_43 on BOTTOM: 262.81,267.75 262.81,269.44 262.71,269.54 261.46,269.54 261.01,269.09 261.01,268.61 260.8,268.4 259.68,268.4 259.38,268.1 258.74,268.1 258.62,267.97 258.62,264.57 258.72,264.46 260.32,264.46 260.75,264.9 260.75,266.62 261.44,267.31 262.37,267.31
Net_44 on BOTTOM: 262.81,207.75 262.81,209.44 262.71,209.54 261.46,209.54 261.01,209.09 261.01,208.61 260.8,208.4 259.68,208.4 259.38,208.1 258.74,208.1 258.62,207.97 258.62,204.57 258.72,204.46 260.32,204.46 260.75,204.9 260.75,206.62 261.44,207.31 262.37,207.31
Net_45 on BOTTOM: 251.89,145.89 258.27,145.89 258.82,146.44 258.82,154.72 258.46,155.09 251.8,155.09 251.28,154.57 251.28,146.5
Net_47 on BOTTOM: 236.78,243.1 236.78,239.52 235.41,238.15 231.17,238.15 229.69,236.68 229.69,218.41 230.23,217.88 237.87,217.88 238.89,218.9 238.89,223.06 240.73,224.91 240.73,245.04 240.33,245.45 239.28,245.45 238.89,245.05 238.89,243.47 238.61,243.2 236.87,243.2 ; 1 cut-out
Net_48 on BOTTOM: 226.94,192.04 226.94,203.11 227.69,203.85 228.51,203.85 229.03,204.38 229.03,207.46 228.6,207.89 228.6,213.74 229.72,214.85 234.01,214.85 234.65,214.22 234.65,207.04 236.94,204.75 236.94,193.6 235.94,192.6 233.93,192.6 231.9,190.57 229.23,190.57 229.11,190.7 229.11,190.95 229.48,191.33 231.31,191.33 231.39,191.42 231.39,191.92 230.38,191.92 230.37,191.91 230.36,191.92 227.06,191.92 ; 2 cut-outs
Net_49 on BOTTOM: 236.78,183.1 236.78,179.52 235.41,178.15 231.17,178.15 229.69,176.68 229.69,158.41 230.23,157.88 237.87,157.88 238.89,158.9 238.89,163.06 240.73,164.91 240.73,185.04 240.33,185.45 239.28,185.45 238.89,185.05 238.89,183.47 238.61,183.2 236.87,183.2 ; 1 cut-out
Net_52 on BOTTOM: 228.27,205.86 228.22,205.91 226.8,205.91 226.69,206.01 224.84,206.01 223.88,206.98 223.11,206.98 222.88,206.75 222.88,205.35 222.99,205.25 226.16,205.25 226.8,204.62 228.19,204.62 228.27,204.69
Net_53 on BOTTOM: 222.81,207.75 222.81,209.44 222.71,209.54 221.46,209.54 221.01,209.09 221.01,208.61 220.8,208.4 219.68,208.4 219.38,208.1 218.74,208.1 218.62,207.97 218.62,204.57 218.72,204.46 220.32,204.46 220.75,204.9 220.75,206.62 221.44,207.31 222.37,207.31
Net_54 on BOTTOM: 211.89,145.89 218.27,145.89 218.82,146.44 218.82,154.72 218.46,155.09 211.8,155.09 211.28,154.57 211.28,146.5
Net_55 on BOTTOM: 208.36,291.04 201.98,291.04 201.42,290.48 201.42,282.2 201.79,281.83 208.44,281.83 208.97,282.36 208.97,290.43
Net_56 on BOTTOM: 191.91,232.53 191.91,226.15 192.47,225.59 200.75,225.59 201.12,225.96 201.12,232.61 200.59,233.14 192.52,233.14
Net_57 on BOTTOM: 109.8,227.13 109.8,229.29 109.42,229.67 103.71,229.67 103.45,229.41 103.45,227 103.96,226.49 105.23,226.49 105.74,227 109.68,227
Net_58 on BOTTOM: 109.8,195.38 109.8,197.54 109.42,197.92 103.71,197.92 103.45,197.66 103.45,195.25 103.96,194.74 105.23,194.74 105.74,195.25 109.68,195.25
Net_59 on BOTTOM: 109.8,163.63 109.8,165.79 109.42,166.17 103.71,166.17 103.45,165.91 103.45,163.5 103.96,162.99 105.23,162.99 105.74,163.5 109.68,163.5
Net_60 on BOTTOM: 109.8,131.88 109.8,134.04 109.42,134.42 103.71,134.42 103.45,134.16 103.45,131.75 103.96,131.24 105.23,131.24 105.74,131.75 109.68,131.75
Net_61 on BOTTOM: 103.45,226.11 98.5,226.11 97.61,225.22 97.61,222.17 97.99,221.79 99.77,221.79 100.15,222.17 100.15,223.82 100.66,224.33 103.07,224.33 103.58,224.84 103.58,225.98
Net_62 on BOTTOM: 103.45,194.36 98.5,194.36 97.61,193.47 97.61,190.42 97.99,190.04 99.77,190.04 100.15,190.42 100.15,192.07 100.66,192.58 103.07,192.58 103.58,193.09 103.58,194.23
Net_63 on BOTTOM: 103.45,162.61 98.5,162.61 97.61,161.72 97.61,158.67 97.99,158.29 99.77,158.29 100.15,158.67 100.15,160.32 100.66,160.83 103.07,160.83 103.58,161.34 103.58,162.48
Net_64 on BOTTOM: 103.45,130.86 98.5,130.86 97.61,129.97 97.61,126.92 97.99,126.54 99.77,126.54 100.15,126.92 100.15,128.57 100.66,129.08 103.07,129.08 103.58,129.59 103.58,130.73
Net_65 on BOTTOM: 81.43,288.59 81.43,288.37 81.53,288.26 84.02,288.26 84.12,288.37 84.12,288.85 84,288.98 82.33,288.98 82,288.65 81.48,288.65
Net_66 on BOTTOM: 81.43,274.88 81.43,274.65 81.53,274.55 84.02,274.55 84.12,274.65 84.12,275.13 84,275.26 82.33,275.26 82,274.93 81.48,274.93
Net_67 on BOTTOM: 81.43,261.16 81.43,260.93 81.53,260.83 84.02,260.83 84.12,260.93 84.12,261.42 84,261.54 82.33,261.54 82,261.21 81.48,261.21
