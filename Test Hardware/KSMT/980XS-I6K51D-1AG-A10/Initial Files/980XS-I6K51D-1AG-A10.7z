# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S3_DCH089:
  vias: v2(314.41,244.96)
S3_DCH108: length 1.4
  BOTTOM w0.16: UNK3K32.2 v2(317.83,232.39)
S3_DCH109: length 1.4
  BOTTOM w0.16: UNK3K32.7 v2(313.63,232.39)
S3_DCH110: length 0.7
  BOTTOM w0.16: UNK3U449.3 v2(312.19,271.11)
S3_DCH111: length 0.9
  BOTTOM w0.16: v2(313.18,271.1) 312.69,270.61 UNK3U449.4
S3_DPS3:
  vias: v2(307.9,244.96) v2(311.15,250.15) v2(311.8,250.15) v2(312.46,250.15) v2(312.46,246.26) v2(312.46,244.3) v2(313.11,250.15) v2(313.76,243.65)
S3_DPS4:
  vias: v2(306.6,250.15) v2(306.6,245.61) v2(313.76,244.96)
S3_MPDCH03+: length 1.3
  BOTTOM w0.165: UNK3U31.2 306.28,232.65 v2(306.41,232.52)
S3_MPDCH03-: length 1.3
  BOTTOM w0.165: v2(305.75,232.52) 305.88,232.65 UNK3U31.3
S3_MPDCH05:
  vias: v2(309.2,246.26)
S3_MPDCH25:
  vias: v2(306.6,242.35)
S3_MPDCH26:
  vias: v2(306.6,241.7)
S3_MPDCH34:
  vias: v2(307.1,269) v2(307.86,269)
S3_MPDCH37+:
  vias: v4(291.66,251.22)
S3_MPDCH37-:
  vias: v4(291.16,251.22)
S3_MPDCH39+:
  vias: v4(291.66,250.22)
S3_MPDCH39-:
  vias: v4(291.16,250.22)
S3_MPDCH41+: length 0.5
  BOTTOM w0.16: UNK3U408.E8 v4(292.16,249.72)
S3_MPDCH41-: length 0.5
  BOTTOM w0.16: UNK3U408.E9 v4(290.66,249.72)
S3_MPDCH43+:
  vias: v4(291.66,239.65)
S3_MPDCH43-:
  vias: v4(291.16,239.65)
S3_MPDCH45+:
  vias: v4(291.66,238.65)
S3_MPDCH45-:
  vias: v4(291.16,238.65)
S3_MPDCH47+: length 0.5
  BOTTOM w0.16: UNK3U409.E8 v4(292.16,238.15)
S3_MPDCH47-: length 0.5
  BOTTOM w0.16: UNK3U409.E9 v4(290.66,238.15)
S3_MPDCH52:
  vias: v2(313.76,241.71)
S3_MPDCH56:
  vias: v2(307.9,246.26)
S3_MPDCH57:
  vias: v2(313.76,243)
S3_MPDCH59:
  vias: v2(313.76,242.36)
S3_MPDCH62:
  vias: v2(315.05,244.96)
S3_MPDCH63:
  vias: v2(313.76,246.91)
S3_MPDCH65:
  vias: v2(315.05,247.56)
S3_MPDCH66:
  vias: v2(315.05,246.91)
S3_MPDCH75:
  vias: v2(315.05,246.26)
S3_MPDCH77:
  vias: v2(313.76,246.26)
S3_MPDCH85:
  vias: v2(313.11,246.26)
S3_MUX_3V3: length 1.5
  TOP w0.508: v2(307.1,267.19) v2(307.86,267.19)
  BOTTOM w0.508: v2(307.86,267.19) UNK3R512.1 v2(307.1,267.19)
  vias: v2(302.48,232.36) v2(309.83,272.29)
S3_OUT_RX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK3U408.B2 295,250.88 296.57,250.88 297.06,251.37 297.06,251.91 v2(297.22,252.07)
S3_OUT_RX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK3U408.B1 295.19,251.25 296.41,251.25 296.68,251.52 296.68,251.9 v2(296.51,252.07)
S3_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK3U408.B4 294.15,251.71 294.15,252.41 294.44,252.7 294.94,252.7 295.3,253.05 295.3,253.77 UNK3R647.1
S3_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK3U408.A4 293.78,251.83 293.78,252.57 294.28,253.07 294.79,253.07 294.92,253.21 294.92,253.38 294.81,253.5 294.45,253.5 294.38,253.57 294.38,253.78 294.46,253.86 UNK3R646.1
S3_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK3C309.1 UNK3R646.2 UNK3R647.2
S3_OUT_RX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(297.22,249.36) 297.05,249.53 297.05,250.08 296.56,250.57 295.02,250.57 UNK3U408.D2
  vias: v2(309.85,247.56)
S3_OUT_RX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(296.51,249.36) 296.68,249.53 296.68,249.93 296.41,250.2 295.18,250.2 UNK3U408.D1
S3_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 293.41,251.97 293.41,251.47 UNK3U408.B5
  BOTTOM w0.132: UNK3R168.1 293.82,253.7 293.82,253.24 293.41,252.83 293.41,251.97
S3_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK3R170.1 293.45,253.7 293.45,253.39 293.2,253.14 292.82,253.14 292.69,253.01 292.69,252.82 292.82,252.69 292.91,252.69 293.04,252.56 293.04,251.84 UNK3U408.A5
S3_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK3R170.2 UNK3R168.2 UNK3C310.1
S3_OUT_RX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK3U408.E2 v2(294.16,249.72)
S3_OUT_RX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK3U408.E1 v2(295.66,249.72)
S3_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK3U408.B6 292.28,251.59 292.28,252.14 291.8,252.62 291.8,253.7 UNK3R176.1
S3_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK3U408.A6 292.66,251.72 292.66,251.73 292.66,252.29 292.17,252.78 292.17,253.1 292.47,253.4 292.66,253.4 292.77,253.51 292.77,253.73 292.64,253.86 UNK3R178.1
S3_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK3R178.2 UNK3R176.2 UNK3C318.1
S3_OUT_RX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(297.22,240.5) 297.06,240.34 297.06,239.8 296.57,239.31 295,239.31 UNK3U409.B2
  vias: v2(308.55,247.56)
S3_OUT_RX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(296.51,240.5) 296.68,240.34 296.68,239.96 296.41,239.69 295.19,239.69 UNK3U409.B1
S3_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK3R1089.1 295.3,242.21 295.3,241.48 294.94,241.13 294.44,241.13 294.15,240.85 294.15,240.14 UNK3U409.B4
S3_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK3R1088.1 294.46,242.3 294.38,242.21 294.38,242 294.45,241.93 294.81,241.93 294.92,241.81 294.92,241.64 294.79,241.51 294.28,241.51 293.78,241 293.78,240.27 UNK3U409.A4
S3_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK3C302.1 UNK3R1088.2 UNK3R1089.2
S3_OUT_RX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK3U409.D2 295.02,239.01 296.56,239.01 297.05,238.51 297.05,237.96 v2(297.22,237.8)
S3_OUT_RX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(296.51,237.8) 296.68,237.96 296.68,238.36 296.41,238.63 295.18,238.63 UNK3U409.D1
  vias: v2(307.9,247.56)
S3_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK3U409.B5 293.41,239.9 293.41,240.41
  BOTTOM w0.132: 293.41,240.41 293.41,241.26 293.82,241.67 293.82,242.13 UNK3R180.1
S3_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK3R182.1 293.45,242.13 293.45,241.83 293.2,241.57 292.82,241.57 292.69,241.44 292.69,241.25 292.82,241.12 292.91,241.12 293.04,240.99 293.04,240.27 UNK3U409.A5
S3_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK3C320.1 UNK3R180.2 UNK3R182.2
S3_OUT_RX0_CH5_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK3U409.E2 v2(294.16,238.15)
S3_OUT_RX0_CH5_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK3U409.E1 v2(295.66,238.15)
S3_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK3U409.B6 292.28,240.03 292.28,240.57 291.8,241.06 291.8,242.13 UNK3R666.1
S3_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK3R664.1 292.64,242.3 292.77,242.17 292.77,241.94 292.66,241.84 292.47,241.84 292.17,241.53 292.17,241.21 292.66,240.72 292.66,240.15 UNK3U409.A6
S3_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK3C924.1 UNK3R666.2 UNK3R664.2
S3_OUT_TX0_CH0_ABC_CASE-:
  vias: v2(306.6,247.56)
S3_OUT_TX0_CH1_ABC_CASE+:
  vias: v2(306.6,246.91)
S3_OUT_TX0_CH2_ABC_CASE-:
  vias: v2(306.6,246.26)
S3_PWR_F001:
  vias: v2(315.05,250.15)
S3_PWR_F004:
  vias: v2(311.81,247.56)
S3_PWR_F005:
  vias: v2(307.9,242.35) v2(312.46,243) v2(313.11,243.01) v2(315.05,243)
S3_PWR_F006:
  vias: v2(310.5,240.4) v2(311.81,241.7) v2(312.46,241.06)
S3_PWR_F007:
  vias: v2(309.85,241.05) v2(310.5,241.7) v2(311.16,241.7)
S3_PWR_F008:
  vias: v2(313.76,244.31)
S3_PWR_M_F001:
  vias: v2(308.55,241.7) v2(308.55,241.06) v2(308.55,239.1) v2(309.2,245.61) v2(309.2,244.96) v2(309.85,244.96) v2(310.5,250.15) v2(310.5,246.91) v2(310.5,246.26) v2(310.5,245.61) v2(310.5,244.3) v2(311.16,246.26) v2(311.16,245.61) v2(311.16,244.96) v2(311.16,244.3) v2(311.81,244.96) v2(311.81,239.1)
S3_SPI_CK_ABCD_CASE:
  vias: v2(315.05,241.7)
S3_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: 461.72,205.99 463.83,205.99 465.91,208.08 465.91,213.03 464.48,214.46 464.48,221.02 465.62,222.16 480.33,222.16 UNK3K3.7
S3_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK3K3.5 481.93,206.47 481.45,205.99 UNK3U19.6
S3_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: UNK3K3.2 483.53,222.16 468.66,222.16 467.65,221.15 467.65,213.95 v1(473.08,208.53)
  BOTTOM w0.16: v1(473.08,208.53) 470.57,208.53
S3_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK3K3.4 485.13,210.45 487.05,208.53 UNK3U19.1 UNK3R205.2
S3_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: 461.72,204.72 463.95,204.72 467.65,208.42 467.65,218.98 UNK3K5.7
S3_SPI_DI_D_CASE: length 18.5
  TOP w0.16: UNK3K5.5 474.78,210.6 477.61,210.6 478.59,209.62 v1(478.59,204.72)
  BOTTOM w0.16: UNK3U19.5 v1(478.59,204.72)
S3_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: 470.57,207.26 474.93,207.26 475.7,208.03 475.7,211.18 474,212.88 474,218.98 UNK3K5.2
S3_SPI_DO_D_CASE: length 24.7
  TOP w0.16: v1(491.9,207.26) 486.53,207.26 479.29,214.5 474.09,214.5 UNK3K5.4
  BOTTOM w0.16: UNK3U19.2 v1(491.9,207.26)
S3_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK3K7.2 461.3,218.98 461.3,214.34 464.57,211.07 464.57,207.87 463.95,207.26 UNK3R202.1
S3_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: v1(477.62,207.26) 476.98,207.9 467.99,207.9 UNK3K7.4
  BOTTOM w0.16: UNK3U19.7 v1(477.62,207.26)
S3_SPI_WPZ_C_CASE: length 27
  TOP w0.16: UNK3K7.7 458.13,218.96 458.13,215.75 467.89,205.99 v1(473.08,205.99)
  BOTTOM w0.16: v1(473.08,205.99) 470.57,205.99
S3_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: v1(491.9,205.99) 488.47,202.56 470.12,202.56 UNK3K7.5
  BOTTOM w0.16: UNK3R207.2 v1(491.9,205.99) UNK3U19.3
S3_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK3U31.6 304.19,234.3 303.94,234.06 UNK3R164.2
S3_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK3R163.2 303.84,233.14 304.6,233.9 UNK3U31.5
S3_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK3U31.16 307.91,233.9 UNK3R165.2
S3_USB_D_AB_CASE+: length 1.3
  BOTTOM w0.165: v2(306.01,236.49) 305.88,236.36 UNK3U31.10
S3_USB_D_AB_CASE-: length 1.3
  BOTTOM w0.165: UNK3U31.9 305.48,236.36 v2(305.35,236.49)
S3_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK3U31.8 303.85,235.1 UNK3R160.2
S3_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK3R161.2 303.85,234.7 UNK3U31.7
S3_USER_3V3: length 2.6
  BOTTOM w0.305: UNK3R205.1 v1(494.28,208.53) ; UNK3R200.1 v1(474.47,208.53) ; UNK3R207.1 v1(494.28,205.99) ; UNK3R203.1 v1(474.47,205.99)
  vias: v1(457.94,209.8) v1(457.94,208.53) v1(457.94,207.26) v1(458.42,211.4) v1(470.92,197.64) v1(472.58,197.91) v1(476.37,209.8) v1(476.62,208.53) v1(476.62,207.26) v1(476.84,211.4)
S3_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: UNK3K32.3 317.03,230.19 316.33,230.9 316.33,236.15 319.01,238.84 319.01,243.18 318.02,244.17 315.57,244.17 315.35,243.95 v2(315.05,243.65)
S3_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK3K32.4 UNK3R135.1
S3_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK3R135.2 UNK3R136.2 UNK3C267.1 316.55,224.48 317.49,223.54 317.49,220.49 316.93,219.93 UNK3Y1.3
S3_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: v2(315.7,243.65) 317,243.65 317.6,243.06 317.6,239.33 314.98,236.7 314.98,230.89 314.28,230.19 UNK3K32.6
S3_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK3K32.5 UNK3R137.1
S3_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK3R137.2 UNK3R136.1 UNK3C268.1 311.69,224.48 311.29,224.07 311.29,222.72 UNK3Y1.1
S3_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(314.03,257.96) 314.03,267.56 313.31,268.29 v2(312.49,268.29)
  BOTTOM w0.16: UNK3K29.7 v2(314.03,257.96) ; UNK3U449.7 312.19,268.59 v2(312.49,268.29)
S3_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 309.6,249.25 v2(309.2,248.85)
  BOTTOM w0.16: 309.6,249.25 309.85,249.5 309.85,251.04 310.61,251.79 311.11,251.79 312.71,253.39 312.71,259.49 313.38,260.16 UNK3K29.6
S3_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK3C271.1 313.19,266.93 UNK3Y2.1 313.19,263.05 313.88,262.36 UNK3K29.5
S3_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK3U449.2 311.69,271.81 UNK3R973.2 311.92,273.09 UNK3R923.1
S3_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(309.84,257.96) 309.84,267.56 310.56,268.29 v2(311.38,268.29)
  BOTTOM w0.16: UNK3K29.2 v2(309.84,257.96) ; UNK3U449.8 311.69,268.59 v2(311.38,268.29)
S3_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: v2(309.2,249.5) 309.2,251.87 311.34,254.01 311.34,259.45 310.64,260.16 UNK3K29.3
S3_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK3C272.1 310.69,266.93 UNK3Y2.2 310.69,263.05 309.99,262.36 UNK3K29.4
S3_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK3R652.1 310.92,273.09 UNK3R973.1 311.19,271.78 UNK3U449.1
S4_0V5: length 41.7
  BOTTOM w0.305: 353.24,296.07 353.44,295.87 UNK4C288.1 353.49,295.89 353.67,296.07
  BOTTOM w0.381: UNK4MU3.3 352.17,297.15 352.29,297.03
  BOTTOM w0.508: UNK4MK1.4 339.18,288.97 338.56,289.59 338.56,297.47 341.47,300.38 353.63,300.38 354.25,299.77 UNK4MR4.1 ; 353.24,296.07 352.29,297.02 352.29,297.03 ; 353.67,296.07 354.32,296.72 UNK4C286.1 354.32,298.29 UNK4MR3.1 UNK4MR4.1 ; UNK4MR2.2 UNK4MR6.1 UNK4MR5.1 UNK4MR4.1
S4_0V25: length 2.8
  BOTTOM w0.508: UNK4MK4.3 344.45,290.44 UNK4MR19.1 341.88,290.44 UNK4MR18.2
S4_0V75: length 4.9
  BOTTOM w0.381: UNK4MU3.6 UNK4MR10.2
  BOTTOM w0.508: UNK4MR10.2 UNK4C290.1 344.85,294.63 UNK4MK2.4
S4_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v4(333.66,247.72) 333.12,247.72 332.78,248.06 UNK4R661.2
  TOP w0.381: v4(334.66,251.72) 334.87,251.5 334.87,248.23 334.36,247.72 v4(333.66,247.72)
  BOTTOM w0.381: v4(333.66,247.72) UNK4C922.2
  BOTTOM w0.508: UNK4C922.2 333.66,245.95 333.3,245.59 331.82,245.59 331.5,245.91 UNK4BDB5.2
S4_3V3_RX1_MIPI: length 13.4
  TOP w0.305: UNK4R663.2 332.78,236.49 333.12,236.15 v4(333.66,236.15)
  TOP w0.381: v4(334.66,240.15) 334.87,239.94 334.87,236.66 334.36,236.15 v4(333.66,236.15)
  BOTTOM w0.381: v4(333.66,236.15) UNK4C923.2
  BOTTOM w0.508: UNK4C923.2 333.66,234.38 333.3,234.02 331.82,234.02 331.5,234.35 UNK4BDB6.2
S4_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK4C262.1 344.6,232.36 345.48,233.24 UNK4U31.4
  BOTTOM w0.305: UNK4BD21.2 UNK4C262.1
S4_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 349.83,270.83 UNK4C1074.1 UNK4R981.1
  BOTTOM w0.356: UNK4U449.10 349.86,269.73 UNK4R981.1
  BOTTOM w0.508: UNK4BD1728.2 349.83,270.83
S4_DCH015:
  vias: v2(346.6,243)
S4_DCH016:
  vias: v2(346.6,243.65)
S4_DCH018:
  vias: v2(347.9,243.66)
S4_DCH069:
  vias: v2(353.75,247.56)
S4_DCH089:
  vias: v2(354.4,244.96)
S4_DCH108: length 1.4
  BOTTOM w0.16: UNK4K32.2 v2(357.83,232.39)
S4_DCH109: length 1.4
  BOTTOM w0.16: UNK4K32.7 v2(353.63,232.39)
S4_DCH110: length 0.7
  BOTTOM w0.16: UNK4U449.3 v2(352.19,271.11)
S4_DCH111: length 0.9
  BOTTOM w0.16: UNK4U449.4 352.69,270.61 v2(353.18,271.1)
S4_DPS3: length 0.7
  BOTTOM w0.508: UNK4CA21.1 v1(335.42,283.46)
  vias: v1(335.42,285.5) v2(347.9,244.96) v2(351.15,250.15) v2(351.8,250.15) v2(352.45,250.15) v2(352.45,246.26) v2(352.45,244.3) v2(353.1,250.15) v2(353.1,244.3) v2(353.75,243.65)
S4_DPS4: length 0.7
  BOTTOM w0.508: UNK4CA35.1 v1(363.87,279.4)
  vias: v1(363.87,281.43) v2(346.6,250.15) v2(346.6,245.61) v2(353.75,244.96)
S4_M_2V5: length 4.8
  BOTTOM w0.508: UNK4MR2.1 UNK4C284.1 ; UNK4C284.1 UNK4C285.1 ; UNK4C284.1 357.42,297.16 UNK4MU2.6
S4_M_3V2: length 24.3
  BOTTOM w0.381: UNK4MU3.7 347.83,297.8 347.96,297.68
  BOTTOM w0.508: UNK4MU2.2 358.69,286.99 UNK4C282.1 UNK4C283.1 357.46,286.91 UNK4MR1.1 354.18,286.91 UNK4MU1.5 355.14,288.02 355.14,293.37 354.29,294.22 352.62,294.22 351.53,295.31 UNK4C289.1 349.25,295.31 348.48,296.08 348.48,297.16 347.96,297.68
S4_MPDCH03+: length 1.3
  BOTTOM w0.165: v2(346.41,232.52) 346.28,232.65 UNK4U31.2
S4_MPDCH03-: length 1.3
  BOTTOM w0.165: v2(345.75,232.52) 345.88,232.65 UNK4U31.3
S4_MPDCH05:
  vias: v2(349.2,246.26)
S4_MPDCH25:
  vias: v2(346.6,242.35)
S4_MPDCH26:
  vias: v2(346.6,241.7)
S4_MPDCH34:
  vias: v2(347.1,269) v2(347.86,269)
S4_MPDCH37+:
  vias: v4(331.66,251.22)
S4_MPDCH37-:
  vias: v4(331.16,251.22)
S4_MPDCH39+:
  vias: v4(331.66,250.22)
S4_MPDCH39-:
  vias: v4(331.16,250.22)
S4_MPDCH41+: length 0.5
  BOTTOM w0.16: UNK4U408.E8 v4(332.16,249.72)
S4_MPDCH41-: length 0.5
  BOTTOM w0.16: UNK4U408.E9 v4(330.66,249.72)
S4_MPDCH43+:
  vias: v4(331.66,239.65)
S4_MPDCH43-:
  vias: v4(331.16,239.65)
S4_MPDCH45+:
  vias: v4(331.66,238.65)
S4_MPDCH45-:
  vias: v4(331.16,238.65)
S4_MPDCH47+: length 0.5
  BOTTOM w0.16: UNK4U409.E8 v4(332.16,238.15)
S4_MPDCH47-: length 0.5
  BOTTOM w0.16: UNK4U409.E9 v4(330.66,238.15)
S4_MPDCH52:
  vias: v2(353.75,241.71)
S4_MPDCH56:
  vias: v2(347.9,246.26)
S4_MPDCH57:
  vias: v2(353.75,243)
S4_MPDCH59:
  vias: v2(353.75,242.36)
S4_MPDCH62:
  vias: v2(355.05,244.96)
S4_MPDCH63:
  vias: v2(353.75,246.91)
S4_MPDCH65:
  vias: v2(355.05,247.56)
S4_MPDCH66:
  vias: v2(355.05,246.91)
S4_MPDCH75:
  vias: v2(355.05,246.26)
S4_MPDCH77:
  vias: v2(353.75,246.26)
S4_MPDCH85:
  vias: v2(353.1,246.26)
S4_MUX_3V3: length 1.5
  TOP w0.508: v2(347.1,267.19) v2(347.86,267.19)
  BOTTOM w0.508: v2(347.1,267.19) UNK4R512.1 v2(347.86,267.19)
  vias: v2(342.48,232.36) v2(349.83,272.29)
S4_OUT_RX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(337.22,252.07) 337.06,251.91 337.06,251.37 336.57,250.88 335,250.88 UNK4U408.B2
S4_OUT_RX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(336.51,252.07) 336.68,251.9 336.68,251.52 336.41,251.25 335.19,251.25 UNK4U408.B1
S4_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.076: UNK4U408.B4 334.15,251.71
  BOTTOM w0.132: UNK4R647.1 335.29,253.77 335.29,253.05 334.94,252.7 334.44,252.7 334.15,252.41 334.15,251.71
S4_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK4U408.A4 333.78,251.83 333.78,252.57 334.28,253.07 334.79,253.07 334.92,253.21 334.92,253.38 334.81,253.5 334.45,253.5 334.38,253.57 334.38,253.78 334.46,253.86 UNK4R646.1
S4_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK4C309.1 UNK4R646.2 UNK4R647.2
S4_OUT_RX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(337.22,249.36) 337.05,249.53 337.05,250.08 336.56,250.57 335.02,250.57 UNK4U408.D2
  vias: v2(349.85,247.56)
S4_OUT_RX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK4U408.D1 335.18,250.2 336.4,250.2 336.68,249.93 336.68,249.53 v2(336.51,249.36)
S4_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: UNK4U408.B5 333.41,251.47 333.41,251.97
  BOTTOM w0.132: UNK4R168.1 333.82,253.7 333.82,253.24 333.41,252.83 333.41,251.97
S4_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK4U408.A5 333.04,251.84 333.04,252.56 332.91,252.69 332.82,252.69 332.69,252.82 332.69,253.01 332.82,253.14 333.2,253.14 333.45,253.39 333.45,253.7 UNK4R170.1
S4_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK4R170.2 UNK4R168.2 UNK4C310.1
S4_OUT_RX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK4U408.E2 v2(334.16,249.72)
S4_OUT_RX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK4U408.E1 v2(335.66,249.72)
S4_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK4U408.B6 332.28,251.59 332.28,252.14 331.8,252.62 331.8,253.7 UNK4R176.1
S4_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK4U408.A6 332.66,251.72 332.66,251.73 332.66,252.29 332.17,252.78 332.17,253.1 332.47,253.4 332.66,253.4 332.77,253.51 332.77,253.73 332.64,253.86 UNK4R178.1
S4_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK4C318.1 UNK4R176.2 UNK4R178.2
S4_OUT_RX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(337.22,240.5) 337.06,240.34 337.06,239.8 336.57,239.31 335,239.31 UNK4U409.B2
  vias: v2(348.55,247.56)
S4_OUT_RX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK4U409.B1 335.19,239.69 336.41,239.69 336.68,239.96 336.68,240.34 v2(336.51,240.5)
S4_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK4U409.B4 334.15,240.14 334.15,240.85 334.44,241.13 334.94,241.13 335.29,241.48 335.29,242.21 UNK4R1089.1
S4_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK4R1088.1 334.46,242.3 334.38,242.21 334.38,242 334.45,241.93 334.81,241.93 334.92,241.81 334.92,241.64 334.79,241.51 334.28,241.51 333.78,241 333.78,240.27 UNK4U409.A4
S4_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK4R1089.2 UNK4R1088.2 UNK4C302.1
S4_OUT_RX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(337.22,237.8) 337.05,237.96 337.05,238.51 336.56,239.01 335.02,239.01 UNK4U409.D2
S4_OUT_RX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK4U409.D1 335.18,238.63 336.4,238.63 336.68,238.36 336.68,237.96 v2(336.51,237.8)
  vias: v2(347.9,247.56)
S4_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: 333.41,240.41 333.41,239.9 UNK4U409.B5
  BOTTOM w0.132: 333.41,240.41 333.41,241.26 333.82,241.67 333.82,242.13 UNK4R180.1
S4_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK4U409.A5 333.04,240.27 333.04,240.99 332.91,241.12 332.82,241.12 332.69,241.25 332.69,241.44 332.82,241.57 333.2,241.57 333.45,241.83 333.45,242.13 UNK4R182.1
S4_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK4C320.1 UNK4R180.2 UNK4R182.2
S4_OUT_RX0_CH5_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK4U409.E2 v2(334.16,238.15)
S4_OUT_RX0_CH5_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK4U409.E1 v2(335.66,238.15)
S4_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK4U409.B6 332.28,240.03 332.28,240.57 331.8,241.06 331.8,242.13 UNK4R666.1
S4_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK4U409.A6 332.66,240.15 332.66,240.16 332.66,240.72 332.17,241.21 332.17,241.53 332.47,241.84 332.66,241.84 332.77,241.94 332.77,242.17 332.64,242.3 UNK4R664.1
S4_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK4R664.2 UNK4R666.2 UNK4C924.1
S4_OUT_TX0_CH0_ABC_CASE-:
  vias: v2(346.6,247.56)
S4_OUT_TX0_CH1_ABC_CASE+:
  vias: v2(346.6,246.91)
S4_OUT_TX0_CH2_ABC_CASE-:
  vias: v2(346.6,246.26)
S4_PM_SAR_GPIO0:
  vias: v1(344.52,286.43)
S4_PWR_F001: length 0.7
  BOTTOM w0.508: UNK4CA27.1 v1(353.93,279.4)
  vias: v1(353.93,281.43) v2(355.05,250.15)
S4_PWR_F004: length 0.7
  BOTTOM w0.508: UNK4CA23.1 v1(341.51,279.4)
  vias: v1(341.51,281.43) v2(351.8,247.56)
S4_PWR_F005: length 0.7
  BOTTOM w0.508: UNK4CA8.1 v1(363.87,283.46)
  vias: v1(363.87,285.5) v2(347.9,242.35) v2(352.45,243) v2(353.1,243.01) v2(355.05,243)
S4_PWR_F006: length 0.7
  BOTTOM w0.508: UNK4CA25.1 v1(335.42,279.4)
  vias: v1(335.42,281.43) v2(350.5,240.4) v2(351.8,241.7) v2(352.45,241.06)
S4_PWR_F007: length 0.7
  BOTTOM w0.508: UNK4CA36.1 v1(347.6,279.4)
  vias: v1(347.6,281.43) v2(349.85,241.05) v2(350.5,241.7) v2(351.15,241.7)
S4_PWR_F008:
  vias: v2(353.75,244.31)
S4_PWR_M_F001: length 0.7
  BOTTOM w0.508: UNK4CA1.1 v1(377.19,245.11)
  vias: v1(377.19,247.65) v2(348.55,241.7) v2(348.55,241.06) v2(348.55,239.1) v2(349.2,245.61) v2(349.2,244.96) v2(349.85,244.96) v2(350.5,250.15) v2(350.5,246.91) v2(350.5,246.26) v2(350.5,245.61) v2(350.5,244.3) v2(351.15,246.26) v2(351.15,245.61) v2(351.15,244.96) v2(351.15,244.3) v2(351.8,244.96) v2(351.8,239.1)
S4_SPI_CK_ABCD_CASE:
  vias: v2(355.05,241.7)
S4_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: 461.72,237.74 463.83,237.74 465.91,239.83 465.91,244.78 464.48,246.21 464.48,252.77 465.62,253.91 480.33,253.91 UNK4K3.7
S4_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK4U19.6 481.45,237.74 481.93,238.22 UNK4K3.5
S4_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: UNK4K3.2 483.53,253.91 468.66,253.91 467.65,252.9 467.65,245.7 v1(473.08,240.28)
  BOTTOM w0.16: v1(473.08,240.28) 470.57,240.28
S4_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK4K3.4 485.13,242.2 487.05,240.28 UNK4U19.1 UNK4R205.2
S4_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK4K5.7 467.65,250.73 467.65,240.17 463.95,236.47 461.72,236.47
S4_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v1(478.59,236.47) 478.59,241.37 477.61,242.35 474.78,242.35 UNK4K5.5
  BOTTOM w0.16: UNK4U19.5 v1(478.59,236.47)
S4_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: 470.57,239.01 474.93,239.01 475.7,239.78 475.7,242.93 474,244.63 474,250.73 UNK4K5.2
S4_SPI_DO_D_CASE: length 24.7
  TOP w0.16: UNK4K5.4 474.09,246.25 479.29,246.25 486.53,239.01 v1(491.9,239.01)
  BOTTOM w0.16: UNK4U19.2 v1(491.9,239.01)
S4_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK4K7.2 461.3,250.73 461.3,246.09 464.57,242.82 464.57,239.62 463.95,239.01 UNK4R202.1
S4_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK4K7.4 467.99,239.65 476.98,239.65 v1(477.62,239.01)
  BOTTOM w0.16: UNK4U19.7 v1(477.62,239.01)
S4_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v1(473.08,237.74) 467.89,237.74 458.13,247.5 458.13,250.71 UNK4K7.7
  BOTTOM w0.16: v1(473.08,237.74) 470.57,237.74
S4_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: v1(491.9,237.74) 488.47,234.31 470.12,234.31 UNK4K7.5
  BOTTOM w0.16: UNK4U19.3 v1(491.9,237.74) UNK4R207.2
S4_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK4R164.2 343.94,234.06 344.19,234.3 UNK4U31.6
S4_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK4R163.2 343.84,233.14 344.6,233.9 UNK4U31.5
S4_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK4U31.16 347.91,233.9 UNK4R165.2
S4_USB_D_AB_CASE+: length 1.3
  BOTTOM w0.165: UNK4U31.10 345.88,236.36 v2(346.01,236.49)
S4_USB_D_AB_CASE-: length 1.3
  BOTTOM w0.165: UNK4U31.9 345.48,236.36 v2(345.35,236.49)
S4_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK4R160.2 343.85,235.1 UNK4U31.8
S4_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK4R161.2 343.85,234.7 UNK4U31.7
S4_USER_3V3: length 2.6
  BOTTOM w0.305: UNK4R200.1 v1(474.47,240.28) ; UNK4R205.1 v1(494.28,240.28) ; UNK4R203.1 v1(474.47,237.74) ; UNK4R207.1 v1(494.28,237.74)
  vias: v1(457.94,241.55) v1(457.94,240.28) v1(457.94,239.01) v1(458.42,243.15) v1(470.92,229.39) v1(472.58,229.66) v1(476.37,241.55) v1(476.62,240.28) v1(476.62,239.01) v1(476.84,243.15)
S4_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(355.05,243.65) 355.35,243.95 355.57,244.17 358.02,244.17 359.01,243.18 359.01,238.84 356.33,236.15 356.33,230.9 357.03,230.19 UNK4K32.3
S4_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK4K32.4 UNK4R135.1
S4_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK4R135.2 UNK4R136.2 UNK4C267.1 356.55,224.48 357.49,223.54 357.49,220.49 356.93,219.93 UNK4Y1.3
S4_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: UNK4K32.6 354.28,230.19 354.98,230.89 354.98,236.7 357.6,239.33 357.6,243.06 357,243.65 v2(355.7,243.65)
S4_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK4K32.5 UNK4R137.1
S4_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK4Y1.1 351.29,222.72 351.29,224.07 351.69,224.48 UNK4C268.1 UNK4R136.1 UNK4R137.2
S4_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(354.03,257.96) 354.03,267.56 353.31,268.29 v2(352.49,268.29)
  BOTTOM w0.16: v2(352.49,268.29) 352.19,268.59 UNK4U449.7 ; UNK4K29.7 v2(354.03,257.96)
S4_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 349.6,249.25 v2(349.2,248.85)
  BOTTOM w0.16: 349.6,249.25 349.85,249.5 349.85,251.04 350.61,251.79 351.11,251.79 352.71,253.39 352.71,259.49 353.38,260.16 UNK4K29.6
S4_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK4C271.1 353.19,266.93 UNK4Y2.1 353.19,263.05 353.88,262.36 UNK4K29.5
S4_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK4U449.2 351.69,271.81 UNK4R973.2 351.92,273.09 UNK4R923.1
S4_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(351.38,268.29) 350.56,268.29 349.84,267.56 v2(349.84,257.96)
  BOTTOM w0.16: UNK4K29.2 v2(349.84,257.96) ; v2(351.38,268.29) 351.69,268.59 UNK4U449.8
S4_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: UNK4K29.3 350.64,260.16 351.34,259.45 351.34,254.01 349.2,251.87 v2(349.2,249.5)
S4_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK4C272.1 350.69,266.93 UNK4Y2.2 350.69,263.05 349.99,262.36 UNK4K29.4
S4_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK4U449.1 351.19,271.78 UNK4R973.1 350.92,273.09 UNK4R652.1
S5_0V5: length 41.7
  BOTTOM w0.305: 227.99,137 228.17,137.18 UNK5C288.1 228.22,137.2 228.42,137
  BOTTOM w0.381: 229.37,136.04 229.49,135.92 UNK5MU3.3
  BOTTOM w0.508: UNK5MR4.1 UNK5MR3.1 227.34,134.78 UNK5C286.1 227.34,136.35 227.99,137 ; UNK5MR4.1 UNK5MR5.1 UNK5MR6.1 UNK5MR2.2 ; UNK5MR4.1 227.41,133.3 227.87,132.84 240.15,132.84 243.37,136.06 243.37,143.22 242.48,144.1 UNK5MK1.4 ; 228.42,137 229.37,136.05 229.37,136.04
S5_0V25: length 2.8
  BOTTOM w0.508: UNK5MR18.2 239.78,142.63 UNK5MR19.1 237.21,142.63 UNK5MK4.3
S5_0V75: length 4.9
  BOTTOM w0.381: UNK5MU3.6 UNK5MR10.2
  BOTTOM w0.508: UNK5MR10.2 UNK5C290.1 236.81,138.44 UNK5MK2.4
S5_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v4(213.66,187.72) 213.12,187.72 212.78,188.06 UNK5R661.2
  TOP w0.381: v4(213.66,187.72) 214.36,187.72 214.87,188.23 214.87,191.5 v4(214.66,191.72)
  BOTTOM w0.381: v4(213.66,187.72) UNK5C922.2
  BOTTOM w0.508: UNK5BDB5.2 211.5,185.91 211.82,185.59 213.3,185.59 213.66,185.95 UNK5C922.2
S5_3V3_RX1_MIPI: length 13.4
  TOP w0.305: v4(213.66,176.15) 213.12,176.15 212.78,176.49 UNK5R663.2
  TOP w0.381: v4(214.66,180.15) 214.87,179.94 214.87,176.66 214.36,176.15 v4(213.66,176.15)
  BOTTOM w0.381: v4(213.66,176.15) UNK5C923.2
  BOTTOM w0.508: UNK5C923.2 213.66,174.38 213.3,174.02 211.82,174.02 211.5,174.35 UNK5BDB6.2
S5_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK5C262.1 224.61,172.36 225.48,173.24 UNK5U31.4
  BOTTOM w0.305: UNK5BD21.2 UNK5C262.1
S5_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: UNK5R981.1 UNK5C1074.1 229.83,210.83
  BOTTOM w0.356: UNK5R981.1 229.86,209.73 UNK5U449.10
  BOTTOM w0.508: UNK5BD1728.2 229.83,210.83
S5_DCH015:
  vias: v2(226.61,183)
S5_DCH016:
  vias: v2(226.61,183.65)
S5_DCH018:
  vias: v2(227.91,183.66)
S5_DCH069:
  vias: v2(233.76,187.56)
S5_DCH089:
  vias: v2(234.41,184.96)
S5_DCH108: length 1.4
  BOTTOM w0.16: UNK5K32.2 v2(237.83,172.39)
S5_DCH109: length 1.4
  BOTTOM w0.16: UNK5K32.7 v2(233.63,172.39)
S5_DCH110: length 0.7
  BOTTOM w0.16: UNK5U449.3 v2(232.19,211.11)
S5_DCH111: length 0.9
  BOTTOM w0.16: v2(233.18,211.1) 232.69,210.61 UNK5U449.4
S5_DPS3: length 0.7
  BOTTOM w0.508: UNK5CA21.1 v1(230.12,150.98)
  vias: v1(230.12,153.01) v2(227.91,184.96) v2(231.15,190.16) v2(231.8,190.16) v2(232.46,190.16) v2(232.46,186.26) v2(232.46,184.3) v2(233.11,190.16) v2(233.11,184.3) v2(233.76,183.65)
S5_DPS4: length 0.7
  BOTTOM w0.508: UNK5CA35.1 v1(244.57,152.5)
  vias: v1(244.57,154.53) v2(226.61,190.16) v2(226.61,185.61) v2(233.76,184.96)
S5_M_2V5: length 4.8
  BOTTOM w0.508: UNK5C284.1 UNK5C285.1 ; UNK5C284.1 UNK5MR2.1 ; UNK5C284.1 224.24,135.91 UNK5MU2.6
S5_M_3V2: length 24.3
  BOTTOM w0.381: UNK5MU3.7 233.83,135.27 233.7,135.39
  BOTTOM w0.508: 233.7,135.39 233.18,135.91 233.18,136.99 232.41,137.76 UNK5C289.1 230.13,137.76 229.04,138.85 227.37,138.85 226.52,139.7 226.52,145.05 UNK5MU1.5 227.48,146.16 UNK5MR1.1 224.2,146.16 UNK5C283.1 UNK5C282.1 222.97,146.08 UNK5MU2.2
S5_MPDCH03+: length 1.3
  BOTTOM w0.165: v2(226.41,172.52) 226.28,172.65 226.28,173.73 UNK5U31.2
S5_MPDCH03-: length 1.3
  BOTTOM w0.165: v2(225.75,172.52) 225.88,172.65 UNK5U31.3
S5_MPDCH05:
  vias: v2(229.21,186.26)
S5_MPDCH25:
  vias: v2(226.61,182.35)
S5_MPDCH26:
  vias: v2(226.61,181.7)
S5_MPDCH34:
  vias: v2(227.1,209) v2(227.86,209)
S5_MPDCH37+:
  vias: v4(211.66,191.22)
S5_MPDCH37-:
  vias: v4(211.16,191.22)
S5_MPDCH39+:
  vias: v4(211.66,190.22)
S5_MPDCH39-:
  vias: v4(211.16,190.22)
S5_MPDCH41+: length 0.5
  BOTTOM w0.16: UNK5U408.E8 v4(212.16,189.72)
S5_MPDCH41-: length 0.5
  BOTTOM w0.16: UNK5U408.E9 v4(210.66,189.72)
S5_MPDCH43+:
  vias: v4(211.66,179.65)
S5_MPDCH43-:
  vias: v4(211.16,179.65)
S5_MPDCH45+:
  vias: v4(211.66,178.65)
S5_MPDCH45-:
  vias: v4(211.16,178.65)
S5_MPDCH47+: length 0.5
  BOTTOM w0.16: UNK5U409.E8 v4(212.16,178.15)
S5_MPDCH47-: length 0.5
  BOTTOM w0.16: UNK5U409.E9 v4(210.66,178.15)
S5_MPDCH52:
  vias: v2(233.76,181.71)
S5_MPDCH53:
  vias: v2(227.91,182.35)
S5_MPDCH56:
  vias: v2(227.91,186.26)
S5_MPDCH57:
  vias: v2(233.76,183)
S5_MPDCH59:
  vias: v2(233.76,182.36)
S5_MPDCH62:
  vias: v2(235.06,184.96)
S5_MPDCH63:
  vias: v2(233.76,186.91)
S5_MPDCH65:
  vias: v2(235.06,187.56)
S5_MPDCH66:
  vias: v2(235.06,186.91)
S5_MPDCH75:
  vias: v2(235.06,186.26)
S5_MPDCH77:
  vias: v2(233.76,186.26)
S5_MPDCH85:
  vias: v2(233.11,186.26)
S5_MUX_3V3: length 1.5
  TOP w0.508: v2(227.1,207.19) v2(227.86,207.19)
  BOTTOM w0.508: v2(227.1,207.19) UNK5R512.1 v2(227.86,207.19)
  vias: v2(222.6,172.36) v2(229.83,212.29)
S5_OUT_RX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK5U408.B2 215,190.88 216.57,190.88 217.06,191.37 217.06,191.91 v2(217.22,192.07)
S5_OUT_RX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(216.51,192.07) 216.68,191.9 216.68,191.52 216.41,191.25 215.19,191.25 UNK5U408.B1
S5_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK5U408.B4 214.15,191.71 214.15,192.41 214.44,192.7 214.94,192.7 215.3,193.05 215.3,193.77 UNK5R647.1
S5_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK5R646.1 214.46,193.86 214.38,193.78 214.38,193.57 214.45,193.5 214.81,193.5 214.92,193.38 214.92,193.21 214.79,193.07 214.28,193.07 213.78,192.57 213.78,191.83 UNK5U408.A4
S5_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK5C309.1 UNK5R646.2 UNK5R647.2
S5_OUT_RX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK5U408.D2 215.02,190.57 216.56,190.57 217.05,190.08 217.05,189.53 v2(217.22,189.36)
  vias: v2(229.86,187.56)
S5_OUT_RX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(216.51,189.36) 216.68,189.53 216.68,189.93 216.41,190.2 215.18,190.2 UNK5U408.D1
S5_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: UNK5U408.B5 213.41,191.47 213.41,191.97
  BOTTOM w0.132: 213.41,191.97 213.41,192.83 213.82,193.24 213.82,193.7 UNK5R168.1
S5_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK5R170.1 213.45,193.7 213.45,193.39 213.2,193.14 212.82,193.14 212.69,193.01 212.69,192.82 212.82,192.69 212.91,192.69 213.04,192.56 213.04,191.84 UNK5U408.A5
S5_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK5C310.1 UNK5R168.2 UNK5R170.2
S5_OUT_RX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK5U408.E2 v2(214.16,189.72)
S5_OUT_RX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK5U408.E1 v2(215.66,189.72)
S5_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK5R176.1 211.8,193.7 211.8,192.62 212.28,192.14 212.28,191.59 UNK5U408.B6
S5_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK5R178.1 212.64,193.86 212.77,193.73 212.77,193.51 212.66,193.4 212.47,193.4 212.17,193.1 212.17,192.78 212.66,192.29 212.66,191.72 UNK5U408.A6
S5_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK5R178.2 UNK5R176.2 UNK5C318.1
S5_OUT_RX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK5U409.B2 215,179.31 216.57,179.31 217.06,179.8 217.06,180.34 v2(217.22,180.5)
  vias: v2(228.56,187.56)
S5_OUT_RX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK5U409.B1 215.19,179.69 216.41,179.69 216.68,179.96 216.68,180.34 v2(216.51,180.5)
S5_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK5R1089.1 215.3,182.21 215.3,181.48 214.94,181.13 214.44,181.13 214.15,180.85 214.15,180.14 UNK5U409.B4
S5_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK5R1088.1 214.46,182.3 214.38,182.21 214.38,182 214.45,181.93 214.81,181.93 214.92,181.81 214.92,181.64 214.79,181.51 214.28,181.51 213.78,181 213.78,180.27 UNK5U409.A4
S5_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK5R1089.2 UNK5R1088.2 UNK5C302.1
S5_OUT_RX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK5U409.D2 215.02,179.01 216.56,179.01 217.05,178.51 217.05,177.97 v2(217.22,177.8)
S5_OUT_RX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK5U409.D1 215.18,178.63 216.41,178.63 216.68,178.36 216.68,177.96 v2(216.51,177.8)
  vias: v2(227.91,187.56)
S5_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: 213.41,180.41 213.41,179.9 UNK5U409.B5
  BOTTOM w0.132: 213.41,180.41 213.41,181.26 213.82,181.67 213.82,182.13 UNK5R180.1
S5_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK5R182.1 213.45,182.13 213.45,181.83 213.2,181.57 212.82,181.57 212.69,181.44 212.69,181.25 212.82,181.12 212.91,181.12 213.04,181 213.04,180.27 UNK5U409.A5
S5_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK5R182.2 UNK5R180.2 UNK5C320.1
S5_OUT_RX0_CH5_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK5U409.E2 v2(214.16,178.15)
S5_OUT_RX0_CH5_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK5U409.E1 v2(215.66,178.15)
S5_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK5R666.1 211.8,182.13 211.8,181.06 212.28,180.57 212.28,180.03 UNK5U409.B6
S5_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK5R664.1 212.64,182.3 212.77,182.17 212.77,181.94 212.66,181.84 212.47,181.84 212.17,181.53 212.17,181.21 212.66,180.72 212.66,180.15 UNK5U409.A6
S5_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK5C924.1 UNK5R666.2 UNK5R664.2
S5_OUT_TX0_CH0_ABC_CASE-:
  vias: v2(226.61,187.56)
S5_OUT_TX0_CH1_ABC_CASE+:
  vias: v2(226.61,186.91)
S5_OUT_TX0_CH2_ABC_CASE-:
  vias: v2(226.61,186.26)
S5_PM_SAR_GPIO0:
  vias: v1(237.14,146.64)
S5_PWR_F001: length 0.7
  BOTTOM w0.508: UNK5CA27.1 v1(225.3,155.04)
  vias: v1(225.3,157.07) v2(235.06,190.16)
S5_PWR_F004: length 0.7
  BOTTOM w0.508: UNK5CA23.1 v1(239.75,147.83)
  vias: v1(239.75,149.86) v2(231.81,187.56)
S5_PWR_F005: length 0.7
  BOTTOM w0.508: UNK5CA8.1 v1(239.75,152.5)
  vias: v1(239.75,154.53) v2(232.46,183) v2(233.11,183.01) v2(235.06,183)
S5_PWR_F006: length 0.7
  BOTTOM w0.508: UNK5CA25.1 v1(220.48,150.98)
  vias: v1(220.48,153.01) v2(230.5,180.41) v2(231.81,181.7) v2(232.46,181.06)
S5_PWR_F007: length 0.7
  BOTTOM w0.508: UNK5CA36.1 v1(225.3,150.98)
  vias: v1(225.3,153.01) v2(229.86,181.06) v2(230.5,181.7) v2(231.16,181.7)
S5_PWR_F008:
  vias: v2(233.76,184.31)
S5_PWR_M_F001: length 0.7
  BOTTOM w0.508: UNK5CA1.1 v1(220.48,155.04)
  vias: v1(220.48,157.07) v2(228.56,181.7) v2(228.56,181.06) v2(228.56,179.11) v2(229.21,185.61) v2(229.21,184.96) v2(229.86,184.96) v2(230.5,190.16) v2(230.5,186.91) v2(230.5,186.26) v2(230.5,185.61) v2(230.5,184.3) v2(231.16,186.26) v2(231.16,185.61) v2(231.16,184.96) v2(231.16,184.3) v2(231.81,184.96) v2(231.81,179.11)
S5_SPI_CK_ABCD_CASE:
  vias: v2(235.06,181.7)
S5_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: 90.88,170.43 92.99,170.43 95.07,172.52 95.07,177.47 93.64,178.9 93.64,185.46 94.78,186.6 109.49,186.6 UNK5K3.7
S5_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK5U19.6 110.61,170.43 111.09,170.91 UNK5K3.5
S5_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: v1(102.24,172.97) 96.81,178.39 96.81,185.59 97.82,186.6 112.69,186.6 UNK5K3.2
  BOTTOM w0.16: v1(102.24,172.97) 99.73,172.97
S5_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK5R205.2 UNK5U19.1 116.21,172.97 114.29,174.89 UNK5K3.4
S5_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK5K5.7 96.81,183.42 96.81,172.86 93.11,169.16 90.88,169.16
S5_SPI_DI_D_CASE: length 18.5
  TOP w0.16: UNK5K5.5 103.94,175.04 106.77,175.04 107.75,174.06 v1(107.75,169.16)
  BOTTOM w0.16: UNK5U19.5 v1(107.75,169.16)
S5_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: 99.73,171.7 104.09,171.7 104.86,172.47 104.86,175.62 103.16,177.32 103.16,183.42 UNK5K5.2
S5_SPI_DO_D_CASE: length 24.7
  TOP w0.16: UNK5K5.4 103.25,178.94 108.45,178.94 115.69,171.7 v1(121.06,171.7)
  BOTTOM w0.16: UNK5U19.2 v1(121.06,171.7)
S5_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK5R202.1 93.11,171.7 93.73,172.31 93.73,175.51 90.46,178.78 90.46,183.42 UNK5K7.2
S5_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK5K7.4 97.15,172.34 106.14,172.34 v1(106.78,171.7)
  BOTTOM w0.16: UNK5U19.7 v1(106.78,171.7)
S5_SPI_WPZ_C_CASE: length 27
  TOP w0.16: UNK5K7.7 87.29,183.4 87.29,180.19 97.05,170.43 v1(102.24,170.43)
  BOTTOM w0.16: v1(102.24,170.43) 99.73,170.43
S5_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: v1(121.06,170.43) 117.63,167 99.28,167 UNK5K7.5
  BOTTOM w0.16: UNK5U19.3 v1(121.06,170.43) UNK5R207.2
S5_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK5R164.2 223.94,174.06 224.19,174.3 UNK5U31.6
S5_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK5U31.5 224.6,173.9 223.84,173.14 UNK5R163.2
S5_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK5U31.16 227.91,173.9 UNK5R165.2
S5_USB_D_AB_CASE+: length 1.3
  BOTTOM w0.165: v2(226.01,176.49) 225.88,176.36 UNK5U31.10
S5_USB_D_AB_CASE-: length 1.3
  BOTTOM w0.165: v2(225.35,176.49) 225.48,176.36 UNK5U31.9
S5_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK5R160.2 223.85,175.1 UNK5U31.8
S5_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK5U31.7 223.85,174.7 UNK5R161.2
S5_USER_3V3: length 2.6
  BOTTOM w0.305: UNK5R205.1 v1(123.44,172.97) ; UNK5R200.1 v1(103.63,172.97) ; UNK5R207.1 v1(123.44,170.43) ; UNK5R203.1 v1(103.63,170.43)
  vias: v1(87.1,174.24) v1(87.1,172.97) v1(87.1,171.7) v1(87.58,175.84) v1(100.08,162.08) v1(101.74,162.35) v1(105.53,174.24) v1(105.78,172.97) v1(105.78,171.7) v1(106,175.84)
S5_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(235.06,183.65) 235.35,183.95 235.57,184.17 238.02,184.17 239.01,183.18 239.01,178.84 236.33,176.15 236.33,170.9 237.03,170.19 UNK5K32.3
S5_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK5K32.4 UNK5R135.1
S5_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK5Y1.3 236.93,159.93 237.49,160.49 237.49,163.54 236.55,164.48 UNK5C267.1 UNK5R136.2 UNK5R135.2
S5_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: v2(235.71,183.65) 237.01,183.65 237.6,183.06 237.6,179.33 234.98,176.7 234.98,170.89 234.28,170.19 UNK5K32.6
S5_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK5K32.5 UNK5R137.1
S5_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK5Y1.1 231.29,162.72 231.29,164.07 231.69,164.48 UNK5C268.1 UNK5R136.1 UNK5R137.2
S5_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(234.04,197.96) 234.04,207.56 233.31,208.29 v2(232.49,208.29)
  BOTTOM w0.16: UNK5K29.7 v2(234.04,197.96) ; UNK5U449.7 232.19,208.59 v2(232.49,208.29)
S5_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 229.6,189.25 v2(229.21,188.86)
  BOTTOM w0.16: 229.6,189.25 229.86,189.51 229.86,191.04 230.61,191.79 231.11,191.79 232.71,193.39 232.71,199.49 233.38,200.16 UNK5K29.6
S5_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK5K29.5 233.88,202.36 233.19,203.05 UNK5Y2.1 233.19,206.93 UNK5C271.1
S5_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK5U449.2 231.69,211.81 UNK5R973.2 231.92,213.09 UNK5R923.1
S5_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(229.84,197.96) 229.84,207.56 230.56,208.29 v2(231.38,208.29)
  BOTTOM w0.16: v2(231.38,208.29) 231.69,208.59 UNK5U449.8 ; UNK5K29.2 v2(229.84,197.96)
S5_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: v2(229.21,189.51) 229.21,191.87 231.34,194.01 231.34,199.45 230.64,200.16 UNK5K29.3
S5_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK5C272.1 230.69,206.93 UNK5Y2.2 230.69,203.05 229.99,202.36 UNK5K29.4
S5_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK5U449.1 231.19,211.78 UNK5R973.1 230.92,213.09 UNK5R652.1
S6_0V5: length 41.7
  BOTTOM w0.305: 268.42,137 268.22,137.2 UNK6C288.1 268.17,137.18 267.99,137
  BOTTOM w0.381: 269.37,136.04 269.49,135.92 UNK6MU3.3
  BOTTOM w0.508: UNK6MR2.2 UNK6MR6.1 UNK6MR5.1 UNK6MR4.1 ; UNK6MR4.1 267.41,133.3 267.87,132.84 280.15,132.84 283.37,136.06 283.37,143.22 282.48,144.1 UNK6MK1.4 ; UNK6MR4.1 UNK6MR3.1 267.34,134.78 UNK6C286.1 267.34,136.35 267.99,137 ; 268.42,137 269.37,136.05 269.37,136.04
S6_0V25: length 2.8
  BOTTOM w0.508: UNK6MR18.2 279.78,142.63 UNK6MR19.1 277.21,142.63 UNK6MK4.3
S6_0V75: length 4.9
  BOTTOM w0.381: UNK6MU3.6 UNK6MR10.2
  BOTTOM w0.508: UNK6MK2.4 276.81,138.44 UNK6C290.1 UNK6MR10.2
S6_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v4(253.66,187.72) 253.12,187.72 252.78,188.06 UNK6R661.2
  TOP w0.381: v4(253.66,187.72) 254.36,187.72 254.87,188.23 254.87,191.5 v4(254.66,191.72)
  BOTTOM w0.381: v4(253.66,187.72) UNK6C922.2
  BOTTOM w0.508: UNK6BDB5.2 251.5,185.91 251.82,185.59 253.3,185.59 253.66,185.95 UNK6C922.2
S6_3V3_RX1_MIPI: length 13.4
  TOP w0.305: UNK6R663.2 252.78,176.49 253.12,176.15 v4(253.66,176.15)
  TOP w0.381: v4(254.66,180.15) 254.87,179.94 254.87,176.66 254.36,176.15 v4(253.66,176.15)
  BOTTOM w0.381: v4(253.66,176.15) UNK6C923.2
  BOTTOM w0.508: UNK6BDB6.2 251.5,174.35 251.82,174.02 253.3,174.02 253.66,174.38 UNK6C923.2
S6_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK6U31.4 265.48,173.24 264.61,172.36 UNK6C262.1
  BOTTOM w0.305: UNK6BD21.2 UNK6C262.1
S6_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 269.83,210.83 UNK6C1074.1 UNK6R981.1
  BOTTOM w0.356: UNK6R981.1 269.86,209.73 UNK6U449.10
  BOTTOM w0.508: UNK6BD1728.2 269.83,210.83
S6_DCH015:
  vias: v2(266.61,183)
S6_DCH016:
  vias: v2(266.61,183.65)
S6_DCH018:
  vias: v2(267.9,183.66)
S6_DCH069:
  vias: v2(273.76,187.56)
S6_DCH089:
  vias: v2(274.41,184.96)
S6_DCH108: length 1.4
  BOTTOM w0.16: UNK6K32.2 v2(277.83,172.39)
S6_DCH109: length 1.4
  BOTTOM w0.16: UNK6K32.7 v2(273.63,172.39)
S6_DCH110: length 0.7
  BOTTOM w0.16: UNK6U449.3 v2(272.19,211.11)
S6_DCH111: length 0.9
  BOTTOM w0.16: v2(273.18,211.1) 272.69,210.61 UNK6U449.4
S6_DPS3: length 0.7
  BOTTOM w0.508: UNK6CA21.1 v1(270.12,150.98)
  vias: v1(270.12,153.01) v2(267.9,184.96) v2(271.15,190.16) v2(271.8,190.16) v2(272.46,190.16) v2(272.46,186.26) v2(272.46,184.3) v2(273.11,190.16) v2(273.11,184.3) v2(273.76,183.65)
S6_DPS4: length 0.7
  BOTTOM w0.508: UNK6CA35.1 v1(284.57,152.5)
  vias: v1(284.57,154.53) v2(266.61,190.16) v2(266.61,185.61) v2(273.76,184.96)
S6_M_2V5: length 4.8
  BOTTOM w0.508: UNK6MU2.6 264.24,135.91 UNK6C284.1 ; UNK6C284.1 UNK6C285.1 ; UNK6C284.1 UNK6MR2.1
S6_M_3V2: length 24.3
  BOTTOM w0.381: UNK6MU3.7 273.83,135.27 273.7,135.39
  BOTTOM w0.508: UNK6MU2.2 262.97,146.08 UNK6C282.1 UNK6C283.1 264.2,146.16 UNK6MR1.1 267.48,146.16 UNK6MU1.5 266.52,145.05 266.52,139.7 267.37,138.85 269.04,138.85 270.13,137.76 UNK6C289.1 272.41,137.76 273.18,136.99 273.18,135.91 273.7,135.39
S6_MPDCH03+: length 1.3
  BOTTOM w0.165: v2(266.41,172.52) 266.28,172.65 UNK6U31.2
S6_MPDCH03-: length 1.3
  BOTTOM w0.165: v2(265.75,172.52) 265.88,172.65 UNK6U31.3
S6_MPDCH05:
  vias: v2(269.2,186.26)
S6_MPDCH25:
  vias: v2(266.61,182.35)
S6_MPDCH26:
  vias: v2(266.61,181.7)
S6_MPDCH34:
  vias: v2(267.1,209) v2(267.86,209)
S6_MPDCH37+:
  vias: v4(251.66,191.22)
S6_MPDCH37-:
  vias: v4(251.16,191.22)
S6_MPDCH39+:
  vias: v4(251.66,190.22)
S6_MPDCH39-:
  vias: v4(251.16,190.22)
S6_MPDCH41+: length 0.5
  BOTTOM w0.16: UNK6U408.E8 v4(252.16,189.72)
S6_MPDCH41-: length 0.5
  BOTTOM w0.16: UNK6U408.E9 v4(250.66,189.72)
S6_MPDCH43+:
  vias: v4(251.66,179.65)
S6_MPDCH43-:
  vias: v4(251.16,179.65)
S6_MPDCH45+:
  vias: v4(251.66,178.65)
S6_MPDCH45-:
  vias: v4(251.16,178.65)
S6_MPDCH47+: length 0.5
  BOTTOM w0.16: UNK6U409.E8 v4(252.16,178.15)
S6_MPDCH47-: length 0.5
  BOTTOM w0.16: UNK6U409.E9 v4(250.66,178.15)
S6_MPDCH52:
  vias: v2(273.76,181.71)
S6_MPDCH53:
  vias: v2(267.9,182.35)
S6_MPDCH56:
  vias: v2(267.9,186.26)
S6_MPDCH57:
  vias: v2(273.76,183)
S6_MPDCH59:
  vias: v2(273.76,182.36)
S6_MPDCH62:
  vias: v2(275.06,184.96)
S6_MPDCH63:
  vias: v2(273.76,186.91)
S6_MPDCH65:
  vias: v2(275.06,187.56)
S6_MPDCH66:
  vias: v2(275.06,186.91)
S6_MPDCH75:
  vias: v2(275.06,186.26)
S6_MPDCH77:
  vias: v2(273.76,186.26)
S6_MPDCH85:
  vias: v2(273.11,186.26)
S6_MUX_3V3: length 1.5
  TOP w0.508: v2(267.1,207.19) v2(267.86,207.19)
  BOTTOM w0.508: v2(267.86,207.19) UNK6R512.1 v2(267.1,207.19)
  vias: v2(262.6,172.36) v2(269.83,212.29)
S6_OUT_RX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK6U408.B2 255,190.88 256.57,190.88 257.06,191.37 257.06,191.91 v2(257.22,192.07)
S6_OUT_RX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK6U408.B1 255.19,191.25 256.41,191.25 256.68,191.52 256.68,191.9 v2(256.51,192.07)
S6_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK6U408.B4 254.15,191.71 254.15,192.41 254.44,192.7 254.94,192.7 255.3,193.05 255.3,193.77 UNK6R647.1
S6_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK6U408.A4 253.78,191.83 253.78,192.57 254.28,193.07 254.79,193.07 254.92,193.21 254.92,193.38 254.81,193.5 254.45,193.5 254.38,193.57 254.38,193.78 254.46,193.86 UNK6R646.1
S6_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK6C309.1 UNK6R646.2 UNK6R647.2
S6_OUT_RX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK6U408.D2 255.02,190.57 256.56,190.57 257.05,190.08 257.05,189.53 v2(257.22,189.36)
  vias: v2(269.85,187.56)
S6_OUT_RX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK6U408.D1 255.18,190.2 256.41,190.2 256.68,189.93 256.68,189.53 v2(256.51,189.36)
S6_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: UNK6U408.B5 253.41,191.47 253.41,191.97
  BOTTOM w0.132: UNK6R168.1 253.82,193.7 253.82,193.24 253.41,192.83 253.41,191.97
S6_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK6R170.1 253.45,193.7 253.45,193.39 253.2,193.14 252.82,193.14 252.69,193.01 252.69,192.82 252.82,192.69 252.91,192.69 253.04,192.56 253.04,191.84 UNK6U408.A5
S6_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK6C310.1 UNK6R168.2 UNK6R170.2
S6_OUT_RX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK6U408.E2 v2(254.16,189.72)
S6_OUT_RX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK6U408.E1 v2(255.66,189.72)
S6_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK6R176.1 251.8,193.7 251.8,192.62 252.28,192.14 252.28,191.59 UNK6U408.B6
S6_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK6R178.1 252.64,193.86 252.77,193.73 252.77,193.51 252.66,193.4 252.47,193.4 252.17,193.1 252.17,192.78 252.66,192.29 252.66,191.72 UNK6U408.A6
S6_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK6R178.2 UNK6R176.2 UNK6C318.1
S6_OUT_RX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK6U409.B2 255,179.31 256.57,179.31 257.06,179.8 257.06,180.34 v2(257.22,180.5)
  vias: v2(268.55,187.56)
S6_OUT_RX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK6U409.B1 255.19,179.69 256.41,179.69 256.68,179.96 256.68,180.34 v2(256.51,180.5)
S6_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK6R1089.1 255.3,182.21 255.3,181.48 254.94,181.13 254.44,181.13 254.15,180.85 254.15,180.14 UNK6U409.B4
S6_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK6U409.A4 253.78,180.27 253.78,181 254.28,181.51 254.79,181.51 254.92,181.64 254.92,181.81 254.81,181.93 254.45,181.93 254.38,182 254.38,182.21 254.46,182.3 UNK6R1088.1
S6_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK6R1089.2 UNK6R1088.2 UNK6C302.1
S6_OUT_RX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK6U409.D2 255.02,179.01 256.56,179.01 257.05,178.51 257.05,177.97 v2(257.22,177.8)
S6_OUT_RX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK6U409.D1 255.18,178.63 256.41,178.63 256.68,178.36 256.68,177.96 v2(256.51,177.8)
  vias: v2(267.9,187.56)
S6_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK6U409.B5 253.41,179.9 253.41,180.41
  BOTTOM w0.132: 253.41,180.41 253.41,181.26 253.82,181.67 253.82,182.13 UNK6R180.1
S6_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK6R182.1 253.45,182.13 253.45,181.83 253.2,181.57 252.82,181.57 252.69,181.44 252.69,181.25 252.82,181.12 252.91,181.12 253.04,181 253.04,180.27 UNK6U409.A5
S6_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK6C320.1 UNK6R180.2 UNK6R182.2
S6_OUT_RX0_CH5_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK6U409.E2 v2(254.16,178.15)
S6_OUT_RX0_CH5_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK6U409.E1 v2(255.66,178.15)
S6_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.076: UNK6U409.B6 252.28,180.03
  BOTTOM w0.132: UNK6R666.1 251.8,182.13 251.8,181.06 252.28,180.57 252.28,180.03
S6_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK6R664.1 252.64,182.3 252.77,182.17 252.77,181.94 252.66,181.84 252.47,181.84 252.17,181.53 252.17,181.21 252.66,180.72 252.66,180.15 UNK6U409.A6
S6_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK6C924.1 UNK6R666.2 UNK6R664.2
S6_OUT_TX0_CH0_ABC_CASE-:
  vias: v2(266.61,187.56)
