# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
PG_VG93K_F_G8D232
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G8D425_ND
  round 1.778 smd: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27) A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G8D427
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G8D428
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G8D429_ND
  round 1.778 smd: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27) A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G8D431
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G8D432
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G8DPS8
  round 1.778 hole 0.711: A01(20.32,2.54) A02(17.78,2.54) A03(15.24,2.54) A04(12.7,2.54) A05(10.16,2.54) A06(7.62,2.54) A07(5.08,2.54) A08(2.54,2.54) A09(0,2.54) A10(-2.54,2.54) A11(-5.08,2.54) A12(-7.62,2.54) A13(-10.16,2.54) A14(-12.7,2.54) A15(-15.24,2.54) A16(-17.78,2.54) A17(-20.32,2.54) B01(20.32,0) B02(17.78,0) B03(15.24,0) B04(12.7,0) B05(10.16,0) B06(7.62,0) B07(5.08,0) B08(2.54,0) B09(0,0) B10(-2.54,0) B11(-5.08,0) B12(-7.62,0) B13(-10.16,0) B14(-12.7,0) B15(-15.24,0) B16(-17.78,0) B17(-20.32,0) C01(20.32,-2.54) C02(17.78,-2.54) C03(15.24,-2.54) C04(12.7,-2.54) C05(10.16,-2.54) C06(7.62,-2.54) C07(5.08,-2.54) C08(2.54,-2.54) C09(0,-2.54) C10(-2.54,-2.54) C11(-5.08,-2.54) C12(-7.62,-2.54) C13(-10.16,-2.54) C14(-12.7,-2.54) C15(-15.24,-2.54) C16(-17.78,-2.54) C17(-20.32,-2.54)
PG_VG93K_F_G8UTI4
  round 1.778 hole 0.711: A01(20.32,1.27) A02(17.78,1.27) A03(15.24,1.27) A04(12.7,1.27) A05(10.16,1.27) A06(7.62,1.27) A07(5.08,1.27) A08(2.54,1.27) A09(0,1.27) A10(-2.54,1.27) A11(-5.08,1.27) A12(-7.62,1.27) A13(-10.16,1.27) A14(-12.7,1.27) A15(-15.24,1.27) A16(-17.78,1.27) A17(-20.32,1.27) B01(20.32,-1.27) B02(17.78,-1.27) B03(15.24,-1.27) B04(12.7,-1.27) B05(10.16,-1.27) B06(7.62,-1.27) B07(5.08,-1.27) B08(2.54,-1.27) B09(0,-1.27) B10(-2.54,-1.27) B11(-5.08,-1.27) B12(-7.62,-1.27) B13(-10.16,-1.27) B14(-12.7,-1.27) B15(-15.24,-1.27) B16(-17.78,-1.27) B17(-20.32,-1.27)
PG_VG93K_F_HSM_G8D226_626_ND
  rect 1.626x1.626 smd: A1(20.32,3.81) A3(15.24,3.81) A5(10.16,3.81) A7(5.08,3.81) A9(0,3.81) A11(-5.08,3.81) A13(-10.16,3.81) A15(-15.24,3.81) A17(-20.32,3.81) B2(17.78,1.27) B4(12.7,1.27) B6(7.62,1.27) B8(2.54,1.27) B10(-2.54,1.27) B12(-7.62,1.27) B14(-12.7,1.27) B16(-17.78,1.27) C1(20.32,-1.27) C3(15.24,-1.27) C5(10.16,-1.27) C7(5.08,-1.27) C9(0,-1.27) C11(-5.08,-1.27) C13(-10.16,-1.27) C15(-15.24,-1.27) C17(-20.32,-1.27) D2(17.78,-3.81) D4(12.7,-3.81) D6(7.62,-3.81) D8(2.54,-3.81) D10(-2.54,-3.81) D12(-7.62,-3.81) D14(-12.7,-3.81) D16(-17.78,-3.81)
  round 1.626 smd: A2(17.78,3.81) A4(12.7,3.81) A6(7.62,3.81) A8(2.54,3.81) A10(-2.54,3.81) A12(-7.62,3.81) A14(-12.7,3.81) A16(-17.78,3.81) B1(20.32,1.27) B3(15.24,1.27) B5(10.16,1.27) B7(5.08,1.27) B9(0,1.27) B11(-5.08,1.27) B13(-10.16,1.27) B15(-15.24,1.27) B17(-20.32,1.27) C2(17.78,-1.27) C4(12.7,-1.27) C6(7.62,-1.27) C8(2.54,-1.27) C10(-2.54,-1.27) C12(-7.62,-1.27) C14(-12.7,-1.27) C16(-17.78,-1.27) D3(15.24,-3.81) D5(10.16,-3.81) D7(5.08,-3.81) D9(0,-3.81) D11(-5.08,-3.81) D13(-10.16,-3.81) D15(-15.24,-3.81)
PG_VG93K_F_HSM_G8D230_630_ND
  rect 1.626x1.626 smd: A1(20.32,3.81) A3(15.24,3.81) A5(10.16,3.81) A7(5.08,3.81) A9(0,3.81) A11(-5.08,3.81) A13(-10.16,3.81) A15(-15.24,3.81) A17(-20.32,3.81) B2(17.78,1.27) B4(12.7,1.27) B6(7.62,1.27) B8(2.54,1.27) B10(-2.54,1.27) B12(-7.62,1.27) B14(-12.7,1.27) B16(-17.78,1.27) C1(20.32,-1.27) C3(15.24,-1.27) C5(10.16,-1.27) C7(5.08,-1.27) C9(0,-1.27) C11(-5.08,-1.27) C13(-10.16,-1.27) C15(-15.24,-1.27) C17(-20.32,-1.27) D2(17.78,-3.81) D4(12.7,-3.81) D6(7.62,-3.81) D8(2.54,-3.81) D10(-2.54,-3.81) D12(-7.62,-3.81) D14(-12.7,-3.81) D16(-17.78,-3.81)
  round 1.626 smd: A2(17.78,3.81) A4(12.7,3.81) A6(7.62,3.81) A8(2.54,3.81) A10(-2.54,3.81) A12(-7.62,3.81) A14(-12.7,3.81) A16(-17.78,3.81) B1(20.32,1.27) B3(15.24,1.27) B5(10.16,1.27) B7(5.08,1.27) B9(0,1.27) B11(-5.08,1.27) B13(-10.16,1.27) B15(-15.24,1.27) B17(-20.32,1.27) C2(17.78,-1.27) C4(12.7,-1.27) C6(7.62,-1.27) C8(2.54,-1.27) C10(-2.54,-1.27) C12(-7.62,-1.27) C14(-12.7,-1.27) C16(-17.78,-1.27) D3(15.24,-3.81) D5(10.16,-3.81) D7(5.08,-3.81) D9(0,-3.81) D11(-5.08,-3.81) D13(-10.16,-3.81) D15(-15.24,-3.81)
PG_VG93K_PF_DPS32_G1D303
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A3(-15.24,-3.81) A5(-10.16,-3.81) A7(-5.08,-3.81) A9(0,-3.81) A11(5.08,-3.81) A13(10.16,-3.81) A15(15.24,-3.81) B2(-17.78,-1.27) B4(-12.7,-1.27) B6(-7.62,-1.27) B8(-2.54,-1.27) B10(2.54,-1.27) B12(7.62,-1.27) B14(12.7,-1.27) B16(17.78,-1.27) C1(-20.32,1.27) C3(-15.24,1.27) C5(-10.16,1.27) C7(-5.08,1.27) C9(0,1.27) C11(5.08,1.27) C13(10.16,1.27) C15(15.24,1.27) D2(-17.78,3.81) D4(-12.7,3.81) D6(-7.62,3.81) D8(-2.54,3.81) D10(2.54,3.81) D12(7.62,3.81) D14(12.7,3.81) D16(17.78,3.81)
  round 1.524 hole 0.711: A2(-17.78,-3.81) A4(-12.7,-3.81) A6(-7.62,-3.81) A8(-2.54,-3.81) A10(2.54,-3.81) A12(7.62,-3.81) A14(12.7,-3.81) A16(17.78,-3.81) A17(20.32,-3.81) B1(-20.32,-1.27) B3(-15.24,-1.27) B5(-10.16,-1.27) B7(-5.08,-1.27) B9(0,-1.27) B11(5.08,-1.27) B13(10.16,-1.27) B15(15.24,-1.27) B17(20.32,-1.27) C2(-17.78,1.27) C4(-12.7,1.27) C6(-7.62,1.27) C8(-2.54,1.27) C10(2.54,1.27) C12(7.62,1.27) C14(12.7,1.27) C16(17.78,1.27) C17(20.32,1.27) D1(-20.32,3.81) D3(-15.24,3.81) D5(-10.16,3.81) D7(-5.08,3.81) D9(0,3.81) D11(5.08,3.81) D13(10.16,3.81) D15(15.24,3.81) D17(20.32,3.81)
PG_VG93K_PF_DPS32_G1D307
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A3(-15.24,-3.81) A5(-10.16,-3.81) A7(-5.08,-3.81) A9(0,-3.81) A11(5.08,-3.81) A13(10.16,-3.81) A15(15.24,-3.81) B2(-17.78,-1.27) B4(-12.7,-1.27) B6(-7.62,-1.27) B8(-2.54,-1.27) B10(2.54,-1.27) B12(7.62,-1.27) B14(12.7,-1.27) B16(17.78,-1.27) C1(-20.32,1.27) C3(-15.24,1.27) C5(-10.16,1.27) C7(-5.08,1.27) C9(0,1.27) C11(5.08,1.27) C13(10.16,1.27) C15(15.24,1.27) D2(-17.78,3.81) D4(-12.7,3.81) D6(-7.62,3.81) D8(-2.54,3.81) D10(2.54,3.81) D12(7.62,3.81) D14(12.7,3.81) D16(17.78,3.81)
  round 1.524 hole 0.711: A2(-17.78,-3.81) A4(-12.7,-3.81) A6(-7.62,-3.81) A8(-2.54,-3.81) A10(2.54,-3.81) A12(7.62,-3.81) A14(12.7,-3.81) A16(17.78,-3.81) A17(20.32,-3.81) B1(-20.32,-1.27) B3(-15.24,-1.27) B5(-10.16,-1.27) B7(-5.08,-1.27) B9(0,-1.27) B11(5.08,-1.27) B13(10.16,-1.27) B15(15.24,-1.27) B17(20.32,-1.27) C2(-17.78,1.27) C4(-12.7,1.27) C6(-7.62,1.27) C8(-2.54,1.27) C10(2.54,1.27) C12(7.62,1.27) C14(12.7,1.27) C16(17.78,1.27) C17(20.32,1.27) D1(-20.32,3.81) D3(-15.24,3.81) D5(-10.16,3.81) D7(-5.08,3.81) D9(0,3.81) D11(5.08,3.81) D13(10.16,3.81) D15(15.24,3.81) D17(20.32,3.81)
PG_VG93K_PF_DPS32_G2D310
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A3(15.24,3.81) A5(10.16,3.81) A7(5.08,3.81) A9(0,3.81) A11(-5.08,3.81) A13(-10.16,3.81) A15(-15.24,3.81) B2(17.78,1.27) B4(12.7,1.27) B6(7.62,1.27) B8(2.54,1.27) B10(-2.54,1.27) B12(-7.62,1.27) B14(-12.7,1.27) B16(-17.78,1.27) C1(20.32,-1.27) C3(15.24,-1.27) C5(10.16,-1.27) C7(5.08,-1.27) C9(0,-1.27) C11(-5.08,-1.27) C13(-10.16,-1.27) C15(-15.24,-1.27) D2(17.78,-3.81) D4(12.7,-3.81) D6(7.62,-3.81) D8(2.54,-3.81) D10(-2.54,-3.81) D12(-7.62,-3.81) D14(-12.7,-3.81) D16(-17.78,-3.81)
  round 1.524 hole 0.711: A2(17.78,3.81) A4(12.7,3.81) A6(7.62,3.81) A8(2.54,3.81) A10(-2.54,3.81) A12(-7.62,3.81) A14(-12.7,3.81) A16(-17.78,3.81) A17(-20.32,3.81) B1(20.32,1.27) B3(15.24,1.27) B5(10.16,1.27) B7(5.08,1.27) B9(0,1.27) B11(-5.08,1.27) B13(-10.16,1.27) B15(-15.24,1.27) B17(-20.32,1.27) C2(17.78,-1.27) C4(12.7,-1.27) C6(7.62,-1.27) C8(2.54,-1.27) C10(-2.54,-1.27) C12(-7.62,-1.27) C14(-12.7,-1.27) C16(-17.78,-1.27) C17(-20.32,-1.27) D1(20.32,-3.81) D3(15.24,-3.81) D5(10.16,-3.81) D7(5.08,-3.81) D9(0,-3.81) D11(-5.08,-3.81) D13(-10.16,-3.81) D15(-15.24,-3.81) D17(-20.32,-3.81)
PG_VG93K_PF_DPS32_G2D314
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A3(15.24,3.81) A5(10.16,3.81) A7(5.08,3.81) A9(0,3.81) A11(-5.08,3.81) A13(-10.16,3.81) A15(-15.24,3.81) B2(17.78,1.27) B4(12.7,1.27) B6(7.62,1.27) B8(2.54,1.27) B10(-2.54,1.27) B12(-7.62,1.27) B14(-12.7,1.27) B16(-17.78,1.27) C1(20.32,-1.27) C3(15.24,-1.27) C5(10.16,-1.27) C7(5.08,-1.27) C9(0,-1.27) C11(-5.08,-1.27) C13(-10.16,-1.27) C15(-15.24,-1.27) D2(17.78,-3.81) D4(12.7,-3.81) D6(7.62,-3.81) D8(2.54,-3.81) D10(-2.54,-3.81) D12(-7.62,-3.81) D14(-12.7,-3.81) D16(-17.78,-3.81)
  round 1.524 hole 0.711: A2(17.78,3.81) A4(12.7,3.81) A6(7.62,3.81) A8(2.54,3.81) A10(-2.54,3.81) A12(-7.62,3.81) A14(-12.7,3.81) A16(-17.78,3.81) A17(-20.32,3.81) B1(20.32,1.27) B3(15.24,1.27) B5(10.16,1.27) B7(5.08,1.27) B9(0,1.27) B11(-5.08,1.27) B13(-10.16,1.27) B15(-15.24,1.27) B17(-20.32,1.27) C2(17.78,-1.27) C4(12.7,-1.27) C6(7.62,-1.27) C8(2.54,-1.27) C10(-2.54,-1.27) C12(-7.62,-1.27) C14(-12.7,-1.27) C16(-17.78,-1.27) C17(-20.32,-1.27) D1(20.32,-3.81) D3(15.24,-3.81) D5(10.16,-3.81) D7(5.08,-3.81) D9(0,-3.81) D11(-5.08,-3.81) D13(-10.16,-3.81) D15(-15.24,-3.81) D17(-20.32,-3.81)
PG_VG93K_PF_DPS32_G3D319
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A3(-15.24,-3.81) A5(-10.16,-3.81) A7(-5.08,-3.81) A9(0,-3.81) A11(5.08,-3.81) A13(10.16,-3.81) A15(15.24,-3.81) B2(-17.78,-1.27) B4(-12.7,-1.27) B6(-7.62,-1.27) B8(-2.54,-1.27) B10(2.54,-1.27) B12(7.62,-1.27) B14(12.7,-1.27) B16(17.78,-1.27) C1(-20.32,1.27) C3(-15.24,1.27) C5(-10.16,1.27) C7(-5.08,1.27) C9(0,1.27) C11(5.08,1.27) C13(10.16,1.27) C15(15.24,1.27) D2(-17.78,3.81) D4(-12.7,3.81) D6(-7.62,3.81) D8(-2.54,3.81) D10(2.54,3.81) D12(7.62,3.81) D14(12.7,3.81) D16(17.78,3.81)
  round 1.524 hole 0.711: A2(-17.78,-3.81) A4(-12.7,-3.81) A6(-7.62,-3.81) A8(-2.54,-3.81) A10(2.54,-3.81) A12(7.62,-3.81) A14(12.7,-3.81) A16(17.78,-3.81) A17(20.32,-3.81) B1(-20.32,-1.27) B3(-15.24,-1.27) B5(-10.16,-1.27) B7(-5.08,-1.27) B9(0,-1.27) B11(5.08,-1.27) B13(10.16,-1.27) B15(15.24,-1.27) B17(20.32,-1.27) C2(-17.78,1.27) C4(-12.7,1.27) C6(-7.62,1.27) C8(-2.54,1.27) C10(2.54,1.27) C12(7.62,1.27) C14(12.7,1.27) C16(17.78,1.27) C17(20.32,1.27) D1(-20.32,3.81) D3(-15.24,3.81) D5(-10.16,3.81) D7(-5.08,3.81) D9(0,3.81) D11(5.08,3.81) D13(10.16,3.81) D15(15.24,3.81) D17(20.32,3.81)
PG_VG93K_PF_DPS32_G3D323
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A3(-15.24,-3.81) A5(-10.16,-3.81) A7(-5.08,-3.81) A9(0,-3.81) A11(5.08,-3.81) A13(10.16,-3.81) A15(15.24,-3.81) B2(-17.78,-1.27) B4(-12.7,-1.27) B6(-7.62,-1.27) B8(-2.54,-1.27) B10(2.54,-1.27) B12(7.62,-1.27) B14(12.7,-1.27) B16(17.78,-1.27) C1(-20.32,1.27) C3(-15.24,1.27) C5(-10.16,1.27) C7(-5.08,1.27) C9(0,1.27) C11(5.08,1.27) C13(10.16,1.27) C15(15.24,1.27) D2(-17.78,3.81) D4(-12.7,3.81) D6(-7.62,3.81) D8(-2.54,3.81) D10(2.54,3.81) D12(7.62,3.81) D14(12.7,3.81) D16(17.78,3.81)
  round 1.524 hole 0.711: A2(-17.78,-3.81) A4(-12.7,-3.81) A6(-7.62,-3.81) A8(-2.54,-3.81) A10(2.54,-3.81) A12(7.62,-3.81) A14(12.7,-3.81) A16(17.78,-3.81) A17(20.32,-3.81) B1(-20.32,-1.27) B3(-15.24,-1.27) B5(-10.16,-1.27) B7(-5.08,-1.27) B9(0,-1.27) B11(5.08,-1.27) B13(10.16,-1.27) B15(15.24,-1.27) B17(20.32,-1.27) C2(-17.78,1.27) C4(-12.7,1.27) C6(-7.62,1.27) C8(-2.54,1.27) C10(2.54,1.27) C12(7.62,1.27) C14(12.7,1.27) C16(17.78,1.27) C17(20.32,1.27) D1(-20.32,3.81) D3(-15.24,3.81) D5(-10.16,3.81) D7(-5.08,3.81) D9(0,3.81) D11(5.08,3.81) D13(10.16,3.81) D15(15.24,3.81) D17(20.32,3.81)
PG_VG93K_PF_DPS32_G8D426
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A3(15.24,3.81) A5(10.16,3.81) A7(5.08,3.81) A9(0,3.81) A11(-5.08,3.81) A13(-10.16,3.81) A15(-15.24,3.81) B2(17.78,1.27) B4(12.7,1.27) B6(7.62,1.27) B8(2.54,1.27) B10(-2.54,1.27) B12(-7.62,1.27) B14(-12.7,1.27) B16(-17.78,1.27) C1(20.32,-1.27) C3(15.24,-1.27) C5(10.16,-1.27) C7(5.08,-1.27) C9(0,-1.27) C11(-5.08,-1.27) C13(-10.16,-1.27) C15(-15.24,-1.27) D2(17.78,-3.81) D4(12.7,-3.81) D6(7.62,-3.81) D8(2.54,-3.81) D10(-2.54,-3.81) D12(-7.62,-3.81) D14(-12.7,-3.81) D16(-17.78,-3.81)
  round 1.524 hole 0.711: A2(17.78,3.81) A4(12.7,3.81) A6(7.62,3.81) A8(2.54,3.81) A10(-2.54,3.81) A12(-7.62,3.81) A14(-12.7,3.81) A16(-17.78,3.81) A17(-20.32,3.81) B1(20.32,1.27) B3(15.24,1.27) B5(10.16,1.27) B7(5.08,1.27) B9(0,1.27) B11(-5.08,1.27) B13(-10.16,1.27) B15(-15.24,1.27) B17(-20.32,1.27) C2(17.78,-1.27) C4(12.7,-1.27) C6(7.62,-1.27) C8(2.54,-1.27) C10(-2.54,-1.27) C12(-7.62,-1.27) C14(-12.7,-1.27) C16(-17.78,-1.27) C17(-20.32,-1.27) D1(20.32,-3.81) D3(15.24,-3.81) D5(10.16,-3.81) D7(5.08,-3.81) D9(0,-3.81) D11(-5.08,-3.81) D13(-10.16,-3.81) D15(-15.24,-3.81) D17(-20.32,-3.81)
PG_VG93K_PF_DPS32_G8D430
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A3(15.24,3.81) A5(10.16,3.81) A7(5.08,3.81) A9(0,3.81) A11(-5.08,3.81) A13(-10.16,3.81) A15(-15.24,3.81) B2(17.78,1.27) B4(12.7,1.27) B6(7.62,1.27) B8(2.54,1.27) B10(-2.54,1.27) B12(-7.62,1.27) B14(-12.7,1.27) B16(-17.78,1.27) C1(20.32,-1.27) C3(15.24,-1.27) C5(10.16,-1.27) C7(5.08,-1.27) C9(0,-1.27) C11(-5.08,-1.27) C13(-10.16,-1.27) C15(-15.24,-1.27) D2(17.78,-3.81) D4(12.7,-3.81) D6(7.62,-3.81) D8(2.54,-3.81) D10(-2.54,-3.81) D12(-7.62,-3.81) D14(-12.7,-3.81) D16(-17.78,-3.81)
  round 1.524 hole 0.711: A2(17.78,3.81) A4(12.7,3.81) A6(7.62,3.81) A8(2.54,3.81) A10(-2.54,3.81) A12(-7.62,3.81) A14(-12.7,3.81) A16(-17.78,3.81) A17(-20.32,3.81) B1(20.32,1.27) B3(15.24,1.27) B5(10.16,1.27) B7(5.08,1.27) B9(0,1.27) B11(-5.08,1.27) B13(-10.16,1.27) B15(-15.24,1.27) B17(-20.32,1.27) C2(17.78,-1.27) C4(12.7,-1.27) C6(7.62,-1.27) C8(2.54,-1.27) C10(-2.54,-1.27) C12(-7.62,-1.27) C14(-12.7,-1.27) C16(-17.78,-1.27) C17(-20.32,-1.27) D1(20.32,-3.81) D3(15.24,-3.81) D5(10.16,-3.81) D7(5.08,-3.81) D9(0,-3.81) D11(-5.08,-3.81) D13(-10.16,-3.81) D15(-15.24,-3.81) D17(-20.32,-3.81)
R0201
  rect 0.305x0.356 smd: 1(-0.3,0) 2(0.3,0)
R0201_MINI
  rect 0.254x0.33 smd: 1(-0.25,0) 2(0.25,0)
R0402
  custom 0.15x0.15 smd: 1(-0.5,0) 2(0.5,0)
R0402_UNBGA_V2
  rect 0.508x0.508 smd: 1(-0.425,0) 2(0.425,0)
R0603
  rect 0.889x0.889 smd: 1(-0.85,0) 2(0.85,0)
R0805
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
RL_AQY221R2MY_5V_V2
  rect 1.219x0.711 smd: 1(-1.35,0.635) 2(-1.35,-0.635) 3(1.35,-0.635) 4(1.35,0.635)
RL_G6K2F-Y_5V_OMRON
  rect 0.813x1.829 smd: 1(-3.8,-3.5) 2(-0.6,-3.5) 3(1.6,-3.5) 4(3.8,-3.5) 5(3.8,3.5) 6(1.6,3.5) 7(-0.6,3.5) 8(-3.8,3.5)
RL_NECEC2_10P_5V
  rect 1.626x1.626 hole 1.041: 1(6.35,2.54)
  round 1.626 hole 1.041: 3(1.27,2.54) 4(-1.27,2.54) 5(-3.81,2.54) 8(-3.81,-2.54) 9(-1.27,-2.54) 10(1.27,-2.54) 12(6.35,-2.54)
RL_NECUA2_5V_V3
  rect 1.626x1.626 hole 1.041: 1(3.6,1.6)
  round 1.626 hole 1.041: 2(0.4,1.6) 3(-1.8,1.6) 4(-4,1.6) 5(-4,-1.6) 6(-1.8,-1.6) 7(0.4,-1.6) 8(3.6,-1.6)
RL_OMRONG6K2PY_5V
  rect 1.626x1.626 hole 1.041: 1(3.6,2.54)
  round 1.626 hole 1.041: 2(0.4,2.54) 3(-1.8,2.54) 4(-4,2.54) 5(-4,-2.54) 6(-1.8,-2.54) 7(0.4,-2.54) 8(3.6,-2.54)
SC70_5P
  rect 0.406x0.762 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(-0.65,0.95)
SK_SO8_1P27MM_DEDIPROG_V3
  rect 0.64x4 smd: 1(-1.905,-4.423) 2(-0.635,-4.423) 3(0.635,-4.423) 4(1.905,-4.423) 5(1.905,4.423) 6(0.635,4.423) 7(-0.635,4.423) 8(-1.905,4.423)
SK_SO8_1P27MM_SDQ54CBAA_V2
  round 0.508 hole 0.864 unplated: (2.5,-2)
  round 0.508 hole 1.067 unplated: (2.5,2)
  rect 0.864x2.032 smd: 1(-1.905,-5.116) 2(-0.635,-5.116) 3(0.635,-5.116) 4(1.905,-5.116) 5(1.905,5.116) 6(0.635,5.116) 7(-0.635,5.116) 8(-1.905,5.116)
SK_TFBGA7X9_290P_0P4MM_JG
  round 0.508 hole 1.61 unplated: (-11.5,11.5) (-11.5,-11.5) (11.5,11.5) (11.5,-11.5)
  round 0.3 smd: A1(-4.2,3.2) A2(-3.8,3.2) A3(-3.4,3.2) A4(-3,3.2) A5(-2.6,3.2) A6(-2.2,3.2) A7(-1.8,3.2) A8(-1.4,3.2) A9(-1,3.2) A10(-0.6,3.2) A11(-0.2,3.2) A12(0.2,3.2) A13(0.6,3.2) A14(1,3.2) A15(1.4,3.2) A16(1.8,3.2) A17(2.2,3.2) A18(2.6,3.2) A19(3,3.2) A20(3.4,3.2) A21(3.8,3.2) A22(4.2,3.2) B1(-4.2,2.8) B2(-3.8,2.8) B3(-3.4,2.8) B4(-3,2.8) B5(-2.6,2.8) B6(-2.2,2.8) B7(-1.8,2.8) B8(-1.4,2.8) B9(-1,2.8) B10(-0.6,2.8) B11(-0.2,2.8) B12(0.2,2.8) B13(0.6,2.8) B14(1,2.8) B15(1.4,2.8) B16(1.8,2.8) B17(2.2,2.8) B18(2.6,2.8) B19(3,2.8) B20(3.4,2.8) B21(3.8,2.8) B22(4.2,2.8) C1(-4.2,2.4) C2(-3.8,2.4) C3(-3.4,2.4) C4(-3,2.4) C5(-2.6,2.4) C6(-2.2,2.4) C7(-1.8,2.4) C8(-1.4,2.4) C9(-1,2.4) C10(-0.6,2.4) C11(-0.2,2.4) C12(0.2,2.4) C13(0.6,2.4) C14(1,2.4) C15(1.4,2.4) C16(1.8,2.4) C17(2.2,2.4) C18(2.6,2.4) C19(3,2.4) C20(3.4,2.4) C21(3.8,2.4) C22(4.2,2.4) D1(-4.2,2) D2(-3.8,2) D3(-3.4,2) D4(-3,2) D5(-2.6,2) D6(-2.2,2) D7(-1.8,2) D8(-1.4,2) D9(-1,2) D10(-0.6,2) D11(-0.2,2) D12(0.2,2) D13(0.6,2) D14(1,2) D15(1.4,2) D16(1.8,2) D17(2.2,2) D18(2.6,2) D19(3,2) D20(3.4,2) D21(3.8,2) D22(4.2,2) E1(-4.2,1.6) E2(-3.8,1.6) E3(-3.4,1.6) E4(-3,1.6) E5(-2.6,1.6) E6(-2.2,1.6) E7(-1.8,1.6) E8(-1.4,1.6) E9(-1,1.6) E10(-0.6,1.6) E11(-0.2,1.6) E12(0.2,1.6) E13(0.6,1.6) E14(1,1.6) E15(1.4,1.6) E16(1.8,1.6) E17(2.2,1.6) E18(2.6,1.6) E19(3,1.6) E20(3.4,1.6) E21(3.8,1.6) E22(4.2,1.6) F1(-4.2,1.2) F2(-3.8,1.2) F3(-3.4,1.2) F4(-3,1.2) F5(-2.6,1.2) F6(-2.2,1.2) F7(-1.8,1.2) F8(-1.4,1.2) F9(-1,1.2) F10(-0.6,1.2) F11(-0.2,1.2) F12(0.2,1.2) F13(0.6,1.2) F14(1,1.2) F15(1.4,1.2) F16(1.8,1.2) F17(2.2,1.2) F18(2.6,1.2) F19(3,1.2) F20(3.4,1.2) F21(3.8,1.2) F22(4.2,1.2) G1(-4.2,0.8) G2(-3.8,0.8) G3(-3.4,0.8) G4(-3,0.8) G5(-2.6,0.8) G6(-2.2,0.8) G7(-1.8,0.8) G8(-1.4,0.8) G9(-1,0.8) G10(-0.6,0.8) G11(-0.2,0.8) G12(0.2,0.8) G13(0.6,0.8) G14(1,0.8) G15(1.4,0.8) G16(1.8,0.8) G17(2.2,0.8) G18(2.6,0.8) G19(3,0.8) G20(3.4,0.8) G21(3.8,0.8) G22(4.2,0.8) H1(-4.2,0.4) H2(-3.8,0.4) H3(-3.4,0.4) H4(-3,0.4) H5(-2.6,0.4) H6(-2.2,0.4) H7(-1.8,0.4) H8(-1.4,0.4) H9(-1,0.4) H10(-0.6,0.4) H11(-0.2,0.4) H12(0.2,0.4) H13(0.6,0.4) H14(1,0.4) H15(1.4,0.4) H16(1.8,0.4) H17(2.2,0.4) H18(2.6,0.4) H19(3,0.4) H20(3.4,0.4) H21(3.8,0.4) H22(4.2,0.4) J1(-4.2,0) J2(-3.8,0) J3(-3.4,0) J4(-3,0) J5(-2.6,0) J6(-2.2,0) J7(-1.8,0) J8(-1.4,0) J9(-1,0) J10(-0.6,0) J11(-0.2,0) J12(0.2,0) J13(0.6,0) J14(1,0) J15(1.4,0) J16(1.8,0) J17(2.2,0) J18(2.6,0) J19(3,0) J20(3.4,0) J21(3.8,0) J22(4.2,0) K1(-4.2,-0.4) K2(-3.8,-0.4) K3(-3.4,-0.4) K4(-3,-0.4) K5(-2.6,-0.4) K6(-2.2,-0.4) K7(-1.8,-0.4) K8(-1.4,-0.4) K9(-1,-0.4) K10(-0.6,-0.4) K11(-0.2,-0.4) K12(0.2,-0.4) K13(0.6,-0.4) K14(1,-0.4) K15(1.4,-0.4) K16(1.8,-0.4) K17(2.2,-0.4) K18(2.6,-0.4) K19(3,-0.4) K20(3.4,-0.4) K21(3.8,-0.4) K22(4.2,-0.4) L1(-4.2,-0.8) L2(-3.8,-0.8) L3(-3.4,-0.8) L4(-3,-0.8) L5(-2.6,-0.8) L6(-2.2,-0.8) L7(-1.8,-0.8) L8(-1.4,-0.8) L9(-1,-0.8) L10(-0.6,-0.8) L11(-0.2,-0.8) L12(0.2,-0.8) L13(0.6,-0.8) L14(1,-0.8) L15(1.4,-0.8) L16(1.8,-0.8) L17(2.2,-0.8) L18(2.6,-0.8) L19(3,-0.8) L20(3.4,-0.8) L21(3.8,-0.8) L22(4.2,-0.8) M1(-4.2,-1.2) M2(-3.8,-1.2) M3(-3.4,-1.2) M4(-3,-1.2) M5(-2.6,-1.2) M6(-2.2,-1.2) M7(-1.8,-1.2) M8(-1.4,-1.2) M9(-1,-1.2) M10(-0.6,-1.2) M11(-0.2,-1.2) M12(0.2,-1.2) M13(0.6,-1.2) M14(1,-1.2) M15(1.4,-1.2) M16(1.8,-1.2) M17(2.2,-1.2) M18(2.6,-1.2) M19(3,-1.2) M20(3.4,-1.2) M21(3.8,-1.2) M22(4.2,-1.2) N1(-4.2,-1.6) N2(-3.8,-1.6) N3(-3.4,-1.6) N4(-3,-1.6) N5(-2.6,-1.6) N6(-2.2,-1.6) N7(-1.8,-1.6) N8(-1.4,-1.6) N9(-1,-1.6) N10(-0.6,-1.6) N11(-0.2,-1.6) N12(0.2,-1.6) N13(0.6,-1.6) N14(1,-1.6) N15(1.4,-1.6) N16(1.8,-1.6) N17(2.2,-1.6) N18(2.6,-1.6) N19(3,-1.6) N20(3.4,-1.6) N21(3.8,-1.6) N22(4.2,-1.6) P1(-4.2,-2) P2(-3.8,-2) P3(-3.4,-2) P4(-3,-2) P5(-2.6,-2) P6(-2.2,-2) P7(-1.8,-2) P8(-1.4,-2) P9(-1,-2) P10(-0.6,-2) P11(-0.2,-2) P12(0.2,-2) P13(0.6,-2) P14(1,-2) P15(1.4,-2) P16(1.8,-2) P17(2.2,-2) P18(2.6,-2) P19(3,-2) P20(3.4,-2) P21(3.8,-2) P22(4.2,-2) R1(-4.2,-2.4) R2(-3.8,-2.4) R3(-3.4,-2.4) R4(-3,-2.4) R5(-2.6,-2.4) R6(-2.2,-2.4) R7(-1.8,-2.4) R8(-1.4,-2.4) R9(-1,-2.4) R10(-0.6,-2.4) R11(-0.2,-2.4) R12(0.2,-2.4) R13(0.6,-2.4) R14(1,-2.4) R15(1.4,-2.4) R16(1.8,-2.4) R17(2.2,-2.4) R18(2.6,-2.4) R19(3,-2.4) R20(3.4,-2.4) R21(3.8,-2.4) R22(4.2,-2.4) T1(-4.2,-2.8) T2(-3.8,-2.8) T3(-3.4,-2.8) T4(-3,-2.8) T5(-2.6,-2.8) T6(-2.2,-2.8) T7(-1.8,-2.8) T8(-1.4,-2.8) T9(-1,-2.8) T10(-0.6,-2.8) T11(-0.2,-2.8) T12(0.2,-2.8) T13(0.6,-2.8) T14(1,-2.8) T15(1.4,-2.8) T16(1.8,-2.8) T17(2.2,-2.8) T18(2.6,-2.8) T19(3,-2.8) T20(3.4,-2.8) T21(3.8,-2.8) T22(4.2,-2.8) U1(-4.2,-3.2) U2(-3.8,-3.2) U3(-3.4,-3.2) U4(-3,-3.2) U5(-2.6,-3.2) U6(-2.2,-3.2) U7(-1.8,-3.2) U8(-1.4,-3.2) U9(-1,-3.2) U10(-0.6,-3.2) U11(-0.2,-3.2) U12(0.2,-3.2) U13(0.6,-3.2) U14(1,-3.2) U15(1.4,-3.2) U16(1.8,-3.2) U17(2.2,-3.2) U18(2.6,-3.2) U19(3,-3.2) U20(3.4,-3.2) U21(3.8,-3.2) U22(4.2,-3.2)
  round 6.096 hole 3.759: NUT1(-15,15) NUT2(15,15) NUT3(-15,-15) NUT4(15,-15)
SO8_172X0P65MM
  rect 1.524x0.406 smd: 1(-2.184,0.975) 2(-2.184,0.325) 3(-2.184,-0.325) 4(-2.184,-0.975) 5(2.184,-0.975) 6(2.184,-0.325) 7(2.184,0.325) 8(2.184,0.975)
SO8_215X127MM
  rect 1.778x0.762 smd: 1(-2.731,2.032) 4(-2.731,-2.032) 5(2.731,-2.032) 8(2.731,2.032)
  rect 1.778x0.61 smd: 2(-2.731,0.635) 3(-2.731,-0.635) 6(2.731,-0.635) 7(2.731,0.635)
SO8_244X127MM
  rect 1.905x0.838 smd: 1(-3.099,1.905) 4(-3.099,-1.905) 5(3.099,-1.905) 8(3.099,1.905)
  rect 1.905x0.635 smd: 2(-3.099,0.635) 3(-3.099,-0.635) 6(3.099,-0.635) 7(3.099,0.635)
SO14_0P5_14P_74HC14
  rect 0.635x0.305 smd: 1(-1.385,-0.25) 7(1.385,-0.25) 8(1.385,0.25) 14(-1.385,0.25)
  rect 0.305x0.635 smd: 2(-1,-1.13) 3(-0.5,-1.13) 4(0,-1.13) 5(0.5,-1.13) 6(1,-1.13) 9(1,1.13) 10(0.5,1.13) 11(0,1.13) 12(-0.5,1.13) 13(-1,1.13)
  rect 1.651x1.143 smd: EP(0,0)
SOCKET_CODE
  round 0.051 smd: 1(0,0)
SOT23_6P_0P95X2P7MM_H1P45MM
  rect 0.7x1.1 smd: 1(-0.95,-1.35) 2(0,-1.35) 3(0.95,-1.35) 4(0.95,1.35) 5(0,1.35) 6(-0.95,1.35)
SOT89
  rect 0.762x1.27 smd: 1(-1.499,-1.714) 3(1.499,-1.714)
  custom 0.508x0.508 smd: 2(0,-1.587)
SOT_89_5
  rect 0.635x1.524 smd: 1(-1.5,-1.879) 3(1.5,-1.879) 4(1.5,1.879) 5(-1.5,1.879)
  custom 0.401x0.401 smd: 2(0,0)
SW8X2_2P54MM_16P_SMD
  rect 1.143x2.032 smd: 1(-8.877,-4.704) 2(-6.337,-4.704) 3(-3.797,-4.704) 4(-1.257,-4.704) 5(1.283,-4.704) 6(3.823,-4.704) 7(6.363,-4.704) 8(8.903,-4.704) 9(-8.877,4.704) 10(-6.337,4.704) 11(-3.797,4.704) 12(-1.257,4.704) 13(1.283,4.704) 14(3.823,4.704) 15(6.363,4.704) 16(8.903,4.704)
SW_8PX1_2P54MM_SMD
  rect 1.016x3.048 smd: 1(-8.89,3.88) 2(-6.35,3.88) 3(-3.81,3.88) 4(-1.27,3.88) 5(1.27,3.88) 6(3.81,3.88) 7(6.35,3.88) 8(8.89,3.88) 9(8.89,-3.88) 10(-8.89,-3.88)
SW_UMLP2P6X1P8_12P_0P4MM
  rect 0.686x0.229 smd: 1(-0.719,0.6)
  rect 0.584x0.229 smd: 2(-0.769,0.2) 3(-0.769,-0.2) 4(-0.769,-0.6) 9(0.769,-0.6) 10(0.769,-0.2) 11(0.769,0.2) 12(0.769,0.6)
  rect 0.229x0.584 smd: 5(-0.6,-1.168) 6(-0.2,-1.168) 7(0.2,-1.168) 8(0.6,-1.168) 13(0.6,1.168) 14(0.2,1.168) 15(-0.2,1.168) 16(-0.6,1.168)
TFBGA9X9_50P_0P5MM
  round 0.35 smd: A1(-2,2) A2(-1.5,2) A4(-0.5,2) A5(0,2) A6(0.5,2) A8(1.5,2) A9(2,2) B1(-2,1.5) B2(-1.5,1.5) B3(-1,1.5) B4(-0.5,1.5) B5(0,1.5) B6(0.5,1.5) B7(1,1.5) B8(1.5,1.5) B9(2,1.5) C2(-1.5,1) C8(1.5,1) D1(-2,0.5) D2(-1.5,0.5) D8(1.5,0.5) D9(2,0.5) E1(-2,0) E2(-1.5,0) E8(1.5,0) E9(2,0) F1(-2,-0.5) F2(-1.5,-0.5) F8(1.5,-0.5) F9(2,-0.5) G2(-1.5,-1) G8(1.5,-1) H1(-2,-1.5) H2(-1.5,-1.5) H3(-1,-1.5) H4(-0.5,-1.5) H5(0,-1.5) H6(0.5,-1.5) H7(1,-1.5) H8(1.5,-1.5) H9(2,-1.5) J1(-2,-2) J2(-1.5,-2) J3(-1,-2) J4(-0.5,-2) J5(0,-2) J6(0.5,-2) J7(1,-2) J8(1.5,-2) J9(2,-2)
TP_040_T
  round 1.016 smd: 1(0,0)
TSSOP16_228X065MM
  rect 1.524x0.584 smd: 1(-2.9,2.377) 8(-2.9,-2.377) 9(2.9,-2.377) 16(2.9,2.377)
  rect 1.524x0.381 smd: 2(-2.9,1.625) 3(-2.9,0.975) 4(-2.9,0.325) 5(-2.9,-0.325) 6(-2.9,-0.975) 7(-2.9,-1.625) 10(2.9,-1.625) 11(2.9,-0.975) 12(2.9,-0.325) 13(2.9,0.325) 14(2.9,0.975) 15(2.9,1.625)
UQFN2P05X1P55_10P_0P5MM
  rect 0.584x0.305 smd: 1(-0.635,0.75) 2(-0.635,0.25) 3(-0.635,-0.25) 4(-0.635,-0.75) 6(0.635,-0.75) 7(0.635,-0.25) 8(0.635,0.25) 9(0.635,0.75)
  rect 0.356x0.635 smd: 5(0,-0.86) 10(0,0.86)
VQFN2P6X4P6_20P_0P5MM_EP
  rect 0.305x0.635 smd: 1(-0.25,2.15) 10(-0.25,-2.15) 11(0.25,-2.15) 20(0.25,2.15)
  rect 0.635x0.305 smd: 2(-1.15,1.75) 3(-1.15,1.25) 4(-1.15,0.75) 5(-1.15,0.25) 6(-1.15,-0.25) 7(-1.15,-0.75) 8(-1.15,-1.25) 9(-1.15,-1.75) 12(1.15,-1.75) 13(1.15,-1.25) 14(1.15,-0.75) 15(1.15,-0.25) 16(1.15,0.25) 17(1.15,0.75) 18(1.15,1.25) 19(1.15,1.75)
  rect 1.143x3.175 smd: EP(0,0)
  round 0.559 hole 0.305: G1(0,-1.25) G2(0,1.25) G3(0,0)
VTP_2P_100
  rect 1.524x1.524 hole 1.041: 1(0,0)
  round 1.524 hole 1.041: 2(0,2.54)
XTAL_3P2X1P5MM_2P_MC
  rect 1.016x1.778 smd: 1(-1.25,0) 2(1.25,0)
XTAL_S_DUAL1
  custom 0.384x0.384 smd: 1(-2.223,-1.143) 2(2.223,-1.143)
  custom 0.374x0.374 smd: 3(2.223,1.143) 4(-2.223,1.143)

## Nets
