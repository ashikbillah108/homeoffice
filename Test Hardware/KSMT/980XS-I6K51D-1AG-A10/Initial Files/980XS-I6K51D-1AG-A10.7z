# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
2SA_CBIT_R29: length 1.4
  BOTTOM w0.203: UNK2K29.8 v2(274.04,254.76)
2SA_CBIT_R32: length 1.4
  BOTTOM w0.203: UNK2K32.8 v2(273.63,235.59)
2SA_CBIT_S01:
  vias: v2(263.24,233.14)
2SA_CBIT_S02:
  vias: v2(263.24,234.06)
2SA_CBIT_S03:
  vias: v2(268.01,233.28)
2SA_CBIT_S20: length 0.6
  TOP w0.203: UNK2R662.2 v2(255.82,241.23)
2SA_CBIT_S29: length 0.6
  TOP w0.203: UNK2R172.2 v2(255.82,252.79)
2SA_CBIT_S97:
  vias: v2(269.23,268.44)
3SA_CBIT_R29: length 1.4
  BOTTOM w0.203: UNK3K29.8 v2(314.03,254.76)
3SA_CBIT_R32: length 1.4
  BOTTOM w0.203: UNK3K32.8 v2(313.63,235.59)
3SA_CBIT_S01:
  vias: v2(303.24,233.14)
3SA_CBIT_S02:
  vias: v2(303.24,234.06)
3SA_CBIT_S03:
  vias: v2(308.01,233.28)
3SA_CBIT_S20: length 0.6
  TOP w0.203: UNK3R662.2 v2(295.82,241.23)
3SA_CBIT_S29: length 0.6
  TOP w0.203: UNK3R172.2 v2(295.82,252.79)
3SA_CBIT_S97:
  vias: v2(309.23,268.44)
4SA_CBIT_R29: length 1.4
  BOTTOM w0.203: UNK4K29.8 v2(354.03,254.76)
4SA_CBIT_R32: length 1.4
  BOTTOM w0.203: UNK4K32.8 v2(353.63,235.59)
4SA_CBIT_S01:
  vias: v2(343.24,233.14)
4SA_CBIT_S02:
  vias: v2(343.24,234.06)
4SA_CBIT_S03:
  vias: v2(348.01,233.28)
4SA_CBIT_S20: length 0.6
  TOP w0.203: UNK4R662.2 v2(335.82,241.23)
4SA_CBIT_S25: length 1.6
  BOTTOM w0.508: UNK4MR12.2 v1(347.22,287.7)
4SA_CBIT_S26: length 1.6
  BOTTOM w0.508: UNK4MR15.2 v1(347.22,293.03)
4SA_CBIT_S27: length 1.6
  BOTTOM w0.508: UNK4MR17.2 v1(347.22,290.37)
4SA_CBIT_S28:
  vias: v1(347.22,285.16)
4SA_CBIT_S29: length 0.6
  TOP w0.203: UNK4R172.2 v2(335.82,252.79)
4SA_CBIT_S97:
  vias: v2(349.23,268.44)
5SA_CBIT_R29: length 1.4
  BOTTOM w0.203: UNK5K29.8 v2(234.04,194.76)
5SA_CBIT_R32: length 1.4
  BOTTOM w0.203: UNK5K32.8 v2(233.63,175.59)
5SA_CBIT_S01:
  vias: v2(223.24,173.14)
5SA_CBIT_S02:
  vias: v2(223.24,174.06)
5SA_CBIT_S03:
  vias: v2(228.01,173.28)
5SA_CBIT_S20: length 0.6
  TOP w0.203: UNK5R662.2 v2(215.82,181.23)
5SA_CBIT_S25: length 1.6
  BOTTOM w0.508: UNK5MR12.2 v1(234.44,145.37)
5SA_CBIT_S26: length 1.6
  BOTTOM w0.508: UNK5MR15.2 v1(234.44,140.04)
5SA_CBIT_S27: length 1.6
  BOTTOM w0.508: UNK5MR17.2 v1(234.44,142.7)
5SA_CBIT_S28:
  vias: v1(234.44,147.91)
5SA_CBIT_S29: length 0.6
  TOP w0.203: UNK5R172.2 v2(215.82,192.79)
5SA_CBIT_S97:
  vias: v2(229.23,208.44)
5SA_RCBIT_01: length 1.7
  BOTTOM w0.203: v1(88.19,287.83) 87.57,288.45 U72.14
5SA_RCBIT_02: length 1.5
  BOTTOM w0.203: U413.15 v1(77.22,268.38)
5SA_RCBIT_03: length 1.9
  BOTTOM w0.203: v1(503.4,215.29) 502.88,214.78 502.88,213.6 U453.16
5SA_RCBIT_04: length 1.7
  BOTTOM w0.203: v1(88.19,274.12) 87.57,274.74 U405.14
5SA_RCBIT_05: length 1.7
  BOTTOM w0.203: v1(502.13,215.29) 502.13,213.6 U453.15
5SA_RCBIT_06: length 1.5
  BOTTOM w0.203: v1(86.92,274.12) U405.15
5SA_RCBIT_07: length 1.7
  BOTTOM w0.203: v1(85.65,287.83) 86.17,288.35 U72.16
5SA_RCBIT_08: length 1.7
  BOTTOM w0.203: v1(78.49,268.38) 77.97,267.87 U413.16
5SA_RCBIT_09: length 1.7
  BOTTOM w0.203: U413.14 76.57,267.76 v1(75.95,268.38)
5SA_RCBIT_10: length 1.7
  BOTTOM w0.203: U415.16 86.17,260.92 v1(85.65,260.4)
5SA_RCBIT_11: length 1.7
  BOTTOM w0.203: U415.14 87.57,261.02 v1(88.19,260.4)
5SA_RCBIT_12: length 1.5
  BOTTOM w0.203: v1(86.92,260.4) U415.15
5SA_RCBIT_13: length 1.7
  BOTTOM w0.203: v1(85.65,274.12) 86.17,274.64 U405.16
5SA_SCBIT_01: length 4.6
  BOTTOM w0.203: U434.18 539.01,210.34 538.42,210.93 536.57,210.93 535.87,210.24 v1(535.59,210.24)
5SA_SCBIT_02: length 4.6
  BOTTOM w0.203: v1(535.97,219.38) 536.25,219.38 536.95,220.08 538.8,220.08 539.39,220.67 U403.12
5SA_SCBIT_03: length 4.4
  BOTTOM w0.203: U434.16 538.51,209.34 538.32,209.54 536.57,209.54 535.87,208.84 v1(535.59,208.84)
5SA_SCBIT_04: length 4.4
  BOTTOM w0.203: v1(535.97,220.78) 536.25,220.78 536.95,221.47 538.7,221.47 538.9,221.67 U403.14
5SA_SCBIT_05: length 4.4
  BOTTOM w0.203: U70.16 538.9,235.63 538.7,235.83 536.95,235.83 536.25,235.13 v1(535.97,235.13)
5SA_SCBIT_06: length 4.6
  BOTTOM w0.203: U70.12 539.39,233.63 538.8,233.03 536.95,233.03 536.25,232.33 v1(535.97,232.33)
5SA_SCBIT_07: length 4.6
  BOTTOM w0.203: U403.18 539.39,223.67 538.8,224.27 536.95,224.27 536.25,223.57 v1(535.97,223.57)
5SA_SCBIT_08: length 4.6
  BOTTOM w0.203: v1(535.59,206.04) 535.87,206.04 536.57,206.74 538.42,206.74 539.01,207.34 U434.12
5SA_SCBIT_09: length 1.6
  BOTTOM w0.203: v1(538.13,195.44) 538.33,195.24 U435.16
5SA_SCBIT_10: length 1.8
  BOTTOM w0.203: v1(538.13,196.84) 538.73,196.24 U435.18
5SA_SCBIT_11: length 4.4
  BOTTOM w0.203: v1(535.59,207.44) 535.87,207.44 536.57,208.14 538.32,208.14 538.51,208.34 U434.14
5SA_SCBIT_12: length 4.4
  BOTTOM w0.203: v1(535.97,222.17) 536.25,222.17 536.95,222.87 538.7,222.87 538.9,222.67 U403.16
5SA_SCBIT_13: length 4.4
  BOTTOM w0.203: U70.14 538.9,234.63 538.7,234.43 536.95,234.43 536.25,233.73 v1(535.97,233.73)
6SA_CBIT_R29: length 1.4
  BOTTOM w0.203: UNK6K29.8 v2(274.04,194.76)
6SA_CBIT_R32: length 1.4
  BOTTOM w0.203: UNK6K32.8 v2(273.63,175.59)
6SA_CBIT_S01:
  vias: v2(263.24,173.14)
6SA_CBIT_S02:
  vias: v2(263.24,174.06)
6SA_CBIT_S03:
  vias: v2(268.01,173.28)
6SA_CBIT_S20: length 0.6
  TOP w0.203: UNK6R662.2 v2(255.82,181.23)
6SA_CBIT_S25: length 1.6
  BOTTOM w0.508: UNK6MR12.2 v1(274.44,145.37)
6SA_CBIT_S26: length 1.6
  BOTTOM w0.508: UNK6MR15.2 v1(274.44,140.04)
6SA_CBIT_S27: length 1.6
  BOTTOM w0.508: UNK6MR17.2 v1(274.44,142.7)
6SA_CBIT_S28:
  vias: v1(274.44,147.91)
6SA_CBIT_S29: length 0.6
  TOP w0.203: UNK6R172.2 v2(255.82,192.79)
6SA_CBIT_S97:
  vias: v2(269.23,208.44)
7SA_CBIT_R29: length 1.4
  BOTTOM w0.203: UNK7K29.8 v2(314.03,194.76)
7SA_CBIT_R32: length 1.4
  BOTTOM w0.203: UNK7K32.8 v2(313.63,175.59)
7SA_CBIT_S01:
  vias: v2(303.24,173.14)
7SA_CBIT_S02:
  vias: v2(303.24,174.06)
7SA_CBIT_S03:
  vias: v2(308.01,173.28)
7SA_CBIT_S20: length 0.6
  TOP w0.203: UNK7R662.2 v2(295.82,181.23)
7SA_CBIT_S25: length 1.6
  BOTTOM w0.508: UNK7MR12.2 v1(314.44,145.37)
7SA_CBIT_S26: length 1.6
  BOTTOM w0.508: UNK7MR15.2 v1(314.44,140.04)
7SA_CBIT_S27: length 1.6
  BOTTOM w0.508: UNK7MR17.2 v1(314.44,142.7)
7SA_CBIT_S28:
  vias: v1(314.44,147.91)
7SA_CBIT_S29: length 0.6
  TOP w0.203: UNK7R172.2 v2(295.82,192.79)
7SA_CBIT_S97:
  vias: v2(309.23,208.44)
8SA_CBIT_R29: length 1.4
  BOTTOM w0.203: UNK8K29.8 v2(354.03,194.76)
8SA_CBIT_R32: length 1.4
  BOTTOM w0.203: UNK8K32.8 v2(353.63,175.59)
8SA_CBIT_S01:
  vias: v2(343.24,173.14)
8SA_CBIT_S02:
  vias: v2(343.24,174.06)
8SA_CBIT_S03:
  vias: v2(348.01,173.28)
8SA_CBIT_S20: length 0.6
  TOP w0.203: UNK8R662.2 v2(335.82,181.23)
8SA_CBIT_S25: length 1.6
  BOTTOM w0.508: UNK8MR12.2 v1(354.44,145.37)
8SA_CBIT_S26: length 1.6
  BOTTOM w0.508: UNK8MR15.2 v1(354.44,140.04)
8SA_CBIT_S27: length 1.6
  BOTTOM w0.508: UNK8MR17.2 v1(354.44,142.7)
8SA_CBIT_S28:
  vias: v1(354.44,147.91)
8SA_CBIT_S29: length 0.6
  TOP w0.203: UNK8R172.2 v2(335.82,192.79)
8SA_CBIT_S97:
  vias: v2(349.23,208.44)
BF_RLY01: length 0.9
  BOTTOM w0.203: v2(81.69,289.07) 81.82,289.2 U73.1
BF_RLY02: length 1.3
  BOTTOM w0.203: v2(79.7,290.69) 79.83,290.82 U73.3
BF_RLY03: length 1.3
  BOTTOM w0.203: v2(79.7,291.94) 79.83,291.82 U73.5
BF_RLY04: length 1.1
  BOTTOM w0.203: v2(84.1,292.77) 83.65,292.32 U73.9
BF_RLY05: length 0.9
  BOTTOM w0.203: U73.11 v2(84.1,291.32)
BF_RLY06: length 1.1
  BOTTOM w0.203: U73.13 83.65,290.32 v2(84.1,289.86)
BF_RLY07: length 0.9
  BOTTOM w0.203: v2(506.6,226.71) 506.73,226.84 U76.1
BF_RLY08: length 1.3
  BOTTOM w0.203: U76.3 504.74,228.45 v2(504.61,228.32)
BF_RLY09: length 1.3
  BOTTOM w0.203: U76.5 504.74,229.45 v2(504.61,229.58)
BF_RLY10: length 1.1
  BOTTOM w0.203: v2(509.02,230.4) 508.57,229.95 U76.9
BF_RLY11: length 0.9
  BOTTOM w0.203: U76.11 v2(509.02,228.95)
BF_RLY12: length 1.1
  BOTTOM w0.203: U76.13 508.57,227.95 v2(509.02,227.5)
BF_RLY13: length 0.9
  BOTTOM w0.203: v2(81.69,275.36) 81.82,275.49 U79.1
BF_RLY14: length 1.3
  BOTTOM w0.203: v2(79.7,276.97) 79.83,277.1 U79.3
BF_RLY15: length 1.3
  BOTTOM w0.203: U79.5 79.83,278.1 v2(79.7,278.23)
BF_RLY16: length 1.1
  BOTTOM w0.203: U79.9 83.65,278.6 v2(84.1,279.05)
BF_RLY17: length 0.9
  BOTTOM w0.203: U79.11 v2(84.1,277.6)
BF_RLY18: length 1.1
  BOTTOM w0.203: U79.13 83.65,276.6 v2(84.1,276.15)
BF_RLY19: length 0.9
  BOTTOM w0.203: v2(81.69,261.64) 81.82,261.77 U414.1
BF_RLY20: length 1.3
  BOTTOM w0.203: v2(79.7,263.26) 79.83,263.38 U414.3
BF_RLY21: length 1.3
  BOTTOM w0.203: U414.5 79.83,264.39 v2(79.7,264.51)
BF_RLY22: length 1.1
  BOTTOM w0.203: U414.9 83.65,264.88 v2(84.1,265.34)
BF_RLY23: length 0.9
  BOTTOM w0.203: U414.11 v2(84.1,263.88)
BF_RLY24: length 1.1
  BOTTOM w0.203: v2(84.1,262.43) 83.65,262.88 U414.13
BF_RLY25: length 0.9
  BOTTOM w0.203: U454.1 506.73,208.68 v2(506.6,208.55)
BF_RLY26: length 1.3
  BOTTOM w0.203: U454.3 504.74,210.29 v2(504.61,210.17)
BF_SW01: length 2.3
  BOTTOM w0.203: v1(545.31,237.72) 545.62,237.72 546.32,238.42 R926.2
BF_SW02: length 2.3
  BOTTOM w0.203: R927.2 546.32,237.02 545.62,236.33 v1(545.31,236.33)
BF_SW03: length 2.3
  BOTTOM w0.203: v1(545.31,234.93) 545.62,234.93 546.32,235.63 R925.2
BF_SW04: length 2.3
  BOTTOM w0.203: v1(545.31,233.53) 545.62,233.53 546.32,234.23 R928.2
BF_SW05: length 2.3
  BOTTOM w0.203: v1(537.24,236.52) 536.93,236.52 536.24,235.83 R932.2
BF_SW06: length 2.3
  BOTTOM w0.203: v1(537.24,235.13) 536.93,235.13 536.24,234.43 R930.2
BF_SW07: length 2.3
  BOTTOM w0.203: v1(537.24,233.73) 536.93,233.73 536.24,233.03 R929.2
BF_SW08: length 2.3
  BOTTOM w0.203: R931.2 536.24,231.63 536.93,232.33 v1(537.24,232.33)
BF_SW09: length 2.3
  BOTTOM w0.203: v1(545.31,224.77) 545.62,224.77 546.32,225.47 R936.2
BF_SW10: length 2.3
  BOTTOM w0.203: v1(545.31,223.37) 545.62,223.37 546.32,224.07 R934.2
BF_SW11: length 2.3
  BOTTOM w0.203: v1(545.31,221.97) 545.62,221.97 546.32,222.67 R933.2
BF_SW12: length 2.3
  BOTTOM w0.203: v1(545.31,220.58) 545.62,220.58 546.32,221.28 R935.2
BF_SW13: length 2.3
  BOTTOM w0.203: v1(537.24,223.57) 536.93,223.57 536.24,222.87 R940.2
BF_SW14: length 2.3
  BOTTOM w0.203: R938.2 536.24,221.48 536.93,222.17 v1(537.24,222.17)
BF_SW15: length 2.3
  BOTTOM w0.203: R937.2 536.24,220.08 536.93,220.78 v1(537.24,220.78)
BF_SW16: length 2.3
  BOTTOM w0.203: v1(537.24,219.38) 536.93,219.38 536.24,218.68 R939.2
BF_SW17: length 2.3
  BOTTOM w0.203: v1(544.93,211.43) 545.24,211.43 545.94,212.13 R944.2
BF_SW18: length 2.3
  BOTTOM w0.203: v1(544.93,210.04) 545.24,210.04 545.94,210.74 R942.2
BF_SW19: length 2.3
  BOTTOM w0.203: v1(544.93,208.64) 545.24,208.64 545.94,209.34 R941.2
BF_SW20: length 2.3
  BOTTOM w0.203: R943.2 545.94,207.94 545.24,207.24 v1(544.93,207.24)
BF_SW21: length 2.3
  BOTTOM w0.203: R948.2 535.86,209.54 536.55,210.24 v1(536.86,210.24)
BF_SW22: length 2.3
  BOTTOM w0.203: R946.2 535.86,208.14 536.55,208.84 v1(536.86,208.84)
BF_SW23: length 2.3
  BOTTOM w0.203: v1(536.86,207.44) 536.55,207.44 535.86,206.74 R945.2
BF_SW24: length 2.3
  BOTTOM w0.203: R947.2 535.86,205.35 536.55,206.04 v1(536.86,206.04)
BF_SW25: length 2.3
  BOTTOM w0.203: R952.2 545.94,198.04 545.24,197.34 v1(544.93,197.34)
BF_SW26: length 2.3
  BOTTOM w0.203: v1(544.93,195.94) 545.24,195.94 545.94,196.64 R950.2
Net_8: length 1.2
  BOTTOM w0.305: 507.37,208.23 507.23,208.36 507.23,209.41
  vias: v1(508.66,208.07)
Net_10:
  vias: v1(478.79,200.66)
Net_19:
  vias: v2(349.87,228.85) v2(350.04,218.49) v2(351.9,236.98) v2(352.08,218.49) v2(354.11,218.49) v2(355.66,236.42) v2(355.66,234.39) v2(355.66,232.36) v2(355.66,230.33) v2(356.14,218.49) v2(356.81,237.58) v2(358,222.76) v2(358,220.73) v2(358,218.69) v2(358.25,239.01) v2(358.3,242.82) v2(358.3,241.05) v2(360.03,245.11) v2(360.03,243.08) v2(360.03,241.05) v2(360.03,239.01) v2(360.03,236.98)
Net_20:
  vias: v2(349.87,168.85) v2(350.04,158.49) v2(351.9,176.98) v2(352.08,158.49) v2(354.11,158.49) v2(355.66,176.42) v2(355.66,174.39) v2(355.66,172.36) v2(355.66,170.33) v2(356.14,158.49) v2(356.81,177.58) v2(358,162.76) v2(358,160.73) v2(358,158.69) v2(358.25,179.01) v2(358.3,182.82) v2(358.3,181.05) v2(360.03,185.11) v2(360.03,183.08) v2(360.03,181.05) v2(360.03,179.01) v2(360.03,176.98)
Net_22:
  vias: v2(347.13,252.15) v2(348.65,252.12) v2(350.76,252.5) v2(352.03,259.97) v2(352.03,257.94) v2(352.03,255.91) v2(352.03,253.87) v2(353.93,273.56) v2(353.93,253.24) v2(355.97,265.43) v2(355.97,253.24)
Net_24:
  vias: v2(347.13,192.15) v2(348.65,192.12) v2(350.76,192.5) v2(352.03,199.97) v2(352.03,197.94) v2(352.03,195.91) v2(352.03,193.87) v2(353.93,213.56) v2(353.93,193.24) v2(355.97,205.43) v2(355.97,193.24)
Net_28:
  vias: v2(307.13,252.15) v2(308.65,252.12) v2(310.76,252.5) v2(312.03,259.97) v2(312.03,257.94) v2(312.03,255.91) v2(312.03,253.87) v2(313.93,273.56) v2(313.93,253.24) v2(315.97,265.43) v2(315.97,253.24)
Net_29:
  vias: v2(309.87,228.85) v2(310.04,218.49) v2(311.9,236.98) v2(312.08,218.49) v2(314.11,218.49) v2(315.66,236.42) v2(315.66,234.39) v2(315.66,232.36) v2(315.66,230.33) v2(316.14,218.49) v2(316.81,237.58) v2(318,222.76) v2(318,220.73) v2(318,218.69) v2(318.25,239.01) v2(318.3,242.82) v2(318.3,241.05) v2(320.03,245.11) v2(320.03,243.08) v2(320.03,241.05) v2(320.03,239.01) v2(320.03,236.98)
Net_30:
  vias: v2(307.13,192.15) v2(308.65,192.12) v2(310.76,192.5) v2(312.03,199.97) v2(312.03,197.94) v2(312.03,195.91) v2(312.03,193.87) v2(313.93,213.56) v2(313.93,193.24) v2(315.97,205.43) v2(315.97,193.24)
Net_31:
  vias: v2(309.87,168.85) v2(310.04,158.49) v2(311.9,176.98) v2(312.08,158.49) v2(314.11,158.49) v2(315.66,176.42) v2(315.66,174.39) v2(315.66,172.36) v2(315.66,170.33) v2(316.14,158.49) v2(316.81,177.58) v2(318,162.76) v2(318,160.73) v2(318,158.69) v2(318.25,179.01) v2(318.3,182.82) v2(318.3,181.05) v2(320.03,185.11) v2(320.03,183.08) v2(320.03,181.05) v2(320.03,179.01) v2(320.03,176.98)
Net_37:
  vias: v2(267.13,252.15) v2(268.65,252.12) v2(270.76,252.5) v2(272.03,259.97) v2(272.03,257.94) v2(272.03,255.91) v2(272.03,253.87) v2(273.93,253.24) v2(275.97,265.43) v2(275.97,253.24)
Net_38:
  vias: v2(269.87,228.85) v2(270.04,218.49) v2(271.9,236.98) v2(272.08,218.49) v2(274.11,218.49) v2(275.66,236.42) v2(275.66,234.39) v2(275.66,232.36) v2(275.66,230.33) v2(276.14,218.49) v2(276.82,237.58) v2(278,222.76) v2(278,220.73) v2(278,218.69) v2(278.25,239.01) v2(278.3,242.82) v2(278.3,241.05) v2(280.03,245.11) v2(280.03,243.08) v2(280.03,241.05) v2(280.03,239.01) v2(280.03,236.98)
Net_39:
  vias: v2(267.13,192.15) v2(268.65,192.12) v2(270.76,192.5) v2(272.03,199.97) v2(272.03,197.94) v2(272.03,195.91) v2(272.03,193.87) v2(273.93,213.56) v2(273.93,193.24) v2(275.97,205.43) v2(275.97,193.24)
Net_40:
  vias: v2(269.87,168.85) v2(270.04,158.49) v2(271.9,176.98) v2(272.08,158.49) v2(274.11,158.49) v2(275.66,176.42) v2(275.66,174.39) v2(275.66,172.36) v2(275.66,170.33) v2(276.14,158.49) v2(276.82,177.58) v2(278,162.76) v2(278,160.73) v2(278,158.69) v2(278.25,179.01) v2(278.3,182.82) v2(278.3,181.05) v2(280.03,185.11) v2(280.03,183.08) v2(280.03,181.05) v2(280.03,179.01) v2(280.03,176.98)
Net_47:
  vias: v2(229.87,228.85) v2(230.04,218.49) v2(231.9,236.98) v2(232.08,218.49) v2(234.11,218.49) v2(235.66,236.42) v2(235.66,234.39) v2(235.66,232.36) v2(235.66,230.33) v2(236.14,218.49) v2(236.82,237.58) v2(238,222.76) v2(238,220.73) v2(238,218.69) v2(238.25,239.01) v2(238.3,242.82) v2(238.3,241.05) v2(240.03,245.11) v2(240.03,243.08) v2(240.03,241.05) v2(240.03,239.01) v2(240.03,236.98)
Net_48:
  vias: v2(227.13,192.15) v2(228.65,192.12) v2(230.76,192.5) v2(232.03,199.97) v2(232.03,197.94) v2(232.03,195.91) v2(232.03,193.87) v2(233.93,213.56) v2(233.93,193.24) v2(235.97,205.43) v2(235.97,193.24)
Net_49:
  vias: v2(229.87,168.85) v2(230.04,158.49) v2(231.9,176.98) v2(232.08,158.49) v2(234.11,158.49) v2(235.66,176.42) v2(235.66,174.39) v2(235.66,172.36) v2(235.66,170.33) v2(236.14,158.49) v2(236.82,177.58) v2(238,162.76) v2(238,160.73) v2(238,158.69) v2(238.25,179.01) v2(238.3,182.82) v2(238.3,181.05) v2(240.03,185.11) v2(240.03,183.08) v2(240.03,181.05) v2(240.03,179.01) v2(240.03,176.98)
Net_458:
  vias: v3(226.63,241.43)
Net_786:
  vias: v2(268.55,246.26)
Net_798:
  vias: v2(267.9,245.61)
Net_799:
  vias: v2(273.76,245.61)
Net_801:
  vias: v2(266.61,244.96)
Net_803:
  vias: v2(267.25,244.96)
Net_810:
  vias: v2(266.61,244.31)
Net_812:
  vias: v2(267.25,244.31)
Net_816:
  vias: v2(274.41,244.31)
Net_817:
  vias: v2(275.06,244.31)
Net_831:
  vias: v2(268.55,242.36)
Net_837:
  vias: v2(275.06,242.36)
Net_1168:
  vias: v2(308.55,246.26)
Net_1180:
  vias: v2(307.9,245.61)
Net_1181:
  vias: v2(313.76,245.61)
Net_1183:
  vias: v2(306.6,244.96)
Net_1185:
  vias: v2(307.25,244.96)
Net_1192:
  vias: v2(306.6,244.31)
Net_1194:
  vias: v2(307.25,244.31)
Net_1198:
  vias: v2(314.41,244.31)
Net_1199:
  vias: v2(315.05,244.31)
Net_1213:
  vias: v2(308.55,242.36)
Net_1219:
  vias: v2(315.05,242.36)
Net_1550:
  vias: v2(348.55,246.26)
Net_1562:
  vias: v2(347.9,245.61)
Net_1563:
  vias: v2(353.75,245.61)
Net_1565:
  vias: v2(346.6,244.96)
Net_1567:
  vias: v2(347.25,244.96)
Net_1574:
  vias: v2(346.6,244.31)
Net_1576:
  vias: v2(347.25,244.31)
Net_1580:
  vias: v2(354.4,244.31)
Net_1581:
  vias: v2(355.05,244.31)
Net_1595:
  vias: v2(348.55,242.36)
Net_1601:
  vias: v2(355.05,242.36)
Net_1932:
  vias: v2(228.56,186.26)
Net_1944:
  vias: v2(227.91,185.61)
Net_1945:
  vias: v2(233.76,185.61)
Net_1947:
  vias: v2(226.61,184.96)
Net_1949:
  vias: v2(227.26,184.96)
Net_1956:
  vias: v2(226.61,184.31)
Net_1958:
  vias: v2(227.26,184.31)
Net_1962:
  vias: v2(234.41,184.31)
Net_1963:
  vias: v2(235.06,184.31)
Net_1977:
  vias: v2(228.56,182.36)
Net_1983:
  vias: v2(235.06,182.36)
Net_2314:
  vias: v2(268.55,186.26)
Net_2326:
  vias: v2(267.9,185.61)
Net_2327:
  vias: v2(273.76,185.61)
Net_2329:
  vias: v2(266.61,184.96)
Net_2331:
  vias: v2(267.25,184.96)
Net_2338:
  vias: v2(266.61,184.31)
Net_2340:
  vias: v2(267.25,184.31)
Net_2344:
  vias: v2(274.41,184.31)
Net_2345:
  vias: v2(275.06,184.31)
Net_2359:
  vias: v2(268.55,182.36)
Net_2365:
  vias: v2(275.06,182.36)
Net_2696:
  vias: v2(308.55,186.26)
Net_2708:
  vias: v2(307.9,185.61)
Net_2709:
  vias: v2(313.76,185.61)
Net_2711:
  vias: v2(306.6,184.96)
Net_2713:
  vias: v2(307.25,184.96)
Net_2720:
  vias: v2(306.6,184.31)
Net_2722:
  vias: v2(307.25,184.31)
Net_2726:
  vias: v2(314.41,184.31)
Net_2727:
  vias: v2(315.05,184.31)
Net_2741:
  vias: v2(308.55,182.36)
Net_2747:
  vias: v2(315.05,182.36)
Net_7785: length 3.3
  TOP w0.16: 105.12,263.08 v1(108.41,263.08)
Net_8533: length 0.5
  BOTTOM w0.16: 215.16,238.15 v2(215.66,238.15)
Net_8534: length 0.5
  BOTTOM w0.16: 214.66,238.15 v4(214.16,238.15)
Net_8537: length 0.5
  BOTTOM w0.16: 211.16,238.15 v4(210.66,238.15)
Net_8538: length 0.5
  BOTTOM w0.16: 211.66,238.15 v4(212.16,238.15)
Net_8541: length 3.1
  BOTTOM w0.132: 212.33,242.3 212.64,242.3 212.77,242.17 212.77,241.94 212.66,241.84 212.47,241.84 212.17,241.53 212.17,241.21 212.66,240.72 212.66,240.15 212.66,240.15
Net_8542: length 3.1
  BOTTOM w0.132: 211.64,242.3 211.8,242.13 211.8,241.06 212.28,240.57 212.28,240.03 212.66,239.65
Net_9322:
  vias: v1(458.47,205.74)
Net_9459:
  vias: v2(355.05,182.36)
Net_9465:
  vias: v2(348.55,182.36)
Net_9479:
  vias: v2(355.05,184.31)
Net_9480:
  vias: v2(354.4,184.31)
Net_9484:
  vias: v2(347.25,184.31)
Net_9486:
  vias: v2(346.6,184.31)
Net_9493:
  vias: v2(347.25,184.96)
Net_9495:
  vias: v2(346.6,184.96)
Net_9497:
  vias: v2(353.75,185.61)
Net_9498:
  vias: v2(347.9,185.61)
Net_9510:
  vias: v2(348.55,186.26)
S1_0V5: length 41.7
  BOTTOM w0.305: 233.67,296.07 233.49,295.89 C288.1 233.44,295.87 233.24,296.07
  BOTTOM w0.381: 232.29,297.03 232.17,297.15 MU3.3
  BOTTOM w0.508: MK1.4 219.18,288.97 218.56,289.59 218.56,297.47 221.47,300.38 233.63,300.38 234.25,299.77 MR4.1 ; MR4.1 MR3.1 234.32,298.29 C286.1 234.32,296.72 233.67,296.07 ; MR4.1 MR5.1 MR6.1 MR2.2 ; 232.29,297.03 232.29,297.02 233.24,296.07
S1_0V25: length 2.8
  BOTTOM w0.508: MK4.3 224.45,290.44 MR19.1 221.88,290.44 MR18.2
S1_0V75: length 4.9
  BOTTOM w0.381: MU3.6 MR10.2
  BOTTOM w0.508: MK2.4 224.85,294.63 C290.1 MR10.2
S1_1SPI_CK: length 3.3
  TOP w0.16: SW10.1 v1(126.48,298.45)
S1_1SPI_DI: length 3.3
  TOP w0.16: SW10.2 v1(126.48,295.91)
S1_1SPI_DO: length 3.3
  TOP w0.16: SW10.4 v1(126.48,290.83)
S1_1SPI_HLD: length 3.3
  TOP w0.16: SW10.5 v1(126.48,288.29)
S1_1SPI_WPZ: length 3.3
  TOP w0.16: SW10.3 v1(126.48,293.37)
S1_3V3_RX0_MIPI: length 9.9
  TOP w0.305: R661.2 233.96,262.58 233.62,262.24 v4(233.62,261.7)
  TOP w0.381: v4(233.62,261.7) 233.62,261 234.13,260.49 237.41,260.49 v4(237.62,260.7)
  BOTTOM w0.381: v4(233.62,261.7) C922.2
S1_3V3_RX1_MIPI: length 9.9
  TOP w0.305: R663.2 222.15,262.58 221.81,262.24 v4(221.81,261.7)
  TOP w0.381: v4(221.81,261.7) 221.81,261 222.32,260.49 225.59,260.49 v4(225.81,260.7)
  BOTTOM w0.381: v4(221.81,261.7) C923.2
S1_3V3_TX0_MIPI: length 13.4
  TOP w0.305: R1101.2 212.78,248.06 213.12,247.72 v4(213.66,247.72)
  TOP w0.381: v4(214.66,251.72) 214.87,251.5 214.87,248.23 214.36,247.72 v4(213.66,247.72)
  BOTTOM w0.381: v4(213.66,247.72) C1090.2
  BOTTOM w0.508: C1090.2 213.66,245.95 213.3,245.59 211.82,245.59 211.5,245.91 BDB8.2
S1_3V3_TX1_MIPI: length 13.4
  TOP w0.305: R1098.2 212.78,236.49 213.12,236.15 v4(213.66,236.15)
  TOP w0.381: v4(213.66,236.15) 214.36,236.15 214.87,236.66 214.87,239.94 v4(214.66,240.15)
  BOTTOM w0.381: v4(213.66,236.15) C1089.2
  BOTTOM w0.508: C1089.2 213.66,234.38 213.3,234.02 211.82,234.02 211.5,234.35 BDB7.2
S1_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: U31.4 225.48,233.24 224.61,232.36 C262.1
  BOTTOM w0.305: BD21.2 C262.1
S1_CON1_0V8:
  vias: v1(36.7,203.82) v1(36.7,201.28) v1(36.7,198.74) v1(36.7,196.2) v1(36.7,177.15) v1(36.7,174.61) v1(36.7,172.07) v1(36.7,169.53)
S1_CON1_1V8:
  vias: v1(58.29,213.98) v1(58.29,211.44) v1(58.29,208.9) v1(58.29,206.36)
S1_CON1_A3V3:
  vias: v1(58.29,187.31) v1(58.29,184.77) v1(58.29,182.23) v1(58.29,179.69) v1(58.29,177.15) v1(58.29,174.61) v1(58.29,172.07) v1(58.29,169.53)
S1_CON1_B3V3:
  vias: v1(58.29,203.82) v1(58.29,201.28) v1(58.29,198.74) v1(58.29,196.2)
S1_CON1_CORE_0V9:
  vias: v1(36.7,213.98) v1(36.7,211.44) v1(36.7,208.9) v1(36.7,206.36) v1(36.7,187.31) v1(36.7,184.77) v1(36.7,182.23) v1(36.7,179.69)
S1_DCH107: length 3.3
  TOP w0.16: SW5.6 v1(126.48,260.35)
S1_DCH108: length 1.4
  BOTTOM w0.16: K32.2 v2(237.83,232.39)
S1_DCH109: length 1.4
  BOTTOM w0.16: K32.7 v2(233.63,232.39)
S1_DPS3: length 0.7
  BOTTOM w0.508: CA21.1 v1(215.42,283.46)
  vias: v1(114.29,298.45) v1(115.43,298.45) v1(116.57,298.45) v1(215.42,285.5)
S1_DPS4: length 0.7
  BOTTOM w0.508: CA35.1 v1(243.87,279.4)
  vias: v1(70.99,187.31) v1(70.99,184.77) v1(70.99,182.23) v1(70.99,179.69) v1(114.29,273.05) v1(115.43,273.05) v1(116.57,273.05) v1(243.87,281.43)
S1_M_2V5: length 4.8
  BOTTOM w0.508: MU2.6 237.42,297.16 C284.1 ; C284.1 MR2.1 ; C284.1 C285.1
S1_M_3V2: length 24.3
  BOTTOM w0.381: 227.96,297.68 227.83,297.8 MU3.7
  BOTTOM w0.508: MU2.2 238.69,286.99 C282.1 C283.1 237.46,286.91 MR1.1 234.18,286.91 MU1.5 235.14,288.02 235.14,293.37 234.29,294.22 232.62,294.22 231.53,295.31 C289.1 229.25,295.31 228.48,296.08 228.48,297.16 227.96,297.68
S1_MPDCH03+: length 1.3
  BOTTOM w0.165: U31.2 226.28,233.73 226.28,232.65 v2(226.41,232.52)
S1_MPDCH03-: length 1.3
  BOTTOM w0.165: U31.3 225.88,232.65 v2(225.75,232.52)
S1_MPDCH37+:
  vias: v4(237.12,263.7)
S1_MPDCH37-:
  vias: v4(237.12,264.2)
S1_MPDCH38+:
  vias: v4(211.66,251.22)
S1_MPDCH38-:
  vias: v4(211.16,251.22)
S1_MPDCH39+:
  vias: v4(236.12,263.7)
S1_MPDCH39-:
  vias: v4(236.12,264.2)
S1_MPDCH40+:
  vias: v4(211.66,250.22)
S1_MPDCH40-:
  vias: v4(211.16,250.22)
S1_MPDCH41+: length 0.5
  BOTTOM w0.16: U408.E8 v4(235.62,263.2)
S1_MPDCH41-: length 0.5
  BOTTOM w0.16: U408.E9 v4(235.62,264.7)
S1_MPDCH42+: length 0.5
  BOTTOM w0.16: U455.E8 v4(212.16,249.72)
S1_MPDCH42-: length 0.5
  BOTTOM w0.16: U455.E9 v4(210.66,249.72)
S1_MPDCH43+:
  vias: v4(225.31,263.7)
S1_MPDCH43-:
  vias: v4(225.31,264.2)
S1_MPDCH44+:
  vias: v4(211.66,239.65)
S1_MPDCH44-:
  vias: v4(211.16,239.65)
S1_MPDCH45+:
  vias: v4(224.31,263.7)
S1_MPDCH45-:
  vias: v4(224.31,264.2)
S1_MPDCH46+:
  vias: v4(211.66,238.65)
S1_MPDCH46-:
  vias: v4(211.16,238.65)
S1_MPDCH47+: length 0.5
  BOTTOM w0.16: U409.E8 v4(223.81,263.2)
S1_MPDCH47-: length 0.5
  BOTTOM w0.16: U409.E9 v4(223.81,264.7)
S1_MUX_3V3:
  vias: v2(222.48,232.36)
S1_OUT_RX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(237.97,258.14) 237.81,258.31 237.27,258.31 236.78,258.79 236.78,260.36 U408.B2
S1_OUT_RX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(237.97,258.85) 237.81,258.68 237.42,258.68 237.15,258.95 237.15,260.17 U408.B1
S1_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: U408.B4 237.61,261.21 238.32,261.21 238.6,260.93 238.6,260.42 238.95,260.07 239.68,260.07 R647.1
S1_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: R646.1 239.77,260.9 239.68,260.98 239.47,260.98 239.4,260.91 239.4,260.55 239.28,260.44 239.11,260.44 238.98,260.57 238.98,261.08 238.47,261.59 237.74,261.59 U408.A4
S1_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: R647.2 R646.2 C309.1
S1_OUT_RX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(235.27,258.14) 235.43,258.31 235.98,258.31 236.48,258.8 236.48,260.35 U408.D2
S1_OUT_RX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: U408.D1 236.1,260.18 236.1,258.96 235.83,258.68 235.43,258.68 v2(235.27,258.85)
S1_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 237.88,261.95 237.37,261.95 U408.B5
  BOTTOM w0.132: R168.1 239.6,261.54 239.14,261.54 238.73,261.95 237.88,261.95
S1_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: R170.1 239.6,261.91 239.3,261.91 239.04,262.17 239.04,262.54 238.91,262.67 238.72,262.67 238.59,262.54 238.59,262.45 238.46,262.32 237.74,262.32 U408.A5
S1_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: R170.2 R168.2 C310.1
S1_OUT_RX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: U408.E2 v2(235.62,261.2)
S1_OUT_RX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: U408.E1 v2(235.62,259.7)
S1_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: U408.B6 237.5,263.08 238.04,263.08 238.53,263.56 239.6,263.56 R176.1
S1_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: R178.1 239.77,262.72 239.64,262.59 239.41,262.59 239.31,262.7 239.31,262.89 239,263.19 238.68,263.19 238.19,262.7 237.63,262.7 237.62,262.7 U408.A6
S1_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: R178.2 R176.2 C318.1
S1_OUT_RX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(226.16,258.14) 226,258.31 225.46,258.31 224.97,258.79 224.97,260.36 U409.B2
S1_OUT_RX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(226.16,258.85) 225.99,258.68 225.61,258.68 225.34,258.95 225.34,260.17 U409.B1
S1_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: R1089.1 227.87,260.07 227.14,260.07 226.79,260.42 226.79,260.93 226.51,261.21 225.8,261.21 U409.B4
S1_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: R1088.1 227.95,260.9 227.87,260.98 227.66,260.98 227.59,260.91 227.59,260.55 227.47,260.44 227.3,260.44 227.17,260.57 227.17,261.08 226.66,261.59 225.92,261.59 U409.A4
S1_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: R1089.2 R1088.2 C302.1
S1_OUT_RX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(223.46,258.14) 223.62,258.31 224.17,258.31 224.66,258.8 224.66,260.35 U409.D2
S1_OUT_RX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(223.46,258.85) 223.62,258.68 224.02,258.68 224.29,258.96 224.29,260.18 U409.D1
S1_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: U409.B5 225.56,261.95 226.07,261.95
  BOTTOM w0.132: R180.1 227.79,261.54 227.33,261.54 226.92,261.95 226.07,261.95
S1_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: R182.1 227.79,261.91 227.48,261.91 227.23,262.17 227.23,262.54 227.1,262.67 226.91,262.67 226.78,262.54 226.78,262.45 226.65,262.32 225.93,262.32 U409.A5
S1_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: C320.1 R180.2 R182.2
S1_OUT_RX0_CH5_ABC_CASE+: length 0.5
  BOTTOM w0.16: U409.E2 v2(223.81,261.2)
S1_OUT_RX0_CH5_ABC_CASE-: length 0.5
  BOTTOM w0.16: U409.E1 v2(223.81,259.7)
S1_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: U409.B6 225.68,263.08 226.23,263.08 226.72,263.56 227.79,263.56 R666.1
S1_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: R664.1 227.95,262.72 227.83,262.59 227.6,262.59 227.49,262.7 227.49,262.89 227.19,263.19 226.87,263.19 226.38,262.7 225.81,262.7 U409.A6
S1_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: R664.2 R666.2 C924.1
S1_OUT_TX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(217.22,252.07) 217.06,251.91 217.06,251.37 216.57,250.88 215,250.88 U455.B2
S1_OUT_TX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(216.51,252.07) 216.68,251.9 216.68,251.52 216.41,251.25 215.19,251.25 U455.B1
S1_OUT_TX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: U455.B4 214.15,251.71 214.15,252.41 214.44,252.7 214.94,252.7 215.3,253.05 215.3,253.77 R1109.1
S1_OUT_TX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: U455.A4 213.78,251.83 213.78,252.57 214.28,253.07 214.79,253.07 214.92,253.21 214.92,253.38 214.81,253.5 214.45,253.5 214.38,253.57 214.38,253.78 214.46,253.86 R1107.1
S1_OUT_TX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: R1109.2 R1107.2 C1086.1
S1_OUT_TX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: U455.D2 215.02,250.57 216.56,250.57 217.05,250.08 217.05,249.53 v2(217.22,249.36)
S1_OUT_TX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(216.51,249.36) 216.68,249.53 216.68,249.93 216.41,250.2 215.18,250.2 U455.D1
S1_OUT_TX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 213.41,251.97 213.41,251.47 U455.B5
  BOTTOM w0.132: 213.41,251.97 213.41,252.83 213.82,253.24 213.82,253.7 R1099.1
S1_OUT_TX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: R1100.1 213.45,253.7 213.45,253.39 213.2,253.14 212.82,253.14 212.69,253.01 212.69,252.82 212.82,252.69 212.91,252.69 213.04,252.56 213.04,251.84 U455.A5
S1_OUT_TX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: R1100.2 R1099.2 C1087.1
S1_OUT_TX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: U455.E2 v2(214.16,249.72)
S1_OUT_TX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: U455.E1 v2(215.66,249.72)
S1_OUT_TX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: U455.B6 212.28,251.59 212.28,252.14 211.8,252.62 211.8,253.7 R1106.1
S1_OUT_TX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: R1103.1 212.64,253.86 212.77,253.73 212.77,253.51 212.66,253.4 212.47,253.4 212.17,253.1 212.17,252.78 212.66,252.29 212.66,251.72 U455.A6
S1_OUT_TX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: C1088.1 R1106.2 R1103.2
S1_OUT_TX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(217.22,240.5) 217.06,240.34 217.06,239.8 216.57,239.31 215,239.31 U456.B2
S1_OUT_TX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: U456.B1 215.19,239.69 216.41,239.69 216.68,239.96 216.68,240.34 v2(216.51,240.5)
S1_OUT_TX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: R1115.1 215.3,242.21 215.3,241.48 214.94,241.13 214.44,241.13 214.15,240.85 214.15,240.14 U456.B4
S1_OUT_TX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: U456.A4 213.78,240.27 213.78,241 214.28,241.51 214.79,241.51 214.92,241.64 214.92,241.81 214.81,241.93 214.45,241.93 214.38,242 214.38,242.21 214.46,242.3 R1114.1
S1_OUT_TX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: R1115.2 R1114.2 C1093.1
S1_OUT_TX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: U456.D2 215.02,239.01 216.56,239.01 217.05,238.51 217.05,237.96 v2(217.22,237.8)
S1_OUT_TX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: U456.D1 215.18,238.63 216.41,238.63 216.68,238.36 216.68,237.96 v2(216.51,237.8)
S1_OUT_TX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: U456.B5 213.41,239.9 213.41,240.41
  BOTTOM w0.132: 213.41,240.41 213.41,241.26 213.82,241.67 213.82,242.13 R1110.1
S1_OUT_TX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: R1111.1 213.45,242.13 213.45,241.83 213.2,241.57 212.82,241.57 212.69,241.44 212.69,241.25 212.82,241.12 212.91,241.12 213.04,240.99 213.04,240.27 U456.A5
S1_OUT_TX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: R1111.2 R1110.2 C1091.1
S1_PM_SAR_GPIO0:
  vias: v1(224.52,286.43)
S1_PM_UART_RX: length 3.3
  TOP w0.991: JP1.2 v1(108.41,259.08)
S1_PWR_F001: length 0.7
  BOTTOM w0.508: CA27.1 v1(233.93,279.4)
  vias: v1(49.4,213.98) v1(49.4,211.44) v1(49.4,208.9) v1(49.4,206.36) v1(49.4,203.82) v1(49.4,201.28) v1(49.4,198.74) v1(49.4,196.2) v1(233.93,281.43)
S1_PWR_F004: length 0.7
  BOTTOM w0.508: CA23.1 v1(221.51,279.4)
  vias: v1(70.99,177.15) v1(70.99,174.61) v1(70.99,172.07) v1(70.99,169.53) v1(221.51,281.43)
S1_PWR_F005: length 0.7
  BOTTOM w0.508: CA8.1 v1(243.87,283.46)
  vias: v1(70.99,213.98) v1(70.99,211.44) v1(70.99,208.9) v1(70.99,206.36) v1(70.99,203.82) v1(70.99,201.28) v1(70.99,198.74) v1(70.99,196.2) v1(243.87,285.5)
S1_PWR_F006: length 0.7
  BOTTOM w0.508: CA25.1 v1(215.42,279.4)
  vias: v1(215.42,281.43)
S1_PWR_F007: length 0.7
  BOTTOM w0.508: CA36.1 v1(227.6,279.4)
  vias: v1(227.6,281.43)
S1_PWR_M_F001: length 0.7
  BOTTOM w0.508: CA1.1 v1(204.47,237.49)
  vias: v1(49.4,187.31) v1(49.4,184.77) v1(49.4,182.23) v1(49.4,179.69) v1(49.4,177.15) v1(49.4,174.61) v1(49.4,172.07) v1(49.4,169.53) v1(204.47,240.03)
S1_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: K3.7 109.49,250.1 94.78,250.1 93.64,248.96 93.64,242.4 95.07,240.97 95.07,236.02 92.99,233.93 90.88,233.93
S1_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: U19.6 110.61,233.93 111.09,234.41 K3.5
S1_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: v1(102.24,236.47) 96.81,241.89 96.81,249.09 97.82,250.1 112.69,250.1 K3.2
  BOTTOM w0.16: v1(102.24,236.47) 99.73,236.47
S1_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: K3.4 114.29,238.39 116.21,236.47 U19.1 R205.2
S1_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: K5.7 96.81,246.92 96.81,236.36 93.11,232.66 90.88,232.66
S1_SPI_DI_D_CASE: length 18.5
  TOP w0.16: K5.5 103.94,238.54 106.77,238.54 107.75,237.56 v1(107.75,232.66)
  BOTTOM w0.16: U19.5 v1(107.75,232.66)
S1_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: 99.73,235.2 104.09,235.2 104.86,235.97 104.86,239.12 103.16,240.82 103.16,246.92 K5.2
S1_SPI_DO_D_CASE: length 24.7
  TOP w0.16: K5.4 103.25,242.44 108.45,242.44 115.69,235.2 v1(121.06,235.2)
  BOTTOM w0.16: U19.2 v1(121.06,235.2)
S1_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: K7.2 90.46,246.92 90.46,242.28 93.73,239.01 93.73,235.81 93.11,235.2 R202.1
S1_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: v1(106.78,235.2) 106.14,235.84 97.15,235.84 K7.4
  BOTTOM w0.16: U19.7 v1(106.78,235.2)
S1_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v1(102.24,233.93) 97.05,233.93 87.29,243.69 87.29,246.9 K7.7
  BOTTOM w0.16: v1(102.24,233.93) 99.73,233.93
S1_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: v1(121.06,233.93) 117.63,230.5 99.28,230.5 K7.5
  BOTTOM w0.16: R207.2 v1(121.06,233.93) U19.3
S1_USB2_SEL0: length 1.2
  BOTTOM w0.16: R164.2 223.94,234.06 224.19,234.3 U31.6
S1_USB2_SEL1: length 1.5
  BOTTOM w0.16: U31.5 224.6,233.9 223.84,233.14 R163.2
S1_USB2_SELS: length 0.8
  BOTTOM w0.16: R165.2 227.91,233.9 U31.16
S1_USB_D_AB_CASE+: length 1.3
  BOTTOM w0.165: U31.10 225.88,236.36 v2(226.01,236.49)
S1_USB_D_AB_CASE-: length 1.3
  BOTTOM w0.165: v2(225.35,236.49) 225.48,236.36 U31.9
S1_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: U31.8 223.85,235.1 R160.2
S1_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: U31.7 223.85,234.7 R161.2
S1_USER_3V3: length 2.6
  BOTTOM w0.305: R205.1 v1(123.44,236.47) ; R203.1 v1(103.63,233.93) ; R207.1 v1(123.44,233.93) ; R200.1 v1(103.63,236.47)
  vias: v1(87.1,237.74) v1(87.1,236.47) v1(87.1,235.2) v1(87.58,239.34) v1(100.08,225.58) v1(101.74,225.85) v1(105.53,237.74) v1(105.78,236.47) v1(105.78,235.2) v1(106,239.34)
S1_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: K32.3 237.03,230.19 236.33,230.9 236.33,236.15 239.01,238.84 239.01,243.18 238.02,244.17 235.57,244.17 235.35,243.95 235.06,243.65
S1_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: K32.4 R135.1
S1_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: Y1.3 236.93,219.93 237.49,220.49 237.49,223.54 236.55,224.48 C267.1 R136.2 R135.2
S1_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: K32.6 234.28,230.19 234.98,230.89 234.98,236.7 237.6,239.33 237.6,243.06 237.01,243.65 235.71,243.65
S1_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: K32.5 R137.1
S1_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: R137.2 R136.1 C268.1 231.69,224.48 231.29,224.07 231.29,222.72 Y1.1
S2_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v4(253.66,247.72) 253.12,247.72 252.78,248.06 UNK2R661.2
  TOP w0.381: v4(254.66,251.72) 254.87,251.5 254.87,248.23 254.36,247.72 v4(253.66,247.72)
  BOTTOM w0.381: v4(253.66,247.72) UNK2C922.2
  BOTTOM w0.508: UNK2C922.2 253.66,245.95 253.3,245.59 251.82,245.59 251.5,245.91 UNK2BDB5.2
S2_3V3_RX1_MIPI: length 13.4
  TOP w0.305: v4(253.66,236.15) 253.12,236.15 252.78,236.49 UNK2R663.2
  TOP w0.381: v4(253.66,236.15) 254.36,236.15 254.87,236.66 254.87,239.94 v4(254.66,240.15)
  BOTTOM w0.381: v4(253.66,236.15) UNK2C923.2
  BOTTOM w0.508: UNK2C923.2 253.66,234.38 253.3,234.02 251.82,234.02 251.5,234.35 UNK2BDB6.2
S2_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK2U31.4 265.48,233.24 264.61,232.36 UNK2C262.1
  BOTTOM w0.305: UNK2BD21.2 UNK2C262.1
S2_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 269.83,270.83 UNK2C1074.1 UNK2R981.1
  BOTTOM w0.356: UNK2R981.1 269.86,269.73 UNK2U449.10
  BOTTOM w0.508: UNK2BD1728.2 269.83,270.83
S2_DCH015:
  vias: v2(266.61,243)
S2_DCH016:
  vias: v2(266.61,243.65)
S2_DCH018:
  vias: v2(267.9,243.66)
S2_DCH069:
  vias: v2(273.76,247.56)
S2_DCH089:
  vias: v2(274.41,244.96)
S2_DCH108: length 1.4
  BOTTOM w0.16: UNK2K32.2 v2(277.83,232.39)
S2_DCH109: length 1.4
  BOTTOM w0.16: UNK2K32.7 v2(273.63,232.39)
S2_DCH110: length 0.7
  BOTTOM w0.16: UNK2U449.3 v2(272.19,271.11)
S2_DCH111: length 0.9
  BOTTOM w0.16: v2(273.18,271.1) 272.69,270.61 UNK2U449.4
S2_DPS3:
  vias: v2(267.9,244.96) v2(271.15,250.15) v2(271.8,250.15) v2(272.46,250.15) v2(272.46,246.26) v2(272.46,244.3) v2(273.11,250.15) v2(273.11,244.3) v2(273.76,243.65)
S2_DPS4:
  vias: v2(266.61,250.15) v2(266.61,245.61) v2(273.76,244.96)
S2_MPDCH03+: length 1.3
  BOTTOM w0.165: v2(266.41,232.52) 266.28,232.65 UNK2U31.2
S2_MPDCH03-: length 1.3
  BOTTOM w0.165: v2(265.75,232.52) 265.88,232.65 UNK2U31.3
S2_MPDCH05:
  vias: v2(269.2,246.26)
S2_MPDCH25:
  vias: v2(266.61,242.35)
S2_MPDCH26:
  vias: v2(266.61,241.7)
S2_MPDCH34:
  vias: v2(267.1,269) v2(267.86,269)
S2_MPDCH37+:
  vias: v4(251.66,251.22)
S2_MPDCH37-:
  vias: v4(251.16,251.22)
S2_MPDCH39+:
  vias: v4(251.66,250.22)
S2_MPDCH39-:
  vias: v4(251.16,250.22)
S2_MPDCH41+: length 0.5
  BOTTOM w0.16: UNK2U408.E8 v4(252.16,249.72)
S2_MPDCH41-: length 0.5
  BOTTOM w0.16: UNK2U408.E9 v4(250.66,249.72)
S2_MPDCH43+:
  vias: v4(251.66,239.65)
S2_MPDCH43-:
  vias: v4(251.16,239.65)
S2_MPDCH45+:
  vias: v4(251.66,238.65)
S2_MPDCH45-:
  vias: v4(251.16,238.65)
S2_MPDCH47+: length 0.5
  BOTTOM w0.16: UNK2U409.E8 v4(252.16,238.15)
S2_MPDCH47-: length 0.5
  BOTTOM w0.16: UNK2U409.E9 v4(250.66,238.15)
S2_MPDCH52:
  vias: v2(273.76,241.71)
S2_MPDCH56:
  vias: v2(267.9,246.26)
S2_MPDCH57:
  vias: v2(273.76,243)
S2_MPDCH59:
  vias: v2(273.76,242.36)
S2_MPDCH62:
  vias: v2(275.06,244.96)
S2_MPDCH63:
  vias: v2(273.76,246.91)
S2_MPDCH65:
  vias: v2(275.06,247.56)
S2_MPDCH66:
  vias: v2(275.06,246.91)
S2_MPDCH75:
  vias: v2(275.06,246.26)
S2_MPDCH77:
  vias: v2(273.76,246.26)
S2_MPDCH85:
  vias: v2(273.11,246.26)
S2_MUX_3V3: length 1.5
  TOP w0.508: v2(267.1,267.19) v2(267.86,267.19)
  BOTTOM w0.508: v2(267.1,267.19) UNK2R512.1 v2(267.86,267.19)
  vias: v2(262.48,232.36) v2(269.83,272.29)
S2_OUT_RX0_CH0_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(257.22,252.07) 257.06,251.91 257.06,251.37 256.57,250.88 255,250.88 UNK2U408.B2
S2_OUT_RX0_CH0_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK2U408.B1 255.19,251.25 256.41,251.25 256.68,251.52 256.68,251.9 v2(256.51,252.07)
S2_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK2R647.1 255.3,253.77 255.3,253.05 254.94,252.7 254.44,252.7 254.15,252.41 254.15,251.71 UNK2U408.B4
S2_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK2U408.A4 253.78,251.83 253.78,252.57 254.28,253.07 254.79,253.07 254.92,253.21 254.92,253.38 254.81,253.5 254.45,253.5 254.38,253.57 254.38,253.78 254.46,253.86 UNK2R646.1
S2_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK2C309.1 UNK2R646.2 UNK2R647.2
S2_OUT_RX0_CH1_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK2U408.D2 255.02,250.57 256.56,250.57 257.05,250.08 257.05,249.53 v2(257.22,249.36)
  vias: v2(269.85,247.56)
S2_OUT_RX0_CH1_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(256.51,249.36) 256.68,249.53 256.68,249.93 256.41,250.2 255.18,250.2 UNK2U408.D1
S2_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 253.41,251.97 253.41,251.47 UNK2U408.B5
  BOTTOM w0.132: 253.41,251.97 253.41,252.83 253.82,253.24 253.82,253.7 UNK2R168.1
S2_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK2U408.A5 253.04,251.84 253.04,252.56 252.91,252.69 252.82,252.69 252.69,252.82 252.69,253.01 252.82,253.14 253.2,253.14 253.45,253.39 253.45,253.7 UNK2R170.1
S2_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK2C310.1 UNK2R168.2 UNK2R170.2
S2_OUT_RX0_CH2_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK2U408.E2 v2(254.16,249.72)
S2_OUT_RX0_CH2_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK2U408.E1 v2(255.66,249.72)
S2_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK2U408.B6 252.28,251.59 252.28,252.14 251.8,252.62 251.8,253.7 UNK2R176.1
S2_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK2R178.1 252.64,253.86 252.77,253.73 252.77,253.51 252.66,253.4 252.47,253.4 252.17,253.1 252.17,252.78 252.66,252.29 252.66,251.72 UNK2U408.A6
S2_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK2R178.2 UNK2R176.2 UNK2C318.1
S2_OUT_RX0_CH3_ABC_CASE+: length 3.5
  BOTTOM w0.132: UNK2U409.B2 255,239.31 256.57,239.31 257.06,239.8 257.06,240.34 v2(257.22,240.5)
  vias: v2(268.55,247.56)
S2_OUT_RX0_CH3_ABC_CASE-: length 2.3
  BOTTOM w0.132: v2(256.51,240.5) 256.68,240.34 256.68,239.96 256.41,239.69 255.19,239.69 UNK2U409.B1
S2_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK2R1089.1 255.3,242.21 255.3,241.48 254.94,241.13 254.44,241.13 254.15,240.85 254.15,240.14 UNK2U409.B4
S2_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK2R1088.1 254.46,242.3 254.38,242.21 254.38,242 254.45,241.93 254.81,241.93 254.92,241.81 254.92,241.64 254.79,241.51 254.28,241.51 253.78,241 253.78,240.27 UNK2U409.A4
S2_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK2R1089.2 UNK2R1088.2 UNK2C302.1
S2_OUT_RX0_CH4_ABC_CASE+: length 3.5
  BOTTOM w0.132: v2(257.22,237.8) 257.05,237.96 257.05,238.51 256.56,239.01 255.02,239.01 UNK2U409.D2
S2_OUT_RX0_CH4_ABC_CASE-: length 2.3
  BOTTOM w0.132: UNK2U409.D1 255.18,238.63 256.41,238.63 256.68,238.36 256.68,237.96 v2(256.51,237.8)
  vias: v2(267.9,247.56)
S2_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: 253.41,240.41 253.41,239.9 UNK2U409.B5
  BOTTOM w0.132: UNK2R180.1 253.82,242.13 253.82,241.67 253.41,241.26 253.41,240.41
S2_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK2U409.A5 253.04,240.27 253.04,240.99 252.91,241.12 252.82,241.12 252.69,241.25 252.69,241.44 252.82,241.57 253.2,241.57 253.45,241.83 253.45,242.13 UNK2R182.1
S2_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK2C320.1 UNK2R180.2 UNK2R182.2
S2_OUT_RX0_CH5_ABC_CASE+: length 0.5
  BOTTOM w0.16: UNK2U409.E2 v2(254.16,238.15)
S2_OUT_RX0_CH5_ABC_CASE-: length 0.5
  BOTTOM w0.16: UNK2U409.E1 v2(255.66,238.15)
S2_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK2U409.B6 252.28,240.03 252.28,240.57 251.8,241.06 251.8,242.13 UNK2R666.1
S2_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK2U409.A6 252.66,240.15 252.66,240.16 252.66,240.72 252.17,241.21 252.17,241.53 252.47,241.84 252.66,241.84 252.77,241.94 252.77,242.17 252.64,242.3 UNK2R664.1
S2_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK2C924.1 UNK2R666.2 UNK2R664.2
S2_OUT_TX0_CH0_ABC_CASE-:
  vias: v2(266.61,247.56)
S2_OUT_TX0_CH1_ABC_CASE+:
  vias: v2(266.61,246.91)
S2_OUT_TX0_CH2_ABC_CASE-:
  vias: v2(266.61,246.26)
S2_PWR_F001:
  vias: v2(275.06,250.15)
S2_PWR_F004:
  vias: v2(271.81,247.56)
S2_PWR_F005:
  vias: v2(267.9,242.35) v2(272.46,243) v2(273.11,243.01) v2(275.06,243)
S2_PWR_F006:
  vias: v2(270.5,240.4) v2(271.81,241.7) v2(272.46,241.06)
S2_PWR_F007:
  vias: v2(269.85,241.05) v2(270.5,241.7) v2(271.16,241.7)
S2_PWR_F008:
  vias: v2(273.76,244.31)
S2_PWR_M_F001:
  vias: v2(268.55,241.7) v2(268.55,241.06) v2(268.55,239.1) v2(269.2,245.61) v2(269.2,244.96) v2(269.85,244.96) v2(270.5,250.15) v2(270.5,246.91) v2(270.5,246.26) v2(270.5,245.61) v2(270.5,244.3) v2(271.16,246.26) v2(271.16,245.61) v2(271.16,244.96) v2(271.16,244.3) v2(271.81,244.96) v2(271.81,239.1)
S2_SPI_CK_ABCD_CASE:
  vias: v2(275.06,241.7)
S2_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: 90.88,202.18 92.99,202.18 95.07,204.27 95.07,209.22 93.64,210.65 93.64,217.21 94.78,218.35 109.49,218.35 UNK2K3.7
S2_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK2U19.6 110.61,202.18 111.09,202.66 UNK2K3.5
S2_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: UNK2K3.2 112.69,218.35 97.82,218.35 96.81,217.34 96.81,210.14 v1(102.24,204.72)
  BOTTOM w0.16: v1(102.24,204.72) 99.73,204.72
S2_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK2R205.2 UNK2U19.1 116.21,204.72 114.29,206.64 UNK2K3.4
S2_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: 90.88,200.91 93.11,200.91 96.81,204.61 96.81,215.17 UNK2K5.7
S2_SPI_DI_D_CASE: length 18.5
  TOP w0.16: UNK2K5.5 103.94,206.79 106.77,206.79 107.75,205.81 v1(107.75,200.91)
  BOTTOM w0.16: UNK2U19.5 v1(107.75,200.91)
S2_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: 99.73,203.45 104.09,203.45 104.86,204.22 104.86,207.37 103.16,209.07 103.16,215.17 UNK2K5.2
S2_SPI_DO_D_CASE: length 24.7
  TOP w0.16: UNK2K5.4 103.25,210.69 108.45,210.69 115.69,203.45 v1(121.06,203.45)
  BOTTOM w0.16: UNK2U19.2 v1(121.06,203.45)
S2_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK2R202.1 93.11,203.45 93.73,204.06 93.73,207.26 90.46,210.53 90.46,215.17 UNK2K7.2
S2_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: v1(106.78,203.45) 106.14,204.09 97.15,204.09 UNK2K7.4
  BOTTOM w0.16: UNK2U19.7 v1(106.78,203.45)
S2_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v1(102.24,202.18) 97.05,202.18 87.29,211.94 87.29,215.15 UNK2K7.7
  BOTTOM w0.16: v1(102.24,202.18) 99.73,202.18
S2_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: UNK2K7.5 99.28,198.75 117.63,198.75 v1(121.06,202.18)
  BOTTOM w0.16: UNK2R207.2 v1(121.06,202.18) UNK2U19.3
S2_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK2R164.2 263.94,234.06 264.19,234.3 UNK2U31.6
S2_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK2U31.5 264.6,233.9 263.84,233.14 UNK2R163.2
S2_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK2U31.16 267.91,233.9 UNK2R165.2
S2_USB_D_AB_CASE+: length 1.3
  BOTTOM w0.165: v2(266.01,236.49) 265.88,236.36 UNK2U31.10
S2_USB_D_AB_CASE-: length 1.3
  BOTTOM w0.165: UNK2U31.9 265.48,236.36 v2(265.35,236.49)
S2_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK2U31.8 263.85,235.1 UNK2R160.2
S2_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK2U31.7 263.85,234.7 UNK2R161.2
S2_USER_3V3: length 2.6
  BOTTOM w0.305: UNK2R205.1 v1(123.44,204.72) ; UNK2R207.1 v1(123.44,202.18) ; UNK2R200.1 v1(103.63,204.72) ; UNK2R203.1 v1(103.63,202.18)
  vias: v1(87.1,205.99) v1(87.1,204.72) v1(87.1,203.45) v1(87.58,207.59) v1(100.08,193.83) v1(101.74,194.1) v1(105.53,205.99) v1(105.78,204.72) v1(105.78,203.45) v1(106,207.59)
S2_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(275.06,243.65) 275.35,243.95 275.57,244.17 278.02,244.17 279.01,243.18 279.01,238.84 276.33,236.15 276.33,230.9 277.03,230.19 UNK2K32.3
S2_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK2K32.4 UNK2R135.1
S2_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK2Y1.3 276.93,219.93 277.49,220.49 277.49,223.54 276.55,224.48 UNK2C267.1 UNK2R136.2 UNK2R135.2
S2_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: UNK2K32.6 274.28,230.19 274.98,230.89 274.98,236.7 277.6,239.33 277.6,243.06 277.01,243.65 v2(275.71,243.65)
S2_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK2K32.5 UNK2R137.1
S2_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK2Y1.1 271.29,222.72 271.29,224.07 271.69,224.48 UNK2C268.1 UNK2R136.1 UNK2R137.2
S2_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(274.04,257.96) 274.04,267.56 273.31,268.29 v2(272.49,268.29)
  BOTTOM w0.16: v2(272.49,268.29) 272.19,268.59 UNK2U449.7 ; UNK2K29.7 v2(274.04,257.96)
S2_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 269.6,249.25 v2(269.2,248.85)
  BOTTOM w0.16: UNK2K29.6 273.38,260.16 272.71,259.49 272.71,253.39 271.11,251.79 270.61,251.79 269.85,251.04 269.85,249.5 269.6,249.25
S2_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK2K29.5 273.88,262.36 273.19,263.05 UNK2Y2.1 273.19,266.93 UNK2C271.1
S2_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK2R923.1 271.92,273.09 UNK2R973.2 271.69,271.81 UNK2U449.2
S2_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(271.38,268.29) 270.56,268.29 269.84,267.56 v2(269.84,257.96)
  BOTTOM w0.16: v2(271.38,268.29) 271.69,268.59 UNK2U449.8 ; UNK2K29.2 v2(269.84,257.96)
S2_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: UNK2K29.3 270.64,260.16 271.34,259.45 271.34,254.01 269.2,251.87 v2(269.2,249.5)
S2_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK2K29.4 269.99,262.36 270.69,263.05 UNK2Y2.2 270.69,266.93 UNK2C272.1
S2_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK2U449.1 271.19,271.78 UNK2R973.1 270.92,273.09 UNK2R652.1
S3_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v4(293.66,247.72) 293.12,247.72 292.78,248.06 UNK3R661.2
  TOP w0.381: v4(293.66,247.72) 294.36,247.72 294.87,248.23 294.87,251.5 v4(294.66,251.72)
  BOTTOM w0.381: v4(293.66,247.72) UNK3C922.2
  BOTTOM w0.508: UNK3C922.2 293.66,245.95 293.3,245.59 291.82,245.59 291.5,245.91 UNK3BDB5.2
S3_3V3_RX1_MIPI: length 13.4
  TOP w0.305: v4(293.66,236.15) 293.12,236.15 292.78,236.49 UNK3R663.2
  TOP w0.381: v4(294.66,240.15) 294.87,239.94 294.87,236.66 294.36,236.15 v4(293.66,236.15)
  BOTTOM w0.381: v4(293.66,236.15) UNK3C923.2
  BOTTOM w0.508: UNK3BDB6.2 291.5,234.35 291.82,234.02 293.3,234.02 293.66,234.38 UNK3C923.2
S3_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK3C262.1 304.6,232.36 305.48,233.24 UNK3U31.4
  BOTTOM w0.305: UNK3BD21.2 UNK3C262.1
S3_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 309.83,270.83 UNK3C1074.1 UNK3R981.1
  BOTTOM w0.356: UNK3R981.1 309.86,269.73 UNK3U449.10
  BOTTOM w0.508: UNK3BD1728.2 309.83,270.83
S3_DCH015:
  vias: v2(306.6,243)
S3_DCH016:
  vias: v2(306.6,243.65)
S3_DCH018:
  vias: v2(307.9,243.66)
S3_DCH069:
  vias: v2(313.76,247.56)
