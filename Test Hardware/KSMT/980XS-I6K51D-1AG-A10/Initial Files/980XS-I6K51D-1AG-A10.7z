# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Nets (continued)
S1_PWR_F001: CA26.1 CA27.1 CC112.1 S1_DPS_SW6.1 S1_DPS_SW6.2 S1_DPS_SW6.3 S1_DPS_SW6.4 S1_DPS_SW6.5 S1_DPS_SW6.6 S1_DPS_SW6.7 S1_DPS_SW6.8 SA16.1 SITE1.F15(DVDD_NODIE) TP_DPS2.1(TP)
S1_PWR_F004: CA22.1 CA23.1 CC96.1 S1_DPS_SW2.5 S1_DPS_SW2.6 S1_DPS_SW2.7 S1_DPS_SW2.8 SA21.1 SITE1.E10(AVDD33_RTC) TP_DPS5.1(TP)
S1_PWR_F005: CA7.1 CA8.1 CC70.1 CC71.1 CC73.1 S1_DPS_SW5.1 S1_DPS_SW5.2 S1_DPS_SW5.3 S1_DPS_SW5.4 S1_DPS_SW5.5 S1_DPS_SW5.6 S1_DPS_SW5.7 S1_DPS_SW5.8 SA8.1 SITE1.G18(VDDP3318_PM) SITE1.N17(VDDP3318_P0) SITE1.P3(VDDP3318_P2) TP_DPS6.1(TP)
S1_PWR_F006: CA24.1 CA25.1 CC101.1 CC103.1 CC105.1 S1_DPS_SW4.1 S1_DPS_SW4.2 S1_DPS_SW4.3 S1_DPS_SW4.4 SA9.1 SITE1.T13(VDD2_DRAM[0]) SITE1.T14(VDD2_DRAM[1]) SITE1.U13(VDD2_DRAM[2]) TP_DPS7.1(TP)
S1_PWR_F007: CA36.1 CA37.1 CC211.1 CC212.1 CC213.1 S1_DPS_SW4.5 S1_DPS_SW4.6 S1_DPS_SW4.7 S1_DPS_SW4.8 SA23.1 SITE1.T10(VDDQ_DRAM[0]) SITE1.T11(VDDQ_DRAM[1]) SITE1.U11(VDDQ_DRAM[2]) TP_DPS8.1(TP)
S1_PWR_F008: CA38.1 CA39.1 CC220.1 S1_DPS_SW3.5 S1_DPS_SW3.6 S1_DPS_SW3.7 S1_DPS_SW3.8 SA25.1 SITE1.K19(AVDD18_XTAL) TP_DPS9.1(TP)
S1_PWR_GS001: SA15.2
S1_PWR_GS002: SA18.2
S1_PWR_GS003: SA20.2
S1_PWR_GS004: SA22.2
S1_PWR_GS005: SA7.2
S1_PWR_GS006: SA10.2
S1_PWR_GS007: SA24.2
S1_PWR_GS008: SA26.2
S1_PWR_M_F001: CA1.1 CA2.1 CC1.1 CC2.1 CC3.1 CC4.1 CC5.1 CC6.1 CC7.1 CC8.1 CC9.1 CC12.1 CC13.1 CC14.1 CC15.1 CC16.1 CC130.1 CC214.1 CC215.1 CC216.1 CC217.1 CC218.1 CC219.1 K96.4 K96.9 S1_DPS_SW1.1 S1_DPS_SW1.2 S1_DPS_SW1.3 S1_DPS_SW1.4 S1_DPS_SW1.5 S1_DPS_SW1.6 S1_DPS_SW1.7 S1_DPS_SW1.8 SA1.1 SITE1.F6(AVDDL_MIPI_RX) SITE1.F7(VDD_CPU[0]) SITE1.F8(VDD_CPU[1]) SITE1.G6(AVDDL_MIPI_TX) SITE1.G7(VDD_CPU[2]) SITE1.G8(VDD_CPU[3]) SITE1.G10(VDD[0]) SITE1.G11(VDD[1]) SITE1.H7(VDD_CPU[4]) SITE1.H8(VDD_CPU[5]) SITE1.H10(VDD[2]) SITE1.H11(VDD[3]) SITE1.H12(VDD[4]) SITE1.J10(VDD[5]) SITE1.J11(VDD[6]) SITE1.J12(VDD[7]) SITE1.J13(VDD[8]) SITE1.K10(VDD[9]) SITE1.K11(VDD[10]) SITE1.K12(VDD[11]) SITE1.K13(VDD[12]) TP_DPS1.1(TP)
S1_PWR_M_GS001: SA2.2
S1_PWR_M_S001: SA1.2
S1_PWR_S001: SA16.2
S1_PWR_S002: SA17.2
S1_PWR_S003: SA19.2
S1_PWR_S004: SA21.2
S1_PWR_S005: SA8.2
S1_PWR_S006: SA9.2
S1_PWR_S007: SA23.2
S1_PWR_S008: SA25.2
S1_SPI_CK_ABCD_CASE: K2.6 SITE1.T22(PAD_SPI_CK)
S1_SPI_CK_B_CASE: K2.5 K3.6
S1_SPI_CK_C_CASE: K3.7 U18.7(RESET#)
S1_SPI_CK_D_CASE: K3.5 U19.6
S1_SPI_CZ_ABCD_CASE: K2.3 SITE1.M21(PAD_SPI_CZ)
S1_SPI_CZ_B_CASE: K2.4 K3.3
S1_SPI_CZ_C_CASE: K3.2 R200.2 U18.1(CS#)
S1_SPI_CZ_D_CASE: K3.4 R205.2 U19.1
S1_SPI_DI_ABCD_CASE: K4.6 SITE1.R21(PAD_SPI_DI)
S1_SPI_DI_B_CASE: K4.5 K5.6
S1_SPI_DI_C_CASE: K5.7
S1_SPI_DI_D_CASE: K5.5 U19.5
S1_SPI_DO_ABCD_CASE: K4.3 SITE1.P22(PAD_SPI_DO)
S1_SPI_DO_B_CASE: K4.4 K5.3
S1_SPI_DO_C_CASE: K5.2
S1_SPI_DO_D_CASE: K5.4 U19.2
S1_SPI_HLD_ABCD_CASE: K6.3 SITE1.P21(PAD_SPI_HLD)
S1_SPI_HLD_B_CASE: K6.4 K7.3
S1_SPI_HLD_C_CASE: K7.2 R202.1
S1_SPI_HLD_D_CASE: K7.4 R206.1 U19.7
S1_SPI_WPZ_ABCD_CASE: K6.6 SITE1.N21(PAD_SPI_WPZ)
S1_SPI_WPZ_B_CASE: K6.5 K7.6
S1_SPI_WPZ_C_CASE: K7.7 R203.2 U18.2(SO)
S1_SPI_WPZ_D_CASE: K7.5 R207.2 U19.3
S1_USB2_SEL0: R164.2 U31.6(SEL0)
S1_USB2_SEL1: R163.2 U31.5(SEL1)
S1_USB2_SELS: R165.2 U31.16(SELS)
S1_USB_D_AB_CASE+: SITE1.J3(PAD_DP_USB) U31.10(HSD2+)
S1_USB_D_AB_CASE-: SITE1.J2(PAD_DM_USB) U31.9(HSD2-)
S1_USB_D_B_CASE+: R160.2 U31.8(HSD2S+)
S1_USB_D_B_CASE-: R161.2 U31.7(HSD2S-)
S1_USER_3V3: C334.1 C335.1 C336.2 C337.2 C338.2 C339.2 R200.1 R201.2 R202.2 R203.1 R204.2 R205.1 R206.2 R207.1 S1_USER_3V3.1 U17.3(VOUT)
S1_XTAL_24M_IN_ABC_CASE: K32.3 SITE1.L22(PAD_XTAL_IN_24M)
S1_XTAL_24M_IN_B_CASE: K32.4 R135.1
S1_XTAL_24M_IN_C_CASE: C267.1 R135.2 R136.2 Y1.3
S1_XTAL_24M_OUT_ABC_CASE: K32.6 SITE1.K21(PAD_XTAL_OUT_24M)
S1_XTAL_24M_OUT_B_CASE: K32.5 R137.1
S1_XTAL_24M_OUT_C_CASE: C268.1 R136.1 R137.2 Y1.1
S1_XTAL_IN_32K_A_CASE: K29.7 U449.7(D-)
S1_XTAL_IN_32K_ABCD_CASE: K29.6 SITE1.B13(PAD_XTAL_IN_32K)
S1_XTAL_IN_32K_B_CASE: C271.1 K29.5 Y2.1
S1_XTAL_IN_32K_D_CASE: R923.1 R973.2 U449.2(USB-)
S1_XTAL_OUT_32K_A_CASE: K29.2 U449.8(D+)
S1_XTAL_OUT_32K_ABCD_CASE: K29.3 SITE1.A12(PAD_XTAL_OUT_32K)
S1_XTAL_OUT_32K_B_CASE: C272.1 K29.4 Y2.2
S1_XTAL_OUT_32K_D_CASE: R652.1 R973.1 U449.1(USB+)
S2_0V5: UNK2C286.1 UNK2C288.1 UNK2MK1.4 UNK2MR2.2 UNK2MR3.1 UNK2MR4.1 UNK2MR5.1 UNK2MR6.1 UNK2MU3.3
S2_0V25: UNK2MK4.3 UNK2MR18.2 UNK2MR19.1
S2_0V75: UNK2C290.1 UNK2MK2.4 UNK2MR10.2 UNK2MU3.6
S2_1SPI_CK: UNK2K2.7
S2_1SPI_DI: UNK2K4.7
S2_1SPI_DO: UNK2K4.2
S2_1SPI_HLD: UNK2K6.2
S2_1SPI_WPZ: UNK2K6.7
S2_3V3_RX0_MIPI: UNK2BDB5.2 UNK2C922.2 UNK2R661.2 UNK2U408.A2 UNK2U408.J4
S2_3V3_RX1_MIPI: UNK2BDB6.2 UNK2C923.2 UNK2R663.2 UNK2U409.A2 UNK2U409.J4
S2_3V3_TX0_MIPI: UNK2BDB8.2 UNK2C1090.2 UNK2R1101.2 UNK2U455.A2 UNK2U455.J4
S2_3V3_TX1_MIPI: UNK2BDB7.2 UNK2C1089.2 UNK2R1098.2 UNK2U456.A2 UNK2U456.J4
S2_3V3_USB2_MUX: UNK2BD21.2 UNK2C262.1 UNK2U31.4
S2_3V3_XTAL32K: UNK2BD1728.2 UNK2C1074.1 UNK2R981.1 UNK2U449.10
S2_AWG_3SHARE+: K109.7 UNK2K34.4
S2_B_DCH001: SITE2.M18(VDDP18_LDO_P0) UNK2CC195.1
S2_B_DCH105: SITE2.C12(PAD_RTC_IO4)
S2_B_DCH106: SITE2.D13(PAD_RTC_IO5)
S2_DCH015: SITE2.N1(PAD_AUD_MICCM0)
S2_DCH016: SITE2.L1(PAD_AUD_MICCM1)
S2_DCH017: SITE2.L3(PAD_AUD_LINEOUT_RP)
S2_DCH018: SITE2.L4(PAD_AUD_LINEOUT_RN)
S2_DCH063: SITE2.A17(PAD_PM_SDIO_CLK)
S2_DCH064: SITE2.B16(PAD_PM_SDIO_CMD)
S2_DCH065: SITE2.A18(PAD_PM_SDIO_D0)
S2_DCH066: SITE2.B18(PAD_PM_SDIO_D1)
S2_DCH067: SITE2.B15(PAD_PM_SDIO_D2)
S2_DCH068: SITE2.A15(PAD_PM_SDIO_D3)
S2_DCH069: SITE2.B19(PAD_PM_SDIO_INT)
S2_DCH082: SITE2.D15(PAD_PM_FUART_CTS)
S2_DCH083: SITE2.D16(PAD_PM_FUART_RTS)
S2_DCH088: SITE2.G20(PAD_PM_PWM2)
S2_DCH089: SITE2.H20(PAD_PM_PWM3)
S2_DCH090: SITE2.A21(PAD_PM_SAR_GPIO1)
S2_DCH103: SITE2.E12(PAD_RTC_IO0)
S2_DCH104: SITE2.D12(PAD_RTC_IO1)
S2_DCH107: SITE2.E11(PAD_RESET)
S2_DCH108: UNK2K32.2
S2_DCH109: UNK2K32.7
S2_DCH110: UNK2U449.3
S2_DCH111: UNK2U449.4
S2_DPS3: SITE2.F4(VDDP18_P1) SITE2.F17(AVDD18_NODIE) SITE2.G5(AVDD18_MIPI_TX) SITE2.H4(AVDD18_USB) SITE2.J18(AVDD18_OTP) SITE2.L5(AVDD18_AUD) SITE2.R11(AVDD18_PLL_DDR) SITE2.R14(VDD1_DRAM[0]) SITE2.R15(VDD1_DRAM[1]) UNK2CA20.1 UNK2CA21.1 UNK2CC84.1 UNK2CC85.1 UNK2CC86.1 UNK2CC87.1 UNK2CC88.1 UNK2CC89.1 UNK2CC90.1 UNK2CC91.1 UNK2CC92.1 UNK2SA17.1 UNK2TP_DPS3.1
S2_DPS4: SITE2.H19(AVDD33_ETH) SITE2.J5(AVDD33_USB) UNK2CA34.1 UNK2CA35.1 UNK2CC182.1 UNK2CC202.1 UNK2SA19.1 UNK2TP_DPS4.1
S2_M_2V5: UNK2C284.1 UNK2C285.1 UNK2MR2.1 UNK2MU2.6
S2_M_3V2: UNK2C282.1 UNK2C283.1 UNK2C289.1 UNK2MR1.1 UNK2MU1.5 UNK2MU2.2 UNK2MU3.7
S2_MPDCH01: SITE2.D7(PAD_I2C1_SDA)
S2_MPDCH03+: UNK2U31.2
S2_MPDCH03-: UNK2U31.3
S2_MPDCH05: SITE2.E7(PAD_I2C1_SCL)
S2_MPDCH06: SITE2.T4(PAD_SD0_D1)
S2_MPDCH09: SITE2.E8(PAD_SR_RST0)
S2_MPDCH10: SITE2.D8(PAD_SR_MCLK0)
S2_MPDCH11: SITE2.T3(PAD_SD0_CDZ)
S2_MPDCH13: SITE2.U4(PAD_SD0_D0)
S2_MPDCH14: SITE2.U5(PAD_SD0_CLK)
S2_MPDCH15: SITE2.T6(PAD_SD0_CMD)
S2_MPDCH16: SITE2.U7(PAD_SD0_D3)
S2_MPDCH17: SITE2.T7(PAD_SD0_D2)
S2_MPDCH18: SITE2.U20(PAD_FUART_RX)
S2_MPDCH19: SITE2.U21(PAD_FUART_TX)
S2_MPDCH20: SITE2.U18(PAD_FUART_RTS)
S2_MPDCH21: SITE2.R2(PAD_GPIO0)
S2_MPDCH22: SITE2.P6(PAD_GPIO5)
S2_MPDCH23: SITE2.R3(PAD_GPIO1)
S2_MPDCH24: SITE2.T2(PAD_GPIO10)
S2_MPDCH25: SITE2.R1(PAD_GPIO8)
S2_MPDCH26: SITE2.T1(PAD_GPIO9)
S2_MPDCH27: SITE2.P7(PAD_GPIO6)
S2_MPDCH28: SITE2.P4(PAD_GPIO3)
S2_MPDCH29: SITE2.U2(PAD_GPIO11)
S2_MPDCH30: SITE2.R7(PAD_GPIO7)
S2_MPDCH32: UNK2K2.2
S2_MPDCH33: SITE2.L2(PAD_AUD_MICIN1)
S2_MPDCH34: SITE2.M3(PAD_AUD_VAG) UNK2C264.1
S2_MPDCH35: SITE2.N2(PAD_AUD_MICIN0)
S2_MPDCH36: SITE2.L20(PAD_I2C0_SDA)
S2_MPDCH37+: UNK2U408.B8
S2_MPDCH37-: UNK2U408.B9
S2_MPDCH38+: UNK2U455.B8
S2_MPDCH38-: UNK2U455.B9
S2_MPDCH39+: UNK2U408.D8
S2_MPDCH39-: UNK2U408.D9
S2_MPDCH40+: UNK2U455.D8
S2_MPDCH40-: UNK2U455.D9
S2_MPDCH41+: UNK2U408.E8
S2_MPDCH41-: UNK2U408.E9
S2_MPDCH42+: UNK2U455.E8
S2_MPDCH42-: UNK2U455.E9
S2_MPDCH43+: UNK2U409.B8
S2_MPDCH43-: UNK2U409.B9
S2_MPDCH44+: UNK2U456.B8
S2_MPDCH44-: UNK2U456.B9
S2_MPDCH45+: UNK2U409.D8
S2_MPDCH45-: UNK2U409.D9
S2_MPDCH46+: UNK2U456.D8
S2_MPDCH46-: UNK2U456.D9
S2_MPDCH47+: UNK2U409.E8
S2_MPDCH47-: UNK2U409.E9
S2_MPDCH49: SITE2.E5(PAD_SR_RST1)
S2_MPDCH50: SITE2.D5(PAD_SR_MCLK1)
S2_MPDCH51: SITE2.T18(PAD_FUART_CTS)
S2_MPDCH52: SITE2.T19(PAD_MSPI0_CZ)
S2_MPDCH53: SITE2.R4(PAD_GPIO2)
S2_MPDCH54: SITE2.P5(PAD_GPIO4)
S2_MPDCH55: SITE2.D4(PAD_I2C2_SCL)
S2_MPDCH56: SITE2.E4(PAD_I2C2_SDA)
S2_MPDCH57: SITE2.N19(PAD_MSPI0_CK)
S2_MPDCH58: SITE2.P19(PAD_MSPI0_DI)
S2_MPDCH59: SITE2.R19(PAD_MSPI0_DO)
S2_MPDCH60: SITE2.M20(PAD_I2C0_SCL)
S2_MPDCH61: SITE2.G21(PAD_PM_UART_RX)
S2_MPDCH62: SITE2.H22(PAD_PM_UART_TX)
S2_MPDCH63: SITE2.C19(PAD_PM_I2C_SDA)
S2_MPDCH64: SITE2.D19(PAD_PM_I2C_SCL)
S2_MPDCH65: SITE2.B22(PAD_PM_GPIO5)
S2_MPDCH66: SITE2.C22(PAD_PM_GPIO6)
S2_MPDCH68: SITE2.B21(PAD_PM_GPIO4)
S2_MPDCH69: SITE2.F19(PAD_PM_PWM1)
S2_MPDCH71: SITE2.H21(PAD_PM_GPIO11)
S2_MPDCH72: SITE2.E15(PAD_PM_FUART_RX)
S2_MPDCH73: SITE2.E18(PAD_PM_GPIO2)
S2_MPDCH74: SITE2.D18(PAD_PM_GPIO3)
S2_MPDCH75: SITE2.E22(PAD_PM_PSPI0_DO)
S2_MPDCH76: SITE2.F22(PAD_PM_PSPI0_DI)
S2_MPDCH77: SITE2.E19(PAD_PM_PWM0)
S2_MPDCH78: SITE2.C20(PAD_PM_UART2_RX)
S2_MPDCH79: SITE2.D20(PAD_PM_UART2_TX)
S2_MPDCH80: SITE2.E21(PAD_PM_PSPI0_CK)
S2_MPDCH81: SITE2.D21(PAD_PM_PSPI0_CZ)
S2_MPDCH84: SITE2.F21(PAD_PM_PSPI0_INT)
S2_MPDCH85: SITE2.E17(PAD_PM_GPIO1)
S2_MPDCH86: SITE2.C16(PAD_PM_GPIO0)
S2_MPDCH87: SITE2.E14(PAD_PM_FUART_TX)
S2_MPDCH88: UNK2K34.2
S2_MUX_3V3: UNK2BD21.1 UNK2BD1728.1 UNK2R234.2 UNK2R512.1 UNK2R1117.2 UNK2R1118.2 UNK2R1119.2
S2_OUT_RX0_CH0_ABC_CASE+: SITE2.B10(PAD_OUTP_RX0_CH[0]) UNK2U408.B2
S2_OUT_RX0_CH0_ABC_CASE-: SITE2.A10(PAD_OUTN_RX0_CH[0]) UNK2U408.B1
S2_OUT_RX0_CH0_B_CASE+: UNK2R647.1 UNK2U408.B4
S2_OUT_RX0_CH0_B_CASE-: UNK2R646.1 UNK2U408.A4
S2_OUT_RX0_CH0_C_CASE: UNK2C309.1 UNK2R646.2 UNK2R647.2
S2_OUT_RX0_CH1_ABC_CASE+: SITE2.B9(PAD_OUTP_RX0_CH[1]) UNK2U408.D2
S2_OUT_RX0_CH1_ABC_CASE-: SITE2.B8(PAD_OUTN_RX0_CH[1]) UNK2U408.D1
S2_OUT_RX0_CH1_B_CASE+: UNK2R168.1 UNK2U408.B5
S2_OUT_RX0_CH1_B_CASE-: UNK2R170.1 UNK2U408.A5
S2_OUT_RX0_CH1_C_CASE: UNK2C310.1 UNK2R168.2 UNK2R170.2
S2_OUT_RX0_CH2_ABC_CASE+: SITE2.A8(PAD_OUTP_RX0_CH[2]) UNK2U408.E2
S2_OUT_RX0_CH2_ABC_CASE-: SITE2.B7(PAD_OUTN_RX0_CH[2]) UNK2U408.E1
S2_OUT_RX0_CH2_B_CASE+: UNK2R176.1 UNK2U408.B6
S2_OUT_RX0_CH2_B_CASE-: UNK2R178.1 UNK2U408.A6
S2_OUT_RX0_CH2_C_CASE: UNK2C318.1 UNK2R176.2 UNK2R178.2
S2_OUT_RX0_CH3_ABC_CASE+: SITE2.B6(PAD_OUTP_RX0_CH[3]) UNK2U409.B2
S2_OUT_RX0_CH3_ABC_CASE-: SITE2.A6(PAD_OUTN_RX0_CH[3]) UNK2U409.B1
S2_OUT_RX0_CH3_B_CASE+: UNK2R1089.1 UNK2U409.B4
S2_OUT_RX0_CH3_B_CASE-: UNK2R1088.1 UNK2U409.A4
S2_OUT_RX0_CH3_C_CASE: UNK2C302.1 UNK2R1088.2 UNK2R1089.2
S2_OUT_RX0_CH4_ABC_CASE+: SITE2.B5(PAD_OUTP_RX0_CH[4]) UNK2U409.D2
S2_OUT_RX0_CH4_ABC_CASE-: SITE2.B4(PAD_OUTN_RX0_CH[4]) UNK2U409.D1
S2_OUT_RX0_CH4_B_CASE+: UNK2R180.1 UNK2U409.B5
S2_OUT_RX0_CH4_B_CASE-: UNK2R182.1 UNK2U409.A5
S2_OUT_RX0_CH4_C_CASE: UNK2C320.1 UNK2R180.2 UNK2R182.2
S2_OUT_RX0_CH5_ABC_CASE+: SITE2.A4(PAD_OUTP_RX0_CH[5]) UNK2U409.E2
S2_OUT_RX0_CH5_ABC_CASE-: SITE2.B3(PAD_OUTN_RX0_CH[5]) UNK2U409.E1
S2_OUT_RX0_CH5_B_CASE+: UNK2R666.1 UNK2U409.B6
S2_OUT_RX0_CH5_B_CASE-: UNK2R664.1 UNK2U409.A6
S2_OUT_RX0_CH5_C_CASE: UNK2C924.1 UNK2R664.2 UNK2R666.2
S2_OUT_TX0_CH0_ABC_CASE+: SITE2.A2(PAD_OUTP_TX0_CH[0]) UNK2U455.B2
S2_OUT_TX0_CH0_ABC_CASE-: SITE2.B1(PAD_OUTN_TX0_CH[0]) UNK2U455.B1
S2_OUT_TX0_CH0_B_CASE+: UNK2R1109.1 UNK2U455.B4
S2_OUT_TX0_CH0_B_CASE-: UNK2R1107.1 UNK2U455.A4
S2_OUT_TX0_CH0_C_CASE: UNK2C1086.1 UNK2R1107.2 UNK2R1109.2
S2_OUT_TX0_CH1_ABC_CASE+: SITE2.C1(PAD_OUTP_TX0_CH[1]) UNK2U455.D2
S2_OUT_TX0_CH1_ABC_CASE-: SITE2.C2(PAD_OUTN_TX0_CH[1]) UNK2U455.D1
S2_OUT_TX0_CH1_B_CASE+: UNK2R1099.1 UNK2U455.B5
S2_OUT_TX0_CH1_B_CASE-: UNK2R1100.1 UNK2U455.A5
S2_OUT_TX0_CH1_C_CASE: UNK2C1087.1 UNK2R1099.2 UNK2R1100.2
S2_OUT_TX0_CH2_ABC_CASE+: SITE2.D2(PAD_OUTP_TX0_CH[2]) UNK2U455.E2
S2_OUT_TX0_CH2_ABC_CASE-: SITE2.E1(PAD_OUTN_TX0_CH[2]) UNK2U455.E1
S2_OUT_TX0_CH2_B_CASE+: UNK2R1106.1 UNK2U455.B6
S2_OUT_TX0_CH2_B_CASE-: UNK2R1103.1 UNK2U455.A6
S2_OUT_TX0_CH2_C_CASE: UNK2C1088.1 UNK2R1103.2 UNK2R1106.2
S2_OUT_TX0_CH3_ABC_CASE+: SITE2.E2(PAD_OUTP_TX0_CH[3]) UNK2U456.B2
S2_OUT_TX0_CH3_ABC_CASE-: SITE2.F2(PAD_OUTN_TX0_CH[3]) UNK2U456.B1
S2_OUT_TX0_CH3_B_CASE+: UNK2R1115.1 UNK2U456.B4
S2_OUT_TX0_CH3_B_CASE-: UNK2R1114.1 UNK2U456.A4
S2_OUT_TX0_CH3_C_CASE: UNK2C1093.1 UNK2R1114.2 UNK2R1115.2
S2_OUT_TX0_CH4_ABC_CASE+: SITE2.G1(PAD_OUTP_TX0_CH[4]) UNK2U456.D2
S2_OUT_TX0_CH4_ABC_CASE-: SITE2.G2(PAD_OUTN_TX0_CH[4]) UNK2U456.D1
S2_OUT_TX0_CH4_B_CASE+: UNK2R1110.1 UNK2U456.B5
S2_OUT_TX0_CH4_B_CASE-: UNK2R1111.1 UNK2U456.A5
S2_OUT_TX0_CH4_C_CASE: UNK2C1091.1 UNK2R1110.2 UNK2R1111.2
S2_PM_SAR_GPIO0: S2_VREF_OUT.1(TP) SITE2.A20(PAD_PM_SAR_GPIO0) UNK2K34.3 UNK2MK3.4
S2_PWR_F001: SITE2.F15(DVDD_NODIE) UNK2CA26.1 UNK2CA27.1 UNK2CC112.1 UNK2SA16.1 UNK2TP_DPS2.1
S2_PWR_F004: SITE2.E10(AVDD33_RTC) UNK2CA22.1 UNK2CA23.1 UNK2CC96.1 UNK2SA21.1 UNK2TP_DPS5.1
S2_PWR_F005: SITE2.G18(VDDP3318_PM) SITE2.N17(VDDP3318_P0) SITE2.P3(VDDP3318_P2) UNK2CA7.1 UNK2CA8.1 UNK2CC70.1 UNK2CC71.1 UNK2CC73.1 UNK2SA8.1 UNK2TP_DPS6.1
S2_PWR_F006: SITE2.T13(VDD2_DRAM[0]) SITE2.T14(VDD2_DRAM[1]) SITE2.U13(VDD2_DRAM[2]) UNK2CA24.1 UNK2CA25.1 UNK2CC101.1 UNK2CC103.1 UNK2CC105.1 UNK2SA9.1 UNK2TP_DPS7.1
S2_PWR_F007: SITE2.T10(VDDQ_DRAM[0]) SITE2.T11(VDDQ_DRAM[1]) SITE2.U11(VDDQ_DRAM[2]) UNK2CA36.1 UNK2CA37.1 UNK2CC211.1 UNK2CC212.1 UNK2CC213.1 UNK2SA23.1 UNK2TP_DPS8.1
S2_PWR_F008: SITE2.K19(AVDD18_XTAL) UNK2CA38.1 UNK2CA39.1 UNK2CC220.1 UNK2SA25.1 UNK2TP_DPS9.1
S2_PWR_GS001: UNK2SA15.2
S2_PWR_GS002: UNK2SA18.2
S2_PWR_GS003: UNK2SA20.2
S2_PWR_GS004: UNK2SA22.2
S2_PWR_GS005: UNK2SA7.2
S2_PWR_GS006: UNK2SA10.2
S2_PWR_GS007: UNK2SA24.2
S2_PWR_GS008: UNK2SA26.2
S2_PWR_M_F001: SITE2.F6(AVDDL_MIPI_RX) SITE2.F7(VDD_CPU[0]) SITE2.F8(VDD_CPU[1]) SITE2.G6(AVDDL_MIPI_TX) SITE2.G7(VDD_CPU[2]) SITE2.G8(VDD_CPU[3]) SITE2.G10(VDD[0]) SITE2.G11(VDD[1]) SITE2.H7(VDD_CPU[4]) SITE2.H8(VDD_CPU[5]) SITE2.H10(VDD[2]) SITE2.H11(VDD[3]) SITE2.H12(VDD[4]) SITE2.J10(VDD[5]) SITE2.J11(VDD[6]) SITE2.J12(VDD[7]) SITE2.J13(VDD[8]) SITE2.K10(VDD[9]) SITE2.K11(VDD[10]) SITE2.K12(VDD[11]) SITE2.K13(VDD[12]) UNK2CA1.1 UNK2CA2.1 UNK2CC1.1 UNK2CC2.1 UNK2CC3.1 UNK2CC4.1 UNK2CC5.1 UNK2CC6.1 UNK2CC7.1 UNK2CC8.1 UNK2CC9.1 UNK2CC12.1 UNK2CC13.1 UNK2CC14.1 UNK2CC15.1 UNK2CC16.1 UNK2CC130.1 UNK2CC214.1 UNK2CC215.1 UNK2CC216.1 UNK2CC217.1 UNK2CC218.1 UNK2CC219.1 UNK2K96.4 UNK2K96.9 UNK2SA1.1 UNK2TP_DPS1.1
S2_PWR_M_GS001: UNK2SA2.2
S2_PWR_M_S001: UNK2SA1.2
S2_PWR_S001: UNK2SA16.2
S2_PWR_S002: UNK2SA17.2
S2_PWR_S003: UNK2SA19.2
S2_PWR_S004: UNK2SA21.2
S2_PWR_S005: UNK2SA8.2
S2_PWR_S006: UNK2SA9.2
S2_PWR_S007: UNK2SA23.2
S2_PWR_S008: UNK2SA25.2
S2_SPI_CK_ABCD_CASE: SITE2.T22(PAD_SPI_CK) UNK2K2.6
S2_SPI_CK_B_CASE: UNK2K2.5 UNK2K3.6
S2_SPI_CK_C_CASE: UNK2K3.7 UNK2U18.7
S2_SPI_CK_D_CASE: UNK2K3.5 UNK2U19.6
S2_SPI_CZ_ABCD_CASE: SITE2.M21(PAD_SPI_CZ) UNK2K2.3
S2_SPI_CZ_B_CASE: UNK2K2.4 UNK2K3.3
S2_SPI_CZ_C_CASE: UNK2K3.2 UNK2R200.2 UNK2U18.1
S2_SPI_CZ_D_CASE: UNK2K3.4 UNK2R205.2 UNK2U19.1
S2_SPI_DI_ABCD_CASE: SITE2.R21(PAD_SPI_DI) UNK2K4.6
S2_SPI_DI_B_CASE: UNK2K4.5 UNK2K5.6
S2_SPI_DI_C_CASE: UNK2K5.7
S2_SPI_DI_D_CASE: UNK2K5.5 UNK2U19.5
S2_SPI_DO_ABCD_CASE: SITE2.P22(PAD_SPI_DO) UNK2K4.3
S2_SPI_DO_B_CASE: UNK2K4.4 UNK2K5.3
S2_SPI_DO_C_CASE: UNK2K5.2
S2_SPI_DO_D_CASE: UNK2K5.4 UNK2U19.2
S2_SPI_HLD_ABCD_CASE: SITE2.P21(PAD_SPI_HLD) UNK2K6.3
S2_SPI_HLD_B_CASE: UNK2K6.4 UNK2K7.3
S2_SPI_HLD_C_CASE: UNK2K7.2 UNK2R202.1
S2_SPI_HLD_D_CASE: UNK2K7.4 UNK2R206.1 UNK2U19.7
S2_SPI_WPZ_ABCD_CASE: SITE2.N21(PAD_SPI_WPZ) UNK2K6.6
S2_SPI_WPZ_B_CASE: UNK2K6.5 UNK2K7.6
S2_SPI_WPZ_C_CASE: UNK2K7.7 UNK2R203.2 UNK2U18.2
S2_SPI_WPZ_D_CASE: UNK2K7.5 UNK2R207.2 UNK2U19.3
S2_USB2_SEL0: UNK2R164.2 UNK2U31.6
S2_USB2_SEL1: UNK2R163.2 UNK2U31.5
S2_USB2_SELS: UNK2R165.2 UNK2U31.16
S2_USB_D_AB_CASE+: SITE2.J3(PAD_DP_USB) UNK2U31.10
S2_USB_D_AB_CASE-: SITE2.J2(PAD_DM_USB) UNK2U31.9
S2_USB_D_B_CASE+: UNK2R160.2 UNK2U31.8
S2_USB_D_B_CASE-: UNK2R161.2 UNK2U31.7
S2_USER_3V3: S2_USER_3V3.1 UNK2C334.1 UNK2C335.1 UNK2C336.2 UNK2C337.2 UNK2C338.2 UNK2C339.2 UNK2R200.1 UNK2R201.2 UNK2R202.2 UNK2R203.1 UNK2R204.2 UNK2R205.1 UNK2R206.2 UNK2R207.1 UNK2U17.3
S2_XTAL_24M_IN_ABC_CASE: SITE2.L22(PAD_XTAL_IN_24M) UNK2K32.3
S2_XTAL_24M_IN_B_CASE: UNK2K32.4 UNK2R135.1
S2_XTAL_24M_IN_C_CASE: UNK2C267.1 UNK2R135.2 UNK2R136.2 UNK2Y1.3
S2_XTAL_24M_OUT_ABC_CASE: SITE2.K21(PAD_XTAL_OUT_24M) UNK2K32.6
S2_XTAL_24M_OUT_B_CASE: UNK2K32.5 UNK2R137.1
S2_XTAL_24M_OUT_C_CASE: UNK2C268.1 UNK2R136.1 UNK2R137.2 UNK2Y1.1
S2_XTAL_IN_32K_A_CASE: UNK2K29.7 UNK2U449.7
S2_XTAL_IN_32K_ABCD_CASE: SITE2.B13(PAD_XTAL_IN_32K) UNK2K29.6
S2_XTAL_IN_32K_B_CASE: UNK2C271.1 UNK2K29.5 UNK2Y2.1
S2_XTAL_IN_32K_D_CASE: UNK2R923.1 UNK2R973.2 UNK2U449.2
S2_XTAL_OUT_32K_A_CASE: UNK2K29.2 UNK2U449.8
S2_XTAL_OUT_32K_ABCD_CASE: SITE2.A12(PAD_XTAL_OUT_32K) UNK2K29.3
S2_XTAL_OUT_32K_B_CASE: UNK2C272.1 UNK2K29.4 UNK2Y2.2
S2_XTAL_OUT_32K_D_CASE: UNK2R652.1 UNK2R973.1 UNK2U449.1
S3_0V5: UNK3C286.1 UNK3C288.1 UNK3MK1.4 UNK3MR2.2 UNK3MR3.1 UNK3MR4.1 UNK3MR5.1 UNK3MR6.1 UNK3MU3.3
S3_0V25: UNK3MK4.3 UNK3MR18.2 UNK3MR19.1
S3_0V75: UNK3C290.1 UNK3MK2.4 UNK3MR10.2 UNK3MU3.6
S3_1SPI_CK: UNK3K2.7
S3_1SPI_DI: UNK3K4.7
S3_1SPI_DO: UNK3K4.2
S3_1SPI_HLD: UNK3K6.2
S3_1SPI_WPZ: UNK3K6.7
S3_3V3_RX0_MIPI: UNK3BDB5.2 UNK3C922.2 UNK3R661.2 UNK3U408.A2 UNK3U408.J4
S3_3V3_RX1_MIPI: UNK3BDB6.2 UNK3C923.2 UNK3R663.2 UNK3U409.A2 UNK3U409.J4
S3_3V3_TX0_MIPI: UNK3BDB8.2 UNK3C1090.2 UNK3R1101.2 UNK3U455.A2 UNK3U455.J4
S3_3V3_TX1_MIPI: UNK3BDB7.2 UNK3C1089.2 UNK3R1098.2 UNK3U456.A2 UNK3U456.J4
S3_3V3_USB2_MUX: UNK3BD21.2 UNK3C262.1 UNK3U31.4
S3_3V3_XTAL32K: UNK3BD1728.2 UNK3C1074.1 UNK3R981.1 UNK3U449.10
S3_AWG_3SHARE+: K110.2 UNK3K34.4
S3_B_DCH001: SITE3.M18(VDDP18_LDO_P0) UNK3CC195.1
S3_B_DCH105: SITE3.C12(PAD_RTC_IO4)
S3_B_DCH106: SITE3.D13(PAD_RTC_IO5)
S3_DCH015: SITE3.N1(PAD_AUD_MICCM0)
S3_DCH016: SITE3.L1(PAD_AUD_MICCM1)
S3_DCH017: SITE3.L3(PAD_AUD_LINEOUT_RP)
S3_DCH018: SITE3.L4(PAD_AUD_LINEOUT_RN)
S3_DCH063: SITE3.A17(PAD_PM_SDIO_CLK)
S3_DCH064: SITE3.B16(PAD_PM_SDIO_CMD)
S3_DCH065: SITE3.A18(PAD_PM_SDIO_D0)
S3_DCH066: SITE3.B18(PAD_PM_SDIO_D1)
S3_DCH067: SITE3.B15(PAD_PM_SDIO_D2)
S3_DCH068: SITE3.A15(PAD_PM_SDIO_D3)
S3_DCH069: SITE3.B19(PAD_PM_SDIO_INT)
S3_DCH082: SITE3.D15(PAD_PM_FUART_CTS)
S3_DCH083: SITE3.D16(PAD_PM_FUART_RTS)
S3_DCH088: SITE3.G20(PAD_PM_PWM2)
S3_DCH089: SITE3.H20(PAD_PM_PWM3)
S3_DCH090: SITE3.A21(PAD_PM_SAR_GPIO1)
S3_DCH103: SITE3.E12(PAD_RTC_IO0)
S3_DCH104: SITE3.D12(PAD_RTC_IO1)
S3_DCH107: SITE3.E11(PAD_RESET)
S3_DCH108: UNK3K32.2
S3_DCH109: UNK3K32.7
S3_DCH110: UNK3U449.3
S3_DCH111: UNK3U449.4
S3_DPS3: SITE3.F4(VDDP18_P1) SITE3.F17(AVDD18_NODIE) SITE3.G5(AVDD18_MIPI_TX) SITE3.H4(AVDD18_USB) SITE3.J18(AVDD18_OTP) SITE3.L5(AVDD18_AUD) SITE3.R11(AVDD18_PLL_DDR) SITE3.R14(VDD1_DRAM[0]) SITE3.R15(VDD1_DRAM[1]) UNK3CA20.1 UNK3CA21.1 UNK3CC84.1 UNK3CC85.1 UNK3CC86.1 UNK3CC87.1 UNK3CC88.1 UNK3CC89.1 UNK3CC90.1 UNK3CC91.1 UNK3CC92.1 UNK3SA17.1 UNK3TP_DPS3.1
S3_DPS4: SITE3.H19(AVDD33_ETH) SITE3.J5(AVDD33_USB) UNK3CA34.1 UNK3CA35.1 UNK3CC182.1 UNK3CC202.1 UNK3SA19.1 UNK3TP_DPS4.1
S3_M_2V5: UNK3C284.1 UNK3C285.1 UNK3MR2.1 UNK3MU2.6
S3_M_3V2: UNK3C282.1 UNK3C283.1 UNK3C289.1 UNK3MR1.1 UNK3MU1.5 UNK3MU2.2 UNK3MU3.7
S3_MPDCH01: SITE3.D7(PAD_I2C1_SDA)
S3_MPDCH03+: UNK3U31.2
S3_MPDCH03-: UNK3U31.3
S3_MPDCH05: SITE3.E7(PAD_I2C1_SCL)
S3_MPDCH06: SITE3.T4(PAD_SD0_D1)
S3_MPDCH09: SITE3.E8(PAD_SR_RST0)
S3_MPDCH10: SITE3.D8(PAD_SR_MCLK0)
S3_MPDCH11: SITE3.T3(PAD_SD0_CDZ)
S3_MPDCH13: SITE3.U4(PAD_SD0_D0)
S3_MPDCH14: SITE3.U5(PAD_SD0_CLK)
S3_MPDCH15: SITE3.T6(PAD_SD0_CMD)
S3_MPDCH16: SITE3.U7(PAD_SD0_D3)
S3_MPDCH17: SITE3.T7(PAD_SD0_D2)
S3_MPDCH18: SITE3.U20(PAD_FUART_RX)
S3_MPDCH19: SITE3.U21(PAD_FUART_TX)
S3_MPDCH20: SITE3.U18(PAD_FUART_RTS)
S3_MPDCH21: SITE3.R2(PAD_GPIO0)
S3_MPDCH22: SITE3.P6(PAD_GPIO5)
S3_MPDCH23: SITE3.R3(PAD_GPIO1)
S3_MPDCH24: SITE3.T2(PAD_GPIO10)
S3_MPDCH25: SITE3.R1(PAD_GPIO8)
S3_MPDCH26: SITE3.T1(PAD_GPIO9)
S3_MPDCH27: SITE3.P7(PAD_GPIO6)
S3_MPDCH28: SITE3.P4(PAD_GPIO3)
S3_MPDCH29: SITE3.U2(PAD_GPIO11)
S3_MPDCH30: SITE3.R7(PAD_GPIO7)
S3_MPDCH32: UNK3K2.2
S3_MPDCH33: SITE3.L2(PAD_AUD_MICIN1)
S3_MPDCH34: SITE3.M3(PAD_AUD_VAG) UNK3C264.1
S3_MPDCH35: SITE3.N2(PAD_AUD_MICIN0)
S3_MPDCH36: SITE3.L20(PAD_I2C0_SDA)
S3_MPDCH37+: UNK3U408.B8
S3_MPDCH37-: UNK3U408.B9
S3_MPDCH38+: UNK3U455.B8
S3_MPDCH38-: UNK3U455.B9
S3_MPDCH39+: UNK3U408.D8
S3_MPDCH39-: UNK3U408.D9
S3_MPDCH40+: UNK3U455.D8
S3_MPDCH40-: UNK3U455.D9
S3_MPDCH41+: UNK3U408.E8
S3_MPDCH41-: UNK3U408.E9
S3_MPDCH42+: UNK3U455.E8
S3_MPDCH42-: UNK3U455.E9
S3_MPDCH43+: UNK3U409.B8
S3_MPDCH43-: UNK3U409.B9
S3_MPDCH44+: UNK3U456.B8
S3_MPDCH44-: UNK3U456.B9
S3_MPDCH45+: UNK3U409.D8
S3_MPDCH45-: UNK3U409.D9
S3_MPDCH46+: UNK3U456.D8
S3_MPDCH46-: UNK3U456.D9
S3_MPDCH47+: UNK3U409.E8
S3_MPDCH47-: UNK3U409.E9
S3_MPDCH49: SITE3.E5(PAD_SR_RST1)
S3_MPDCH50: SITE3.D5(PAD_SR_MCLK1)
S3_MPDCH51: SITE3.T18(PAD_FUART_CTS)
S3_MPDCH52: SITE3.T19(PAD_MSPI0_CZ)
S3_MPDCH53: SITE3.R4(PAD_GPIO2)
S3_MPDCH54: SITE3.P5(PAD_GPIO4)
S3_MPDCH55: SITE3.D4(PAD_I2C2_SCL)
S3_MPDCH56: SITE3.E4(PAD_I2C2_SDA)
S3_MPDCH57: SITE3.N19(PAD_MSPI0_CK)
S3_MPDCH58: SITE3.P19(PAD_MSPI0_DI)
S3_MPDCH59: SITE3.R19(PAD_MSPI0_DO)
S3_MPDCH60: SITE3.M20(PAD_I2C0_SCL)
S3_MPDCH61: SITE3.G21(PAD_PM_UART_RX)
S3_MPDCH62: SITE3.H22(PAD_PM_UART_TX)
S3_MPDCH63: SITE3.C19(PAD_PM_I2C_SDA)
S3_MPDCH64: SITE3.D19(PAD_PM_I2C_SCL)
S3_MPDCH65: SITE3.B22(PAD_PM_GPIO5)
S3_MPDCH66: SITE3.C22(PAD_PM_GPIO6)
S3_MPDCH68: SITE3.B21(PAD_PM_GPIO4)
S3_MPDCH69: SITE3.F19(PAD_PM_PWM1)
S3_MPDCH71: SITE3.H21(PAD_PM_GPIO11)
S3_MPDCH72: SITE3.E15(PAD_PM_FUART_RX)
S3_MPDCH73: SITE3.E18(PAD_PM_GPIO2)
S3_MPDCH74: SITE3.D18(PAD_PM_GPIO3)
S3_MPDCH75: SITE3.E22(PAD_PM_PSPI0_DO)
S3_MPDCH76: SITE3.F22(PAD_PM_PSPI0_DI)
S3_MPDCH77: SITE3.E19(PAD_PM_PWM0)
S3_MPDCH78: SITE3.C20(PAD_PM_UART2_RX)
S3_MPDCH79: SITE3.D20(PAD_PM_UART2_TX)
S3_MPDCH80: SITE3.E21(PAD_PM_PSPI0_CK)
S3_MPDCH81: SITE3.D21(PAD_PM_PSPI0_CZ)
S3_MPDCH84: SITE3.F21(PAD_PM_PSPI0_INT)
S3_MPDCH85: SITE3.E17(PAD_PM_GPIO1)
S3_MPDCH86: SITE3.C16(PAD_PM_GPIO0)
S3_MPDCH87: SITE3.E14(PAD_PM_FUART_TX)
S3_MPDCH88: UNK3K34.2
S3_MUX_3V3: UNK3BD21.1 UNK3BD1728.1 UNK3R234.2 UNK3R512.1 UNK3R1117.2 UNK3R1118.2 UNK3R1119.2
S3_OUT_RX0_CH0_ABC_CASE+: SITE3.B10(PAD_OUTP_RX0_CH[0]) UNK3U408.B2
S3_OUT_RX0_CH0_ABC_CASE-: SITE3.A10(PAD_OUTN_RX0_CH[0]) UNK3U408.B1
S3_OUT_RX0_CH0_B_CASE+: UNK3R647.1 UNK3U408.B4
S3_OUT_RX0_CH0_B_CASE-: UNK3R646.1 UNK3U408.A4
S3_OUT_RX0_CH0_C_CASE: UNK3C309.1 UNK3R646.2 UNK3R647.2
S3_OUT_RX0_CH1_ABC_CASE+: SITE3.B9(PAD_OUTP_RX0_CH[1]) UNK3U408.D2
S3_OUT_RX0_CH1_ABC_CASE-: SITE3.B8(PAD_OUTN_RX0_CH[1]) UNK3U408.D1
S3_OUT_RX0_CH1_B_CASE+: UNK3R168.1 UNK3U408.B5
S3_OUT_RX0_CH1_B_CASE-: UNK3R170.1 UNK3U408.A5
S3_OUT_RX0_CH1_C_CASE: UNK3C310.1 UNK3R168.2 UNK3R170.2
S3_OUT_RX0_CH2_ABC_CASE+: SITE3.A8(PAD_OUTP_RX0_CH[2]) UNK3U408.E2
S3_OUT_RX0_CH2_ABC_CASE-: SITE3.B7(PAD_OUTN_RX0_CH[2]) UNK3U408.E1
S3_OUT_RX0_CH2_B_CASE+: UNK3R176.1 UNK3U408.B6
S3_OUT_RX0_CH2_B_CASE-: UNK3R178.1 UNK3U408.A6
S3_OUT_RX0_CH2_C_CASE: UNK3C318.1 UNK3R176.2 UNK3R178.2
S3_OUT_RX0_CH3_ABC_CASE+: SITE3.B6(PAD_OUTP_RX0_CH[3]) UNK3U409.B2
S3_OUT_RX0_CH3_ABC_CASE-: SITE3.A6(PAD_OUTN_RX0_CH[3]) UNK3U409.B1
S3_OUT_RX0_CH3_B_CASE+: UNK3R1089.1 UNK3U409.B4
S3_OUT_RX0_CH3_B_CASE-: UNK3R1088.1 UNK3U409.A4
S3_OUT_RX0_CH3_C_CASE: UNK3C302.1 UNK3R1088.2 UNK3R1089.2
S3_OUT_RX0_CH4_ABC_CASE+: SITE3.B5(PAD_OUTP_RX0_CH[4]) UNK3U409.D2
S3_OUT_RX0_CH4_ABC_CASE-: SITE3.B4(PAD_OUTN_RX0_CH[4]) UNK3U409.D1
S3_OUT_RX0_CH4_B_CASE+: UNK3R180.1 UNK3U409.B5
S3_OUT_RX0_CH4_B_CASE-: UNK3R182.1 UNK3U409.A5
S3_OUT_RX0_CH4_C_CASE: UNK3C320.1 UNK3R180.2 UNK3R182.2
S3_OUT_RX0_CH5_ABC_CASE+: SITE3.A4(PAD_OUTP_RX0_CH[5]) UNK3U409.E2
S3_OUT_RX0_CH5_ABC_CASE-: SITE3.B3(PAD_OUTN_RX0_CH[5]) UNK3U409.E1
S3_OUT_RX0_CH5_B_CASE+: UNK3R666.1 UNK3U409.B6
S3_OUT_RX0_CH5_B_CASE-: UNK3R664.1 UNK3U409.A6
S3_OUT_RX0_CH5_C_CASE: UNK3C924.1 UNK3R664.2 UNK3R666.2
S3_OUT_TX0_CH0_ABC_CASE+: SITE3.A2(PAD_OUTP_TX0_CH[0]) UNK3U455.B2
S3_OUT_TX0_CH0_ABC_CASE-: SITE3.B1(PAD_OUTN_TX0_CH[0]) UNK3U455.B1
S3_OUT_TX0_CH0_B_CASE+: UNK3R1109.1 UNK3U455.B4
S3_OUT_TX0_CH0_B_CASE-: UNK3R1107.1 UNK3U455.A4
S3_OUT_TX0_CH0_C_CASE: UNK3C1086.1 UNK3R1107.2 UNK3R1109.2
S3_OUT_TX0_CH1_ABC_CASE+: SITE3.C1(PAD_OUTP_TX0_CH[1]) UNK3U455.D2
S3_OUT_TX0_CH1_ABC_CASE-: SITE3.C2(PAD_OUTN_TX0_CH[1]) UNK3U455.D1
S3_OUT_TX0_CH1_B_CASE+: UNK3R1099.1 UNK3U455.B5
S3_OUT_TX0_CH1_B_CASE-: UNK3R1100.1 UNK3U455.A5
S3_OUT_TX0_CH1_C_CASE: UNK3C1087.1 UNK3R1099.2 UNK3R1100.2
S3_OUT_TX0_CH2_ABC_CASE+: SITE3.D2(PAD_OUTP_TX0_CH[2]) UNK3U455.E2
S3_OUT_TX0_CH2_ABC_CASE-: SITE3.E1(PAD_OUTN_TX0_CH[2]) UNK3U455.E1
S3_OUT_TX0_CH2_B_CASE+: UNK3R1106.1 UNK3U455.B6
S3_OUT_TX0_CH2_B_CASE-: UNK3R1103.1 UNK3U455.A6
S3_OUT_TX0_CH2_C_CASE: UNK3C1088.1 UNK3R1103.2 UNK3R1106.2
S3_OUT_TX0_CH3_ABC_CASE+: SITE3.E2(PAD_OUTP_TX0_CH[3]) UNK3U456.B2
S3_OUT_TX0_CH3_ABC_CASE-: SITE3.F2(PAD_OUTN_TX0_CH[3]) UNK3U456.B1
S3_OUT_TX0_CH3_B_CASE+: UNK3R1115.1 UNK3U456.B4
S3_OUT_TX0_CH3_B_CASE-: UNK3R1114.1 UNK3U456.A4
S3_OUT_TX0_CH3_C_CASE: UNK3C1093.1 UNK3R1114.2 UNK3R1115.2
S3_OUT_TX0_CH4_ABC_CASE+: SITE3.G1(PAD_OUTP_TX0_CH[4]) UNK3U456.D2
S3_OUT_TX0_CH4_ABC_CASE-: SITE3.G2(PAD_OUTN_TX0_CH[4]) UNK3U456.D1
S3_OUT_TX0_CH4_B_CASE+: UNK3R1110.1 UNK3U456.B5
S3_OUT_TX0_CH4_B_CASE-: UNK3R1111.1 UNK3U456.A5
S3_OUT_TX0_CH4_C_CASE: UNK3C1091.1 UNK3R1110.2 UNK3R1111.2
S3_PM_SAR_GPIO0: S3_VREF_OUT.1(TP) SITE3.A20(PAD_PM_SAR_GPIO0) UNK3K34.3 UNK3MK3.4
S3_PWR_F001: SITE3.F15(DVDD_NODIE) UNK3CA26.1 UNK3CA27.1 UNK3CC112.1 UNK3SA16.1 UNK3TP_DPS2.1
S3_PWR_F004: SITE3.E10(AVDD33_RTC) UNK3CA22.1 UNK3CA23.1 UNK3CC96.1 UNK3SA21.1 UNK3TP_DPS5.1
S3_PWR_F005: SITE3.G18(VDDP3318_PM) SITE3.N17(VDDP3318_P0) SITE3.P3(VDDP3318_P2) UNK3CA7.1 UNK3CA8.1 UNK3CC70.1 UNK3CC71.1 UNK3CC73.1 UNK3SA8.1 UNK3TP_DPS6.1
S3_PWR_F006: SITE3.T13(VDD2_DRAM[0]) SITE3.T14(VDD2_DRAM[1]) SITE3.U13(VDD2_DRAM[2]) UNK3CA24.1 UNK3CA25.1 UNK3CC101.1 UNK3CC103.1 UNK3CC105.1 UNK3SA9.1 UNK3TP_DPS7.1
S3_PWR_F007: SITE3.T10(VDDQ_DRAM[0]) SITE3.T11(VDDQ_DRAM[1]) SITE3.U11(VDDQ_DRAM[2]) UNK3CA36.1 UNK3CA37.1 UNK3CC211.1 UNK3CC212.1 UNK3CC213.1 UNK3SA23.1 UNK3TP_DPS8.1
S3_PWR_F008: SITE3.K19(AVDD18_XTAL) UNK3CA38.1 UNK3CA39.1 UNK3CC220.1 UNK3SA25.1 UNK3TP_DPS9.1
S3_PWR_GS001: UNK3SA15.2
S3_PWR_GS002: UNK3SA18.2
S3_PWR_GS003: UNK3SA20.2
S3_PWR_GS004: UNK3SA22.2
S3_PWR_GS005: UNK3SA7.2
S3_PWR_GS006: UNK3SA10.2
S3_PWR_GS007: UNK3SA24.2
S3_PWR_GS008: UNK3SA26.2
S3_PWR_M_F001: SITE3.F6(AVDDL_MIPI_RX) SITE3.F7(VDD_CPU[0]) SITE3.F8(VDD_CPU[1]) SITE3.G6(AVDDL_MIPI_TX) SITE3.G7(VDD_CPU[2]) SITE3.G8(VDD_CPU[3]) SITE3.G10(VDD[0]) SITE3.G11(VDD[1]) SITE3.H7(VDD_CPU[4]) SITE3.H8(VDD_CPU[5]) SITE3.H10(VDD[2]) SITE3.H11(VDD[3]) SITE3.H12(VDD[4]) SITE3.J10(VDD[5]) SITE3.J11(VDD[6]) SITE3.J12(VDD[7]) SITE3.J13(VDD[8]) SITE3.K10(VDD[9]) SITE3.K11(VDD[10]) SITE3.K12(VDD[11]) SITE3.K13(VDD[12]) UNK3CA1.1 UNK3CA2.1 UNK3CC1.1 UNK3CC2.1 UNK3CC3.1 UNK3CC4.1 UNK3CC5.1 UNK3CC6.1 UNK3CC7.1 UNK3CC8.1 UNK3CC9.1 UNK3CC12.1 UNK3CC13.1 UNK3CC14.1 UNK3CC15.1 UNK3CC16.1 UNK3CC130.1 UNK3CC214.1 UNK3CC215.1 UNK3CC216.1 UNK3CC217.1 UNK3CC218.1 UNK3CC219.1 UNK3K96.4 UNK3K96.9 UNK3SA1.1 UNK3TP_DPS1.1
S3_PWR_M_GS001: UNK3SA2.2
S3_PWR_M_S001: UNK3SA1.2
S3_PWR_S001: UNK3SA16.2
S3_PWR_S002: UNK3SA17.2
S3_PWR_S003: UNK3SA19.2
S3_PWR_S004: UNK3SA21.2
S3_PWR_S005: UNK3SA8.2
S3_PWR_S006: UNK3SA9.2
S3_PWR_S007: UNK3SA23.2
S3_PWR_S008: UNK3SA25.2
S3_SPI_CK_ABCD_CASE: SITE3.T22(PAD_SPI_CK) UNK3K2.6
S3_SPI_CK_B_CASE: UNK3K2.5 UNK3K3.6
S3_SPI_CK_C_CASE: UNK3K3.7 UNK3U18.7
S3_SPI_CK_D_CASE: UNK3K3.5 UNK3U19.6
S3_SPI_CZ_ABCD_CASE: SITE3.M21(PAD_SPI_CZ) UNK3K2.3
S3_SPI_CZ_B_CASE: UNK3K2.4 UNK3K3.3
S3_SPI_CZ_C_CASE: UNK3K3.2 UNK3R200.2 UNK3U18.1
S3_SPI_CZ_D_CASE: UNK3K3.4 UNK3R205.2 UNK3U19.1
S3_SPI_DI_ABCD_CASE: SITE3.R21(PAD_SPI_DI) UNK3K4.6
S3_SPI_DI_B_CASE: UNK3K4.5 UNK3K5.6
S3_SPI_DI_C_CASE: UNK3K5.7
S3_SPI_DI_D_CASE: UNK3K5.5 UNK3U19.5
S3_SPI_DO_ABCD_CASE: SITE3.P22(PAD_SPI_DO) UNK3K4.3
S3_SPI_DO_B_CASE: UNK3K4.4 UNK3K5.3
S3_SPI_DO_C_CASE: UNK3K5.2
S3_SPI_DO_D_CASE: UNK3K5.4 UNK3U19.2
S3_SPI_HLD_ABCD_CASE: SITE3.P21(PAD_SPI_HLD) UNK3K6.3
S3_SPI_HLD_B_CASE: UNK3K6.4 UNK3K7.3
S3_SPI_HLD_C_CASE: UNK3K7.2 UNK3R202.1
S3_SPI_HLD_D_CASE: UNK3K7.4 UNK3R206.1 UNK3U19.7
S3_SPI_WPZ_ABCD_CASE: SITE3.N21(PAD_SPI_WPZ) UNK3K6.6
S3_SPI_WPZ_B_CASE: UNK3K6.5 UNK3K7.6
S3_SPI_WPZ_C_CASE: UNK3K7.7 UNK3R203.2 UNK3U18.2
S3_SPI_WPZ_D_CASE: UNK3K7.5 UNK3R207.2 UNK3U19.3
S3_USB2_SEL0: UNK3R164.2 UNK3U31.6
S3_USB2_SEL1: UNK3R163.2 UNK3U31.5
S3_USB2_SELS: UNK3R165.2 UNK3U31.16
S3_USB_D_AB_CASE+: SITE3.J3(PAD_DP_USB) UNK3U31.10
S3_USB_D_AB_CASE-: SITE3.J2(PAD_DM_USB) UNK3U31.9
S3_USB_D_B_CASE+: UNK3R160.2 UNK3U31.8
S3_USB_D_B_CASE-: UNK3R161.2 UNK3U31.7
S3_USER_3V3: S3_USER_3V3.1 UNK3C334.1 UNK3C335.1 UNK3C336.2 UNK3C337.2 UNK3C338.2 UNK3C339.2 UNK3R200.1 UNK3R201.2 UNK3R202.2 UNK3R203.1 UNK3R204.2 UNK3R205.1 UNK3R206.2 UNK3R207.1 UNK3U17.3
S3_XTAL_24M_IN_ABC_CASE: SITE3.L22(PAD_XTAL_IN_24M) UNK3K32.3
S3_XTAL_24M_IN_B_CASE: UNK3K32.4 UNK3R135.1
S3_XTAL_24M_IN_C_CASE: UNK3C267.1 UNK3R135.2 UNK3R136.2 UNK3Y1.3
S3_XTAL_24M_OUT_ABC_CASE: SITE3.K21(PAD_XTAL_OUT_24M) UNK3K32.6
S3_XTAL_24M_OUT_B_CASE: UNK3K32.5 UNK3R137.1
S3_XTAL_24M_OUT_C_CASE: UNK3C268.1 UNK3R136.1 UNK3R137.2 UNK3Y1.1
S3_XTAL_IN_32K_A_CASE: UNK3K29.7 UNK3U449.7
S3_XTAL_IN_32K_ABCD_CASE: SITE3.B13(PAD_XTAL_IN_32K) UNK3K29.6
S3_XTAL_IN_32K_B_CASE: UNK3C271.1 UNK3K29.5 UNK3Y2.1
S3_XTAL_IN_32K_D_CASE: UNK3R923.1 UNK3R973.2 UNK3U449.2
S3_XTAL_OUT_32K_A_CASE: UNK3K29.2 UNK3U449.8
S3_XTAL_OUT_32K_ABCD_CASE: SITE3.A12(PAD_XTAL_OUT_32K) UNK3K29.3
S3_XTAL_OUT_32K_B_CASE: UNK3C272.1 UNK3K29.4 UNK3Y2.2
S3_XTAL_OUT_32K_D_CASE: UNK3R652.1 UNK3R973.1 UNK3U449.1
S4_0V5: UNK4C286.1 UNK4C288.1 UNK4MK1.4 UNK4MR2.2 UNK4MR3.1 UNK4MR4.1 UNK4MR5.1 UNK4MR6.1 UNK4MU3.3
S4_0V25: UNK4MK4.3 UNK4MR18.2 UNK4MR19.1
S4_0V75: UNK4C290.1 UNK4MK2.4 UNK4MR10.2 UNK4MU3.6
S4_1SPI_CK: UNK4K2.7
S4_1SPI_DI: UNK4K4.7
S4_1SPI_DO: UNK4K4.2
S4_1SPI_HLD: UNK4K6.2
S4_1SPI_WPZ: UNK4K6.7
S4_3V3_RX0_MIPI: UNK4BDB5.2 UNK4C922.2 UNK4R661.2 UNK4U408.A2 UNK4U408.J4
S4_3V3_RX1_MIPI: UNK4BDB6.2 UNK4C923.2 UNK4R663.2 UNK4U409.A2 UNK4U409.J4
S4_3V3_TX0_MIPI: UNK4BDB8.2 UNK4C1090.2 UNK4R1101.2 UNK4U455.A2 UNK4U455.J4
S4_3V3_TX1_MIPI: UNK4BDB7.2 UNK4C1089.2 UNK4R1098.2 UNK4U456.A2 UNK4U456.J4
S4_3V3_USB2_MUX: UNK4BD21.2 UNK4C262.1 UNK4U31.4
S4_3V3_XTAL32K: UNK4BD1728.2 UNK4C1074.1 UNK4R981.1 UNK4U449.10
S4_AWG_3SHARE+: K110.7 UNK4K34.4
S4_B_DCH001: SITE4.M18(VDDP18_LDO_P0) UNK4CC195.1
S4_B_DCH105: SITE4.C12(PAD_RTC_IO4)
S4_B_DCH106: SITE4.D13(PAD_RTC_IO5)
S4_DCH015: SITE4.N1(PAD_AUD_MICCM0)
S4_DCH016: SITE4.L1(PAD_AUD_MICCM1)
S4_DCH017: SITE4.L3(PAD_AUD_LINEOUT_RP)
S4_DCH018: SITE4.L4(PAD_AUD_LINEOUT_RN)
S4_DCH063: SITE4.A17(PAD_PM_SDIO_CLK)
S4_DCH064: SITE4.B16(PAD_PM_SDIO_CMD)
S4_DCH065: SITE4.A18(PAD_PM_SDIO_D0)
S4_DCH066: SITE4.B18(PAD_PM_SDIO_D1)
S4_DCH067: SITE4.B15(PAD_PM_SDIO_D2)
S4_DCH068: SITE4.A15(PAD_PM_SDIO_D3)
S4_DCH069: SITE4.B19(PAD_PM_SDIO_INT)
S4_DCH082: SITE4.D15(PAD_PM_FUART_CTS)
S4_DCH083: SITE4.D16(PAD_PM_FUART_RTS)
S4_DCH088: SITE4.G20(PAD_PM_PWM2)
S4_DCH089: SITE4.H20(PAD_PM_PWM3)
S4_DCH090: SITE4.A21(PAD_PM_SAR_GPIO1)
S4_DCH103: SITE4.E12(PAD_RTC_IO0)
S4_DCH104: SITE4.D12(PAD_RTC_IO1)
S4_DCH107: SITE4.E11(PAD_RESET)
S4_DCH108: UNK4K32.2
S4_DCH109: UNK4K32.7
S4_DCH110: UNK4U449.3
S4_DCH111: UNK4U449.4
S4_DPS3: SITE4.F4(VDDP18_P1) SITE4.F17(AVDD18_NODIE) SITE4.G5(AVDD18_MIPI_TX) SITE4.H4(AVDD18_USB) SITE4.J18(AVDD18_OTP) SITE4.L5(AVDD18_AUD) SITE4.R11(AVDD18_PLL_DDR) SITE4.R14(VDD1_DRAM[0]) SITE4.R15(VDD1_DRAM[1]) UNK4CA20.1 UNK4CA21.1 UNK4CC84.1 UNK4CC85.1 UNK4CC86.1 UNK4CC87.1 UNK4CC88.1 UNK4CC89.1 UNK4CC90.1 UNK4CC91.1 UNK4CC92.1 UNK4SA17.1 UNK4TP_DPS3.1
S4_DPS4: SITE4.H19(AVDD33_ETH) SITE4.J5(AVDD33_USB) UNK4CA34.1 UNK4CA35.1 UNK4CC182.1 UNK4CC202.1 UNK4SA19.1 UNK4TP_DPS4.1
S4_M_2V5: UNK4C284.1 UNK4C285.1 UNK4MR2.1 UNK4MU2.6
S4_M_3V2: UNK4C282.1 UNK4C283.1 UNK4C289.1 UNK4MR1.1 UNK4MU1.5 UNK4MU2.2 UNK4MU3.7
S4_MPDCH01: SITE4.D7(PAD_I2C1_SDA)
S4_MPDCH03+: UNK4U31.2
S4_MPDCH03-: UNK4U31.3
S4_MPDCH05: SITE4.E7(PAD_I2C1_SCL)
S4_MPDCH06: SITE4.T4(PAD_SD0_D1)
S4_MPDCH09: SITE4.E8(PAD_SR_RST0)
S4_MPDCH10: SITE4.D8(PAD_SR_MCLK0)
S4_MPDCH11: SITE4.T3(PAD_SD0_CDZ)
S4_MPDCH13: SITE4.U4(PAD_SD0_D0)
S4_MPDCH14: SITE4.U5(PAD_SD0_CLK)
S4_MPDCH15: SITE4.T6(PAD_SD0_CMD)
S4_MPDCH16: SITE4.U7(PAD_SD0_D3)
S4_MPDCH17: SITE4.T7(PAD_SD0_D2)
S4_MPDCH18: SITE4.U20(PAD_FUART_RX)
S4_MPDCH19: SITE4.U21(PAD_FUART_TX)
S4_MPDCH20: SITE4.U18(PAD_FUART_RTS)
S4_MPDCH21: SITE4.R2(PAD_GPIO0)
S4_MPDCH22: SITE4.P6(PAD_GPIO5)
S4_MPDCH23: SITE4.R3(PAD_GPIO1)
S4_MPDCH24: SITE4.T2(PAD_GPIO10)
S4_MPDCH25: SITE4.R1(PAD_GPIO8)
S4_MPDCH26: SITE4.T1(PAD_GPIO9)
S4_MPDCH27: SITE4.P7(PAD_GPIO6)
S4_MPDCH28: SITE4.P4(PAD_GPIO3)
S4_MPDCH29: SITE4.U2(PAD_GPIO11)
S4_MPDCH30: SITE4.R7(PAD_GPIO7)
S4_MPDCH32: UNK4K2.2
S4_MPDCH33: SITE4.L2(PAD_AUD_MICIN1)
S4_MPDCH34: SITE4.M3(PAD_AUD_VAG) UNK4C264.1
S4_MPDCH35: SITE4.N2(PAD_AUD_MICIN0)
S4_MPDCH36: SITE4.L20(PAD_I2C0_SDA)
S4_MPDCH37+: UNK4U408.B8
S4_MPDCH37-: UNK4U408.B9
S4_MPDCH38+: UNK4U455.B8
S4_MPDCH38-: UNK4U455.B9
S4_MPDCH39+: UNK4U408.D8
S4_MPDCH39-: UNK4U408.D9
S4_MPDCH40+: UNK4U455.D8
S4_MPDCH40-: UNK4U455.D9
S4_MPDCH41+: UNK4U408.E8
S4_MPDCH41-: UNK4U408.E9
S4_MPDCH42+: UNK4U455.E8
S4_MPDCH42-: UNK4U455.E9
S4_MPDCH43+: UNK4U409.B8
S4_MPDCH43-: UNK4U409.B9
S4_MPDCH44+: UNK4U456.B8
S4_MPDCH44-: UNK4U456.B9
S4_MPDCH45+: UNK4U409.D8
S4_MPDCH45-: UNK4U409.D9
S4_MPDCH46+: UNK4U456.D8
S4_MPDCH46-: UNK4U456.D9
S4_MPDCH47+: UNK4U409.E8
S4_MPDCH47-: UNK4U409.E9
S4_MPDCH49: SITE4.E5(PAD_SR_RST1)
S4_MPDCH50: SITE4.D5(PAD_SR_MCLK1)
S4_MPDCH51: SITE4.T18(PAD_FUART_CTS)
S4_MPDCH52: SITE4.T19(PAD_MSPI0_CZ)
S4_MPDCH53: SITE4.R4(PAD_GPIO2)
S4_MPDCH54: SITE4.P5(PAD_GPIO4)
S4_MPDCH55: SITE4.D4(PAD_I2C2_SCL)
S4_MPDCH56: SITE4.E4(PAD_I2C2_SDA)
S4_MPDCH57: SITE4.N19(PAD_MSPI0_CK)
S4_MPDCH58: SITE4.P19(PAD_MSPI0_DI)
S4_MPDCH59: SITE4.R19(PAD_MSPI0_DO)
S4_MPDCH60: SITE4.M20(PAD_I2C0_SCL)
S4_MPDCH61: SITE4.G21(PAD_PM_UART_RX)
S4_MPDCH62: SITE4.H22(PAD_PM_UART_TX)
S4_MPDCH63: SITE4.C19(PAD_PM_I2C_SDA)
S4_MPDCH64: SITE4.D19(PAD_PM_I2C_SCL)
S4_MPDCH65: SITE4.B22(PAD_PM_GPIO5)
S4_MPDCH66: SITE4.C22(PAD_PM_GPIO6)
S4_MPDCH68: SITE4.B21(PAD_PM_GPIO4)
S4_MPDCH69: SITE4.F19(PAD_PM_PWM1)
S4_MPDCH71: SITE4.H21(PAD_PM_GPIO11)
S4_MPDCH72: SITE4.E15(PAD_PM_FUART_RX)
S4_MPDCH73: SITE4.E18(PAD_PM_GPIO2)
S4_MPDCH74: SITE4.D18(PAD_PM_GPIO3)
S4_MPDCH75: SITE4.E22(PAD_PM_PSPI0_DO)
S4_MPDCH76: SITE4.F22(PAD_PM_PSPI0_DI)
S4_MPDCH77: SITE4.E19(PAD_PM_PWM0)
S4_MPDCH78: SITE4.C20(PAD_PM_UART2_RX)
S4_MPDCH79: SITE4.D20(PAD_PM_UART2_TX)
S4_MPDCH80: SITE4.E21(PAD_PM_PSPI0_CK)
S4_MPDCH81: SITE4.D21(PAD_PM_PSPI0_CZ)
S4_MPDCH84: SITE4.F21(PAD_PM_PSPI0_INT)
S4_MPDCH85: SITE4.E17(PAD_PM_GPIO1)
S4_MPDCH86: SITE4.C16(PAD_PM_GPIO0)
S4_MPDCH87: SITE4.E14(PAD_PM_FUART_TX)
S4_MPDCH88: UNK4K34.2
S4_MUX_3V3: UNK4BD21.1 UNK4BD1728.1 UNK4R234.2 UNK4R512.1 UNK4R1117.2 UNK4R1118.2 UNK4R1119.2
S4_OUT_RX0_CH0_ABC_CASE+: SITE4.B10(PAD_OUTP_RX0_CH[0]) UNK4U408.B2
S4_OUT_RX0_CH0_ABC_CASE-: SITE4.A10(PAD_OUTN_RX0_CH[0]) UNK4U408.B1
S4_OUT_RX0_CH0_B_CASE+: UNK4R647.1 UNK4U408.B4
S4_OUT_RX0_CH0_B_CASE-: UNK4R646.1 UNK4U408.A4
S4_OUT_RX0_CH0_C_CASE: UNK4C309.1 UNK4R646.2 UNK4R647.2
S4_OUT_RX0_CH1_ABC_CASE+: SITE4.B9(PAD_OUTP_RX0_CH[1]) UNK4U408.D2
S4_OUT_RX0_CH1_ABC_CASE-: SITE4.B8(PAD_OUTN_RX0_CH[1]) UNK4U408.D1
S4_OUT_RX0_CH1_B_CASE+: UNK4R168.1 UNK4U408.B5
S4_OUT_RX0_CH1_B_CASE-: UNK4R170.1 UNK4U408.A5
S4_OUT_RX0_CH1_C_CASE: UNK4C310.1 UNK4R168.2 UNK4R170.2
S4_OUT_RX0_CH2_ABC_CASE+: SITE4.A8(PAD_OUTP_RX0_CH[2]) UNK4U408.E2
S4_OUT_RX0_CH2_ABC_CASE-: SITE4.B7(PAD_OUTN_RX0_CH[2]) UNK4U408.E1
S4_OUT_RX0_CH2_B_CASE+: UNK4R176.1 UNK4U408.B6
S4_OUT_RX0_CH2_B_CASE-: UNK4R178.1 UNK4U408.A6
S4_OUT_RX0_CH2_C_CASE: UNK4C318.1 UNK4R176.2 UNK4R178.2
S4_OUT_RX0_CH3_ABC_CASE+: SITE4.B6(PAD_OUTP_RX0_CH[3]) UNK4U409.B2
S4_OUT_RX0_CH3_ABC_CASE-: SITE4.A6(PAD_OUTN_RX0_CH[3]) UNK4U409.B1
S4_OUT_RX0_CH3_B_CASE+: UNK4R1089.1 UNK4U409.B4
S4_OUT_RX0_CH3_B_CASE-: UNK4R1088.1 UNK4U409.A4
S4_OUT_RX0_CH3_C_CASE: UNK4C302.1 UNK4R1088.2 UNK4R1089.2
S4_OUT_RX0_CH4_ABC_CASE+: SITE4.B5(PAD_OUTP_RX0_CH[4]) UNK4U409.D2
S4_OUT_RX0_CH4_ABC_CASE-: SITE4.B4(PAD_OUTN_RX0_CH[4]) UNK4U409.D1
S4_OUT_RX0_CH4_B_CASE+: UNK4R180.1 UNK4U409.B5
S4_OUT_RX0_CH4_B_CASE-: UNK4R182.1 UNK4U409.A5
S4_OUT_RX0_CH4_C_CASE: UNK4C320.1 UNK4R180.2 UNK4R182.2
S4_OUT_RX0_CH5_ABC_CASE+: SITE4.A4(PAD_OUTP_RX0_CH[5]) UNK4U409.E2
S4_OUT_RX0_CH5_ABC_CASE-: SITE4.B3(PAD_OUTN_RX0_CH[5]) UNK4U409.E1
S4_OUT_RX0_CH5_B_CASE+: UNK4R666.1 UNK4U409.B6
S4_OUT_RX0_CH5_B_CASE-: UNK4R664.1 UNK4U409.A6
S4_OUT_RX0_CH5_C_CASE: UNK4C924.1 UNK4R664.2 UNK4R666.2
S4_OUT_TX0_CH0_ABC_CASE+: SITE4.A2(PAD_OUTP_TX0_CH[0]) UNK4U455.B2
S4_OUT_TX0_CH0_ABC_CASE-: SITE4.B1(PAD_OUTN_TX0_CH[0]) UNK4U455.B1
S4_OUT_TX0_CH0_B_CASE+: UNK4R1109.1 UNK4U455.B4
S4_OUT_TX0_CH0_B_CASE-: UNK4R1107.1 UNK4U455.A4
S4_OUT_TX0_CH0_C_CASE: UNK4C1086.1 UNK4R1107.2 UNK4R1109.2
S4_OUT_TX0_CH1_ABC_CASE+: SITE4.C1(PAD_OUTP_TX0_CH[1]) UNK4U455.D2
S4_OUT_TX0_CH1_ABC_CASE-: SITE4.C2(PAD_OUTN_TX0_CH[1]) UNK4U455.D1
S4_OUT_TX0_CH1_B_CASE+: UNK4R1099.1 UNK4U455.B5
S4_OUT_TX0_CH1_B_CASE-: UNK4R1100.1 UNK4U455.A5
S4_OUT_TX0_CH1_C_CASE: UNK4C1087.1 UNK4R1099.2 UNK4R1100.2
S4_OUT_TX0_CH2_ABC_CASE+: SITE4.D2(PAD_OUTP_TX0_CH[2]) UNK4U455.E2
S4_OUT_TX0_CH2_ABC_CASE-: SITE4.E1(PAD_OUTN_TX0_CH[2]) UNK4U455.E1
S4_OUT_TX0_CH2_B_CASE+: UNK4R1106.1 UNK4U455.B6
S4_OUT_TX0_CH2_B_CASE-: UNK4R1103.1 UNK4U455.A6
S4_OUT_TX0_CH2_C_CASE: UNK4C1088.1 UNK4R1103.2 UNK4R1106.2
S4_OUT_TX0_CH3_ABC_CASE+: SITE4.E2(PAD_OUTP_TX0_CH[3]) UNK4U456.B2
S4_OUT_TX0_CH3_ABC_CASE-: SITE4.F2(PAD_OUTN_TX0_CH[3]) UNK4U456.B1
S4_OUT_TX0_CH3_B_CASE+: UNK4R1115.1 UNK4U456.B4
S4_OUT_TX0_CH3_B_CASE-: UNK4R1114.1 UNK4U456.A4
S4_OUT_TX0_CH3_C_CASE: UNK4C1093.1 UNK4R1114.2 UNK4R1115.2
S4_OUT_TX0_CH4_ABC_CASE+: SITE4.G1(PAD_OUTP_TX0_CH[4]) UNK4U456.D2
S4_OUT_TX0_CH4_ABC_CASE-: SITE4.G2(PAD_OUTN_TX0_CH[4]) UNK4U456.D1
S4_OUT_TX0_CH4_B_CASE+: UNK4R1110.1 UNK4U456.B5
S4_OUT_TX0_CH4_B_CASE-: UNK4R1111.1 UNK4U456.A5
S4_OUT_TX0_CH4_C_CASE: UNK4C1091.1 UNK4R1110.2 UNK4R1111.2
S4_PM_SAR_GPIO0: S4_VREF_OUT.1(TP) SITE4.A20(PAD_PM_SAR_GPIO0) UNK4K34.3 UNK4MK3.4
S4_PWR_F001: SITE4.F15(DVDD_NODIE) UNK4CA26.1 UNK4CA27.1 UNK4CC112.1 UNK4SA16.1 UNK4TP_DPS2.1
S4_PWR_F004: SITE4.E10(AVDD33_RTC) UNK4CA22.1 UNK4CA23.1 UNK4CC96.1 UNK4SA21.1 UNK4TP_DPS5.1
S4_PWR_F005: SITE4.G18(VDDP3318_PM) SITE4.N17(VDDP3318_P0) SITE4.P3(VDDP3318_P2) UNK4CA7.1 UNK4CA8.1 UNK4CC70.1 UNK4CC71.1 UNK4CC73.1 UNK4SA8.1 UNK4TP_DPS6.1
S4_PWR_F006: SITE4.T13(VDD2_DRAM[0]) SITE4.T14(VDD2_DRAM[1]) SITE4.U13(VDD2_DRAM[2]) UNK4CA24.1 UNK4CA25.1 UNK4CC101.1 UNK4CC103.1 UNK4CC105.1 UNK4SA9.1 UNK4TP_DPS7.1
S4_PWR_F007: SITE4.T10(VDDQ_DRAM[0]) SITE4.T11(VDDQ_DRAM[1]) SITE4.U11(VDDQ_DRAM[2]) UNK4CA36.1 UNK4CA37.1 UNK4CC211.1 UNK4CC212.1 UNK4CC213.1 UNK4SA23.1 UNK4TP_DPS8.1
S4_PWR_F008: SITE4.K19(AVDD18_XTAL) UNK4CA38.1 UNK4CA39.1 UNK4CC220.1 UNK4SA25.1 UNK4TP_DPS9.1
S4_PWR_GS001: UNK4SA15.2
S4_PWR_GS002: UNK4SA18.2
S4_PWR_GS003: UNK4SA20.2
S4_PWR_GS004: UNK4SA22.2
S4_PWR_GS005: UNK4SA7.2
S4_PWR_GS006: UNK4SA10.2
S4_PWR_GS007: UNK4SA24.2
S4_PWR_GS008: UNK4SA26.2
S4_PWR_M_F001: SITE4.F6(AVDDL_MIPI_RX) SITE4.F7(VDD_CPU[0]) SITE4.F8(VDD_CPU[1]) SITE4.G6(AVDDL_MIPI_TX) SITE4.G7(VDD_CPU[2]) SITE4.G8(VDD_CPU[3]) SITE4.G10(VDD[0]) SITE4.G11(VDD[1]) SITE4.H7(VDD_CPU[4]) SITE4.H8(VDD_CPU[5]) SITE4.H10(VDD[2]) SITE4.H11(VDD[3]) SITE4.H12(VDD[4]) SITE4.J10(VDD[5]) SITE4.J11(VDD[6]) SITE4.J12(VDD[7]) SITE4.J13(VDD[8]) SITE4.K10(VDD[9]) SITE4.K11(VDD[10]) SITE4.K12(VDD[11]) SITE4.K13(VDD[12]) UNK4CA1.1 UNK4CA2.1 UNK4CC1.1 UNK4CC2.1 UNK4CC3.1 UNK4CC4.1 UNK4CC5.1 UNK4CC6.1 UNK4CC7.1 UNK4CC8.1 UNK4CC9.1 UNK4CC12.1 UNK4CC13.1 UNK4CC14.1 UNK4CC15.1 UNK4CC16.1 UNK4CC130.1 UNK4CC214.1 UNK4CC215.1 UNK4CC216.1 UNK4CC217.1 UNK4CC218.1 UNK4CC219.1 UNK4K96.4 UNK4K96.9 UNK4SA1.1 UNK4TP_DPS1.1
S4_PWR_M_GS001: UNK4SA2.2
S4_PWR_M_S001: UNK4SA1.2
S4_PWR_S001: UNK4SA16.2
S4_PWR_S002: UNK4SA17.2
S4_PWR_S003: UNK4SA19.2
S4_PWR_S004: UNK4SA21.2
S4_PWR_S005: UNK4SA8.2
S4_PWR_S006: UNK4SA9.2
S4_PWR_S007: UNK4SA23.2
S4_PWR_S008: UNK4SA25.2
S4_SPI_CK_ABCD_CASE: SITE4.T22(PAD_SPI_CK) UNK4K2.6
S4_SPI_CK_B_CASE: UNK4K2.5 UNK4K3.6
S4_SPI_CK_C_CASE: UNK4K3.7 UNK4U18.7
S4_SPI_CK_D_CASE: UNK4K3.5 UNK4U19.6
S4_SPI_CZ_ABCD_CASE: SITE4.M21(PAD_SPI_CZ) UNK4K2.3
S4_SPI_CZ_B_CASE: UNK4K2.4 UNK4K3.3
S4_SPI_CZ_C_CASE: UNK4K3.2 UNK4R200.2 UNK4U18.1
S4_SPI_CZ_D_CASE: UNK4K3.4 UNK4R205.2 UNK4U19.1
S4_SPI_DI_ABCD_CASE: SITE4.R21(PAD_SPI_DI) UNK4K4.6
S4_SPI_DI_B_CASE: UNK4K4.5 UNK4K5.6
S4_SPI_DI_C_CASE: UNK4K5.7
S4_SPI_DI_D_CASE: UNK4K5.5 UNK4U19.5
S4_SPI_DO_ABCD_CASE: SITE4.P22(PAD_SPI_DO) UNK4K4.3
S4_SPI_DO_B_CASE: UNK4K4.4 UNK4K5.3
S4_SPI_DO_C_CASE: UNK4K5.2
S4_SPI_DO_D_CASE: UNK4K5.4 UNK4U19.2
S4_SPI_HLD_ABCD_CASE: SITE4.P21(PAD_SPI_HLD) UNK4K6.3
S4_SPI_HLD_B_CASE: UNK4K6.4 UNK4K7.3
S4_SPI_HLD_C_CASE: UNK4K7.2 UNK4R202.1
S4_SPI_HLD_D_CASE: UNK4K7.4 UNK4R206.1 UNK4U19.7
S4_SPI_WPZ_ABCD_CASE: SITE4.N21(PAD_SPI_WPZ) UNK4K6.6
S4_SPI_WPZ_B_CASE: UNK4K6.5 UNK4K7.6
S4_SPI_WPZ_C_CASE: UNK4K7.7 UNK4R203.2 UNK4U18.2
S4_SPI_WPZ_D_CASE: UNK4K7.5 UNK4R207.2 UNK4U19.3
S4_USB2_SEL0: UNK4R164.2 UNK4U31.6
S4_USB2_SEL1: UNK4R163.2 UNK4U31.5
S4_USB2_SELS: UNK4R165.2 UNK4U31.16
S4_USB_D_AB_CASE+: SITE4.J3(PAD_DP_USB) UNK4U31.10
S4_USB_D_AB_CASE-: SITE4.J2(PAD_DM_USB) UNK4U31.9
S4_USB_D_B_CASE+: UNK4R160.2 UNK4U31.8
S4_USB_D_B_CASE-: UNK4R161.2 UNK4U31.7
S4_USER_3V3: S4_USER_3V3.1 UNK4C334.1 UNK4C335.1 UNK4C336.2 UNK4C337.2 UNK4C338.2 UNK4C339.2 UNK4R200.1 UNK4R201.2 UNK4R202.2 UNK4R203.1 UNK4R204.2 UNK4R205.1 UNK4R206.2 UNK4R207.1 UNK4U17.3
S4_XTAL_24M_IN_ABC_CASE: SITE4.L22(PAD_XTAL_IN_24M) UNK4K32.3
S4_XTAL_24M_IN_B_CASE: UNK4K32.4 UNK4R135.1
S4_XTAL_24M_IN_C_CASE: UNK4C267.1 UNK4R135.2 UNK4R136.2 UNK4Y1.3
S4_XTAL_24M_OUT_ABC_CASE: SITE4.K21(PAD_XTAL_OUT_24M) UNK4K32.6
S4_XTAL_24M_OUT_B_CASE: UNK4K32.5 UNK4R137.1
S4_XTAL_24M_OUT_C_CASE: UNK4C268.1 UNK4R136.1 UNK4R137.2 UNK4Y1.1
S4_XTAL_IN_32K_A_CASE: UNK4K29.7 UNK4U449.7
S4_XTAL_IN_32K_ABCD_CASE: SITE4.B13(PAD_XTAL_IN_32K) UNK4K29.6
S4_XTAL_IN_32K_B_CASE: UNK4C271.1 UNK4K29.5 UNK4Y2.1
S4_XTAL_IN_32K_D_CASE: UNK4R923.1 UNK4R973.2 UNK4U449.2
S4_XTAL_OUT_32K_A_CASE: UNK4K29.2 UNK4U449.8
S4_XTAL_OUT_32K_ABCD_CASE: SITE4.A12(PAD_XTAL_OUT_32K) UNK4K29.3
S4_XTAL_OUT_32K_B_CASE: UNK4C272.1 UNK4K29.4 UNK4Y2.2
S4_XTAL_OUT_32K_D_CASE: UNK4R652.1 UNK4R973.1 UNK4U449.1
S5_0V5: UNK5C286.1 UNK5C288.1 UNK5MK1.4 UNK5MR2.2 UNK5MR3.1 UNK5MR4.1 UNK5MR5.1 UNK5MR6.1 UNK5MU3.3
S5_0V25: UNK5MK4.3 UNK5MR18.2 UNK5MR19.1
S5_0V75: UNK5C290.1 UNK5MK2.4 UNK5MR10.2 UNK5MU3.6
S5_1SPI_CK: UNK5K2.7
S5_1SPI_DI: UNK5K4.7
S5_1SPI_DO: UNK5K4.2
S5_1SPI_HLD: UNK5K6.2
S5_1SPI_WPZ: UNK5K6.7
S5_3V3_RX0_MIPI: UNK5BDB5.2 UNK5C922.2 UNK5R661.2 UNK5U408.A2 UNK5U408.J4
S5_3V3_RX1_MIPI: UNK5BDB6.2 UNK5C923.2 UNK5R663.2 UNK5U409.A2 UNK5U409.J4
S5_3V3_TX0_MIPI: UNK5BDB8.2 UNK5C1090.2 UNK5R1101.2 UNK5U455.A2 UNK5U455.J4
S5_3V3_TX1_MIPI: UNK5BDB7.2 UNK5C1089.2 UNK5R1098.2 UNK5U456.A2 UNK5U456.J4
S5_3V3_USB2_MUX: UNK5BD21.2 UNK5C262.1 UNK5U31.4
S5_3V3_XTAL32K: UNK5BD1728.2 UNK5C1074.1 UNK5R981.1 UNK5U449.10
S5_AWG_3SHARE+: K109.4 UNK5K34.4
S5_B_DCH001: SITE5.M18(VDDP18_LDO_P0) UNK5CC195.1
S5_B_DCH105: SITE5.C12(PAD_RTC_IO4)
S5_B_DCH106: SITE5.D13(PAD_RTC_IO5)
S5_DCH015: SITE5.N1(PAD_AUD_MICCM0)
S5_DCH016: SITE5.L1(PAD_AUD_MICCM1)
S5_DCH017: SITE5.L3(PAD_AUD_LINEOUT_RP)
S5_DCH018: SITE5.L4(PAD_AUD_LINEOUT_RN)
S5_DCH063: SITE5.A17(PAD_PM_SDIO_CLK)
S5_DCH064: SITE5.B16(PAD_PM_SDIO_CMD)
S5_DCH065: SITE5.A18(PAD_PM_SDIO_D0)
S5_DCH066: SITE5.B18(PAD_PM_SDIO_D1)
S5_DCH067: SITE5.B15(PAD_PM_SDIO_D2)
S5_DCH068: SITE5.A15(PAD_PM_SDIO_D3)
S5_DCH069: SITE5.B19(PAD_PM_SDIO_INT)
S5_DCH082: SITE5.D15(PAD_PM_FUART_CTS)
S5_DCH083: SITE5.D16(PAD_PM_FUART_RTS)
S5_DCH088: SITE5.G20(PAD_PM_PWM2)
S5_DCH089: SITE5.H20(PAD_PM_PWM3)
S5_DCH090: SITE5.A21(PAD_PM_SAR_GPIO1)
S5_DCH103: SITE5.E12(PAD_RTC_IO0)
S5_DCH104: SITE5.D12(PAD_RTC_IO1)
S5_DCH107: SITE5.E11(PAD_RESET)
S5_DCH108: UNK5K32.2
S5_DCH109: UNK5K32.7
S5_DCH110: UNK5U449.3
S5_DCH111: UNK5U449.4
S5_DPS3: SITE5.F4(VDDP18_P1) SITE5.F17(AVDD18_NODIE) SITE5.G5(AVDD18_MIPI_TX) SITE5.H4(AVDD18_USB) SITE5.J18(AVDD18_OTP) SITE5.L5(AVDD18_AUD) SITE5.R11(AVDD18_PLL_DDR) SITE5.R14(VDD1_DRAM[0]) SITE5.R15(VDD1_DRAM[1]) UNK5CA20.1 UNK5CA21.1 UNK5CC84.1 UNK5CC85.1 UNK5CC86.1 UNK5CC87.1 UNK5CC88.1 UNK5CC89.1 UNK5CC90.1 UNK5CC91.1 UNK5CC92.1 UNK5SA17.1 UNK5TP_DPS3.1
S5_DPS4: SITE5.H19(AVDD33_ETH) SITE5.J5(AVDD33_USB) UNK5CA34.1 UNK5CA35.1 UNK5CC182.1 UNK5CC202.1 UNK5SA19.1 UNK5TP_DPS4.1
S5_M_2V5: UNK5C284.1 UNK5C285.1 UNK5MR2.1 UNK5MU2.6
S5_M_3V2: UNK5C282.1 UNK5C283.1 UNK5C289.1 UNK5MR1.1 UNK5MU1.5 UNK5MU2.2 UNK5MU3.7
S5_MPDCH01: SITE5.D7(PAD_I2C1_SDA)
S5_MPDCH03+: UNK5U31.2
S5_MPDCH03-: UNK5U31.3
S5_MPDCH05: SITE5.E7(PAD_I2C1_SCL)
S5_MPDCH06: SITE5.T4(PAD_SD0_D1)
S5_MPDCH09: SITE5.E8(PAD_SR_RST0)
S5_MPDCH10: SITE5.D8(PAD_SR_MCLK0)
S5_MPDCH11: SITE5.T3(PAD_SD0_CDZ)
S5_MPDCH13: SITE5.U4(PAD_SD0_D0)
S5_MPDCH14: SITE5.U5(PAD_SD0_CLK)
S5_MPDCH15: SITE5.T6(PAD_SD0_CMD)
S5_MPDCH16: SITE5.U7(PAD_SD0_D3)
S5_MPDCH17: SITE5.T7(PAD_SD0_D2)
S5_MPDCH18: SITE5.U20(PAD_FUART_RX)
S5_MPDCH19: SITE5.U21(PAD_FUART_TX)
S5_MPDCH20: SITE5.U18(PAD_FUART_RTS)
S5_MPDCH21: SITE5.R2(PAD_GPIO0)
S5_MPDCH22: SITE5.P6(PAD_GPIO5)
S5_MPDCH23: SITE5.R3(PAD_GPIO1)
S5_MPDCH24: SITE5.T2(PAD_GPIO10)
S5_MPDCH25: SITE5.R1(PAD_GPIO8)
S5_MPDCH26: SITE5.T1(PAD_GPIO9)
S5_MPDCH27: SITE5.P7(PAD_GPIO6)
S5_MPDCH28: SITE5.P4(PAD_GPIO3)
S5_MPDCH29: SITE5.U2(PAD_GPIO11)
S5_MPDCH30: SITE5.R7(PAD_GPIO7)
S5_MPDCH32: UNK5K2.2
S5_MPDCH33: SITE5.L2(PAD_AUD_MICIN1)
S5_MPDCH34: SITE5.M3(PAD_AUD_VAG) UNK5C264.1
S5_MPDCH35: SITE5.N2(PAD_AUD_MICIN0)
S5_MPDCH36: SITE5.L20(PAD_I2C0_SDA)
S5_MPDCH37+: UNK5U408.B8
S5_MPDCH37-: UNK5U408.B9
S5_MPDCH38+: UNK5U455.B8
S5_MPDCH38-: UNK5U455.B9
S5_MPDCH39+: UNK5U408.D8
S5_MPDCH39-: UNK5U408.D9
S5_MPDCH40+: UNK5U455.D8
S5_MPDCH40-: UNK5U455.D9
S5_MPDCH41+: UNK5U408.E8
S5_MPDCH41-: UNK5U408.E9
S5_MPDCH42+: UNK5U455.E8
S5_MPDCH42-: UNK5U455.E9
S5_MPDCH43+: UNK5U409.B8
S5_MPDCH43-: UNK5U409.B9
S5_MPDCH44+: UNK5U456.B8
S5_MPDCH44-: UNK5U456.B9
S5_MPDCH45+: UNK5U409.D8
S5_MPDCH45-: UNK5U409.D9
S5_MPDCH46+: UNK5U456.D8
S5_MPDCH46-: UNK5U456.D9
S5_MPDCH47+: UNK5U409.E8
S5_MPDCH47-: UNK5U409.E9
S5_MPDCH49: SITE5.E5(PAD_SR_RST1)
S5_MPDCH50: SITE5.D5(PAD_SR_MCLK1)
S5_MPDCH51: SITE5.T18(PAD_FUART_CTS)
S5_MPDCH52: SITE5.T19(PAD_MSPI0_CZ)
S5_MPDCH53: SITE5.R4(PAD_GPIO2)
S5_MPDCH54: SITE5.P5(PAD_GPIO4)
S5_MPDCH55: SITE5.D4(PAD_I2C2_SCL)
S5_MPDCH56: SITE5.E4(PAD_I2C2_SDA)
S5_MPDCH57: SITE5.N19(PAD_MSPI0_CK)
S5_MPDCH58: SITE5.P19(PAD_MSPI0_DI)
S5_MPDCH59: SITE5.R19(PAD_MSPI0_DO)
S5_MPDCH60: SITE5.M20(PAD_I2C0_SCL)
S5_MPDCH61: SITE5.G21(PAD_PM_UART_RX)
S5_MPDCH62: SITE5.H22(PAD_PM_UART_TX)
S5_MPDCH63: SITE5.C19(PAD_PM_I2C_SDA)
S5_MPDCH64: SITE5.D19(PAD_PM_I2C_SCL)
S5_MPDCH65: SITE5.B22(PAD_PM_GPIO5)
S5_MPDCH66: SITE5.C22(PAD_PM_GPIO6)
S5_MPDCH68: SITE5.B21(PAD_PM_GPIO4)
S5_MPDCH69: SITE5.F19(PAD_PM_PWM1)
S5_MPDCH71: SITE5.H21(PAD_PM_GPIO11)
S5_MPDCH72: SITE5.E15(PAD_PM_FUART_RX)
S5_MPDCH73: SITE5.E18(PAD_PM_GPIO2)
S5_MPDCH74: SITE5.D18(PAD_PM_GPIO3)
S5_MPDCH75: SITE5.E22(PAD_PM_PSPI0_DO)
S5_MPDCH76: SITE5.F22(PAD_PM_PSPI0_DI)
S5_MPDCH77: SITE5.E19(PAD_PM_PWM0)
S5_MPDCH78: SITE5.C20(PAD_PM_UART2_RX)
S5_MPDCH79: SITE5.D20(PAD_PM_UART2_TX)
S5_MPDCH80: SITE5.E21(PAD_PM_PSPI0_CK)
S5_MPDCH81: SITE5.D21(PAD_PM_PSPI0_CZ)
S5_MPDCH84: SITE5.F21(PAD_PM_PSPI0_INT)
S5_MPDCH85: SITE5.E17(PAD_PM_GPIO1)
S5_MPDCH86: SITE5.C16(PAD_PM_GPIO0)
S5_MPDCH87: SITE5.E14(PAD_PM_FUART_TX)
S5_MPDCH88: UNK5K34.2
S5_MUX_3V3: UNK5BD21.1 UNK5BD1728.1 UNK5R234.2 UNK5R512.1 UNK5R1117.2 UNK5R1118.2 UNK5R1119.2
S5_OUT_RX0_CH0_ABC_CASE+: SITE5.B10(PAD_OUTP_RX0_CH[0]) UNK5U408.B2
S5_OUT_RX0_CH0_ABC_CASE-: SITE5.A10(PAD_OUTN_RX0_CH[0]) UNK5U408.B1
S5_OUT_RX0_CH0_B_CASE+: UNK5R647.1 UNK5U408.B4
S5_OUT_RX0_CH0_B_CASE-: UNK5R646.1 UNK5U408.A4
S5_OUT_RX0_CH0_C_CASE: UNK5C309.1 UNK5R646.2 UNK5R647.2
S5_OUT_RX0_CH1_ABC_CASE+: SITE5.B9(PAD_OUTP_RX0_CH[1]) UNK5U408.D2
S5_OUT_RX0_CH1_ABC_CASE-: SITE5.B8(PAD_OUTN_RX0_CH[1]) UNK5U408.D1
S5_OUT_RX0_CH1_B_CASE+: UNK5R168.1 UNK5U408.B5
S5_OUT_RX0_CH1_B_CASE-: UNK5R170.1 UNK5U408.A5
S5_OUT_RX0_CH1_C_CASE: UNK5C310.1 UNK5R168.2 UNK5R170.2
S5_OUT_RX0_CH2_ABC_CASE+: SITE5.A8(PAD_OUTP_RX0_CH[2]) UNK5U408.E2
S5_OUT_RX0_CH2_ABC_CASE-: SITE5.B7(PAD_OUTN_RX0_CH[2]) UNK5U408.E1
S5_OUT_RX0_CH2_B_CASE+: UNK5R176.1 UNK5U408.B6
S5_OUT_RX0_CH2_B_CASE-: UNK5R178.1 UNK5U408.A6
S5_OUT_RX0_CH2_C_CASE: UNK5C318.1 UNK5R176.2 UNK5R178.2
S5_OUT_RX0_CH3_ABC_CASE+: SITE5.B6(PAD_OUTP_RX0_CH[3]) UNK5U409.B2
S5_OUT_RX0_CH3_ABC_CASE-: SITE5.A6(PAD_OUTN_RX0_CH[3]) UNK5U409.B1
S5_OUT_RX0_CH3_B_CASE+: UNK5R1089.1 UNK5U409.B4
S5_OUT_RX0_CH3_B_CASE-: UNK5R1088.1 UNK5U409.A4
S5_OUT_RX0_CH3_C_CASE: UNK5C302.1 UNK5R1088.2 UNK5R1089.2
S5_OUT_RX0_CH4_ABC_CASE+: SITE5.B5(PAD_OUTP_RX0_CH[4]) UNK5U409.D2
S5_OUT_RX0_CH4_ABC_CASE-: SITE5.B4(PAD_OUTN_RX0_CH[4]) UNK5U409.D1
S5_OUT_RX0_CH4_B_CASE+: UNK5R180.1 UNK5U409.B5
S5_OUT_RX0_CH4_B_CASE-: UNK5R182.1 UNK5U409.A5
S5_OUT_RX0_CH4_C_CASE: UNK5C320.1 UNK5R180.2 UNK5R182.2
S5_OUT_RX0_CH5_ABC_CASE+: SITE5.A4(PAD_OUTP_RX0_CH[5]) UNK5U409.E2
S5_OUT_RX0_CH5_ABC_CASE-: SITE5.B3(PAD_OUTN_RX0_CH[5]) UNK5U409.E1
S5_OUT_RX0_CH5_B_CASE+: UNK5R666.1 UNK5U409.B6
S5_OUT_RX0_CH5_B_CASE-: UNK5R664.1 UNK5U409.A6
S5_OUT_RX0_CH5_C_CASE: UNK5C924.1 UNK5R664.2 UNK5R666.2
S5_OUT_TX0_CH0_ABC_CASE+: SITE5.A2(PAD_OUTP_TX0_CH[0]) UNK5U455.B2
S5_OUT_TX0_CH0_ABC_CASE-: SITE5.B1(PAD_OUTN_TX0_CH[0]) UNK5U455.B1
S5_OUT_TX0_CH0_B_CASE+: UNK5R1109.1 UNK5U455.B4
S5_OUT_TX0_CH0_B_CASE-: UNK5R1107.1 UNK5U455.A4
S5_OUT_TX0_CH0_C_CASE: UNK5C1086.1 UNK5R1107.2 UNK5R1109.2
S5_OUT_TX0_CH1_ABC_CASE+: SITE5.C1(PAD_OUTP_TX0_CH[1]) UNK5U455.D2
S5_OUT_TX0_CH1_ABC_CASE-: SITE5.C2(PAD_OUTN_TX0_CH[1]) UNK5U455.D1
S5_OUT_TX0_CH1_B_CASE+: UNK5R1099.1 UNK5U455.B5
S5_OUT_TX0_CH1_B_CASE-: UNK5R1100.1 UNK5U455.A5
S5_OUT_TX0_CH1_C_CASE: UNK5C1087.1 UNK5R1099.2 UNK5R1100.2
S5_OUT_TX0_CH2_ABC_CASE+: SITE5.D2(PAD_OUTP_TX0_CH[2]) UNK5U455.E2
S5_OUT_TX0_CH2_ABC_CASE-: SITE5.E1(PAD_OUTN_TX0_CH[2]) UNK5U455.E1
S5_OUT_TX0_CH2_B_CASE+: UNK5R1106.1 UNK5U455.B6
