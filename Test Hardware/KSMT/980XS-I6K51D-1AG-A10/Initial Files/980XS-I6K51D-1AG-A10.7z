# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UNK6CC4  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.19 186.26 180 bottom
UNK6CC5  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.16 186.56 90 bottom
UNK6CC6  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.87 184.96 180 bottom
UNK6CC7  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.14 184.96 0 bottom
UNK6CC8  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.5 183.97 270 bottom
UNK6CC9  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.16 183.97 270 bottom
UNK6CC12  0.1U-16-X7S-S2-MU  [C0201_MINI]  269.85 184.62 270 bottom
UNK6CC13  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.24 181.06 180 bottom
UNK6CC14  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.46 185.61 0 bottom
UNK6CC15  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.19 185.61 180 bottom
UNK6CC16  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.84 184.96 180 bottom
UNK6CC70  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.46 182.67 270 bottom
UNK6CC71  0.1U-16-X7S-S2-MU  [C0201_MINI]  275.38 183 0 bottom
UNK6CC73  0.1U-16-X7S-S2-MU  [C0201_MINI]  267.9 182.68 90 bottom
UNK6CC84  0.1U-16-X7S-S2-MU  [C0201_MINI]  273.11 190.48 90 bottom
UNK6CC85  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.15 190.48 90 bottom
UNK6CC86  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.46 190.48 90 bottom
UNK6CC87  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.14 186.26 180 bottom
UNK6CC88  0.1U-16-X7S-S2-MU  [C0201_MINI]  273.11 184 270 bottom
UNK6CC89  0.1U-16-X7S-S2-MU  [C0201_MINI]  267.9 184.66 270 bottom
UNK6CC90  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.8 190.48 90 bottom
UNK6CC91  0.1U-16-X7S-S2-MU  [C0201_MINI]  274.06 183.65 0 bottom
UNK6CC92  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.45 184 270 bottom
UNK6CC96  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.51 187.56 180 bottom
UNK6CC101  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.84 180.4 0 bottom
UNK6CC103  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.81 182.02 90 bottom
UNK6CC105  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.46 180.72 270 bottom
UNK6CC112  0.1U-16-X7S-S2-MU  [C0201_MINI]  275.06 190.48 90 bottom
UNK6CC130  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.24 181.7 180 bottom
UNK6CC182  0.1U-16-X7S-S2-MU  [C0201_MINI]  266.61 190.48 90 bottom
UNK6CC195  4.7U-25-X7R-S8-TY  [C0805]  186.15 484.67 0 top
UNK6CC202  0.1U-16-X7S-S2-MU  [C0201_MINI]  266.28 185.61 180 bottom
UNK6CC211  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.5 182.02 90 bottom
UNK6CC212  0.1U-16-X7S-S2-MU  [C0201_MINI]  269.53 181.06 180 bottom
UNK6CC213  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.16 182.02 90 bottom
UNK6CC214  0.1U-16-X7S-S2-MU  [C0201_MINI]  280.48 484.08 0 top
UNK6CC215  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.81 179.42 90 bottom
UNK6CC216  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.55 178.78 270 bottom
UNK6CC217  0.1U-16-X7S-S2-MU  [C0201_MINI]  143.08 484.08 0 top
UNK6CC218  0.1U-16-X7S-S2-MU  [C0201_MINI]  144.48 484.08 0 top
UNK6CC219  0.1U-16-X7S-S2-MU  [C0201_MINI]  145.88 484.08 0 top
UNK6CC220  0.1U-16-X7S-S2-MU  [C0201_MINI]  147.29 484.08 0 top
UNK6K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  119.04 152.85 90 bottom
UNK6K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  112.69 152.85 90 bottom
UNK6K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  106.34 152.85 90 bottom
UNK6K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  99.99 152.85 90 bottom
UNK6K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  93.64 152.85 90 bottom
UNK6K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  87.29 152.85 90 bottom
UNK6K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  271.94 198.56 90 bottom
UNK6K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  275.73 171.79 270 bottom
UNK6K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  176.53 244.86 90 bottom
UNK6K96  EC2-5NJ  [RL_NECEC2_10P_5V]  255.03 157.73 90 bottom
UNK6MBD1  BD120-1.5A-S4-MU  [FB0402]  278.71 138.77 90 bottom
UNK6MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  275.79 144.74 0 bottom
UNK6MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  275.79 139.4 0 bottom
UNK6MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  275.79 147.28 0 bottom
UNK6MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  275.79 142.07 0 bottom
UNK6MR1  1M-1-S4  [R0402_UNBGA_V2]  265.44 146.59 90 bottom
UNK6MR2  1K-0.01-S4  [R0402_UNBGA_V2]  265.75 135.72 0 bottom
UNK6MR3  1K-0.01-S4  [R0402_UNBGA_V2]  267.84 134.7 0 bottom
UNK6MR4  1K-0.01-S4  [R0402_UNBGA_V2]  267.84 133.69 0 bottom
UNK6MR5  1K-0.01-S4  [R0402_UNBGA_V2]  265.75 133.69 180 bottom
UNK6MR6  1K-0.01-S4  [R0402_UNBGA_V2]  265.75 134.7 180 bottom
UNK6MR7  332K-1-S4  [R0402_UNBGA_V2]  266.45 147.44 270 bottom
UNK6MR8  1K-0.01-S4  [R0402_UNBGA_V2]  277.31 133.69 0 bottom
UNK6MR9  499-0.1-S4  [R0402]  277.31 134.8 0 bottom
UNK6MR10  0-5-S4  [R0402]  277.31 135.92 180 bottom
UNK6MR11  750-1-S4  [R0402]  272.36 144.1 0 bottom
UNK6MR12  360-1-S6  [R0603]  271.98 145.37 0 bottom
UNK6MR13  750-1-S4  [R0402]  272.36 138.77 0 bottom
UNK6MR14  1.2K-1-S4  [R0402]  272.61 146.64 180 bottom
UNK6MR15  360-1-S6  [R0603]  271.98 140.04 0 bottom
UNK6MR16  750-1-S4  [R0402]  272.36 141.43 0 bottom
UNK6MR17  360-1-S6  [R0603]  271.98 142.7 0 bottom
UNK6MR18  11K-0.1-S4  [R0402]  279.85 142.2 90 bottom
UNK6MR19  1K-0.01-S4  [R0402_UNBGA_V2]  278.71 142.2 270 bottom
UNK6MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  268.51 145.44 270 bottom
UNK6MU2  KSMT004-SO8  [SO8_244X127MM]  263.6 141.05 270 bottom
UNK6MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  272.74 135.59 0 bottom
UNK6MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  280.99 138.77 180 bottom
UNK6R135  0-5-S4  [R0402]  278.73 165.44 180 bottom
UNK6R136  1M-1-S4  [R0402]  275.73 165.44 0 bottom
UNK6R137  0-5-S4  [R0402]  272.73 165.44 0 bottom
UNK6R160  38.3-1-S2  [R0201_MINI]  263.52 175.18 0 bottom
UNK6R161  38.3-1-S2  [R0201_MINI]  263.52 174.62 0 bottom
UNK6R162  4.7K-1-S2  [R0201_MINI]  268.01 174.55 90 bottom
UNK6R163  0-5-S2  [R0201_MINI]  263.52 173.14 0 bottom
UNK6R164  0-5-S2  [R0201_MINI]  263.52 174.06 0 bottom
UNK6R165  0-5-S2  [R0201_MINI]  268.01 173.55 90 bottom
UNK6R168  42.2-1-S2  [R0201]  253.99 194.16 90 bottom
UNK6R170  42.2-1-S2  [R0201]  253.29 194.16 90 bottom
UNK6R172  0-5-S2  [R0201]  254.96 192.79 0 top
UNK6R176  42.2-1-S2  [R0201]  251.64 194.16 90 bottom
UNK6R178  42.2-1-S2  [R0201]  252.33 194.16 90 bottom
UNK6R180  42.2-1-S2  [R0201]  253.99 182.6 90 bottom
UNK6R182  42.2-1-S2  [R0201]  253.29 182.6 90 bottom
UNK6R200  4.7K-1-S2  [R0201]  102.68 141.22 180 bottom
UNK6R201  0-5-S4  [R0402]  87.6 141.22 180 bottom
UNK6R202  NC/4.7K-1-S4  [R0402]  87.6 139.95 180 bottom
UNK6R203  4.7K-1-S2  [R0201]  102.68 138.68 180 bottom
UNK6R204  0-5-S4  [R0402]  106.28 141.22 180 bottom
UNK6R205  4.7K-1-S2  [R0201]  122.48 141.22 180 bottom
UNK6R206  NC/4.7K-1-S4  [R0402]  106.28 139.95 180 bottom
UNK6R207  4.7K-1-S2  [R0201]  122.48 138.68 180 bottom
UNK6R234  0-1-S4-YA  [R0402]  459.68 484.22 0 top
UNK6R331  10K-1-S2-WA  [R0201]  280.04 135.77 90 bottom
UNK6R509  0-5-S4  [R0402]  259 204.31 90 bottom
UNK6R510  1.2K-1-S4  [R0402]  264.69 205.11 270 bottom
UNK6R511  523-1-S4  [R0402]  265.19 202.36 0 bottom
UNK6R512  0-5-S8  [R0805]  267.48 206.24 270 bottom
UNK6R646  42.2-1-S2  [R0201]  254.68 194.16 90 bottom
UNK6R647  42.2-1-S2  [R0201]  255.38 194.16 90 bottom
UNK6R652  NC/100K-1-S4  [R0402]  270.85 213.67 90 bottom
UNK6R659  10K-1-S2-WA  [R0201]  253.54 190.99 90 top
UNK6R661  4.7K-1-S2  [R0201]  252.78 190.99 270 top
UNK6R662  0-5-S2  [R0201]  254.96 181.23 0 top
UNK6R663  4.7K-1-S2  [R0201]  252.78 179.42 270 top
UNK6R664  42.2-1-S2  [R0201]  252.33 182.6 90 bottom
UNK6R666  42.2-1-S2  [R0201]  251.64 182.6 90 bottom
UNK6R672  10K-1-S2-WA  [R0201]  253.54 179.42 90 top
UNK6R923  100K-1-S4  [R0402]  272 213.67 90 bottom
UNK6R973  0-5-S4  [R0402]  271.42 212.04 0 bottom
UNK6R980  10K-1-S2-WA  [R0201]  273.66 209.4 90 bottom
UNK6R981  NC/4.7K-1-S2  [R0201]  269.83 209.4 270 bottom
UNK6R982  0-5-S2  [R0201]  269.53 208.44 0 bottom
UNK6R1088  42.2-1-S2  [R0201]  254.68 182.6 90 bottom
UNK6R1089  42.2-1-S2  [R0201]  255.38 182.6 90 bottom
UNK6R1098  4.7K-1-S2  [R0201]  361.29 484.08 0 top
UNK6R1099  42.2-1-S2  [R0201]  293.94 484.08 0 top
UNK6R1100  42.2-1-S2  [R0201]  295.35 484.08 0 top
UNK6R1101  4.7K-1-S2  [R0201]  362.69 484.08 0 top
UNK6R1102  0-5-S2  [R0201]  383.74 484.08 0 top
UNK6R1103  42.2-1-S2  [R0201]  296.75 484.08 0 top
UNK6R1104  0-5-S2  [R0201]  385.14 484.08 0 top
UNK6R1105  10K-1-S2-WA  [R0201]  406.19 484.08 0 top
UNK6R1106  42.2-1-S2  [R0201]  298.15 484.08 0 top
UNK6R1107  42.2-1-S2  [R0201]  299.55 484.08 0 top
UNK6R1108  10K-1-S2-WA  [R0201]  407.59 484.08 0 top
UNK6R1109  42.2-1-S2  [R0201]  533.82 484.08 0 top
UNK6R1110  42.2-1-S2  [R0201]  302.36 484.08 0 top
UNK6R1111  42.2-1-S2  [R0201]  303.76 484.08 0 top
UNK6R1114  42.2-1-S2  [R0201]  305.17 484.08 0 top
UNK6R1115  42.2-1-S2  [R0201]  306.57 484.08 0 top
UNK6R1117  0-1-S4-YA  [R0402]  453.07 484.22 0 top
UNK6R1118  0-1-S4-YA  [R0402]  455.27 484.22 0 top
UNK6R1119  0-1-S4-YA  [R0402]  457.47 484.22 0 top
UNK6SA1  SHORT  [DEFAULT_SHORT_SMALL]  276.06 191.36 0 top
UNK6SA2  SHORT  [DEFAULT_SHORT_SMALL]  276.06 191.87 0 top
UNK6SA7  SHORT  [DEFAULT_SHORT_SMALL]  263.4 185.16 90 top
UNK6SA8  SHORT  [DEFAULT_SHORT_SMALL]  263.91 185.16 90 top
UNK6SA9  SHORT  [DEFAULT_SHORT_SMALL]  274.24 174.5 270 top
UNK6SA10  SHORT  [DEFAULT_SHORT_SMALL]  275.03 174.5 270 top
UNK6SA15  SHORT  [DEFAULT_SHORT_SMALL]  279.49 193.83 90 top
UNK6SA16  SHORT  [DEFAULT_SHORT_SMALL]  278.98 193.83 90 top
UNK6SA17  SHORT  [DEFAULT_SHORT_SMALL]  275.98 191.77 0 top
UNK6SA18  SHORT  [DEFAULT_SHORT_SMALL]  275.98 192.46 0 top
UNK6SA19  SHORT  [DEFAULT_SHORT_SMALL]  264.08 183.68 270 top
UNK6SA20  SHORT  [DEFAULT_SHORT_SMALL]  263.49 183.68 270 top
UNK6SA21  SHORT  [DEFAULT_SHORT_SMALL]  274.54 193.95 0 top
UNK6SA22  SHORT  [DEFAULT_SHORT_SMALL]  274.54 195.43 0 top
UNK6SA23  SHORT  [DEFAULT_SHORT_SMALL]  273.04 174.51 270 top
UNK6SA24  SHORT  [DEFAULT_SHORT_SMALL]  274.32 174.51 270 top
UNK6SA25  SHORT  [DEFAULT_SHORT_SMALL]  505.94 484.3 0 top
UNK6SA26  SHORT  [DEFAULT_SHORT_SMALL]  508.15 484.3 0 top
UNK6TP_DPS1  TP01  [TP_040_T]  260.48 157.07 0 top
UNK6TP_DPS2  TP01  [TP_040_T]  265.3 157.07 180 top
UNK6TP_DPS3  TP01  [TP_040_T]  270.12 153.01 180 top
UNK6TP_DPS4  TP01  [TP_040_T]  284.57 154.53 0 top
UNK6TP_DPS5  TP01  [TP_040_T]  279.75 149.86 0 top
UNK6TP_DPS6  TP01  [TP_040_T]  279.75 154.53 0 top
UNK6TP_DPS7  TP01  [TP_040_T]  260.48 153.01 0 top
UNK6TP_DPS8  TP01  [TP_040_T]  265.3 153.01 180 top
UNK6TP_DPS9  TP01  [TP_040_T]  568.21 484.56 0 top
UNK6TP_MUX_3V3  TP01  [TP_040_T]  255.65 209.49 180 top
UNK6U17  XC6203E-0.4A-33-SOT89  [SOT89]  104.66 131.99 180 bottom
UNK6U18  SK-SO8-1.27-DEDIPROG-V3  [SK_SO8_1P27MM_DEDIPROG_V3]  92.33 139.06 270 bottom
UNK6U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  114.42 139.32 270 bottom
UNK6U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  266.08 174.5 90 bottom
UNK6U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  261.84 204.24 180 bottom
UNK6U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  253.16 189.72 180 bottom
UNK6U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  253.16 178.15 180 bottom
UNK6U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  271.94 209.73 270 bottom
UNK6U455  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  373.73 465.08 0 top
UNK6U456  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  368.32 465.08 0 top
UNK6Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  274.01 161.07 0 bottom
UNK6Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  271.94 205.49 180 bottom
UNK7BD9  BD120-1.5A-S4-MU  [FB0402]  304.65 183.84 270 bottom
UNK7BD21  BD120-1.5A-S4-MU  [FB0402]  302.95 172.36 0 bottom
UNK7BD1728  BD120-1.5A-S4-MU  [FB0402]  309.83 211.82 270 bottom
UNK7BDB5  BD120-1.5A-S4-MU  [FB0402]  291.03 186.46 0 bottom
UNK7BDB6  BD120-1.5A-S4-MU  [FB0402]  291.03 174.89 0 bottom
UNK7BDB7  BD120-1.5A-S4-MU  [FB0402]  539.28 484.17 0 top
UNK7BDB8  BD120-1.5A-S4-MU  [FB0402]  557.16 484.17 0 top
UNK7C262  0.1U-16-X7S-S2-MU  [C0201]  304.41 172.06 270 bottom
UNK7C264  NC/10U-16-X7R-S8-SS  [C0805]  307.48 209.95 90 bottom
UNK7C267  33P-50-N-S2-MU  [C0201]  316.23 164.18 270 bottom
UNK7C268  33P-50-N-S2-MU  [C0201]  315.23 164.18 270 bottom
UNK7C271  12P-50-N-S4-MU  [C0402]  312.95 207.19 180 bottom
UNK7C272  12P-50-N-S4-MU  [C0402]  310.93 207.19 0 bottom
UNK7C278  1U-10-X7S-S4-TDK  [C0402]  308.79 139.96 180 bottom
UNK7C279  1U-10-X7S-S4-TDK  [C0402]  308.79 141.15 180 bottom
UNK7C280  0.1U-16-X-S4-MU  [C0402]  308.79 142.35 180 bottom
UNK7C281  0.1U-16-X-S4-MU  [C0402]  308.79 143.54 180 bottom
UNK7C282  1U-10-X7S-S4-TDK  [C0402]  302.96 146.59 90 bottom
UNK7C283  0.1U-16-X-S4-MU  [C0402]  304.12 146.59 90 bottom
UNK7C284  1U-10-X7S-S4-TDK  [C0402]  304.04 135.22 270 bottom
UNK7C285  0.1U-16-X-S4-MU  [C0402]  302.85 135.22 270 bottom
UNK7C286  0.1U-16-X-S4-MU  [C0402]  307.84 135.72 0 bottom
UNK7C288  1000P-50-X7R-S2-MU  [C0201]  308.17 137.5 90 bottom
UNK7C289  0.1U-16-X-S4-MU  [C0402]  310.45 138.26 90 bottom
UNK7C290  NC/0.1U-16-X7R-S4-TY  [C0402]  317.31 137.04 0 bottom
UNK7C298  0.1U-16-X7S-S2-MU  [C0201]  318.71 140.42 270 bottom
UNK7C299  0.1U-16-X7S-S2-MU  [C0201]  321.64 136.1 0 bottom
UNK7C300  0.1U-16-X-S4-MU  [C0402]  320.99 142.2 90 bottom
UNK7C301  1U-10-X7S-S4-TDK  [C0402]  322.15 142.2 90 bottom
UNK7C302  10P-50-N-S2-MU  [C0201]  294.98 183.61 0 bottom
UNK7C309  10P-50-N-S2-MU  [C0201]  294.98 195.18 0 bottom
UNK7C310  10P-50-N-S2-MU  [C0201]  293.69 195.18 180 bottom
UNK7C318  10P-50-N-S2-MU  [C0201]  291.94 195.18 0 bottom
UNK7C320  10P-50-N-S2-MU  [C0201]  293.69 183.61 180 bottom
UNK7C332  2.2U-16-X7R-S6-TY  [C0603]  479.94 135.21 270 bottom
UNK7C333  0.1U-16-X-S4-MU  [C0402]  478.54 135.39 270 bottom
UNK7C334  10U-16-X7R-S8-SS  [C0805]  470.92 135.09 90 bottom
UNK7C335  0.1U-16-X-S4-MU  [C0402]  472.58 134.91 90 bottom
UNK7C336  4.7U-25-X7R-S8-TY  [C0805]  458.42 148.85 270 bottom
UNK7C337  0.1U-16-X-S4-MU  [C0402]  458.44 146.3 180 bottom
UNK7C338  4.7U-25-X7R-S8-TY  [C0805]  476.84 148.85 270 bottom
UNK7C339  0.1U-16-X-S4-MU  [C0402]  476.87 146.3 180 bottom
UNK7C475  4.7U-6.3-X-S4-MU  [C0402]  305.86 205.11 270 bottom
UNK7C476  1U-10-X7S-S4-TDK  [C0402]  299 208.25 90 bottom
UNK7C477  10U-25-X-S6-MU  [C0603]  300.32 208.76 90 bottom
UNK7C478  22U-16-X5R-SA-SS  [C1206]  303.32 208.5 0 bottom
UNK7C922  0.1U-16-X-S4-MU  [C0402]  293.16 186.46 0 bottom
UNK7C923  0.1U-16-X-S4-MU  [C0402]  293.16 174.89 0 bottom
UNK7C924  10P-50-N-S2-MU  [C0201]  291.94 183.61 0 bottom
UNK7C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  309.58 210.27 180 bottom
UNK7C1086  10P-50-N-S2-MU  [C0201]  39.69 484.08 0 top
UNK7C1087  10P-50-N-S2-MU  [C0201]  41.09 484.08 0 top
UNK7C1088  10P-50-N-S2-MU  [C0201]  42.49 484.08 0 top
UNK7C1089  0.1U-16-X-S4-MU  [C0402]  93.38 484.22 0 top
UNK7C1090  0.1U-16-X-S4-MU  [C0402]  95.59 484.22 0 top
UNK7C1091  10P-50-N-S2-MU  [C0201]  43.9 484.08 0 top
UNK7C1093  10P-50-N-S2-MU  [C0201]  45.3 484.08 0 top
UNK7CA1  0.1U-16-X-S4-MU  [C0402]  301.73 155.04 0 bottom
UNK7CA2  10U-25-X7R-SA  [C1206]  301.73 157.07 0 bottom
UNK7CA7  10U-25-X7R-SA  [C1206]  321 154.53 0 bottom
UNK7CA8  0.1U-16-X-S4-MU  [C0402]  321 152.5 0 bottom
UNK7CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  294.88 143.83 180 bottom
UNK7CA20  10U-25-X7R-SA  [C1206]  311.37 153.01 0 bottom
UNK7CA21  0.1U-16-X-S4-MU  [C0402]  311.37 150.98 0 bottom
UNK7CA22  10U-25-X7R-SA  [C1206]  321 149.86 0 bottom
UNK7CA23  0.1U-16-X-S4-MU  [C0402]  321 147.83 0 bottom
UNK7CA24  10U-25-X7R-SA  [C1206]  301.73 153.01 0 bottom
UNK7CA25  0.1U-16-X-S4-MU  [C0402]  301.73 150.98 0 bottom
UNK7CA26  10U-25-X7R-SA  [C1206]  306.55 157.07 0 bottom
UNK7CA27  0.1U-16-X-S4-MU  [C0402]  306.55 155.04 0 bottom
UNK7CA34  10U-25-X7R-SA  [C1206]  325.82 154.53 0 bottom
UNK7CA35  0.1U-16-X-S4-MU  [C0402]  325.82 152.5 0 bottom
UNK7CA36  0.1U-16-X-S4-MU  [C0402]  306.55 150.98 0 bottom
UNK7CA37  10U-25-X7R-SA  [C1206]  306.55 153.01 0 bottom
UNK7CA38  10U-25-X7R-SA  [C1206]  224.78 484.92 0 top
UNK7CA39  0.1U-16-X-S4-MU  [C0402]  97.79 484.22 0 top
UNK7CC1  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.19 186.91 180 bottom
UNK7CC2  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.5 190.48 90 bottom
UNK7CC3  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.87 185.61 180 bottom
UNK7CC4  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.19 186.26 180 bottom
UNK7CC5  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.16 186.56 90 bottom
UNK7CC6  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.87 184.96 180 bottom
UNK7CC7  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.14 184.96 0 bottom
UNK7CC8  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.5 183.97 270 bottom
UNK7CC9  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.16 183.97 270 bottom
UNK7CC12  0.1U-16-X7S-S2-MU  [C0201_MINI]  309.85 184.62 270 bottom
UNK7CC13  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.24 181.06 180 bottom
UNK7CC14  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.46 185.61 0 bottom
UNK7CC15  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.19 185.61 180 bottom
UNK7CC16  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.84 184.96 180 bottom
UNK7CC70  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.46 182.67 270 bottom
UNK7CC71  0.1U-16-X7S-S2-MU  [C0201_MINI]  315.38 183 0 bottom
UNK7CC73  0.1U-16-X7S-S2-MU  [C0201_MINI]  307.9 182.68 90 bottom
UNK7CC84  0.1U-16-X7S-S2-MU  [C0201_MINI]  313.11 190.48 90 bottom
UNK7CC85  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.15 190.48 90 bottom
UNK7CC86  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.46 190.48 90 bottom
UNK7CC87  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.14 186.26 180 bottom
UNK7CC88  0.1U-16-X7S-S2-MU  [C0201_MINI]  313.11 184 270 bottom
UNK7CC89  0.1U-16-X7S-S2-MU  [C0201_MINI]  307.9 184.66 270 bottom
UNK7CC90  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.8 190.48 90 bottom
UNK7CC91  0.1U-16-X7S-S2-MU  [C0201_MINI]  314.05 183.65 0 bottom
UNK7CC92  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.45 184 270 bottom
UNK7CC96  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.51 187.56 180 bottom
UNK7CC101  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.84 180.4 0 bottom
UNK7CC103  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.81 182.02 90 bottom
UNK7CC105  0.1U-16-X7S-S2-MU  [C0201_MINI]  312.46 180.72 270 bottom
UNK7CC112  0.1U-16-X7S-S2-MU  [C0201_MINI]  315.05 190.48 90 bottom
UNK7CC130  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.24 181.7 180 bottom
UNK7CC182  0.1U-16-X7S-S2-MU  [C0201_MINI]  306.6 190.48 90 bottom
UNK7CC195  4.7U-25-X7R-S8-TY  [C0805]  189.95 484.67 0 top
UNK7CC202  0.1U-16-X7S-S2-MU  [C0201_MINI]  306.28 185.61 180 bottom
UNK7CC211  0.1U-16-X7S-S2-MU  [C0201_MINI]  310.5 182.02 90 bottom
UNK7CC212  0.1U-16-X7S-S2-MU  [C0201_MINI]  309.53 181.06 180 bottom
UNK7CC213  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.16 182.02 90 bottom
UNK7CC214  0.1U-16-X7S-S2-MU  [C0201_MINI]  148.69 484.08 0 top
UNK7CC215  0.1U-16-X7S-S2-MU  [C0201_MINI]  311.81 179.42 90 bottom
UNK7CC216  0.1U-16-X7S-S2-MU  [C0201_MINI]  308.55 178.78 270 bottom
UNK7CC217  0.1U-16-X7S-S2-MU  [C0201_MINI]  150.09 484.08 0 top
UNK7CC218  0.1U-16-X7S-S2-MU  [C0201_MINI]  151.49 484.08 0 top
UNK7CC219  0.1U-16-X7S-S2-MU  [C0201_MINI]  152.9 484.08 0 top
UNK7CC220  0.1U-16-X7S-S2-MU  [C0201_MINI]  154.3 484.08 0 top
UNK7K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  489.88 156.66 90 bottom
UNK7K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  483.53 156.66 90 bottom
UNK7K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  477.18 156.66 90 bottom
UNK7K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  470.83 156.66 90 bottom
UNK7K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  464.48 156.66 90 bottom
UNK7K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  458.13 156.66 90 bottom
UNK7K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  311.94 198.56 90 bottom
UNK7K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  315.73 171.79 270 bottom
UNK7K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  186.18 244.86 90 bottom
UNK7K96  EC2-5NJ  [RL_NECEC2_10P_5V]  295.03 157.73 90 bottom
UNK7MBD1  BD120-1.5A-S4-MU  [FB0402]  318.71 138.77 90 bottom
UNK7MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  315.79 144.74 0 bottom
UNK7MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  315.79 139.4 0 bottom
UNK7MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  315.79 147.28 0 bottom
UNK7MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  315.79 142.07 0 bottom
UNK7MR1  1M-1-S4  [R0402_UNBGA_V2]  305.44 146.59 90 bottom
UNK7MR2  1K-0.01-S4  [R0402_UNBGA_V2]  305.75 135.72 0 bottom
UNK7MR3  1K-0.01-S4  [R0402_UNBGA_V2]  307.84 134.7 0 bottom
UNK7MR4  1K-0.01-S4  [R0402_UNBGA_V2]  307.84 133.69 0 bottom
UNK7MR5  1K-0.01-S4  [R0402_UNBGA_V2]  305.75 133.69 180 bottom
UNK7MR6  1K-0.01-S4  [R0402_UNBGA_V2]  305.75 134.7 180 bottom
UNK7MR7  332K-1-S4  [R0402_UNBGA_V2]  306.45 147.44 270 bottom
UNK7MR8  1K-0.01-S4  [R0402_UNBGA_V2]  317.31 133.69 0 bottom
UNK7MR9  499-0.1-S4  [R0402]  317.31 134.8 0 bottom
UNK7MR10  0-5-S4  [R0402]  317.31 135.92 180 bottom
UNK7MR11  750-1-S4  [R0402]  312.36 144.1 0 bottom
UNK7MR12  360-1-S6  [R0603]  311.98 145.37 0 bottom
UNK7MR13  750-1-S4  [R0402]  312.36 138.77 0 bottom
UNK7MR14  1.2K-1-S4  [R0402]  312.61 146.64 180 bottom
UNK7MR15  360-1-S6  [R0603]  311.98 140.04 0 bottom
UNK7MR16  750-1-S4  [R0402]  312.36 141.43 0 bottom
UNK7MR17  360-1-S6  [R0603]  311.98 142.7 0 bottom
UNK7MR18  11K-0.1-S4  [R0402]  319.85 142.2 90 bottom
UNK7MR19  1K-0.01-S4  [R0402_UNBGA_V2]  318.71 142.2 270 bottom
UNK7MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  308.51 145.44 270 bottom
UNK7MU2  KSMT004-SO8  [SO8_244X127MM]  303.6 141.05 270 bottom
UNK7MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  312.74 135.59 0 bottom
UNK7MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  320.99 138.77 180 bottom
UNK7R135  0-5-S4  [R0402]  318.73 165.44 180 bottom
UNK7R136  1M-1-S4  [R0402]  315.73 165.44 0 bottom
UNK7R137  0-5-S4  [R0402]  312.73 165.44 0 bottom
UNK7R160  38.3-1-S2  [R0201_MINI]  303.52 175.18 0 bottom
UNK7R161  38.3-1-S2  [R0201_MINI]  303.52 174.62 0 bottom
UNK7R162  4.7K-1-S2  [R0201_MINI]  308.01 174.55 90 bottom
UNK7R163  0-5-S2  [R0201_MINI]  303.52 173.14 0 bottom
UNK7R164  0-5-S2  [R0201_MINI]  303.52 174.06 0 bottom
UNK7R165  0-5-S2  [R0201_MINI]  308.01 173.55 90 bottom
UNK7R168  42.2-1-S2  [R0201]  293.99 194.16 90 bottom
UNK7R170  42.2-1-S2  [R0201]  293.29 194.16 90 bottom
UNK7R172  0-5-S2  [R0201]  294.96 192.79 0 top
UNK7R176  42.2-1-S2  [R0201]  291.64 194.16 90 bottom
UNK7R178  42.2-1-S2  [R0201]  292.33 194.16 90 bottom
UNK7R180  42.2-1-S2  [R0201]  293.99 182.6 90 bottom
UNK7R182  42.2-1-S2  [R0201]  293.29 182.6 90 bottom
UNK7R200  4.7K-1-S2  [R0201]  473.52 145.03 180 bottom
UNK7R201  0-5-S4  [R0402]  458.44 145.03 180 bottom
UNK7R202  NC/4.7K-1-S4  [R0402]  458.44 143.76 180 bottom
UNK7R203  4.7K-1-S2  [R0201]  473.52 142.49 180 bottom
UNK7R204  0-5-S4  [R0402]  477.12 145.03 180 bottom
UNK7R205  4.7K-1-S2  [R0201]  493.32 145.03 180 bottom
UNK7R206  NC/4.7K-1-S4  [R0402]  477.12 143.76 180 bottom
UNK7R207  4.7K-1-S2  [R0201]  493.32 142.49 180 bottom
UNK7R234  0-1-S4-YA  [R0402]  468.49 484.22 0 top
UNK7R331  10K-1-S2-WA  [R0201]  320.04 135.77 90 bottom
UNK7R509  0-5-S4  [R0402]  299 204.31 90 bottom
UNK7R510  1.2K-1-S4  [R0402]  304.69 205.11 270 bottom
UNK7R511  523-1-S4  [R0402]  305.19 202.36 0 bottom
UNK7R512  0-5-S8  [R0805]  307.48 206.24 270 bottom
UNK7R646  42.2-1-S2  [R0201]  294.68 194.16 90 bottom
UNK7R647  42.2-1-S2  [R0201]  295.38 194.16 90 bottom
UNK7R652  NC/100K-1-S4  [R0402]  310.84 213.67 90 bottom
UNK7R659  10K-1-S2-WA  [R0201]  293.54 190.99 90 top
UNK7R661  4.7K-1-S2  [R0201]  292.78 190.99 270 top
UNK7R662  0-5-S2  [R0201]  294.96 181.23 0 top
UNK7R663  4.7K-1-S2  [R0201]  292.78 179.42 270 top
UNK7R664  42.2-1-S2  [R0201]  292.33 182.6 90 bottom
UNK7R666  42.2-1-S2  [R0201]  291.64 182.6 90 bottom
UNK7R672  10K-1-S2-WA  [R0201]  293.54 179.42 90 top
UNK7R923  100K-1-S4  [R0402]  312 213.67 90 bottom
UNK7R973  0-5-S4  [R0402]  311.42 212.04 0 bottom
UNK7R980  10K-1-S2-WA  [R0201]  313.66 209.4 90 bottom
UNK7R981  NC/4.7K-1-S2  [R0201]  309.83 209.4 270 bottom
UNK7R982  0-5-S2  [R0201]  309.53 208.44 0 bottom
UNK7R1088  42.2-1-S2  [R0201]  294.68 182.6 90 bottom
UNK7R1089  42.2-1-S2  [R0201]  295.38 182.6 90 bottom
UNK7R1098  4.7K-1-S2  [R0201]  364.1 484.08 0 top
UNK7R1099  42.2-1-S2  [R0201]  307.97 484.08 0 top
UNK7R1100  42.2-1-S2  [R0201]  309.38 484.08 0 top
UNK7R1101  4.7K-1-S2  [R0201]  365.5 484.08 0 top
UNK7R1102  0-5-S2  [R0201]  386.55 484.08 0 top
UNK7R1103  42.2-1-S2  [R0201]  310.78 484.08 0 top
UNK7R1104  0-5-S2  [R0201]  387.95 484.08 0 top
UNK7R1105  10K-1-S2-WA  [R0201]  409 484.08 0 top
UNK7R1106  42.2-1-S2  [R0201]  312.18 484.08 0 top
UNK7R1107  42.2-1-S2  [R0201]  313.59 484.08 0 top
UNK7R1108  10K-1-S2-WA  [R0201]  410.4 484.08 0 top
UNK7R1109  42.2-1-S2  [R0201]  314.99 484.08 0 top
UNK7R1110  42.2-1-S2  [R0201]  316.39 484.08 0 top
UNK7R1111  42.2-1-S2  [R0201]  317.79 484.08 0 top
UNK7R1114  42.2-1-S2  [R0201]  319.2 484.08 0 top
UNK7R1115  42.2-1-S2  [R0201]  320.6 484.08 0 top
UNK7R1117  0-1-S4-YA  [R0402]  461.88 484.22 0 top
UNK7R1118  0-1-S4-YA  [R0402]  464.08 484.22 0 top
UNK7R1119  0-1-S4-YA  [R0402]  466.28 484.22 0 top
UNK7SA1  SHORT  [DEFAULT_SHORT_SMALL]  316.06 191.36 0 top
UNK7SA2  SHORT  [DEFAULT_SHORT_SMALL]  316.06 191.87 0 top
UNK7SA7  SHORT  [DEFAULT_SHORT_SMALL]  303.4 185.16 90 top
UNK7SA8  SHORT  [DEFAULT_SHORT_SMALL]  303.91 185.16 90 top
UNK7SA9  SHORT  [DEFAULT_SHORT_SMALL]  314.24 174.5 270 top
UNK7SA10  SHORT  [DEFAULT_SHORT_SMALL]  315.03 174.5 270 top
UNK7SA15  SHORT  [DEFAULT_SHORT_SMALL]  319.49 193.83 90 top
UNK7SA16  SHORT  [DEFAULT_SHORT_SMALL]  318.98 193.83 90 top
UNK7SA17  SHORT  [DEFAULT_SHORT_SMALL]  315.98 191.77 0 top
UNK7SA18  SHORT  [DEFAULT_SHORT_SMALL]  315.98 192.46 0 top
UNK7SA19  SHORT  [DEFAULT_SHORT_SMALL]  304.08 183.68 270 top
UNK7SA20  SHORT  [DEFAULT_SHORT_SMALL]  303.49 183.68 270 top
UNK7SA21  SHORT  [DEFAULT_SHORT_SMALL]  314.54 193.95 0 top
UNK7SA22  SHORT  [DEFAULT_SHORT_SMALL]  314.54 195.43 0 top
UNK7SA23  SHORT  [DEFAULT_SHORT_SMALL]  313.04 174.51 270 top
UNK7SA24  SHORT  [DEFAULT_SHORT_SMALL]  314.32 174.51 270 top
UNK7SA25  SHORT  [DEFAULT_SHORT_SMALL]  510.35 484.3 0 top
UNK7SA26  SHORT  [DEFAULT_SHORT_SMALL]  512.55 484.3 0 top
UNK7TP_DPS1  TP01  [TP_040_T]  300.48 157.07 0 top
UNK7TP_DPS2  TP01  [TP_040_T]  305.3 157.07 180 top
UNK7TP_DPS3  TP01  [TP_040_T]  310.12 153.01 180 top
UNK7TP_DPS4  TP01  [TP_040_T]  324.57 154.53 0 top
UNK7TP_DPS5  TP01  [TP_040_T]  319.75 149.86 0 top
UNK7TP_DPS6  TP01  [TP_040_T]  319.75 154.53 0 top
UNK7TP_DPS7  TP01  [TP_040_T]  300.48 153.01 0 top
UNK7TP_DPS8  TP01  [TP_040_T]  305.3 153.01 180 top
UNK7TP_DPS9  TP01  [TP_040_T]  570.19 484.56 0 top
UNK7TP_MUX_3V3  TP01  [TP_040_T]  295.65 209.49 180 top
UNK7U17  XC6203E-0.4A-33-SOT89  [SOT89]  475.5 135.8 180 bottom
UNK7U18  SK-SO8-1.27-DEDIPROG-V3  [SK_SO8_1P27MM_DEDIPROG_V3]  463.17 142.88 270 bottom
UNK7U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  485.26 143.13 270 bottom
UNK7U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  306.08 174.5 90 bottom
UNK7U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  301.84 204.24 180 bottom
UNK7U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  293.16 189.72 180 bottom
UNK7U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  293.16 178.15 180 bottom
UNK7U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  311.94 209.73 270 bottom
UNK7U455  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  362.92 465.08 0 top
UNK7U456  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  357.52 465.08 0 top
UNK7Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  314.01 161.07 0 bottom
UNK7Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  311.94 205.49 180 bottom
UNK8BD9  BD120-1.5A-S4-MU  [FB0402]  344.65 183.84 270 bottom
UNK8BD21  BD120-1.5A-S4-MU  [FB0402]  342.95 172.36 0 bottom
UNK8BD1728  BD120-1.5A-S4-MU  [FB0402]  349.83 211.82 270 bottom
UNK8BDB5  BD120-1.5A-S4-MU  [FB0402]  331.03 186.46 0 bottom
UNK8BDB6  BD120-1.5A-S4-MU  [FB0402]  331.03 174.89 0 bottom
UNK8BDB7  BD120-1.5A-S4-MU  [FB0402]  554.93 484.17 0 top
UNK8BDB8  BD120-1.5A-S4-MU  [FB0402]  552.69 484.17 0 top
UNK8C262  0.1U-16-X7S-S2-MU  [C0201]  344.41 172.06 270 bottom
UNK8C264  NC/10U-16-X7R-S8-SS  [C0805]  347.48 209.95 90 bottom
UNK8C267  33P-50-N-S2-MU  [C0201]  356.23 164.18 270 bottom
UNK8C268  33P-50-N-S2-MU  [C0201]  355.23 164.18 270 bottom
UNK8C271  12P-50-N-S4-MU  [C0402]  352.95 207.19 180 bottom
UNK8C272  12P-50-N-S4-MU  [C0402]  350.93 207.19 0 bottom
UNK8C278  1U-10-X7S-S4-TDK  [C0402]  348.79 139.96 180 bottom
UNK8C279  1U-10-X7S-S4-TDK  [C0402]  348.79 141.15 180 bottom
UNK8C280  0.1U-16-X-S4-MU  [C0402]  348.79 142.35 180 bottom
UNK8C281  0.1U-16-X-S4-MU  [C0402]  348.79 143.54 180 bottom
UNK8C282  1U-10-X7S-S4-TDK  [C0402]  342.96 146.59 90 bottom
UNK8C283  0.1U-16-X-S4-MU  [C0402]  344.12 146.59 90 bottom
UNK8C284  1U-10-X7S-S4-TDK  [C0402]  344.04 135.22 270 bottom
UNK8C285  0.1U-16-X-S4-MU  [C0402]  342.85 135.22 270 bottom
UNK8C286  0.1U-16-X-S4-MU  [C0402]  347.84 135.72 0 bottom
UNK8C288  1000P-50-X7R-S2-MU  [C0201]  348.17 137.5 90 bottom
UNK8C289  0.1U-16-X-S4-MU  [C0402]  350.45 138.26 90 bottom
UNK8C290  NC/0.1U-16-X7R-S4-TY  [C0402]  357.31 137.04 0 bottom
UNK8C298  0.1U-16-X7S-S2-MU  [C0201]  358.71 140.42 270 bottom
UNK8C299  0.1U-16-X7S-S2-MU  [C0201]  361.64 136.1 0 bottom
UNK8C300  0.1U-16-X-S4-MU  [C0402]  360.99 142.2 90 bottom
UNK8C301  1U-10-X7S-S4-TDK  [C0402]  362.15 142.2 90 bottom
UNK8C302  10P-50-N-S2-MU  [C0201]  334.98 183.61 0 bottom
UNK8C309  10P-50-N-S2-MU  [C0201]  334.98 195.18 0 bottom
UNK8C310  10P-50-N-S2-MU  [C0201]  333.69 195.18 180 bottom
UNK8C318  10P-50-N-S2-MU  [C0201]  331.94 195.18 0 bottom
UNK8C320  10P-50-N-S2-MU  [C0201]  333.69 183.61 180 bottom
UNK8C332  2.2U-16-X7R-S6-TY  [C0603]  479.94 166.96 270 bottom
UNK8C333  0.1U-16-X-S4-MU  [C0402]  478.54 167.14 270 bottom
UNK8C334  10U-16-X7R-S8-SS  [C0805]  470.92 166.84 90 bottom
UNK8C335  0.1U-16-X-S4-MU  [C0402]  472.58 166.66 90 bottom
UNK8C336  4.7U-25-X7R-S8-TY  [C0805]  458.42 180.6 270 bottom
UNK8C337  0.1U-16-X-S4-MU  [C0402]  458.44 178.05 180 bottom
UNK8C338  4.7U-25-X7R-S8-TY  [C0805]  476.84 180.6 270 bottom
UNK8C339  0.1U-16-X-S4-MU  [C0402]  476.87 178.05 180 bottom
UNK8C475  4.7U-6.3-X-S4-MU  [C0402]  345.86 205.11 270 bottom
UNK8C476  1U-10-X7S-S4-TDK  [C0402]  339 208.25 90 bottom
UNK8C477  10U-25-X-S6-MU  [C0603]  340.32 208.76 90 bottom
UNK8C478  22U-16-X5R-SA-SS  [C1206]  343.32 208.5 0 bottom
UNK8C922  0.1U-16-X-S4-MU  [C0402]  333.16 186.46 0 bottom
UNK8C923  0.1U-16-X-S4-MU  [C0402]  333.16 174.89 0 bottom
UNK8C924  10P-50-N-S2-MU  [C0201]  331.94 183.61 0 bottom
UNK8C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  349.58 210.27 180 bottom
UNK8C1086  10P-50-N-S2-MU  [C0201]  46.7 484.08 0 top
UNK8C1087  10P-50-N-S2-MU  [C0201]  48.11 484.08 0 top
UNK8C1088  10P-50-N-S2-MU  [C0201]  49.51 484.08 0 top
UNK8C1089  0.1U-16-X-S4-MU  [C0402]  99.99 484.22 0 top
UNK8C1090  0.1U-16-X-S4-MU  [C0402]  102.2 484.22 0 top
UNK8C1091  10P-50-N-S2-MU  [C0201]  50.91 484.08 0 top
UNK8C1093  10P-50-N-S2-MU  [C0201]  52.32 484.08 0 top
UNK8CA1  0.1U-16-X-S4-MU  [C0402]  341.73 155.04 0 bottom
UNK8CA2  10U-25-X7R-SA  [C1206]  341.73 157.07 0 bottom
UNK8CA7  10U-25-X7R-SA  [C1206]  361 154.53 0 bottom
UNK8CA8  0.1U-16-X-S4-MU  [C0402]  361 152.5 0 bottom
UNK8CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  334.88 143.83 180 bottom
UNK8CA20  10U-25-X7R-SA  [C1206]  351.37 153.01 0 bottom
UNK8CA21  0.1U-16-X-S4-MU  [C0402]  351.37 150.98 0 bottom
UNK8CA22  10U-25-X7R-SA  [C1206]  361 149.86 0 bottom
UNK8CA23  0.1U-16-X-S4-MU  [C0402]  361 147.83 0 bottom
UNK8CA24  10U-25-X7R-SA  [C1206]  341.73 153.01 0 bottom
UNK8CA25  0.1U-16-X-S4-MU  [C0402]  341.73 150.98 0 bottom
UNK8CA26  10U-25-X7R-SA  [C1206]  346.55 157.07 0 bottom
UNK8CA27  0.1U-16-X-S4-MU  [C0402]  346.55 155.04 0 bottom
UNK8CA34  10U-25-X7R-SA  [C1206]  365.82 154.53 0 bottom
UNK8CA35  0.1U-16-X-S4-MU  [C0402]  365.82 152.5 0 bottom
UNK8CA36  0.1U-16-X-S4-MU  [C0402]  346.55 150.98 0 bottom
UNK8CA37  10U-25-X7R-SA  [C1206]  346.55 153.01 0 bottom
UNK8CA38  10U-25-X7R-SA  [C1206]  229.38 484.92 0 top
UNK8CA39  0.1U-16-X-S4-MU  [C0402]  104.4 484.22 0 top
UNK8CC1  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.19 186.91 180 bottom
UNK8CC2  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.5 190.48 90 bottom
UNK8CC3  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.87 185.61 180 bottom
UNK8CC4  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.19 186.26 180 bottom
UNK8CC5  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.15 186.56 90 bottom
UNK8CC6  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.87 184.96 180 bottom
UNK8CC7  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.14 184.96 0 bottom
UNK8CC8  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.5 183.97 270 bottom
UNK8CC9  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.15 183.97 270 bottom
UNK8CC12  0.1U-16-X7S-S2-MU  [C0201_MINI]  349.85 184.62 270 bottom
UNK8CC13  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.24 181.06 180 bottom
UNK8CC14  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.45 185.61 0 bottom
UNK8CC15  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.19 185.61 180 bottom
UNK8CC16  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.84 184.96 180 bottom
UNK8CC70  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.45 182.67 270 bottom
UNK8CC71  0.1U-16-X7S-S2-MU  [C0201_MINI]  355.38 183 0 bottom
UNK8CC73  0.1U-16-X7S-S2-MU  [C0201_MINI]  347.9 182.68 90 bottom
UNK8CC84  0.1U-16-X7S-S2-MU  [C0201_MINI]  353.1 190.48 90 bottom
UNK8CC85  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.15 190.48 90 bottom
UNK8CC86  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.45 190.48 90 bottom
UNK8CC87  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.14 186.26 180 bottom
UNK8CC88  0.1U-16-X7S-S2-MU  [C0201_MINI]  353.1 184 270 bottom
UNK8CC89  0.1U-16-X7S-S2-MU  [C0201_MINI]  347.9 184.66 270 bottom
UNK8CC90  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.8 190.48 90 bottom
UNK8CC91  0.1U-16-X7S-S2-MU  [C0201_MINI]  354.05 183.65 0 bottom
UNK8CC92  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.45 184 270 bottom
UNK8CC96  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.51 187.56 180 bottom
UNK8CC101  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.84 180.4 0 bottom
UNK8CC103  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.8 182.02 90 bottom
UNK8CC105  0.1U-16-X7S-S2-MU  [C0201_MINI]  352.45 180.72 270 bottom
UNK8CC112  0.1U-16-X7S-S2-MU  [C0201_MINI]  355.05 190.48 90 bottom
UNK8CC130  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.24 181.7 180 bottom
UNK8CC182  0.1U-16-X7S-S2-MU  [C0201_MINI]  346.6 190.48 90 bottom
UNK8CC195  4.7U-25-X7R-S8-TY  [C0805]  193.76 484.67 0 top
UNK8CC202  0.1U-16-X7S-S2-MU  [C0201_MINI]  346.28 185.61 180 bottom
UNK8CC211  0.1U-16-X7S-S2-MU  [C0201_MINI]  350.5 182.02 90 bottom
UNK8CC212  0.1U-16-X7S-S2-MU  [C0201_MINI]  349.53 181.06 180 bottom
UNK8CC213  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.15 182.02 90 bottom
UNK8CC214  0.1U-16-X7S-S2-MU  [C0201_MINI]  155.7 484.08 0 top
UNK8CC215  0.1U-16-X7S-S2-MU  [C0201_MINI]  351.8 179.42 90 bottom
UNK8CC216  0.1U-16-X7S-S2-MU  [C0201_MINI]  348.55 178.78 270 bottom
UNK8CC217  0.1U-16-X7S-S2-MU  [C0201_MINI]  157.11 484.08 0 top
UNK8CC218  0.1U-16-X7S-S2-MU  [C0201_MINI]  158.51 484.08 0 top
UNK8CC219  0.1U-16-X7S-S2-MU  [C0201_MINI]  159.91 484.08 0 top
UNK8CC220  0.1U-16-X7S-S2-MU  [C0201_MINI]  161.32 484.08 0 top
UNK8K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  489.88 188.41 90 bottom
UNK8K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  483.53 188.41 90 bottom
UNK8K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  477.18 188.41 90 bottom
UNK8K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  470.83 188.41 90 bottom
UNK8K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  464.48 188.41 90 bottom
UNK8K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  458.13 188.41 90 bottom
UNK8K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  351.94 198.56 90 bottom
UNK8K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  355.73 171.79 270 bottom
UNK8K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  195.83 244.86 90 bottom
UNK8K96  EC2-5NJ  [RL_NECEC2_10P_5V]  335.03 157.73 90 bottom
UNK8MBD1  BD120-1.5A-S4-MU  [FB0402]  358.71 138.77 90 bottom
UNK8MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  355.79 144.74 0 bottom
UNK8MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  355.79 139.4 0 bottom
UNK8MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  355.79 147.28 0 bottom
UNK8MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  355.79 142.07 0 bottom
UNK8MR1  1M-1-S4  [R0402_UNBGA_V2]  345.44 146.59 90 bottom
UNK8MR2  1K-0.01-S4  [R0402_UNBGA_V2]  345.75 135.72 0 bottom
UNK8MR3  1K-0.01-S4  [R0402_UNBGA_V2]  347.84 134.7 0 bottom
UNK8MR4  1K-0.01-S4  [R0402_UNBGA_V2]  347.84 133.69 0 bottom
UNK8MR5  1K-0.01-S4  [R0402_UNBGA_V2]  345.75 133.69 180 bottom
UNK8MR6  1K-0.01-S4  [R0402_UNBGA_V2]  345.75 134.7 180 bottom
UNK8MR7  332K-1-S4  [R0402_UNBGA_V2]  346.45 147.44 270 bottom
UNK8MR8  1K-0.01-S4  [R0402_UNBGA_V2]  357.31 133.69 0 bottom
UNK8MR9  499-0.1-S4  [R0402]  357.31 134.8 0 bottom
UNK8MR10  0-5-S4  [R0402]  357.31 135.92 180 bottom
UNK8MR11  750-1-S4  [R0402]  352.36 144.1 0 bottom
UNK8MR12  360-1-S6  [R0603]  351.98 145.37 0 bottom
UNK8MR13  750-1-S4  [R0402]  352.36 138.77 0 bottom
UNK8MR14  1.2K-1-S4  [R0402]  352.61 146.64 180 bottom
UNK8MR15  360-1-S6  [R0603]  351.98 140.04 0 bottom
UNK8MR16  750-1-S4  [R0402]  352.36 141.43 0 bottom
UNK8MR17  360-1-S6  [R0603]  351.98 142.7 0 bottom
UNK8MR18  11K-0.1-S4  [R0402]  359.85 142.2 90 bottom
UNK8MR19  1K-0.01-S4  [R0402_UNBGA_V2]  358.71 142.2 270 bottom
UNK8MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  348.51 145.44 270 bottom
UNK8MU2  KSMT004-SO8  [SO8_244X127MM]  343.6 141.05 270 bottom
UNK8MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  352.74 135.59 0 bottom
UNK8MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  360.99 138.77 180 bottom
UNK8R135  0-5-S4  [R0402]  358.73 165.44 180 bottom
UNK8R136  1M-1-S4  [R0402]  355.73 165.44 0 bottom
UNK8R137  0-5-S4  [R0402]  352.73 165.44 0 bottom
UNK8R160  38.3-1-S2  [R0201_MINI]  343.52 175.18 0 bottom
UNK8R161  38.3-1-S2  [R0201_MINI]  343.52 174.62 0 bottom
UNK8R162  4.7K-1-S2  [R0201_MINI]  348.01 174.55 90 bottom
UNK8R163  0-5-S2  [R0201_MINI]  343.52 173.14 0 bottom
UNK8R164  0-5-S2  [R0201_MINI]  343.52 174.06 0 bottom
UNK8R165  0-5-S2  [R0201_MINI]  348.01 173.55 90 bottom
UNK8R168  42.2-1-S2  [R0201]  333.99 194.16 90 bottom
UNK8R170  42.2-1-S2  [R0201]  333.29 194.16 90 bottom
UNK8R172  0-5-S2  [R0201]  334.96 192.79 0 top
UNK8R176  42.2-1-S2  [R0201]  331.64 194.16 90 bottom
UNK8R178  42.2-1-S2  [R0201]  332.33 194.16 90 bottom
UNK8R180  42.2-1-S2  [R0201]  333.99 182.6 90 bottom
UNK8R182  42.2-1-S2  [R0201]  333.29 182.6 90 bottom
UNK8R200  4.7K-1-S2  [R0201]  473.52 176.78 180 bottom
UNK8R201  0-5-S4  [R0402]  458.44 176.78 180 bottom
UNK8R202  NC/4.7K-1-S4  [R0402]  458.44 175.51 180 bottom
UNK8R203  4.7K-1-S2  [R0201]  473.52 174.24 180 bottom
UNK8R204  0-5-S4  [R0402]  477.12 176.78 180 bottom
UNK8R205  4.7K-1-S2  [R0201]  493.32 176.78 180 bottom
UNK8R206  NC/4.7K-1-S4  [R0402]  477.12 175.51 180 bottom
UNK8R207  4.7K-1-S2  [R0201]  493.32 174.24 180 bottom
UNK8R234  0-1-S4-YA  [R0402]  477.3 484.22 0 top
UNK8R331  10K-1-S2-WA  [R0201]  360.04 135.77 90 bottom
UNK8R509  0-5-S4  [R0402]  339 204.31 90 bottom
UNK8R510  1.2K-1-S4  [R0402]  344.69 205.11 270 bottom
UNK8R511  523-1-S4  [R0402]  345.19 202.36 0 bottom
UNK8R512  0-5-S8  [R0805]  347.48 206.24 270 bottom
UNK8R646  42.2-1-S2  [R0201]  334.68 194.16 90 bottom
UNK8R647  42.2-1-S2  [R0201]  335.38 194.16 90 bottom
UNK8R652  NC/100K-1-S4  [R0402]  350.84 213.67 90 bottom
UNK8R659  10K-1-S2-WA  [R0201]  333.54 190.99 90 top
UNK8R661  4.7K-1-S2  [R0201]  332.78 190.99 270 top
UNK8R662  0-5-S2  [R0201]  334.96 181.23 0 top
UNK8R663  4.7K-1-S2  [R0201]  332.78 179.42 270 top
UNK8R664  42.2-1-S2  [R0201]  332.33 182.6 90 bottom
UNK8R666  42.2-1-S2  [R0201]  331.64 182.6 90 bottom
UNK8R672  10K-1-S2-WA  [R0201]  333.54 179.42 90 top
UNK8R923  100K-1-S4  [R0402]  352 213.67 90 bottom
UNK8R973  0-5-S4  [R0402]  351.42 212.04 0 bottom
UNK8R980  10K-1-S2-WA  [R0201]  353.66 209.4 90 bottom
UNK8R981  NC/4.7K-1-S2  [R0201]  349.83 209.4 270 bottom
UNK8R982  0-5-S2  [R0201]  349.53 208.44 0 bottom
UNK8R1088  42.2-1-S2  [R0201]  334.68 182.6 90 bottom
UNK8R1089  42.2-1-S2  [R0201]  335.38 182.6 90 bottom
UNK8R1098  4.7K-1-S2  [R0201]  366.9 484.08 0 top
UNK8R1099  42.2-1-S2  [R0201]  322 484.08 0 top
UNK8R1100  42.2-1-S2  [R0201]  323.41 484.08 0 top
UNK8R1101  4.7K-1-S2  [R0201]  368.31 484.08 0 top
UNK8R1102  0-5-S2  [R0201]  389.35 484.08 0 top
UNK8R1103  42.2-1-S2  [R0201]  324.81 484.08 0 top
UNK8R1104  0-5-S2  [R0201]  390.76 484.08 0 top
UNK8R1105  10K-1-S2-WA  [R0201]  411.8 484.08 0 top
UNK8R1106  42.2-1-S2  [R0201]  326.21 484.08 0 top
UNK8R1107  42.2-1-S2  [R0201]  327.62 484.08 0 top
UNK8R1108  10K-1-S2-WA  [R0201]  413.21 484.08 0 top
UNK8R1109  42.2-1-S2  [R0201]  329.02 484.08 0 top
UNK8R1110  42.2-1-S2  [R0201]  330.42 484.08 0 top
UNK8R1111  42.2-1-S2  [R0201]  331.83 484.08 0 top
UNK8R1114  42.2-1-S2  [R0201]  333.23 484.08 0 top
UNK8R1115  42.2-1-S2  [R0201]  334.63 484.08 0 top
UNK8R1117  0-1-S4-YA  [R0402]  470.69 484.22 0 top
UNK8R1118  0-1-S4-YA  [R0402]  472.89 484.22 0 top
UNK8R1119  0-1-S4-YA  [R0402]  475.1 484.22 0 top
UNK8SA1  SHORT  [DEFAULT_SHORT_SMALL]  356.06 191.36 0 top
UNK8SA2  SHORT  [DEFAULT_SHORT_SMALL]  356.06 191.87 0 top
UNK8SA7  SHORT  [DEFAULT_SHORT_SMALL]  343.4 185.16 90 top
UNK8SA8  SHORT  [DEFAULT_SHORT_SMALL]  343.91 185.16 90 top
UNK8SA9  SHORT  [DEFAULT_SHORT_SMALL]  354.24 174.5 270 top
UNK8SA10  SHORT  [DEFAULT_SHORT_SMALL]  355.03 174.5 270 top
UNK8SA15  SHORT  [DEFAULT_SHORT_SMALL]  359.49 193.83 90 top
UNK8SA16  SHORT  [DEFAULT_SHORT_SMALL]  358.98 193.83 90 top
UNK8SA17  SHORT  [DEFAULT_SHORT_SMALL]  355.98 191.77 0 top
UNK8SA18  SHORT  [DEFAULT_SHORT_SMALL]  355.98 192.46 0 top
UNK8SA19  SHORT  [DEFAULT_SHORT_SMALL]  344.08 183.68 270 top
UNK8SA20  SHORT  [DEFAULT_SHORT_SMALL]  343.49 183.68 270 top
UNK8SA21  SHORT  [DEFAULT_SHORT_SMALL]  354.54 193.95 0 top
UNK8SA22  SHORT  [DEFAULT_SHORT_SMALL]  354.54 195.43 0 top
UNK8SA23  SHORT  [DEFAULT_SHORT_SMALL]  353.04 174.51 270 top
UNK8SA24  SHORT  [DEFAULT_SHORT_SMALL]  354.32 174.51 270 top
UNK8SA25  SHORT  [DEFAULT_SHORT_SMALL]  514.76 484.3 0 top
UNK8SA26  SHORT  [DEFAULT_SHORT_SMALL]  516.96 484.3 0 top
UNK8TP_DPS1  TP01  [TP_040_T]  340.48 157.07 0 top
UNK8TP_DPS2  TP01  [TP_040_T]  345.3 157.07 180 top
UNK8TP_DPS3  TP01  [TP_040_T]  350.12 153.01 180 top
UNK8TP_DPS4  TP01  [TP_040_T]  364.57 154.53 0 top
UNK8TP_DPS5  TP01  [TP_040_T]  359.75 149.86 0 top
UNK8TP_DPS6  TP01  [TP_040_T]  359.75 154.53 0 top
UNK8TP_DPS7  TP01  [TP_040_T]  340.48 153.01 0 top
UNK8TP_DPS8  TP01  [TP_040_T]  345.3 153.01 180 top
UNK8TP_DPS9  TP01  [TP_040_T]  286.74 469.82 0 top
UNK8TP_MUX_3V3  TP01  [TP_040_T]  335.65 209.49 180 top
UNK8U17  XC6203E-0.4A-33-SOT89  [SOT89]  475.5 167.55 180 bottom
UNK8U18  SK-SO8-1.27-DEDIPROG-V3  [SK_SO8_1P27MM_DEDIPROG_V3]  463.17 174.62 270 bottom
UNK8U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  485.26 174.88 270 bottom
UNK8U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  346.08 174.5 90 bottom
UNK8U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  341.84 204.24 180 bottom
UNK8U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  333.16 189.72 180 bottom
UNK8U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  333.16 178.15 180 bottom
UNK8U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  351.94 209.73 270 bottom
UNK8U455  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  352.12 465.08 0 top
UNK8U456  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  346.71 465.08 0 top
UNK8Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  354.01 161.07 0 bottom
UNK8Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  351.94 205.49 180 bottom
UNK038XS-I6K51D18Q-A100  REF-CODE-PCB  [PCB_CODE]  283.6 469.34 0 top
UNK980XS-I6K51D-1AG-  REF-CODE-PCB  [PCB_CODE]  581.38 484.07 0 top
UT1_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  167 6.98 180 top
UT1_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  189.23 6.98 180 top
UT2_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  314.32 6.98 180 top
UT2_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  336.55 6.98 180 top
UT3_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  414.65 422.27 0 top
UT3_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  392.43 422.27 0 top
UT4_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  267.33 422.27 0 top
UT4_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  245.11 422.27 0 top
UT5_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  19.69 6.98 180 top
UT5_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  41.91 6.98 180 top
UT6_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  461.64 6.98 180 top
UT6_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  483.87 6.98 180 top
UT7_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  561.97 422.27 0 top
UT7_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  539.75 422.27 0 top
UT8_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  120.01 422.27 0 top
UT8_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  97.79 422.27 0 top
UT_UP5V  TP01  [TP_040_T]  43.74 298.45 0 top
UTL1  V93K_UTL  [PG_VG93K_F_G3UTI1]  180.34 16.51 0 top
UTL2  V93K_UTL  [PG_VG93K_F_G1UTI2]  327.66 16.51 0 top
UTL3  V93K_UTL  [PG_VG93K_F_G2UTI3]  401.32 412.75 0 top
UTL4  V93K_UTL  [PG_VG93K_F_G8UTI4]  254 412.75 0 top
UTL5  V93K_UTL  [PG_VG93K_F_G4UTI5]  33.02 16.51 0 top
UTL6  V93K_UTL  [PG_VG93K_F_G5UTI6]  474.98 16.51 0 top
UTL7  V93K_UTL  [PG_VG93K_F_G6UTI7]  548.64 412.75 0 top
UTL8  V93K_UTL  [PG_VG93K_F_G7UTI8]  106.68 412.75 0 top
VP1  V93K_PROTECTOR  [PCB_CODE]  92.33 291.85 0 top
XC2  0.1U-16-X-S4-MU  [C0402]  212.98 17.59 0 bottom
Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  234.01 221.07 0 bottom
Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  238.82 271.62 90 bottom

## Library data of the parts
BD5 BD9 BD21 BD1721-BD1723 BD1728 BDB5-BDB8 MBD1 UNK2BD9 UNK2BD21 UNK2BD1728 UNK2BDB5-UNK2BDB8 UNK2MBD1 UNK3BD9 UNK3BD21 UNK3BD1728 UNK3BDB5-UNK3BDB8 UNK3MBD1 UNK4BD9 UNK4BD21 UNK4BD1728 UNK4BDB5-UNK4BDB8 UNK4MBD1 UNK5BD9 UNK5BD21 UNK5BD1728 UNK5BDB5-UNK5BDB8 UNK5MBD1 UNK6BD9 UNK6BD21 UNK6BD1728 UNK6BDB5-UNK6BDB8 UNK6MBD1 UNK7BD9 UNK7BD21 UNK7BD1728 UNK7BDB5-UNK7BDB8 UNK7MBD1 UNK8BD9 UNK8BD21 UNK8BD1728 UNK8BDB5-UNK8BDB8 UNK8MBD1 = BD120-1.5A-S4-MU: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
BGA293-9X7-P0.4 JG261002WW011 = REF-CODE-SOCKET
C262 C298 C299 C1074 CC1-CC9 CC12-CC16 CC70 CC71 CC73 CC84-CC92 CC96 CC101 CC103 CC105 CC112 CC130 CC182 CC202 CC211-CC220 UNK2C262 UNK2C298 UNK2C299 UNK2C1074 UNK2CC1-UNK2CC9 UNK2CC12-UNK2CC16 UNK2CC70 UNK2CC71 UNK2CC73 UNK2CC84-UNK2CC92 UNK2CC96 UNK2CC101 UNK2CC103 UNK2CC105 UNK2CC112 UNK2CC130 UNK2CC182 UNK2CC202 UNK2CC211-UNK2CC220 UNK3C262 UNK3C298 UNK3C299 UNK3C1074 UNK3CC1-UNK3CC9 UNK3CC12-UNK3CC16 UNK3CC70 UNK3CC71 UNK3CC73 UNK3CC84-UNK3CC92 UNK3CC96 UNK3CC101 UNK3CC103 UNK3CC105 UNK3CC112 UNK3CC130 UNK3CC182 UNK3CC202 UNK3CC211-UNK3CC220 UNK4C262 UNK4C298 UNK4C299 UNK4C1074 UNK4CC1-UNK4CC9 UNK4CC12-UNK4CC16 UNK4CC70 UNK4CC71 UNK4CC73 UNK4CC84-UNK4CC92 UNK4CC96 UNK4CC101 UNK4CC103 UNK4CC105 UNK4CC112 UNK4CC130 UNK4CC182 UNK4CC202 UNK4CC211-UNK4CC220 UNK5C262 UNK5C298 UNK5C299 UNK5C1074 UNK5CC1-UNK5CC9 UNK5CC12-UNK5CC16 UNK5CC70 UNK5CC71 UNK5CC73 UNK5CC84-UNK5CC92 UNK5CC96 UNK5CC101 UNK5CC103 UNK5CC105 UNK5CC112 UNK5CC130 UNK5CC182 UNK5CC202 UNK5CC211-UNK5CC220 UNK6C262 UNK6C298 UNK6C299 UNK6C1074 UNK6CC1-UNK6CC9 UNK6CC12-UNK6CC16 UNK6CC70 UNK6CC71 UNK6CC73 UNK6CC84-UNK6CC92 UNK6CC96 UNK6CC101 UNK6CC103 UNK6CC105 UNK6CC112 UNK6CC130 UNK6CC182 UNK6CC202 UNK6CC211-UNK6CC220 UNK7C262 UNK7C298 UNK7C299 UNK7C1074 UNK7CC1-UNK7CC9 UNK7CC12-UNK7CC16 UNK7CC70 UNK7CC71 UNK7CC73 UNK7CC84-UNK7CC92 UNK7CC96 UNK7CC101 UNK7CC103 UNK7CC105 UNK7CC112 UNK7CC130 UNK7CC182 UNK7CC202 UNK7CC211-UNK7CC220 UNK8C262 UNK8C298 UNK8C299 UNK8C1074 UNK8CC1-UNK8CC9 UNK8CC12-UNK8CC16 UNK8CC70 UNK8CC71 UNK8CC73 UNK8CC84-UNK8CC92 UNK8CC96 UNK8CC101 UNK8CC103 UNK8CC105 UNK8CC112 UNK8CC130 UNK8CC182 UNK8CC202 UNK8CC211-UNK8CC220 = 0.1U-16-X7S-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C264 C334 UNK2C264 UNK2C334 UNK3C264 UNK3C334 UNK4C264 UNK4C334 UNK5C264 UNK5C334 UNK6C264 UNK6C334 UNK7C264 UNK7C334 UNK8C264 UNK8C334 = 10U-16-X7R-S8-SS: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C267 C268 UNK2C267 UNK2C268 UNK3C267 UNK3C268 UNK4C267 UNK4C268 UNK5C267 UNK5C268 UNK6C267 UNK6C268 UNK7C267 UNK7C268 UNK8C267 UNK8C268 = 33P-50-N-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C271 C272 UNK2C271 UNK2C272 UNK3C271 UNK3C272 UNK4C271 UNK4C272 UNK5C271 UNK5C272 UNK6C271 UNK6C272 UNK7C271 UNK7C272 UNK8C271 UNK8C272 = 12P-50-N-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C278 C279 C282 C284 C301 UNK2C278 UNK2C279 UNK2C282 UNK2C284 UNK2C301 UNK3C278 UNK3C279 UNK3C282 UNK3C284 UNK3C301 UNK4C278 UNK4C279 UNK4C282 UNK4C284 UNK4C301 UNK5C278 UNK5C279 UNK5C282 UNK5C284 UNK5C301 UNK6C278 UNK6C279 UNK6C282 UNK6C284 UNK6C301 UNK7C278 UNK7C279 UNK7C282 UNK7C284 UNK7C301 UNK8C278 UNK8C279 UNK8C282 UNK8C284 UNK8C301 = 1U-10-X7S-S4-TDK: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
