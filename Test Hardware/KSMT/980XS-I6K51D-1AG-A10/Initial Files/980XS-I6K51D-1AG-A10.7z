# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#4610  -  []  312.46 190.23 90 top
NOREF#4611  -  []  90.33 162.11 0 top
NOREF#4612  -  []  333.99 182.3 90 top
NOREF#4613  -  []  474.12 238.07 0 top
NOREF#4614  -  []  365.72 467.68 0 top
NOREF#4615  -  []  335.56 180.9 90 top
NOREF#4616  -  []  164 133.8 90 top
NOREF#4617  -  []  103.28 202.51 0 top
NOREF#4618  -  []  314.21 249.57 90 top
NOREF#4619  -  []  117.45 483.84 90 top
NOREF#4620  -  []  346.84 190.05 0 top
NOREF#4621  -  []  276.24 417.57 90 top
NOREF#4622  -  []  229.94 186.26 0 top
NOREF#4623  -  []  324.21 484.4 0 top
NOREF#4624  -  []  350.16 185.37 90 top
NOREF#4625  -  []  350.16 245.37 90 top
NOREF#4626  -  []  231.4 190.05 0 top
NOREF#4627  -  []  252.78 190.69 90 top
NOREF#4628  -  []  352.25 249.57 90 top
NOREF#4629  -  []  270.62 185.85 0 top
NOREF#4630  -  []  225.43 295.89 90 top
NOREF#4631  -  []  228.03 289.54 0 top
NOREF#4632  -  []  287.53 483.75 90 top
NOREF#4633  -  []  332.54 254.22 90 top
NOREF#4634  -  []  342.56 290.08 90 top
NOREF#4635  -  []  50.61 484.08 0 top
NOREF#4636  -  []  232.13 184.72 90 top
NOREF#4637  -  []  354.75 286.43 0 top
NOREF#4638  -  []  230.62 246.5 0 top
NOREF#4639  -  []  474.97 2.28 90 top
NOREF#4640  -  []  310.74 181.59 0 top
NOREF#4641  -  []  241.08 260.08 90 top
NOREF#4642  -  []  90.89 151.25 90 top
NOREF#4643  -  []  309.04 261.34 90 top
NOREF#4644  -  []  274.75 285.63 90 top
NOREF#4645  -  []  87.91 168.91 90 top
NOREF#4646  -  []  549.44 236.7 90 top
NOREF#4647  -  []  235.12 299.77 90 top
NOREF#4648  -  []  136.49 483.84 90 top
NOREF#4649  -  []  553.49 163.32 90 top
NOREF#4650  -  []  254.36 253.12 0 top
NOREF#4651  -  []  85.87 295.23 0 top
NOREF#4652  -  []  92.33 197.21 90 top
NOREF#4653  -  []  254.2 269.34 90 top
NOREF#4654  -  []  349.85 184.37 90 top
NOREF#4655  -  []  230.62 185.85 0 top
NOREF#4656  -  []  327.02 484.4 0 top
NOREF#4657  -  []  404.15 466.58 90 top
NOREF#4658  -  []  269.01 241.77 90 top
NOREF#4659  -  []  352.26 185.65 90 top
NOREF#4660  -  []  88.89 219.95 0 top
NOREF#4661  -  []  224.09 232.66 0 top
NOREF#4662  -  []  507.23 227.57 90 top
NOREF#4663  -  []  313.56 189.57 90 top
NOREF#4664  -  []  506.92 225.81 0 top
NOREF#4665  -  []  239.77 263.72 0 top
NOREF#4666  -  []  240.39 483.75 90 top
NOREF#4667  -  []  359.52 463.08 90 top
NOREF#4668  -  []  264.42 176.56 0 top
NOREF#4669  -  []  312.13 184.72 90 top
NOREF#4670  -  []  278.78 484.08 0 top
NOREF#4671  -  []  306.91 141.04 90 top
NOREF#4672  -  []  262.56 290.08 90 top
NOREF#4673  -  []  106.74 186.2 0 top
NOREF#4674  -  []  356.23 223.88 90 top
NOREF#4675  -  []  369.83 263.63 90 top
NOREF#4676  -  []  90.33 225.61 0 top
NOREF#4677  -  []  254.31 182 0 top
NOREF#4678  -  []  227.91 182.43 90 top
NOREF#4679  -  []  313.11 190.23 90 top
NOREF#4680  -  []  471.23 158.26 0 top
NOREF#4681  -  []  232.46 190.23 90 top
NOREF#4682  -  []  350.12 467.08 0 top
NOREF#4683  -  []  211.83 170.23 315 top
NOREF#4684  -  []  264.75 484.08 0 top
NOREF#4685  -  []  253.99 193.86 90 top
NOREF#4686  -  []  38.88 483.76 90 top
NOREF#4687  -  []  355.44 254.76 90 top
NOREF#4688  -  []  229.53 240.81 90 top
NOREF#4689  -  []  462.68 158.26 0 top
NOREF#4690  -  []  479.53 158.26 0 top
NOREF#4691  -  []  317.95 138.45 90 top
NOREF#4692  -  []  222.95 292.35 90 top
NOREF#4693  -  []  223.27 173.14 0 top
NOREF#4694  -  []  333.39 183.61 0 top
NOREF#4695  -  []  345.05 145.8 90 top
NOREF#4696  -  []  461.73 186.81 90 top
NOREF#4697  -  []  312.99 484.4 0 top
NOREF#4698  -  []  270.5 183.72 90 top
NOREF#4699  -  []  508.11 227.95 90 top
NOREF#4700  -  []  38.35 142.86 0 top
NOREF#4701  -  []  268.25 233.12 0 top
NOREF#4702  -  []  321.04 135.78 0 top
NOREF#4703  -  []  231.4 250.05 0 top
NOREF#4704  -  []  300.66 484.08 0 top
NOREF#4705  -  []  271.8 190.23 90 top
NOREF#4706  -  []  345.43 295.89 90 top
NOREF#4707  -  []  101.59 156.45 0 top
NOREF#4708  -  []  315.3 190.05 0 top
NOREF#4709  -  []  346.6 190.23 90 top
NOREF#4710  -  []  357.44 253.76 90 top
NOREF#4711  -  []  97.42 198.09 0 top
NOREF#4712  -  []  254.29 243.93 0 top
NOREF#4713  -  []  220.81 187.17 90 top
NOREF#4714  -  []  347.66 245.09 0 top
NOREF#4715  -  []  243.84 272.69 90 top
NOREF#4716  -  []  85 264.21 0 top
NOREF#4717  -  []  352.2 288.28 0 top
NOREF#4718  -  []  256.91 252.91 90 top
NOREF#4719  -  []  272.26 241.11 90 top
NOREF#4720  -  []  232.23 232.39 90 top
NOREF#4721  -  []  353.1 250.23 90 top
NOREF#4722  -  []  272.04 190.05 0 top
NOREF#4723  -  []  548.24 224.4 0 top
NOREF#4724  -  []  295.38 242.3 90 top
NOREF#4725  -  []  267.71 249.57 90 top
NOREF#4726  -  []  383.14 484.4 0 top
NOREF#4727  -  []  65.94 247.71 0 top
NOREF#4728  -  []  309.5 210 0 top
NOREF#4729  -  []  270.16 245.37 90 top
NOREF#4730  -  []  354.91 164.78 0 top
NOREF#4731  -  []  225.14 299.77 0 top
NOREF#4732  -  []  221.26 254.55 0 top
NOREF#4733  -  []  310.5 250.23 90 top
NOREF#4734  -  []  307.41 133.69 0 top
NOREF#4735  -  []  541.95 210.34 90 top
NOREF#4736  -  []  233.11 243.75 90 top
NOREF#4737  -  []  487.13 250.31 90 top
NOREF#4738  -  []  235.44 194.76 90 top
NOREF#4739  -  []  334.68 183.61 0 top
NOREF#4740  -  []  102.38 236.47 0 top
NOREF#4741  -  []  255.51 192.91 90 top
NOREF#4742  -  []  210.56 240.75 0 top
NOREF#4743  -  []  97.24 246.5 90 top
NOREF#4744  -  []  537.16 484.08 0 top
NOREF#4745  -  []  38.35 169.53 0 top
NOREF#4746  -  []  225.05 146.58 0 top
NOREF#4747  -  []  559.34 164.88 0 top
NOREF#4748  -  []  300.83 271.63 0 top
NOREF#4749  -  []  308.03 294.87 0 top
NOREF#4750  -  []  302.56 290.08 90 top
NOREF#4751  -  []  530.78 483.75 90 top
NOREF#4752  -  []  120.02 164.07 90 top
NOREF#4753  -  []  404.15 467.08 0 top
NOREF#4754  -  []  55.46 268.47 0 top
NOREF#4755  -  []  255.49 254.86 90 top
NOREF#4756  -  []  87.81 240.82 0 top
NOREF#4757  -  []  335.58 194.22 90 top
NOREF#4758  -  []  294.42 249.74 90 top
NOREF#4759  -  []  48.16 247.71 0 top
NOREF#4760  -  []  406.99 484.4 0 top
NOREF#4761  -  []  509.92 227.82 0 top
NOREF#4762  -  []  80.69 260.01 90 top
NOREF#4763  -  []  276.89 133.69 0 top
NOREF#4764  -  []  316.23 223.88 90 top
NOREF#4765  -  []  67.52 246.93 90 top
NOREF#4766  -  []  311.48 246.02 90 top
NOREF#4767  -  []  348.25 233.12 0 top
NOREF#4768  -  []  351.27 239.68 90 top
NOREF#4769  -  []  350.13 207.46 90 top
NOREF#4770  -  []  538.06 483.75 90 top
NOREF#4771  -  []  535.51 220.5 90 top
NOREF#4772  -  []  376.28 462.53 90 top
NOREF#4773  -  []  346.63 241.83 90 top
NOREF#4774  -  []  234.44 141.43 0 top
NOREF#4775  -  []  272.2 288.28 0 top
NOREF#4776  -  []  275.06 250.23 90 top
NOREF#4777  -  []  303.46 484.08 0 top
NOREF#4778  -  []  224.42 236.56 0 top
NOREF#4779  -  []  47.37 253.55 90 top
NOREF#4780  -  []  335.71 252.27 0 top
NOREF#4781  -  []  327.65 2.28 90 top
NOREF#4782  -  []  230.55 134.62 90 top
NOREF#4783  -  []  295.16 191.22 90 top
NOREF#4784  -  []  36.58 484.08 0 top
NOREF#4785  -  []  482.26 226.78 0 top
NOREF#4786  -  []  340.96 235.55 90 top
NOREF#4787  -  []  237.09 266.12 90 top
NOREF#4788  -  []  214.38 254.86 0 top
NOREF#4789  -  []  228.32 179.21 0 top
NOREF#4790  -  []  87.91 200.66 90 top
NOREF#4791  -  []  194.97 286.37 90 top
NOREF#4792  -  []  294.3 190.94 90 top
NOREF#4793  -  []  458.75 140.97 0 top
NOREF#4794  -  []  79.1 290.69 0 top
NOREF#4795  -  []  480.26 179.13 0 top
NOREF#4796  -  []  271.16 183.72 90 top
NOREF#4797  -  []  260.04 483.75 90 top
NOREF#4798  -  []  542.83 148.37 0 top
NOREF#4799  -  []  502.58 226.3 0 top
NOREF#4800  -  []  229.94 245.61 0 top
NOREF#4801  -  []  271.39 190.05 0 top
NOREF#4802  -  []  308.55 238.53 90 top
NOREF#4803  -  []  352.07 483.75 90 top
NOREF#4804  -  []  353.66 209.1 90 top
NOREF#4805  -  []  232.46 250.23 90 top
NOREF#4806  -  []  508.12 225.16 90 top
NOREF#4807  -  []  352.21 183.1 0 top
NOREF#4808  -  []  329.83 165.63 90 top
NOREF#4809  -  []  271.15 250.23 90 top
NOREF#4810  -  []  309.94 246.26 0 top
NOREF#4811  -  []  80.24 252.5 0 top
NOREF#4812  -  []  318.71 141.78 90 top
NOREF#4813  -  []  313.11 250.23 90 top
NOREF#4814  -  []  485.13 160.26 0 top
NOREF#4815  -  []  485.26 206.63 0 top
NOREF#4816  -  []  73.51 280.5 90 top
NOREF#4817  -  []  210.61 240.7 0 top
NOREF#4818  -  []  279.59 140.38 90 top
NOREF#4819  -  []  263.95 173.34 90 top
NOREF#4820  -  []  120.8 484.32 0 top
NOREF#4821  -  []  383.44 484.08 0 top
NOREF#4822  -  []  359.29 484.4 0 top
NOREF#4823  -  []  212.45 238.82 0 top
NOREF#4824  -  []  314.44 138.77 0 top
NOREF#4825  -  []  231.48 185.37 90 top
NOREF#4826  -  []  315.48 299.38 0 top
NOREF#4827  -  []  525.67 484.08 0 top
NOREF#4828  -  []  270.57 210.84 0 top
NOREF#4829  -  []  527.98 483.76 90 top
NOREF#4830  -  []  458.47 236.22 0 top
NOREF#4831  -  []  313.62 183.41 0 top
NOREF#4832  -  []  273.35 190.05 0 top
NOREF#4833  -  []  269.94 186.26 0 top
NOREF#4834  -  []  94.04 249.7 0 top
NOREF#4835  -  []  291.34 183.29 0 top
NOREF#4836  -  []  355.23 163.88 90 top
NOREF#4837  -  []  293.22 238.82 0 top
NOREF#4838  -  []  224.52 288.97 0 top
NOREF#4839  -  []  276.7 297.74 0 top
NOREF#4840  -  []  213.09 254.86 90 top
NOREF#4841  -  []  333.1 180.02 0 top
NOREF#4842  -  []  270.92 184.4 0 top
NOREF#4843  -  []  215.06 243.2 0 top
NOREF#4844  -  []  329.83 203.63 90 top
NOREF#4845  -  []  311.16 246.31 90 top
NOREF#4846  -  []  316.22 286.06 90 top
NOREF#4847  -  []  401.18 483.75 90 top
NOREF#4848  -  []  97.99 188.85 90 top
NOREF#4849  -  []  274.61 297.98 90 top
NOREF#4850  -  []  260.81 235.6 90 top
NOREF#4851  -  []  238.57 231.63 90 top
NOREF#4852  -  []  295.95 483.75 90 top
NOREF#4853  -  []  226.61 250.23 90 top
NOREF#4854  -  []  254.66 192.79 0 top
NOREF#4855  -  []  235.19 208.15 90 top
NOREF#4856  -  []  298.17 209.61 90 top
NOREF#4857  -  []  461.17 165.92 0 top
NOREF#4858  -  []  271.12 183.92 90 top
NOREF#4859  -  []  13.83 484.4 0 top
NOREF#4860  -  []  79.1 276.97 0 top
NOREF#4861  -  []  463.78 224.56 0 top
NOREF#4862  -  []  354.67 462.53 90 top
NOREF#4863  -  []  463.78 161.06 0 top
NOREF#4864  -  []  233.73 243.95 90 top
R135  0-5-S4  [R0402]  238.73 225.44 180 bottom
R136  1M-1-S4  [R0402]  235.73 225.44 0 bottom
R137  0-5-S4  [R0402]  232.73 225.44 0 bottom
R160  38.3-1-S2  [R0201_MINI]  223.52 235.18 0 bottom
R161  38.3-1-S2  [R0201_MINI]  223.52 234.62 0 bottom
R162  4.7K-1-S2  [R0201_MINI]  228.01 234.55 90 bottom
R163  0-5-S2  [R0201_MINI]  223.52 233.14 0 bottom
R164  0-5-S2  [R0201_MINI]  223.52 234.06 0 bottom
R165  0-5-S2  [R0201_MINI]  228.01 233.55 90 bottom
R168  42.2-1-S2  [R0201]  240.07 261.38 0 bottom
R170  42.2-1-S2  [R0201]  240.07 262.07 0 bottom
R172  0-5-S2  [R0201]  238.7 260.4 270 top
R176  42.2-1-S2  [R0201]  240.07 263.72 0 bottom
R178  42.2-1-S2  [R0201]  240.07 263.03 0 bottom
R180  42.2-1-S2  [R0201]  228.25 261.38 0 bottom
R182  42.2-1-S2  [R0201]  228.25 262.07 0 bottom
R200  4.7K-1-S2  [R0201]  102.68 236.47 180 bottom
R201  0-5-S4  [R0402]  87.6 236.47 180 bottom
R202  NC/4.7K-1-S4  [R0402]  87.6 235.2 180 bottom
R203  4.7K-1-S2  [R0201]  102.68 233.93 180 bottom
R204  0-5-S4  [R0402]  106.28 236.47 180 bottom
R205  4.7K-1-S2  [R0201]  122.48 236.47 180 bottom
R206  NC/4.7K-1-S4  [R0402]  106.28 235.2 180 bottom
R207  4.7K-1-S2  [R0201]  122.48 233.93 180 bottom
R234  0-1-S4-YA  [R0402]  231.24 264.3 270 bottom
R331  10K-1-S2-WA  [R0201]  221.62 297.3 270 bottom
R400  249-1-S4  [R0402]  544.81 237.72 0 bottom
R401  523-1-S4  [R0402]  526.26 151.45 90 bottom
R402  1.2K-1-S4  [R0402]  523.51 150.95 0 bottom
R403  0-5-S4  [R0402]  523.49 153.29 180 bottom
R404  0-5-S4  [R0402]  524.31 145.26 180 bottom
R405  4.7K-1-S2  [R0201]  81.69 288.77 90 bottom
R406  4.7K-1-S2  [R0201]  79.4 290.69 0 bottom
R407  4.7K-1-S2  [R0201]  79.4 291.94 0 bottom
R408  4.7K-1-S2  [R0201]  84.4 292.77 180 bottom
R409  4.7K-1-S2  [R0201]  84.4 291.32 180 bottom
R410  4.7K-1-S2  [R0201]  84.4 289.86 180 bottom
R411  4.7K-1-S2  [R0201]  506.6 226.41 90 bottom
R412  4.7K-1-S2  [R0201]  509.32 230.4 180 bottom
R413  4.7K-1-S2  [R0201]  509.32 228.95 180 bottom
R414  4.7K-1-S2  [R0201]  509.32 227.5 180 bottom
R415  4.7K-1-S2  [R0201]  504.31 228.32 0 bottom
R416  4.7K-1-S2  [R0201]  504.31 229.58 0 bottom
R420  4.7K-1-S2  [R0201]  79.4 276.97 0 bottom
R422  4.7K-1-S2  [R0201]  81.69 275.06 90 bottom
R509  0-5-S4  [R0402]  249.86 271.3 90 bottom
R510  1.2K-1-S4  [R0402]  255.55 272.09 270 bottom
R511  523-1-S4  [R0402]  256.05 269.34 0 bottom
R512  0-5-S8  [R0805]  239.57 276.07 180 bottom
R589  249-1-S4  [R0402]  544.81 236.33 0 bottom
R590  249-1-S4  [R0402]  544.81 234.93 0 bottom
R591  249-1-S4  [R0402]  544.81 233.53 0 bottom
R592  249-1-S4  [R0402]  537.74 236.52 180 bottom
R593  249-1-S4  [R0402]  537.74 235.13 180 bottom
R594  249-1-S4  [R0402]  537.74 233.73 180 bottom
R595  249-1-S4  [R0402]  537.74 232.33 180 bottom
R596  249-1-S4  [R0402]  544.81 223.37 0 bottom
R597  249-1-S4  [R0402]  544.81 221.97 0 bottom
R598  249-1-S4  [R0402]  544.81 220.58 0 bottom
R599  249-1-S4  [R0402]  537.74 223.57 180 bottom
R600  249-1-S4  [R0402]  537.74 222.17 180 bottom
R601  249-1-S4  [R0402]  537.74 220.78 180 bottom
R602  249-1-S4  [R0402]  537.74 219.38 180 bottom
R603  249-1-S4  [R0402]  544.81 224.77 0 bottom
R646  42.2-1-S2  [R0201]  240.07 260.68 0 bottom
R647  42.2-1-S2  [R0201]  240.07 259.98 0 bottom
R648  4.7K-1-S2  [R0201]  79.4 278.23 0 bottom
R649  4.7K-1-S2  [R0201]  84.4 279.05 180 bottom
R650  4.7K-1-S2  [R0201]  84.4 277.6 180 bottom
R652  NC/100K-1-S4  [R0402]  247 272.71 0 bottom
R658  4.7K-1-S2  [R0201]  84.4 276.15 180 bottom
R659  10K-1-S2-WA  [R0201]  236.89 261.82 0 top
R661  4.7K-1-S2  [R0201]  236.89 262.58 180 top
R662  0-5-S2  [R0201]  226.89 260.4 270 top
R663  4.7K-1-S2  [R0201]  225.08 262.58 180 top
R664  42.2-1-S2  [R0201]  228.25 263.03 0 bottom
R666  42.2-1-S2  [R0201]  228.25 263.72 0 bottom
R672  10K-1-S2-WA  [R0201]  225.08 261.82 0 top
R709  4.7K-1-S2  [R0201]  84.4 265.34 180 bottom
R710  4.7K-1-S2  [R0201]  84.4 263.88 180 bottom
R711  4.7K-1-S2  [R0201]  79.4 264.51 0 bottom
R712  4.7K-1-S2  [R0201]  81.69 261.34 90 bottom
R713  4.7K-1-S2  [R0201]  79.4 263.26 0 bottom
R714  4.7K-1-S2  [R0201]  84.4 262.43 180 bottom
R751  249-1-S4  [R0402]  544.43 211.43 0 bottom
R752  249-1-S4  [R0402]  537.36 208.84 180 bottom
R753  249-1-S4  [R0402]  544.43 208.64 0 bottom
R754  249-1-S4  [R0402]  537.36 207.44 180 bottom
R755  249-1-S4  [R0402]  544.43 207.24 0 bottom
R756  249-1-S4  [R0402]  537.36 206.04 180 bottom
R757  249-1-S4  [R0402]  537.36 210.24 180 bottom
R758  249-1-S4  [R0402]  544.43 210.04 0 bottom
R759  249-1-S4  [R0402]  544.43 197.34 0 bottom
R766  249-1-S4  [R0402]  544.43 195.94 0 bottom
R923  100K-1-S4  [R0402]  247 271.56 0 bottom
R925  4.7K-1-S2  [R0201]  547.64 235.63 180 bottom
R926  4.7K-1-S2  [R0201]  547.64 238.42 180 bottom
R927  4.7K-1-S2  [R0201]  547.64 237.02 180 bottom
R928  4.7K-1-S2  [R0201]  547.64 234.23 180 bottom
R929  4.7K-1-S2  [R0201]  534.91 233.03 0 bottom
R930  4.7K-1-S2  [R0201]  534.91 234.43 0 bottom
R931  4.7K-1-S2  [R0201]  534.91 231.63 0 bottom
R932  4.7K-1-S2  [R0201]  534.91 235.83 0 bottom
R933  4.7K-1-S2  [R0201]  547.64 222.67 180 bottom
R934  4.7K-1-S2  [R0201]  547.64 224.07 180 bottom
R935  4.7K-1-S2  [R0201]  547.64 221.28 180 bottom
R936  4.7K-1-S2  [R0201]  547.64 225.47 180 bottom
R937  4.7K-1-S2  [R0201]  534.91 220.08 0 bottom
R938  4.7K-1-S2  [R0201]  534.91 221.48 0 bottom
R939  4.7K-1-S2  [R0201]  534.91 218.68 0 bottom
R940  4.7K-1-S2  [R0201]  534.91 222.87 0 bottom
R941  4.7K-1-S2  [R0201]  547.26 209.34 180 bottom
R942  4.7K-1-S2  [R0201]  547.26 210.74 180 bottom
R943  4.7K-1-S2  [R0201]  547.26 207.94 180 bottom
R944  4.7K-1-S2  [R0201]  547.26 212.13 180 bottom
R945  4.7K-1-S2  [R0201]  534.53 206.74 0 bottom
R946  4.7K-1-S2  [R0201]  534.53 208.14 0 bottom
R947  4.7K-1-S2  [R0201]  534.53 205.35 0 bottom
R948  4.7K-1-S2  [R0201]  534.53 209.54 0 bottom
R950  4.7K-1-S2  [R0201]  547.26 196.64 180 bottom
R952  4.7K-1-S2  [R0201]  547.26 198.04 180 bottom
R973  0-5-S4  [R0402]  245.37 272.13 270 bottom
R980  10K-1-S2-WA  [R0201]  242.73 269.89 0 bottom
R981  NC/4.7K-1-S2  [R0201]  242.73 273.73 180 bottom
R982  0-5-S2  [R0201]  241.77 274.03 270 bottom
R1088  42.2-1-S2  [R0201]  228.25 260.68 0 bottom
R1089  42.2-1-S2  [R0201]  228.25 259.98 0 bottom
R1093  4.7K-1-S2  [R0201]  506.6 208.25 90 bottom
R1097  4.7K-1-S2  [R0201]  504.31 210.17 0 bottom
R1098  4.7K-1-S2  [R0201]  212.78 239.42 270 top
R1099  42.2-1-S2  [R0201]  213.99 254.16 90 bottom
R1100  42.2-1-S2  [R0201]  213.29 254.16 90 bottom
R1101  4.7K-1-S2  [R0201]  212.78 250.99 270 top
R1102  0-5-S2  [R0201]  214.96 241.23 0 top
R1103  42.2-1-S2  [R0201]  212.33 254.16 90 bottom
R1104  0-5-S2  [R0201]  214.96 252.79 0 top
R1105  10K-1-S2-WA  [R0201]  213.54 250.99 90 top
R1106  42.2-1-S2  [R0201]  211.64 254.16 90 bottom
R1107  42.2-1-S2  [R0201]  214.68 254.16 90 bottom
R1108  10K-1-S2-WA  [R0201]  213.54 239.42 90 top
R1109  42.2-1-S2  [R0201]  215.38 254.16 90 bottom
R1110  42.2-1-S2  [R0201]  213.99 242.6 90 bottom
R1111  42.2-1-S2  [R0201]  213.29 242.6 90 bottom
R1114  42.2-1-S2  [R0201]  214.68 242.6 90 bottom
R1115  42.2-1-S2  [R0201]  215.38 242.6 90 bottom
R1117  0-1-S4-YA  [R0402]  219.43 264.3 270 bottom
R1118  0-1-S4-YA  [R0402]  208.94 246.46 180 bottom
R1119  0-1-S4-YA  [R0402]  208.94 234.89 180 bottom
RB1  10K-1-S2-WA  [R0201]  212.72 15.11 0 bottom
RB2  10K-1-S2-WA  [R0201]  212.72 13.4 0 bottom
RB501  0-5-S4  [R0402]  457.97 134.62 180 bottom
RB502  0-5-S4  [R0402]  554.49 130.81 180 bottom
RB507  0-5-S4  [R0402]  554.49 298.45 180 bottom
RB508  0-5-S4  [R0402]  452.89 298.45 180 bottom
RB509  0-5-S4  [R0402]  411.48 130.81 180 bottom
RB510  0-5-S4  [R0402]  424.18 288.29 180 bottom
RB511  0-5-S4  [R0402]  170.18 130.81 180 bottom
RB512  0-5-S4  [R0402]  157.48 288.29 0 bottom
RB513  0-5-S4  [R0402]  127.77 130.81 180 bottom
RB514  0-5-S4  [R0402]  109.99 300.99 180 bottom
RB515  0-5-S4  [R0402]  27.17 130.81 180 bottom
RB516  0-5-S4  [R0402]  27.17 298.45 180 bottom
S1_DPS_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  43.05 178.44 270 bottom
S1_DPS_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  64.64 178.44 270 bottom
S1_DPS_SW3  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  43.05 151.76 270 bottom
S1_DPS_SW4  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  64.64 151.76 270 bottom
S1_DPS_SW5  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  64.64 205.1 270 bottom
S1_DPS_SW6  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  43.05 205.1 270 bottom
S1_USER_3V3  VTP-2X1  [VTP_2P_100]  99.07 223.1 270 top
S1_VREF_OUT  TP01  [TP_040_T]  224.52 286.43 270 top
S2_USER_3V3  VTP-2X1  [VTP_2P_100]  99.07 191.35 270 top
S2_VREF_OUT  TP01  [TP_040_T]  264.52 286.43 270 top
S3_USER_3V3  VTP-2X1  [VTP_2P_100]  469.91 195.16 270 top
S3_VREF_OUT  TP01  [TP_040_T]  304.52 286.43 270 top
S4_USER_3V3  VTP-2X1  [VTP_2P_100]  469.91 226.91 270 top
S4_VREF_OUT  TP01  [TP_040_T]  344.52 286.43 270 top
S5_USER_3V3  VTP-2X1  [VTP_2P_100]  99.07 159.6 270 top
S5_VREF_OUT  TP01  [TP_040_T]  237.14 146.64 270 top
S6_USER_3V3  VTP-2X1  [VTP_2P_100]  99.07 127.85 270 top
S6_VREF_OUT  TP01  [TP_040_T]  277.14 146.64 270 top
S7_USER_3V3  VTP-2X1  [VTP_2P_100]  469.91 131.66 270 top
S7_VREF_OUT  TP01  [TP_040_T]  317.14 146.64 270 top
S8_USER_3V3  VTP-2X1  [VTP_2P_100]  469.91 163.41 270 top
S8_VREF_OUT  TP01  [TP_040_T]  357.14 146.64 270 top
SA1  SHORT  [DEFAULT_SHORT_SMALL]  225.71 251.64 180 top
SA2  SHORT  [DEFAULT_SHORT_SMALL]  225.71 252.15 180 top
SA7  SHORT  [DEFAULT_SHORT_SMALL]  224.03 245.86 90 top
SA8  SHORT  [DEFAULT_SHORT_SMALL]  225.3 245.86 90 top
SA9  SHORT  [DEFAULT_SHORT_SMALL]  226.07 238 180 top
SA10  SHORT  [DEFAULT_SHORT_SMALL]  226.07 237.49 180 top
SA15  SHORT  [DEFAULT_SHORT_SMALL]  237.49 250.16 90 top
SA16  SHORT  [DEFAULT_SHORT_SMALL]  236.98 250.16 90 top
SA17  SHORT  [DEFAULT_SHORT_SMALL]  233.21 238.53 0 top
SA18  SHORT  [DEFAULT_SHORT_SMALL]  233.21 237.92 0 top
SA19  SHORT  [DEFAULT_SHORT_SMALL]  224.08 243.68 270 top
SA20  SHORT  [DEFAULT_SHORT_SMALL]  223.49 243.68 270 top
SA21  SHORT  [DEFAULT_SHORT_SMALL]  239.27 250.18 90 top
SA22  SHORT  [DEFAULT_SHORT_SMALL]  240.54 250.2 90 top
SA23  SHORT  [DEFAULT_SHORT_SMALL]  233.41 237.52 270 top
SA24  SHORT  [DEFAULT_SHORT_SMALL]  234.06 237.52 270 top
SA25  SHORT  [DEFAULT_SHORT_SMALL]  193.84 290.35 0 top
SA26  SHORT  [DEFAULT_SHORT_SMALL]  196.04 290.35 0 top
SC1  NC  [C0402_UNBGA_V2]  48.95 250.3 0 bottom
SC2  NC  [C0402_UNBGA_V2]  38.28 250.3 180 bottom
SC3  NC  [C0402_UNBGA_V2]  46.58 254.72 0 bottom
SC4  NC  [C0402_UNBGA_V2]  48.95 248.1 0 bottom
SC5  NC  [C0402_UNBGA_V2]  40.65 254.72 180 bottom
SC6  NC  [C0402_UNBGA_V2]  38.28 248.1 180 bottom
SC7  NC  [C0402_UNBGA_V2]  66.73 250.3 0 bottom
SC8  NC  [C0402_UNBGA_V2]  56.06 250.3 180 bottom
SC9  NC  [C0402_UNBGA_V2]  64.36 254.72 0 bottom
SC10  NC  [C0402_UNBGA_V2]  66.73 248.1 0 bottom
SC11  NC  [C0402_UNBGA_V2]  58.43 254.72 180 bottom
SC12  NC  [C0402_UNBGA_V2]  56.06 248.1 180 bottom
SC13  NC  [C0402_UNBGA_V2]  64.18 272.89 0 bottom
SC14  NC  [C0402_UNBGA_V2]  66.55 268.47 0 bottom
SC15  NC  [C0402_UNBGA_V2]  55.88 268.47 180 bottom
SC16  NC  [C0402_UNBGA_V2]  58.25 272.89 180 bottom
SC17  NC  [C0402_UNBGA_V2]  66.55 266.27 0 bottom
SC18  NC  [C0402_UNBGA_V2]  55.88 266.27 180 bottom
SC19  NC  [C0402_UNBGA_V2]  46.4 272.89 0 bottom
SC20  NC  [C0402_UNBGA_V2]  48.77 268.47 0 bottom
SC21  NC  [C0402_UNBGA_V2]  38.1 268.47 180 bottom
SC22  NC  [C0402_UNBGA_V2]  40.47 272.89 180 bottom
SC23  NC  [C0402_UNBGA_V2]  48.77 266.27 0 bottom
SC24  NC  [C0402_UNBGA_V2]  38.1 266.27 180 bottom
SC25  NC  [C0402_UNBGA_V2]  566.84 171.11 0 bottom
SC26  NC  [C0402_UNBGA_V2]  569.21 166.69 0 bottom
SC27  NC  [C0402_UNBGA_V2]  558.55 166.69 180 bottom
SC28  NC  [C0402_UNBGA_V2]  560.92 171.11 180 bottom
SC29  NC  [C0402_UNBGA_V2]  569.21 164.49 0 bottom
SC30  NC  [C0402_UNBGA_V2]  558.55 164.49 180 bottom
SC31  NC  [C0402_UNBGA_V2]  550.33 171.11 0 bottom
SC32  NC  [C0402_UNBGA_V2]  552.7 166.69 0 bottom
SC33  NC  [C0402_UNBGA_V2]  542.04 166.69 180 bottom
SC34  NC  [C0402_UNBGA_V2]  544.41 171.11 180 bottom
SC35  NC  [C0402_UNBGA_V2]  552.7 164.49 0 bottom
SC36  NC  [C0402_UNBGA_V2]  542.04 164.49 180 bottom
SC37  NC  [C0402_UNBGA_V2]  550.33 154.6 0 bottom
SC38  NC  [C0402_UNBGA_V2]  552.7 150.18 0 bottom
SC39  NC  [C0402_UNBGA_V2]  542.04 150.18 180 bottom
SC40  NC  [C0402_UNBGA_V2]  544.41 154.6 180 bottom
SC41  NC  [C0402_UNBGA_V2]  552.7 147.98 0 bottom
SC42  NC  [C0402_UNBGA_V2]  542.04 147.98 180 bottom
SC43  NC  [C0402_UNBGA_V2]  566.84 154.6 0 bottom
SC44  NC  [C0402_UNBGA_V2]  569.21 150.18 0 bottom
SC45  NC  [C0402_UNBGA_V2]  558.55 150.18 180 bottom
SC46  NC  [C0402_UNBGA_V2]  560.92 154.6 180 bottom
SC47  NC  [C0402_UNBGA_V2]  569.21 147.98 0 bottom
SC48  NC  [C0402_UNBGA_V2]  558.55 147.98 180 bottom
SCREW1  V93KMFHOLE  [PG_VG93K_F_FULLOUTLINE]  290.83 214.63 0 top
SITE1  I6K51D-BGA290-9X7  [SK_TFBGA7X9_290P_0P4MM_JG]  230.83 244.63 0 top
SITE2  I6K51D-BGA290-9X7  [SK_TFBGA7X9_290P_0P4MM_JG]  270.83 244.63 0 top
SITE3  I6K51D-BGA290-9X7  [SK_TFBGA7X9_290P_0P4MM_JG]  310.83 244.63 0 top
SITE4  I6K51D-BGA290-9X7  [SK_TFBGA7X9_290P_0P4MM_JG]  350.83 244.63 0 top
SITE5  I6K51D-BGA290-9X7  [SK_TFBGA7X9_290P_0P4MM_JG]  230.83 184.63 0 top
SITE6  I6K51D-BGA290-9X7  [SK_TFBGA7X9_290P_0P4MM_JG]  270.83 184.63 0 top
SITE7  I6K51D-BGA290-9X7  [SK_TFBGA7X9_290P_0P4MM_JG]  310.83 184.63 0 top
SITE8  I6K51D-BGA290-9X7  [SK_TFBGA7X9_290P_0P4MM_JG]  350.83 184.63 0 top
SK1  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  43.62 248.5 270 bottom
SK2  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  61.4 248.5 270 bottom
SK3  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  61.22 266.67 270 bottom
SK4  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  43.44 266.67 270 bottom
SK5  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  563.88 164.89 270 bottom
SK6  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  547.37 164.89 270 bottom
SK7  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  547.37 148.38 270 bottom
SK8  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  563.88 148.38 270 bottom
SR1  0-5-S4  [R0402]  38.21 251.42 0 bottom
SR2  0-5-S4  [R0402]  49.03 251.42 180 bottom
SR3  0-5-S4  [R0402]  38.21 246.97 180 bottom
SR4  0-5-S4  [R0402]  40.58 255.86 180 bottom
SR5  0-5-S4  [R0402]  49.03 246.97 0 bottom
SR6  0-5-S4  [R0402]  46.66 255.86 0 bottom
SR7  0-5-S4  [R0402]  55.99 251.42 0 bottom
SR8  0-5-S4  [R0402]  66.81 251.42 180 bottom
SR9  0-5-S4  [R0402]  55.99 246.97 180 bottom
SR10  0-5-S4  [R0402]  58.36 255.86 180 bottom
SR11  0-5-S4  [R0402]  66.81 246.97 0 bottom
SR12  0-5-S4  [R0402]  64.44 255.86 0 bottom
SR13  0-5-S4  [R0402]  66.63 269.59 180 bottom
SR14  0-5-S4  [R0402]  66.63 265.14 0 bottom
SR15  0-5-S4  [R0402]  64.26 274.03 0 bottom
SR16  0-5-S4  [R0402]  55.81 269.59 0 bottom
SR17  0-5-S4  [R0402]  55.81 265.14 180 bottom
SR18  0-5-S4  [R0402]  58.18 274.03 180 bottom
SR19  0-5-S4  [R0402]  48.85 269.59 180 bottom
SR20  0-5-S4  [R0402]  48.85 265.14 0 bottom
SR21  0-5-S4  [R0402]  46.48 274.03 0 bottom
SR22  0-5-S4  [R0402]  38.03 269.59 0 bottom
SR23  0-5-S4  [R0402]  38.03 265.14 180 bottom
SR24  0-5-S4  [R0402]  40.4 274.03 180 bottom
SR25  0-5-S4  [R0402]  569.29 167.81 180 bottom
SR26  0-5-S4  [R0402]  569.29 163.37 0 bottom
SR27  0-5-S4  [R0402]  566.92 172.26 0 bottom
SR28  0-5-S4  [R0402]  558.47 167.81 0 bottom
SR29  0-5-S4  [R0402]  558.47 163.37 180 bottom
SR30  0-5-S4  [R0402]  560.84 172.26 180 bottom
SR31  0-5-S4  [R0402]  552.78 167.81 180 bottom
SR32  0-5-S4  [R0402]  552.78 163.37 0 bottom
SR33  0-5-S4  [R0402]  550.41 172.26 0 bottom
SR34  0-5-S4  [R0402]  541.96 167.81 0 bottom
SR35  0-5-S4  [R0402]  541.96 163.37 180 bottom
SR36  0-5-S4  [R0402]  544.33 172.26 180 bottom
SR37  0-5-S4  [R0402]  552.78 151.3 180 bottom
SR38  0-5-S4  [R0402]  552.78 146.86 0 bottom
SR39  0-5-S4  [R0402]  550.41 155.75 0 bottom
SR40  0-5-S4  [R0402]  541.96 151.3 0 bottom
SR41  0-5-S4  [R0402]  541.96 146.86 180 bottom
SR42  0-5-S4  [R0402]  544.33 155.75 180 bottom
SR43  0-5-S4  [R0402]  569.29 151.3 180 bottom
SR44  0-5-S4  [R0402]  569.29 146.86 0 bottom
SR45  0-5-S4  [R0402]  566.92 155.75 0 bottom
SR46  0-5-S4  [R0402]  558.47 151.3 0 bottom
SR47  0-5-S4  [R0402]  558.47 146.86 180 bottom
SR48  0-5-S4  [R0402]  560.84 155.75 180 bottom
SSI6K51D  REF-CODE-CHIP  [CHIP_CODE]  285.43 469.34 0 top
STP1  TP01  [TP_040_T]  37.71 252.31 0 top
STP2  TP01  [TP_040_T]  49.53 252.31 0 top
STP3  TP01  [TP_040_T]  37.71 246.08 0 top
STP4  TP01  [TP_040_T]  40.08 256.75 0 top
STP5  TP01  [TP_040_T]  49.53 246.08 0 top
STP6  TP01  [TP_040_T]  47.16 256.75 0 top
STP7  TP01  [TP_040_T]  55.49 252.31 0 top
STP8  TP01  [TP_040_T]  67.31 252.31 0 top
STP9  TP01  [TP_040_T]  55.49 246.08 0 top
STP10  TP01  [TP_040_T]  57.86 256.75 0 top
STP11  TP01  [TP_040_T]  67.31 246.08 0 top
STP12  TP01  [TP_040_T]  64.94 256.75 0 top
STP13  TP01  [TP_040_T]  64.76 274.92 0 top
STP14  TP01  [TP_040_T]  67.13 264.25 0 top
STP15  TP01  [TP_040_T]  55.31 264.25 0 top
STP16  TP01  [TP_040_T]  57.68 274.92 0 top
STP17  TP01  [TP_040_T]  55.31 270.48 0 top
STP18  TP01  [TP_040_T]  67.13 270.48 0 top
STP19  TP01  [TP_040_T]  46.98 274.92 0 top
STP20  TP01  [TP_040_T]  49.35 264.25 0 top
STP21  TP01  [TP_040_T]  37.53 264.25 0 top
STP22  TP01  [TP_040_T]  39.9 274.92 0 top
STP23  TP01  [TP_040_T]  37.53 270.48 0 top
STP24  TP01  [TP_040_T]  49.35 270.48 0 top
STP25  TP01  [TP_040_T]  567.42 173.14 0 top
STP26  TP01  [TP_040_T]  569.79 162.48 0 top
STP27  TP01  [TP_040_T]  557.97 162.48 0 top
STP28  TP01  [TP_040_T]  560.34 173.14 0 top
STP29  TP01  [TP_040_T]  557.97 168.7 0 top
STP30  TP01  [TP_040_T]  569.79 168.7 0 top
STP31  TP01  [TP_040_T]  550.91 173.14 0 top
STP32  TP01  [TP_040_T]  553.28 162.48 0 top
STP33  TP01  [TP_040_T]  541.46 162.48 0 top
STP34  TP01  [TP_040_T]  543.83 173.14 0 top
STP35  TP01  [TP_040_T]  541.46 168.7 0 top
STP36  TP01  [TP_040_T]  553.28 168.7 0 top
STP37  TP01  [TP_040_T]  550.91 156.63 0 top
STP38  TP01  [TP_040_T]  553.28 145.97 0 top
STP39  TP01  [TP_040_T]  541.46 145.97 0 top
STP40  TP01  [TP_040_T]  541.46 152.19 0 top
STP41  TP01  [TP_040_T]  543.83 156.63 0 top
STP42  TP01  [TP_040_T]  553.28 152.19 0 top
STP43  TP01  [TP_040_T]  567.42 156.63 0 top
STP44  TP01  [TP_040_T]  569.79 145.97 0 top
STP45  TP01  [TP_040_T]  557.97 145.97 0 top
STP46  TP01  [TP_040_T]  557.97 152.19 0 top
STP47  TP01  [TP_040_T]  560.34 156.63 0 top
STP48  TP01  [TP_040_T]  569.79 152.19 0 top
SW5  SW-SLIDE-8-S2.54-TRI-EN  [SW_8PX1_2P54MM_SMD]  119.31 264.16 270 top
SW10  SW-SLIDE-8-S2.54-TRI-EN  [SW_8PX1_2P54MM_SMD]  119.31 289.56 270 top
TP_DPS1  TP01  [TP_040_T]  204.47 240.03 0 top
TP_DPS2  TP01  [TP_040_T]  233.93 281.43 0 top
TP_DPS3  TP01  [TP_040_T]  215.42 285.5 0 top
TP_DPS4  TP01  [TP_040_T]  243.87 281.43 0 top
TP_DPS5  TP01  [TP_040_T]  221.51 281.43 0 top
TP_DPS6  TP01  [TP_040_T]  243.87 285.5 0 top
TP_DPS7  TP01  [TP_040_T]  215.42 281.43 0 top
TP_DPS8  TP01  [TP_040_T]  227.6 281.43 180 top
TP_DPS9  TP01  [TP_040_T]  187.25 291.19 0 top
TP_MUX_3V3  TP01  [TP_040_T]  249.86 274.73 180 top
U17  XC6203E-0.4A-33-SOT89  [SOT89]  104.66 227.24 180 bottom
U18  SK-SO8-1.27-DEDIPROG-V3  [SK_SO8_1P27MM_DEDIPROG_V3]  92.33 234.31 270 bottom
U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  114.42 234.57 270 bottom
U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  226.08 234.5 90 bottom
U70  74HC244BQ-DHVQFN20  [VQFN2P6X4P6_20P_0P5MM_EP]  541.19 235.38 180 bottom
U71  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  524.38 148.11 270 bottom
U72  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  88.54 292.21 270 bottom
U73  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  82.07 291.32 90 bottom
U74  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  75.59 291.44 90 bottom
U75  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  513.46 229.84 270 bottom
U76  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  506.98 228.95 90 bottom
U77  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  500.5 229.08 90 bottom
U79  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  82.07 277.6 90 bottom
U80  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  75.59 277.73 90 bottom
U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  252.7 271.22 180 bottom
U403  74HC244BQ-DHVQFN20  [VQFN2P6X4P6_20P_0P5MM_EP]  541.19 222.42 180 bottom
U405  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  88.54 278.49 270 bottom
U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  235.62 262.2 90 bottom
U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  223.81 262.2 90 bottom
U413  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  75.59 264.01 90 bottom
U414  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  82.07 263.88 90 bottom
U415  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  88.54 264.77 270 bottom
U434  74HC244BQ-DHVQFN20  [VQFN2P6X4P6_20P_0P5MM_EP]  540.8 209.09 180 bottom
U435  74HC244BQ-DHVQFN20  [VQFN2P6X4P6_20P_0P5MM_EP]  540.8 194.99 180 bottom
U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  243.06 271.62 180 bottom
U453  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  500.51 210.69 90 bottom
U454  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  506.98 210.79 90 bottom
U455  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  213.16 249.72 180 bottom
U456  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  213.16 238.15 180 bottom
UB1  AT24C04C-SSHM-SO8  [SO8_215X127MM]  423.69 465.15 0 top
UBIT_3V3_UP  TP01  [TP_040_T]  522.78 153.29 270 top
UNK2BD9  BD120-1.5A-S4-MU  [FB0402]  264.66 243.83 270 bottom
UNK2BD21  BD120-1.5A-S4-MU  [FB0402]  262.95 232.36 0 bottom
UNK2BD1728  BD120-1.5A-S4-MU  [FB0402]  269.83 271.82 270 bottom
UNK2BDB5  BD120-1.5A-S4-MU  [FB0402]  251.03 246.46 0 bottom
UNK2BDB6  BD120-1.5A-S4-MU  [FB0402]  251.03 234.89 0 bottom
UNK2BDB7  BD120-1.5A-S4-MU  [FB0402]  561.63 484.17 0 top
UNK2BDB8  BD120-1.5A-S4-MU  [FB0402]  543.75 484.17 0 top
UNK2C262  0.1U-16-X7S-S2-MU  [C0201]  264.41 232.06 270 bottom
UNK2C264  NC/10U-16-X7R-S8-SS  [C0805]  267.48 269.95 90 bottom
UNK2C267  33P-50-N-S2-MU  [C0201]  276.23 224.18 270 bottom
UNK2C268  33P-50-N-S2-MU  [C0201]  275.23 224.18 270 bottom
UNK2C271  12P-50-N-S4-MU  [C0402]  272.95 267.19 180 bottom
UNK2C272  12P-50-N-S4-MU  [C0402]  270.93 267.19 0 bottom
UNK2C278  1U-10-X7S-S4-TDK  [C0402]  272.87 293.11 0 bottom
UNK2C279  1U-10-X7S-S4-TDK  [C0402]  272.87 291.92 0 bottom
UNK2C280  0.1U-16-X-S4-MU  [C0402]  272.87 290.72 0 bottom
UNK2C281  0.1U-16-X-S4-MU  [C0402]  272.87 289.53 0 bottom
UNK2C282  1U-10-X7S-S4-TDK  [C0402]  278.7 286.48 270 bottom
UNK2C283  0.1U-16-X-S4-MU  [C0402]  277.54 286.48 270 bottom
UNK2C284  1U-10-X7S-S4-TDK  [C0402]  277.62 297.85 90 bottom
UNK2C285  0.1U-16-X-S4-MU  [C0402]  278.81 297.85 90 bottom
UNK2C286  0.1U-16-X-S4-MU  [C0402]  273.82 297.35 180 bottom
UNK2C288  1000P-50-X7R-S2-MU  [C0201]  273.49 295.57 270 bottom
UNK2C289  0.1U-16-X-S4-MU  [C0402]  271.21 294.81 270 bottom
UNK2C290  NC/0.1U-16-X7R-S4-TY  [C0402]  264.35 296.03 180 bottom
UNK2C298  0.1U-16-X7S-S2-MU  [C0201]  262.95 292.65 90 bottom
UNK2C299  0.1U-16-X7S-S2-MU  [C0201]  260.02 296.97 180 bottom
UNK2C300  0.1U-16-X-S4-MU  [C0402]  260.67 290.87 270 bottom
UNK2C301  1U-10-X7S-S4-TDK  [C0402]  259.51 290.87 270 bottom
UNK2C302  10P-50-N-S2-MU  [C0201]  254.98 243.61 0 bottom
UNK2C309  10P-50-N-S2-MU  [C0201]  254.98 255.18 0 bottom
UNK2C310  10P-50-N-S2-MU  [C0201]  253.69 255.18 180 bottom
UNK2C318  10P-50-N-S2-MU  [C0201]  251.94 255.18 0 bottom
UNK2C320  10P-50-N-S2-MU  [C0201]  253.69 243.61 180 bottom
UNK2C332  2.2U-16-X7R-S6-TY  [C0603]  109.1 194.9 270 bottom
UNK2C333  0.1U-16-X-S4-MU  [C0402]  107.7 195.08 270 bottom
UNK2C334  10U-16-X7R-S8-SS  [C0805]  100.08 194.78 90 bottom
UNK2C335  0.1U-16-X-S4-MU  [C0402]  101.74 194.6 90 bottom
UNK2C336  4.7U-25-X7R-S8-TY  [C0805]  87.58 208.54 270 bottom
UNK2C337  0.1U-16-X-S4-MU  [C0402]  87.6 205.99 180 bottom
UNK2C338  4.7U-25-X7R-S8-TY  [C0805]  106 208.54 270 bottom
UNK2C339  0.1U-16-X-S4-MU  [C0402]  106.03 205.99 180 bottom
UNK2C475  4.7U-6.3-X-S4-MU  [C0402]  265.86 265.11 270 bottom
UNK2C476  1U-10-X7S-S4-TDK  [C0402]  259 268.25 90 bottom
UNK2C477  10U-25-X-S6-MU  [C0603]  260.32 268.76 90 bottom
UNK2C478  22U-16-X5R-SA-SS  [C1206]  263.32 268.5 0 bottom
UNK2C922  0.1U-16-X-S4-MU  [C0402]  253.16 246.46 0 bottom
UNK2C923  0.1U-16-X-S4-MU  [C0402]  253.16 234.89 0 bottom
UNK2C924  10P-50-N-S2-MU  [C0201]  251.94 243.61 0 bottom
UNK2C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  269.58 270.27 180 bottom
UNK2C1086  10P-50-N-S2-MU  [C0201]  528.78 484.08 0 top
UNK2C1087  10P-50-N-S2-MU  [C0201]  527.38 484.08 0 top
UNK2C1088  10P-50-N-S2-MU  [C0201]  525.97 484.08 0 top
UNK2C1089  0.1U-16-X-S4-MU  [C0402]  61.13 484.22 0 top
UNK2C1090  0.1U-16-X-S4-MU  [C0402]  69.15 484.22 0 top
UNK2C1091  10P-50-N-S2-MU  [C0201]  524.57 484.08 0 top
UNK2C1093  10P-50-N-S2-MU  [C0201]  523.17 484.08 0 top
UNK2CA1  0.1U-16-X-S4-MU  [C0402]  214.86 295.91 0 bottom
UNK2CA2  10U-25-X7R-SA  [C1206]  214.86 297.94 0 bottom
UNK2CA7  10U-25-X7R-SA  [C1206]  285.12 285.5 0 bottom
UNK2CA8  0.1U-16-X-S4-MU  [C0402]  285.12 283.46 0 bottom
UNK2CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  206.72 293.29 0 bottom
UNK2CA20  10U-25-X7R-SA  [C1206]  256.67 285.5 0 bottom
UNK2CA21  0.1U-16-X-S4-MU  [C0402]  256.67 283.46 0 bottom
UNK2CA22  10U-25-X7R-SA  [C1206]  262.76 281.43 0 bottom
UNK2CA23  0.1U-16-X-S4-MU  [C0402]  262.76 279.4 0 bottom
UNK2CA24  10U-25-X7R-SA  [C1206]  256.67 281.43 0 bottom
UNK2CA25  0.1U-16-X-S4-MU  [C0402]  256.67 279.4 0 bottom
UNK2CA26  10U-25-X7R-SA  [C1206]  275.18 281.43 0 bottom
UNK2CA27  0.1U-16-X-S4-MU  [C0402]  275.18 279.4 0 bottom
UNK2CA34  10U-25-X7R-SA  [C1206]  285.12 281.43 0 bottom
UNK2CA35  0.1U-16-X-S4-MU  [C0402]  285.12 279.4 0 bottom
UNK2CA36  0.1U-16-X-S4-MU  [C0402]  268.85 279.4 0 bottom
UNK2CA37  10U-25-X7R-SA  [C1206]  268.85 281.43 0 bottom
UNK2CA38  10U-25-X7R-SA  [C1206]  201.76 484.92 0 top
UNK2CA39  0.1U-16-X-S4-MU  [C0402]  64.74 484.22 0 top
UNK2CC1  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.19 246.91 180 bottom
UNK2CC2  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.5 250.48 90 bottom
UNK2CC3  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.87 245.61 180 bottom
UNK2CC4  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.19 246.26 180 bottom
UNK2CC5  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.16 246.56 90 bottom
UNK2CC6  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.87 244.96 180 bottom
UNK2CC7  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.14 244.96 0 bottom
UNK2CC8  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.5 243.97 270 bottom
UNK2CC9  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.16 243.97 270 bottom
UNK2CC12  0.1U-16-X7S-S2-MU  [C0201_MINI]  269.85 244.62 270 bottom
UNK2CC13  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.24 241.05 180 bottom
UNK2CC14  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.46 245.61 0 bottom
UNK2CC15  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.19 245.61 180 bottom
UNK2CC16  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.84 244.96 180 bottom
UNK2CC70  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.46 242.67 270 bottom
UNK2CC71  0.1U-16-X7S-S2-MU  [C0201_MINI]  275.38 243 0 bottom
UNK2CC73  0.1U-16-X7S-S2-MU  [C0201_MINI]  267.9 242.68 90 bottom
UNK2CC84  0.1U-16-X7S-S2-MU  [C0201_MINI]  273.11 250.48 90 bottom
UNK2CC85  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.15 250.48 90 bottom
UNK2CC86  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.46 250.48 90 bottom
UNK2CC87  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.14 246.26 180 bottom
UNK2CC88  0.1U-16-X7S-S2-MU  [C0201_MINI]  273.11 244 270 bottom
UNK2CC89  0.1U-16-X7S-S2-MU  [C0201_MINI]  267.9 244.66 270 bottom
UNK2CC90  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.8 250.48 90 bottom
UNK2CC91  0.1U-16-X7S-S2-MU  [C0201_MINI]  274.06 243.65 0 bottom
UNK2CC92  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.45 244 270 bottom
UNK2CC96  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.51 247.56 180 bottom
UNK2CC101  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.84 240.4 0 bottom
UNK2CC103  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.81 242.02 90 bottom
UNK2CC105  0.1U-16-X7S-S2-MU  [C0201_MINI]  272.46 240.72 270 bottom
UNK2CC112  0.1U-16-X7S-S2-MU  [C0201_MINI]  275.06 250.48 90 bottom
UNK2CC130  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.24 241.7 180 bottom
UNK2CC182  0.1U-16-X7S-S2-MU  [C0201_MINI]  266.61 250.48 90 bottom
UNK2CC195  4.7U-25-X7R-S8-TY  [C0805]  170.94 484.67 0 top
UNK2CC202  0.1U-16-X7S-S2-MU  [C0201_MINI]  266.28 245.61 180 bottom
UNK2CC211  0.1U-16-X7S-S2-MU  [C0201_MINI]  270.5 242.02 90 bottom
UNK2CC212  0.1U-16-X7S-S2-MU  [C0201_MINI]  269.53 241.06 180 bottom
UNK2CC213  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.16 242.02 90 bottom
UNK2CC214  0.1U-16-X7S-S2-MU  [C0201_MINI]  112.81 484.08 0 top
UNK2CC215  0.1U-16-X7S-S2-MU  [C0201_MINI]  271.81 239.42 90 bottom
UNK2CC216  0.1U-16-X7S-S2-MU  [C0201_MINI]  268.55 238.78 270 bottom
UNK2CC217  0.1U-16-X7S-S2-MU  [C0201_MINI]  114.21 484.08 0 top
UNK2CC218  0.1U-16-X7S-S2-MU  [C0201_MINI]  115.62 484.08 0 top
UNK2CC219  0.1U-16-X7S-S2-MU  [C0201_MINI]  117.02 484.08 0 top
UNK2CC220  0.1U-16-X7S-S2-MU  [C0201_MINI]  118.42 484.08 0 top
UNK2K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  119.04 216.35 90 bottom
UNK2K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  112.69 216.35 90 bottom
UNK2K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  106.34 216.35 90 bottom
UNK2K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  99.99 216.35 90 bottom
UNK2K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  93.64 216.35 90 bottom
UNK2K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  87.29 216.35 90 bottom
UNK2K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  271.94 258.56 90 bottom
UNK2K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  275.73 231.79 270 bottom
UNK2K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  176.53 269.24 90 bottom
UNK2K96  EC2-5NJ  [RL_NECEC2_10P_5V]  205.22 279.19 270 bottom
UNK2MBD1  BD120-1.5A-S4-MU  [FB0402]  262.95 294.3 270 bottom
UNK2MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  265.87 288.33 180 bottom
UNK2MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  265.87 293.67 180 bottom
UNK2MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  265.87 285.79 180 bottom
UNK2MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  265.87 291 180 bottom
UNK2MR1  1M-1-S4  [R0402_UNBGA_V2]  276.22 286.48 270 bottom
UNK2MR2  1K-0.01-S4  [R0402_UNBGA_V2]  275.91 297.35 180 bottom
UNK2MR3  1K-0.01-S4  [R0402_UNBGA_V2]  273.82 298.37 180 bottom
UNK2MR4  1K-0.01-S4  [R0402_UNBGA_V2]  273.82 299.38 180 bottom
UNK2MR5  1K-0.01-S4  [R0402_UNBGA_V2]  275.91 299.38 0 bottom
UNK2MR6  1K-0.01-S4  [R0402_UNBGA_V2]  275.91 298.37 0 bottom
UNK2MR7  332K-1-S4  [R0402_UNBGA_V2]  275.21 285.63 90 bottom
UNK2MR8  1K-0.01-S4  [R0402_UNBGA_V2]  264.35 299.38 180 bottom
UNK2MR9  499-0.1-S4  [R0402]  264.35 298.27 180 bottom
UNK2MR10  0-5-S4  [R0402]  264.35 297.15 0 bottom
UNK2MR11  750-1-S4  [R0402]  269.3 288.97 180 bottom
UNK2MR12  360-1-S6  [R0603]  269.68 287.7 180 bottom
UNK2MR13  750-1-S4  [R0402]  269.3 294.3 180 bottom
UNK2MR14  1.2K-1-S4  [R0402]  269.05 286.43 0 bottom
UNK2MR15  360-1-S6  [R0603]  269.68 293.03 180 bottom
UNK2MR16  750-1-S4  [R0402]  269.3 291.64 180 bottom
UNK2MR17  360-1-S6  [R0603]  269.68 290.37 180 bottom
UNK2MR18  11K-0.1-S4  [R0402]  261.81 290.87 270 bottom
UNK2MR19  1K-0.01-S4  [R0402_UNBGA_V2]  262.95 290.87 90 bottom
UNK2MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  273.15 287.63 90 bottom
UNK2MU2  KSMT004-SO8  [SO8_244X127MM]  278.06 292.02 90 bottom
UNK2MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  268.92 297.48 180 bottom
UNK2MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  260.67 294.3 0 bottom
UNK2R135  0-5-S4  [R0402]  278.73 225.44 180 bottom
UNK2R136  1M-1-S4  [R0402]  275.73 225.44 0 bottom
UNK2R137  0-5-S4  [R0402]  272.73 225.44 0 bottom
UNK2R160  38.3-1-S2  [R0201_MINI]  263.52 235.18 0 bottom
UNK2R161  38.3-1-S2  [R0201_MINI]  263.52 234.62 0 bottom
UNK2R162  4.7K-1-S2  [R0201_MINI]  268.01 234.55 90 bottom
UNK2R163  0-5-S2  [R0201_MINI]  263.52 233.14 0 bottom
UNK2R164  0-5-S2  [R0201_MINI]  263.52 234.06 0 bottom
UNK2R165  0-5-S2  [R0201_MINI]  268.01 233.55 90 bottom
UNK2R168  42.2-1-S2  [R0201]  253.99 254.16 90 bottom
UNK2R170  42.2-1-S2  [R0201]  253.29 254.16 90 bottom
UNK2R172  0-5-S2  [R0201]  254.96 252.79 0 top
UNK2R176  42.2-1-S2  [R0201]  251.64 254.16 90 bottom
UNK2R178  42.2-1-S2  [R0201]  252.33 254.16 90 bottom
UNK2R180  42.2-1-S2  [R0201]  253.99 242.6 90 bottom
UNK2R182  42.2-1-S2  [R0201]  253.29 242.6 90 bottom
UNK2R200  4.7K-1-S2  [R0201]  102.68 204.72 180 bottom
UNK2R201  0-5-S4  [R0402]  87.6 204.72 180 bottom
UNK2R202  NC/4.7K-1-S4  [R0402]  87.6 203.45 180 bottom
UNK2R203  4.7K-1-S2  [R0201]  102.68 202.18 180 bottom
UNK2R204  0-5-S4  [R0402]  106.28 204.72 180 bottom
UNK2R205  4.7K-1-S2  [R0201]  122.48 204.72 180 bottom
UNK2R206  NC/4.7K-1-S4  [R0402]  106.28 203.45 180 bottom
UNK2R207  4.7K-1-S2  [R0201]  122.48 202.18 180 bottom
UNK2R234  0-1-S4-YA  [R0402]  424.42 484.22 0 top
UNK2R331  10K-1-S2-WA  [R0201]  261.62 297.3 270 bottom
UNK2R509  0-5-S4  [R0402]  259 264.31 90 bottom
UNK2R510  1.2K-1-S4  [R0402]  264.69 265.11 270 bottom
UNK2R511  523-1-S4  [R0402]  265.19 262.36 0 bottom
UNK2R512  0-5-S8  [R0805]  267.48 266.24 270 bottom
UNK2R646  42.2-1-S2  [R0201]  254.68 254.16 90 bottom
UNK2R647  42.2-1-S2  [R0201]  255.38 254.16 90 bottom
UNK2R652  NC/100K-1-S4  [R0402]  270.85 273.67 90 bottom
UNK2R659  10K-1-S2-WA  [R0201]  253.54 250.99 90 top
UNK2R661  4.7K-1-S2  [R0201]  252.78 250.99 270 top
UNK2R662  0-5-S2  [R0201]  254.96 241.23 0 top
UNK2R663  4.7K-1-S2  [R0201]  252.78 239.42 270 top
UNK2R664  42.2-1-S2  [R0201]  252.33 242.6 90 bottom
UNK2R666  42.2-1-S2  [R0201]  251.64 242.6 90 bottom
UNK2R672  10K-1-S2-WA  [R0201]  253.54 239.42 90 top
UNK2R923  100K-1-S4  [R0402]  272 273.67 90 bottom
UNK2R973  0-5-S4  [R0402]  271.42 272.04 0 bottom
UNK2R980  10K-1-S2-WA  [R0201]  273.66 269.4 90 bottom
UNK2R981  NC/4.7K-1-S2  [R0201]  269.83 269.4 270 bottom
UNK2R982  0-5-S2  [R0201]  269.53 268.44 0 bottom
UNK2R1088  42.2-1-S2  [R0201]  254.68 242.6 90 bottom
UNK2R1089  42.2-1-S2  [R0201]  255.38 242.6 90 bottom
UNK2R1098  4.7K-1-S2  [R0201]  350.07 484.08 0 top
UNK2R1099  42.2-1-S2  [R0201]  236.99 484.08 0 top
UNK2R1100  42.2-1-S2  [R0201]  238.39 484.08 0 top
UNK2R1101  4.7K-1-S2  [R0201]  351.47 484.08 0 top
UNK2R1102  0-5-S2  [R0201]  372.52 484.08 0 top
UNK2R1103  42.2-1-S2  [R0201]  239.79 484.08 0 top
UNK2R1104  0-5-S2  [R0201]  373.92 484.08 0 top
UNK2R1105  10K-1-S2-WA  [R0201]  394.96 484.08 0 top
UNK2R1106  42.2-1-S2  [R0201]  241.2 484.08 0 top
UNK2R1107  42.2-1-S2  [R0201]  242.6 484.08 0 top
UNK2R1108  10K-1-S2-WA  [R0201]  396.37 484.08 0 top
UNK2R1109  42.2-1-S2  [R0201]  244 484.08 0 top
UNK2R1110  42.2-1-S2  [R0201]  245.4 484.08 0 top
UNK2R1111  42.2-1-S2  [R0201]  246.81 484.08 0 top
UNK2R1114  42.2-1-S2  [R0201]  248.21 484.08 0 top
UNK2R1115  42.2-1-S2  [R0201]  249.61 484.08 0 top
UNK2R1117  0-1-S4-YA  [R0402]  417.81 484.22 0 top
UNK2R1118  0-1-S4-YA  [R0402]  420.02 484.22 0 top
UNK2R1119  0-1-S4-YA  [R0402]  422.22 484.22 0 top
UNK2SA1  SHORT  [DEFAULT_SHORT_SMALL]  265.71 251.64 180 top
UNK2SA2  SHORT  [DEFAULT_SHORT_SMALL]  265.71 252.15 180 top
UNK2SA7  SHORT  [DEFAULT_SHORT_SMALL]  264.03 245.86 90 top
UNK2SA8  SHORT  [DEFAULT_SHORT_SMALL]  265.3 245.86 90 top
UNK2SA9  SHORT  [DEFAULT_SHORT_SMALL]  266.07 238 180 top
UNK2SA10  SHORT  [DEFAULT_SHORT_SMALL]  266.07 237.49 180 top
UNK2SA15  SHORT  [DEFAULT_SHORT_SMALL]  277.49 250.16 90 top
UNK2SA16  SHORT  [DEFAULT_SHORT_SMALL]  276.98 250.16 90 top
UNK2SA17  SHORT  [DEFAULT_SHORT_SMALL]  273.21 238.53 0 top
UNK2SA18  SHORT  [DEFAULT_SHORT_SMALL]  273.21 237.92 0 top
UNK2SA19  SHORT  [DEFAULT_SHORT_SMALL]  264.08 243.68 270 top
UNK2SA20  SHORT  [DEFAULT_SHORT_SMALL]  263.49 243.68 270 top
UNK2SA21  SHORT  [DEFAULT_SHORT_SMALL]  279.27 250.18 90 top
UNK2SA22  SHORT  [DEFAULT_SHORT_SMALL]  280.54 250.2 90 top
UNK2SA23  SHORT  [DEFAULT_SHORT_SMALL]  273.41 237.52 270 top
UNK2SA24  SHORT  [DEFAULT_SHORT_SMALL]  274.06 237.52 270 top
UNK2SA25  SHORT  [DEFAULT_SHORT_SMALL]  488.32 484.3 0 top
UNK2SA26  SHORT  [DEFAULT_SHORT_SMALL]  490.52 484.3 0 top
UNK2TP_DPS1  TP01  [TP_040_T]  213.61 297.94 0 top
UNK2TP_DPS2  TP01  [TP_040_T]  273.93 281.43 0 top
UNK2TP_DPS3  TP01  [TP_040_T]  255.42 285.5 0 top
UNK2TP_DPS4  TP01  [TP_040_T]  283.87 281.43 0 top
UNK2TP_DPS5  TP01  [TP_040_T]  261.51 281.43 0 top
UNK2TP_DPS6  TP01  [TP_040_T]  283.87 285.5 0 top
UNK2TP_DPS7  TP01  [TP_040_T]  255.42 281.43 0 top
UNK2TP_DPS8  TP01  [TP_040_T]  267.6 281.43 180 top
UNK2TP_DPS9  TP01  [TP_040_T]  572.17 484.56 0 top
UNK2TP_MUX_3V3  TP01  [TP_040_T]  258.74 268 180 top
UNK2U17  XC6203E-0.4A-33-SOT89  [SOT89]  104.66 195.49 180 bottom
UNK2U18  SK-SO8-1.27-DEDIPROG-V3  [SK_SO8_1P27MM_DEDIPROG_V3]  92.33 202.56 270 bottom
UNK2U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  114.42 202.82 270 bottom
UNK2U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  266.08 234.5 90 bottom
UNK2U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  261.84 264.24 180 bottom
UNK2U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  253.16 249.72 180 bottom
UNK2U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  253.16 238.15 180 bottom
UNK2U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  271.94 269.73 270 bottom
UNK2U455  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  416.95 465.08 0 top
UNK2U456  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  411.55 465.08 0 top
UNK2Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  274.01 221.07 0 bottom
UNK2Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  271.94 265.49 180 bottom
UNK3BD9  BD120-1.5A-S4-MU  [FB0402]  304.65 243.83 270 bottom
UNK3BD21  BD120-1.5A-S4-MU  [FB0402]  302.95 232.36 0 bottom
UNK3BD1728  BD120-1.5A-S4-MU  [FB0402]  309.83 271.82 270 bottom
UNK3BDB5  BD120-1.5A-S4-MU  [FB0402]  291.03 246.46 0 bottom
UNK3BDB6  BD120-1.5A-S4-MU  [FB0402]  291.03 234.89 0 bottom
UNK3BDB7  BD120-1.5A-S4-MU  [FB0402]  545.98 484.17 0 top
UNK3BDB8  BD120-1.5A-S4-MU  [FB0402]  548.22 484.17 0 top
UNK3C262  0.1U-16-X7S-S2-MU  [C0201]  304.41 232.06 270 bottom
UNK3C264  NC/10U-16-X7R-S8-SS  [C0805]  307.48 269.95 90 bottom
UNK3C267  33P-50-N-S2-MU  [C0201]  316.23 224.18 270 bottom
UNK3C268  33P-50-N-S2-MU  [C0201]  315.23 224.18 270 bottom
UNK3C271  12P-50-N-S4-MU  [C0402]  312.95 267.19 180 bottom
UNK3C272  12P-50-N-S4-MU  [C0402]  310.93 267.19 0 bottom
UNK3C278  1U-10-X7S-S4-TDK  [C0402]  312.87 293.11 0 bottom
UNK3C279  1U-10-X7S-S4-TDK  [C0402]  312.87 291.92 0 bottom
UNK3C280  0.1U-16-X-S4-MU  [C0402]  312.87 290.72 0 bottom
UNK3C281  0.1U-16-X-S4-MU  [C0402]  312.87 289.53 0 bottom
UNK3C282  1U-10-X7S-S4-TDK  [C0402]  318.7 286.48 270 bottom
UNK3C283  0.1U-16-X-S4-MU  [C0402]  317.54 286.48 270 bottom
UNK3C284  1U-10-X7S-S4-TDK  [C0402]  317.62 297.85 90 bottom
UNK3C285  0.1U-16-X-S4-MU  [C0402]  318.81 297.85 90 bottom
UNK3C286  0.1U-16-X-S4-MU  [C0402]  313.82 297.35 180 bottom
UNK3C288  1000P-50-X7R-S2-MU  [C0201]  313.49 295.57 270 bottom
UNK3C289  0.1U-16-X-S4-MU  [C0402]  311.21 294.81 270 bottom
UNK3C290  NC/0.1U-16-X7R-S4-TY  [C0402]  304.35 296.03 180 bottom
UNK3C298  0.1U-16-X7S-S2-MU  [C0201]  302.95 292.65 90 bottom
UNK3C299  0.1U-16-X7S-S2-MU  [C0201]  300.02 296.97 180 bottom
UNK3C300  0.1U-16-X-S4-MU  [C0402]  300.67 290.87 270 bottom
UNK3C301  1U-10-X7S-S4-TDK  [C0402]  299.51 290.87 270 bottom
UNK3C302  10P-50-N-S2-MU  [C0201]  294.98 243.61 0 bottom
UNK3C309  10P-50-N-S2-MU  [C0201]  294.98 255.18 0 bottom
UNK3C310  10P-50-N-S2-MU  [C0201]  293.69 255.18 180 bottom
UNK3C318  10P-50-N-S2-MU  [C0201]  291.94 255.18 0 bottom
UNK3C320  10P-50-N-S2-MU  [C0201]  293.69 243.61 180 bottom
UNK3C332  2.2U-16-X7R-S6-TY  [C0603]  479.94 198.71 270 bottom
UNK3C333  0.1U-16-X-S4-MU  [C0402]  478.54 198.89 270 bottom
UNK3C334  10U-16-X7R-S8-SS  [C0805]  470.92 198.59 90 bottom
UNK3C335  0.1U-16-X-S4-MU  [C0402]  472.58 198.41 90 bottom
UNK3C336  4.7U-25-X7R-S8-TY  [C0805]  458.42 212.35 270 bottom
UNK3C337  0.1U-16-X-S4-MU  [C0402]  458.44 209.8 180 bottom
UNK3C338  4.7U-25-X7R-S8-TY  [C0805]  476.84 212.35 270 bottom
UNK3C339  0.1U-16-X-S4-MU  [C0402]  476.87 209.8 180 bottom
UNK3C475  4.7U-6.3-X-S4-MU  [C0402]  305.86 265.11 270 bottom
UNK3C476  1U-10-X7S-S4-TDK  [C0402]  299 268.25 90 bottom
