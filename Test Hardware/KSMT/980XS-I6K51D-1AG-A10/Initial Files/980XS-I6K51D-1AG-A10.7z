# Allegro board 980XS-I6K51D-1119-2.brd (continued)
## Library data of the parts (continued)
C280 C281 C283 C285 C286 C289 C290 C300 C333 C335 C337 C339 C401 C406 C408-C411 C413 C415 C417 C894 C910 C922 C923 C955 C957 C958 C983 C985 C1082 C1083 C1089 C1090 CA1 CA8 CA21 CA23 CA25 CA27 CA35 CA36 CA39 UNK2C280 UNK2C281 UNK2C283 UNK2C285 UNK2C286 UNK2C289 UNK2C290 UNK2C300 UNK2C333 UNK2C335 UNK2C337 UNK2C339 UNK2C922 UNK2C923 UNK2C1089 UNK2C1090 UNK2CA1 UNK2CA8 UNK2CA21 UNK2CA23 UNK2CA25 UNK2CA27 UNK2CA35 UNK2CA36 UNK2CA39 UNK3C280 UNK3C281 UNK3C283 UNK3C285 UNK3C286 UNK3C289 UNK3C290 UNK3C300 UNK3C333 UNK3C335 UNK3C337 UNK3C339 UNK3C922 UNK3C923 UNK3C1089 UNK3C1090 UNK3CA1 UNK3CA8 UNK3CA21 UNK3CA23 UNK3CA25 UNK3CA27 UNK3CA35 UNK3CA36 UNK3CA39 UNK4C280 UNK4C281 UNK4C283 UNK4C285 UNK4C286 UNK4C289 UNK4C290 UNK4C300 UNK4C333 UNK4C335 UNK4C337 UNK4C339 UNK4C922 UNK4C923 UNK4C1089 UNK4C1090 UNK4CA1 UNK4CA8 UNK4CA21 UNK4CA23 UNK4CA25 UNK4CA27 UNK4CA35 UNK4CA36 UNK4CA39 UNK5C280 UNK5C281 UNK5C283 UNK5C285 UNK5C286 UNK5C289 UNK5C290 UNK5C300 UNK5C333 UNK5C335 UNK5C337 UNK5C339 UNK5C922 UNK5C923 UNK5C1089 UNK5C1090 UNK5CA1 UNK5CA8 UNK5CA21 UNK5CA23 UNK5CA25 UNK5CA27 UNK5CA35 UNK5CA36 UNK5CA39 UNK6C280 UNK6C281 UNK6C283 UNK6C285 UNK6C286 UNK6C289 UNK6C290 UNK6C300 UNK6C333 UNK6C335 UNK6C337 UNK6C339 UNK6C922 UNK6C923 UNK6C1089 UNK6C1090 UNK6CA1 UNK6CA8 UNK6CA21 UNK6CA23 UNK6CA25 UNK6CA27 UNK6CA35 UNK6CA36 UNK6CA39 UNK7C280 UNK7C281 UNK7C283 UNK7C285 UNK7C286 UNK7C289 UNK7C290 UNK7C300 UNK7C333 UNK7C335 UNK7C337 UNK7C339 UNK7C922 UNK7C923 UNK7C1089 UNK7C1090 UNK7CA1 UNK7CA8 UNK7CA21 UNK7CA23 UNK7CA25 UNK7CA27 UNK7CA35 UNK7CA36 UNK7CA39 UNK8C280 UNK8C281 UNK8C283 UNK8C285 UNK8C286 UNK8C289 UNK8C290 UNK8C300 UNK8C333 UNK8C335 UNK8C337 UNK8C339 UNK8C922 UNK8C923 UNK8C1089 UNK8C1090 UNK8CA1 UNK8CA8 UNK8CA21 UNK8CA23 UNK8CA25 UNK8CA27 UNK8CA35 UNK8CA36 UNK8CA39 XC2 = 0.1U-16-X-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C288 UNK2C288 UNK3C288 UNK4C288 UNK5C288 UNK6C288 UNK7C288 UNK8C288 = 1000P-50-X7R-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C302 C309 C310 C318 C320 C924 C1086-C1088 C1091 C1093 UNK2C302 UNK2C309 UNK2C310 UNK2C318 UNK2C320 UNK2C924 UNK2C1086-UNK2C1088 UNK2C1091 UNK2C1093 UNK3C302 UNK3C309 UNK3C310 UNK3C318 UNK3C320 UNK3C924 UNK3C1086-UNK3C1088 UNK3C1091 UNK3C1093 UNK4C302 UNK4C309 UNK4C310 UNK4C318 UNK4C320 UNK4C924 UNK4C1086-UNK4C1088 UNK4C1091 UNK4C1093 UNK5C302 UNK5C309 UNK5C310 UNK5C318 UNK5C320 UNK5C924 UNK5C1086-UNK5C1088 UNK5C1091 UNK5C1093 UNK6C302 UNK6C309 UNK6C310 UNK6C318 UNK6C320 UNK6C924 UNK6C1086-UNK6C1088 UNK6C1091 UNK6C1093 UNK7C302 UNK7C309 UNK7C310 UNK7C318 UNK7C320 UNK7C924 UNK7C1086-UNK7C1088 UNK7C1091 UNK7C1093 UNK8C302 UNK8C309 UNK8C310 UNK8C318 UNK8C320 UNK8C924 UNK8C1086-UNK8C1088 UNK8C1091 UNK8C1093 = 10P-50-N-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C332 UNK2C332 UNK3C332 UNK4C332 UNK5C332 UNK6C332 UNK7C332 UNK8C332 = 2.2U-16-X7R-S6-TY: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C336 C338 CC195 UNK2C336 UNK2C338 UNK2CC195 UNK3C336 UNK3C338 UNK3CC195 UNK4C336 UNK4C338 UNK4CC195 UNK5C336 UNK5C338 UNK5CC195 UNK6C336 UNK6C338 UNK6CC195 UNK7C336 UNK7C338 UNK7CC195 UNK8C336 UNK8C338 UNK8CC195 = 4.7U-25-X7R-S8-TY: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C400 C407 C412 C416 C895 C956 C984 C986 C1085 = 2.2U-10-X-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C402 C475 UNK2C475 UNK3C475 UNK4C475 UNK5C475 UNK6C475 UNK7C475 UNK8C475 = 4.7U-6.3-X-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C403 C478 UNK2C478 UNK3C478 UNK4C478 UNK5C478 UNK6C478 UNK7C478 UNK8C478 = 22U-16-X5R-SA-SS: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C404 C477 UNK2C477 UNK3C477 UNK4C477 UNK5C477 UNK6C477 UNK7C477 UNK8C477 = 10U-25-X-S6-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C405 C476 UNK2C476 UNK3C476 UNK4C476 UNK5C476 UNK6C476 UNK7C476 UNK8C476 = 1U-10-X-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CA2 CA7 CA20 CA22 CA24 CA26 CA34 CA37 CA38 CB2 CB4 CB6 CB8 CB10 CB12 CB14 CB16 UNK2CA2 UNK2CA7 UNK2CA20 UNK2CA22 UNK2CA24 UNK2CA26 UNK2CA34 UNK2CA37 UNK2CA38 UNK3CA2 UNK3CA7 UNK3CA20 UNK3CA22 UNK3CA24 UNK3CA26 UNK3CA34 UNK3CA37 UNK3CA38 UNK4CA2 UNK4CA7 UNK4CA20 UNK4CA22 UNK4CA24 UNK4CA26 UNK4CA34 UNK4CA37 UNK4CA38 UNK5CA2 UNK5CA7 UNK5CA20 UNK5CA22 UNK5CA24 UNK5CA26 UNK5CA34 UNK5CA37 UNK5CA38 UNK6CA2 UNK6CA7 UNK6CA20 UNK6CA22 UNK6CA24 UNK6CA26 UNK6CA34 UNK6CA37 UNK6CA38 UNK7CA2 UNK7CA7 UNK7CA20 UNK7CA22 UNK7CA24 UNK7CA26 UNK7CA34 UNK7CA37 UNK7CA38 UNK8CA2 UNK8CA7 UNK8CA20 UNK8CA22 UNK8CA24 UNK8CA26 UNK8CA34 UNK8CA37 UNK8CA38 = 10U-25-X7R-SA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CA19 UNK2CA19 UNK3CA19 UNK4CA19 UNK5CA19 UNK6CA19 UNK7CA19 UNK8CA19 = 470U-25-E-S10.4X10.4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB1 CB3 CB5 CB7 CB9 CB11 CB13 CB15 = 0.1U-25-X-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CON1 = MS-PWR-CONN-30P-V3-SI6D70: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
CSDPS303 CSDPS307 CSDPS319 CSDPS323 = V93K_CSDPS_DPS32: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CSDPS310 CSDPS314 = V93K_CSDPS_DPS32: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
CSDPS426 CSDPS430 = V93K_CSDPS_A: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
D101-D132 D201-D225 D227-D229 D231 D232 D325-D332 D409-D425 D427-D429 D431 D432 = V93K_CH: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
D226/D626 D230/D630 = V93K_PS1600_HD: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
DPS1-DPS3 DPS8 = V93K_DPS: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
FD1-FD16 = FD_040_V2: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
H1-H4 = M3-HOLE: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
J1 J2 = HDR-2X1-M: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
JP1 = A2001WV0-4PS_V2: Tolerance: TOL; User Part Number: PAXXXXXXXXXX
K2-K7 UNK2K2-UNK2K7 UNK3K2-UNK3K7 UNK4K2-UNK4K7 UNK5K2-UNK5K7 UNK6K2-UNK6K7 UNK7K2-UNK7K7 UNK8K2-UNK8K7 = UA2-5NJ-A-V3: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
K29 K32 UNK2K29 UNK2K32 UNK3K29 UNK3K32 UNK4K29 UNK4K32 UNK5K29 UNK5K32 UNK6K29 UNK6K32 UNK7K29 UNK7K32 UNK8K29 UNK8K32 = G6K-2F-Y-5V-A: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
K34 K109 K110 SK1-SK8 UNK2K34 UNK3K34 UNK4K34 UNK5K34 UNK6K34 UNK7K34 UNK8K34 = G6K-2P-Y5VDC-A: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
K96 UNK2K96 UNK3K96 UNK4K96 UNK5K96 UNK6K96 UNK7K96 UNK8K96 = EC2-5NJ: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
LDB1 = LDG-2-S8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
LOGO1 = LOGO_MS_Morningstar
LOGO2 = LOGO_KT_KSMT
LRB1 = 330-1-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MK1-MK4 UNK2MK1-UNK2MK4 UNK3MK1-UNK3MK4 UNK4MK1-UNK4MK4 UNK5MK1-UNK5MK4 UNK6MK1-UNK6MK4 UNK7MK1-UNK7MK4 UNK8MK1-UNK8MK4 = AQY221R2MY-V2: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR1 R136 UNK2MR1 UNK2R136 UNK3MR1 UNK3R136 UNK4MR1 UNK4R136 UNK5MR1 UNK5R136 UNK6MR1 UNK6R136 UNK7MR1 UNK7R136 UNK8MR1 UNK8R136 = 1M-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR2-MR6 MR8 MR19 UNK2MR2-UNK2MR6 UNK2MR8 UNK2MR19 UNK3MR2-UNK3MR6 UNK3MR8 UNK3MR19 UNK4MR2-UNK4MR6 UNK4MR8 UNK4MR19 UNK5MR2-UNK5MR6 UNK5MR8 UNK5MR19 UNK6MR2-UNK6MR6 UNK6MR8 UNK6MR19 UNK7MR2-UNK7MR6 UNK7MR8 UNK7MR19 UNK8MR2-UNK8MR6 UNK8MR8 UNK8MR19 = 1K-0.01-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR7 UNK2MR7 UNK3MR7 UNK4MR7 UNK5MR7 UNK6MR7 UNK7MR7 UNK8MR7 = 332K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR9 UNK2MR9 UNK3MR9 UNK4MR9 UNK5MR9 UNK6MR9 UNK7MR9 UNK8MR9 = 499-0.1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR10 R135 R137 R201 R204 R400 R403 R404 R509 R589-R603 R751-R759 R766 R973 RB501 RB502 RB507-RB516 SR1-SR48 UNK2MR10 UNK2R135 UNK2R137 UNK2R201 UNK2R204 UNK2R509 UNK2R973 UNK3MR10 UNK3R135 UNK3R137 UNK3R201 UNK3R204 UNK3R509 UNK3R973 UNK4MR10 UNK4R135 UNK4R137 UNK4R201 UNK4R204 UNK4R509 UNK4R973 UNK5MR10 UNK5R135 UNK5R137 UNK5R201 UNK5R204 UNK5R509 UNK5R973 UNK6MR10 UNK6R135 UNK6R137 UNK6R201 UNK6R204 UNK6R509 UNK6R973 UNK7MR10 UNK7R135 UNK7R137 UNK7R201 UNK7R204 UNK7R509 UNK7R973 UNK8MR10 UNK8R135 UNK8R137 UNK8R201 UNK8R204 UNK8R509 UNK8R973 = 0-5-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR11 MR13 MR16 UNK2MR11 UNK2MR13 UNK2MR16 UNK3MR11 UNK3MR13 UNK3MR16 UNK4MR11 UNK4MR13 UNK4MR16 UNK5MR11 UNK5MR13 UNK5MR16 UNK6MR11 UNK6MR13 UNK6MR16 UNK7MR11 UNK7MR13 UNK7MR16 UNK8MR11 UNK8MR13 UNK8MR16 = 750-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR12 MR15 MR17 UNK2MR12 UNK2MR15 UNK2MR17 UNK3MR12 UNK3MR15 UNK3MR17 UNK4MR12 UNK4MR15 UNK4MR17 UNK5MR12 UNK5MR15 UNK5MR17 UNK6MR12 UNK6MR15 UNK6MR17 UNK7MR12 UNK7MR15 UNK7MR17 UNK8MR12 UNK8MR15 UNK8MR17 = 360-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR14 R402 R510 UNK2MR14 UNK2R510 UNK3MR14 UNK3R510 UNK4MR14 UNK4R510 UNK5MR14 UNK5R510 UNK6MR14 UNK6R510 UNK7MR14 UNK7R510 UNK8MR14 UNK8R510 = 1.2K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MR18 UNK2MR18 UNK3MR18 UNK4MR18 UNK5MR18 UNK6MR18 UNK7MR18 UNK8MR18 = 11K-0.1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MU1 UNK2MU1 UNK3MU1 UNK4MU1 UNK5MU1 UNK6MU1 UNK7MU1 UNK8MU1 = KSMT002-0.15A-A-SC70-5: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
MU2 UNK2MU2 UNK3MU2 UNK4MU2 UNK5MU2 UNK6MU2 UNK7MU2 UNK8MU2 = KSMT004-SO8: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
MU3 UNK2MU3 UNK3MU3 UNK4MU3 UNK5MU3 UNK6MU3 UNK7MU3 UNK8MU3 = KSMT003-MSOP8: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
MU4 UNK2MU4 UNK3MU4 UNK4MU4 UNK5MU4 UNK6MU4 UNK7MU4 UNK8MU4 = MAX6070AAUT30+T-SOT23: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
R160 R161 UNK2R160 UNK2R161 UNK3R160 UNK3R161 UNK4R160 UNK4R161 UNK5R160 UNK5R161 UNK6R160 UNK6R161 UNK7R160 UNK7R161 UNK8R160 UNK8R161 = 38.3-1-S2: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R162 R200 R202 R203 R205-R207 R405-R416 R420 R422 R648-R650 R658 R661 R663 R709-R714 R925-R948 R950 R952 R981 R1093 R1097 R1098 R1101 UNK2R162 UNK2R200 UNK2R202 UNK2R203 UNK2R205-UNK2R207 UNK2R661 UNK2R663 UNK2R981 UNK2R1098 UNK2R1101 UNK3R162 UNK3R200 UNK3R202 UNK3R203 UNK3R205-UNK3R207 UNK3R661 UNK3R663 UNK3R981 UNK3R1098 UNK3R1101 UNK4R162 UNK4R200 UNK4R202 UNK4R203 UNK4R205-UNK4R207 UNK4R661 UNK4R663 UNK4R981 UNK4R1098 UNK4R1101 UNK5R162 UNK5R200 UNK5R202 UNK5R203 UNK5R205-UNK5R207 UNK5R661 UNK5R663 UNK5R981 UNK5R1098 UNK5R1101 UNK6R162 UNK6R200 UNK6R202 UNK6R203 UNK6R205-UNK6R207 UNK6R661 UNK6R663 UNK6R981 UNK6R1098 UNK6R1101 UNK7R162 UNK7R200 UNK7R202 UNK7R203 UNK7R205-UNK7R207 UNK7R661 UNK7R663 UNK7R981 UNK7R1098 UNK7R1101 UNK8R162 UNK8R200 UNK8R202 UNK8R203 UNK8R205-UNK8R207 UNK8R661 UNK8R663 UNK8R981 UNK8R1098 UNK8R1101 = 4.7K-1-S2: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R163-R165 R172 R662 R982 R1102 R1104 UNK2R163-UNK2R165 UNK2R172 UNK2R662 UNK2R982 UNK2R1102 UNK2R1104 UNK3R163-UNK3R165 UNK3R172 UNK3R662 UNK3R982 UNK3R1102 UNK3R1104 UNK4R163-UNK4R165 UNK4R172 UNK4R662 UNK4R982 UNK4R1102 UNK4R1104 UNK5R163-UNK5R165 UNK5R172 UNK5R662 UNK5R982 UNK5R1102 UNK5R1104 UNK6R163-UNK6R165 UNK6R172 UNK6R662 UNK6R982 UNK6R1102 UNK6R1104 UNK7R163-UNK7R165 UNK7R172 UNK7R662 UNK7R982 UNK7R1102 UNK7R1104 UNK8R163-UNK8R165 UNK8R172 UNK8R662 UNK8R982 UNK8R1102 UNK8R1104 = 0-5-S2: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R168 R170 R176 R178 R180 R182 R646 R647 R664 R666 R1088 R1089 R1099 R1100 R1103 R1106 R1107 R1109-R1111 R1114 R1115 UNK2R168 UNK2R170 UNK2R176 UNK2R178 UNK2R180 UNK2R182 UNK2R646 UNK2R647 UNK2R664 UNK2R666 UNK2R1088 UNK2R1089 UNK2R1099 UNK2R1100 UNK2R1103 UNK2R1106 UNK2R1107 UNK2R1109-UNK2R1111 UNK2R1114 UNK2R1115 UNK3R168 UNK3R170 UNK3R176 UNK3R178 UNK3R180 UNK3R182 UNK3R646 UNK3R647 UNK3R664 UNK3R666 UNK3R1088 UNK3R1089 UNK3R1099 UNK3R1100 UNK3R1103 UNK3R1106 UNK3R1107 UNK3R1109-UNK3R1111 UNK3R1114 UNK3R1115 UNK4R168 UNK4R170 UNK4R176 UNK4R178 UNK4R180 UNK4R182 UNK4R646 UNK4R647 UNK4R664 UNK4R666 UNK4R1088 UNK4R1089 UNK4R1099 UNK4R1100 UNK4R1103 UNK4R1106 UNK4R1107 UNK4R1109-UNK4R1111 UNK4R1114 UNK4R1115 UNK5R168 UNK5R170 UNK5R176 UNK5R178 UNK5R180 UNK5R182 UNK5R646 UNK5R647 UNK5R664 UNK5R666 UNK5R1088 UNK5R1089 UNK5R1099 UNK5R1100 UNK5R1103 UNK5R1106 UNK5R1107 UNK5R1109-UNK5R1111 UNK5R1114 UNK5R1115 UNK6R168 UNK6R170 UNK6R176 UNK6R178 UNK6R180 UNK6R182 UNK6R646 UNK6R647 UNK6R664 UNK6R666 UNK6R1088 UNK6R1089 UNK6R1099 UNK6R1100 UNK6R1103 UNK6R1106 UNK6R1107 UNK6R1109-UNK6R1111 UNK6R1114 UNK6R1115 UNK7R168 UNK7R170 UNK7R176 UNK7R178 UNK7R180 UNK7R182 UNK7R646 UNK7R647 UNK7R664 UNK7R666 UNK7R1088 UNK7R1089 UNK7R1099 UNK7R1100 UNK7R1103 UNK7R1106 UNK7R1107 UNK7R1109-UNK7R1111 UNK7R1114 UNK7R1115 UNK8R168 UNK8R170 UNK8R176 UNK8R178 UNK8R180 UNK8R182 UNK8R646 UNK8R647 UNK8R664 UNK8R666 UNK8R1088 UNK8R1089 UNK8R1099 UNK8R1100 UNK8R1103 UNK8R1106 UNK8R1107 UNK8R1109-UNK8R1111 UNK8R1114 UNK8R1115 = 42.2-1-S2: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R234 R1117-R1119 UNK2R234 UNK2R1117-UNK2R1119 UNK3R234 UNK3R1117-UNK3R1119 UNK4R234 UNK4R1117-UNK4R1119 UNK5R234 UNK5R1117-UNK5R1119 UNK6R234 UNK6R1117-UNK6R1119 UNK7R234 UNK7R1117-UNK7R1119 UNK8R234 UNK8R1117-UNK8R1119 = 0-1-S4-YA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R331 R659 R672 R980 R1105 R1108 RB1 RB2 UNK2R331 UNK2R659 UNK2R672 UNK2R980 UNK2R1105 UNK2R1108 UNK3R331 UNK3R659 UNK3R672 UNK3R980 UNK3R1105 UNK3R1108 UNK4R331 UNK4R659 UNK4R672 UNK4R980 UNK4R1105 UNK4R1108 UNK5R331 UNK5R659 UNK5R672 UNK5R980 UNK5R1105 UNK5R1108 UNK6R331 UNK6R659 UNK6R672 UNK6R980 UNK6R1105 UNK6R1108 UNK7R331 UNK7R659 UNK7R672 UNK7R980 UNK7R1105 UNK7R1108 UNK8R331 UNK8R659 UNK8R672 UNK8R980 UNK8R1105 UNK8R1108 = 10K-1-S2-WA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R401 R511 UNK2R511 UNK3R511 UNK4R511 UNK5R511 UNK6R511 UNK7R511 UNK8R511 = 523-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R512 UNK2R512 UNK3R512 UNK4R512 UNK5R512 UNK6R512 UNK7R512 UNK8R512 = 0-5-S8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R652 R923 UNK2R652 UNK2R923 UNK3R652 UNK3R923 UNK4R652 UNK4R923 UNK5R652 UNK5R923 UNK6R652 UNK6R923 UNK7R652 UNK7R923 UNK8R652 UNK8R923 = 100K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
S1_DPS_SW1-S1_DPS_SW6 UT1_SW1 UT1_SW2 UT2_SW1 UT2_SW2 UT3_SW1 UT3_SW2 UT4_SW1 UT4_SW2 UT5_SW1 UT5_SW2 UT6_SW1 UT6_SW2 UT7_SW1 UT7_SW2 UT8_SW1 UT8_SW2 = SW-SLIDE-8-S2.54: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
S1_USER_3V3 S2_USER_3V3 S3_USER_3V3 S4_USER_3V3 S5_USER_3V3 S6_USER_3V3 S7_USER_3V3 S8_USER_3V3 = VTP-2X1: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
S1_VREF_OUT S2_VREF_OUT S3_VREF_OUT S4_VREF_OUT S5_VREF_OUT S6_VREF_OUT S7_VREF_OUT S8_VREF_OUT STP1-STP48 TP_DPS1-TP_DPS9 UNK2TP_DPS1-UNK2TP_DPS9 UNK3TP_DPS1-UNK3TP_DPS9 UNK4TP_DPS1-UNK4TP_DPS9 UNK5TP_DPS1-UNK5TP_DPS9 UNK6TP_DPS1-UNK6TP_DPS9 UNK7TP_DPS1-UNK7TP_DPS9 UNK8TP_DPS1-UNK8TP_DPS9 = TP01: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
SA1 SA2 SA7-SA10 SA15-SA26 UNK2SA1 UNK2SA2 UNK2SA7-UNK2SA10 UNK2SA15-UNK2SA26 UNK3SA1 UNK3SA2 UNK3SA7-UNK3SA10 UNK3SA15-UNK3SA26 UNK4SA1 UNK4SA2 UNK4SA7-UNK4SA10 UNK4SA15-UNK4SA26 UNK5SA1 UNK5SA2 UNK5SA7-UNK5SA10 UNK5SA15-UNK5SA26 UNK6SA1 UNK6SA2 UNK6SA7-UNK6SA10 UNK6SA15-UNK6SA26 UNK7SA1 UNK7SA2 UNK7SA7-UNK7SA10 UNK7SA15-UNK7SA26 UNK8SA1 UNK8SA2 UNK8SA7-UNK8SA10 UNK8SA15-UNK8SA26 = SHORT: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
SC1-SC48 = 0.01U-50-X7R-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
SCREW1 = V93KMFHOLE: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
SITE1-SITE8 = I6K51D-BGA290-9X7: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
SSI6K51D = REF-CODE-CHIP
SW5 SW10 = SW-SLIDE-8-S2.54-TRI-EN: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
TP_MUX_3V3 UBIT_3V3_UP UNK2TP_MUX_3V3 UNK3TP_MUX_3V3 UNK4TP_MUX_3V3 UNK5TP_MUX_3V3 UNK6TP_MUX_3V3 UNK7TP_MUX_3V3 UNK8TP_MUX_3V3 UT_UP5V = TP03-D: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U17 UNK2U17 UNK3U17 UNK4U17 UNK5U17 UNK6U17 UNK7U17 UNK8U17 = XC6203E-0.4A-33-SOT89: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U18 UNK2U18 UNK3U18 UNK4U18 UNK5U18 UNK6U18 UNK7U18 UNK8U18 = SK-SO8-1.27-DEDIPROG-V3: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
U19 UNK2U19 UNK3U19 UNK4U19 UNK5U19 UNK6U19 UNK7U19 UNK8U19 = SK-SO8-1.27-ICSOCKET-6X8-V2: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U31 UNK2U31 UNK3U31 UNK4U31 UNK5U31 UNK6U31 UNK7U31 UNK8U31 = FSUSB73UMX-UMLP16: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U70 U403 U434 U435 = 74HC244BQ-DHVQFN20: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U71 U108 UNK2U108 UNK3U108 UNK4U108 UNK5U108 UNK6U108 UNK7U108 UNK8U108 = R1173H001B-1A-A-SOT-89-5: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U72 U74 U75 U77 U80 U405 U413 U415 U453 = ULN2003AIPW-TSSOP16: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U73 U76 U79 U414 U454 = 74HC04BQ-DHVQFN14: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
U408 U409 U455 U456 UNK2U408 UNK2U409 UNK2U455 UNK2U456 UNK3U408 UNK3U409 UNK3U455 UNK3U456 UNK4U408 UNK4U409 UNK4U455 UNK4U456 UNK5U408 UNK5U409 UNK5U455 UNK5U456 UNK6U408 UNK6U409 UNK6U455 UNK6U456 UNK7U408 UNK7U409 UNK7U455 UNK7U456 UNK8U408 UNK8U409 UNK8U455 UNK8U456 = CBTL06GP213EE-TFBGA50: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U449 UNK2U449 UNK3U449 UNK4U449 UNK5U449 UNK6U449 UNK7U449 UNK8U449 = TS3USB3000RSER-UQFN10: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
UB1 = AT24C04C-SSHM-SO8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
UNK2Y1 UNK3Y1 UNK4Y1 UNK5Y1 UNK6Y1 UNK7Y1 UNK8Y1 Y1 = XTAL24M-S5032-SIWARD-12P: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
UNK2Y2 UNK3Y2 UNK4Y2 UNK5Y2 UNK6Y2 UNK7Y2 UNK8Y2 Y2 = XTAL32.768K-S3215-MCD-12.5P: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
UNK038XS-I6K51D18Q-A100 UNK980XS-I6K51D-1AG- = REF-CODE-PCB
UTL1-UTL8 = V93K_UTL: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
VP1 = V93K_PROTECTOR

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
C0201
  rect 0.305x0.356 smd: 1(-0.3,0) 2(0.3,0)
C0201_MINI
  rect 0.254x0.33 smd: 1(-0.25,0) 2(0.25,0)
C0402
  custom 0.15x0.15 smd: 1(-0.5,0) 2(0.5,0)
C0402_UNBGA_V2
  rect 0.508x0.508 smd: 1(-0.425,0) 2(0.425,0)
C0603
  rect 0.889x0.889 smd: 1(-0.85,0) 2(0.85,0)
C0805
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
C1206
  rect 1.321x1.829 smd: 1(-1.25,0) 2(1.25,0)
CHIP_CODE
  round 0.051 smd: 1(0,0)
CONN_15X2_100MIL_PH_MS_V2
  rect 1.524x1.524 hole 1.041: 1(0,0)
  round 1.524 hole 1.041: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54) 11(12.7,0) 12(12.7,2.54) 13(15.24,0) 14(15.24,2.54) 15(17.78,0) 16(17.78,2.54) 17(20.32,0) 18(20.32,2.54) 19(22.86,0) 20(22.86,2.54) 21(25.4,0) 22(25.4,2.54) 23(27.94,0) 24(27.94,2.54) 25(30.48,0) 26(30.48,2.54) 27(33.02,0) 28(33.02,2.54) 29(35.56,0) 30(35.56,2.54)
CONN_S4X1_2MM_JWT
  rect 1x5.5 smd: 1(-3,-4.75) 2(-1,-4.75) 3(1,-4.75) 4(3,-4.75)
  rect 1.5x3 smd: NC1(-5.35,-2.5) NC2(5.35,-2.5)
DEFAULT_SHORT_SMALL
  custom 0.07x0.07 smd: 1(-0.5,0) 2(0.5,0)
EC_10P3X10_S
  rect 1.651x4.064 smd: 1(0,4.25) 2(0,-4.25)
FB0402
  rect 0.584x0.508 smd: 1(-0.47,0) 2(0.47,0)
FD_040_V2
  round 1.016 smd: 1(0,0)
JP_2P_100
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(0,2.54)
LED_0805
  rect 1.118x1.372 smd: 1(0.95,0) 2(-0.95,0)
LOGO_KT_KSMT
  round 0.051 smd: 1(-0.711,-0.711)
LOGO_SR_SIGMASTAR
  round 0.051 smd: 1(-0.711,-0.711)
M3_NPTH169
  round 0.508 hole 4.293 unplated: (0,0)
PCB_CODE
  round 0.051 smd: 1(0,0)
PG_VG93K_F_FULLOUTLINE
  round 0.508 hole 3.2 unplated: (-287.604,198.12) (-287.604,102.006) (-287.604,0) (-287.604,-102.006) (-287.604,-198.12) (-220.98,157.48) (-220.98,-157.48) (-140.276,198.12) (-140.276,102.006) (-140.276,0) (-140.276,-102.006) (-140.276,-198.12) (-73.66,157.48) (-73.66,-157.48) (7.044,198.12) (7.044,102.006) (7.044,-102.006) (7.044,-198.12) (73.66,157.48) (73.66,-157.48) (140.304,198.12) (140.304,102.006) (140.304,0) (140.304,-102.006) (140.304,-198.12) (220.98,157.48) (220.98,-157.48) (287.604,198.12) (287.604,102.006) (287.604,0) (287.604,-102.006) (287.604,-198.12)
  round 0.051 smd: GH1(70,70) GH2(-70,70) GH3(-70,-70) GH4(70,-70)
PG_VG93K_F_G1D101
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G1D102
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G1D103
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G1D104
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G1D105
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G1D106
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G1D107
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G1D108
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G1DPS1
  round 1.778 hole 0.711: A01(-20.32,-2.54) A02(-17.78,-2.54) A03(-15.24,-2.54) A04(-12.7,-2.54) A05(-10.16,-2.54) A06(-7.62,-2.54) A07(-5.08,-2.54) A08(-2.54,-2.54) A09(0,-2.54) A10(2.54,-2.54) A11(5.08,-2.54) A12(7.62,-2.54) A13(10.16,-2.54) A14(12.7,-2.54) A15(15.24,-2.54) A16(17.78,-2.54) A17(20.32,-2.54) B01(-20.32,0) B02(-17.78,0) B03(-15.24,0) B04(-12.7,0) B05(-10.16,0) B06(-7.62,0) B07(-5.08,0) B08(-2.54,0) B09(0,0) B10(2.54,0) B11(5.08,0) B12(7.62,0) B13(10.16,0) B14(12.7,0) B15(15.24,0) B16(17.78,0) B17(20.32,0) C01(-20.32,2.54) C02(-17.78,2.54) C03(-15.24,2.54) C04(-12.7,2.54) C05(-10.16,2.54) C06(-7.62,2.54) C07(-5.08,2.54) C08(-2.54,2.54) C09(0,2.54) C10(2.54,2.54) C11(5.08,2.54) C12(7.62,2.54) C13(10.16,2.54) C14(12.7,2.54) C15(15.24,2.54) C16(17.78,2.54) C17(20.32,2.54)
PG_VG93K_F_G1UTI2
  round 1.778 hole 0.711: A01(-20.32,-1.27) A02(-17.78,-1.27) A03(-15.24,-1.27) A04(-12.7,-1.27) A05(-10.16,-1.27) A06(-7.62,-1.27) A07(-5.08,-1.27) A08(-2.54,-1.27) A09(0,-1.27) A10(2.54,-1.27) A11(5.08,-1.27) A12(7.62,-1.27) A13(10.16,-1.27) A14(12.7,-1.27) A15(15.24,-1.27) A16(17.78,-1.27) A17(20.32,-1.27) B01(-20.32,1.27) B02(-17.78,1.27) B03(-15.24,1.27) B04(-12.7,1.27) B05(-10.16,1.27) B06(-7.62,1.27) B07(-5.08,1.27) B08(-2.54,1.27) B09(0,1.27) B10(2.54,1.27) B11(5.08,1.27) B12(7.62,1.27) B13(10.16,1.27) B14(12.7,1.27) B15(15.24,1.27) B16(17.78,1.27) B17(20.32,1.27)
PG_VG93K_F_G2D109
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G2D110
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G2D111
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G2D112
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G2D113
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G2D114
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G2D115
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G2D116
  round 1.778 hole 0.711: 01(20.32,1.27) 02(17.78,-1.27) 03(15.24,1.27) 04(12.7,-1.27) 05(10.16,1.27) 06(7.62,-1.27) 07(5.08,1.27) 08(2.54,-1.27) 09(0,1.27) 10(-2.54,-1.27) 11(-5.08,1.27) 12(-7.62,-1.27) 13(-10.16,1.27) 14(-12.7,-1.27) 15(-15.24,1.27) 16(-17.78,-1.27) 17(-20.32,1.27)
  rect 1.778x1.778 hole 0.711: A1(20.32,3.81) A2(17.78,1.27) A3(15.24,3.81) A4(12.7,1.27) A5(10.16,3.81) A6(7.62,1.27) A7(5.08,3.81) A8(2.54,1.27) A9(0,3.81) A10(-2.54,1.27) A11(-5.08,3.81) A12(-7.62,1.27) A13(-10.16,3.81) A14(-12.7,1.27) A15(-15.24,3.81) A16(-17.78,1.27) A17(-20.32,3.81) B1(20.32,-1.27) B2(17.78,-3.81) B3(15.24,-1.27) B4(12.7,-3.81) B5(10.16,-1.27) B6(7.62,-3.81) B7(5.08,-1.27) B8(2.54,-3.81) B9(0,-1.27) B10(-2.54,-3.81) B11(-5.08,-1.27) B12(-7.62,-3.81) B13(-10.16,-1.27) B14(-12.7,-3.81) B15(-15.24,-1.27) B16(-17.78,-3.81) B17(-20.32,-1.27)
PG_VG93K_F_G2DPS2
  round 1.778 hole 0.711: A01(20.32,2.54) A02(17.78,2.54) A03(15.24,2.54) A04(12.7,2.54) A05(10.16,2.54) A06(7.62,2.54) A07(5.08,2.54) A08(2.54,2.54) A09(0,2.54) A10(-2.54,2.54) A11(-5.08,2.54) A12(-7.62,2.54) A13(-10.16,2.54) A14(-12.7,2.54) A15(-15.24,2.54) A16(-17.78,2.54) A17(-20.32,2.54) B01(20.32,0) B02(17.78,0) B03(15.24,0) B04(12.7,0) B05(10.16,0) B06(7.62,0) B07(5.08,0) B08(2.54,0) B09(0,0) B10(-2.54,0) B11(-5.08,0) B12(-7.62,0) B13(-10.16,0) B14(-12.7,0) B15(-15.24,0) B16(-17.78,0) B17(-20.32,0) C01(20.32,-2.54) C02(17.78,-2.54) C03(15.24,-2.54) C04(12.7,-2.54) C05(10.16,-2.54) C06(7.62,-2.54) C07(5.08,-2.54) C08(2.54,-2.54) C09(0,-2.54) C10(-2.54,-2.54) C11(-5.08,-2.54) C12(-7.62,-2.54) C13(-10.16,-2.54) C14(-12.7,-2.54) C15(-15.24,-2.54) C16(-17.78,-2.54) C17(-20.32,-2.54)
PG_VG93K_F_G2UTI3
  round 1.778 hole 0.711: A01(20.32,1.27) A02(17.78,1.27) A03(15.24,1.27) A04(12.7,1.27) A05(10.16,1.27) A06(7.62,1.27) A07(5.08,1.27) A08(2.54,1.27) A09(0,1.27) A10(-2.54,1.27) A11(-5.08,1.27) A12(-7.62,1.27) A13(-10.16,1.27) A14(-12.7,1.27) A15(-15.24,1.27) A16(-17.78,1.27) A17(-20.32,1.27) B01(20.32,-1.27) B02(17.78,-1.27) B03(15.24,-1.27) B04(12.7,-1.27) B05(10.16,-1.27) B06(7.62,-1.27) B07(5.08,-1.27) B08(2.54,-1.27) B09(0,-1.27) B10(-2.54,-1.27) B11(-5.08,-1.27) B12(-7.62,-1.27) B13(-10.16,-1.27) B14(-12.7,-1.27) B15(-15.24,-1.27) B16(-17.78,-1.27) B17(-20.32,-1.27)
PG_VG93K_F_G3D117
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G3D118
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G3D119
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G3D120
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G3D121
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G3D122
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G3D123
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G3D124
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G3DPS3
  round 1.778 hole 0.711: A01(-20.32,-2.54) A02(-17.78,-2.54) A03(-15.24,-2.54) A04(-12.7,-2.54) A05(-10.16,-2.54) A06(-7.62,-2.54) A07(-5.08,-2.54) A08(-2.54,-2.54) A09(0,-2.54) A10(2.54,-2.54) A11(5.08,-2.54) A12(7.62,-2.54) A13(10.16,-2.54) A14(12.7,-2.54) A15(15.24,-2.54) A16(17.78,-2.54) A17(20.32,-2.54) B01(-20.32,0) B02(-17.78,0) B03(-15.24,0) B04(-12.7,0) B05(-10.16,0) B06(-7.62,0) B07(-5.08,0) B08(-2.54,0) B09(0,0) B10(2.54,0) B11(5.08,0) B12(7.62,0) B13(10.16,0) B14(12.7,0) B15(15.24,0) B16(17.78,0) B17(20.32,0) C01(-20.32,2.54) C02(-17.78,2.54) C03(-15.24,2.54) C04(-12.7,2.54) C05(-10.16,2.54) C06(-7.62,2.54) C07(-5.08,2.54) C08(-2.54,2.54) C09(0,2.54) C10(2.54,2.54) C11(5.08,2.54) C12(7.62,2.54) C13(10.16,2.54) C14(12.7,2.54) C15(15.24,2.54) C16(17.78,2.54) C17(20.32,2.54)
PG_VG93K_F_G3UTI1
  round 1.778 hole 0.711: A01(-20.32,-1.27) A02(-17.78,-1.27) A03(-15.24,-1.27) A04(-12.7,-1.27) A05(-10.16,-1.27) A06(-7.62,-1.27) A07(-5.08,-1.27) A08(-2.54,-1.27) A09(0,-1.27) A10(2.54,-1.27) A11(5.08,-1.27) A12(7.62,-1.27) A13(10.16,-1.27) A14(12.7,-1.27) A15(15.24,-1.27) A16(17.78,-1.27) A17(20.32,-1.27) B01(-20.32,1.27) B02(-17.78,1.27) B03(-15.24,1.27) B04(-12.7,1.27) B05(-10.16,1.27) B06(-7.62,1.27) B07(-5.08,1.27) B08(-2.54,1.27) B09(0,1.27) B10(2.54,1.27) B11(5.08,1.27) B12(7.62,1.27) B13(10.16,1.27) B14(12.7,1.27) B15(15.24,1.27) B16(17.78,1.27) B17(20.32,1.27)
PG_VG93K_F_G4D125
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G4D126
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G4D127
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G4D128
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G4D129
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
PG_VG93K_F_G4D130
  round 1.778 hole 0.711: 01(-20.32,-1.27) 02(-17.78,1.27) 03(-15.24,-1.27) 04(-12.7,1.27) 05(-10.16,-1.27) 06(-7.62,1.27) 07(-5.08,-1.27) 08(-2.54,1.27) 09(0,-1.27) 10(2.54,1.27) 11(5.08,-1.27) 12(7.62,1.27) 13(10.16,-1.27) 14(12.7,1.27) 15(15.24,-1.27) 16(17.78,1.27) 17(20.32,-1.27)
  rect 1.778x1.778 hole 0.711: A1(-20.32,-3.81) A2(-17.78,-1.27) A3(-15.24,-3.81) A4(-12.7,-1.27) A5(-10.16,-3.81) A6(-7.62,-1.27) A7(-5.08,-3.81) A8(-2.54,-1.27) A9(0,-3.81) A10(2.54,-1.27) A11(5.08,-3.81) A12(7.62,-1.27) A13(10.16,-3.81) A14(12.7,-1.27) A15(15.24,-3.81) A16(17.78,-1.27) A17(20.32,-3.81) B1(-20.32,1.27) B2(-17.78,3.81) B3(-15.24,1.27) B4(-12.7,3.81) B5(-10.16,1.27) B6(-7.62,3.81) B7(-5.08,1.27) B8(-2.54,3.81) B9(0,1.27) B10(2.54,3.81) B11(5.08,1.27) B12(7.62,3.81) B13(10.16,1.27) B14(12.7,3.81) B15(15.24,1.27) B16(17.78,3.81) B17(20.32,1.27)
