# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D10516: length 342.5
  L25_SIGNAL w0.079: 331.31,178 331.31,177.67 329.71,176.06 329.71,174.09 330.81,172.99 330.81,167.34 334.24,163.92 334.24,153.44 331.37,150.57 331.37,139.02 333.3,137.08 335.91,137.08 347.96,125.03 347.96,116.7 349.58,115.09 353.37,115.09 354.74,116.46 354.74,120.83 355.31,121.41 356.8,121.41 357.25,120.96 357.25,107.24 359.44,105.05 364.46,105.05 366.58,107.16 366.58,122.98 367.29,123.7 399.15,123.7 399.87,122.98 399.87,121.25 399.08,120.46 375.59,120.46 373.39,118.26 373.39,112.98 375.3,111.07 412.79,111.07 413.47,110.39 413.47,107.76 412.75,107.05 375.69,107.05 374.22,105.58 374.22,96.58 378.4,92.39 412.36,92.39 415.39,95.42 415.39,97.05
  L25_SIGNAL w0.091: D105.16 417.83,97.79 416.12,97.79 415.39,97.05 ; 331.31,178 UNK8U409.E9 v1(330.66,178.15)
  BOTTOM w0.16: UNK8U409.E9 v1(330.66,178.15)
D10601: length 257
  L29_SIGNAL w0.109: D106.01 383.42,73.78 383.42,72.26 382.98,71.83 382.46,71.83 382.35,71.94 382.35,71.99 382.25,72.1 382.03,72.1 381.92,71.99 381.92,71.94 381.81,71.83 381.59,71.83 381.48,71.94 381.48,71.99 381.37,72.1 381.15,72.1 381.04,71.99 381.04,71.94 380.93,71.83 380.72,71.83 380.61,71.94 380.61,71.99 380.5,72.1 380.28,72.1 380.17,71.99 380.17,71.94 380.06,71.83 368.91,71.83 353.23,87.5 232.79,87.5 225.04,95.25 225.04,132.21 227,134.17 227,144.05 229.18,146.22 229.18,160.46 230.05,161.33 230.05,166.84 229.27,167.62 228.05,167.62 226.24,169.43 226.24,172.34 v2(226.41,172.52)
  BOTTOM w0.165: v2(226.41,172.52) 226.28,172.65 226.28,173.73 UNK5U31.2
D10602: length 205.6
  L27_SIGNAL w0.109: D106.02 384.68,77.6 384.68,75.04 381.78,72.13 378.21,72.13 374.84,75.5 374.84,75.66 374.92,75.74 374.92,75.89 374.77,76.05 374.61,76.05 374.53,75.97 374.38,75.97 374.22,76.12 374.22,76.27 374.3,76.36 374.3,76.51 374.15,76.66 374,76.66 373.91,76.58 373.76,76.58 373.61,76.74 373.61,76.89 373.69,76.97 373.69,77.13 373.53,77.28 373.38,77.28 373.3,77.2 373.14,77.2 372.99,77.36 372.99,77.51 373.07,77.59 373.07,77.75 372.91,77.9 372.76,77.9 372.68,77.82 372.52,77.82 372.37,77.97 372.37,78.13 372.45,78.21 372.45,78.36 372.3,78.52 372.14,78.52 372.06,78.44 371.91,78.44 371.75,78.59 371.75,78.75 371.83,78.83 371.83,78.98 371.68,79.14 371.52,79.14 371.44,79.06 371.29,79.06 371.13,79.21 371.13,79.37 371.21,79.45 371.21,79.6 371.06,79.76 370.9,79.76 370.82,79.67 370.67,79.67 361.57,88.77 303.28,88.77 286.13,105.92 286.13,120.11 276.84,129.41 267.69,129.41 267,130.1 267,144.05 269.18,146.22 269.18,160.46 270.04,161.33 270.04,166.84 269.27,167.62 268.05,167.62 266.24,169.43 266.24,172.34 v2(266.41,172.52)
  BOTTOM w0.165: v2(266.41,172.52) 266.28,172.65 UNK6U31.2
D10603: length 257
  L29_SIGNAL w0.109: D106.03 383.66,73.78 383.66,72.16 383.08,71.58 368.81,71.58 353.13,87.25 232.69,87.25 224.8,95.15 224.8,132.31 226.75,134.27 226.75,144.15 228.93,146.33 228.93,160.56 229.8,161.43 229.8,166.74 229.16,167.37 227.95,167.37 225.99,169.33 225.99,172.28 v2(225.75,172.52)
  BOTTOM w0.165: UNK5U31.3 225.88,172.65 v2(225.75,172.52)
D10604: length 205.6
  L27_SIGNAL w0.109: D106.04 387.35,77.47 385.69,77.47 384.93,76.71 384.93,74.93 381.88,71.88 378.11,71.88 361.47,88.52 303.17,88.52 285.88,105.81 285.88,120.01 276.73,129.16 267.59,129.16 266.75,129.99 266.75,144.15 268.93,146.33 268.93,160.56 269.8,161.43 269.8,166.74 269.16,167.37 267.95,167.37 265.99,169.33 265.99,172.28 v2(265.75,172.52)
  BOTTOM w0.165: UNK6U31.3 265.88,172.65 v2(265.75,172.52)
D10605: length 177.4
  L25_SIGNAL w0.109: D106.05 393.58,73.78 393.58,72.39 392.81,71.63 390.12,71.63 390.01,71.74 390.01,71.86 389.9,71.97 389.68,71.97 389.57,71.86 389.57,71.74 389.46,71.63 389.24,71.63 389.13,71.74 389.13,71.86 389.02,71.97 388.8,71.97 388.7,71.86 388.7,71.74 388.59,71.63 380.93,71.63 375.79,76.76 375.79,86.99 351.15,111.63 327.66,111.63 327.02,112.27 327.02,124.21 323.47,127.76 308.76,127.76 307,129.52 307,144.05 309.18,146.22 309.18,160.46 310.04,161.33 310.04,166.84 309.27,167.62 308.05,167.62 306.24,169.43 306.24,172.34 v2(306.41,172.52)
  BOTTOM w0.165: UNK7U31.2 306.28,172.65 v2(306.41,172.52)
D10606: length 142.4
  L31_SIGNAL w0.109: D106.06 394.85,77.59 394.85,75.57 394.46,75.18 378.97,75.18 376.81,77.35 376.81,77.5 376.92,77.61 376.92,77.77 376.76,77.92 376.61,77.92 376.5,77.81 376.34,77.81 376.19,77.97 376.19,78.12 376.3,78.23 376.3,78.38 376.14,78.54 375.99,78.54 375.88,78.43 375.72,78.43 375.57,78.58 375.57,78.74 375.68,78.85 375.68,79 375.53,79.16 375.37,79.16 375.26,79.05 375.11,79.05 374.95,79.2 374.95,79.36 375.06,79.47 375.06,79.62 374.91,79.78 374.75,79.78 374.64,79.67 374.49,79.67 374.33,79.82 374.33,79.97 374.44,80.09 374.44,80.24 374.29,80.39 374.13,80.39 374.02,80.28 373.87,80.28 373.71,80.44 373.71,80.59 373.83,80.7 373.83,80.86 373.67,81.01 373.52,81.01 373.4,80.9 373.25,80.9 371.6,82.55 371.6,112.27 355.23,128.64 347.87,128.64 347,129.5 347,144.05 349.18,146.22 349.18,160.46 350.04,161.33 350.04,166.84 349.27,167.62 348.05,167.62 346.24,169.43 346.24,172.34 v2(346.41,172.52)
  BOTTOM w0.165: UNK8U31.2 346.28,172.65 v2(346.41,172.52)
D10607: length 177.4
  L25_SIGNAL w0.109: D106.07 393.82,73.78 393.82,72.29 392.91,71.38 380.82,71.38 375.54,76.66 375.54,86.89 351.05,111.38 327.56,111.38 326.78,112.16 326.78,124.1 323.37,127.51 308.66,127.51 306.75,129.42 306.75,144.15 308.93,146.33 308.93,160.56 309.8,161.43 309.8,166.74 309.16,167.37 307.95,167.37 305.99,169.33 305.99,172.28 v2(305.75,172.52)
  BOTTOM w0.165: v2(305.75,172.52) 305.88,172.65 UNK7U31.3
D10608: length 142.4
  L31_SIGNAL w0.109: D106.08 397.51,77.47 395.67,77.47 395.09,76.89 395.09,75.46 394.57,74.94 378.86,74.94 371.35,82.45 371.35,112.16 355.13,128.39 347.77,128.39 346.75,129.4 346.75,144.15 348.93,146.33 348.93,160.56 349.8,161.43 349.8,166.74 349.16,167.37 347.95,167.37 345.99,169.33 345.99,172.28 v2(345.75,172.52)
  BOTTOM w0.165: UNK8U31.3 345.88,172.65 v2(345.75,172.52)
D10609: length 281.7
  L29_SIGNAL w0.091: D106.09 395.02,69.9 368.25,69.9 351.79,86.36 231.9,86.36 222.74,95.52 222.74,132.25 222.23,132.76 222.23,137.92 224.68,140.37 224.68,158.82 223.07,160.43 223.07,170.17 222.02,171.22 222.02,176.49 224.82,179.3 226.8,179.3 v2(227.26,179.76)
D10610: length 233.2
  L27_SIGNAL w0.091: D106.10 402.59,77.47 402.59,71.37 399.67,68.45 379.09,68.45 360.04,87.5 302.67,87.5 284.23,105.95 284.23,117.09 273.3,128.02 266.7,128.02 264.68,130.04 264.68,158.82 263.07,160.43 263.07,170.17 262.02,171.22 262.02,176.49 264.82,179.3 266.8,179.3 v2(267.25,179.76)
D10611: length 199.5
  L25_SIGNAL w0.091: D106.11 400.56,70.36 379.86,70.36 373.63,76.58 373.63,83.19 349.5,107.31 324.74,107.31 323.98,108.08 323.98,123.32 320.8,126.49 305.31,126.49 302.74,129.06 302.74,132.25 302.23,132.76 302.23,137.92 304.68,140.37 304.68,158.82 303.07,160.43 303.07,170.17 302.02,171.22 302.02,176.49 304.82,179.3 306.8,179.3 v2(307.25,179.76)
D10612: length 172.3
  L31_SIGNAL w0.091: D106.12 407.67,77.47 407.67,72.64 406.91,71.88 370.33,71.88 357.89,84.33 357.89,122.43 352.69,127.62 347.37,127.62 342.23,132.76 342.23,137.92 344.68,140.37 344.68,158.82 343.07,160.43 343.07,170.17 342.02,171.22 342.02,176.49 344.82,179.3 346.8,179.3 v2(347.25,179.76)
D10613: length 288
  L31_SIGNAL w0.076: v2(228.56,186.26) 228.23,186.58 225.61,186.58
  L31_SIGNAL w0.091: 225.61,186.58 222.46,183.43 222.46,178.17 222.02,177.73 222.02,171.22 223.07,170.17 223.07,165.53 222.22,164.69 222.22,162.17 221.21,161.15 221.21,150.85 218.32,147.95 218.32,126.94 228.22,117.04 v3(229.87,117.04)
  L33_SIGNAL w0.091: v3(229.87,117.04) 228.22,115.39 228.22,108.74 231.7,105.26 344.58,105.26 372.36,77.47 410.21,77.47 D106.13
D10614: length 305
  L29_SIGNAL w0.076: v2(268.55,186.26) 268.23,186.58 265.61,186.58
  L29_SIGNAL w0.091: 265.61,186.58 262.46,183.43 262.46,178.17 262.02,177.73 262.02,171.22 263.07,170.17 263.07,165.53 262.22,164.69 262.22,162.17 261.21,161.15 261.21,150.46 258.32,147.57 258.32,143.38 255.23,140.3 254.47,140.3 250.72,136.54 250.72,135.78 241.17,126.24 241.17,107.48 245.85,102.81 354.59,102.81 355.79,104.01 418.72,104.01 423.8,98.93 423.8,88.52 D106.14
D10615: length 238.1
  L27_SIGNAL w0.076: 305.61,186.58 308.23,186.58 v2(308.55,186.26)
  L27_SIGNAL w0.091: 305.61,186.58 302.46,183.43 302.46,178.17 302.02,177.73 302.02,171.22 303.07,170.17 303.07,165.53 302.22,164.69 302.22,162.17 301.21,161.15 301.21,150.41 298.32,147.52 298.32,127.64 301.62,124.33 301.62,108.08 306.71,102.99 419.74,102.99 423.27,99.46 423.27,87.49 417.83,82.04 417.83,77.47 D106.15
D10616: length 194
  L25_SIGNAL w0.076: 345.61,186.58 348.23,186.58 v2(348.55,186.26)
  L25_SIGNAL w0.091: D106.16 425.96,85.6 425.96,118.37 416.06,128.27 370.84,128.27 369.82,129.29 347.6,129.29 343.15,133.73 342.77,133.73 341.25,135.25 341.25,136.02 338.32,138.95 338.32,150.13 340.14,151.95 340.71,151.95 341.21,152.45 341.21,161.15 342.22,162.17 342.22,164.69 343.07,165.53 343.07,170.17 342.02,171.22 342.02,177.73 342.46,178.17 342.46,183.43 345.61,186.58
D10701: length 275.4
  L29_SIGNAL w0.076: 225.81,184.63 226.93,184.63 v2(227.26,184.31)
  L29_SIGNAL w0.091: 225.81,184.63 225.21,184.63 224.92,184.91 223.49,184.91 220.17,181.59 220.17,167.8 218.62,166.25 218.62,162.63 216.44,160.45 216.44,98.77 231.39,83.82 351.79,83.82 379.73,55.88 D107.01
D10702: length 223.5
  L27_SIGNAL w0.076: v2(267.25,184.31) 266.93,184.63 265.81,184.63
  L27_SIGNAL w0.091: D107.02 382.27,59.69 382.27,62.8 359.4,85.67 301.94,85.67 282.49,105.12 282.49,110.03 266.54,125.98 260.1,125.98 256.44,129.64 256.44,160.45 258.62,162.63 258.62,166.25 260.17,167.8 260.17,181.59 263.49,184.91 264.92,184.91 265.21,184.63 265.81,184.63
D10703: length 199.7
  L25_SIGNAL w0.076: v2(307.25,184.31) 306.93,184.63 305.81,184.63
  L25_SIGNAL w0.091: 305.81,184.63 305.21,184.63 304.92,184.91 303.49,184.91 300.17,181.59 300.17,167.8 298.62,166.25 298.62,162.63 296.44,160.45 296.44,130.53 302.39,124.59 311.66,124.59 313.41,122.83 313.41,108.71 316.59,105.54 348.43,105.54 371.91,82.06 371.91,65.68 380.44,57.15 384.81,57.15 D107.03
D10704: length 166.2
  L31_SIGNAL w0.076: v2(347.25,184.31) 346.93,184.63 345.81,184.63
  L31_SIGNAL w0.091: D107.04 387.35,59.69 378.57,59.69 355.85,82.41 355.85,121.54 351.81,125.59 341.52,125.59 336.44,130.66 336.44,160.45 338.62,162.63 338.62,166.25 340.17,167.8 340.17,181.59 343.49,184.91 344.92,184.91 345.21,184.63 345.81,184.63
D10705: length 284.4
  L29_SIGNAL w0.076: v2(227.26,183) 226.93,183.33 225.8,183.33
  L29_SIGNAL w0.091: D107.05 389.89,57.15 389.89,62.09 388.62,63.36 372.87,63.36 351.65,84.58 231.39,84.58 218.89,97.08 218.89,160.86 219.47,161.44 219.47,166.01 220.9,167.44 220.9,180.92 223.32,183.33 225.8,183.33
D10706: length 227.7
  L27_SIGNAL w0.076: v2(267.25,183) 266.93,183.33 265.8,183.33
  L27_SIGNAL w0.091: 265.8,183.33 263.32,183.33 260.9,180.92 260.9,167.44 259.47,166.01 259.47,161.44 258.89,160.86 258.89,129.92 262.32,126.49 266.64,126.49 282.92,110.21 282.92,105.3 302.12,86.09 359.57,86.09 379.37,66.29 387.6,66.29 392.43,61.47 392.43,59.69 D107.06
D10707: length 206.9
  L25_SIGNAL w0.076: 305.8,183.33 306.93,183.33 v2(307.25,183)
  L25_SIGNAL w0.091: 305.8,183.33 303.32,183.33 300.9,180.92 300.9,167.44 299.47,166.01 299.47,161.44 298.89,160.86 298.89,130.12 304.04,124.97 320.07,124.97 322.61,122.43 322.61,107.35 323.96,105.99 348.62,105.99 372.36,82.25 372.36,65.91 378.59,59.69 394.59,59.69 394.97,59.31 394.97,57.15 D107.07
D10708: length 172.3
  L31_SIGNAL w0.076: v2(347.25,183) 346.93,183.33 345.8,183.33
  L31_SIGNAL w0.091: D107.08 397.51,59.69 397.51,61.21 396.49,62.23 376.94,62.23 356.36,82.8 356.36,121.75 352.02,126.1 343.04,126.1 338.89,130.25 338.89,160.86 339.47,161.44 339.47,166.01 340.9,167.44 340.9,180.92 343.32,183.33 345.8,183.33
D10709: length 291.2
  L29_SIGNAL w0.091: D107.09 400.05,57.15 400.05,61.59 397.55,64.09 372.78,64.09 351.78,85.09 231.65,85.09 220.67,96.07 220.67,139.29 221.2,139.83 221.2,160.88 222.28,161.95 222.28,169.43 221.27,170.44 221.27,179.51 224.71,182.95 226.17,182.95 226.23,183 v2(226.61,183)
D10710: length 237
  L27_SIGNAL w0.091: D107.10 402.66,59.62 402.66,63.65 399.21,67.11 379.19,67.11 359.76,86.54 302.31,86.54 283.37,105.48 283.37,113.79 270.08,127.07 263.52,127.07 261.2,129.39 261.2,160.88 262.28,161.95 262.28,169.43 261.27,170.44 261.27,179.51 264.71,182.95 266.17,182.95 266.23,183 v2(266.61,183)
D10711: length 214.8
  L25_SIGNAL w0.091: D107.11 405.13,57.15 405.13,61.39 404.55,61.98 377.16,61.98 372.78,66.36 372.78,82.42 348.79,106.41 324.13,106.41 323.02,107.52 323.02,122.69 320.24,125.48 304.8,125.48 300.67,129.61 300.67,139.29 301.2,139.83 301.2,160.88 302.28,161.95 302.28,169.43 301.27,170.44 301.27,179.51 304.71,182.95 306.17,182.95 306.23,183 v2(306.6,183)
D10712: length 180.1
  L31_SIGNAL w0.091: v2(346.6,183) 346.23,183 346.17,182.95 344.71,182.95 341.27,179.51 341.27,170.44 342.28,169.43 342.28,161.95 341.2,160.88 341.2,139.83 340.67,139.29 340.67,130.25 344.35,126.57 352.21,126.57 356.83,121.95 356.83,83.35 375.41,64.77 406.65,64.77 407.67,63.75 407.67,59.69 D107.12
D10713: length 298.2
  L29_SIGNAL w0.091: D107.13 410.21,57.15 410.21,61.46 406.91,64.76 372.71,64.76 351.87,85.6 231.9,85.6 221.29,96.21 221.29,138.8 222.21,139.71 222.21,160.27 222.64,160.7 222.64,169.79 221.64,170.8 221.64,178.13 223.47,179.96 226.16,179.96 v2(226.61,180.41)
D10714: length 245.5
  L27_SIGNAL w0.091: v2(266.61,180.41) 266.16,179.96 263.47,179.96 261.64,178.13 261.64,170.8 262.64,169.79 262.64,160.7 262.21,160.27 262.21,129 263.7,127.51 270.26,127.51 283.82,113.95 283.82,105.67 302.49,86.99 359.95,86.99 379.18,67.77 411.48,67.77 412.76,66.48 412.76,59.68 D107.14
D10715: length 221.7
  L25_SIGNAL w0.091: v2(306.6,180.41) 306.16,179.96 303.47,179.96 301.64,178.13 301.64,170.8 302.64,169.79 302.64,160.7 302.21,160.27 302.21,139.71 301.29,138.8 301.29,129.75 305.18,125.86 320.67,125.86 323.44,123.09 323.44,107.7 324.31,106.83 348.96,106.83 373.2,82.59 373.2,66.83 377.29,62.74 413.74,62.74 415.29,61.19 415.29,57.15 D107.15
D10716: length 187.5
  L31_SIGNAL w0.091: v2(346.6,180.41) 346.16,179.96 343.47,179.96 341.64,178.13 341.64,170.8 342.64,169.79 342.64,160.7 342.21,160.27 342.21,139.71 341.29,138.8 341.29,131.91 346.09,127.11 352.44,127.11 357.38,122.17 357.38,83.82 373.89,67.31 416.56,67.31 417.83,66.04 417.83,59.69 D107.16
D10801: length 340.1
  L29_SIGNAL w0.079: 383.44,33.12 383.44,33.12 383.44,32 383.05,31.61 382.94,31.61 382.88,31.68 382.76,31.68 382.65,31.57 382.65,31.46 382.72,31.39 382.72,31.28 382.61,31.17 382.5,31.17 382.43,31.24 382.32,31.24 382.21,31.12 382.21,31.01 382.27,30.95 382.27,30.83 381.75,30.3 367.37,30.3 359.33,22.27 355.87,22.27 351.43,26.7 351.43,79.86 348.36,82.93 224.53,82.93 212.74,94.72 212.74,141.25 214.36,142.86 214.36,159.93 211.42,162.86 211.42,175.31 209.61,177.13 209.61,179.29 210.83,180.52 210.83,185.14 211.51,185.82 211.51,190.06 v1(211.66,190.22)
  L29_SIGNAL w0.091: 383.44,33.12 D108.01
D10802: length 285.6
  L27_SIGNAL w0.079: 384.71,36.19 384.71,33.96 382.63,31.88 379.34,31.88 377.08,34.14 377.08,36.72 377.16,36.8 377.36,36.8 377.44,36.88 377.44,37.03 377.36,37.11 377.16,37.11 377.08,37.19 377.08,37.35 377.16,37.43 377.36,37.43 377.44,37.51 377.44,37.66 377.36,37.74 377.16,37.74 377.08,37.82 377.08,37.98 377.16,38.06 377.36,38.06 377.44,38.14 377.44,38.29 377.36,38.37 377.16,38.37 377.08,38.45 377.08,38.61 377.16,38.69 377.36,38.69 377.44,38.77 377.44,38.92 377.36,39 377.16,39 377.08,39.08 377.08,39.24 377.16,39.32 377.36,39.32 377.44,39.4 377.44,39.55 377.36,39.63 377.16,39.63 377.08,39.71 377.08,64.08 376.46,64.7 375.05,64.7 374.46,64.11 374.46,58.99 373.63,58.17 370.08,58.17 369.26,58.99 369.26,62.95 347.34,84.86 300.09,84.86 280.92,104.02 280.92,109.56 278.6,111.89 254.13,111.89 253.05,112.97 253.05,141.55 254.36,142.86 254.36,159.93 251.42,162.86 251.42,175.31 249.61,177.13 249.61,179.29 250.83,180.52 250.83,185.14 251.51,185.82 251.51,190.06 v1(251.66,190.22)
  L27_SIGNAL w0.091: 384.71,36.19 384.71,36.93 D108.02
D10803: length 340.1
  L29_SIGNAL w0.079: v1(211.16,190.22) 211.31,190.06 211.31,185.9 210.64,185.22 210.64,180.6 209.41,179.37 209.41,177.05 211.23,175.23 211.23,162.78 214.16,159.85 214.16,142.94 212.55,141.33 212.55,94.64 224.45,82.74 348.28,82.74 351.24,79.78 351.24,26.62 355.79,22.07 359.41,22.07 367.45,30.11 381.83,30.11 383.64,31.92 383.64,33.12
  L29_SIGNAL w0.091: 383.64,33.12 D108.03
D10804: length 285.6
  L27_SIGNAL w0.079: v1(251.16,190.22) 251.31,190.06 251.31,185.9 250.64,185.22 250.64,180.6 249.41,179.37 249.41,177.05 251.23,175.23 251.23,162.78 254.16,159.85 254.16,142.94 252.85,141.63 252.85,112.89 254.05,111.69 278.52,111.69 280.73,109.48 280.73,103.94 300.01,84.67 347.26,84.67 369.06,62.87 369.06,58.91 370,57.97 373.71,57.97 374.65,58.91 374.65,64.03 375.13,64.51 376.38,64.51 376.89,64 376.89,34.06 379.26,31.68 382.71,31.68 384.91,33.88 384.91,36.1
  L27_SIGNAL w0.091: D108.04 387.35,36.83 385.64,36.83 384.91,36.1
D10805: length 304.3
  L25_SIGNAL w0.079: 393.6,33.12 393.6,32.93 393.38,32.7 393.27,32.7 393.2,32.77 393.09,32.77 392.98,32.66 392.98,32.55 393.04,32.48 393.04,32.37 392.93,32.26 392.82,32.26 392.76,32.32 392.64,32.32 392.53,32.21 392.53,32.1 392.6,32.04 392.6,31.92 392.3,31.62 380.64,31.62 369.57,42.69 369.57,70.58 367.12,73.04 360.33,73.04 357.8,70.51 357.8,46.34 356.21,44.75 353.26,44.75 351.69,46.32 351.69,80.17 343.76,88.1 305.49,88.1 300.95,92.63 300.95,102.61 305.31,106.97 305.31,117.86 293.05,130.12 293.05,141.55 294.36,142.86 294.36,159.93 291.42,162.86 291.42,175.31 289.61,177.13 289.61,179.29 290.83,180.52 290.83,185.14 291.51,185.82 291.51,190.06 v1(291.66,190.22)
  L25_SIGNAL w0.091: 393.6,33.12 D108.05
D10806: length 342.5
  L31_SIGNAL w0.079: v1(331.66,190.22) 331.51,190.06 331.51,185.82 330.83,185.14 330.83,180.52 329.61,179.29 329.61,177.13 331.42,175.31 331.42,162.86 334.36,159.93 334.36,142.86 333.05,141.55 333.05,129.82 338.12,124.75 351.24,124.75 353.64,122.34 353.64,89.17 350.71,86.24 350.71,35.88 351.94,34.66 354.17,34.66 355.35,35.83 355.35,70.8 356.04,71.49 359.37,71.49 360.07,70.79 360.07,36.8 362.14,34.72 367.97,34.72 370.02,36.78 370.02,59.08 370.92,59.98 373.63,59.98 374.59,59.02 374.59,40.19 376.19,38.59 376.3,38.59 376.42,38.71 376.53,38.71 376.64,38.59 376.64,38.48 376.52,38.37 376.52,38.26 376.64,38.15 376.75,38.15 376.86,38.26 376.97,38.26 377.08,38.15 377.08,38.04 376.97,37.92 376.97,37.81 377.08,37.7 377.19,37.7 377.31,37.81 377.42,37.81 377.53,37.7 377.53,37.59 377.42,37.48 377.42,37.37 377.53,37.25 377.64,37.25 377.75,37.37 377.86,37.37 377.97,37.26 377.97,37.15 377.86,37.03 377.86,36.92 377.97,36.81 378.08,36.81 378.2,36.92 378.31,36.92 378.42,36.81 378.42,36.7 378.31,36.59 378.31,36.48 378.42,36.36 378.53,36.36 378.64,36.48 378.75,36.48 378.87,36.37 378.87,36.25 378.75,36.14 378.75,36.03 380.49,34.29 394.21,34.29 394.87,34.96 394.87,36.21
  L31_SIGNAL w0.091: 394.87,36.21 394.87,36.93 D108.06
D10807: length 304.3
  L25_SIGNAL w0.079: v1(291.16,190.22) 291.31,190.06 291.31,185.9 290.64,185.22 290.64,180.6 289.41,179.37 289.41,177.05 291.23,175.23 291.23,162.78 294.16,159.85 294.16,142.94 292.85,141.63 292.85,130.04 305.11,117.78 305.11,107.05 300.76,102.69 300.76,92.55 305.41,87.9 343.68,87.9 351.5,80.09 351.5,46.24 353.18,44.56 356.29,44.56 358,46.26 358,70.43 360.41,72.84 367.04,72.84 369.38,70.5 369.38,42.61 380.56,31.43 392.38,31.43 393.8,32.85 393.8,33.12
  L25_SIGNAL w0.091: 393.8,33.12 D108.07
D10808: length 342.5
  L31_SIGNAL w0.079: 395.07,36.13 395.07,34.88 394.29,34.1 380.41,34.1 374.4,40.11 374.4,58.94 373.55,59.79 371,59.79 370.22,59 370.22,36.7 368.05,34.53 362.06,34.53 359.88,36.72 359.88,70.71 359.29,71.3 356.12,71.3 355.54,70.72 355.54,35.75 354.25,34.47 351.86,34.47 350.52,35.8 350.52,86.32 353.45,89.25 353.45,122.26 351.16,124.55 338.04,124.55 332.85,129.74 332.85,141.63 334.16,142.94 334.16,159.85 331.23,162.78 331.23,175.23 329.41,177.05 329.41,179.37 330.64,180.6 330.64,185.22 331.31,185.9 331.31,190.06 v1(331.16,190.22)
  L31_SIGNAL w0.091: D108.08 397.51,36.83 395.77,36.83 395.07,36.13
D10809: length 391
  L33_SIGNAL w0.091: UNK5K34.2 167.89,243.73 167.89,240.36 170.76,237.49 170.76,165.9 198.24,138.42 198.24,130.49 224.23,104.5 344.28,104.5 373.38,75.4 373.38,41.91 381,34.29 400.05,34.29 D108.09
D10810: length 402.2
  L23_SIGNAL w0.091: D108.10 402.74,36.98 373.61,36.98 349.02,61.57 349.02,113 334.77,127.25 193.67,127.25 180.49,140.44 180.49,243.83 UNK6K34.2
D10811: length 396.7
  L23_SIGNAL w0.091: D108.11 405.05,36.91 405.05,38.38 404.16,39.27 375.39,39.27 349.5,65.15 349.5,113.28 335.03,127.76 198.42,127.76 190.45,135.74 190.45,243.53 UNK7K34.2
D10812: length 391.7
  L23_SIGNAL w0.091: D108.12 407.41,39.63 375.78,39.63 349.88,65.53 349.88,116.59 338.2,128.27 203.69,128.27 201.29,130.66 201.29,233.6 200.86,234.04 200.86,242.77 UNK8K34.2
D10813: length 322.5
  L31_SIGNAL w0.076: v2(227.26,183.65) 226.93,183.98 225.81,183.98
  L31_SIGNAL w0.091: v3(229.87,118.56) 227.35,118.56 218.71,127.21 218.71,147.69 221.7,150.69 221.7,157.71 222.67,158.67 222.67,164.46 223.34,165.13 224.8,165.13 225.27,165.6 225.27,169.53 223.83,170.97 223.83,177.71 223,178.54 223,181.49 225.49,183.98 225.81,183.98
  L33_SIGNAL w0.091: D108.13 410.11,36.93 380.64,36.93 374.55,43.03 374.55,74.75 344.42,104.88 231.4,104.88 227.63,108.64 227.63,116.35 229.85,118.56 v3(229.87,118.56)
D10814: length 345
  L29_SIGNAL w0.076: 265.81,183.98 266.93,183.98 v2(267.25,183.65)
  L29_SIGNAL w0.091: D108.14 415.29,39.37 420.75,39.37 424.43,43.05 424.43,99.05 419.11,104.38 355.62,104.38 354.43,103.19 247.33,103.19 243.59,106.93 243.59,127 254.13,137.54 254.13,138.68 254.38,138.94 255.63,138.94 258.71,142.02 258.71,147.15 261.7,150.15 261.7,157.79 262.67,158.75 262.67,164.46 263.34,165.13 264.8,165.13 265.27,165.6 265.27,169.53 263.83,170.97 263.83,177.71 263,178.54 263,181.49 265.49,183.98 265.81,183.98
D10815: length 279.9
  L27_SIGNAL w0.076: v2(307.25,183.65) 306.93,183.98 305.81,183.98
  L27_SIGNAL w0.091: 305.81,183.98 305.49,183.98 303,181.49 303,178.54 303.83,177.71 303.83,170.97 305.27,169.53 305.27,165.6 304.8,165.13 303.34,165.13 302.67,164.46 302.67,158.49 301.7,157.52 301.7,150.3 298.71,147.3 298.71,127.8 302.02,124.49 302.02,108.24 306.88,103.38 419.91,103.38 423.66,99.62 423.66,37.3 423.19,36.83 417.83,36.83 D108.15
D10816: length 229.2
  L25_SIGNAL w0.076: 345.8,183.98 346.93,183.98 v2(347.25,183.65)
  L25_SIGNAL w0.091: 345.8,183.98 345.49,183.98 343,181.49 343,178.54 343.83,177.71 343.83,170.97 345.27,169.53 345.27,165.6 344.8,165.13 343.34,165.13 342.67,164.46 342.67,158.68 341.7,157.72 341.7,151.9 341.09,151.29 341.09,139.1 347.22,132.97 347.22,132.08 349.5,129.79 370.08,129.79 371.09,128.78 416.34,128.78 426.32,118.8 426.32,45.32 D108.16
D10901: length 333.4
  L19_SIGNAL w0.076: 234.08,249.79 234.08,248.53 v2(233.76,248.2)
  L19_SIGNAL w0.102: D109.01 420.4,331.5 420.4,326.98 419.21,325.78 390.5,325.78 385.83,321.11 385.83,304.49 381.33,299.99 381.33,268.01 377.51,264.19 357.35,264.19 356.34,263.19 340.58,263.19 339.55,264.21 316.84,264.21 315.88,263.26 300.93,263.26 300.21,263.98 274.6,263.98 264.55,253.93 258.03,253.93 257.53,253.43 255.63,253.43 255.32,253.74 241.66,253.74 240.84,254.56 238.01,254.56 236.21,256.36 229.54,256.36 227.07,253.9 217.86,253.9 215.19,251.23 215.19,243.5 213.11,241.41 213.11,236.22 213.61,235.71 221.55,235.71 223.78,237.95 234.52,237.95 237.73,241.16 237.73,248.99 235.46,251.26 234.7,251.26 234.08,250.65 234.08,249.79
D10902: length 334.3
  L19_SIGNAL w0.076: v2(232.46,248.2) 232.78,248.53 232.78,251.01
  L19_SIGNAL w0.102: D109.02 415.11,326.21 390.32,326.21 385.4,321.29 385.4,304.67 380.89,300.17 380.89,268.19 377.33,264.63 357.17,264.63 356.16,263.62 340.76,263.62 339.73,264.64 316.66,264.64 315.71,263.69 301.11,263.69 300.39,264.42 274.4,264.42 264.34,254.36 257.82,254.36 257.31,253.86 255.81,253.86 255.5,254.17 241.82,254.17 240.26,255.73 238.19,255.73 237.15,256.77 229.37,256.77 227.03,254.43 216.82,254.43 215.21,252.83 215.21,251.89 214.78,251.46 214.78,244.22 212.6,242.03 212.6,235.71 213.87,234.44 221.08,234.44 224.13,237.49 235.55,237.49 238.8,240.74 238.8,248.61 235.71,251.69 233.35,251.69 232.78,251.12 232.78,251.01
D10905: length 224.4
  L17_SIGNAL w0.508: v2(319.33,270.23) 319.07,269.98
  L17_SIGNAL w1.016: 319.07,269.98 318.3,269.98 316.91,268.58 313.5,268.58 312.38,269.7 311.11,269.7 308.83,271.98 308.83,293.13 312.87,297.17 312.87,300.71 315.06,302.9 318.21,302.9 320.19,304.88 320.19,316.72 321.21,317.74 344.26,317.74 345.34,318.82 345.34,324.24 349.86,328.77 349.86,364.85 352.46,367.45 375.58,367.45 378.5,364.53 378.5,349.48 382.54,345.44 398.78,345.44 D109.05
  BOTTOM w0.305: UNK3U450.3 v2(319.33,270.23)
D10906: length 263.6
  L17_SIGNAL w0.508: 367.04,271.22 v2(366.71,271.22)
  L17_SIGNAL w1.016: 367.04,271.22 368.48,271.22 370.46,269.24 372.49,269.24 373.38,268.35 373.38,259.51 373.81,259.08 390.32,259.08 391.21,259.97 391.21,270.82 392.21,271.82 420.57,271.82 421.74,270.64 421.74,267.57 420.62,266.45 402.17,266.45 401.44,265.72 401.44,262.6 402.42,261.62 438.96,261.62 444.87,267.54 444.87,303.06 438.45,309.48 399.33,309.48 398.53,310.27 398.53,321.02 401.55,324.04 402.78,324.04 D109.06
  BOTTOM w0.305: UNK4U451.4 366.1,270.6 v2(366.71,271.22) 366.4,271.53 UNK4U452.7
D10907: length 207.1
  L17_SIGNAL w0.508: 317.37,272.47 318.08,271.75 v2(318.08,271.17)
  L17_SIGNAL w1.016: 317.37,272.47 313.45,272.47 312.92,273 312.92,283.36 314.95,285.39 314.95,300.51 315.76,301.32 319.34,301.32 323.02,305 323.02,312.47 324.08,313.53 344.02,313.53 345.35,314.86 345.35,316.72 346.37,317.74 348.15,317.74 349.16,318.76 349.16,321.13 351.61,323.58 351.61,363.52 353.59,365.5 374.27,365.5 377.14,362.63 377.14,348.2 381.66,343.68 395.46,343.68 D109.07
  BOTTOM w0.305: v2(318.08,271.17) 318.08,270.81 318.33,270.56 UNK3U450.1
D10908: length 264.1
  L17_SIGNAL w0.508: v2(365.6,271.22) 365.6,271.9
  L17_SIGNAL w1.016: D109.08 396.53,322.87 396.53,307.04 398.29,305.28 436.14,305.28 442.66,298.76 442.66,272.07 434.75,264.16 425.12,264.16 424.1,265.18 424.1,268.55 424.87,269.32 434.85,269.32 435.86,270.34 435.86,273.24 434.85,274.25 389.32,274.25 388.6,273.54 388.6,262.33 387.9,261.63 376.74,261.63 375.88,262.49 375.88,283.09 374.23,284.74 365.73,284.74 365.16,284.17 365.16,275.18 365.6,274.75 365.6,271.9
  BOTTOM w0.305: UNK4U452.8 365.9,271.53 v2(365.6,271.22) UNK4U451.3
D10909: length 206.3
  L17_SIGNAL w0.508: 319.42,271.51 v2(319.08,271.17)
  L17_SIGNAL w1.016: 319.42,271.51 319.42,272.39 319.01,272.8 319.01,273.91 318.43,274.5 315.7,274.5 314.99,275.22 314.99,277.97 315.68,278.66 316.4,278.66 317.01,279.27 317.01,281.18 316.24,281.94 316.24,283.38 321.02,288.15 321.02,300.68 324.62,304.28 324.62,308.38 325.63,309.39 344.02,309.39 345.44,310.81 345.44,312.52 346.45,313.53 352.01,313.53 354.42,315.95 354.42,361.01 355.75,362.34 372.87,362.34 375.47,359.74 375.47,354.95 373.67,353.15 368.68,353.15 367.67,352.13 367.67,349.36 368.95,348.08 374.69,348.08 380.78,341.98 392.08,341.98 D109.09
  BOTTOM w0.305: UNK3U450.2 318.83,270.56 319.08,270.81 v2(319.08,271.17)
D10910: length 223.7
  L17_SIGNAL w0.508: 360.57,270.48 v2(360.33,270.23)
  L17_SIGNAL w0.762: 361.07,274.57 361.25,274.75 361.25,278.28
  L17_SIGNAL w1.016: 360.57,270.48 361.07,270.98 361.07,274.57 ; 361.25,278.28 361.07,278.46 361.07,286.08 361.74,286.75 377.08,286.75 380.75,283.08 380.75,265.35 381.76,264.33 385.15,264.33 386.17,265.35 386.17,276.02 386.86,276.71 435.54,276.71 440.47,281.64 440.47,297.41 434.32,303.56 396.17,303.56 392.13,307.61 392.13,323.55 D109.10
  BOTTOM w0.305: v2(360.33,270.23) 359.83,269.74 UNK4U450.4
D10911: length 223.7
  L17_SIGNAL w0.508: 320.57,270.48 v2(320.33,270.23)
  L17_SIGNAL w0.762: 321.25,278.28 321.25,274.75 321.07,274.57
  L17_SIGNAL w1.016: 321.07,274.57 321.07,270.98 320.57,270.48 ; 321.25,278.28 321.07,278.46 321.07,284.23 321.58,284.73 322.62,284.73 323.08,285.19 323.08,300.58 327.48,304.98 352.59,304.98 356.16,308.55 356.16,357.78 357.78,359.4 370.69,359.4 371.97,358.12 371.97,355.97 370.96,354.96 362.49,354.96 361.18,353.65 361.18,333.11 362.62,331.66 367.44,331.66 369.03,333.26 369.03,344.36 370.5,345.82 374.42,345.82 379.99,340.25 388.73,340.25 D109.11
  BOTTOM w0.305: UNK3U450.4 319.83,269.74 v2(320.33,270.23)
D10912: length 206.3
  L17_SIGNAL w0.508: 359.42,271.51 v2(359.08,271.17)
  L17_SIGNAL w1.016: D109.12 389.81,326.31 389.81,306.04 393.97,301.88 431.96,301.88 436.92,296.93 436.92,283.1 433.33,279.52 384.26,279.52 383.44,280.33 383.44,287.08 381.74,288.78 360.52,288.78 355.89,284.15 355.89,282.29 357.35,280.83 358.55,280.83 359.08,280.3 359.08,279.33 358.43,278.68 355.73,278.68 354.95,277.89 354.95,275.3 355.75,274.5 358.43,274.5 359.01,273.91 359.01,272.8 359.42,272.39 359.42,271.51
  BOTTOM w0.305: v2(359.08,271.17) 359.08,270.81 358.83,270.56 UNK4U450.2
D10913: length 264.1
  L17_SIGNAL w0.508: v2(325.6,271.22) 325.6,271.9
  L17_SIGNAL w0.762: 335.19,253.61 336.69,253.61
  L17_SIGNAL w1.016: 335.19,253.61 330.43,253.61 329.09,252.26 327.74,252.26 327.14,251.66 327.14,242.64 326.63,242.13 323.57,242.13 323.08,242.63 323.08,251.74 322.6,252.22 319.66,252.22 319.07,252.81 319.07,264.13 319.46,264.52 328.75,264.52 330.61,266.37 330.61,283.82 329.59,284.84 325.59,284.84 325.02,284.26 325.02,275.33 325.6,274.75 325.6,271.9 ; D109.13 385.38,338.52 377.85,338.52 376.1,336.77 376.1,329 372.83,325.73 372.83,312.03 363.97,303.16 344.68,303.16 342.76,301.25 342.76,292.88 336.67,286.78 336.67,268.63 340.45,264.85 340.45,262.14 341.31,261.28 354.01,261.28 355.14,260.15 355.14,257.65 354.37,256.87 344.63,256.87 343.95,256.18 343.39,256.18 342.86,255.65 342.86,252.36 342.73,252.24 338.85,252.24 337.48,253.61 336.69,253.61
  BOTTOM w0.305: UNK3U451.3 v2(325.6,271.22) 325.9,271.53 UNK3U452.8
D10914: length 207.1
  L17_SIGNAL w0.508: 357.37,272.47 358.08,271.75 v2(358.08,271.17)
  L17_SIGNAL w1.016: D109.14 384.1,325.68 384.1,305.99 385.12,304.97 387.79,304.97 393.7,299.06 393.7,298.07 394.56,297.21 433.03,297.21 435.26,294.97 435.26,283.94 433.25,281.93 386.87,281.93 386.05,282.76 386.05,288.87 385.35,289.56 383.59,289.56 382.35,290.8 357.42,290.8 354.95,288.33 354.95,285.39 352.92,283.36 352.92,273 353.45,272.47 357.37,272.47
  BOTTOM w0.305: v2(358.08,271.17) 358.08,270.81 358.33,270.56 UNK4U450.1
D10915: length 263.7
  L17_SIGNAL w0.508: 327.04,271.22 v2(326.71,271.22)
  L17_SIGNAL w1.016: D109.15 381.93,336.89 380.06,336.89 378.19,335.02 378.19,328.59 374.6,325.01 374.6,306.28 380.89,299.99 384.89,299.99 385.9,298.97 385.9,295.56 384.89,294.55 375.85,294.55 369.06,301.33 345.73,301.33 344.87,300.46 344.87,284.51 342.81,282.45 342.81,270.16 343.14,269.83 343.14,265.96 345.54,263.56 355.11,263.56 356.23,262.44 358.4,262.44 358.95,261.9 358.95,256.96 358.28,256.29 357.68,256.29 354.95,253.57 354.95,252.96 354.31,252.32 352.28,252.32 351.1,253.51 347.16,253.51 345.72,252.07 345.72,251.74 342.11,248.13 336.02,248.13 333.24,245.35 331.25,245.35 330.24,244.34 330.24,239.31 328.99,238.07 321.71,238.07 321.1,238.68 321.1,249.83 320.71,250.23 317.68,250.23 316.91,251 316.91,265.65 317.68,266.42 328.49,266.42 329.15,267.08 329.15,270.44 328.37,271.22 327.04,271.22
  BOTTOM w0.305: UNK3U451.4 326.1,270.6 v2(326.71,271.22) 326.4,271.53 UNK3U452.7
D10916: length 224.4
  L17_SIGNAL w0.508: v2(359.33,270.23) 359.07,269.98
  L17_SIGNAL w1.016: D109.16 381.38,328.04 381.15,328.04 376.41,323.29 376.41,306.34 379.39,303.36 386.44,303.36 391.2,298.61 391.2,295.48 392.12,294.56 430.29,294.56 431.3,293.54 431.3,288.07 430.21,286.97 389.17,286.97 388.54,287.61 388.54,291.27 387.52,292.29 375.31,292.29 368.55,299.05 349.67,299.05 348.83,298.2 348.83,271.98 351.11,269.7 352.38,269.7 353.5,268.58 356.91,268.58 358.3,269.98 359.07,269.98
  BOTTOM w0.305: UNK4U450.3 v2(359.33,270.23)
D11001: length 275.9
  L27_SIGNAL w0.076: v2(235.06,244.31) 236.13,244.31
  L27_SIGNAL w0.091: D110.01 420.37,351.79 420.37,347.2 418.24,345.07 269.38,345.07 245.47,321.16 245.47,304.14 239.46,298.13 239.46,287.83 238.14,286.51 238.14,280.74 238.53,280.35 238.53,270.98 237.86,270.31 237.86,267.44 238.63,266.67 238.63,253.96 239.43,253.17 239.43,246.91 236.82,244.31 236.13,244.31
D11002: length 229.9
  L25_SIGNAL w0.076: v2(275.06,244.31) 276.13,244.31
  L25_SIGNAL w0.091: D110.02 415.16,346.58 348.74,346.58 345.39,343.23 309.16,343.23 289.36,323.43 289.36,295.96 287.12,293.72 285.55,293.72 282.4,290.58 281.89,290.58 279.46,288.14 279.46,287.83 278.14,286.51 278.14,280.74 278.53,280.35 278.53,270.98 277.86,270.31 277.86,267.44 278.63,266.67 278.63,253.96 279.43,253.17 279.43,246.91 276.82,244.31 276.13,244.31
D11003: length 188.9
  L31_SIGNAL w0.076: 316.13,244.31 v2(315.05,244.31)
  L31_SIGNAL w0.091: D110.03 415.29,351.79 415.29,347.73 410.83,343.27 365.63,343.27 355.36,332.99 355.36,317.39 350.39,312.42 350.39,312.4 342.92,304.93 327.65,304.93 322.51,299.79 322.51,299.79 320.22,297.49 320.22,297.49 319.53,296.81 319.53,283.97 318.14,282.58 318.14,280.74 318.53,280.35 318.53,270.98 317.86,270.31 317.86,267.44 318.63,266.67 318.63,253.96 319.43,253.17 319.43,246.91 316.82,244.31 316.13,244.31
D11004: length 164.5
  L29_SIGNAL w0.076: 356.13,244.31 v2(355.05,244.31)
  L29_SIGNAL w0.091: v3(351.79,316.41) 352.12,316.41 359.54,308.99 359.54,287.91 358.14,286.51 358.14,280.74 358.53,280.35 358.53,270.98 357.86,270.31 357.86,267.44 358.63,266.67 358.63,253.96 359.43,253.17 359.43,246.91 356.82,244.31 356.13,244.31
  L31_SIGNAL w0.091: v3(351.79,316.41) 354.96,319.58 354.96,333.38 365.38,343.79 407.29,343.79 D110.04
D11005: length 318.8
  L29_SIGNAL w0.091: K34.2 171.67,271.89 171.67,298.14 224.01,350.47 277.7,350.47 307.64,380.42 345.77,380.42 376.94,349.25 409.45,349.25 410.21,350.01 410.21,351.79 D110.05
D11006: length 287.6
  L23_SIGNAL w0.091: UNK2K34.2 181.48,272.05 181.48,284.86 183.39,286.77 197.74,286.77 203.45,292.48 223.01,292.48 223.78,293.25 231.39,293.25 231.91,292.74 235.26,292.74 235.7,293.17 259.42,293.17 261.06,291.52 269.67,291.52 270.81,292.66 277.2,292.66 277.5,292.35 284.73,292.35 286.38,294 289.18,294 292.1,296.93 292.1,301.87 292.95,302.72 351.75,302.72 355.6,306.57 355.6,313.17 382.16,339.73 386.97,339.73 394.97,347.73 394.97,353.82 395.61,354.46 406.91,354.46 407.67,353.69 407.67,351.79 D110.06
D11007: length 272.7
  L23_SIGNAL w0.091: D110.07 405.14,353.06 400.56,348.48 400.56,346.58 393.22,339.24 382.36,339.24 356.11,312.99 356.11,306.39 351.95,302.23 293.15,302.23 292.58,301.67 292.58,294.55 288.88,290.86 278.43,290.86 277.03,292.25 270.98,292.25 269.07,290.35 261.66,290.35 259.25,292.76 235.86,292.76 235.23,292.13 226.65,292.13 224.62,290.09 222.04,290.09 221.02,291.11 203.61,291.11 198.63,286.13 192.79,286.13 191.13,284.48 191.13,272.05 UNK3K34.2
D11008: length 261.7
  L23_SIGNAL w0.091: D110.08 401.32,347.98 401.32,346.46 393.7,338.84 382.52,338.84 356.62,312.93 356.62,306.07 352.37,301.83 293.32,301.83 292.99,301.5 292.99,294.39 289.05,290.45 278.26,290.45 276.86,291.85 271.14,291.85 269.24,289.94 261.49,289.94 259.08,292.35 237.24,292.35 235.46,290.58 232.16,290.58 231.01,291.72 226.82,291.72 224.79,289.69 221.87,289.69 220.85,290.7 204.6,290.7 200.66,286.77 200.66,271.93 UNK4K34.2
D11009: length 360.5
  L29_SIGNAL w0.091: K2.2 132.08,259.94 132.08,280.36 202.95,351.24 277.27,351.24 307.44,381.41 346.56,381.41 376.17,351.79 400.05,351.79 D110.09
D11010: length 364.9
  L21_SIGNAL w0.102: UNK2K2.2 150.42,246.52 150.42,289.63 161.69,300.9 326.55,300.9 352.79,327.14 352.79,337.55 364.49,349.25 397.51,349.25 D110.10
D11011: length 228.8
  L21_SIGNAL w0.102: D110.11 397.51,351.79 422.4,351.79 425.96,348.23 425.96,329.07 456.95,298.08 456.95,270 446.53,259.59 446.53,214.38 450.21,210.69 484,210.69 484.89,211.58 484.89,215.23 UNK3K2.2
D11012: length 170.4
  L17_SIGNAL w0.091: D110.12 394.97,351.79 394.97,355.9 395.94,356.87 425.45,356.87 480.06,302.26 480.06,300.48 485.09,295.45 485.09,249.81 UNK4K2.2
D11013: length 372.2
  TOP w0.16: SW10.5 v3(126.48,288.29)
  L23_SIGNAL w0.091: v3(126.48,288.29) 125.67,288.29 96.82,259.45 96.82,250.08 K6.2
  L29_SIGNAL w0.091: v3(126.48,288.29) 147.73,309.54 157.69,309.54 199.93,351.79 276.56,351.79 307.04,382.26 347.73,382.26 373.38,356.62 387.6,356.62 D110.13
D11014: length 377.8
  L23_SIGNAL w0.091: D110.14 355.09,316.99 355.09,306.83 351.35,303.09 167.97,303.09 162.4,297.53 162.4,273.15 126.62,237.36 126.62,222.43 122.63,218.44 96.93,218.44 UNK2K6.2
D11015: length 191.4
  L17_SIGNAL w0.091: UNK3K6.2 459.31,218.44 450.96,218.44 449.24,220.16 449.24,320.13 422.55,346.81 391.69,346.81 389.89,348.62 389.89,351.05 389.15,351.79 387.35,351.79 D110.15
D11016: length 157.8
  L15_SIGNAL w0.091: D110.16 384.94,349.12 423.56,349.12 425.34,347.35 425.34,340.35 462.28,303.4 462.28,249.78 UNK4K6.2
D11101: length 396.3
  TOP w0.16: SW10.1 v3(126.48,298.45)
  L23_SIGNAL w0.091: K2.7 119.02,250.08 119.02,265.08 130.09,276.15 130.09,294.84 v3(126.48,298.45)
  L29_SIGNAL w0.091: v3(126.48,298.45) 140.34,312.31 152.04,312.31 194.87,355.14 275.17,355.14 305.65,385.61 409.41,385.61 D111.01
D11102: length 409.5
  L17_SIGNAL w0.091: D111.02 417.83,372.11 417.83,376.43 417.02,377.24 305.51,377.24 295.36,367.1 229.98,367.1 206.22,343.34 186.37,343.34 162.56,319.53 162.56,257.74 123.05,218.23 118.92,218.23 UNK2K2.7
D11103: length 195.6
  L15_SIGNAL w0.091: D111.03 417.83,372.11 424.56,372.11 427.86,368.81 427.86,354.99 469.16,313.69 472.82,313.69 488.06,298.45 488.06,243.2 484.76,239.9 484.76,225.3 481.71,222.25 481.71,218.24 UNK3K2.7
D11104: length 157.9
  L15_SIGNAL w0.091: D111.04 415.29,369.57 425.2,369.57 427.1,367.66 427.1,350.93 484.5,293.53 484.5,249.8 UNK4K2.7
D11105: length 388.3
  TOP w0.16: SW10.2 v3(126.48,295.91)
  L23_SIGNAL w0.091: K4.7 106.32,250.08 106.32,258.04 127.4,279.11 127.4,288.59 125.75,290.24 125.75,291.28 127.36,292.9 127.36,295.03 v3(126.48,295.91)
  L29_SIGNAL w0.091: D111.05 400.08,384.78 306,384.78 275.52,354.3 197.43,354.3 154.8,311.67 142.73,311.67 126.97,295.91 v3(126.48,295.91)
D11106: length 402.4
  L21_SIGNAL w0.102: UNK2K4.7 106.3,215.19 106.3,214.12 106.93,213.49 111.89,213.49 112.78,214.38 112.78,220.47 114.17,221.87 116.2,221.87 149.86,255.52 149.86,290.11 161.23,301.48 326.4,301.48 352.21,327.29 352.21,337.79 378.9,364.49 404.37,364.49 405.13,365.25 405.13,367.03 D111.06
D11107: length 205.6
  L21_SIGNAL w0.102: D111.07 407.52,372.26 423.52,372.26 426.97,368.81 426.97,333.46 453.65,306.78 453.65,305.31 459.49,299.48 459.49,270 448.56,259.08 448.56,234.31 461.26,221.62 468.12,221.62 468.88,220.85 468.88,218.36 UNK3K4.7
D11108: length 161.7
  L15_SIGNAL w0.091: D111.08 407.29,367.41 424.81,367.41 426.08,366.14 426.08,343.82 451.38,318.52 451.48,318.52 472.19,297.81 472.19,250.18 UNK4K4.7
D11109: length 380.2
  TOP w0.16: SW10.3 v3(126.48,293.37)
  L23_SIGNAL w0.091: K6.7 93.62,250.08 93.62,262.24 124.75,293.37 v3(126.48,293.37)
  L29_SIGNAL w0.091: v3(126.48,293.37) 144.36,311.25 155.16,311.25 197.37,353.46 275.87,353.46 306.35,383.94 390.76,383.94 D111.09
D11110: length 401.7
  L21_SIGNAL w0.102: UNK2K6.7 93.14,215.65 102.11,215.65 103.25,216.79 103.25,217.42 103.89,218.06 105.54,218.06 106.43,217.17 106.43,216.28 107.06,215.65 109.09,215.65 109.98,216.53 109.98,220.98 112.39,223.39 116.71,223.39 149.35,256.03 149.35,290.54 160.84,302.04 323.37,302.04 351.65,330.32 351.65,338.02 380.92,367.28 395.22,367.28 D111.10
D11111: length 205.5
  L21_SIGNAL w0.102: D111.11 397.76,371.86 423.16,371.86 426.47,368.55 426.47,329.44 457.83,298.07 457.83,269.62 447.55,259.33 447.55,230.25 456.18,221.62 456.18,218.36 UNK3K6.7
D11112: length 168.2
  L17_SIGNAL w0.091: UNK4K6.7 456.64,249.66 456.64,316.66 424.05,349.25 392.89,349.25 392.43,349.71 392.43,369.57 D111.12
D11113: length 363
  TOP w0.16: SW10.4 v3(126.48,290.83)
  L23_SIGNAL w0.091: K4.2 109.52,250.08 109.52,257.64 129.11,277.23 129.11,289.15 127.43,290.83 v3(126.48,290.83)
  L29_SIGNAL w0.091: D111.13 381.44,383.1 306.69,383.1 276.22,352.62 200,352.62 157.3,309.93 146.29,309.93 127.2,290.83 v3(126.48,290.83)
D11114: length 371.2
  L21_SIGNAL w0.102: D111.14 387.22,369.44 382.34,369.44 351.13,338.24 351.13,330.43 323.26,302.56 160.45,302.56 148.84,290.95 148.84,256.54 116.71,224.41 112.27,224.41 109.35,221.49 109.35,218.15 UNK2K4.2
D11115: length 231.8
  L21_SIGNAL w0.102: D111.15 387.35,374.65 422.27,374.65 427.38,369.54 427.38,333.63 460.38,300.63 460.38,268.86 449.83,258.32 449.83,234.31 455.04,229.11 467.23,229.11 470.28,226.06 470.28,223.14 472.06,221.36 472.06,218.39 UNK3K4.2
D11116: length 184.9
  L15_SIGNAL w0.091: D111.16 384.68,371.98 412.37,371.98 413,371.35 413,370.08 413.88,369.2 423.92,369.2 426.46,366.65 426.46,347.22 474.73,298.96 474.73,249.52 UNK4K4.2
D11201: length 294.1
  L27_SIGNAL w0.076: 235.51,245.28 234.08,245.28 v2(233.76,244.96)
  L27_SIGNAL w0.091: D112.01 420.37,392.43 420.37,385.83 418.08,383.54 384.81,383.54 346.84,345.57 269.11,345.57 244.93,321.39 244.93,304.24 238.53,297.83 238.53,295.8 238.17,295.44 238.17,287.06 236.98,285.87 236.98,279.36 237.49,278.85 237.49,254.53 238.98,253.04 238.98,248.76 235.51,245.28
D11202: length 247.1
  L25_SIGNAL w0.076: 275.51,245.28 274.08,245.28 v2(273.76,244.96)
  L25_SIGNAL w0.091: D112.02 411.98,384.04 385.31,384.04 345,343.73 308.95,343.73 288.86,323.63 288.86,296.9 286.58,294.62 284.05,294.62 278.17,288.74 278.17,287.06 276.98,285.87 276.98,279.36 277.49,278.85 277.49,254.53 278.98,253.04 278.98,248.76 275.51,245.28
D11203: length 226.2
  L31_SIGNAL w0.076: 315.51,245.28 314.08,245.28 v2(313.76,244.96)
  L31_SIGNAL w0.091: 315.51,245.28 318.98,248.76 318.98,253.04 317.49,254.53 317.49,278.85 316.98,279.36 316.98,282.95 318.17,284.13 318.17,295.44 319.02,296.3 319.02,297.69 326.71,305.38 339.61,305.38 350,315.76 350,364.86 366.27,381.13 408.56,381.13 415.29,387.86 415.29,392.43 D112.03
D11204: length 192.8
  L23_SIGNAL w0.091: D112.04 407.67,384.81 386.84,384.81 373.13,371.09 373.13,345.57 350.01,322.45 350.01,316.65 351.77,314.89 v3(351.79,314.89)
  L29_SIGNAL w0.076: 355.51,245.28 354.08,245.28 v2(353.75,244.96)
  L29_SIGNAL w0.091: v3(351.79,314.89) 352.12,314.89 357.25,309.75 357.25,295.94 358.17,295.02 358.17,287.06 356.98,285.87 356.98,279.36 357.49,278.85 357.49,254.53 358.98,253.04 358.98,248.76 355.51,245.28
D11205: length 281
  L27_SIGNAL w0.091: D112.05 410.26,392.48 410.26,387.92 407.14,384.81 384.99,384.81 346.28,346.1 268.88,346.1 244.42,321.64 244.42,305.2 235.6,296.38 235.6,285.41 235.98,285.03 235.98,281.31 235.36,280.69 235.36,255.37 237,253.73 237,251.53 237.54,250.99 237.54,248.23 236.22,246.91 v2(235.06,246.91)
D11206: length 236.2
  L25_SIGNAL w0.091: v2(275.06,246.91) 276.22,246.91 277.54,248.23 277.54,250.99 277,251.53 277,253.73 275.36,255.37 275.36,280.69 275.98,281.31 275.98,285.03 275.6,285.41 275.6,287.67 281.36,293.43 282.25,293.43 282.91,294.09 282.91,294.79 284.01,295.89 286.72,295.89 287.71,296.88 287.71,323.88 308.06,344.23 344.49,344.23 385.35,385.1 402.88,385.1 D112.06
D11207: length 215.8
  L31_SIGNAL w0.091: v2(315.05,246.91) 316.22,246.91 317.54,248.23 317.54,250.99 317,251.53 317,253.73 315.36,255.37 315.36,280.69 315.98,281.31 315.98,285.03 315.6,285.41 315.6,295.78 317.31,297.49 318.19,297.49 326.5,305.81 339.46,305.81 349.63,315.98 349.63,367.01 365.9,383.29 400.56,383.29 405.13,387.86 405.13,392.43 D112.07
D11208: length 177.2
  L19_SIGNAL w0.102: D112.08 399.03,386.33 389.64,386.33 378.97,375.67 378.97,339.39 v3(351.79,312.22)
  L29_SIGNAL w0.091: v2(355.05,246.91) 356.21,246.91 357.54,248.23 357.54,250.99 357,251.53 357,253.73 355.36,255.37 355.36,280.69 355.98,281.31 355.98,285.03 355.6,285.41 355.6,296.8 356.87,298.07 356.87,307.59 352.24,312.22 v3(351.79,312.22)
D11209: length 283.3
  L27_SIGNAL w0.076: 225.75,247.88 228.04,247.88 228.23,247.69 228.23,247.23 v2(228.56,246.91)
  L27_SIGNAL w0.091: D112.09 400.06,392.44 400.06,387.92 397.48,385.34 311.17,385.34 280.29,354.46 267.08,354.46 233.68,321.06 233.68,308.74 223.07,298.13 223.07,292.19 224.58,290.69 224.58,284.96 225.08,284.47 225.08,272.19 224.1,271.22 224.1,267.56 224.85,266.81 224.85,260.16 225.45,259.57 225.45,248.19 225.75,247.88
D11210: length 254.2
  L25_SIGNAL w0.076: v2(268.55,246.91) 268.23,247.23 268.23,247.69 268.04,247.88 265.75,247.88
  L25_SIGNAL w0.091: 265.75,247.88 265.44,248.19 265.44,259.57 264.85,260.16 264.85,266.81 264.1,267.56 264.1,271.22 265.08,272.19 265.08,284.47 264.58,284.96 264.58,298.5 265.15,299.07 273.7,299.07 280.2,305.58 280.2,350.29 315.5,385.58 393.2,385.58 D112.10
D11211: length 245.1
  L31_SIGNAL w0.076: v2(308.55,246.91) 308.23,247.23 308.23,247.69 308.04,247.88 305.75,247.88
  L31_SIGNAL w0.091: 305.75,247.88 305.44,248.19 305.44,259.57 304.85,260.16 304.85,266.81 304.1,267.56 304.1,271.22 305.08,272.19 305.08,284.47 304.58,284.96 304.58,294.04 308.74,298.2 308.74,305.18 306.58,307.34 306.58,319.91 299.72,326.77 299.72,376.43 307.09,383.79 390.91,383.79 394.97,387.86 394.97,392.43 D112.11
D11212: length 175.6
  L19_SIGNAL w0.102: D112.12 377.32,374.78 377.32,339.55 355.52,317.75 348.8,317.75 v3(347.48,319.08)
  L29_SIGNAL w0.076: 345.75,247.88 348.04,247.88 348.23,247.69 348.23,247.23 v2(348.55,246.91)
  L29_SIGNAL w0.091: v3(347.48,319.08) 346.26,319.08 344.68,317.5 344.68,283.72 345.08,283.32 345.08,272.19 344.1,271.22 344.1,267.56 344.85,266.81 344.85,260.16 345.44,259.57 345.44,248.19 345.75,247.88
D11213: length 273.7
  L27_SIGNAL w0.091: v2(226.61,246.91) 225.71,246.91 225.08,247.54 225.08,259.3 224.48,259.89 224.48,266.6 223.45,267.63 223.45,270.55 222.73,271.28 222.73,285.39 222,286.12 222,293.12 222.5,293.62 222.5,299.97 229.81,307.28 229.81,320.73 264.04,354.97 280.04,354.97 310.84,385.77 387.67,385.77 389.89,387.99 389.89,392.43 D112.13
D11214: length 244.2
  L25_SIGNAL w0.091: v2(266.61,246.91) 265.71,246.91 265.08,247.54 265.08,259.3 264.48,259.89 264.48,266.6 263.45,267.63 263.45,270.55 262.73,271.28 262.73,285.39 262,286.12 262,292.27 262.97,293.23 262.97,298.44 264.05,299.52 272.79,299.52 279.72,306.45 279.72,350.49 315.3,386.07 383.53,386.07 D112.14
D11215: length 233.8
  L31_SIGNAL w0.091: v2(306.6,246.91) 305.71,246.91 305.08,247.54 305.08,259.3 304.48,259.89 304.48,266.6 303.45,267.63 303.45,270.55 302.73,271.28 302.73,285.39 302,286.12 302,292.22 307.09,297.31 307.09,305.69 306.07,306.7 306.07,319.79 299.21,326.64 299.21,376.64 306.88,384.3 380.75,384.3 384.81,388.37 384.81,392.43 D112.15
D11216: length 173
  L19_SIGNAL w0.102: D112.16 376.81,384.43 376.81,339.77 355.31,318.26 350.27,318.26 347.93,320.6 v3(347.48,320.6)
  L29_SIGNAL w0.091: v3(347.48,320.6) 345.49,320.6 344.3,319.4 344.3,304.8 342.9,303.4 342.9,292.61 342,291.71 342,286.12 342.72,285.39 342.72,271.28 343.45,270.55 343.45,267.63 344.48,266.6 344.48,259.89 345.08,259.3 345.08,247.54 345.71,246.91 v2(346.6,246.91)
D11302: length 87.6
  L19_SIGNAL w0.102: v3(284.67,297.86) 284.67,301.07 285.52,301.93 336.85,301.93 340.59,305.68 340.59,325.35 D113.02
D11303: length 244.4
  L19_SIGNAL w0.102: D113.03 329.29,346.35 240.34,346.35 229.95,356.74 229.95,374.95 202.31,402.59 161.29,402.59 D432.17
  L23_SIGNAL w0.091: D432.17 161.29,402.59 161.29,384.81 D431.17
D11304: length 87.8
  L19_SIGNAL w0.102: v3(284.67,295.33) 283.34,296.66 283.34,300.46 285.46,302.58 334.53,302.58 337.38,305.43 337.38,327.22 D113.04
D11305: length 224.4
  L17_SIGNAL w0.508: 239.07,269.98 v2(239.33,270.23)
  L17_SIGNAL w1.016: D113.05 325.12,345.44 308.2,345.44 297.45,356.2 226.49,356.2 220.62,350.32 220.62,308.59 228.83,300.38 228.83,271.98 231.11,269.7 232.38,269.7 233.5,268.58 236.91,268.58 238.3,269.98 239.07,269.98
  BOTTOM w0.305: U450.3 v2(239.33,270.23)
D11306: length 263.6
  L17_SIGNAL w0.508: v2(286.71,271.22) 287.04,271.22
  L17_SIGNAL w1.016: D113.06 326.89,321.81 320.97,321.81 318.61,319.46 318.61,305.69 317.38,304.46 314.35,304.46 312.52,302.63 303.7,302.63 301.16,305.17 301.16,311.61 300.15,312.62 298.55,312.62 297.48,311.55 297.48,305.83 296.73,305.08 294.59,305.08 293.84,305.83 293.84,320.34 292.91,321.26 291.39,321.26 290.55,320.42 290.55,303.36 289.07,301.88 289.07,275.59 290.09,274.57 296.01,274.57 296.57,274.01 296.57,267.2 297.33,266.44 298.58,266.44 300.28,264.74 300.28,262.26 301.45,261.09 312.41,261.09 313.09,260.41 313.09,255.49 312.49,254.9 311.55,254.9 309.97,253.32 306.74,253.32 305.8,252.37 305.8,251.83 303,249.04 303,244.77 302.3,244.06 294.82,244.06 294.04,244.84 291.83,244.84 291.11,244.12 279.58,244.12 279.01,244.69 279.01,263.79 279.72,264.49 288.58,264.49 289.31,265.22 289.31,270.21 288.29,271.22 287.04,271.22
  BOTTOM w0.305: UNK2U452.7 286.4,271.53 v2(286.71,271.22) 286.1,270.6 UNK2U451.4
D11307: length 207.1
  L17_SIGNAL w0.508: 237.37,272.47 238.08,271.75 v2(238.08,271.17)
  L17_SIGNAL w1.016: D113.07 321.8,343.68 307.75,343.68 296.91,354.52 230.95,354.52 223.64,347.21 223.64,307.74 230.99,300.38 230.99,293.12 230.99,293.11 230.99,292.27 230.19,291.47 230.19,287.46 232.88,284.77 232.88,275.07 233.37,274.57 234.21,274.57 234.85,273.94 234.85,273.38 235.59,272.64 235.69,272.64 235.86,272.47 237.37,272.47
  BOTTOM w0.305: v2(238.08,271.17) 238.08,270.81 238.33,270.56 U450.1
D11308: length 264.1
  L17_SIGNAL w0.508: 285.6,271.9 v2(285.6,271.22)
  L17_SIGNAL w1.016: 285.6,271.9 285.6,274.75 285.16,275.18 285.16,281.97 284.35,282.78 283.72,282.78 283.07,283.43 283.07,300.69 280.82,302.94 280.82,320.17 282.5,321.85 282.5,337.75 283.69,338.94 289.72,338.94 291.29,337.38 291.29,335.96 289.92,334.59 286.51,334.59 285.43,333.52 285.43,320.72 283.67,318.96 283.67,304.26 284.88,303.05 287.24,303.05 288.38,304.18 288.38,330.69 289.22,331.53 295.8,331.53 297.04,330.3 297.04,328.35 296.09,327.4 294.85,327.4 293.98,326.53 293.98,324.4 294.9,323.48 301.07,323.48 302.73,321.82 302.73,306.07 303.74,305.06 305.18,305.06 306.2,306.07 306.2,316.76 307.21,317.77 308.95,317.77 309.85,316.87 309.85,306.45 310.87,305.43 313.37,305.43 315.11,307.17 315.11,320.13 318.27,323.29 323.29,323.29 D113.08
  BOTTOM w0.305: UNK2U451.3 v2(285.6,271.22) 285.9,271.53 UNK2U452.8
D11309: length 206.3
  L17_SIGNAL w0.508: v2(239.08,271.17) 239.42,271.51
  L17_SIGNAL w1.016: D113.09 318.42,341.98 307.08,341.98 296.13,352.93 233.73,352.93 226.93,346.13 226.93,306.61 232.04,301.5 235.85,301.5 238.24,303.89 239.55,303.89 240.38,303.06 240.38,301.98 241.07,301.29 241.07,288.75 236.25,283.93 236.25,281.94 237.35,280.83 238.37,280.83 239.01,280.19 239.01,272.8 239.42,272.39 239.42,271.51
  BOTTOM w0.305: v2(239.08,271.17) 239.08,270.81 238.83,270.56 U450.2
