# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Nets (continued)
D20712: D207.12 SITE3.C16(PAD_PM_SDIO_INT)
D20713: D207.13 SITE3.E12(PAD_PM_SDIO_D3)
D20714: D207.14 UNK3K113.6
D20715: D207.15 SITE3.B11(PAD_PM_SDIO_CMD)
D20716: D207.16 UNK3K32.2
D20801: D208.01
D20802: D208.02
D20803: D208.03
D20804: D208.04
D20805: D208.05
D20806: D208.06
D20807: D208.07
D20808: D208.08
D20809: D208.09
D20810: D208.10
D20811: D208.11
D20812: D208.12
D20813: D208.13
D20814: D208.14 SITE3.H1(PAD_AUD_VRP_ADC) UNK3C270.1
D20815: D208.15
D20816: D208.16 SITE3.D12(PAD_PM_SDIO_D2)
D20901: D209.01 SITE1.T15(PAD_MSPI_DO)
D20902: D209.02 SITE2.T15(PAD_MSPI_DO)
D20903: D209.03 SITE3.T15(PAD_MSPI_DO)
D20904: D209.04 SITE4.T15(PAD_MSPI_DO)
D20905: D209.05 SITE1.R16(PAD_MSPI_CZ)
D20906: D209.06 SITE2.R16(PAD_MSPI_CZ)
D20907: D209.07 SITE3.R16(PAD_MSPI_CZ)
D20908: D209.08 SITE4.R16(PAD_MSPI_CZ)
D20909: D209.09 SITE1.R14(PAD_MSPI_DI)
D20910: D209.10 SITE2.R14(PAD_MSPI_DI)
D20911: D209.11 SITE3.R14(PAD_MSPI_DI)
D20912: D209.12 SITE4.R14(PAD_MSPI_DI)
D20913: D209.13 SITE1.G11(PAD_PM_PSPI0_DO)
D20914: D209.14 SITE2.G11(PAD_PM_PSPI0_DO)
D20915: D209.15 SITE3.G11(PAD_PM_PSPI0_DO)
D20916: D209.16 SITE4.G11(PAD_PM_PSPI0_DO)
D21001: D210.01 SITE1.G12(PAD_PM_PSPI0_DI)
D21002: D210.02 SITE2.G12(PAD_PM_PSPI0_DI)
D21003: D210.03 SITE3.G12(PAD_PM_PSPI0_DI)
D21004: D210.04 SITE4.G12(PAD_PM_PSPI0_DI)
D21005: D210.05 SITE1.F12(PAD_PM_PSPI0_INT)
D21006: D210.06 SITE2.F12(PAD_PM_PSPI0_INT)
D21007: D210.07 SITE3.F12(PAD_PM_PSPI0_INT)
D21008: D210.08 SITE4.F12(PAD_PM_PSPI0_INT)
D21009: D210.09 SITE1.F14(PAD_PM_GPIO7)
D21010: D210.10 SITE2.F14(PAD_PM_GPIO7)
D21011: D210.11 SITE3.F14(PAD_PM_GPIO7)
D21012: D210.12 SITE4.F14(PAD_PM_GPIO7)
D21013: D210.13 SITE1.E14(PAD_PM_UART2_RX)
D21014: D210.14 SITE2.E14(PAD_PM_UART2_RX)
D21015: D210.15 SITE3.E14(PAD_PM_UART2_RX)
D21016: D210.16 SITE4.E14(PAD_PM_UART2_RX)
D21101: D211.01 SITE1.E11(PAD_PM_GPIO8)
D21102: D211.02 SITE2.E11(PAD_PM_GPIO8)
D21103: D211.03 SITE3.E11(PAD_PM_GPIO8)
D21104: D211.04 SITE4.E11(PAD_PM_GPIO8)
D21105: D211.05 SITE1.C10(PAD_PM_GPIO0)
D21106: D211.06 SITE2.C10(PAD_PM_GPIO0)
D21107: D211.07 SITE3.C10(PAD_PM_GPIO0)
D21108: D211.08 SITE4.C10(PAD_PM_GPIO0)
D21109: D211.09 SITE1.F5(PAD_I2C1_SDA)
D21110: D211.10 SITE2.F5(PAD_I2C1_SDA)
D21111: D211.11 SITE3.F5(PAD_I2C1_SDA)
D21112: D211.12 SITE4.F5(PAD_I2C1_SDA)
D21113: D211.13 SITE1.K3(PAD_GPIO3)
D21114: D211.14 SITE2.K3(PAD_GPIO3)
D21115: D211.15 SITE3.K3(PAD_GPIO3)
D21116: D211.16 SITE4.K3(PAD_GPIO3)
D21201: D212.01 SITE1.M2(PAD_GPIO5)
D21202: D212.02 SITE2.M2(PAD_GPIO5)
D21203: D212.03 SITE3.M2(PAD_GPIO5)
D21204: D212.04 SITE4.M2(PAD_GPIO5)
D21205: D212.05 SITE1.N3(PAD_GPIO7)
D21206: D212.06 SITE2.N3(PAD_GPIO7)
D21207: D212.07 SITE3.N3(PAD_GPIO7)
D21208: D212.08 SITE4.N3(PAD_GPIO7)
D21209: D212.09 SITE1.P2(PAD_GPIO10)
D21210: D212.10 SITE2.P2(PAD_GPIO10)
D21211: D212.11 SITE3.P2(PAD_GPIO10)
D21212: D212.12 SITE4.P2(PAD_GPIO10)
D21213: D212.13 SITE1.P3(PAD_SD0_CMD)
D21214: D212.14 SITE2.P3(PAD_SD0_CMD)
D21215: D212.15 SITE3.P3(PAD_SD0_CMD)
D21216: D212.16 SITE4.P3(PAD_SD0_CMD)
D21301: D213.01 U409.B8(DIN2_0+)
D21302: D213.02 UNK2U409.B8
D21303: D213.03 U409.B9(DIN2_0-)
D21304: D213.04 UNK2U409.B9
D21305: D213.05 UNK3U409.B8
D21306: D213.06 UNK4U409.B8
D21307: D213.07 UNK3U409.B9
D21308: D213.08 UNK4U409.B9
D21309: D213.09 U409.E8(DIN2_2+)
D21310: D213.10 UNK2U409.E8
D21311: D213.11 U409.E9(DIN2_2-)
D21312: D213.12 UNK2U409.E9
D21313: D213.13 UNK3U409.E8
D21314: D213.14 UNK4U409.E8
D21315: D213.15 UNK3U409.E9
D21316: D213.16 UNK4U409.E9
D21401: D214.01 U31.2(D+)
D21402: D214.02 UNK2U31.2
D21403: D214.03 U31.3(D-)
D21404: D214.04 UNK2U31.3
D21405: D214.05 UNK3U31.2
D21406: D214.06 UNK4U31.2
D21407: D214.07 UNK3U31.3
D21408: D214.08 UNK4U31.3
D21409: D214.09 SITE1.J3(PAD_AUD_MICIN1)
D21410: D214.10 SITE2.J3(PAD_AUD_MICIN1)
D21411: D214.11 SITE3.J3(PAD_AUD_MICIN1)
D21412: D214.12 SITE4.J3(PAD_AUD_MICIN1)
D21413: D214.13 SITE1.L3(PAD_GPIO4)
D21414: D214.14 SITE2.L3(PAD_GPIO4)
D21415: D214.15 SITE3.L3(PAD_GPIO4)
D21416: D214.16 SITE4.L3(PAD_GPIO4)
D21501: D215.01 SITE1.L2(PAD_GPIO0)
D21502: D215.02 SITE2.L2(PAD_GPIO0)
D21503: D215.03 SITE3.L2(PAD_GPIO0)
D21504: D215.04 SITE4.L2(PAD_GPIO0)
D21505: D215.05 SITE1.R2(PAD_SD0_D0)
D21506: D215.06 SITE2.R2(PAD_SD0_D0)
D21507: D215.07 SITE3.R2(PAD_SD0_D0)
D21508: D215.08 SITE4.R2(PAD_SD0_D0)
D21509: D215.09 SITE1.T3(PAD_SD0_D2)
D21510: D215.10 SITE2.T3(PAD_SD0_D2)
D21511: D215.11 SITE3.T3(PAD_SD0_D2)
D21512: D215.12 SITE4.T3(PAD_SD0_D2)
D21513: D215.13 SITE1.T14(PAD_I2C0_SCL)
D21514: D215.14 SITE2.T14(PAD_I2C0_SCL)
D21515: D215.15 SITE3.T14(PAD_I2C0_SCL)
D21516: D215.16 SITE4.T14(PAD_I2C0_SCL)
D21601: D216.01 U408.D8(DIN2_1+)
D21602: D216.02 UNK2U408.D8
D21603: D216.03 U408.D9(DIN2_1-)
D21604: D216.04 UNK2U408.D9
D21605: D216.05 UNK3U408.D8
D21606: D216.06 UNK4U408.D8
D21607: D216.07 UNK3U408.D9
D21608: D216.08 UNK4U408.D9
D21609: D216.09 SITE1.R15(PAD_MSPI_CK)
D21610: D216.10 SITE2.R15(PAD_MSPI_CK)
D21611: D216.11 SITE3.R15(PAD_MSPI_CK)
D21612: D216.12 SITE4.R15(PAD_MSPI_CK)
D21613: D216.13 SITE1.P13(PAD_FUART_TX)
D21614: D216.14 SITE2.P13(PAD_FUART_TX)
D21615: D216.15 SITE3.P13(PAD_FUART_TX)
D21616: D216.16 SITE4.P13(PAD_FUART_TX)
D21701: D217.01 SITE1.C15(PAD_PM_PWM1)
D21702: D217.02 SITE2.C15(PAD_PM_PWM1)
D21703: D217.03 SITE3.C15(PAD_PM_PWM1)
D21704: D217.04 SITE4.C15(PAD_PM_PWM1)
D21705: D217.05 SITE1.G13(PAD_PM_PSPI0_CZ)
D21706: D217.06 SITE2.G13(PAD_PM_PSPI0_CZ)
D21707: D217.07 SITE3.G13(PAD_PM_PSPI0_CZ)
D21708: D217.08 SITE4.G13(PAD_PM_PSPI0_CZ)
D21709: D217.09 SITE1.J14(PAD_PM_GPIO10)
D21710: D217.10 SITE2.J14(PAD_PM_GPIO10)
D21711: D217.11 SITE3.J14(PAD_PM_GPIO10)
D21712: D217.12 SITE4.J14(PAD_PM_GPIO10)
D21713: D217.13 SITE1.M14(PAD_PM_GPIO11)
D21714: D217.14 SITE2.M14(PAD_PM_GPIO11)
D21715: D217.15 SITE3.M14(PAD_PM_GPIO11)
D21716: D217.16 SITE4.M14(PAD_PM_GPIO11)
D21801: D218.01 SITE1.P14(PAD_I2C0_SDA)
D21802: D218.02 SITE2.P14(PAD_I2C0_SDA)
D21803: D218.03 SITE3.P14(PAD_I2C0_SDA)
D21804: D218.04 SITE4.P14(PAD_I2C0_SDA)
D21805: D218.05 SITE1.R13(PAD_FUART_RX)
D21806: D218.06 SITE2.R13(PAD_FUART_RX)
D21807: D218.07 SITE3.R13(PAD_FUART_RX)
D21808: D218.08 SITE4.R13(PAD_FUART_RX)
D21809: D218.09 SITE1.T13(PAD_FUART_CTS)
D21810: D218.10 SITE2.T13(PAD_FUART_CTS)
D21811: D218.11 SITE3.T13(PAD_FUART_CTS)
D21812: D218.12 SITE4.T13(PAD_FUART_CTS)
D21813: D218.13 SITE1.R12(PAD_FUART_RTS)
D21814: D218.14 SITE2.R12(PAD_FUART_RTS)
D21815: D218.15 SITE3.R12(PAD_FUART_RTS)
D21816: D218.16 SITE4.R12(PAD_FUART_RTS)
D21901: D219.01 U408.E8(DIN2_2+)
D21902: D219.02 UNK2U408.E8
D21903: D219.03 U408.E9(DIN2_2-)
D21904: D219.04 UNK2U408.E9
D21905: D219.05 UNK3U408.E8
D21906: D219.06 UNK4U408.E8
D21907: D219.07 UNK3U408.E9
D21908: D219.08 UNK4U408.E9
D21909: D219.09 SITE1.T4(PAD_SD0_CDZ)
D21910: D219.10 SITE2.T4(PAD_SD0_CDZ)
D21911: D219.11 SITE3.T4(PAD_SD0_CDZ)
D21912: D219.12 SITE4.T4(PAD_SD0_CDZ)
D21913: D219.13 SITE1.R3(PAD_SD0_D3)
D21914: D219.14 SITE2.R3(PAD_SD0_D3)
D21915: D219.15 SITE3.R3(PAD_SD0_D3)
D21916: D219.16 SITE4.R3(PAD_SD0_D3)
D22001: D220.01 SITE1.N2(PAD_GPIO9)
D22002: D220.02 SITE2.N2(PAD_GPIO9)
D22003: D220.03 SITE3.N2(PAD_GPIO9)
D22004: D220.04 SITE4.N2(PAD_GPIO9)
D22005: D220.05 SITE1.P1(PAD_GPIO11)
D22006: D220.06 SITE2.P1(PAD_GPIO11)
D22007: D220.07 SITE3.P1(PAD_GPIO11)
D22008: D220.08 SITE4.P1(PAD_GPIO11)
D22009: D220.09 SITE1.R1(PAD_SD0_D1)
D22010: D220.10 SITE2.R1(PAD_SD0_D1)
D22011: D220.11 SITE3.R1(PAD_SD0_D1)
D22012: D220.12 SITE4.R1(PAD_SD0_D1)
D22013: D220.13 SITE1.T2(PAD_SD0_CLK)
D22014: D220.14 SITE2.T2(PAD_SD0_CLK)
D22015: D220.15 SITE3.T2(PAD_SD0_CLK)
D22016: D220.16 SITE4.T2(PAD_SD0_CLK)
D22101: D221.01 U409.D8(DIN2_1+)
D22102: D221.02 UNK2U409.D8
D22103: D221.03 U409.D9(DIN2_1-)
D22104: D221.04 UNK2U409.D9
D22105: D221.05 UNK3U409.D8
D22106: D221.06 UNK4U409.D8
D22107: D221.07 UNK3U409.D9
D22108: D221.08 UNK4U409.D9
D22109: D221.09 U408.B8(DIN2_0+)
D22110: D221.10 UNK2U408.B8
D22111: D221.11 U408.B9(DIN2_0-)
D22112: D221.12 UNK2U408.B9
D22113: D221.13 UNK3U408.B8
D22114: D221.14 UNK4U408.B8
D22115: D221.15 UNK3U408.B9
D22116: D221.16 UNK4U408.B9
D22201: D222.01 SITE1.M3(PAD_GPIO6)
D22202: D222.02 SITE2.M3(PAD_GPIO6)
D22203: D222.03 SITE3.M3(PAD_GPIO6)
D22204: D222.04 SITE4.M3(PAD_GPIO6)
D22205: D222.05 SITE1.M1(PAD_GPIO8)
D22206: D222.06 SITE2.M1(PAD_GPIO8)
D22207: D222.07 SITE3.M1(PAD_GPIO8)
D22208: D222.08 SITE4.M1(PAD_GPIO8)
D22209: D222.09 SITE1.K1(PAD_GPIO1)
D22210: D222.10 SITE2.K1(PAD_GPIO1)
D22211: D222.11 SITE3.K1(PAD_GPIO1)
D22212: D222.12 SITE4.K1(PAD_GPIO1)
D22213: D222.13 SITE1.J2(PAD_AUD_MICIN0)
D22214: D222.14 SITE2.J2(PAD_AUD_MICIN0)
D22215: D222.15 SITE3.J2(PAD_AUD_MICIN0)
D22216: D222.16 SITE4.J2(PAD_AUD_MICIN0)
D22301: D223.01 SITE1.E3(PAD_SR_RST1)
D22302: D223.02 SITE2.E3(PAD_SR_RST1)
D22303: D223.03 SITE3.E3(PAD_SR_RST1)
D22304: D223.04 SITE4.E3(PAD_SR_RST1)
D22305: C264.1 D223.05 SITE1.H2(PAD_AUD_VAG)
D22306: D223.06 SITE2.H2(PAD_AUD_VAG) UNK2C264.1
D22307: D223.07 SITE3.H2(PAD_AUD_VAG) UNK3C264.1
D22308: D223.08 SITE4.H2(PAD_AUD_VAG) UNK4C264.1
D22309: D223.09 SITE1.B4(PAD_I2C2_SCL)
D22310: D223.10 SITE2.B4(PAD_I2C2_SCL)
D22311: D223.11 SITE3.B4(PAD_I2C2_SCL)
D22312: D223.12 SITE4.B4(PAD_I2C2_SCL)
D22313: D223.13 SITE1.B8(PAD_PM_FUART_TX)
D22314: D223.14 SITE2.B8(PAD_PM_FUART_TX)
D22315: D223.15 SITE3.B8(PAD_PM_FUART_TX)
D22316: D223.16 SITE4.B8(PAD_PM_FUART_TX)
D22401: D224.01 SITE1.A10(PAD_PM_GPIO3)
D22402: D224.02 SITE2.A10(PAD_PM_GPIO3)
D22403: D224.03 SITE3.A10(PAD_PM_GPIO3)
D22404: D224.04 SITE4.A10(PAD_PM_GPIO3)
D22405: D224.05 SITE1.C12(PAD_PM_GPIO2)
D22406: D224.06 SITE2.C12(PAD_PM_GPIO2)
D22407: D224.07 SITE3.C12(PAD_PM_GPIO2)
D22408: D224.08 SITE4.C12(PAD_PM_GPIO2)
D22409: D224.09 SITE1.B14(PAD_PM_GPIO4)
D22410: D224.10 SITE2.B14(PAD_PM_GPIO4)
D22411: D224.11 SITE3.B14(PAD_PM_GPIO4)
D22412: D224.12 SITE4.B14(PAD_PM_GPIO4)
D22413: D224.13 SITE1.A15(PAD_PM_GPIO6)
D22414: D224.14 SITE2.A15(PAD_PM_GPIO6)
D22415: D224.15 SITE3.A15(PAD_PM_GPIO6)
D22416: D224.16 SITE4.A15(PAD_PM_GPIO6)
D32501: D325.01
D32502: D325.02
D32503: D325.03
D32504: D325.04
D32505: D325.05
D32506: D325.06
D32507: D325.07
D32508: D325.08
D32509: D325.09
D32510: D325.10
D32511: D325.11
D32512: D325.12
D32513: D325.13
D32514: D325.14
D32515: D325.15
D32516: D325.16
D32601: D326.01
D32602: D326.02
D32603: D326.03
D32604: D326.04
D32605: D326.05
D32606: D326.06
D32607: D326.07
D32608: D326.08
D32609: D326.09
D32610: D326.10
D32611: D326.11
D32612: D326.12
D32613: D326.13
D32614: D326.14
D32615: D326.15
D32616: D326.16
D32701: D327.01
D32702: D327.02
D32703: D327.03
D32704: D327.04
D32705: D327.05
D32706: D327.06
D32707: D327.07
D32708: D327.08
D32709: D327.09
D32710: D327.10
D32711: D327.11
D32712: D327.12
D32713: D327.13
D32714: D327.14
D32715: D327.15
D32716: D327.16
D32801: D328.01
D32802: D328.02
D32803: D328.03
D32804: D328.04
D32805: D328.05
D32806: D328.06
D32807: D328.07
D32808: D328.08
D32809: D328.09
D32810: D328.10
D32811: D328.11
D32812: D328.12
D32813: D328.13
D32814: D328.14
D32815: D328.15
D32816: D328.16
D32901: D329.01
D32902: D329.02
D32903: D329.03
D32904: D329.04
D32905: D329.05
D32906: D329.06
D32907: D329.07
D32908: D329.08
D32909: D329.09
D32910: D329.10
D32911: D329.11
D32912: D329.12
D32913: D329.13
D32914: D329.14
D32915: D329.15
D32916: D329.16
D33001: D330.01
D33002: D330.02
D33003: D330.03
D33004: D330.04
D33005: D330.05
D33006: D330.06
D33007: D330.07
D33008: D330.08
D33009: D330.09
D33010: D330.10
D33011: D330.11
D33012: D330.12
D33013: D330.13
D33014: D330.14
D33015: D330.15
D33016: D330.16
D33101: D331.01
D33102: D331.02
D33103: D331.03
D33104: D331.04
D33105: D331.05
D33106: D331.06
D33107: D331.07
D33108: D331.08
D33109: D331.09
D33110: D331.10
D33111: D331.11
D33112: D331.12
D33113: D331.13
D33114: D331.14
D33115: D331.15
D33116: D331.16
D33201: D332.01
D33202: D332.02
D33203: D332.03
D33204: D332.04
D33205: D332.05
D33206: D332.06
D33207: D332.07
D33208: D332.08
D33209: D332.09
D33210: D332.10
D33211: D332.11
D33212: D332.12
D33213: D332.13
D33214: D332.14
D33215: D332.15
D33216: D332.16
D40901: D409.01 SITE7.C8(PAD_RESET)
D40902: D409.02 SITE5.C13(PAD_PM_SAR3)
D40903: D409.03 SITE7.C9(PAD_PM_FUART_CTS)
D40904: D409.04 SITE5.C11(PAD_PM_SDIO_D1)
D40905: D409.05 SITE7.C11(PAD_PM_SDIO_D1)
D40906: D409.06 SITE5.C9(PAD_PM_FUART_CTS)
D40907: D409.07 SITE7.C13(PAD_PM_SAR3)
D40908: D409.08 SITE5.C8(PAD_RESET)
D40909: D409.09 SITE6.B5(PAD_RTC_IO4)
D40910: D409.10 SITE5.A5(PAD_RTC_IO5)
D40911: D409.11 SITE6.A5(PAD_RTC_IO5)
D40912: D409.12 SITE5.B5(PAD_RTC_IO4)
D40913: D409.13 SITE6.C9(PAD_PM_FUART_CTS)
D40914: D409.14 SITE6.C13(PAD_PM_SAR3)
D40915: D409.15 SITE6.C8(PAD_RESET)
D40916: D409.16 SITE6.C11(PAD_PM_SDIO_D1)
D41001: D410.01 SITE8.C13(PAD_PM_SAR3)
D41002: D410.02 SITE7.A5(PAD_RTC_IO5)
D41003: D410.03 SITE8.C11(PAD_PM_SDIO_D1)
D41004: D410.04 SITE7.B5(PAD_RTC_IO4)
D41005: D410.05 SITE8.A13(PAD_PM_SAR4)
D41006: D410.06 UNK8K113.6
D41007: D410.07 SITE8.B13(PAD_PM_SAR2)
D41008: D410.08 UNK8K32.2
D41009: D410.09 SITE8.D13(PAD_PM_SDIO_CLK)
D41010: D410.10 UNK8K32.7
D41011: D410.11 SITE8.B16(PAD_PM_PWM3)
D41012: D410.12 SITE8.L10(VDDP18_P0_CAP) UNK8CC194.1
D41013: D410.13 SITE8.D14(PAD_PM_PWM2)
D41014: D410.14 SITE8.L14(PAD_PM_GPIO12)
D41015: D410.15 SITE8.C16(PAD_PM_SDIO_INT)
D41016: D410.16 SITE8.E13(PAD_PM_SDIO_D0)
D41101: D411.01 SITE8.C9(PAD_PM_FUART_CTS)
D41102: D411.02 SITE8.C8(PAD_RESET)
D41103: D411.03 SITE8.A5(PAD_RTC_IO5)
D41104: D411.04 SITE8.B5(PAD_RTC_IO4)
D41105: D411.05 UNK8K39.2
D41106: D411.06 SITE8.A12(PAD_PM_SAR1)
D41107: D411.07 SITE8.H1(PAD_AUD_VRP_ADC) UNK8C270.1
D41108: D411.08 SITE8.D12(PAD_PM_SDIO_D2)
D41109: D411.09 SITE8.G3(PAD_AUD_LINEOUT_R0)
D41110: D411.10 SITE8.B11(PAD_PM_SDIO_CMD)
D41111: D411.11 SITE8.C7(PAD_RTC_IO1)
D41112: D411.12 UNK8U449.4
D41113: D411.13 SITE8.A8(PAD_PM_FUART_RTS)
D41114: D411.14 UNK8U449.3
D41115: D411.15 SITE8.B7(PAD_RTC_IO0)
D41116: D411.16 SITE8.E12(PAD_PM_SDIO_D3)
D41201: D412.01
D41202: D412.02
D41203: D412.03
D41204: D412.04
D41205: D412.05 SITE7.B13(PAD_PM_SAR2)
D41206: D412.06 UNK8K39.7
D41207: D412.07 SITE7.D13(PAD_PM_SDIO_CLK)
D41208: D412.08 UNK7K113.6
D41209: D412.09 SITE7.B16(PAD_PM_PWM3)
D41210: D412.10 UNK7K32.2
D41211: D412.11 SITE7.C16(PAD_PM_SDIO_INT)
D41212: D412.12 UNK7K32.7
D41213: D412.13 SITE7.E13(PAD_PM_SDIO_D0)
D41214: D412.14 SITE7.L10(VDDP18_P0_CAP) UNK7CC194.1
D41215: D412.15 SITE7.D14(PAD_PM_PWM2)
D41216: D412.16 SITE7.L14(PAD_PM_GPIO12)
D41301: D413.01 UNK6K32.2
D41302: D413.02 SITE7.A13(PAD_PM_SAR4)
D41303: D413.03 UNK6K113.6
D41304: D413.04 SITE7.A12(PAD_PM_SAR1)
D41305: D413.05 UNK7K39.7
D41306: D413.06 SITE7.D12(PAD_PM_SDIO_D2)
D41307: D413.07 UNK7K39.2
D41308: D413.08 SITE7.B11(PAD_PM_SDIO_CMD)
D41309: D413.09 SITE7.H1(PAD_AUD_VRP_ADC) UNK7C270.1
D41310: D413.10 UNK7U449.4
D41311: D413.11 SITE7.G3(PAD_AUD_LINEOUT_R0)
D41312: D413.12 UNK7U449.3
D41313: D413.13 SITE7.B7(PAD_RTC_IO0)
D41314: D413.14 SITE7.E12(PAD_PM_SDIO_D3)
D41315: D413.15 SITE7.C7(PAD_RTC_IO1)
D41316: D413.16 SITE7.A8(PAD_PM_FUART_RTS)
D41401: D414.01 SITE6.E12(PAD_PM_SDIO_D3)
D41402: D414.02 UNK6K32.7
D41403: D414.03 UNK6U449.3
D41404: D414.04 SITE6.L10(VDDP18_P0_CAP) UNK6CC194.1
D41405: D414.05 UNK6U449.4
D41406: D414.06 SITE6.L14(PAD_PM_GPIO12)
D41407: D414.07 SITE6.B11(PAD_PM_SDIO_CMD)
D41408: D414.08 SITE6.E13(PAD_PM_SDIO_D0)
D41409: D414.09 SITE6.D12(PAD_PM_SDIO_D2)
D41410: D414.10 SITE6.D14(PAD_PM_PWM2)
D41411: D414.11 SITE6.A12(PAD_PM_SAR1)
D41412: D414.12 SITE6.C16(PAD_PM_SDIO_INT)
D41413: D414.13 SITE6.B13(PAD_PM_SAR2)
D41414: D414.14 SITE6.B16(PAD_PM_PWM3)
D41415: D414.15 SITE6.A13(PAD_PM_SAR4)
D41416: D414.16 SITE6.D13(PAD_PM_SDIO_CLK)
D41501: D415.01 SITE5.B16(PAD_PM_PWM3)
D41502: D415.02 SITE6.A8(PAD_PM_FUART_RTS)
D41503: D415.03 SITE5.C16(PAD_PM_SDIO_INT)
D41504: D415.04 SITE6.B7(PAD_RTC_IO0)
D41505: D415.05 SITE5.D14(PAD_PM_PWM2)
D41506: D415.06 SITE6.C7(PAD_RTC_IO1)
D41507: D415.07 SITE5.E13(PAD_PM_SDIO_D0)
D41508: D415.08 SITE6.G3(PAD_AUD_LINEOUT_R0)
D41509: D415.09 SITE5.L14(PAD_PM_GPIO12)
D41510: D415.10 SITE6.H1(PAD_AUD_VRP_ADC) UNK6C270.1
D41511: D415.11 SITE5.L10(VDDP18_P0_CAP) UNK5CC194.1
D41512: D415.12 UNK6K39.2
D41513: D415.13 UNK5K32.2
D41514: D415.14 UNK6K39.7
D41515: D415.15 UNK5K32.7
D41516: D415.16 UNK5K113.6
D41601: D416.01 UNK5K39.7
D41602: D416.02 SITE5.D13(PAD_PM_SDIO_CLK)
D41603: D416.03 UNK5K39.2
D41604: D416.04 SITE5.B13(PAD_PM_SAR2)
D41605: D416.05 SITE5.H1(PAD_AUD_VRP_ADC) UNK5C270.1
D41606: D416.06 SITE5.A13(PAD_PM_SAR4)
D41607: D416.07 SITE5.G3(PAD_AUD_LINEOUT_R0)
D41608: D416.08 SITE5.A12(PAD_PM_SAR1)
D41609: D416.09 SITE5.C7(PAD_RTC_IO1)
D41610: D416.10 SITE5.D12(PAD_PM_SDIO_D2)
D41611: D416.11 SITE5.B7(PAD_RTC_IO0)
D41612: D416.12 SITE5.B11(PAD_PM_SDIO_CMD)
D41613: D416.13 SITE5.E12(PAD_PM_SDIO_D3)
D41614: D416.14 UNK5U449.4
D41615: D416.15 SITE5.A8(PAD_PM_FUART_RTS)
D41616: D416.16 UNK5U449.3
D41701: D417.01
D41702: D417.02
D41703: D417.03
D41704: D417.04
D41705: D417.05
D41706: D417.06
D41707: D417.07
D41708: D417.08
D41709: D417.09
D41710: D417.10
D41711: D417.11
D41712: D417.12
D41713: D417.13
D41714: D417.14
D41715: D417.15
D41716: D417.16
D41801: D418.01
D41802: D418.02
D41803: D418.03
D41804: D418.04
D41805: D418.05
D41806: D418.06
D41807: D418.07
D41808: D418.08
D41809: D418.09
D41810: D418.10
D41811: D418.11
D41812: D418.12
D41813: D418.13
D41814: D418.14
D41815: D418.15
D41816: D418.16
D41901: D419.01
D41902: D419.02
D41903: D419.03
D41904: D419.04
D41905: D419.05
D41906: D419.06
D41907: D419.07
D41908: D419.08
D41909: D419.09
D41910: D419.10
D41911: D419.11
D41912: D419.12
D41913: D419.13
D41914: D419.14
D41915: D419.15
D41916: D419.16
D42001: D420.01
D42002: D420.02
D42003: D420.03
D42004: D420.04
D42005: D420.05
D42006: D420.06
D42007: D420.07
D42008: D420.08
D42009: D420.09
D42010: D420.10
D42011: D420.11
D42012: D420.12
D42013: D420.13
D42014: D420.14
D42015: D420.15
D42016: D420.16
D42101: D421.01
D42102: D421.02
D42103: D421.03
D42104: D421.04
D42105: D421.05
D42106: D421.06
D42107: D421.07
D42108: D421.08
D42109: D421.09
D42110: D421.10
D42111: D421.11
D42112: D421.12
D42113: D421.13
D42114: D421.14
D42115: D421.15
D42116: D421.16
D42201: D422.01
D42202: D422.02
D42203: D422.03
D42204: D422.04
D42205: D422.05
D42206: D422.06
D42207: D422.07
D42208: D422.08
D42209: D422.09
D42210: D422.10
D42211: D422.11
D42212: D422.12
D42213: D422.13
D42214: D422.14
D42215: D422.15
D42216: D422.16
D42301: D423.01
D42302: D423.02
D42303: D423.03
D42304: D423.04
D42305: D423.05
D42306: D423.06
D42307: D423.07
D42308: D423.08
D42309: D423.09
D42310: D423.10
D42311: D423.11
D42312: D423.12
D42313: D423.13
D42314: D423.14
D42315: D423.15
D42316: D423.16
D42401: D424.01
D42402: D424.02
D42403: D424.03
D42404: D424.04
D42405: D424.05
D42406: D424.06
D42407: D424.07
D42408: D424.08
D42409: D424.09
D42410: D424.10
D42411: D424.11
D42412: D424.12
D42413: D424.13
D42414: D424.14
D42415: D424.15
D42416: D424.16
MSDPS1_1F: DPS1.C03
MSDPS1_1GRD: DPS1.B02
MSDPS1_1GS: DPS1.A02
MSDPS1_1S: DPS1.C02
MSDPS1_2F: DPS1.C07
MSDPS1_2GRD: DPS1.B06
MSDPS1_2GS: DPS1.A06
MSDPS1_2S: DPS1.C06
MSDPS1_3F: DPS1.C13
MSDPS1_3GRD: DPS1.B12
MSDPS1_3GS: DPS1.A12
MSDPS1_3S: DPS1.C12
MSDPS1_4F: DPS1.C17
MSDPS1_4GRD: DPS1.B16
MSDPS1_4GS: DPS1.A16
MSDPS1_4S: DPS1.C16
MSDPS1_5F: DPS1.A03
MSDPS1_5GS: DPS1.B01
MSDPS1_5S: DPS1.B03
MSDPS1_6F: DPS1.A07
MSDPS1_6GS: DPS1.B05
MSDPS1_6S: DPS1.B07
MSDPS1_7F: DPS1.A13
MSDPS1_7GS: DPS1.B11
MSDPS1_7S: DPS1.B13
MSDPS1_8F: DPS1.A17
MSDPS1_8GS: DPS1.B15
MSDPS1_8S: DPS1.B17
MSDPS1_TR+: DPS1.A09
MSDPS1_VB+: DPS1.C09
MSDPS2_1F: DPS2.C03
MSDPS2_1GRD: DPS2.B02
MSDPS2_1GS: DPS2.A02
MSDPS2_1S: DPS2.C02
MSDPS2_2F: DPS2.C07
MSDPS2_2GRD: DPS2.B06
MSDPS2_2GS: DPS2.A06
MSDPS2_2S: DPS2.C06
MSDPS2_3F: DPS2.C13
MSDPS2_3GRD: DPS2.B12
MSDPS2_3GS: DPS2.A12
MSDPS2_3S: DPS2.C12
MSDPS2_4F: DPS2.C17
MSDPS2_4GRD: DPS2.B16
MSDPS2_4GS: DPS2.A16
MSDPS2_4S: DPS2.C16
MSDPS2_5F: DPS2.A03
MSDPS2_5GS: DPS2.B01
MSDPS2_5S: DPS2.B03
MSDPS2_6F: DPS2.A07
MSDPS2_6GS: DPS2.B05
MSDPS2_6S: DPS2.B07
MSDPS2_7F: DPS2.A13
MSDPS2_7GS: DPS2.B11
MSDPS2_7S: DPS2.B13
MSDPS2_8F: DPS2.A17
MSDPS2_8GS: DPS2.B15
MSDPS2_8S: DPS2.B17
MSDPS2_TR+: DPS2.A09
MSDPS2_VB+: DPS2.C09
MSDPS3_1F: DPS3.C03
MSDPS3_1GRD: DPS3.B02
MSDPS3_1GS: DPS3.A02
MSDPS3_1S: DPS3.C02
MSDPS3_2F: DPS3.C07
MSDPS3_2GRD: DPS3.B06
MSDPS3_2GS: DPS3.A06
MSDPS3_2S: DPS3.C06
MSDPS3_3F: DPS3.C13
MSDPS3_3GRD: DPS3.B12
MSDPS3_3GS: DPS3.A12
MSDPS3_3S: DPS3.C12
MSDPS3_4F: DPS3.C17
MSDPS3_4GRD: DPS3.B16
MSDPS3_4GS: DPS3.A16
MSDPS3_4S: DPS3.C16
MSDPS3_5F: DPS3.A03
MSDPS3_5GS: DPS3.B01
MSDPS3_5S: DPS3.B03
MSDPS3_6F: DPS3.A07
MSDPS3_6GS: DPS3.B05
MSDPS3_6S: DPS3.B07
MSDPS3_7F: DPS3.A13
MSDPS3_7GS: DPS3.B11
MSDPS3_7S: DPS3.B13
MSDPS3_8F: DPS3.A17
MSDPS3_8GS: DPS3.B15
MSDPS3_8S: DPS3.B17
MSDPS3_TR+: DPS3.A09
MSDPS3_VB+: DPS3.C09
MSDPS8_1F: DPS8.C03
MSDPS8_1GRD: DPS8.B02
MSDPS8_1GS: DPS8.A02
MSDPS8_1S: DPS8.C02
MSDPS8_2F: DPS8.C07
MSDPS8_2GRD: DPS8.B06
MSDPS8_2GS: DPS8.A06
MSDPS8_2S: DPS8.C06
MSDPS8_3F: DPS8.C13
MSDPS8_3GRD: DPS8.B12
MSDPS8_3GS: DPS8.A12
MSDPS8_3S: DPS8.C12
MSDPS8_4F: DPS8.C17
MSDPS8_4GRD: DPS8.B16
MSDPS8_4GS: DPS8.A16
MSDPS8_4S: DPS8.C16
MSDPS8_5F: DPS8.A03
MSDPS8_5GS: DPS8.B01
MSDPS8_5S: DPS8.B03
MSDPS8_6F: DPS8.A07
MSDPS8_6GS: DPS8.B05
MSDPS8_6S: DPS8.B07
MSDPS8_7F: DPS8.A13
MSDPS8_7GS: DPS8.B11
MSDPS8_7S: DPS8.B13
MSDPS8_8F: DPS8.A17
MSDPS8_8GS: DPS8.B15
MSDPS8_8S: DPS8.B17
MSDPS8_TR+: DPS8.A09
MSDPS8_VB+: DPS8.C09
S1_0V5: C286.1 C288.1 MK1.4 MR2.2 MR3.1 MR4.1 MR5.1 MR6.1 MU3.3(+IN)
S1_0V25: MK4.3 MR18.2 MR19.1
S1_0V75: C290.1 MK2.4 MR10.2 MU3.6(OUT)
S1_1AWG_SHARE+: K34.4 K107.2
S1_3V3_ETH_MUX: BD1729.2 C1077.1 C1080.1 C1081.1 R984.1 R987.1 R990.1 U450.10(VCC) U451.10(VCC) U452.10(VCC)
S1_3V3_RX0_MIPI: BDB5.2 C922.2 R661.2 U408.A2(VDD_A2) U408.J4(VDD_J4)
S1_3V3_RX1_MIPI: BDB6.2 C923.2 R663.2 U409.A2(VDD_A2) U409.J4(VDD_J4)
S1_3V3_USB2_MUX: BD21.2 C262.1 U31.4(VCC)
S1_3V3_XTAL32K: BD1728.2 C1074.1 R981.1 U449.10(VCC)
S1_AWG_2SHARE+: K107.4 U451.1(USB+)
S1_AWG_2SHARE-: K107.5 U451.2(USB-)
S1_AWG_3SHARE+: K107.3 K109.2
S1_AWG_3SHARE-: K107.6 K109.7
S1_CON1_0V6: CON1.5(LPDDR4X_0V6-1) CON1.6(LPDDR4X_0V6-2)
S1_CON1_0V8: S1_DPS_SW1.13 S1_DPS_SW1.14 S1_DPS_SW1.15 S1_DPS_SW1.16 S1_DPS_SW6.13 S1_DPS_SW6.14 S1_DPS_SW6.15 S1_DPS_SW6.16
S1_CON1_1V1_1V2: CON1.25(DDR4_VDDIO-1) CON1.26(DDR4_VDDIO-2)
S1_CON1_1V5_1V2: CON1.29(1V5_1V2-1) CON1.30(1V5_1V2-2) S1_DPS_SW4.9 S1_DPS_SW4.10 S1_DPS_SW4.11 S1_DPS_SW4.12 S1_DPS_SW4.13 S1_DPS_SW4.14 S1_DPS_SW4.15 S1_DPS_SW4.16
S1_CON1_1V8: CON1.7(1V8-1) CON1.8(1V8-2) S1_DPS_SW3.9 S1_DPS_SW3.10 S1_DPS_SW3.11 S1_DPS_SW3.12 S1_DPS_SW3.13 S1_DPS_SW3.14 S1_DPS_SW3.15 S1_DPS_SW3.16 S1_DPS_SW5.9 S1_DPS_SW5.10 S1_DPS_SW5.11 S1_DPS_SW5.12
S1_CON1_A3V3: CON1.3(A3V3) S1_DPS_SW2.9 S1_DPS_SW2.10 S1_DPS_SW2.11 S1_DPS_SW2.12 S1_DPS_SW2.13 S1_DPS_SW2.14 S1_DPS_SW2.15 S1_DPS_SW2.16
S1_CON1_B3V3: CON1.4(B3V3) S1_DPS_SW5.13 S1_DPS_SW5.14 S1_DPS_SW5.15 S1_DPS_SW5.16
S1_CON1_CORE_0V9: CON1.13(VCORE_CORE-1) CON1.14(VCORE_CORE-2) S1_DPS_SW1.9 S1_DPS_SW1.10 S1_DPS_SW1.11 S1_DPS_SW1.12 S1_DPS_SW6.9 S1_DPS_SW6.10 S1_DPS_SW6.11 S1_DPS_SW6.12
S1_CON1_CPU_0V9: CON1.15(VCORE_CPU-1) CON1.16(VCORE_CPU-2)
S1_CON1_DDR2DDR3: CON1.23(DDR2DDR3-1) CON1.24(DDR2DDR3-2)
S1_CON1_IPU_0V9: CON1.17(VCORE_IPU-1) CON1.18(VCORE_IPU-2)
S1_CON1_VDD_DSP: CON1.27(VDD_DSP-1) CON1.28(VDD_DSP-2)
S1_DVDD_DDR_RX: CC133.1 K39.3 SITE1.R4(DVDD_DDR_RX)
S1_DVDD_DDR_TX: CC134.1 K39.6 SITE1.R5(DVDD_DDR_TX)
S1_ETH_RN_AB_CASE: SITE1.H16(PAD_ETH_RN) U451.7(D-)
S1_ETH_RP_AB_CASE: SITE1.H15(PAD_ETH_RP) U451.8(D+)
S1_ETH_TN_AB_CASE: SITE1.G15(PAD_ETH_TN) U450.7(D-)
S1_ETH_TP_AB_CASE: SITE1.G14(PAD_ETH_TP) U450.8(D+)
S1_M_2V5: C284.1 C285.1 MR2.1 MU2.6(VOUT)
S1_M_3V2: C282.1 C283.1 C289.1 MR1.1 MU1.5(VOUT) MU2.2(VIN) MU3.7(V+)
S1_MUX_3V3: BD21.1 BD1728.1 BD1729.1 BDB5.1 BDB6.1 R512.1
S1_OUT_RX0_CH0_ABC_CASE+: SITE1.A3(PAD_OUTP_RX0_CH[0]) U408.B2(DOUT_0+)
S1_OUT_RX0_CH0_ABC_CASE-: SITE1.C4(PAD_OUTN_RX0_CH[0]) U408.B1(DOUT_0-)
S1_OUT_RX0_CH0_B_CASE+: R647.1 U408.B4(DIN1_0+)
S1_OUT_RX0_CH0_B_CASE-: R646.1 U408.A4(DIN1_0-)
S1_OUT_RX0_CH0_C_CASE: C309.1 R646.2 R647.2
S1_OUT_RX0_CH1_ABC_CASE+: SITE1.A2(PAD_OUTP_RX0_CH[1]) U408.D2(DOUT_1+)
S1_OUT_RX0_CH1_ABC_CASE-: SITE1.B3(PAD_OUTN_RX0_CH[1]) U408.D1(DOUT_1-)
S1_OUT_RX0_CH1_B_CASE+: R168.1 U408.B5(DIN1_1+)
S1_OUT_RX0_CH1_B_CASE-: R170.1 U408.A5(DIN1_1-)
S1_OUT_RX0_CH1_C_CASE: C310.1 R168.2 R170.2
S1_OUT_RX0_CH2_ABC_CASE+: SITE1.B2(PAD_OUTP_RX0_CH[2]) U408.E2(DOUT_2+)
S1_OUT_RX0_CH2_ABC_CASE-: SITE1.C3(PAD_OUTN_RX0_CH[2]) U408.E1(DOUT_2-)
S1_OUT_RX0_CH2_B_CASE+: R176.1 U408.B6(DIN1_2+)
S1_OUT_RX0_CH2_B_CASE-: R178.1 U408.A6(DIN1_2-)
S1_OUT_RX0_CH2_C_CASE: C318.1 R176.2 R178.2
S1_OUT_RX0_CH3_ABC_CASE+: SITE1.C2(PAD_OUTP_RX0_CH[3]) U409.B2(DOUT_0+)
S1_OUT_RX0_CH3_ABC_CASE-: SITE1.B1(PAD_OUTN_RX0_CH[3]) U409.B1(DOUT_0-)
S1_OUT_RX0_CH3_B_CASE+: R1089.1 U409.B4(DIN1_0+)
S1_OUT_RX0_CH3_B_CASE-: R1088.1 U409.A4(DIN1_0-)
S1_OUT_RX0_CH3_C_CASE: C302.1 R1088.2 R1089.2
S1_OUT_RX0_CH4_ABC_CASE+: SITE1.D2(PAD_OUTP_RX0_CH[4]) U409.D2(DOUT_1+)
S1_OUT_RX0_CH4_ABC_CASE-: SITE1.C1(PAD_OUTN_RX0_CH[4]) U409.D1(DOUT_1-)
S1_OUT_RX0_CH4_B_CASE+: R180.1 U409.B5(DIN1_1+)
S1_OUT_RX0_CH4_B_CASE-: R182.1 U409.A5(DIN1_1-)
S1_OUT_RX0_CH4_C_CASE: C320.1 R180.2 R182.2
S1_OUT_RX0_CH5_ABC_CASE+: SITE1.D3(PAD_OUTP_RX0_CH[5]) U409.E2(DOUT_2+)
S1_OUT_RX0_CH5_ABC_CASE-: SITE1.D1(PAD_OUTN_RX0_CH[5]) U409.E1(DOUT_2-)
S1_OUT_RX0_CH5_B_CASE+: R666.1 U409.B6(DIN1_2+)
S1_OUT_RX0_CH5_B_CASE-: R664.1 U409.A6(DIN1_2-)
S1_OUT_RX0_CH5_C_CASE: C924.1 R664.2 R666.2
S1_PAD_SZQ: K113.5(IN) SITE1.T11(PAD_SZQ)
S1_PM_SAR0: K34.3 MK3.4 S1_VREF_OUT.1(TP) SITE1.B12(PAD_PM_SAR0)
S1_SPI_CK_ABCD_CASE: K2.6 SITE1.N15(PAD_SPI0_CK)
S1_SPI_CK_B_CASE: K2.5 K3.6
S1_SPI_CK_C_CASE: K3.7 U18.6
S1_SPI_CK_D_CASE: K3.5 U19.6
S1_SPI_CZ_ABCD_CASE: K2.3 SITE1.N14(PAD_SPI0_CZ)
S1_SPI_CZ_B_CASE: K2.4 K3.3
S1_SPI_CZ_C_CASE: K3.2 R200.2 U18.1
S1_SPI_CZ_D_CASE: K3.4 R205.2 U19.1
S1_SPI_DI_ABCD_CASE: K4.6 SITE1.P16(PAD_SPI0_DI)
S1_SPI_DI_B_CASE: K4.5 K5.6
S1_SPI_DI_C_CASE: K5.7 U18.5
S1_SPI_DI_D_CASE: K5.5 U19.5
S1_SPI_DO_ABCD_CASE: K4.3 SITE1.P15(PAD_SPI0_DO)
S1_SPI_DO_B_CASE: K4.4 K5.3
S1_SPI_DO_C_CASE: K5.2 U18.2
S1_SPI_DO_D_CASE: K5.4 U19.2
S1_SPI_HLD_ABCD_CASE: K6.3 SITE1.M15(PAD_SPI0_HLD)
S1_SPI_HLD_B_CASE: K6.4 K7.3
S1_SPI_HLD_C_CASE: K7.2 R202.1 U18.7
S1_SPI_HLD_D_CASE: K7.4 R206.1 U19.7
S1_SPI_WPZ_ABCD_CASE: K6.6 SITE1.M16(PAD_SPI0_WPZ)
S1_SPI_WPZ_B_CASE: K6.5 K7.6
S1_SPI_WPZ_C_CASE: K7.7 R203.2 U18.3
S1_SPI_WPZ_D_CASE: K7.5 R207.2 U19.3
S1_USB2_SEL0: R164.2 U31.6(SEL0)
S1_USB2_SEL1: R163.2 U31.5(SEL1)
S1_USB2_SELS: R165.2 U31.16(SELS)
S1_USB_D_AB_CASE+: SITE1.F1(PAD_USB_DP) U31.10(HSD2+)
S1_USB_D_AB_CASE-: SITE1.F2(PAD_USB_DM) U31.9(HSD2-)
S1_USB_D_B_CASE+: R160.2 U31.8(HSD2S+)
S1_USB_D_B_CASE-: R161.2 U31.7(HSD2S-)
S1_USER_3V3: C334.1 C335.1 C336.2 C337.2 C338.2 C339.2 R200.1 R201.2 R202.2 R203.1 R204.2 R205.1 R206.2 R207.1 S1_USER_3V3.1 U17.3(VOUT)
S1_XTAL_24M_IN_ABC_CASE: K32.3 SITE1.K15(PAD_XTAL_24M_IN)
S1_XTAL_24M_IN_B_CASE: K32.4 R135.1
S1_XTAL_24M_IN_C_CASE: C267.1 R135.2 R136.2 Y1.3
S1_XTAL_24M_OUT_ABC_CASE: K32.6 SITE1.K16(PAD_XTAL_24M_OUT)
S1_XTAL_24M_OUT_B_CASE: K32.5 R137.1
S1_XTAL_24M_OUT_C_CASE: C268.1 R136.1 R137.2 Y1.1
S1_XTAL_IN_32K_A_CASE: K29.7 U449.7(D-)
S1_XTAL_IN_32K_ABCD_CASE: K29.6 SITE1.B6(PAD_XTAL_IN_32K)
S1_XTAL_IN_32K_B_CASE: C271.1 K29.5 Y2.1
S1_XTAL_IN_32K_D_CASE: R923.1 R973.2 U449.2(USB-)
S1_XTAL_OUT_32K_A_CASE: K29.2 U449.8(D+)
S1_XTAL_OUT_32K_ABCD_CASE: K29.3 SITE1.A6(PAD_XTAL_OUT_32K)
S1_XTAL_OUT_32K_B_CASE: C272.1 K29.4 Y2.2
S1_XTAL_OUT_32K_D_CASE: R652.1 R973.1 U449.1(USB+)
S2_0V5: UNK2C286.1 UNK2C288.1 UNK2MK1.4 UNK2MR2.2 UNK2MR3.1 UNK2MR4.1 UNK2MR5.1 UNK2MR6.1 UNK2MU3.3
S2_0V25: UNK2MK4.3 UNK2MR18.2 UNK2MR19.1
S2_0V75: UNK2C290.1 UNK2MK2.4 UNK2MR10.2 UNK2MU3.6
S2_1AWG_SHARE+: UNK2K34.4 UNK2K107.2
S2_3V3_ETH_MUX: UNK2BD1729.2 UNK2C1077.1 UNK2C1080.1 UNK2C1081.1 UNK2R984.1 UNK2R987.1 UNK2R990.1 UNK2U450.10 UNK2U451.10 UNK2U452.10
S2_3V3_RX0_MIPI: UNK2BDB5.2 UNK2C922.2 UNK2R661.2 UNK2U408.A2 UNK2U408.J4
S2_3V3_RX1_MIPI: UNK2BDB6.2 UNK2C923.2 UNK2R663.2 UNK2U409.A2 UNK2U409.J4
S2_3V3_USB2_MUX: UNK2BD21.2 UNK2C262.1 UNK2U31.4
S2_3V3_XTAL32K: UNK2BD1728.2 UNK2C1074.1 UNK2R981.1 UNK2U449.10
S2_AWG_2SHARE+: UNK2K107.4 UNK2U451.1
S2_AWG_2SHARE-: UNK2K107.5 UNK2U451.2
S2_AWG_3SHARE+: K110.2 UNK2K107.3
S2_AWG_3SHARE-: K110.7 UNK2K107.6
S2_DVDD_DDR_RX: SITE2.R4(DVDD_DDR_RX) UNK2CC133.1 UNK2K39.3
S2_DVDD_DDR_TX: SITE2.R5(DVDD_DDR_TX) UNK2CC134.1 UNK2K39.6
S2_ETH_RN_AB_CASE: SITE2.H16(PAD_ETH_RN) UNK2U451.7
S2_ETH_RP_AB_CASE: SITE2.H15(PAD_ETH_RP) UNK2U451.8
S2_ETH_TN_AB_CASE: SITE2.G15(PAD_ETH_TN) UNK2U450.7
S2_ETH_TP_AB_CASE: SITE2.G14(PAD_ETH_TP) UNK2U450.8
S2_M_2V5: UNK2C284.1 UNK2C285.1 UNK2MR2.1 UNK2MU2.6
S2_M_3V2: UNK2C282.1 UNK2C283.1 UNK2C289.1 UNK2MR1.1 UNK2MU1.5 UNK2MU2.2 UNK2MU3.7
S2_MUX_3V3: UNK2BD21.1 UNK2BD1728.1 UNK2BD1729.1 UNK2BDB5.1 UNK2BDB6.1 UNK2R512.1
S2_OUT_RX0_CH0_ABC_CASE+: SITE2.A3(PAD_OUTP_RX0_CH[0]) UNK2U408.B2
S2_OUT_RX0_CH0_ABC_CASE-: SITE2.C4(PAD_OUTN_RX0_CH[0]) UNK2U408.B1
S2_OUT_RX0_CH0_B_CASE+: UNK2R647.1 UNK2U408.B4
S2_OUT_RX0_CH0_B_CASE-: UNK2R646.1 UNK2U408.A4
S2_OUT_RX0_CH0_C_CASE: UNK2C309.1 UNK2R646.2 UNK2R647.2
S2_OUT_RX0_CH1_ABC_CASE+: SITE2.A2(PAD_OUTP_RX0_CH[1]) UNK2U408.D2
S2_OUT_RX0_CH1_ABC_CASE-: SITE2.B3(PAD_OUTN_RX0_CH[1]) UNK2U408.D1
S2_OUT_RX0_CH1_B_CASE+: UNK2R168.1 UNK2U408.B5
S2_OUT_RX0_CH1_B_CASE-: UNK2R170.1 UNK2U408.A5
S2_OUT_RX0_CH1_C_CASE: UNK2C310.1 UNK2R168.2 UNK2R170.2
S2_OUT_RX0_CH2_ABC_CASE+: SITE2.B2(PAD_OUTP_RX0_CH[2]) UNK2U408.E2
S2_OUT_RX0_CH2_ABC_CASE-: SITE2.C3(PAD_OUTN_RX0_CH[2]) UNK2U408.E1
S2_OUT_RX0_CH2_B_CASE+: UNK2R176.1 UNK2U408.B6
S2_OUT_RX0_CH2_B_CASE-: UNK2R178.1 UNK2U408.A6
S2_OUT_RX0_CH2_C_CASE: UNK2C318.1 UNK2R176.2 UNK2R178.2
S2_OUT_RX0_CH3_ABC_CASE+: SITE2.C2(PAD_OUTP_RX0_CH[3]) UNK2U409.B2
S2_OUT_RX0_CH3_ABC_CASE-: SITE2.B1(PAD_OUTN_RX0_CH[3]) UNK2U409.B1
S2_OUT_RX0_CH3_B_CASE+: UNK2R1089.1 UNK2U409.B4
S2_OUT_RX0_CH3_B_CASE-: UNK2R1088.1 UNK2U409.A4
S2_OUT_RX0_CH3_C_CASE: UNK2C302.1 UNK2R1088.2 UNK2R1089.2
S2_OUT_RX0_CH4_ABC_CASE+: SITE2.D2(PAD_OUTP_RX0_CH[4]) UNK2U409.D2
S2_OUT_RX0_CH4_ABC_CASE-: SITE2.C1(PAD_OUTN_RX0_CH[4]) UNK2U409.D1
S2_OUT_RX0_CH4_B_CASE+: UNK2R180.1 UNK2U409.B5
S2_OUT_RX0_CH4_B_CASE-: UNK2R182.1 UNK2U409.A5
S2_OUT_RX0_CH4_C_CASE: UNK2C320.1 UNK2R180.2 UNK2R182.2
S2_OUT_RX0_CH5_ABC_CASE+: SITE2.D3(PAD_OUTP_RX0_CH[5]) UNK2U409.E2
S2_OUT_RX0_CH5_ABC_CASE-: SITE2.D1(PAD_OUTN_RX0_CH[5]) UNK2U409.E1
S2_OUT_RX0_CH5_B_CASE+: UNK2R666.1 UNK2U409.B6
S2_OUT_RX0_CH5_B_CASE-: UNK2R664.1 UNK2U409.A6
S2_OUT_RX0_CH5_C_CASE: UNK2C924.1 UNK2R664.2 UNK2R666.2
S2_PAD_SZQ: SITE2.T11(PAD_SZQ) UNK2K113.5
S2_PM_SAR0: S2_VREF_OUT.1(TP) SITE2.B12(PAD_PM_SAR0) UNK2K34.3 UNK2MK3.4
S2_SPI_CK_ABCD_CASE: SITE2.N15(PAD_SPI0_CK) UNK2K2.6
S2_SPI_CK_B_CASE: UNK2K2.5 UNK2K3.6
S2_SPI_CK_C_CASE: UNK2K3.7 UNK2U18.6
S2_SPI_CK_D_CASE: UNK2K3.5 UNK2U19.6
S2_SPI_CZ_ABCD_CASE: SITE2.N14(PAD_SPI0_CZ) UNK2K2.3
S2_SPI_CZ_B_CASE: UNK2K2.4 UNK2K3.3
S2_SPI_CZ_C_CASE: UNK2K3.2 UNK2R200.2 UNK2U18.1
S2_SPI_CZ_D_CASE: UNK2K3.4 UNK2R205.2 UNK2U19.1
S2_SPI_DI_ABCD_CASE: SITE2.P16(PAD_SPI0_DI) UNK2K4.6
S2_SPI_DI_B_CASE: UNK2K4.5 UNK2K5.6
S2_SPI_DI_C_CASE: UNK2K5.7 UNK2U18.5
S2_SPI_DI_D_CASE: UNK2K5.5 UNK2U19.5
S2_SPI_DO_ABCD_CASE: SITE2.P15(PAD_SPI0_DO) UNK2K4.3
S2_SPI_DO_B_CASE: UNK2K4.4 UNK2K5.3
S2_SPI_DO_C_CASE: UNK2K5.2 UNK2U18.2
S2_SPI_DO_D_CASE: UNK2K5.4 UNK2U19.2
S2_SPI_HLD_ABCD_CASE: SITE2.M15(PAD_SPI0_HLD) UNK2K6.3
S2_SPI_HLD_B_CASE: UNK2K6.4 UNK2K7.3
S2_SPI_HLD_C_CASE: UNK2K7.2 UNK2R202.1 UNK2U18.7
S2_SPI_HLD_D_CASE: UNK2K7.4 UNK2R206.1 UNK2U19.7
S2_SPI_WPZ_ABCD_CASE: SITE2.M16(PAD_SPI0_WPZ) UNK2K6.6
S2_SPI_WPZ_B_CASE: UNK2K6.5 UNK2K7.6
S2_SPI_WPZ_C_CASE: UNK2K7.7 UNK2R203.2 UNK2U18.3
S2_SPI_WPZ_D_CASE: UNK2K7.5 UNK2R207.2 UNK2U19.3
S2_USB2_SEL0: UNK2R164.2 UNK2U31.6
S2_USB2_SEL1: UNK2R163.2 UNK2U31.5
S2_USB2_SELS: UNK2R165.2 UNK2U31.16
S2_USB_D_AB_CASE+: SITE2.F1(PAD_USB_DP) UNK2U31.10
S2_USB_D_AB_CASE-: SITE2.F2(PAD_USB_DM) UNK2U31.9
S2_USB_D_B_CASE+: UNK2R160.2 UNK2U31.8
S2_USB_D_B_CASE-: UNK2R161.2 UNK2U31.7
S2_USER_3V3: S2_USER_3V3.1 UNK2C334.1 UNK2C335.1 UNK2C336.2 UNK2C337.2 UNK2C338.2 UNK2C339.2 UNK2R200.1 UNK2R201.2 UNK2R202.2 UNK2R203.1 UNK2R204.2 UNK2R205.1 UNK2R206.2 UNK2R207.1 UNK2U17.3
S2_XTAL_24M_IN_ABC_CASE: SITE2.K15(PAD_XTAL_24M_IN) UNK2K32.3
S2_XTAL_24M_IN_B_CASE: UNK2K32.4 UNK2R135.1
S2_XTAL_24M_IN_C_CASE: UNK2C267.1 UNK2R135.2 UNK2R136.2 UNK2Y1.3
S2_XTAL_24M_OUT_ABC_CASE: SITE2.K16(PAD_XTAL_24M_OUT) UNK2K32.6
S2_XTAL_24M_OUT_B_CASE: UNK2K32.5 UNK2R137.1
S2_XTAL_24M_OUT_C_CASE: UNK2C268.1 UNK2R136.1 UNK2R137.2 UNK2Y1.1
S2_XTAL_IN_32K_A_CASE: UNK2K29.7 UNK2U449.7
S2_XTAL_IN_32K_ABCD_CASE: SITE2.B6(PAD_XTAL_IN_32K) UNK2K29.6
S2_XTAL_IN_32K_B_CASE: UNK2C271.1 UNK2K29.5 UNK2Y2.1
S2_XTAL_IN_32K_D_CASE: UNK2R923.1 UNK2R973.2 UNK2U449.2
S2_XTAL_OUT_32K_A_CASE: UNK2K29.2 UNK2U449.8
S2_XTAL_OUT_32K_ABCD_CASE: SITE2.A6(PAD_XTAL_OUT_32K) UNK2K29.3
S2_XTAL_OUT_32K_B_CASE: UNK2C272.1 UNK2K29.4 UNK2Y2.2
S2_XTAL_OUT_32K_D_CASE: UNK2R652.1 UNK2R973.1 UNK2U449.1
S3_0V5: UNK3C286.1 UNK3C288.1 UNK3MK1.4 UNK3MR2.2 UNK3MR3.1 UNK3MR4.1 UNK3MR5.1 UNK3MR6.1 UNK3MU3.3
S3_0V25: UNK3MK4.3 UNK3MR18.2 UNK3MR19.1
S3_0V75: UNK3C290.1 UNK3MK2.4 UNK3MR10.2 UNK3MU3.6
S3_1AWG_SHARE+: UNK3K34.4 UNK3K107.2
S3_3V3_ETH_MUX: UNK3BD1729.2 UNK3C1077.1 UNK3C1080.1 UNK3C1081.1 UNK3R984.1 UNK3R987.1 UNK3R990.1 UNK3U450.10 UNK3U451.10 UNK3U452.10
S3_3V3_RX0_MIPI: UNK3BDB5.2 UNK3C922.2 UNK3R661.2 UNK3U408.A2 UNK3U408.J4
S3_3V3_RX1_MIPI: UNK3BDB6.2 UNK3C923.2 UNK3R663.2 UNK3U409.A2 UNK3U409.J4
S3_3V3_USB2_MUX: UNK3BD21.2 UNK3C262.1 UNK3U31.4
S3_3V3_XTAL32K: UNK3BD1728.2 UNK3C1074.1 UNK3R981.1 UNK3U449.10
S3_AWG_2SHARE+: UNK3K107.4 UNK3U451.1
S3_AWG_2SHARE-: UNK3K107.5 UNK3U451.2
S3_AWG_3SHARE+: K111.2 UNK3K107.3
S3_AWG_3SHARE-: K111.7 UNK3K107.6
S3_DVDD_DDR_RX: SITE3.R4(DVDD_DDR_RX) UNK3CC133.1 UNK3K39.3
S3_DVDD_DDR_TX: SITE3.R5(DVDD_DDR_TX) UNK3CC134.1 UNK3K39.6
S3_ETH_RN_AB_CASE: SITE3.H16(PAD_ETH_RN) UNK3U451.7
S3_ETH_RP_AB_CASE: SITE3.H15(PAD_ETH_RP) UNK3U451.8
S3_ETH_TN_AB_CASE: SITE3.G15(PAD_ETH_TN) UNK3U450.7
S3_ETH_TP_AB_CASE: SITE3.G14(PAD_ETH_TP) UNK3U450.8
S3_M_2V5: UNK3C284.1 UNK3C285.1 UNK3MR2.1 UNK3MU2.6
S3_M_3V2: UNK3C282.1 UNK3C283.1 UNK3C289.1 UNK3MR1.1 UNK3MU1.5 UNK3MU2.2 UNK3MU3.7
S3_MUX_3V3: UNK3BD21.1 UNK3BD1728.1 UNK3BD1729.1 UNK3BDB5.1 UNK3BDB6.1 UNK3R512.1
S3_OUT_RX0_CH0_ABC_CASE+: SITE3.A3(PAD_OUTP_RX0_CH[0]) UNK3U408.B2
S3_OUT_RX0_CH0_ABC_CASE-: SITE3.C4(PAD_OUTN_RX0_CH[0]) UNK3U408.B1
S3_OUT_RX0_CH0_B_CASE+: UNK3R647.1 UNK3U408.B4
S3_OUT_RX0_CH0_B_CASE-: UNK3R646.1 UNK3U408.A4
S3_OUT_RX0_CH0_C_CASE: UNK3C309.1 UNK3R646.2 UNK3R647.2
S3_OUT_RX0_CH1_ABC_CASE+: SITE3.A2(PAD_OUTP_RX0_CH[1]) UNK3U408.D2
S3_OUT_RX0_CH1_ABC_CASE-: SITE3.B3(PAD_OUTN_RX0_CH[1]) UNK3U408.D1
S3_OUT_RX0_CH1_B_CASE+: UNK3R168.1 UNK3U408.B5
S3_OUT_RX0_CH1_B_CASE-: UNK3R170.1 UNK3U408.A5
S3_OUT_RX0_CH1_C_CASE: UNK3C310.1 UNK3R168.2 UNK3R170.2
S3_OUT_RX0_CH2_ABC_CASE+: SITE3.B2(PAD_OUTP_RX0_CH[2]) UNK3U408.E2
S3_OUT_RX0_CH2_ABC_CASE-: SITE3.C3(PAD_OUTN_RX0_CH[2]) UNK3U408.E1
S3_OUT_RX0_CH2_B_CASE+: UNK3R176.1 UNK3U408.B6
S3_OUT_RX0_CH2_B_CASE-: UNK3R178.1 UNK3U408.A6
S3_OUT_RX0_CH2_C_CASE: UNK3C318.1 UNK3R176.2 UNK3R178.2
S3_OUT_RX0_CH3_ABC_CASE+: SITE3.C2(PAD_OUTP_RX0_CH[3]) UNK3U409.B2
S3_OUT_RX0_CH3_ABC_CASE-: SITE3.B1(PAD_OUTN_RX0_CH[3]) UNK3U409.B1
S3_OUT_RX0_CH3_B_CASE+: UNK3R1089.1 UNK3U409.B4
S3_OUT_RX0_CH3_B_CASE-: UNK3R1088.1 UNK3U409.A4
S3_OUT_RX0_CH3_C_CASE: UNK3C302.1 UNK3R1088.2 UNK3R1089.2
S3_OUT_RX0_CH4_ABC_CASE+: SITE3.D2(PAD_OUTP_RX0_CH[4]) UNK3U409.D2
S3_OUT_RX0_CH4_ABC_CASE-: SITE3.C1(PAD_OUTN_RX0_CH[4]) UNK3U409.D1
S3_OUT_RX0_CH4_B_CASE+: UNK3R180.1 UNK3U409.B5
S3_OUT_RX0_CH4_B_CASE-: UNK3R182.1 UNK3U409.A5
S3_OUT_RX0_CH4_C_CASE: UNK3C320.1 UNK3R180.2 UNK3R182.2
S3_OUT_RX0_CH5_ABC_CASE+: SITE3.D3(PAD_OUTP_RX0_CH[5]) UNK3U409.E2
S3_OUT_RX0_CH5_ABC_CASE-: SITE3.D1(PAD_OUTN_RX0_CH[5]) UNK3U409.E1
S3_OUT_RX0_CH5_B_CASE+: UNK3R666.1 UNK3U409.B6
S3_OUT_RX0_CH5_B_CASE-: UNK3R664.1 UNK3U409.A6
S3_OUT_RX0_CH5_C_CASE: UNK3C924.1 UNK3R664.2 UNK3R666.2
S3_PAD_SZQ: SITE3.T11(PAD_SZQ) UNK3K113.5
S3_PM_SAR0: S3_VREF_OUT.1(TP) SITE3.B12(PAD_PM_SAR0) UNK3K34.3 UNK3MK3.4
S3_SPI_CK_ABCD_CASE: SITE3.N15(PAD_SPI0_CK) UNK3K2.6
S3_SPI_CK_B_CASE: UNK3K2.5 UNK3K3.6
S3_SPI_CK_C_CASE: UNK3K3.7 UNK3U18.6
S3_SPI_CK_D_CASE: UNK3K3.5 UNK3U19.6
S3_SPI_CZ_ABCD_CASE: SITE3.N14(PAD_SPI0_CZ) UNK3K2.3
S3_SPI_CZ_B_CASE: UNK3K2.4 UNK3K3.3
S3_SPI_CZ_C_CASE: UNK3K3.2 UNK3R200.2 UNK3U18.1
S3_SPI_CZ_D_CASE: UNK3K3.4 UNK3R205.2 UNK3U19.1
S3_SPI_DI_ABCD_CASE: SITE3.P16(PAD_SPI0_DI) UNK3K4.6
S3_SPI_DI_B_CASE: UNK3K4.5 UNK3K5.6
S3_SPI_DI_C_CASE: UNK3K5.7 UNK3U18.5
S3_SPI_DI_D_CASE: UNK3K5.5 UNK3U19.5
S3_SPI_DO_ABCD_CASE: SITE3.P15(PAD_SPI0_DO) UNK3K4.3
S3_SPI_DO_B_CASE: UNK3K4.4 UNK3K5.3
S3_SPI_DO_C_CASE: UNK3K5.2 UNK3U18.2
S3_SPI_DO_D_CASE: UNK3K5.4 UNK3U19.2
S3_SPI_HLD_ABCD_CASE: SITE3.M15(PAD_SPI0_HLD) UNK3K6.3
S3_SPI_HLD_B_CASE: UNK3K6.4 UNK3K7.3
S3_SPI_HLD_C_CASE: UNK3K7.2 UNK3R202.1 UNK3U18.7
S3_SPI_HLD_D_CASE: UNK3K7.4 UNK3R206.1 UNK3U19.7
S3_SPI_WPZ_ABCD_CASE: SITE3.M16(PAD_SPI0_WPZ) UNK3K6.6
S3_SPI_WPZ_B_CASE: UNK3K6.5 UNK3K7.6
S3_SPI_WPZ_C_CASE: UNK3K7.7 UNK3R203.2 UNK3U18.3
S3_SPI_WPZ_D_CASE: UNK3K7.5 UNK3R207.2 UNK3U19.3
S3_USB2_SEL0: UNK3R164.2 UNK3U31.6
S3_USB2_SEL1: UNK3R163.2 UNK3U31.5
S3_USB2_SELS: UNK3R165.2 UNK3U31.16
S3_USB_D_AB_CASE+: SITE3.F1(PAD_USB_DP) UNK3U31.10
S3_USB_D_AB_CASE-: SITE3.F2(PAD_USB_DM) UNK3U31.9
S3_USB_D_B_CASE+: UNK3R160.2 UNK3U31.8
S3_USB_D_B_CASE-: UNK3R161.2 UNK3U31.7
S3_USER_3V3: S3_USER_3V3.1 UNK3C334.1 UNK3C335.1 UNK3C336.2 UNK3C337.2 UNK3C338.2 UNK3C339.2 UNK3R200.1 UNK3R201.2 UNK3R202.2 UNK3R203.1 UNK3R204.2 UNK3R205.1 UNK3R206.2 UNK3R207.1 UNK3U17.3
S3_XTAL_24M_IN_ABC_CASE: SITE3.K15(PAD_XTAL_24M_IN) UNK3K32.3
S3_XTAL_24M_IN_B_CASE: UNK3K32.4 UNK3R135.1
S3_XTAL_24M_IN_C_CASE: UNK3C267.1 UNK3R135.2 UNK3R136.2 UNK3Y1.3
S3_XTAL_24M_OUT_ABC_CASE: SITE3.K16(PAD_XTAL_24M_OUT) UNK3K32.6
S3_XTAL_24M_OUT_B_CASE: UNK3K32.5 UNK3R137.1
S3_XTAL_24M_OUT_C_CASE: UNK3C268.1 UNK3R136.1 UNK3R137.2 UNK3Y1.1
S3_XTAL_IN_32K_A_CASE: UNK3K29.7 UNK3U449.7
S3_XTAL_IN_32K_ABCD_CASE: SITE3.B6(PAD_XTAL_IN_32K) UNK3K29.6
S3_XTAL_IN_32K_B_CASE: UNK3C271.1 UNK3K29.5 UNK3Y2.1
S3_XTAL_IN_32K_D_CASE: UNK3R923.1 UNK3R973.2 UNK3U449.2
S3_XTAL_OUT_32K_A_CASE: UNK3K29.2 UNK3U449.8
S3_XTAL_OUT_32K_ABCD_CASE: SITE3.A6(PAD_XTAL_OUT_32K) UNK3K29.3
S3_XTAL_OUT_32K_B_CASE: UNK3C272.1 UNK3K29.4 UNK3Y2.2
S3_XTAL_OUT_32K_D_CASE: UNK3R652.1 UNK3R973.1 UNK3U449.1
S4_0V5: UNK4C286.1 UNK4C288.1 UNK4MK1.4 UNK4MR2.2 UNK4MR3.1 UNK4MR4.1 UNK4MR5.1 UNK4MR6.1 UNK4MU3.3
S4_0V25: UNK4MK4.3 UNK4MR18.2 UNK4MR19.1
S4_0V75: UNK4C290.1 UNK4MK2.4 UNK4MR10.2 UNK4MU3.6
S4_1AWG_SHARE+: UNK4K34.4 UNK4K107.2
S4_3V3_ETH_MUX: UNK4BD1729.2 UNK4C1077.1 UNK4C1080.1 UNK4C1081.1 UNK4R984.1 UNK4R987.1 UNK4R990.1 UNK4U450.10 UNK4U451.10 UNK4U452.10
S4_3V3_RX0_MIPI: UNK4BDB5.2 UNK4C922.2 UNK4R661.2 UNK4U408.A2 UNK4U408.J4
S4_3V3_RX1_MIPI: UNK4BDB6.2 UNK4C923.2 UNK4R663.2 UNK4U409.A2 UNK4U409.J4
S4_3V3_USB2_MUX: UNK4BD21.2 UNK4C262.1 UNK4U31.4
S4_3V3_XTAL32K: UNK4BD1728.2 UNK4C1074.1 UNK4R981.1 UNK4U449.10
S4_AWG_2SHARE+: UNK4K107.4 UNK4U451.1
S4_AWG_2SHARE-: UNK4K107.5 UNK4U451.2
S4_AWG_3SHARE+: K112.2 UNK4K107.3
S4_AWG_3SHARE-: K112.7 UNK4K107.6
S4_DVDD_DDR_RX: SITE4.R4(DVDD_DDR_RX) UNK4CC133.1 UNK4K39.3
S4_DVDD_DDR_TX: SITE4.R5(DVDD_DDR_TX) UNK4CC134.1 UNK4K39.6
S4_ETH_RN_AB_CASE: SITE4.H16(PAD_ETH_RN) UNK4U451.7
S4_ETH_RP_AB_CASE: SITE4.H15(PAD_ETH_RP) UNK4U451.8
S4_ETH_TN_AB_CASE: SITE4.G15(PAD_ETH_TN) UNK4U450.7
S4_ETH_TP_AB_CASE: SITE4.G14(PAD_ETH_TP) UNK4U450.8
S4_M_2V5: UNK4C284.1 UNK4C285.1 UNK4MR2.1 UNK4MU2.6
S4_M_3V2: UNK4C282.1 UNK4C283.1 UNK4C289.1 UNK4MR1.1 UNK4MU1.5 UNK4MU2.2 UNK4MU3.7
S4_MUX_3V3: UNK4BD21.1 UNK4BD1728.1 UNK4BD1729.1 UNK4BDB5.1 UNK4BDB6.1 UNK4R512.1
S4_OUT_RX0_CH0_ABC_CASE+: SITE4.A3(PAD_OUTP_RX0_CH[0]) UNK4U408.B2
S4_OUT_RX0_CH0_ABC_CASE-: SITE4.C4(PAD_OUTN_RX0_CH[0]) UNK4U408.B1
S4_OUT_RX0_CH0_B_CASE+: UNK4R647.1 UNK4U408.B4
S4_OUT_RX0_CH0_B_CASE-: UNK4R646.1 UNK4U408.A4
S4_OUT_RX0_CH0_C_CASE: UNK4C309.1 UNK4R646.2 UNK4R647.2
S4_OUT_RX0_CH1_ABC_CASE+: SITE4.A2(PAD_OUTP_RX0_CH[1]) UNK4U408.D2
S4_OUT_RX0_CH1_ABC_CASE-: SITE4.B3(PAD_OUTN_RX0_CH[1]) UNK4U408.D1
S4_OUT_RX0_CH1_B_CASE+: UNK4R168.1 UNK4U408.B5
S4_OUT_RX0_CH1_B_CASE-: UNK4R170.1 UNK4U408.A5
S4_OUT_RX0_CH1_C_CASE: UNK4C310.1 UNK4R168.2 UNK4R170.2
S4_OUT_RX0_CH2_ABC_CASE+: SITE4.B2(PAD_OUTP_RX0_CH[2]) UNK4U408.E2
S4_OUT_RX0_CH2_ABC_CASE-: SITE4.C3(PAD_OUTN_RX0_CH[2]) UNK4U408.E1
S4_OUT_RX0_CH2_B_CASE+: UNK4R176.1 UNK4U408.B6
S4_OUT_RX0_CH2_B_CASE-: UNK4R178.1 UNK4U408.A6
S4_OUT_RX0_CH2_C_CASE: UNK4C318.1 UNK4R176.2 UNK4R178.2
S4_OUT_RX0_CH3_ABC_CASE+: SITE4.C2(PAD_OUTP_RX0_CH[3]) UNK4U409.B2
S4_OUT_RX0_CH3_ABC_CASE-: SITE4.B1(PAD_OUTN_RX0_CH[3]) UNK4U409.B1
S4_OUT_RX0_CH3_B_CASE+: UNK4R1089.1 UNK4U409.B4
S4_OUT_RX0_CH3_B_CASE-: UNK4R1088.1 UNK4U409.A4
S4_OUT_RX0_CH3_C_CASE: UNK4C302.1 UNK4R1088.2 UNK4R1089.2
S4_OUT_RX0_CH4_ABC_CASE+: SITE4.D2(PAD_OUTP_RX0_CH[4]) UNK4U409.D2
S4_OUT_RX0_CH4_ABC_CASE-: SITE4.C1(PAD_OUTN_RX0_CH[4]) UNK4U409.D1
S4_OUT_RX0_CH4_B_CASE+: UNK4R180.1 UNK4U409.B5
S4_OUT_RX0_CH4_B_CASE-: UNK4R182.1 UNK4U409.A5
S4_OUT_RX0_CH4_C_CASE: UNK4C320.1 UNK4R180.2 UNK4R182.2
S4_OUT_RX0_CH5_ABC_CASE+: SITE4.D3(PAD_OUTP_RX0_CH[5]) UNK4U409.E2
S4_OUT_RX0_CH5_ABC_CASE-: SITE4.D1(PAD_OUTN_RX0_CH[5]) UNK4U409.E1
S4_OUT_RX0_CH5_B_CASE+: UNK4R666.1 UNK4U409.B6
S4_OUT_RX0_CH5_B_CASE-: UNK4R664.1 UNK4U409.A6
S4_OUT_RX0_CH5_C_CASE: UNK4C924.1 UNK4R664.2 UNK4R666.2
S4_PAD_SZQ: SITE4.T11(PAD_SZQ) UNK4K113.5
S4_PM_SAR0: S4_VREF_OUT.1(TP) SITE4.B12(PAD_PM_SAR0) UNK4K34.3 UNK4MK3.4
S4_SPI_CK_ABCD_CASE: SITE4.N15(PAD_SPI0_CK) UNK4K2.6
S4_SPI_CK_B_CASE: UNK4K2.5 UNK4K3.6
S4_SPI_CK_C_CASE: UNK4K3.7 UNK4U18.6
S4_SPI_CK_D_CASE: UNK4K3.5 UNK4U19.6
S4_SPI_CZ_ABCD_CASE: SITE4.N14(PAD_SPI0_CZ) UNK4K2.3
S4_SPI_CZ_B_CASE: UNK4K2.4 UNK4K3.3
S4_SPI_CZ_C_CASE: UNK4K3.2 UNK4R200.2 UNK4U18.1
S4_SPI_CZ_D_CASE: UNK4K3.4 UNK4R205.2 UNK4U19.1
S4_SPI_DI_ABCD_CASE: SITE4.P16(PAD_SPI0_DI) UNK4K4.6
S4_SPI_DI_B_CASE: UNK4K4.5 UNK4K5.6
S4_SPI_DI_C_CASE: UNK4K5.7 UNK4U18.5
S4_SPI_DI_D_CASE: UNK4K5.5 UNK4U19.5
S4_SPI_DO_ABCD_CASE: SITE4.P15(PAD_SPI0_DO) UNK4K4.3
S4_SPI_DO_B_CASE: UNK4K4.4 UNK4K5.3
S4_SPI_DO_C_CASE: UNK4K5.2 UNK4U18.2
S4_SPI_DO_D_CASE: UNK4K5.4 UNK4U19.2
S4_SPI_HLD_ABCD_CASE: SITE4.M15(PAD_SPI0_HLD) UNK4K6.3
S4_SPI_HLD_B_CASE: UNK4K6.4 UNK4K7.3
S4_SPI_HLD_C_CASE: UNK4K7.2 UNK4R202.1 UNK4U18.7
S4_SPI_HLD_D_CASE: UNK4K7.4 UNK4R206.1 UNK4U19.7
S4_SPI_WPZ_ABCD_CASE: SITE4.M16(PAD_SPI0_WPZ) UNK4K6.6
S4_SPI_WPZ_B_CASE: UNK4K6.5 UNK4K7.6
S4_SPI_WPZ_C_CASE: UNK4K7.7 UNK4R203.2 UNK4U18.3
S4_SPI_WPZ_D_CASE: UNK4K7.5 UNK4R207.2 UNK4U19.3
S4_USB2_SEL0: UNK4R164.2 UNK4U31.6
S4_USB2_SEL1: UNK4R163.2 UNK4U31.5
S4_USB2_SELS: UNK4R165.2 UNK4U31.16
S4_USB_D_AB_CASE+: SITE4.F1(PAD_USB_DP) UNK4U31.10
S4_USB_D_AB_CASE-: SITE4.F2(PAD_USB_DM) UNK4U31.9
S4_USB_D_B_CASE+: UNK4R160.2 UNK4U31.8
S4_USB_D_B_CASE-: UNK4R161.2 UNK4U31.7
S4_USER_3V3: S4_USER_3V3.1 UNK4C334.1 UNK4C335.1 UNK4C336.2 UNK4C337.2 UNK4C338.2 UNK4C339.2 UNK4R200.1 UNK4R201.2 UNK4R202.2 UNK4R203.1 UNK4R204.2 UNK4R205.1 UNK4R206.2 UNK4R207.1 UNK4U17.3
S4_XTAL_24M_IN_ABC_CASE: SITE4.K15(PAD_XTAL_24M_IN) UNK4K32.3
S4_XTAL_24M_IN_B_CASE: UNK4K32.4 UNK4R135.1
S4_XTAL_24M_IN_C_CASE: UNK4C267.1 UNK4R135.2 UNK4R136.2 UNK4Y1.3
S4_XTAL_24M_OUT_ABC_CASE: SITE4.K16(PAD_XTAL_24M_OUT) UNK4K32.6
S4_XTAL_24M_OUT_B_CASE: UNK4K32.5 UNK4R137.1
S4_XTAL_24M_OUT_C_CASE: UNK4C268.1 UNK4R136.1 UNK4R137.2 UNK4Y1.1
S4_XTAL_IN_32K_A_CASE: UNK4K29.7 UNK4U449.7
S4_XTAL_IN_32K_ABCD_CASE: SITE4.B6(PAD_XTAL_IN_32K) UNK4K29.6
S4_XTAL_IN_32K_B_CASE: UNK4C271.1 UNK4K29.5 UNK4Y2.1
S4_XTAL_IN_32K_D_CASE: UNK4R923.1 UNK4R973.2 UNK4U449.2
S4_XTAL_OUT_32K_A_CASE: UNK4K29.2 UNK4U449.8
S4_XTAL_OUT_32K_ABCD_CASE: SITE4.A6(PAD_XTAL_OUT_32K) UNK4K29.3
S4_XTAL_OUT_32K_B_CASE: UNK4C272.1 UNK4K29.4 UNK4Y2.2
S4_XTAL_OUT_32K_D_CASE: UNK4R652.1 UNK4R973.1 UNK4U449.1
S5_0V5: UNK5C286.1 UNK5C288.1 UNK5MK1.4 UNK5MR2.2 UNK5MR3.1 UNK5MR4.1 UNK5MR5.1 UNK5MR6.1 UNK5MU3.3
S5_0V25: UNK5MK4.3 UNK5MR18.2 UNK5MR19.1
S5_0V75: UNK5C290.1 UNK5MK2.4 UNK5MR10.2 UNK5MU3.6
S5_1AWG_SHARE+: UNK5K34.4 UNK5K107.2
S5_3V3_ETH_MUX: UNK5BD1729.2 UNK5C1077.1 UNK5C1080.1 UNK5C1081.1 UNK5R984.1 UNK5R987.1 UNK5R990.1 UNK5U450.10 UNK5U451.10 UNK5U452.10
S5_3V3_RX0_MIPI: UNK5BDB5.2 UNK5C922.2 UNK5R661.2 UNK5U408.A2 UNK5U408.J4
S5_3V3_RX1_MIPI: UNK5BDB6.2 UNK5C923.2 UNK5R663.2 UNK5U409.A2 UNK5U409.J4
S5_3V3_USB2_MUX: UNK5BD21.2 UNK5C262.1 UNK5U31.4
S5_3V3_XTAL32K: UNK5BD1728.2 UNK5C1074.1 UNK5R981.1 UNK5U449.10
S5_AWG_2SHARE+: UNK5K107.4 UNK5U451.1
S5_AWG_2SHARE-: UNK5K107.5 UNK5U451.2
S5_AWG_3SHARE+: K109.4 UNK5K107.3
S5_AWG_3SHARE-: K109.5 UNK5K107.6
S5_DVDD_DDR_RX: SITE5.R4(DVDD_DDR_RX) UNK5CC133.1 UNK5K39.3
S5_DVDD_DDR_TX: SITE5.R5(DVDD_DDR_TX) UNK5CC134.1 UNK5K39.6
S5_ETH_RN_AB_CASE: SITE5.H16(PAD_ETH_RN) UNK5U451.7
S5_ETH_RP_AB_CASE: SITE5.H15(PAD_ETH_RP) UNK5U451.8
S5_ETH_TN_AB_CASE: SITE5.G15(PAD_ETH_TN) UNK5U450.7
S5_ETH_TP_AB_CASE: SITE5.G14(PAD_ETH_TP) UNK5U450.8
S5_M_2V5: UNK5C284.1 UNK5C285.1 UNK5MR2.1 UNK5MU2.6
S5_M_3V2: UNK5C282.1 UNK5C283.1 UNK5C289.1 UNK5MR1.1 UNK5MU1.5 UNK5MU2.2 UNK5MU3.7
S5_MUX_3V3: UNK5BD21.1 UNK5BD1728.1 UNK5BD1729.1 UNK5BDB5.1 UNK5BDB6.1 UNK5R512.1
S5_OUT_RX0_CH0_ABC_CASE+: SITE5.A3(PAD_OUTP_RX0_CH[0]) UNK5U408.B2
S5_OUT_RX0_CH0_ABC_CASE-: SITE5.C4(PAD_OUTN_RX0_CH[0]) UNK5U408.B1
S5_OUT_RX0_CH0_B_CASE+: UNK5R647.1 UNK5U408.B4
S5_OUT_RX0_CH0_B_CASE-: UNK5R646.1 UNK5U408.A4
S5_OUT_RX0_CH0_C_CASE: UNK5C309.1 UNK5R646.2 UNK5R647.2
S5_OUT_RX0_CH1_ABC_CASE+: SITE5.A2(PAD_OUTP_RX0_CH[1]) UNK5U408.D2
S5_OUT_RX0_CH1_ABC_CASE-: SITE5.B3(PAD_OUTN_RX0_CH[1]) UNK5U408.D1
S5_OUT_RX0_CH1_B_CASE+: UNK5R168.1 UNK5U408.B5
S5_OUT_RX0_CH1_B_CASE-: UNK5R170.1 UNK5U408.A5
S5_OUT_RX0_CH1_C_CASE: UNK5C310.1 UNK5R168.2 UNK5R170.2
S5_OUT_RX0_CH2_ABC_CASE+: SITE5.B2(PAD_OUTP_RX0_CH[2]) UNK5U408.E2
S5_OUT_RX0_CH2_ABC_CASE-: SITE5.C3(PAD_OUTN_RX0_CH[2]) UNK5U408.E1
S5_OUT_RX0_CH2_B_CASE+: UNK5R176.1 UNK5U408.B6
S5_OUT_RX0_CH2_B_CASE-: UNK5R178.1 UNK5U408.A6
S5_OUT_RX0_CH2_C_CASE: UNK5C318.1 UNK5R176.2 UNK5R178.2
S5_OUT_RX0_CH3_ABC_CASE+: SITE5.C2(PAD_OUTP_RX0_CH[3]) UNK5U409.B2
S5_OUT_RX0_CH3_ABC_CASE-: SITE5.B1(PAD_OUTN_RX0_CH[3]) UNK5U409.B1
S5_OUT_RX0_CH3_B_CASE+: UNK5R1089.1 UNK5U409.B4
S5_OUT_RX0_CH3_B_CASE-: UNK5R1088.1 UNK5U409.A4
S5_OUT_RX0_CH3_C_CASE: UNK5C302.1 UNK5R1088.2 UNK5R1089.2
S5_OUT_RX0_CH4_ABC_CASE+: SITE5.D2(PAD_OUTP_RX0_CH[4]) UNK5U409.D2
S5_OUT_RX0_CH4_ABC_CASE-: SITE5.C1(PAD_OUTN_RX0_CH[4]) UNK5U409.D1
S5_OUT_RX0_CH4_B_CASE+: UNK5R180.1 UNK5U409.B5
S5_OUT_RX0_CH4_B_CASE-: UNK5R182.1 UNK5U409.A5
S5_OUT_RX0_CH4_C_CASE: UNK5C320.1 UNK5R180.2 UNK5R182.2
S5_OUT_RX0_CH5_ABC_CASE+: SITE5.D3(PAD_OUTP_RX0_CH[5]) UNK5U409.E2
S5_OUT_RX0_CH5_ABC_CASE-: SITE5.D1(PAD_OUTN_RX0_CH[5]) UNK5U409.E1
S5_OUT_RX0_CH5_B_CASE+: UNK5R666.1 UNK5U409.B6
S5_OUT_RX0_CH5_B_CASE-: UNK5R664.1 UNK5U409.A6
S5_OUT_RX0_CH5_C_CASE: UNK5C924.1 UNK5R664.2 UNK5R666.2
S5_PAD_SZQ: SITE5.T11(PAD_SZQ) UNK5K113.5
S5_PM_SAR0: S5_VREF_OUT.1(TP) SITE5.B12(PAD_PM_SAR0) UNK5K34.3 UNK5MK3.4
S5_SPI_CK_ABCD_CASE: SITE5.N15(PAD_SPI0_CK) UNK5K2.6
S5_SPI_CK_B_CASE: UNK5K2.5 UNK5K3.6
S5_SPI_CK_C_CASE: UNK5K3.7 UNK5U18.6
S5_SPI_CK_D_CASE: UNK5K3.5 UNK5U19.6
S5_SPI_CZ_ABCD_CASE: SITE5.N14(PAD_SPI0_CZ) UNK5K2.3
S5_SPI_CZ_B_CASE: UNK5K2.4 UNK5K3.3
S5_SPI_CZ_C_CASE: UNK5K3.2 UNK5R200.2 UNK5U18.1
S5_SPI_CZ_D_CASE: UNK5K3.4 UNK5R205.2 UNK5U19.1
S5_SPI_DI_ABCD_CASE: SITE5.P16(PAD_SPI0_DI) UNK5K4.6
S5_SPI_DI_B_CASE: UNK5K4.5 UNK5K5.6
S5_SPI_DI_C_CASE: UNK5K5.7 UNK5U18.5
S5_SPI_DI_D_CASE: UNK5K5.5 UNK5U19.5
S5_SPI_DO_ABCD_CASE: SITE5.P15(PAD_SPI0_DO) UNK5K4.3
S5_SPI_DO_B_CASE: UNK5K4.4 UNK5K5.3
S5_SPI_DO_C_CASE: UNK5K5.2 UNK5U18.2
S5_SPI_DO_D_CASE: UNK5K5.4 UNK5U19.2
S5_SPI_HLD_ABCD_CASE: SITE5.M15(PAD_SPI0_HLD) UNK5K6.3
S5_SPI_HLD_B_CASE: UNK5K6.4 UNK5K7.3
S5_SPI_HLD_C_CASE: UNK5K7.2 UNK5R202.1 UNK5U18.7
S5_SPI_HLD_D_CASE: UNK5K7.4 UNK5R206.1 UNK5U19.7
S5_SPI_WPZ_ABCD_CASE: SITE5.M16(PAD_SPI0_WPZ) UNK5K6.6
S5_SPI_WPZ_B_CASE: UNK5K6.5 UNK5K7.6
S5_SPI_WPZ_C_CASE: UNK5K7.7 UNK5R203.2 UNK5U18.3
S5_SPI_WPZ_D_CASE: UNK5K7.5 UNK5R207.2 UNK5U19.3
S5_USB2_SEL0: UNK5R164.2 UNK5U31.6
S5_USB2_SEL1: UNK5R163.2 UNK5U31.5
S5_USB2_SELS: UNK5R165.2 UNK5U31.16
S5_USB_D_AB_CASE+: SITE5.F1(PAD_USB_DP) UNK5U31.10
S5_USB_D_AB_CASE-: SITE5.F2(PAD_USB_DM) UNK5U31.9
S5_USB_D_B_CASE+: UNK5R160.2 UNK5U31.8
S5_USB_D_B_CASE-: UNK5R161.2 UNK5U31.7
S5_USER_3V3: S5_USER_3V3.1 UNK5C334.1 UNK5C335.1 UNK5C336.2 UNK5C337.2 UNK5C338.2 UNK5C339.2 UNK5R200.1 UNK5R201.2 UNK5R202.2 UNK5R203.1 UNK5R204.2 UNK5R205.1 UNK5R206.2 UNK5R207.1 UNK5U17.3
S5_XTAL_24M_IN_ABC_CASE: SITE5.K15(PAD_XTAL_24M_IN) UNK5K32.3
S5_XTAL_24M_IN_B_CASE: UNK5K32.4 UNK5R135.1
S5_XTAL_24M_IN_C_CASE: UNK5C267.1 UNK5R135.2 UNK5R136.2 UNK5Y1.3
S5_XTAL_24M_OUT_ABC_CASE: SITE5.K16(PAD_XTAL_24M_OUT) UNK5K32.6
S5_XTAL_24M_OUT_B_CASE: UNK5K32.5 UNK5R137.1
S5_XTAL_24M_OUT_C_CASE: UNK5C268.1 UNK5R136.1 UNK5R137.2 UNK5Y1.1
S5_XTAL_IN_32K_A_CASE: UNK5K29.7 UNK5U449.7
S5_XTAL_IN_32K_ABCD_CASE: SITE5.B6(PAD_XTAL_IN_32K) UNK5K29.6
S5_XTAL_IN_32K_B_CASE: UNK5C271.1 UNK5K29.5 UNK5Y2.1
S5_XTAL_IN_32K_D_CASE: UNK5R923.1 UNK5R973.2 UNK5U449.2
S5_XTAL_OUT_32K_A_CASE: UNK5K29.2 UNK5U449.8
S5_XTAL_OUT_32K_ABCD_CASE: SITE5.A6(PAD_XTAL_OUT_32K) UNK5K29.3
S5_XTAL_OUT_32K_B_CASE: UNK5C272.1 UNK5K29.4 UNK5Y2.2
S5_XTAL_OUT_32K_D_CASE: UNK5R652.1 UNK5R973.1 UNK5U449.1
S6_0V5: UNK6C286.1 UNK6C288.1 UNK6MK1.4 UNK6MR2.2 UNK6MR3.1 UNK6MR4.1 UNK6MR5.1 UNK6MR6.1 UNK6MU3.3
S6_0V25: UNK6MK4.3 UNK6MR18.2 UNK6MR19.1
S6_0V75: UNK6C290.1 UNK6MK2.4 UNK6MR10.2 UNK6MU3.6
S6_1AWG_SHARE+: UNK6K34.4 UNK6K107.2
S6_3V3_ETH_MUX: UNK6BD1729.2 UNK6C1077.1 UNK6C1080.1 UNK6C1081.1 UNK6R984.1 UNK6R987.1 UNK6R990.1 UNK6U450.10 UNK6U451.10 UNK6U452.10
S6_3V3_RX0_MIPI: UNK6BDB5.2 UNK6C922.2 UNK6R661.2 UNK6U408.A2 UNK6U408.J4
S6_3V3_RX1_MIPI: UNK6BDB6.2 UNK6C923.2 UNK6R663.2 UNK6U409.A2 UNK6U409.J4
S6_3V3_USB2_MUX: UNK6BD21.2 UNK6C262.1 UNK6U31.4
S6_3V3_XTAL32K: UNK6BD1728.2 UNK6C1074.1 UNK6R981.1 UNK6U449.10
S6_AWG_2SHARE+: UNK6K107.4 UNK6U451.1
