# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Nets (continued)
CSDPS303GS1: 7SA24.2 CSDPS303.D2
CSDPS303GS2: CSDPS303.A1
CSDPS303GS3: 7SA15.2 CSDPS303.D4
CSDPS303GS4: CSDPS303.A3
CSDPS303GS5: CSDPS303.D6
CSDPS303GS6: 7SA10.2 CSDPS303.A5
CSDPS303GS7: CSDPS303.D8
CSDPS303GS8: CSDPS303.A7
CSDPS303GS9: 7SA7.2 CSDPS303.D10
CSDPS303GS10: CSDPS303.A9
CSDPS303GS11: 7SA20.2 CSDPS303.D12
CSDPS303GS12: CSDPS303.A11
CSDPS303GS13: 7SA18.2 CSDPS303.D14
CSDPS303GS14: 7SA22.2 CSDPS303.A13
CSDPS303GS15: 7SA2.2 CSDPS303.A15 CSDPS303.D16
CSDPS303P1: 7SA23.1 CSDPS303.B1 SITE7.N8(VDDQ_DRAM-01) SITE7.N9(VDDQ_DRAM-02) SITE7.P7(VDDQ-01) SITE7.P8(VDDQ-02) SITE7.P9(VDDQ_DRAM-03) SITE7.R7(VDDQ-03) UNK7CA36.1 UNK7CA37.1 UNK7CC210.1 UNK7CC211.1 UNK7CC212.1 UNK7CC213.1 UNK7CC215.1 UNK7CC216.1 UNK7TP_DPS8.1
CSDPS303P2: CSDPS303.C2
CSDPS303P3: 7SA16.1 CSDPS303.B3 SITE7.E10(DVDD_NODIE) UNK7CA26.1 UNK7CA27.1 UNK7CC112.1 UNK7TP_DPS2.1
CSDPS303P4: CSDPS303.C4
CSDPS303P5: CSDPS303.B5
CSDPS303P6: 7SA9.1 CSDPS303.C6 SITE7.N10(VDD2_DRAM-01) SITE7.N11(VDD2_DRAM-02) SITE7.P11(VDD2_DRAM-03) SITE7.R8(VDDIO-01) SITE7.T7(VDDIO-02) SITE7.T8(VDDIO-03) SITE7.T9(VDDIO-04) UNK7CA24.1 UNK7CA25.1 UNK7CC101.1 UNK7CC103.1 UNK7CC105.1 UNK7CC107.1 UNK7CC203.1 UNK7CC204.1 UNK7CC205.1 UNK7TP_DPS7.1
CSDPS303P7: CSDPS303.B7
CSDPS303P8: CSDPS303.C8
CSDPS303P9: 7SA8.1 CSDPS303.B9 SITE7.F13(VDDP3318_PM) SITE7.L11(VDDP3318_P0) SITE7.M4(VDDP3318_P2) UNK7CA7.1 UNK7CA8.1 UNK7CC70.1 UNK7CC71.1 UNK7CC73.1 UNK7TP_DPS6.1
CSDPS303P10: CSDPS303.C10
CSDPS303P11: 7SA19.1 CSDPS303.B11 SITE7.G4(AVDD33_USB) SITE7.H12(AVDD33_ETH) UNK7CA34.1 UNK7CA35.1 UNK7CC182.1 UNK7CC202.1 UNK7TP_DPS4.1
CSDPS303P12: CSDPS303.C12
CSDPS303P13: 7SA17.1 CSDPS303.B13 SITE7.D5(VDDP18_P1) SITE7.D11(AVDD18_NODIE) SITE7.F4(AVDD18_USB) SITE7.F11(AVDD18_HSRAM) SITE7.H4(AVDD18_AUD) SITE7.J11(AVDD18_OTP) SITE7.J12(AVDD18_ETH) SITE7.K13(AVDD18_XTAL) SITE7.P10(VDD1_DRAM) SITE7.T5(AVDD18_PLL2_DDR) SITE7.T6(AVDD18_PLL_DDR) UNK7CA20.1 UNK7CA21.1 UNK7CC84.1 UNK7CC85.1 UNK7CC86.1 UNK7CC87.1 UNK7CC88.1 UNK7CC89.1 UNK7CC90.1 UNK7CC91.1 UNK7CC92.1 UNK7CC208.1 UNK7CC209.1 UNK7TP_DPS3.1
CSDPS303P14: 7SA21.1 CSDPS303.C14 SITE7.D10(AVDD33_RTC) UNK7CA22.1 UNK7CA23.1 UNK7CC96.1 UNK7TP_DPS5.1
CSDPS303P15: 7SA1.1 CSDPS303.B15 CSDPS303.C16 SITE7.E8(AVDDL_MIPIRX) SITE7.F6(VDD_CPU-01) SITE7.F8(VDD-01) SITE7.F9(VDD-02) SITE7.G6(VDD_CPU-02) SITE7.G8(VDD-03) SITE7.G9(VDD-04) SITE7.H6(VDD_CPU-03) SITE7.H7(VDD_CPU-04) SITE7.H9(VDD-05) SITE7.H10(VDD-06) SITE7.J8(VDD-07) SITE7.J9(VDD-08) SITE7.N5(DVDD_DDR_NNDRV) SITE7.P5(DVDD_DDR) UNK7CA1.1 UNK7CA2.1 UNK7CC1.1 UNK7CC2.1 UNK7CC3.1 UNK7CC4.1 UNK7CC5.1 UNK7CC6.1 UNK7CC7.1 UNK7CC8.1 UNK7CC9.1 UNK7CC12.1 UNK7CC13.1 UNK7CC14.1 UNK7CC15.1 UNK7CC16.1 UNK7CC130.1 UNK7K39.4 UNK7K39.5 UNK7K96.4 UNK7K96.9 UNK7TP_DPS1.1
CSDPS303PS1: 7SA23.2 CSDPS303.D1
CSDPS303PS2: CSDPS303.A2
CSDPS303PS3: 7SA16.2 CSDPS303.D3
CSDPS303PS4: CSDPS303.A4
CSDPS303PS5: CSDPS303.D5
CSDPS303PS6: 7SA9.2 CSDPS303.A6
CSDPS303PS7: CSDPS303.D7
CSDPS303PS8: CSDPS303.A8
CSDPS303PS9: 7SA8.2 CSDPS303.D9
CSDPS303PS10: CSDPS303.A10
CSDPS303PS11: 7SA19.2 CSDPS303.D11
CSDPS303PS12: CSDPS303.A12
CSDPS303PS13: 7SA17.2 CSDPS303.D13
CSDPS303PS14: 7SA21.2 CSDPS303.A14
CSDPS303PS15: 7SA1.2 CSDPS303.A16 CSDPS303.D15
CSDPS307GS1: 8SA24.2 CSDPS307.D2
CSDPS307GS2: CSDPS307.A1
CSDPS307GS3: 8SA15.2 CSDPS307.D4
CSDPS307GS4: CSDPS307.A3
CSDPS307GS5: CSDPS307.D6
CSDPS307GS6: 8SA10.2 CSDPS307.A5
CSDPS307GS7: CSDPS307.D8
CSDPS307GS8: CSDPS307.A7
CSDPS307GS9: 8SA7.2 CSDPS307.D10
CSDPS307GS10: CSDPS307.A9
CSDPS307GS11: 8SA20.2 CSDPS307.D12
CSDPS307GS12: CSDPS307.A11
CSDPS307GS13: 8SA18.2 CSDPS307.D14
CSDPS307GS14: 8SA22.2 CSDPS307.A13
CSDPS307GS15: 8SA2.2 CSDPS307.A15 CSDPS307.D16
CSDPS307P1: 8SA23.1 CSDPS307.B1 SITE8.N8(VDDQ_DRAM-01) SITE8.N9(VDDQ_DRAM-02) SITE8.P7(VDDQ-01) SITE8.P8(VDDQ-02) SITE8.P9(VDDQ_DRAM-03) SITE8.R7(VDDQ-03) UNK8CA36.1 UNK8CA37.1 UNK8CC210.1 UNK8CC211.1 UNK8CC212.1 UNK8CC213.1 UNK8CC215.1 UNK8CC216.1 UNK8TP_DPS8.1
CSDPS307P2: CSDPS307.C2
CSDPS307P3: 8SA16.1 CSDPS307.B3 SITE8.E10(DVDD_NODIE) UNK8CA26.1 UNK8CA27.1 UNK8CC112.1 UNK8TP_DPS2.1
CSDPS307P4: CSDPS307.C4
CSDPS307P5: CSDPS307.B5
CSDPS307P6: 8SA9.1 CSDPS307.C6 SITE8.N10(VDD2_DRAM-01) SITE8.N11(VDD2_DRAM-02) SITE8.P11(VDD2_DRAM-03) SITE8.R8(VDDIO-01) SITE8.T7(VDDIO-02) SITE8.T8(VDDIO-03) SITE8.T9(VDDIO-04) UNK8CA24.1 UNK8CA25.1 UNK8CC101.1 UNK8CC103.1 UNK8CC105.1 UNK8CC107.1 UNK8CC203.1 UNK8CC204.1 UNK8CC205.1 UNK8TP_DPS7.1
CSDPS307P7: CSDPS307.B7
CSDPS307P8: CSDPS307.C8
CSDPS307P9: 8SA8.1 CSDPS307.B9 SITE8.F13(VDDP3318_PM) SITE8.L11(VDDP3318_P0) SITE8.M4(VDDP3318_P2) UNK8CA7.1 UNK8CA8.1 UNK8CC70.1 UNK8CC71.1 UNK8CC73.1 UNK8TP_DPS6.1
CSDPS307P10: CSDPS307.C10
CSDPS307P11: 8SA19.1 CSDPS307.B11 SITE8.G4(AVDD33_USB) SITE8.H12(AVDD33_ETH) UNK8CA34.1 UNK8CA35.1 UNK8CC182.1 UNK8CC202.1 UNK8TP_DPS4.1
CSDPS307P12: CSDPS307.C12
CSDPS307P13: 8SA17.1 CSDPS307.B13 SITE8.D5(VDDP18_P1) SITE8.D11(AVDD18_NODIE) SITE8.F4(AVDD18_USB) SITE8.F11(AVDD18_HSRAM) SITE8.H4(AVDD18_AUD) SITE8.J11(AVDD18_OTP) SITE8.J12(AVDD18_ETH) SITE8.K13(AVDD18_XTAL) SITE8.P10(VDD1_DRAM) SITE8.T5(AVDD18_PLL2_DDR) SITE8.T6(AVDD18_PLL_DDR) UNK8CA20.1 UNK8CA21.1 UNK8CC84.1 UNK8CC85.1 UNK8CC86.1 UNK8CC87.1 UNK8CC88.1 UNK8CC89.1 UNK8CC90.1 UNK8CC91.1 UNK8CC92.1 UNK8CC208.1 UNK8CC209.1 UNK8TP_DPS3.1
CSDPS307P14: 8SA21.1 CSDPS307.C14 SITE8.D10(AVDD33_RTC) UNK8CA22.1 UNK8CA23.1 UNK8CC96.1 UNK8TP_DPS5.1
CSDPS307P15: 8SA1.1 CSDPS307.B15 CSDPS307.C16 SITE8.E8(AVDDL_MIPIRX) SITE8.F6(VDD_CPU-01) SITE8.F8(VDD-01) SITE8.F9(VDD-02) SITE8.G6(VDD_CPU-02) SITE8.G8(VDD-03) SITE8.G9(VDD-04) SITE8.H6(VDD_CPU-03) SITE8.H7(VDD_CPU-04) SITE8.H9(VDD-05) SITE8.H10(VDD-06) SITE8.J8(VDD-07) SITE8.J9(VDD-08) SITE8.N5(DVDD_DDR_NNDRV) SITE8.P5(DVDD_DDR) UNK8CA1.1 UNK8CA2.1 UNK8CC1.1 UNK8CC2.1 UNK8CC3.1 UNK8CC4.1 UNK8CC5.1 UNK8CC6.1 UNK8CC7.1 UNK8CC8.1 UNK8CC9.1 UNK8CC12.1 UNK8CC13.1 UNK8CC14.1 UNK8CC15.1 UNK8CC16.1 UNK8CC130.1 UNK8K39.4 UNK8K39.5 UNK8K96.4 UNK8K96.9 UNK8TP_DPS1.1
CSDPS307PS1: 8SA23.2 CSDPS307.D1
CSDPS307PS2: CSDPS307.A2
CSDPS307PS3: 8SA16.2 CSDPS307.D3
CSDPS307PS4: CSDPS307.A4
CSDPS307PS5: CSDPS307.D5
CSDPS307PS6: 8SA9.2 CSDPS307.A6
CSDPS307PS7: CSDPS307.D7
CSDPS307PS8: CSDPS307.A8
CSDPS307PS9: 8SA8.2 CSDPS307.D9
CSDPS307PS10: CSDPS307.A10
CSDPS307PS11: 8SA19.2 CSDPS307.D11
CSDPS307PS12: CSDPS307.A12
CSDPS307PS13: 8SA17.2 CSDPS307.D13
CSDPS307PS14: 8SA21.2 CSDPS307.A14
CSDPS307PS15: 8SA1.2 CSDPS307.A16 CSDPS307.D15
CSDPS310GS1: 4SA2.2 CSDPS310.A1 CSDPS310.D2
CSDPS310GS3: 4SA20.2 CSDPS310.D4
CSDPS310GS4: 4SA22.2 CSDPS310.A3
CSDPS310GS5: 4SA18.2 CSDPS310.D6
CSDPS310GS6: CSDPS310.A5
CSDPS310GS7: 4SA7.2 CSDPS310.D8
CSDPS310GS8: CSDPS310.A7
CSDPS310GS9: CSDPS310.D10
CSDPS310GS10: CSDPS310.A9
CSDPS310GS11: 4SA15.2 CSDPS310.D12
CSDPS310GS12: CSDPS310.A11
CSDPS310GS13: CSDPS310.D14
CSDPS310GS14: 4SA10.2 CSDPS310.A13
CSDPS310GS15: 4SA24.2 CSDPS310.D16
CSDPS310GS16: CSDPS310.A15
CSDPS310P1: 4SA1.1 CSDPS310.B1 CSDPS310.C2 SITE4.E8(AVDDL_MIPIRX) SITE4.F6(VDD_CPU-01) SITE4.F8(VDD-01) SITE4.F9(VDD-02) SITE4.G6(VDD_CPU-02) SITE4.G8(VDD-03) SITE4.G9(VDD-04) SITE4.H6(VDD_CPU-03) SITE4.H7(VDD_CPU-04) SITE4.H9(VDD-05) SITE4.H10(VDD-06) SITE4.J8(VDD-07) SITE4.J9(VDD-08) SITE4.N5(DVDD_DDR_NNDRV) SITE4.P5(DVDD_DDR) UNK4CA1.1 UNK4CA2.1 UNK4CC1.1 UNK4CC2.1 UNK4CC3.1 UNK4CC4.1 UNK4CC5.1 UNK4CC6.1 UNK4CC7.1 UNK4CC8.1 UNK4CC9.1 UNK4CC12.1 UNK4CC13.1 UNK4CC14.1 UNK4CC15.1 UNK4CC16.1 UNK4CC130.1 UNK4K39.4 UNK4K39.5 UNK4K96.4 UNK4K96.9 UNK4TP_DPS1.1
CSDPS310P3: 4SA19.1 CSDPS310.B3 SITE4.G4(AVDD33_USB) SITE4.H12(AVDD33_ETH) UNK4CA34.1 UNK4CA35.1 UNK4CC182.1 UNK4CC202.1 UNK4TP_DPS4.1
CSDPS310P4: 4SA21.1 CSDPS310.C4 SITE4.D10(AVDD33_RTC) UNK4CA22.1 UNK4CA23.1 UNK4CC96.1 UNK4TP_DPS5.1
CSDPS310P5: 4SA17.1 CSDPS310.B5 SITE4.D5(VDDP18_P1) SITE4.D11(AVDD18_NODIE) SITE4.F4(AVDD18_USB) SITE4.F11(AVDD18_HSRAM) SITE4.H4(AVDD18_AUD) SITE4.J11(AVDD18_OTP) SITE4.J12(AVDD18_ETH) SITE4.K13(AVDD18_XTAL) SITE4.P10(VDD1_DRAM) SITE4.T5(AVDD18_PLL2_DDR) SITE4.T6(AVDD18_PLL_DDR) UNK4CA20.1 UNK4CA21.1 UNK4CC84.1 UNK4CC85.1 UNK4CC86.1 UNK4CC87.1 UNK4CC88.1 UNK4CC89.1 UNK4CC90.1 UNK4CC91.1 UNK4CC92.1 UNK4CC208.1 UNK4CC209.1 UNK4TP_DPS3.1
CSDPS310P6: CSDPS310.C6
CSDPS310P7: 4SA8.1 CSDPS310.B7 SITE4.F13(VDDP3318_PM) SITE4.L11(VDDP3318_P0) SITE4.M4(VDDP3318_P2) UNK4CA7.1 UNK4CA8.1 UNK4CC70.1 UNK4CC71.1 UNK4CC73.1 UNK4TP_DPS6.1
CSDPS310P8: CSDPS310.C8
CSDPS310P9: CSDPS310.B9
CSDPS310P10: CSDPS310.C10
CSDPS310P11: 4SA16.1 CSDPS310.B11 SITE4.E10(DVDD_NODIE) UNK4CA26.1 UNK4CA27.1 UNK4CC112.1 UNK4TP_DPS2.1
CSDPS310P12: CSDPS310.C12
CSDPS310P13: CSDPS310.B13
CSDPS310P14: 4SA9.1 CSDPS310.C14 SITE4.N10(VDD2_DRAM-01) SITE4.N11(VDD2_DRAM-02) SITE4.P11(VDD2_DRAM-03) SITE4.R8(VDDIO-01) SITE4.T7(VDDIO-02) SITE4.T8(VDDIO-03) SITE4.T9(VDDIO-04) UNK4CA24.1 UNK4CA25.1 UNK4CC101.1 UNK4CC103.1 UNK4CC105.1 UNK4CC107.1 UNK4CC203.1 UNK4CC204.1 UNK4CC205.1 UNK4TP_DPS7.1
CSDPS310P15: 4SA23.1 CSDPS310.B15 SITE4.N8(VDDQ_DRAM-01) SITE4.N9(VDDQ_DRAM-02) SITE4.P7(VDDQ-01) SITE4.P8(VDDQ-02) SITE4.P9(VDDQ_DRAM-03) SITE4.R7(VDDQ-03) UNK4CA36.1 UNK4CA37.1 UNK4CC210.1 UNK4CC211.1 UNK4CC212.1 UNK4CC213.1 UNK4CC215.1 UNK4CC216.1 UNK4TP_DPS8.1
CSDPS310P16: CSDPS310.C16
CSDPS310PS1: 4SA1.2 CSDPS310.A2 CSDPS310.D1
CSDPS310PS3: 4SA19.2 CSDPS310.D3
CSDPS310PS4: 4SA21.2 CSDPS310.A4
CSDPS310PS5: 4SA17.2 CSDPS310.D5
CSDPS310PS6: CSDPS310.A6
CSDPS310PS7: 4SA8.2 CSDPS310.D7
CSDPS310PS8: CSDPS310.A8
CSDPS310PS9: CSDPS310.D9
CSDPS310PS10: CSDPS310.A10
CSDPS310PS11: 4SA16.2 CSDPS310.D11
CSDPS310PS12: CSDPS310.A12
CSDPS310PS13: CSDPS310.D13
CSDPS310PS14: 4SA9.2 CSDPS310.A14
CSDPS310PS15: 4SA23.2 CSDPS310.D15
CSDPS310PS16: CSDPS310.A16
CSDPS314GS1: 3SA2.2 CSDPS314.A1 CSDPS314.D2
CSDPS314GS3: 3SA20.2 CSDPS314.D4
CSDPS314GS4: 3SA22.2 CSDPS314.A3
CSDPS314GS5: 3SA18.2 CSDPS314.D6
CSDPS314GS6: CSDPS314.A5
CSDPS314GS7: 3SA7.2 CSDPS314.D8
CSDPS314GS8: CSDPS314.A7
CSDPS314GS9: CSDPS314.D10
CSDPS314GS10: CSDPS314.A9
CSDPS314GS11: 3SA15.2 CSDPS314.D12
CSDPS314GS12: CSDPS314.A11
CSDPS314GS13: CSDPS314.D14
CSDPS314GS14: 3SA10.2 CSDPS314.A13
CSDPS314GS15: 3SA24.2 CSDPS314.D16
CSDPS314GS16: CSDPS314.A15
CSDPS314P1: 3SA1.1 CSDPS314.B1 CSDPS314.C2 SITE3.E8(AVDDL_MIPIRX) SITE3.F6(VDD_CPU-01) SITE3.F8(VDD-01) SITE3.F9(VDD-02) SITE3.G6(VDD_CPU-02) SITE3.G8(VDD-03) SITE3.G9(VDD-04) SITE3.H6(VDD_CPU-03) SITE3.H7(VDD_CPU-04) SITE3.H9(VDD-05) SITE3.H10(VDD-06) SITE3.J8(VDD-07) SITE3.J9(VDD-08) SITE3.N5(DVDD_DDR_NNDRV) SITE3.P5(DVDD_DDR) UNK3CA1.1 UNK3CA2.1 UNK3CC1.1 UNK3CC2.1 UNK3CC3.1 UNK3CC4.1 UNK3CC5.1 UNK3CC6.1 UNK3CC7.1 UNK3CC8.1 UNK3CC9.1 UNK3CC12.1 UNK3CC13.1 UNK3CC14.1 UNK3CC15.1 UNK3CC16.1 UNK3CC130.1 UNK3K39.4 UNK3K39.5 UNK3K96.4 UNK3K96.9 UNK3TP_DPS1.1
CSDPS314P3: 3SA19.1 CSDPS314.B3 SITE3.G4(AVDD33_USB) SITE3.H12(AVDD33_ETH) UNK3CA34.1 UNK3CA35.1 UNK3CC182.1 UNK3CC202.1 UNK3TP_DPS4.1
CSDPS314P4: 3SA21.1 CSDPS314.C4 SITE3.D10(AVDD33_RTC) UNK3CA22.1 UNK3CA23.1 UNK3CC96.1 UNK3TP_DPS5.1
CSDPS314P5: 3SA17.1 CSDPS314.B5 SITE3.D5(VDDP18_P1) SITE3.D11(AVDD18_NODIE) SITE3.F4(AVDD18_USB) SITE3.F11(AVDD18_HSRAM) SITE3.H4(AVDD18_AUD) SITE3.J11(AVDD18_OTP) SITE3.J12(AVDD18_ETH) SITE3.K13(AVDD18_XTAL) SITE3.P10(VDD1_DRAM) SITE3.T5(AVDD18_PLL2_DDR) SITE3.T6(AVDD18_PLL_DDR) UNK3CA20.1 UNK3CA21.1 UNK3CC84.1 UNK3CC85.1 UNK3CC86.1 UNK3CC87.1 UNK3CC88.1 UNK3CC89.1 UNK3CC90.1 UNK3CC91.1 UNK3CC92.1 UNK3CC208.1 UNK3CC209.1 UNK3TP_DPS3.1
CSDPS314P6: CSDPS314.C6
CSDPS314P7: 3SA8.1 CSDPS314.B7 SITE3.F13(VDDP3318_PM) SITE3.L11(VDDP3318_P0) SITE3.M4(VDDP3318_P2) UNK3CA7.1 UNK3CA8.1 UNK3CC70.1 UNK3CC71.1 UNK3CC73.1 UNK3TP_DPS6.1
CSDPS314P8: CSDPS314.C8
CSDPS314P9: CSDPS314.B9
CSDPS314P10: CSDPS314.C10
CSDPS314P11: 3SA16.1 CSDPS314.B11 SITE3.E10(DVDD_NODIE) UNK3CA26.1 UNK3CA27.1 UNK3CC112.1 UNK3TP_DPS2.1
CSDPS314P12: CSDPS314.C12
CSDPS314P13: CSDPS314.B13
CSDPS314P14: 3SA9.1 CSDPS314.C14 SITE3.N10(VDD2_DRAM-01) SITE3.N11(VDD2_DRAM-02) SITE3.P11(VDD2_DRAM-03) SITE3.R8(VDDIO-01) SITE3.T7(VDDIO-02) SITE3.T8(VDDIO-03) SITE3.T9(VDDIO-04) UNK3CA24.1 UNK3CA25.1 UNK3CC101.1 UNK3CC103.1 UNK3CC105.1 UNK3CC107.1 UNK3CC203.1 UNK3CC204.1 UNK3CC205.1 UNK3TP_DPS7.1
CSDPS314P15: 3SA23.1 CSDPS314.B15 SITE3.N8(VDDQ_DRAM-01) SITE3.N9(VDDQ_DRAM-02) SITE3.P7(VDDQ-01) SITE3.P8(VDDQ-02) SITE3.P9(VDDQ_DRAM-03) SITE3.R7(VDDQ-03) UNK3CA36.1 UNK3CA37.1 UNK3CC210.1 UNK3CC211.1 UNK3CC212.1 UNK3CC213.1 UNK3CC215.1 UNK3CC216.1 UNK3TP_DPS8.1
CSDPS314P16: CSDPS314.C16
CSDPS314PS1: 3SA1.2 CSDPS314.A2 CSDPS314.D1
CSDPS314PS3: 3SA19.2 CSDPS314.D3
CSDPS314PS4: 3SA21.2 CSDPS314.A4
CSDPS314PS5: 3SA17.2 CSDPS314.D5
CSDPS314PS6: CSDPS314.A6
CSDPS314PS7: 3SA8.2 CSDPS314.D7
CSDPS314PS8: CSDPS314.A8
CSDPS314PS9: CSDPS314.D9
CSDPS314PS10: CSDPS314.A10
CSDPS314PS11: 3SA16.2 CSDPS314.D11
CSDPS314PS12: CSDPS314.A12
CSDPS314PS13: CSDPS314.D13
CSDPS314PS14: 3SA9.2 CSDPS314.A14
CSDPS314PS15: 3SA23.2 CSDPS314.D15
CSDPS314PS16: CSDPS314.A16
CSDPS319GS1: 5SA24.2 CSDPS319.D2
CSDPS319GS2: CSDPS319.A1
CSDPS319GS3: 5SA15.2 CSDPS319.D4
CSDPS319GS4: CSDPS319.A3
CSDPS319GS5: CSDPS319.D6
CSDPS319GS6: 5SA10.2 CSDPS319.A5
CSDPS319GS7: CSDPS319.D8
CSDPS319GS8: CSDPS319.A7
CSDPS319GS9: 5SA7.2 CSDPS319.D10
CSDPS319GS10: CSDPS319.A9
CSDPS319GS11: 5SA20.2 CSDPS319.D12
CSDPS319GS12: CSDPS319.A11
CSDPS319GS13: 5SA18.2 CSDPS319.D14
CSDPS319GS14: 5SA22.2 CSDPS319.A13
CSDPS319GS15: 5SA2.2 CSDPS319.A15 CSDPS319.D16
CSDPS319P1: 5SA23.1 CSDPS319.B1 SITE5.N8(VDDQ_DRAM-01) SITE5.N9(VDDQ_DRAM-02) SITE5.P7(VDDQ-01) SITE5.P8(VDDQ-02) SITE5.P9(VDDQ_DRAM-03) SITE5.R7(VDDQ-03) UNK5CA36.1 UNK5CA37.1 UNK5CC210.1 UNK5CC211.1 UNK5CC212.1 UNK5CC213.1 UNK5CC215.1 UNK5CC216.1 UNK5TP_DPS8.1
CSDPS319P2: CSDPS319.C2
CSDPS319P3: 5SA16.1 CSDPS319.B3 SITE5.E10(DVDD_NODIE) UNK5CA26.1 UNK5CA27.1 UNK5CC112.1 UNK5TP_DPS2.1
CSDPS319P4: CSDPS319.C4
CSDPS319P5: CSDPS319.B5
CSDPS319P6: 5SA9.1 CSDPS319.C6 SITE5.N10(VDD2_DRAM-01) SITE5.N11(VDD2_DRAM-02) SITE5.P11(VDD2_DRAM-03) SITE5.R8(VDDIO-01) SITE5.T7(VDDIO-02) SITE5.T8(VDDIO-03) SITE5.T9(VDDIO-04) UNK5CA24.1 UNK5CA25.1 UNK5CC101.1 UNK5CC103.1 UNK5CC105.1 UNK5CC107.1 UNK5CC203.1 UNK5CC204.1 UNK5CC205.1 UNK5TP_DPS7.1
CSDPS319P7: CSDPS319.B7
CSDPS319P8: CSDPS319.C8
CSDPS319P9: 5SA8.1 CSDPS319.B9 SITE5.F13(VDDP3318_PM) SITE5.L11(VDDP3318_P0) SITE5.M4(VDDP3318_P2) UNK5CA7.1 UNK5CA8.1 UNK5CC70.1 UNK5CC71.1 UNK5CC73.1 UNK5TP_DPS6.1
CSDPS319P10: CSDPS319.C10
CSDPS319P11: 5SA19.1 CSDPS319.B11 SITE5.G4(AVDD33_USB) SITE5.H12(AVDD33_ETH) UNK5CA34.1 UNK5CA35.1 UNK5CC182.1 UNK5CC202.1 UNK5TP_DPS4.1
CSDPS319P12: CSDPS319.C12
CSDPS319P13: 5SA17.1 CSDPS319.B13 SITE5.D5(VDDP18_P1) SITE5.D11(AVDD18_NODIE) SITE5.F4(AVDD18_USB) SITE5.F11(AVDD18_HSRAM) SITE5.H4(AVDD18_AUD) SITE5.J11(AVDD18_OTP) SITE5.J12(AVDD18_ETH) SITE5.K13(AVDD18_XTAL) SITE5.P10(VDD1_DRAM) SITE5.T5(AVDD18_PLL2_DDR) SITE5.T6(AVDD18_PLL_DDR) UNK5CA20.1 UNK5CA21.1 UNK5CC84.1 UNK5CC85.1 UNK5CC86.1 UNK5CC87.1 UNK5CC88.1 UNK5CC89.1 UNK5CC90.1 UNK5CC91.1 UNK5CC92.1 UNK5CC208.1 UNK5CC209.1 UNK5TP_DPS3.1
CSDPS319P14: 5SA21.1 CSDPS319.C14 SITE5.D10(AVDD33_RTC) UNK5CA22.1 UNK5CA23.1 UNK5CC96.1 UNK5TP_DPS5.1
CSDPS319P15: 5SA1.1 CSDPS319.B15 CSDPS319.C16 SITE5.E8(AVDDL_MIPIRX) SITE5.F6(VDD_CPU-01) SITE5.F8(VDD-01) SITE5.F9(VDD-02) SITE5.G6(VDD_CPU-02) SITE5.G8(VDD-03) SITE5.G9(VDD-04) SITE5.H6(VDD_CPU-03) SITE5.H7(VDD_CPU-04) SITE5.H9(VDD-05) SITE5.H10(VDD-06) SITE5.J8(VDD-07) SITE5.J9(VDD-08) SITE5.N5(DVDD_DDR_NNDRV) SITE5.P5(DVDD_DDR) UNK5CA1.1 UNK5CA2.1 UNK5CC1.1 UNK5CC2.1 UNK5CC3.1 UNK5CC4.1 UNK5CC5.1 UNK5CC6.1 UNK5CC7.1 UNK5CC8.1 UNK5CC9.1 UNK5CC12.1 UNK5CC13.1 UNK5CC14.1 UNK5CC15.1 UNK5CC16.1 UNK5CC130.1 UNK5K39.4 UNK5K39.5 UNK5K96.4 UNK5K96.9 UNK5TP_DPS1.1
CSDPS319PS1: 5SA23.2 CSDPS319.D1
CSDPS319PS2: CSDPS319.A2
CSDPS319PS3: 5SA16.2 CSDPS319.D3
CSDPS319PS4: CSDPS319.A4
CSDPS319PS5: CSDPS319.D5
CSDPS319PS6: 5SA9.2 CSDPS319.A6
CSDPS319PS7: CSDPS319.D7
CSDPS319PS8: CSDPS319.A8
CSDPS319PS9: 5SA8.2 CSDPS319.D9
CSDPS319PS10: CSDPS319.A10
CSDPS319PS11: 5SA19.2 CSDPS319.D11
CSDPS319PS12: CSDPS319.A12
CSDPS319PS13: 5SA17.2 CSDPS319.D13
CSDPS319PS14: 5SA21.2 CSDPS319.A14
CSDPS319PS15: 5SA1.2 CSDPS319.A16 CSDPS319.D15
CSDPS323GS1: 6SA24.2 CSDPS323.D2
CSDPS323GS2: CSDPS323.A1
CSDPS323GS3: 6SA15.2 CSDPS323.D4
CSDPS323GS4: CSDPS323.A3
CSDPS323GS5: CSDPS323.D6
CSDPS323GS6: 6SA10.2 CSDPS323.A5
CSDPS323GS7: CSDPS323.D8
CSDPS323GS8: CSDPS323.A7
CSDPS323GS9: 6SA7.2 CSDPS323.D10
CSDPS323GS10: CSDPS323.A9
CSDPS323GS11: 6SA20.2 CSDPS323.D12
CSDPS323GS12: CSDPS323.A11
CSDPS323GS13: 6SA18.2 CSDPS323.D14
CSDPS323GS14: 6SA22.2 CSDPS323.A13
CSDPS323GS15: 6SA2.2 CSDPS323.A15 CSDPS323.D16
CSDPS323P1: 6SA23.1 CSDPS323.B1 SITE6.N8(VDDQ_DRAM-01) SITE6.N9(VDDQ_DRAM-02) SITE6.P7(VDDQ-01) SITE6.P8(VDDQ-02) SITE6.P9(VDDQ_DRAM-03) SITE6.R7(VDDQ-03) UNK6CA36.1 UNK6CA37.1 UNK6CC210.1 UNK6CC211.1 UNK6CC212.1 UNK6CC213.1 UNK6CC215.1 UNK6CC216.1 UNK6TP_DPS8.1
CSDPS323P2: CSDPS323.C2
CSDPS323P3: 6SA16.1 CSDPS323.B3 SITE6.E10(DVDD_NODIE) UNK6CA26.1 UNK6CA27.1 UNK6CC112.1 UNK6TP_DPS2.1
CSDPS323P4: CSDPS323.C4
CSDPS323P5: CSDPS323.B5
CSDPS323P6: 6SA9.1 CSDPS323.C6 SITE6.N10(VDD2_DRAM-01) SITE6.N11(VDD2_DRAM-02) SITE6.P11(VDD2_DRAM-03) SITE6.R8(VDDIO-01) SITE6.T7(VDDIO-02) SITE6.T8(VDDIO-03) SITE6.T9(VDDIO-04) UNK6CA24.1 UNK6CA25.1 UNK6CC101.1 UNK6CC103.1 UNK6CC105.1 UNK6CC107.1 UNK6CC203.1 UNK6CC204.1 UNK6CC205.1 UNK6TP_DPS7.1
CSDPS323P7: CSDPS323.B7
CSDPS323P8: CSDPS323.C8
CSDPS323P9: 6SA8.1 CSDPS323.B9 SITE6.F13(VDDP3318_PM) SITE6.L11(VDDP3318_P0) SITE6.M4(VDDP3318_P2) UNK6CA7.1 UNK6CA8.1 UNK6CC70.1 UNK6CC71.1 UNK6CC73.1 UNK6TP_DPS6.1
CSDPS323P10: CSDPS323.C10
CSDPS323P11: 6SA19.1 CSDPS323.B11 SITE6.G4(AVDD33_USB) SITE6.H12(AVDD33_ETH) UNK6CA34.1 UNK6CA35.1 UNK6CC182.1 UNK6CC202.1 UNK6TP_DPS4.1
CSDPS323P12: CSDPS323.C12
CSDPS323P13: 6SA17.1 CSDPS323.B13 SITE6.D5(VDDP18_P1) SITE6.D11(AVDD18_NODIE) SITE6.F4(AVDD18_USB) SITE6.F11(AVDD18_HSRAM) SITE6.H4(AVDD18_AUD) SITE6.J11(AVDD18_OTP) SITE6.J12(AVDD18_ETH) SITE6.K13(AVDD18_XTAL) SITE6.P10(VDD1_DRAM) SITE6.T5(AVDD18_PLL2_DDR) SITE6.T6(AVDD18_PLL_DDR) UNK6CA20.1 UNK6CA21.1 UNK6CC84.1 UNK6CC85.1 UNK6CC86.1 UNK6CC87.1 UNK6CC88.1 UNK6CC89.1 UNK6CC90.1 UNK6CC91.1 UNK6CC92.1 UNK6CC208.1 UNK6CC209.1 UNK6TP_DPS3.1
CSDPS323P14: 6SA21.1 CSDPS323.C14 SITE6.D10(AVDD33_RTC) UNK6CA22.1 UNK6CA23.1 UNK6CC96.1 UNK6TP_DPS5.1
CSDPS323P15: 6SA1.1 CSDPS323.B15 CSDPS323.C16 SITE6.E8(AVDDL_MIPIRX) SITE6.F6(VDD_CPU-01) SITE6.F8(VDD-01) SITE6.F9(VDD-02) SITE6.G6(VDD_CPU-02) SITE6.G8(VDD-03) SITE6.G9(VDD-04) SITE6.H6(VDD_CPU-03) SITE6.H7(VDD_CPU-04) SITE6.H9(VDD-05) SITE6.H10(VDD-06) SITE6.J8(VDD-07) SITE6.J9(VDD-08) SITE6.N5(DVDD_DDR_NNDRV) SITE6.P5(DVDD_DDR) UNK6CA1.1 UNK6CA2.1 UNK6CC1.1 UNK6CC2.1 UNK6CC3.1 UNK6CC4.1 UNK6CC5.1 UNK6CC6.1 UNK6CC7.1 UNK6CC8.1 UNK6CC9.1 UNK6CC12.1 UNK6CC13.1 UNK6CC14.1 UNK6CC15.1 UNK6CC16.1 UNK6CC130.1 UNK6K39.4 UNK6K39.5 UNK6K96.4 UNK6K96.9 UNK6TP_DPS1.1
CSDPS323PS1: 6SA23.2 CSDPS323.D1
CSDPS323PS2: CSDPS323.A2
CSDPS323PS3: 6SA16.2 CSDPS323.D3
CSDPS323PS4: CSDPS323.A4
CSDPS323PS5: CSDPS323.D5
CSDPS323PS6: 6SA9.2 CSDPS323.A6
CSDPS323PS7: CSDPS323.D7
CSDPS323PS8: CSDPS323.A8
CSDPS323PS9: 6SA8.2 CSDPS323.D9
CSDPS323PS10: CSDPS323.A10
CSDPS323PS11: 6SA19.2 CSDPS323.D11
CSDPS323PS12: CSDPS323.A12
CSDPS323PS13: 6SA17.2 CSDPS323.D13
CSDPS323PS14: 6SA21.2 CSDPS323.A14
CSDPS323PS15: 6SA1.2 CSDPS323.A16 CSDPS323.D15
CSDPS426GS1: 2SA2.2 CSDPS426.A1 CSDPS426.D2
CSDPS426GS3: 2SA20.2 CSDPS426.D4
CSDPS426GS4: 2SA22.2 CSDPS426.A3
CSDPS426GS5: 2SA18.2 CSDPS426.D6
CSDPS426GS6: CSDPS426.A5
CSDPS426GS7: 2SA7.2 CSDPS426.D8
CSDPS426GS8: CSDPS426.A7
CSDPS426GS9: CSDPS426.D10
CSDPS426GS10: CSDPS426.A9
CSDPS426GS11: 2SA15.2 CSDPS426.D12
CSDPS426GS12: CSDPS426.A11
CSDPS426GS13: CSDPS426.D14
CSDPS426GS14: 2SA10.2 CSDPS426.A13
CSDPS426GS15: 2SA24.2 CSDPS426.D16
CSDPS426GS16: CSDPS426.A15
CSDPS426P1: 2SA1.1 CSDPS426.B1 CSDPS426.C2 SITE2.E8(AVDDL_MIPIRX) SITE2.F6(VDD_CPU-01) SITE2.F8(VDD-01) SITE2.F9(VDD-02) SITE2.G6(VDD_CPU-02) SITE2.G8(VDD-03) SITE2.G9(VDD-04) SITE2.H6(VDD_CPU-03) SITE2.H7(VDD_CPU-04) SITE2.H9(VDD-05) SITE2.H10(VDD-06) SITE2.J8(VDD-07) SITE2.J9(VDD-08) SITE2.N5(DVDD_DDR_NNDRV) SITE2.P5(DVDD_DDR) UNK2CA1.1 UNK2CA2.1 UNK2CC1.1 UNK2CC2.1 UNK2CC3.1 UNK2CC4.1 UNK2CC5.1 UNK2CC6.1 UNK2CC7.1 UNK2CC8.1 UNK2CC9.1 UNK2CC12.1 UNK2CC13.1 UNK2CC14.1 UNK2CC15.1 UNK2CC16.1 UNK2CC130.1 UNK2K39.4 UNK2K39.5 UNK2K96.4 UNK2K96.9 UNK2TP_DPS1.1
CSDPS426P3: 2SA19.1 CSDPS426.B3 SITE2.G4(AVDD33_USB) SITE2.H12(AVDD33_ETH) UNK2CA34.1 UNK2CA35.1 UNK2CC182.1 UNK2CC202.1 UNK2TP_DPS4.1
CSDPS426P4: 2SA21.1 CSDPS426.C4 SITE2.D10(AVDD33_RTC) UNK2CA22.1 UNK2CA23.1 UNK2CC96.1 UNK2TP_DPS5.1
CSDPS426P5: 2SA17.1 CSDPS426.B5 SITE2.D5(VDDP18_P1) SITE2.D11(AVDD18_NODIE) SITE2.F4(AVDD18_USB) SITE2.F11(AVDD18_HSRAM) SITE2.H4(AVDD18_AUD) SITE2.J11(AVDD18_OTP) SITE2.J12(AVDD18_ETH) SITE2.K13(AVDD18_XTAL) SITE2.P10(VDD1_DRAM) SITE2.T5(AVDD18_PLL2_DDR) SITE2.T6(AVDD18_PLL_DDR) UNK2CA20.1 UNK2CA21.1 UNK2CC84.1 UNK2CC85.1 UNK2CC86.1 UNK2CC87.1 UNK2CC88.1 UNK2CC89.1 UNK2CC90.1 UNK2CC91.1 UNK2CC92.1 UNK2CC208.1 UNK2CC209.1 UNK2TP_DPS3.1
CSDPS426P6: CSDPS426.C6
CSDPS426P7: 2SA8.1 CSDPS426.B7 SITE2.F13(VDDP3318_PM) SITE2.L11(VDDP3318_P0) SITE2.M4(VDDP3318_P2) UNK2CA7.1 UNK2CA8.1 UNK2CC70.1 UNK2CC71.1 UNK2CC73.1 UNK2TP_DPS6.1
CSDPS426P8: CSDPS426.C8
CSDPS426P9: CSDPS426.B9
CSDPS426P10: CSDPS426.C10
CSDPS426P11: 2SA16.1 CSDPS426.B11 SITE2.E10(DVDD_NODIE) UNK2CA26.1 UNK2CA27.1 UNK2CC112.1 UNK2TP_DPS2.1
CSDPS426P12: CSDPS426.C12
CSDPS426P13: CSDPS426.B13
CSDPS426P14: 2SA9.1 CSDPS426.C14 SITE2.N10(VDD2_DRAM-01) SITE2.N11(VDD2_DRAM-02) SITE2.P11(VDD2_DRAM-03) SITE2.R8(VDDIO-01) SITE2.T7(VDDIO-02) SITE2.T8(VDDIO-03) SITE2.T9(VDDIO-04) UNK2CA24.1 UNK2CA25.1 UNK2CC101.1 UNK2CC103.1 UNK2CC105.1 UNK2CC107.1 UNK2CC203.1 UNK2CC204.1 UNK2CC205.1 UNK2TP_DPS7.1
CSDPS426P15: 2SA23.1 CSDPS426.B15 SITE2.N8(VDDQ_DRAM-01) SITE2.N9(VDDQ_DRAM-02) SITE2.P7(VDDQ-01) SITE2.P8(VDDQ-02) SITE2.P9(VDDQ_DRAM-03) SITE2.R7(VDDQ-03) UNK2CA36.1 UNK2CA37.1 UNK2CC210.1 UNK2CC211.1 UNK2CC212.1 UNK2CC213.1 UNK2CC215.1 UNK2CC216.1 UNK2TP_DPS8.1
CSDPS426P16: CSDPS426.C16
CSDPS426PS1: 2SA1.2 CSDPS426.A2 CSDPS426.D1
CSDPS426PS3: 2SA19.2 CSDPS426.D3
CSDPS426PS4: 2SA21.2 CSDPS426.A4
CSDPS426PS5: 2SA17.2 CSDPS426.D5
CSDPS426PS6: CSDPS426.A6
CSDPS426PS7: 2SA8.2 CSDPS426.D7
CSDPS426PS8: CSDPS426.A8
CSDPS426PS9: CSDPS426.D9
CSDPS426PS10: CSDPS426.A10
CSDPS426PS11: 2SA16.2 CSDPS426.D11
CSDPS426PS12: CSDPS426.A12
CSDPS426PS13: CSDPS426.D13
CSDPS426PS14: 2SA9.2 CSDPS426.A14
CSDPS426PS15: 2SA23.2 CSDPS426.D15
CSDPS426PS16: CSDPS426.A16
CSDPS426WW: CSDPS426.B17
CSDPS426XX: CSDPS426.C17
CSDPS430GS1: CSDPS430.A1 CSDPS430.D2 SA2.2
CSDPS430GS3: CSDPS430.D4 SA20.2
CSDPS430GS4: CSDPS430.A3 SA22.2
CSDPS430GS5: CSDPS430.D6 SA18.2
CSDPS430GS6: CSDPS430.A5
CSDPS430GS7: CSDPS430.D8 SA7.2
CSDPS430GS8: CSDPS430.A7
CSDPS430GS9: CSDPS430.D10
CSDPS430GS10: CSDPS430.A9
CSDPS430GS11: CSDPS430.D12 SA15.2
CSDPS430GS12: CSDPS430.A11
CSDPS430GS13: CSDPS430.D14
CSDPS430GS14: CSDPS430.A13 SA10.2
CSDPS430GS15: CSDPS430.D16 SA24.2
CSDPS430GS16: CSDPS430.A15
CSDPS430P1: CA1.1 CA2.1 CC1.1 CC2.1 CC3.1 CC4.1 CC5.1 CC6.1 CC7.1 CC8.1 CC9.1 CC12.1 CC13.1 CC14.1 CC15.1 CC16.1 CC130.1 CSDPS430.B1 CSDPS430.C2 K39.4 K39.5 K96.4 K96.9 S1_DPS_SW1.1 S1_DPS_SW1.2 S1_DPS_SW1.3 S1_DPS_SW1.4 S1_DPS_SW1.5 S1_DPS_SW1.6 S1_DPS_SW1.7 S1_DPS_SW1.8 SA1.1 SITE1.E8(AVDDL_MIPIRX) SITE1.F6(VDD_CPU-01) SITE1.F8(VDD-01) SITE1.F9(VDD-02) SITE1.G6(VDD_CPU-02) SITE1.G8(VDD-03) SITE1.G9(VDD-04) SITE1.H6(VDD_CPU-03) SITE1.H7(VDD_CPU-04) SITE1.H9(VDD-05) SITE1.H10(VDD-06) SITE1.J8(VDD-07) SITE1.J9(VDD-08) SITE1.N5(DVDD_DDR_NNDRV) SITE1.P5(DVDD_DDR) TP_DPS1.1(TP)
CSDPS430P3: CA34.1 CA35.1 CC182.1 CC202.1 CSDPS430.B3 S1_DPS_SW2.1 S1_DPS_SW2.2 S1_DPS_SW2.3 S1_DPS_SW2.4 SA19.1 SITE1.G4(AVDD33_USB) SITE1.H12(AVDD33_ETH) SW5.10 TP_DPS4.1(TP)
CSDPS430P4: CA22.1 CA23.1 CC96.1 CSDPS430.C4 S1_DPS_SW2.5 S1_DPS_SW2.6 S1_DPS_SW2.7 S1_DPS_SW2.8 SA21.1 SITE1.D10(AVDD33_RTC) TP_DPS5.1(TP)
CSDPS430P5: CA20.1 CA21.1 CC84.1 CC85.1 CC86.1 CC87.1 CC88.1 CC89.1 CC90.1 CC91.1 CC92.1 CC208.1 CC209.1 CSDPS430.B5 S1_DPS_SW3.1 S1_DPS_SW3.2 S1_DPS_SW3.3 S1_DPS_SW3.4 S1_DPS_SW3.5 S1_DPS_SW3.6 S1_DPS_SW3.7 S1_DPS_SW3.8 SA17.1 SITE1.D5(VDDP18_P1) SITE1.D11(AVDD18_NODIE) SITE1.F4(AVDD18_USB) SITE1.F11(AVDD18_HSRAM) SITE1.H4(AVDD18_AUD) SITE1.J11(AVDD18_OTP) SITE1.J12(AVDD18_ETH) SITE1.K13(AVDD18_XTAL) SITE1.P10(VDD1_DRAM) SITE1.T5(AVDD18_PLL2_DDR) SITE1.T6(AVDD18_PLL_DDR) SW10.10 TP_DPS3.1(TP)
CSDPS430P6: CSDPS430.C6
CSDPS430P7: CA7.1 CA8.1 CC70.1 CC71.1 CC73.1 CSDPS430.B7 S1_DPS_SW5.1 S1_DPS_SW5.2 S1_DPS_SW5.3 S1_DPS_SW5.4 S1_DPS_SW5.5 S1_DPS_SW5.6 S1_DPS_SW5.7 S1_DPS_SW5.8 SA8.1 SITE1.F13(VDDP3318_PM) SITE1.L11(VDDP3318_P0) SITE1.M4(VDDP3318_P2) TP_DPS6.1(TP)
CSDPS430P8: CSDPS430.C8
CSDPS430P9: CSDPS430.B9
CSDPS430P10: CSDPS430.C10
CSDPS430P11: CA26.1 CA27.1 CC112.1 CSDPS430.B11 S1_DPS_SW6.1 S1_DPS_SW6.2 S1_DPS_SW6.3 S1_DPS_SW6.4 S1_DPS_SW6.5 S1_DPS_SW6.6 S1_DPS_SW6.7 S1_DPS_SW6.8 SA16.1 SITE1.E10(DVDD_NODIE) TP_DPS2.1(TP)
CSDPS430P12: CSDPS430.C12
CSDPS430P13: CSDPS430.B13
CSDPS430P14: CA24.1 CA25.1 CC101.1 CC103.1 CC105.1 CC107.1 CC203.1 CC204.1 CC205.1 CSDPS430.C14 S1_DPS_SW4.1 S1_DPS_SW4.2 S1_DPS_SW4.3 S1_DPS_SW4.4 SA9.1 SITE1.N10(VDD2_DRAM-01) SITE1.N11(VDD2_DRAM-02) SITE1.P11(VDD2_DRAM-03) SITE1.R8(VDDIO-01) SITE1.T7(VDDIO-02) SITE1.T8(VDDIO-03) SITE1.T9(VDDIO-04) TP_DPS7.1(TP)
CSDPS430P15: CA36.1 CA37.1 CC210.1 CC211.1 CC212.1 CC213.1 CC215.1 CC216.1 CSDPS430.B15 S1_DPS_SW4.5 S1_DPS_SW4.6 S1_DPS_SW4.7 S1_DPS_SW4.8 SA23.1 SITE1.N8(VDDQ_DRAM-01) SITE1.N9(VDDQ_DRAM-02) SITE1.P7(VDDQ-01) SITE1.P8(VDDQ-02) SITE1.P9(VDDQ_DRAM-03) SITE1.R7(VDDQ-03) TP_DPS8.1(TP)
CSDPS430P16: CSDPS430.C16
CSDPS430PS1: CSDPS430.A2 CSDPS430.D1 SA1.2
CSDPS430PS3: CSDPS430.D3 SA19.2
CSDPS430PS4: CSDPS430.A4 SA21.2
CSDPS430PS5: CSDPS430.D5 SA17.2
CSDPS430PS6: CSDPS430.A6
CSDPS430PS7: CSDPS430.D7 SA8.2
CSDPS430PS8: CSDPS430.A8
CSDPS430PS9: CSDPS430.D9
CSDPS430PS10: CSDPS430.A10
CSDPS430PS11: CSDPS430.D11 SA16.2
CSDPS430PS12: CSDPS430.A12
CSDPS430PS13: CSDPS430.D13
CSDPS430PS14: CSDPS430.A14 SA9.2
CSDPS430PS15: CSDPS430.D15 SA23.2
CSDPS430PS16: CSDPS430.A16
CSDPS430WW: CSDPS430.B17
CSDPS430XX: CSDPS430.C17
D231_MCB1_CT2: D231.17
D231_MCB1_E+: D231.16
D231_MCB1_E-: D231.15
D231_MCB1_EE+: D231.08
D231_MCB1_EE-: D231.07
D231_MCB1_F+: D231.14
D231_MCB1_F-: D231.13
D231_MCB1_FF+: D231.06
D231_MCB1_FF-: D231.05
D231_MCB1_G+: D231.12
D231_MCB1_G-: D231.11
D231_MCB1_GG+: D231.04
D231_MCB1_GG-: D231.03
D231_MCB1_H+: D231.10
D231_MCB1_H-: D231.09
D231_MCB1_HH+: D231.02
D231_MCB1_HH-: D231.01
D232_MCB1_CT2: D232.17
D232_MCB1_E+: D232.16
D232_MCB1_E-: D232.15
D232_MCB1_EE+: D232.08
D232_MCB1_EE-: D232.07
D232_MCB1_F+: D232.14
D232_MCB1_F-: D232.13
D232_MCB1_FF+: D232.06
D232_MCB1_FF-: D232.05
D232_MCB1_G+: D232.12
D232_MCB1_G-: D232.11
D232_MCB1_GG+: D232.04
D232_MCB1_GG-: D232.03
D232_MCB1_H+: D232.10
D232_MCB1_H-: D232.09
D232_MCB1_HH+: D232.02
D232_MCB1_HH-: D232.01
D431_MCB1_A+: D431.16 K109.3
D431_MCB1_A-: D431.15 K109.6
D431_MCB1_AA+: D431.08
D431_MCB1_AA-: D431.07
D431_MCB1_B+: D431.14 K110.3
D431_MCB1_B-: D431.13 K110.6
D431_MCB1_BB+: D431.06
D431_MCB1_BB-: D431.05
D431_MCB1_C+: D431.12 K111.3
D431_MCB1_C-: D431.11 K111.6
D431_MCB1_CC+: D431.04
D431_MCB1_CC-: D431.03
D431_MCB1_D+: D431.10 K112.3
D431_MCB1_D-: D431.09 K112.6
D431_MCB1_DD+: D431.02
D431_MCB1_DD-: D431.01
D432_MCB1_A+: D432.16
D432_MCB1_A-: D432.15
D432_MCB1_AA+: D432.08
D432_MCB1_AA-: D432.07
D432_MCB1_B+: D432.14
D432_MCB1_B-: D432.13
D432_MCB1_BB+: D432.06
D432_MCB1_BB-: D432.05
D432_MCB1_C+: D432.12
D432_MCB1_C-: D432.11
D432_MCB1_CC+: D432.04
D432_MCB1_CC-: D432.03
D432_MCB1_D+: D432.10
D432_MCB1_D-: D432.09
D432_MCB1_DD+: D432.02
D432_MCB1_DD-: D432.01
D10101: D101.01 UNK5K4.7
D10102: D101.02 UNK6K4.7
D10103: D101.03 UNK7K4.7
D10104: D101.04 UNK8K4.7
D10105: D101.05 UNK5K4.2
D10106: D101.06 UNK6K4.2
D10107: D101.07 UNK7K4.2
D10108: D101.08 UNK8K4.2
D10109: D101.09 UNK5K2.7
D10110: D101.10 UNK6K2.7
D10111: D101.11 UNK7K2.7
D10112: D101.12 UNK8K2.7
D10113: D101.13 UNK5K2.2
D10114: D101.14 UNK6K2.2
D10115: D101.15 UNK7K2.2
D10116: D101.16 UNK8K2.2
D10201: D102.01 SITE5.B10(PAD_PM_GPIO1)
D10202: D102.02 SITE6.B10(PAD_PM_GPIO1)
D10203: D102.03 SITE7.B10(PAD_PM_GPIO1)
D10204: D102.04 SITE8.B10(PAD_PM_GPIO1)
D10205: D102.05 SITE5.B9(PAD_PM_FUART_RX)
D10206: D102.06 SITE6.B9(PAD_PM_FUART_RX)
D10207: D102.07 SITE7.B9(PAD_PM_FUART_RX)
D10208: D102.08 SITE8.B9(PAD_PM_FUART_RX)
D10209: D102.09 SITE5.E6(PAD_SR_MCLK0)
D10210: D102.10 SITE6.E6(PAD_SR_MCLK0)
D10211: D102.11 SITE7.E6(PAD_SR_MCLK0)
D10212: D102.12 SITE8.E6(PAD_SR_MCLK0)
D10213: D102.13 UNK5K6.2
D10214: D102.14 UNK6K6.2
D10215: D102.15 UNK7K6.2
D10216: D102.16 UNK8K6.2
D10301: D103.01 SITE5.D16(PAD_PM_I2C_CLK)
D10302: D103.02 SITE6.D16(PAD_PM_I2C_CLK)
D10303: D103.03 SITE7.D16(PAD_PM_I2C_CLK)
D10304: D103.04 SITE8.D16(PAD_PM_I2C_CLK)
D10305: D103.05 SITE5.D15(PAD_PM_I2C_SDA)
D10306: D103.06 SITE6.D15(PAD_PM_I2C_SDA)
D10307: D103.07 SITE7.D15(PAD_PM_I2C_SDA)
D10308: D103.08 SITE8.D15(PAD_PM_I2C_SDA)
D10309: D103.09 SITE5.B15(PAD_PM_PWM0)
D10310: D103.10 SITE6.B15(PAD_PM_PWM0)
D10311: D103.11 SITE7.B15(PAD_PM_PWM0)
D10312: D103.12 SITE8.B15(PAD_PM_PWM0)
D10313: D103.13 SITE5.C14(PAD_PM_GPIO5)
D10314: D103.14 SITE6.C14(PAD_PM_GPIO5)
D10315: D103.15 SITE7.C14(PAD_PM_GPIO5)
D10316: D103.16 SITE8.C14(PAD_PM_GPIO5)
D10401: D104.01 SITE5.R15(PAD_MSPI_CK)
D10402: D104.02 SITE6.R15(PAD_MSPI_CK)
D10403: D104.03 SITE7.R15(PAD_MSPI_CK)
D10404: D104.04 SITE8.R15(PAD_MSPI_CK)
D10405: D104.05 SITE5.J15(PAD_PM_GPIO9)
D10406: D104.06 SITE6.J15(PAD_PM_GPIO9)
D10407: D104.07 SITE7.J15(PAD_PM_GPIO9)
D10408: D104.08 SITE8.J15(PAD_PM_GPIO9)
D10409: D104.09 SITE5.H13(PAD_PM_PSPI0_CK)
D10410: D104.10 SITE6.H13(PAD_PM_PSPI0_CK)
D10411: D104.11 SITE7.H13(PAD_PM_PSPI0_CK)
D10412: D104.12 SITE8.H13(PAD_PM_PSPI0_CK)
D10413: D104.13 SITE5.E15(PAD_PM_UART2_TX)
D10414: D104.14 SITE6.E15(PAD_PM_UART2_TX)
D10415: D104.15 SITE7.E15(PAD_PM_UART2_TX)
D10416: D104.16 SITE8.E15(PAD_PM_UART2_TX)
D10501: D105.01 UNK5U409.B8
D10502: D105.02 UNK6U409.B8
D10503: D105.03 UNK5U409.B9
D10504: D105.04 UNK6U409.B9
D10505: D105.05 UNK7U409.B8
D10506: D105.06 UNK8U409.B8
D10507: D105.07 UNK7U409.B9
D10508: D105.08 UNK8U409.B9
D10509: D105.09 UNK5U409.E8
D10510: D105.10 UNK6U409.E8
D10511: D105.11 UNK5U409.E9
D10512: D105.12 UNK6U409.E9
D10513: D105.13 UNK7U409.E8
D10514: D105.14 UNK8U409.E8
D10515: D105.15 UNK7U409.E9
D10516: D105.16 UNK8U409.E9
D10601: D106.01 UNK5U31.2
D10602: D106.02 UNK6U31.2
D10603: D106.03 UNK5U31.3
D10604: D106.04 UNK6U31.3
D10605: D106.05 UNK7U31.2
D10606: D106.06 UNK8U31.2
D10607: D106.07 UNK7U31.3
D10608: D106.08 UNK8U31.3
D10609: D106.09 SITE5.T3(PAD_SD0_D2)
D10610: D106.10 SITE6.T3(PAD_SD0_D2)
D10611: D106.11 SITE7.T3(PAD_SD0_D2)
D10612: D106.12 SITE8.T3(PAD_SD0_D2)
D10613: D106.13 SITE5.F5(PAD_I2C1_SDA)
D10614: D106.14 SITE6.F5(PAD_I2C1_SDA)
D10615: D106.15 SITE7.F5(PAD_I2C1_SDA)
D10616: D106.16 SITE8.F5(PAD_I2C1_SDA)
D10701: D107.01 SITE5.J3(PAD_AUD_MICIN1)
D10702: D107.02 SITE6.J3(PAD_AUD_MICIN1)
D10703: D107.03 SITE7.J3(PAD_AUD_MICIN1)
D10704: D107.04 SITE8.J3(PAD_AUD_MICIN1)
D10705: D107.05 SITE5.L3(PAD_GPIO4)
D10706: D107.06 SITE6.L3(PAD_GPIO4)
D10707: D107.07 SITE7.L3(PAD_GPIO4)
D10708: D107.08 SITE8.L3(PAD_GPIO4)
D10709: D107.09 SITE5.L2(PAD_GPIO0)
D10710: D107.10 SITE6.L2(PAD_GPIO0)
D10711: D107.11 SITE7.L2(PAD_GPIO0)
D10712: D107.12 SITE8.L2(PAD_GPIO0)
D10713: D107.13 SITE5.R2(PAD_SD0_D0)
D10714: D107.14 SITE6.R2(PAD_SD0_D0)
D10715: D107.15 SITE7.R2(PAD_SD0_D0)
D10716: D107.16 SITE8.R2(PAD_SD0_D0)
D10801: D108.01 UNK5U408.D8
D10802: D108.02 UNK6U408.D8
D10803: D108.03 UNK5U408.D9
D10804: D108.04 UNK6U408.D9
D10805: D108.05 UNK7U408.D8
D10806: D108.06 UNK8U408.D8
D10807: D108.07 UNK7U408.D9
D10808: D108.08 UNK8U408.D9
D10809: D108.09 UNK5K34.2
D10810: D108.10 UNK6K34.2
D10811: D108.11 UNK7K34.2
D10812: D108.12 UNK8K34.2
D10813: D108.13 SITE5.K3(PAD_GPIO3)
D10814: D108.14 SITE6.K3(PAD_GPIO3)
D10815: D108.15 SITE7.K3(PAD_GPIO3)
D10816: D108.16 SITE8.K3(PAD_GPIO3)
D10901: D109.01 SITE1.C13(PAD_PM_SAR3)
D10902: D109.02 SITE1.C11(PAD_PM_SDIO_D1)
D10903: D109.03
D10904: D109.04
D10905: D109.05 UNK3U450.3
D10906: D109.06 UNK4U451.4 UNK4U452.7
D10907: D109.07 UNK3R849.1 UNK3U450.1
D10908: D109.08 UNK4U451.3 UNK4U452.8
D10909: D109.09 UNK3R849.2 UNK3U450.2
D10910: D109.10 UNK4U450.4
D10911: D109.11 UNK3U450.4
D10912: D109.12 UNK4R849.2 UNK4U450.2
D10913: D109.13 UNK3U451.3 UNK3U452.8
D10914: D109.14 UNK4R849.1 UNK4U450.1
D10915: D109.15 UNK3U451.4 UNK3U452.7
D10916: D109.16 UNK4U450.3
D11001: D110.01 SITE1.J15(PAD_PM_GPIO9)
D11002: D110.02 SITE2.J15(PAD_PM_GPIO9)
D11003: D110.03 SITE3.J15(PAD_PM_GPIO9)
D11004: D110.04 SITE4.J15(PAD_PM_GPIO9)
D11005: D110.05 K34.2
D11006: D110.06 UNK2K34.2
D11007: D110.07 UNK3K34.2
D11008: D110.08 UNK4K34.2
D11009: D110.09 K2.2
D11010: D110.10 UNK2K2.2
D11011: D110.11 UNK3K2.2
D11012: D110.12 UNK4K2.2
D11013: D110.13 K6.2 SW10.5
D11014: D110.14 UNK2K6.2
D11015: D110.15 UNK3K6.2
D11016: D110.16 UNK4K6.2
D11101: D111.01 K2.7 SW10.1
D11102: D111.02 UNK2K2.7
D11103: D111.03 UNK3K2.7
D11104: D111.04 UNK4K2.7
D11105: D111.05 K4.7 SW10.2
D11106: D111.06 UNK2K4.7
D11107: D111.07 UNK3K4.7
D11108: D111.08 UNK4K4.7
D11109: D111.09 K6.7 SW10.3
D11110: D111.10 UNK2K6.7
D11111: D111.11 UNK3K6.7
D11112: D111.12 UNK4K6.7
D11113: D111.13 K4.2 SW10.4
D11114: D111.14 UNK2K4.2
D11115: D111.15 UNK3K4.2
D11116: D111.16 UNK4K4.2
D11201: D112.01 SITE1.H13(PAD_PM_PSPI0_CK)
D11202: D112.02 SITE2.H13(PAD_PM_PSPI0_CK)
D11203: D112.03 SITE3.H13(PAD_PM_PSPI0_CK)
D11204: D112.04 SITE4.H13(PAD_PM_PSPI0_CK)
D11205: D112.05 SITE1.E15(PAD_PM_UART2_TX)
D11206: D112.06 SITE2.E15(PAD_PM_UART2_TX)
D11207: D112.07 SITE3.E15(PAD_PM_UART2_TX)
D11208: D112.08 SITE4.E15(PAD_PM_UART2_TX)
D11209: D112.09 SITE1.E5(PAD_SR_MCLK1)
D11210: D112.10 SITE2.E5(PAD_SR_MCLK1)
D11211: D112.11 SITE3.E5(PAD_SR_MCLK1)
D11212: D112.12 SITE4.E5(PAD_SR_MCLK1)
D11213: D112.13 SITE1.E2(PAD_I2C1_SCL)
D11214: D112.14 SITE2.E2(PAD_I2C1_SCL)
D11215: D112.15 SITE3.E2(PAD_I2C1_SCL)
D11216: D112.16 SITE4.E2(PAD_I2C1_SCL)
D11301: D113.01
D11302: D113.02 RD19.1
D11303: D113.03 D431.17 D432.17
D11304: D113.04 RD20.1
D11305: D113.05 U450.3(MHL+)
D11306: D113.06 UNK2U451.4 UNK2U452.7
D11307: D113.07 R849.1 U450.1(USB+)
D11308: D113.08 UNK2U451.3 UNK2U452.8
D11309: D113.09 R849.2 U450.2(USB-)
D11310: D113.10 UNK2U450.4
D11311: D113.11 U450.4(MHL-)
D11312: D113.12 UNK2R849.2 UNK2U450.2
D11313: D113.13 U451.3(MHL+) U452.8(D+)
D11314: D113.14 UNK2R849.1 UNK2U450.1
D11315: D113.15 U451.4(MHL-) U452.7(D-)
D11316: D113.16 UNK2U450.3
D11401: D114.01 SITE1.D16(PAD_PM_I2C_CLK)
D11402: D114.02 SITE2.D16(PAD_PM_I2C_CLK)
D11403: D114.03 SITE3.D16(PAD_PM_I2C_CLK)
D11404: D114.04 SITE4.D16(PAD_PM_I2C_CLK)
D11405: D114.05 SITE1.D15(PAD_PM_I2C_SDA)
D11406: D114.06 SITE2.D15(PAD_PM_I2C_SDA)
D11407: D114.07 SITE3.D15(PAD_PM_I2C_SDA)
D11408: D114.08 SITE4.D15(PAD_PM_I2C_SDA)
D11409: D114.09 SITE1.B15(PAD_PM_PWM0)
D11410: D114.10 SITE2.B15(PAD_PM_PWM0)
D11411: D114.11 SITE3.B15(PAD_PM_PWM0)
D11412: D114.12 SITE4.B15(PAD_PM_PWM0)
D11413: D114.13 SITE1.C14(PAD_PM_GPIO5)
D11414: D114.14 SITE2.C14(PAD_PM_GPIO5)
D11415: D114.15 SITE3.C14(PAD_PM_GPIO5)
D11416: D114.16 SITE4.C14(PAD_PM_GPIO5)
D11501: D115.01 SITE1.B10(PAD_PM_GPIO1)
D11502: D115.02 SITE2.B10(PAD_PM_GPIO1)
D11503: D115.03 SITE3.B10(PAD_PM_GPIO1)
D11504: D115.04 SITE4.B10(PAD_PM_GPIO1)
D11505: D115.05 SITE1.B9(PAD_PM_FUART_RX)
D11506: D115.06 SITE2.B9(PAD_PM_FUART_RX)
D11507: D115.07 SITE3.B9(PAD_PM_FUART_RX)
D11508: D115.08 SITE4.B9(PAD_PM_FUART_RX)
D11509: D115.09 SITE1.E6(PAD_SR_MCLK0)
D11510: D115.10 SITE2.E6(PAD_SR_MCLK0)
D11511: D115.11 SITE3.E6(PAD_SR_MCLK0)
D11512: D115.12 SITE4.E6(PAD_SR_MCLK0)
D11513: D115.13 SITE1.C5(PAD_I2C2_SDA)
D11514: D115.14 SITE2.C5(PAD_I2C2_SDA)
D11515: D115.15 SITE3.C5(PAD_I2C2_SDA)
D11516: D115.16 SITE4.C5(PAD_I2C2_SDA)
D11601: D116.01 SITE1.E4(PAD_SR_RST0)
D11602: D116.02 SITE2.E4(PAD_SR_RST0)
D11603: D116.03 SITE3.E4(PAD_SR_RST0)
D11604: D116.04 SITE4.E4(PAD_SR_RST0)
D11605: D116.05 SITE1.K2(PAD_GPIO2)
D11606: D116.06 SITE2.K2(PAD_GPIO2)
D11607: D116.07 SITE3.K2(PAD_GPIO2)
D11608: D116.08 SITE4.K2(PAD_GPIO2)
D11609: D116.09 JP1.3 SITE1.F15(PAD_PM_UART_RX)
D11610: D116.10 SITE2.F15(PAD_PM_UART_RX)
D11611: D116.11 SITE3.F15(PAD_PM_UART_RX)
D11612: D116.12 SITE4.F15(PAD_PM_UART_RX)
D11613: D116.13 JP1.4 SITE1.F16(PAD_PM_UART_TX)
D11614: D116.14 SITE2.F16(PAD_PM_UART_TX)
D11615: D116.15 SITE3.F16(PAD_PM_UART_TX)
D11616: D116.16 SITE4.F16(PAD_PM_UART_TX)
D11701: D117.01 SITE3.A5(PAD_RTC_IO5)
D11702: D117.02 SITE3.B5(PAD_RTC_IO4)
D11703: D117.03 SITE4.C13(PAD_PM_SAR3)
D11704: D117.04 SITE4.C11(PAD_PM_SDIO_D1)
D11705: D117.05 UNK6U451.4 UNK6U452.7
D11706: D117.06 UNK5U450.4
D11707: D117.07 UNK6U451.3 UNK6U452.8
D11708: D117.08 UNK5R849.2 UNK5U450.2
D11709: D117.09 UNK6U450.3
D11710: D117.10 UNK5R849.1 UNK5U450.1
D11711: D117.11 UNK6R849.1 UNK6U450.1
D11712: D117.12 UNK5U450.3
D11713: D117.13 UNK6R849.2 UNK6U450.2
D11714: D117.14 UNK5U451.3 UNK5U452.8
D11715: D117.15 UNK6U450.4
D11716: D117.16 UNK5U451.4 UNK5U452.7
D11801: D118.01 SITE5.M14(PAD_PM_GPIO11)
D11802: D118.02 SITE6.M14(PAD_PM_GPIO11)
D11803: D118.03 SITE7.M14(PAD_PM_GPIO11)
D11804: D118.04 SITE8.M14(PAD_PM_GPIO11)
D11805: D118.05 SITE5.J14(PAD_PM_GPIO10)
D11806: D118.06 SITE6.J14(PAD_PM_GPIO10)
D11807: D118.07 SITE7.J14(PAD_PM_GPIO10)
D11808: D118.08 SITE8.J14(PAD_PM_GPIO10)
D11809: D118.09 SITE5.G13(PAD_PM_PSPI0_CZ)
D11810: D118.10 SITE6.G13(PAD_PM_PSPI0_CZ)
D11811: D118.11 SITE7.G13(PAD_PM_PSPI0_CZ)
D11812: D118.12 SITE8.G13(PAD_PM_PSPI0_CZ)
D11813: D118.13 SITE5.C15(PAD_PM_PWM1)
D11814: D118.14 SITE6.C15(PAD_PM_PWM1)
D11815: D118.15 SITE7.C15(PAD_PM_PWM1)
D11816: D118.16 SITE8.C15(PAD_PM_PWM1)
D11901: D119.01 SITE5.A15(PAD_PM_GPIO6)
D11902: D119.02 SITE6.A15(PAD_PM_GPIO6)
D11903: D119.03 SITE7.A15(PAD_PM_GPIO6)
D11904: D119.04 SITE8.A15(PAD_PM_GPIO6)
D11905: D119.05 SITE5.B14(PAD_PM_GPIO4)
D11906: D119.06 SITE6.B14(PAD_PM_GPIO4)
D11907: D119.07 SITE7.B14(PAD_PM_GPIO4)
D11908: D119.08 SITE8.B14(PAD_PM_GPIO4)
D11909: D119.09 SITE5.C12(PAD_PM_GPIO2)
D11910: D119.10 SITE6.C12(PAD_PM_GPIO2)
D11911: D119.11 SITE7.C12(PAD_PM_GPIO2)
D11912: D119.12 SITE8.C12(PAD_PM_GPIO2)
D11913: D119.13 SITE5.A10(PAD_PM_GPIO3)
D11914: D119.14 SITE6.A10(PAD_PM_GPIO3)
D11915: D119.15 SITE7.A10(PAD_PM_GPIO3)
D11916: D119.16 SITE8.A10(PAD_PM_GPIO3)
D12001: D120.01 SITE5.C5(PAD_I2C2_SDA)
D12002: D120.02 SITE6.C5(PAD_I2C2_SDA)
D12003: D120.03 SITE7.C5(PAD_I2C2_SDA)
D12004: D120.04 SITE8.C5(PAD_I2C2_SDA)
D12005: D120.05 UNK5K6.7
D12006: D120.06 UNK6K6.7
D12007: D120.07 UNK7K6.7
D12008: D120.08 UNK8K6.7
D12009: D120.09 UNK5U408.E8
D12010: D120.10 UNK6U408.E8
D12011: D120.11 UNK5U408.E9
D12012: D120.12 UNK6U408.E9
D12013: D120.13 UNK7U408.E8
D12014: D120.14 UNK8U408.E8
D12015: D120.15 UNK7U408.E9
D12016: D120.16 UNK8U408.E9
D12101: D121.01 SITE4.C8(PAD_RESET)
D12102: D121.02 SITE4.A5(PAD_RTC_IO5)
D12103: D121.03 SITE4.C9(PAD_PM_FUART_CTS)
D12104: D121.04 SITE4.B5(PAD_RTC_IO4)
D12105: D121.05 UNK8U451.4 UNK8U452.7
D12106: D121.06 UNK7U450.4
D12107: D121.07 UNK8U451.3 UNK8U452.8
D12108: D121.08 UNK7R849.2 UNK7U450.2
D12109: D121.09 UNK8U450.3
D12110: D121.10 UNK7R849.1 UNK7U450.1
D12111: D121.11 UNK8R849.1 UNK8U450.1
D12112: D121.12 UNK7U450.3
D12113: D121.13 UNK8R849.2 UNK8U450.2
D12114: D121.14 UNK7U451.3 UNK7U452.8
D12115: D121.15 UNK8U450.4
D12116: D121.16 UNK7U451.4 UNK7U452.7
D12201: D122.01 SITE5.R3(PAD_SD0_D3)
D12202: D122.02 SITE6.R3(PAD_SD0_D3)
D12203: D122.03 SITE7.R3(PAD_SD0_D3)
D12204: D122.04 SITE8.R3(PAD_SD0_D3)
D12205: D122.05 SITE5.T4(PAD_SD0_CDZ)
D12206: D122.06 SITE6.T4(PAD_SD0_CDZ)
D12207: D122.07 SITE7.T4(PAD_SD0_CDZ)
D12208: D122.08 SITE8.T4(PAD_SD0_CDZ)
D12209: D122.09 SITE5.P13(PAD_FUART_TX)
D12210: D122.10 SITE6.P13(PAD_FUART_TX)
D12211: D122.11 SITE7.P13(PAD_FUART_TX)
D12212: D122.12 SITE8.P13(PAD_FUART_TX)
D12213: D122.13 SITE5.T14(PAD_I2C0_SCL)
D12214: D122.14 SITE6.T14(PAD_I2C0_SCL)
D12215: D122.15 SITE7.T14(PAD_I2C0_SCL)
D12216: D122.16 SITE8.T14(PAD_I2C0_SCL)
D12301: D123.01 SITE5.N2(PAD_GPIO9)
D12302: D123.02 SITE6.N2(PAD_GPIO9)
D12303: D123.03 SITE7.N2(PAD_GPIO9)
D12304: D123.04 SITE8.N2(PAD_GPIO9)
D12305: D123.05 SITE5.P1(PAD_GPIO11)
D12306: D123.06 SITE6.P1(PAD_GPIO11)
D12307: D123.07 SITE7.P1(PAD_GPIO11)
D12308: D123.08 SITE8.P1(PAD_GPIO11)
D12309: D123.09 SITE5.R1(PAD_SD0_D1)
D12310: D123.10 SITE6.R1(PAD_SD0_D1)
D12311: D123.11 SITE7.R1(PAD_SD0_D1)
D12312: D123.12 SITE8.R1(PAD_SD0_D1)
D12313: D123.13 SITE5.T2(PAD_SD0_CLK)
D12314: D123.14 SITE6.T2(PAD_SD0_CLK)
D12315: D123.15 SITE7.T2(PAD_SD0_CLK)
D12316: D123.16 SITE8.T2(PAD_SD0_CLK)
D12401: D124.01 SITE5.E5(PAD_SR_MCLK1)
D12402: D124.02 SITE6.E5(PAD_SR_MCLK1)
D12403: D124.03 SITE7.E5(PAD_SR_MCLK1)
D12404: D124.04 SITE8.E5(PAD_SR_MCLK1)
D12405: D124.05 SITE5.E2(PAD_I2C1_SCL)
D12406: D124.06 SITE6.E2(PAD_I2C1_SCL)
D12407: D124.07 SITE7.E2(PAD_I2C1_SCL)
D12408: D124.08 SITE8.E2(PAD_I2C1_SCL)
D12409: D124.09 SITE5.E4(PAD_SR_RST0)
D12410: D124.10 SITE6.E4(PAD_SR_RST0)
D12411: D124.11 SITE7.E4(PAD_SR_RST0)
D12412: D124.12 SITE8.E4(PAD_SR_RST0)
D12413: D124.13 SITE5.K2(PAD_GPIO2)
D12414: D124.14 SITE6.K2(PAD_GPIO2)
D12415: D124.15 SITE7.K2(PAD_GPIO2)
D12416: D124.16 SITE8.K2(PAD_GPIO2)
D12501: D125.01 SITE1.C16(PAD_PM_SDIO_INT)
D12502: C270.1 D125.02 SITE1.H1(PAD_AUD_VRP_ADC)
D12503: D125.03 SITE1.E13(PAD_PM_SDIO_D0)
D12504: D125.04 SITE1.D12(PAD_PM_SDIO_D2)
D12505: D125.05 SITE1.L14(PAD_PM_GPIO12)
D12506: D125.06 SITE1.B11(PAD_PM_SDIO_CMD)
D12507: CC194.1 D125.07 SITE1.L10(VDDP18_P0_CAP)
D12508: D125.08 SITE1.E12(PAD_PM_SDIO_D3)
D12509: D125.09 K32.7
D12510: D125.10 SITE1.C8(PAD_RESET) SW5.6
D12511: D125.11 SITE1.G3(PAD_AUD_LINEOUT_R0)
D12512: D125.12 SITE1.A8(PAD_PM_FUART_RTS)
D12513: D125.13 SITE1.C7(PAD_RTC_IO1)
D12514: D125.14 K39.2
D12515: D125.15 SITE1.B7(PAD_RTC_IO0)
D12516: D125.16 K39.7
D12601: D126.01 UNK2K39.7
D12602: D126.02 K113.6(NO)
D12603: D126.03 UNK2K39.2
D12604: D126.04 K32.2
D12605: D126.05 SITE2.A8(PAD_PM_FUART_RTS)
D12606: D126.06 SITE1.B16(PAD_PM_PWM3)
D12607: D126.07 SITE2.E12(PAD_PM_SDIO_D3)
D12608: D126.08 SITE1.D13(PAD_PM_SDIO_CLK)
D12609: D126.09 SITE2.B11(PAD_PM_SDIO_CMD)
D12610: D126.10 SITE1.B13(PAD_PM_SAR2)
D12611: D126.11 SITE2.D12(PAD_PM_SDIO_D2)
D12612: D126.12 SITE1.A13(PAD_PM_SAR4)
D12613: D126.13 SITE2.H1(PAD_AUD_VRP_ADC) UNK2C270.1
D12614: D126.14 U449.3(MHL+)
D12615: D126.15 U449.4(MHL-)
D12616: D126.16 SITE1.A12(PAD_PM_SAR1)
D12701: D127.01 SITE2.A12(PAD_PM_SAR1)
D12702: D127.02 SITE2.B7(PAD_RTC_IO0)
D12703: D127.03 SITE2.A13(PAD_PM_SAR4)
D12704: D127.04 SITE2.C7(PAD_RTC_IO1)
D12705: D127.05 SITE2.B13(PAD_PM_SAR2)
D12706: D127.06 SITE2.G3(PAD_AUD_LINEOUT_R0)
D12707: D127.07 SITE2.D13(PAD_PM_SDIO_CLK)
D12708: D127.08 UNK2K32.7
D12709: D127.09 SITE2.B16(PAD_PM_PWM3)
D12710: D127.10 SITE2.L10(VDDP18_P0_CAP) UNK2CC194.1
D12711: D127.11 UNK2K32.2
D12712: D127.12 SITE2.L14(PAD_PM_GPIO12)
D12713: D127.13 UNK2K113.6
D12714: D127.14 SITE2.D14(PAD_PM_PWM2)
D12715: D127.15 SITE2.C16(PAD_PM_SDIO_INT)
D12716: D127.16 SITE2.E13(PAD_PM_SDIO_D0)
D12801: D128.01 SITE3.C8(PAD_RESET)
D12802: D128.02 UNK2U449.3
D12803: D128.03 SITE3.C9(PAD_PM_FUART_CTS)
D12804: D128.04 UNK2U449.4
D12805: D128.05 SITE3.C11(PAD_PM_SDIO_D1)
D12806: D128.06 SITE1.D14(PAD_PM_PWM2)
D12807: D128.07 SITE3.C13(PAD_PM_SAR3)
D12808: D128.08 SITE1.C9(PAD_PM_FUART_CTS)
D12809: D128.09 SITE2.B5(PAD_RTC_IO4)
D12810: D128.10 SITE1.A5(PAD_RTC_IO5)
D12811: D128.11 SITE2.A5(PAD_RTC_IO5)
D12812: D128.12 SITE1.B5(PAD_RTC_IO4)
D12813: D128.13 SITE2.C9(PAD_PM_FUART_CTS)
D12814: D128.14 SITE2.C13(PAD_PM_SAR3)
D12815: D128.15 SITE2.C8(PAD_RESET)
D12816: D128.16 SITE2.C11(PAD_PM_SDIO_D1)
D12901: D129.01 UNK5U408.B8
D12902: D129.02 UNK6U408.B8
D12903: D129.03 UNK5U408.B9
D12904: D129.04 UNK6U408.B9
D12905: D129.05 UNK7U408.B8
D12906: D129.06 UNK8U408.B8
D12907: D129.07 UNK7U408.B9
D12908: D129.08 UNK8U408.B9
D12909: D129.09 UNK5U409.D8
D12910: D129.10 UNK6U409.D8
D12911: D129.11 UNK5U409.D9
D12912: D129.12 UNK6U409.D9
D12913: D129.13 UNK7U409.D8
D12914: D129.14 UNK8U409.D8
D12915: D129.15 UNK7U409.D9
D12916: D129.16 UNK8U409.D9
D13001: D130.01 SITE5.B8(PAD_PM_FUART_TX)
D13002: D130.02 SITE6.B8(PAD_PM_FUART_TX)
D13003: D130.03 SITE7.B8(PAD_PM_FUART_TX)
D13004: D130.04 SITE8.B8(PAD_PM_FUART_TX)
D13005: D130.05 SITE5.B4(PAD_I2C2_SCL)
D13006: D130.06 SITE6.B4(PAD_I2C2_SCL)
D13007: D130.07 SITE7.B4(PAD_I2C2_SCL)
D13008: D130.08 SITE8.B4(PAD_I2C2_SCL)
D13009: D130.09 SITE5.E3(PAD_SR_RST1)
D13010: D130.10 SITE6.E3(PAD_SR_RST1)
D13011: D130.11 SITE7.E3(PAD_SR_RST1)
D13012: D130.12 SITE8.E3(PAD_SR_RST1)
D13013: D130.13 SITE5.J2(PAD_AUD_MICIN0)
D13014: D130.14 SITE6.J2(PAD_AUD_MICIN0)
D13015: D130.15 SITE7.J2(PAD_AUD_MICIN0)
D13016: D130.16 SITE8.J2(PAD_AUD_MICIN0)
D13101: D131.01 SITE5.K1(PAD_GPIO1)
D13102: D131.02 SITE6.K1(PAD_GPIO1)
D13103: D131.03 SITE7.K1(PAD_GPIO1)
D13104: D131.04 SITE8.K1(PAD_GPIO1)
D13105: D131.05 SITE5.M1(PAD_GPIO8)
D13106: D131.06 SITE6.M1(PAD_GPIO8)
D13107: D131.07 SITE7.M1(PAD_GPIO8)
D13108: D131.08 SITE8.M1(PAD_GPIO8)
D13109: D131.09 SITE5.M3(PAD_GPIO6)
D13110: D131.10 SITE6.M3(PAD_GPIO6)
D13111: D131.11 SITE7.M3(PAD_GPIO6)
D13112: D131.12 SITE8.M3(PAD_GPIO6)
D13113: D131.13 SITE5.R12(PAD_FUART_RTS)
D13114: D131.14 SITE6.R12(PAD_FUART_RTS)
D13115: D131.15 SITE7.R12(PAD_FUART_RTS)
D13116: D131.16 SITE8.R12(PAD_FUART_RTS)
D13201: D132.01 SITE5.H2(PAD_AUD_VAG) UNK5C264.1
D13202: D132.02 SITE6.H2(PAD_AUD_VAG) UNK6C264.1
D13203: D132.03 SITE7.H2(PAD_AUD_VAG) UNK7C264.1
D13204: D132.04 SITE8.H2(PAD_AUD_VAG) UNK8C264.1
D13205: D132.05 SITE5.R13(PAD_FUART_RX)
D13206: D132.06 SITE6.R13(PAD_FUART_RX)
D13207: D132.07 SITE7.R13(PAD_FUART_RX)
D13208: D132.08 SITE8.R13(PAD_FUART_RX)
D13209: D132.09 SITE5.T13(PAD_FUART_CTS)
D13210: D132.10 SITE6.T13(PAD_FUART_CTS)
D13211: D132.11 SITE7.T13(PAD_FUART_CTS)
D13212: D132.12 SITE8.T13(PAD_FUART_CTS)
D13213: D132.13 SITE5.P14(PAD_I2C0_SDA)
D13214: D132.14 SITE6.P14(PAD_I2C0_SDA)
D13215: D132.15 SITE7.P14(PAD_I2C0_SDA)
D13216: D132.16 SITE8.P14(PAD_I2C0_SDA)
D20101: D201.01 SITE5.F16(PAD_PM_UART_TX)
D20102: D201.02 SITE6.F16(PAD_PM_UART_TX)
D20103: D201.03 SITE7.F16(PAD_PM_UART_TX)
D20104: D201.04 SITE8.F16(PAD_PM_UART_TX)
D20105: D201.05 SITE5.F15(PAD_PM_UART_RX)
D20106: D201.06 SITE6.F15(PAD_PM_UART_RX)
D20107: D201.07 SITE7.F15(PAD_PM_UART_RX)
D20108: D201.08 SITE8.F15(PAD_PM_UART_RX)
D20109: D201.09 SITE5.E11(PAD_PM_GPIO8)
D20110: D201.10 SITE6.E11(PAD_PM_GPIO8)
D20111: D201.11 SITE7.E11(PAD_PM_GPIO8)
D20112: D201.12 SITE8.E11(PAD_PM_GPIO8)
D20113: D201.13 SITE5.C10(PAD_PM_GPIO0)
D20114: D201.14 SITE6.C10(PAD_PM_GPIO0)
D20115: D201.15 SITE7.C10(PAD_PM_GPIO0)
D20116: D201.16 SITE8.C10(PAD_PM_GPIO0)
D20201: D202.01 SITE5.G12(PAD_PM_PSPI0_DI)
D20202: D202.02 SITE6.G12(PAD_PM_PSPI0_DI)
D20203: D202.03 SITE7.G12(PAD_PM_PSPI0_DI)
D20204: D202.04 SITE8.G12(PAD_PM_PSPI0_DI)
D20205: D202.05 SITE5.F12(PAD_PM_PSPI0_INT)
D20206: D202.06 SITE6.F12(PAD_PM_PSPI0_INT)
D20207: D202.07 SITE7.F12(PAD_PM_PSPI0_INT)
D20208: D202.08 SITE8.F12(PAD_PM_PSPI0_INT)
D20209: D202.09 SITE5.F14(PAD_PM_GPIO7)
D20210: D202.10 SITE6.F14(PAD_PM_GPIO7)
D20211: D202.11 SITE7.F14(PAD_PM_GPIO7)
D20212: D202.12 SITE8.F14(PAD_PM_GPIO7)
D20213: D202.13 SITE5.E14(PAD_PM_UART2_RX)
D20214: D202.14 SITE6.E14(PAD_PM_UART2_RX)
D20215: D202.15 SITE7.E14(PAD_PM_UART2_RX)
D20216: D202.16 SITE8.E14(PAD_PM_UART2_RX)
D20301: D203.01 SITE5.T15(PAD_MSPI_DO)
D20302: D203.02 SITE6.T15(PAD_MSPI_DO)
D20303: D203.03 SITE7.T15(PAD_MSPI_DO)
D20304: D203.04 SITE8.T15(PAD_MSPI_DO)
D20305: D203.05 SITE5.R16(PAD_MSPI_CZ)
D20306: D203.06 SITE6.R16(PAD_MSPI_CZ)
D20307: D203.07 SITE7.R16(PAD_MSPI_CZ)
D20308: D203.08 SITE8.R16(PAD_MSPI_CZ)
D20309: D203.09 SITE5.R14(PAD_MSPI_DI)
D20310: D203.10 SITE6.R14(PAD_MSPI_DI)
D20311: D203.11 SITE7.R14(PAD_MSPI_DI)
D20312: D203.12 SITE8.R14(PAD_MSPI_DI)
D20313: D203.13 SITE5.G11(PAD_PM_PSPI0_DO)
D20314: D203.14 SITE6.G11(PAD_PM_PSPI0_DO)
D20315: D203.15 SITE7.G11(PAD_PM_PSPI0_DO)
D20316: D203.16 SITE8.G11(PAD_PM_PSPI0_DO)
D20401: D204.01 SITE5.M2(PAD_GPIO5)
D20402: D204.02 SITE6.M2(PAD_GPIO5)
D20403: D204.03 SITE7.M2(PAD_GPIO5)
D20404: D204.04 SITE8.M2(PAD_GPIO5)
D20405: D204.05 SITE5.N3(PAD_GPIO7)
D20406: D204.06 SITE6.N3(PAD_GPIO7)
D20407: D204.07 SITE7.N3(PAD_GPIO7)
D20408: D204.08 SITE8.N3(PAD_GPIO7)
D20409: D204.09 SITE5.P2(PAD_GPIO10)
D20410: D204.10 SITE6.P2(PAD_GPIO10)
D20411: D204.11 SITE7.P2(PAD_GPIO10)
D20412: D204.12 SITE8.P2(PAD_GPIO10)
D20413: D204.13 SITE5.P3(PAD_SD0_CMD)
D20414: D204.14 SITE6.P3(PAD_SD0_CMD)
D20415: D204.15 SITE7.P3(PAD_SD0_CMD)
D20416: D204.16 SITE8.P3(PAD_SD0_CMD)
D20501: D205.01 UNK4K113.6
D20502: D205.02 SITE4.B16(PAD_PM_PWM3)
D20503: D205.03 SITE4.C16(PAD_PM_SDIO_INT)
D20504: D205.04 UNK4K32.2
D20505: D205.05 SITE4.D14(PAD_PM_PWM2)
D20506: D205.06 SITE4.D13(PAD_PM_SDIO_CLK)
D20507: D205.07 SITE4.E13(PAD_PM_SDIO_D0)
D20508: D205.08 SITE4.B13(PAD_PM_SAR2)
D20509: D205.09 SITE4.L14(PAD_PM_GPIO12)
D20510: D205.10 SITE4.A13(PAD_PM_SAR4)
D20511: D205.11 SITE4.L10(VDDP18_P0_CAP) UNK4CC194.1
D20512: D205.12 SITE4.A12(PAD_PM_SAR1)
D20513: D205.13 UNK4K32.7
D20514: D205.14 UNK4U449.3
D20515: D205.15 SITE4.G3(PAD_AUD_LINEOUT_R0)
D20516: D205.16 UNK4U449.4
D20601: D206.01 SITE4.H1(PAD_AUD_VRP_ADC) UNK4C270.1
D20602: D206.02 SITE4.B11(PAD_PM_SDIO_CMD)
D20603: D206.03 UNK3U449.4
D20604: D206.04 SITE4.D12(PAD_PM_SDIO_D2)
D20605: D206.05 UNK3U449.3
D20606: D206.06 SITE4.E12(PAD_PM_SDIO_D3)
D20607: D206.07 SITE3.A12(PAD_PM_SAR1)
D20608: D206.08 SITE4.A8(PAD_PM_FUART_RTS)
D20609: D206.09 SITE3.A13(PAD_PM_SAR4)
D20610: D206.10 UNK4K39.2
D20611: D206.11 SITE3.B13(PAD_PM_SAR2)
D20612: D206.12 UNK4K39.7
D20613: D206.13 SITE3.D13(PAD_PM_SDIO_CLK)
D20614: D206.14 SITE4.B7(PAD_RTC_IO0)
D20615: D206.15 SITE3.B16(PAD_PM_PWM3)
D20616: D206.16 SITE4.C7(PAD_RTC_IO1)
D20701: D207.01 SITE3.G3(PAD_AUD_LINEOUT_R0)
D20702: D207.02 SITE3.L10(VDDP18_P0_CAP) UNK3CC194.1
D20703: D207.03 SITE3.C7(PAD_RTC_IO1)
D20704: D207.04 UNK3K32.7
D20705: D207.05 SITE3.B7(PAD_RTC_IO0)
D20706: D207.06 SITE3.L14(PAD_PM_GPIO12)
D20707: D207.07 UNK3K39.7
D20708: D207.08 SITE3.E13(PAD_PM_SDIO_D0)
D20709: D207.09 UNK3K39.2
D20710: D207.10 SITE3.D14(PAD_PM_PWM2)
D20711: D207.11 SITE3.A8(PAD_PM_FUART_RTS)
