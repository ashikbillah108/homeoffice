# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S7_OUT_RX0_CH0_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(297.22,192.07) 297.05,192.24
  L21_SIGNAL w0.105: 297.05,192.24 297.05,193.92 297.17,194.04 298.32,194.04 298.53,193.83 298.53,193.13 299.24,192.41 300.27,192.41 300.37,192.31 300.37,192.15 300.48,192.05 300.69,192.05 300.79,192.15 300.79,192.31 300.9,192.41 301.1,192.41 301.21,192.31 301.21,192.15 301.31,192.05 301.52,192.05 301.63,192.15 301.63,192.31 301.73,192.41 301.94,192.41 302.05,192.31 302.05,192.15 302.15,192.05 302.36,192.05 302.47,192.15 302.47,192.31 302.57,192.41 305.65,192.41 307.25,190.81 v2(307.25,189.51)
  BOTTOM w0.132: UNK7U408.B2 295,190.88 296.57,190.88 297.06,191.37 297.06,191.91 v2(297.22,192.07)
S7_OUT_RX0_CH0_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 307.62,189.81 307.62,189.03 307.58,188.99 307.58,188.72 307.9,188.4 v2(307.9,188.21)
  L21_SIGNAL w0.102: v2(296.51,192.07) 296.68,192.24
  L21_SIGNAL w0.105: 307.62,189.81 307.62,190.96 305.81,192.78 299.4,192.78 298.89,193.28 298.89,193.98 298.47,194.41 297.02,194.41 296.68,194.08 296.68,192.24
  BOTTOM w0.132: UNK7U408.B1 295.19,191.25 296.41,191.25 296.68,191.52 296.68,191.9 v2(296.51,192.07)
S7_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK7R647.1 295.3,193.77 295.3,193.05 294.94,192.7 294.44,192.7 294.15,192.41 294.15,191.71 UNK7U408.B4
S7_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK7R646.1 294.46,193.86 294.38,193.78 294.38,193.57 294.45,193.5 294.81,193.5 294.92,193.38 294.92,193.21 294.79,193.07 294.28,193.07 293.78,192.57 293.78,191.83 UNK7U408.A4
S7_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK7R647.2 UNK7R646.2 UNK7C309.1
S7_OUT_RX0_CH1_ABC_CASE+: length 20.2
  L19_SIGNAL w0.102: v2(297.22,189.36) 297.05,189.19
  L19_SIGNAL w0.105: v2(306.6,189.51) 305.92,190.19 305,190.19 304.85,190.33 304.57,190.33 304.43,190.19 302.88,190.19 302.59,190.47 302.59,192.13 302.05,192.67 299.22,192.67 298.57,192.02 298.57,188.82 298.01,188.26 297.36,188.26 297.05,188.58 297.05,189.19
  BOTTOM w0.132: UNK7U408.D2 295.02,190.57 296.56,190.57 297.05,190.08 297.05,189.53 v2(297.22,189.36)
S7_OUT_RX0_CH1_ABC_CASE-: length 20.2
  L19_SIGNAL w0.076: 306.41,189.18 306.93,189.18 v2(307.25,188.86)
  L19_SIGNAL w0.102: v2(296.51,189.36) 296.68,189.19
  L19_SIGNAL w0.105: 306.41,189.18 305.77,189.82 302.73,189.82 302.22,190.32 302.22,191.98 301.9,192.31 299.37,192.31 298.93,191.87 298.93,188.67 298.17,187.9 297.21,187.9 296.68,188.42 296.68,189.19
  BOTTOM w0.132: v2(296.51,189.36) 296.68,189.53 296.68,189.93 296.41,190.2 295.18,190.2 UNK7U408.D1
S7_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 293.41,191.97 293.41,191.47 UNK7U408.B5
  BOTTOM w0.132: 293.41,191.97 293.41,192.83 293.82,193.24 293.82,193.7 UNK7R168.1
S7_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK7R170.1 293.45,193.7 293.45,193.39 293.2,193.14 292.82,193.14 292.69,193.01 292.69,192.82 292.82,192.69 292.91,192.69 293.04,192.56 293.04,191.84 UNK7U408.A5
S7_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK7C310.1 UNK7R168.2 UNK7R170.2
S7_OUT_RX0_CH2_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: 294.73,189.82 294.62,189.72 v2(294.16,189.72)
  L21_SIGNAL w0.105: 294.73,189.82 294.73,190.84 295.3,191.41 298.06,191.41 298.65,190.81 298.65,188.05 298.94,187.76 301.09,187.76 302.36,189.03 302.36,190.19 302.86,190.68 303.94,190.68 304.54,190.09 304.81,190.09 304.97,189.92 304.97,189.66 305.43,189.19 306.27,189.19 v2(306.6,188.86)
  BOTTOM w0.16: UNK7U408.E2 v2(294.16,189.72)
S7_OUT_RX0_CH2_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 305.81,188.53 306.93,188.53 v2(307.25,188.21)
  L21_SIGNAL w0.102: v2(295.66,189.72) 295.2,189.72 295.09,189.82
  L21_SIGNAL w0.105: 305.81,188.53 305.57,188.53 303.79,190.32 303.01,190.32 302.73,190.03 302.73,188.88 301.24,187.39 298.79,187.39 298.28,187.89 298.28,190.66 297.9,191.04 295.45,191.04 295.09,190.69 295.09,189.82
  BOTTOM w0.16: UNK7U408.E1 v2(295.66,189.72)
S7_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK7R176.1 291.8,193.7 291.8,192.62 292.28,192.14 292.28,191.59 UNK7U408.B6
S7_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK7R178.1 292.64,193.86 292.77,193.73 292.77,193.51 292.66,193.4 292.47,193.4 292.17,193.1 292.17,192.78 292.66,192.29 292.66,191.72 UNK7U408.A6
S7_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK7R178.2 UNK7R176.2 UNK7C318.1
S7_OUT_RX0_CH3_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: v2(306.6,188.21) 306.28,188.53 305.74,188.53
  L19_SIGNAL w0.102: v2(297.22,180.5) 297.05,180.67
  L19_SIGNAL w0.105: 297.05,180.67 297.05,183.91 296.55,184.42 296.55,185.39 296.87,185.72 302.19,185.72 305.01,188.53 305.74,188.53
  BOTTOM w0.132: v2(297.22,180.5) 297.06,180.34 297.06,179.8 296.57,179.31 295,179.31 UNK7U409.B2
S7_OUT_RX0_CH3_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(296.51,180.5) 296.68,180.67
  L19_SIGNAL w0.105: v2(305.95,188.86) 305.91,188.9 304.86,188.9 304.56,188.6 304.41,188.6 304.31,188.71 304.16,188.71 304.01,188.56 304.01,188.41 304.11,188.3 304.11,188.16 303.97,188.01 303.82,188.01 303.71,188.11 303.56,188.11 303.41,187.96 303.41,187.81 303.52,187.71 303.52,187.56 303.37,187.41 303.22,187.41 303.12,187.52 302.97,187.52 302.82,187.37 302.82,187.22 302.93,187.12 302.93,186.97 302.04,186.08 296.72,186.08 296.18,185.54 296.18,184.26 296.68,183.76 296.68,180.67
  BOTTOM w0.132: UNK7U409.B1 295.19,179.69 296.41,179.69 296.68,179.96 296.68,180.34 v2(296.51,180.5)
S7_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK7R1089.1 295.3,182.21 295.3,181.48 294.94,181.13 294.44,181.13 294.15,180.85 294.15,180.14 UNK7U409.B4
S7_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK7U409.A4 293.78,180.27 293.78,181 294.28,181.51 294.79,181.51 294.92,181.64 294.92,181.81 294.81,181.93 294.45,181.93 294.38,182 294.38,182.21 294.46,182.3 UNK7R1088.1
S7_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK7C302.1 UNK7R1088.2 UNK7R1089.2
S7_OUT_RX0_CH4_ABC_CASE+: length 20.2
  L21_SIGNAL w0.076: 305.68,187.88 306.28,187.88 v2(306.6,187.56)
  L21_SIGNAL w0.102: v2(297.22,177.8) 297.05,177.97
  L21_SIGNAL w0.105: 297.05,177.97 297.05,178.34 297.46,178.76 298.18,178.76 298.69,179.27 298.69,182.83 301.86,186 302.33,186 303.37,187.03 303.37,187.53 303.67,187.84 305.64,187.84 305.68,187.88
  BOTTOM w0.132: UNK7U409.D2 295.02,179.01 296.56,179.01 297.05,178.51 297.05,177.97 v2(297.22,177.8)
S7_OUT_RX0_CH4_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 305.63,188.21 v2(305.95,188.21)
  L21_SIGNAL w0.102: v2(296.51,177.8) 296.68,177.97
  L21_SIGNAL w0.105: 305.63,188.21 303.52,188.21 303,187.69 303,187.18 302.18,186.36 301.7,186.36 298.33,182.99 298.33,182.34 298.22,182.24 297.94,182.24 297.84,182.13 297.84,181.92 297.94,181.82 298.22,181.82 298.33,181.71 298.33,181.5 298.22,181.4 297.94,181.4 297.84,181.29 297.84,181.08 297.94,180.98 298.22,180.98 298.33,180.87 298.33,179.43 298.03,179.13 297.31,179.13 296.68,178.5 296.68,177.97
  BOTTOM w0.132: v2(296.51,177.8) 296.68,177.96 296.68,178.36 296.41,178.63 295.18,178.63 UNK7U409.D1
S7_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK7U409.B5 293.41,179.9 293.41,180.41
  BOTTOM w0.132: 293.41,180.41 293.41,181.26 293.82,181.67 293.82,182.13 UNK7R180.1
S7_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK7R182.1 293.45,182.13 293.45,181.83 293.2,181.57 292.82,181.57 292.69,181.44 292.69,181.25 292.82,181.12 292.91,181.12 293.04,181 293.04,180.27 UNK7U409.A5
S7_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK7R182.2 UNK7R180.2 UNK7C320.1
S7_OUT_RX0_CH5_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 306.27,187.23 306.93,187.23 v2(307.25,187.56)
  L19_SIGNAL w0.102: 294.73,178.05 294.62,178.15 v2(294.16,178.15)
  L19_SIGNAL w0.105: 294.73,178.05 294.73,177.41 295.25,176.89 297.59,176.89 299.04,178.35 299.04,179.11 303.27,183.33 303.27,184.74 305.71,187.18 306.23,187.18 306.27,187.23
  BOTTOM w0.16: UNK7U409.E2 v2(294.16,178.15)
S7_OUT_RX0_CH5_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: 295.09,178.05 295.2,178.15 v2(295.66,178.15)
  L19_SIGNAL w0.105: 295.09,178.05 295.09,177.56 295.4,177.26 297.44,177.26 298.68,178.5 298.68,179.26 301.06,181.64 301.06,181.79 300.88,181.97 300.88,182.12 301.02,182.27 301.17,182.27 301.35,182.09 301.5,182.09 301.65,182.24 301.65,182.38 301.47,182.57 301.47,182.71 301.62,182.86 301.77,182.86 301.95,182.68 302.1,182.68 302.25,182.83 302.25,182.98 302.06,183.16 302.06,183.31 302.21,183.46 302.36,183.46 302.54,183.28 302.69,183.28 302.9,183.48 302.9,184.89 305.56,187.55 305.95,187.55 v2(305.95,187.56)
  BOTTOM w0.16: UNK7U409.E1 v2(295.66,178.15)
S7_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK7R666.1 291.8,182.13 291.8,181.06 292.28,180.57 292.28,180.03 UNK7U409.B6
S7_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK7U409.A6 292.66,180.15 292.66,180.16 292.66,180.72 292.17,181.21 292.17,181.53 292.47,181.84 292.66,181.84 292.77,181.94 292.77,182.17 292.64,182.3 UNK7R664.1
S7_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK7C924.1 UNK7R666.2 UNK7R664.2
S7_PAD_SZQ: length 24.9
  L21_SIGNAL w0.102: UNK7K113.5 323.89,161.31 323.89,163.18 315.2,171.86 315.2,175.74 312.46,178.49 v2(312.46,179.76)
S7_PM_SAR0: length 202.5
  L33_SIGNAL w0.091: UNK7K34.3 190.6,241.18 190.6,227.22 205.75,212.07 205.75,169.29 217.05,157.99 217.68,157.99 218.95,156.71 218.95,155.19 219.87,154.27 233.3,154.27 235.99,151.57 274.02,151.57 276.36,149.22 314.55,149.22 v3(317.14,146.64)
  vias: v2(313.11,188.86)
S7_SPI_CK_ABCD_CASE: length 194.1
  L15_SIGNAL w0.091: v2(315.05,181.7) 315.87,181.7 316.58,181 316.58,178.61 317.27,177.91 317.27,168.38 322,163.65 329.49,163.65 335.7,157.44 335.7,156.76 336.96,155.5 338.58,155.5 339.59,154.49 348.24,154.49 349.25,155.5 442.98,155.5 450.7,147.78 465.1,147.78 465.84,148.51 465.84,151.05 466.88,152.1 482.15,152.1 UNK7K2.6
S7_SPI_CK_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK7K3.6 478.45,149.45 478.45,148.11 479.19,147.37 481.72,147.37 UNK7K2.5
S7_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK7K3.7 475.25,154.85 460.54,154.85 459.4,153.71 459.4,147.15 460.83,145.72 460.83,140.77 458.75,138.68 UNK7U18.6
S7_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK7K3.5 476.85,139.16 476.37,138.68 UNK7U19.6
S7_SPI_CZ_ABCD_CASE: length 202.4
  L15_SIGNAL w0.076: v2(314.41,181.7) 314.73,181.38 314.73,179.58 ; 314.3,179.15 314.3,178.81
  L15_SIGNAL w0.091: UNK7K2.3 484.68,149.33 484.68,148.21 481.63,145.16 449.71,145.16 448.11,146.76 375.46,146.76 370.59,151.64 331.85,151.64 327.48,156.01 319.99,156.01 318.47,157.53 318.47,163.82 314.3,167.99 314.3,178.81 ; 314.73,179.58 314.3,179.15
S7_SPI_CZ_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK7K2.4 485.3,149.95 481.15,149.95 UNK7K3.3
S7_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: UNK7K3.2 478.45,154.85 463.58,154.85 462.57,153.84 462.57,146.64 v3(468,141.22)
  BOTTOM w0.16: v3(468,141.22) UNK7U18.1
S7_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK7K3.4 480.05,143.14 481.97,141.22 UNK7U19.1 UNK7R205.2
S7_SPI_DI_ABCD_CASE: length 181.6
  L15_SIGNAL w0.091: UNK7K4.6 468.76,149.3 468.76,148.18 467.72,147.14 450.2,147.14 442.34,155 370.2,155 369.1,153.9 339.34,153.9 338.24,155 335.48,155 332.45,158.03 322.35,158.03 321.06,159.33 321.06,163.8 316.41,168.45 316.41,176.99 316.07,177.33 316.07,180.69 v2(315.7,181.06)
S7_SPI_DI_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK7K5.6 465.75,149.45 465.75,148.11 466.49,147.37 469.02,147.37 UNK7K4.5
S7_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK7K5.7 462.57,151.67 462.57,141.11 458.87,137.41 UNK7U18.5
S7_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v3(473.51,137.41) 473.51,142.31 472.53,143.29 469.7,143.29 UNK7K5.5
  BOTTOM w0.16: UNK7U19.5 v3(473.51,137.41)
S7_SPI_DO_ABCD_CASE: length 187.6
  L15_SIGNAL w0.076: v2(315.05,181.06) 315.38,180.73 315.38,179.6
  L15_SIGNAL w0.091: UNK7K4.3 472.62,149.97 472.62,147.65 471.65,146.69 449.58,146.69 448.69,147.57 376.83,147.57 371.03,153.38 354.04,153.38 353.06,152.4 338.71,152.4 338.33,152.78 331.38,152.78 326.86,157.3 320.78,157.3 319.35,158.72 319.35,164.18 315.11,168.42 315.11,179.02 315.38,179.29 315.38,179.6
S7_SPI_DO_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK7K4.4 472.6,149.95 468.45,149.95 UNK7K5.3
S7_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: UNK7K5.2 468.92,151.67 468.92,145.57 470.62,143.87 470.62,140.72 469.85,139.95 UNK7U18.2
S7_SPI_DO_D_CASE: length 24.7
  TOP w0.16: v3(486.82,139.95) 481.45,139.95 474.21,147.19 469.01,147.19 UNK7K5.4
  BOTTOM w0.16: UNK7U19.2 v3(486.82,139.95)
S7_SPI_HLD_ABCD_CASE: length 168.4
  L15_SIGNAL w0.076: v2(315.05,182.36) 315.38,182.68 316.07,182.68
  L15_SIGNAL w0.091: UNK7K6.3 459.41,152.64 459.41,157.15 458.37,158.19 449.86,158.19 449.62,157.95 336.87,157.95 329.62,165.2 323.26,165.2 319.47,168.98 319.47,176.98 317.71,178.75 317.71,181.71 316.73,182.68 316.07,182.68
S7_SPI_HLD_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK7K7.3 455.75,149.95 459.9,149.95 UNK7K6.4
S7_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK7K7.2 456.22,151.67 456.22,147.03 459.49,143.76 459.49,140.56 458.87,139.95 UNK7U18.7 UNK7R202.1
S7_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK7K7.4 462.91,140.59 471.9,140.59 v3(472.54,139.95)
  BOTTOM w0.16: UNK7U19.7 v3(472.54,139.95)
S7_SPI_WPZ_ABCD_CASE: length 165.6
  L15_SIGNAL w0.091: v2(315.7,182.36) 315.82,182.24 316.42,182.24 317.31,181.35 317.31,178.47 318.71,177.07 318.71,168.5 322.75,164.46 329.62,164.46 336.58,157.51 338.11,157.51 339.42,156.2 370.26,156.2 371.3,157.24 449.69,157.24 450.14,157.68 455.55,157.68 456.36,156.87 456.36,152.49 UNK7K6.6
S7_SPI_WPZ_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK7K6.5 456.32,147.37 453.79,147.37 453.05,148.11 453.05,149.45 UNK7K7.6
S7_SPI_WPZ_C_CASE: length 27
  TOP w0.16: UNK7K7.7 453.05,151.65 453.05,148.44 462.81,138.68 v3(468,138.68)
  BOTTOM w0.16: v3(468,138.68) UNK7U18.3
S7_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: UNK7K7.5 465.04,135.25 483.39,135.25 v3(486.82,138.68)
  BOTTOM w0.16: UNK7R207.2 v3(486.82,138.68) UNK7U19.3
S7_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK7U31.6 304.19,174.3 303.94,174.06 UNK7R164.2
S7_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK7U31.5 304.6,173.9 303.84,173.14 UNK7R163.2
S7_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK7R165.2 307.91,173.9 UNK7U31.16
S7_USB_D_AB_CASE+: length 15.4
  L21_SIGNAL w0.13: v2(305.95,186.26) 305.56,185.86 304.52,185.86 303.42,184.76 303.42,184.05 303.55,183.92 303.86,183.92 303.99,183.79 303.99,183.53 303.86,183.41 303.55,183.41 303.42,183.28 303.42,183.02 303.55,182.89 303.86,182.89 303.99,182.76 303.99,182.5 303.86,182.37 303.55,182.37 303.42,182.24 303.42,181.3 305.94,178.78 305.94,176.56 v2(306.01,176.49)
  BOTTOM w0.165: v2(306.01,176.49) 305.88,176.36 UNK7U31.10
S7_USB_D_AB_CASE-: length 15.4
  L21_SIGNAL w0.13: v2(306.6,186.26) 306.13,186.73 305.73,186.73 305.25,186.25 304.78,186.25 304.73,186.31 304.34,186.31 302.98,184.94 302.98,181.11 305.49,178.6 305.49,176.63 v2(305.35,176.49)
  BOTTOM w0.165: UNK7U31.9 305.48,176.36 v2(305.35,176.49)
S7_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK7R160.2 303.85,175.1 UNK7U31.8
S7_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK7R161.2 303.85,174.7 UNK7U31.7
S7_USER_3V3: length 2.6
  BOTTOM w0.305: UNK7R205.1 v3(489.2,141.22) ; UNK7R203.1 v3(469.39,138.68) ; UNK7R200.1 v3(469.39,141.22) ; UNK7R207.1 v3(489.2,138.68)
  vias: v3(452.86,142.49) v3(452.86,141.22) v3(452.86,139.95) v3(453.34,144.09) v3(465.84,130.33) v3(467.5,130.6) v3(471.29,142.49) v3(471.54,141.22) v3(471.54,139.95) v3(471.76,144.09)
S7_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(315.05,183.65) 315.35,183.95 315.57,184.17 318.02,184.17 319.01,183.18 319.01,178.84 316.33,176.15 316.33,170.9 317.03,170.19 UNK7K32.3
S7_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK7K32.4 UNK7R135.1
S7_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK7R135.2 UNK7R136.2 UNK7C267.1 316.55,164.48 317.49,163.54 317.49,160.49 316.93,159.93 UNK7Y1.3
S7_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: UNK7K32.6 314.28,170.19 314.98,170.89 314.98,176.7 317.6,179.33 317.6,183.06 317,183.65 v2(315.7,183.65)
S7_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK7K32.5 UNK7R137.1
S7_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK7R137.2 UNK7R136.1 UNK7C268.1 311.69,164.48 311.29,164.07 311.29,162.72 UNK7Y1.1
S7_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(314.03,197.96) 314.03,207.56 313.31,208.29 v2(312.49,208.29)
  BOTTOM w0.16: v2(312.49,208.29) 312.19,208.59 UNK7U449.7 ; UNK7K29.7 v2(314.03,197.96)
S7_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 309.6,189.25 v2(309.2,188.86)
  BOTTOM w0.16: 309.6,189.25 309.85,189.51 309.85,191.04 310.61,191.79 311.11,191.79 312.71,193.39 312.71,199.49 313.38,200.16 UNK7K29.6
S7_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK7K29.5 313.88,202.36 313.19,203.05 UNK7Y2.1 313.19,206.93 UNK7C271.1
S7_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK7U449.2 311.69,211.81 UNK7R973.2 311.92,213.09 UNK7R923.1
S7_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(311.38,208.29) 310.56,208.29 309.84,207.56 v2(309.84,197.96)
  BOTTOM w0.16: UNK7K29.2 v2(309.84,197.96) ; v2(311.38,208.29) 311.69,208.59 UNK7U449.8
S7_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: UNK7K29.3 310.64,200.16 311.34,199.45 311.34,194.01 309.2,191.87 v2(309.2,189.51)
S7_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK7K29.4 309.99,202.36 310.69,203.05 UNK7Y2.2 310.69,206.93 UNK7C272.1
S7_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK7R652.1 310.92,213.09 UNK7R973.1 311.19,211.78 UNK7U449.1
S8_0V5: length 41.7
  BOTTOM w0.305: 347.99,137 348.17,137.18 UNK8C288.1 348.22,137.2 348.42,137
  BOTTOM w0.381: 349.37,136.04 349.49,135.92 UNK8MU3.3
  BOTTOM w0.508: 347.99,137 347.34,136.35 UNK8C286.1 347.34,134.78 UNK8MR3.1 UNK8MR4.1 ; UNK8MR4.1 347.41,133.3 347.87,132.84 360.15,132.84 363.37,136.06 363.37,143.22 362.48,144.1 UNK8MK1.4 ; UNK8MR4.1 UNK8MR5.1 UNK8MR6.1 UNK8MR2.2 ; 349.37,136.04 349.37,136.05 348.42,137
S8_0V25: length 2.8
  BOTTOM w0.508: UNK8MK4.3 357.21,142.63 UNK8MR19.1 359.78,142.63 UNK8MR18.2
S8_0V75: length 4.9
  BOTTOM w0.381: UNK8MU3.6 UNK8MR10.2
  BOTTOM w0.508: UNK8MK2.4 356.81,138.44 UNK8C290.1 UNK8MR10.2
S8_1AWG_SHARE+: length 17.9
  L21_SIGNAL w0.102: UNK8K34.4 199.95,242.43 199.95,255.87 UNK8K107.2
S8_3V3_ETH_MUX: length 7.8
  BOTTOM w0.254: v2(363.75,209.49) UNK8C1080.1 UNK8R987.1 ; 356.97,209.95 UNK8C1077.1 UNK8R984.1 ; UNK8R990.1 UNK8C1081.1 v2(364.55,213.3)
  BOTTOM w0.305: UNK8R987.1 363.27,208.86 UNK8U451.10 ; UNK8R984.1 357.01,208.86 UNK8U450.10 ; UNK8U452.10 364.08,212.67 UNK8R990.1
  BOTTOM w0.508: v2(356.97,210.47) 356.97,209.95
S8_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v1(333.66,187.72) 333.12,187.72 332.78,188.06 UNK8R661.2
  TOP w0.381: v1(334.66,191.72) 334.87,191.5 334.87,188.23 334.36,187.72 v1(333.66,187.72)
  BOTTOM w0.381: v1(333.66,187.72) UNK8C922.2
  BOTTOM w0.508: UNK8C922.2 333.66,185.95 333.3,185.59 331.82,185.59 331.5,185.91 UNK8BDB5.2
S8_3V3_RX1_MIPI: length 13.4
  TOP w0.305: UNK8R663.2 332.78,176.49 333.12,176.15 v1(333.66,176.15)
  TOP w0.381: v1(334.66,180.15) 334.87,179.94 334.87,176.66 334.36,176.15 v1(333.66,176.15)
  BOTTOM w0.381: v1(333.66,176.15) UNK8C923.2
  BOTTOM w0.508: UNK8C923.2 333.66,174.38 333.3,174.02 331.82,174.02 331.5,174.35 UNK8BDB6.2
S8_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK8U31.4 345.48,173.24 344.6,172.36 UNK8C262.1
  BOTTOM w0.305: UNK8BD21.2 UNK8C262.1
S8_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 349.83,210.83 UNK8C1074.1 UNK8R981.1
  BOTTOM w0.356: UNK8U449.10 349.86,209.73 UNK8R981.1
  BOTTOM w0.508: UNK8BD1728.2 349.83,210.83
S8_AWG_2SHARE+: length 213
  L21_SIGNAL w0.102: 364.8,209.89 364.52,210.18 v2(364.3,210.18) ; UNK8K107.4 196.12,253.05 196.02,252.94
  L21_SIGNAL w0.105: 364.8,209.89 367.33,209.89 368.06,210.62 368.06,211.78 367.02,212.82 351.46,212.82 349.26,215.03 311.72,215.03 309.69,217.06 272.28,217.06 271.32,218.01 215.6,218.01 209.98,223.63 199.49,223.63 196.02,227.1 196.02,252.94
  BOTTOM w0.132: v2(364.3,210.18) 364.51,210.18 364.64,210.05 364.64,209.54 UNK8U451.1
S8_AWG_2SHARE-: length 212.9
  L21_SIGNAL w0.102: 364.96,210.26 364.78,210.44 v2(364.78,210.66) ; 195.65,252.94 195.55,253.05 UNK8K107.5
  L21_SIGNAL w0.105: 364.96,210.26 367.18,210.26 367.69,210.77 367.69,211.63 366.87,212.45 351.31,212.45 349.1,214.66 311.57,214.66 309.54,216.69 272.12,216.69 271.17,217.64 215.45,217.64 209.83,223.26 199.33,223.26 195.65,226.95 195.65,251.59 195.55,251.69 195.34,251.69 195.23,251.8 195.23,252.01 195.34,252.11 195.55,252.11 195.65,252.22 195.65,252.94
  BOTTOM w0.132: v2(364.78,210.66) 364.78,210.44 365.02,210.2 365.02,209.57 UNK8U451.2
S8_AWG_3SHARE+: length 39.2
  L25_SIGNAL w0.079: 195.93,255.33 195.93,289.55
  L25_SIGNAL w0.091: K112.4 196.01,289.62 195.93,289.55 ; 195.93,255.33 196.01,255.25 UNK8K107.3
S8_AWG_3SHARE-: length 39.2
  L25_SIGNAL w0.079: 195.74,289.55 195.74,255.33
  L25_SIGNAL w0.091: K112.5 195.66,289.62 195.74,289.55 ; UNK8K107.6 195.66,255.25 195.74,255.33
S8_DVDD_DDR_RX: length 13.6
  L17_SIGNAL w0.508: 349.79,178.4 349.79,171.91 346.46,168.57 UNK8K39.3
  vias: v2(347.25,179.11) v2(347.9,180.41)
S8_DVDD_DDR_TX: length 18.3
  L23_SIGNAL w0.508: 349.87,178.11 350.72,177.26 350.72,165.43 349.83,164.54 348.06,164.54 UNK8K39.6
  vias: v2(347.9,179.11) v2(348.55,180.41)
S8_ETH_RN_AB_CASE: length 31.5
  TOP w0.381: SITE8.H16 v2(356.35,184.96)
  L15_SIGNAL w0.508: 356.97,184.96 v2(356.35,184.96)
  L15_SIGNAL w0.889: 365.12,205.76 365.9,206.54 v2(365.9,207.41) ; 357.35,184.96 356.97,184.96
  L15_SIGNAL w1.016: 365.12,205.76 365.12,204.92 364.55,204.35 359.66,204.35 358.99,203.68 358.99,186.59 357.35,184.96
  BOTTOM w0.305: UNK8U451.7 365.6,207.72 v2(365.9,207.41)
S8_ETH_RP_AB_CASE: length 31
  L15_SIGNAL w0.305: v2(355.05,184.96) 356.52,186.42
  L15_SIGNAL w0.889: 363.6,206.46 364.55,207.41 v2(364.79,207.41) ; 356.52,186.42 357.02,186.92
  L15_SIGNAL w1.016: 357.02,186.92 357.02,205.77 357.7,206.46 363.6,206.46
  BOTTOM w0.305: UNK8U451.8 365.1,207.72 v2(364.79,207.41)
S8_ETH_TN_AB_CASE: length 26.2
  TOP w0.381: SITE8.G15 v2(356.35,185.61)
  L21_SIGNAL w0.305: v2(356.35,185.61) 356.48,185.48 356.81,185.48
  L21_SIGNAL w0.508: 359.03,187.12 357.39,185.48 356.81,185.48
  L21_SIGNAL w0.889: 359.64,206.7 v2(359.64,207.41)
  L21_SIGNAL w1.016: 359.03,187.12 359.03,205.82 359.64,206.43 359.64,206.7
  BOTTOM w0.305: UNK8U450.7 359.33,207.72 v2(359.64,207.41)
S8_ETH_TP_AB_CASE: length 25.5
  L21_SIGNAL w0.305: v2(354.4,185.61) 355.7,185.61 356.49,186.39
  L21_SIGNAL w0.762: 356.49,186.39 357.07,186.97 357.07,187.15
  L21_SIGNAL w0.889: 357.07,206.4 358.09,207.41 v2(358.52,207.41)
  L21_SIGNAL w1.016: 357.07,187.15 357.07,206.4
  BOTTOM w0.305: UNK8U450.8 358.83,207.72 v2(358.52,207.41)
S8_M_2V5: length 4.8
  BOTTOM w0.508: UNK8C284.1 UNK8C285.1 ; UNK8C284.1 344.24,135.91 UNK8MU2.6 ; UNK8C284.1 UNK8MR2.1
S8_M_3V2: length 24.3
  BOTTOM w0.381: 353.7,135.39 353.83,135.27 UNK8MU3.7
  BOTTOM w0.508: UNK8MU2.2 342.97,146.08 UNK8C282.1 UNK8C283.1 344.2,146.16 UNK8MR1.1 347.48,146.16 UNK8MU1.5 346.52,145.05 346.52,139.7 347.37,138.85 349.04,138.85 350.13,137.76 UNK8C289.1 352.41,137.76 353.18,136.99 353.18,135.91 353.7,135.39
S8_MUX_3V3: length 1.5
  TOP w0.508: v2(347.1,207.19) v2(347.86,207.19)
  BOTTOM w0.508: v2(347.1,207.19) UNK8R512.1 v2(347.86,207.19)
  vias: v2(330.56,186.46) v2(330.56,174.89) v2(342.6,172.36) v2(349.83,212.29) v2(356.97,211.41)
S8_OUT_RX0_CH0_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(337.22,192.07) 337.05,192.24
  L21_SIGNAL w0.105: 337.05,192.24 337.05,193.92 337.17,194.04 338.32,194.04 338.53,193.83 338.53,193.13 339.24,192.41 340.27,192.41 340.37,192.31 340.37,192.15 340.48,192.05 340.69,192.05 340.79,192.15 340.79,192.31 340.89,192.41 341.1,192.41 341.21,192.31 341.21,192.15 341.31,192.05 341.52,192.05 341.63,192.15 341.63,192.31 341.73,192.41 341.94,192.41 342.05,192.31 342.05,192.15 342.15,192.05 342.36,192.05 342.47,192.15 342.47,192.31 342.57,192.41 345.65,192.41 347.25,190.81 v2(347.25,189.51)
  BOTTOM w0.132: UNK8U408.B2 335,190.88 336.57,190.88 337.06,191.37 337.06,191.91 v2(337.22,192.07)
S8_OUT_RX0_CH0_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 347.62,189.81 347.62,189.03 347.58,188.99 347.58,188.72 347.9,188.4 v2(347.9,188.21)
  L21_SIGNAL w0.102: v2(336.51,192.07) 336.68,192.24
  L21_SIGNAL w0.105: 336.68,192.24 336.68,194.08 337.02,194.41 338.47,194.41 338.89,193.98 338.89,193.28 339.4,192.78 345.8,192.78 347.62,190.96 347.62,189.81
  BOTTOM w0.132: v2(336.51,192.07) 336.68,191.9 336.68,191.52 336.41,191.25 335.19,191.25 UNK8U408.B1
S8_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK8U408.B4 334.15,191.71 334.15,192.41 334.44,192.7 334.94,192.7 335.29,193.05 335.29,193.77 UNK8R647.1
S8_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK8R646.1 334.46,193.86 334.38,193.78 334.38,193.57 334.45,193.5 334.81,193.5 334.92,193.38 334.92,193.21 334.79,193.07 334.28,193.07 333.78,192.57 333.78,191.83 UNK8U408.A4
S8_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK8R647.2 UNK8R646.2 UNK8C309.1
S8_OUT_RX0_CH1_ABC_CASE+: length 20.2
  L19_SIGNAL w0.102: v2(337.22,189.36) 337.05,189.19
  L19_SIGNAL w0.105: 337.05,189.19 337.05,188.58 337.36,188.26 338.01,188.26 338.57,188.82 338.57,192.02 339.22,192.67 342.05,192.67 342.59,192.13 342.59,190.47 342.88,190.19 344.43,190.19 344.57,190.33 344.85,190.33 345,190.19 345.92,190.19 v2(346.6,189.51)
  BOTTOM w0.132: UNK8U408.D2 335.02,190.57 336.56,190.57 337.05,190.08 337.05,189.53 v2(337.22,189.36)
S8_OUT_RX0_CH1_ABC_CASE-: length 20.2
  L19_SIGNAL w0.076: 346.41,189.18 346.93,189.18 v2(347.25,188.86)
  L19_SIGNAL w0.102: v2(336.51,189.36) 336.68,189.19
  L19_SIGNAL w0.105: 336.68,189.19 336.68,188.42 337.21,187.9 338.17,187.9 338.93,188.67 338.93,191.87 339.37,192.31 341.9,192.31 342.22,191.98 342.22,190.32 342.73,189.82 345.77,189.82 346.41,189.18
  BOTTOM w0.132: UNK8U408.D1 335.18,190.2 336.4,190.2 336.68,189.93 336.68,189.53 v2(336.51,189.36)
S8_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: UNK8U408.B5 333.41,191.47 333.41,191.97
  BOTTOM w0.132: 333.41,191.97 333.41,192.83 333.82,193.24 333.82,193.7 UNK8R168.1
S8_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK8R170.1 333.45,193.7 333.45,193.39 333.2,193.14 332.82,193.14 332.69,193.01 332.69,192.82 332.82,192.69 332.91,192.69 333.04,192.56 333.04,191.84 UNK8U408.A5
S8_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK8C310.1 UNK8R168.2 UNK8R170.2
S8_OUT_RX0_CH2_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: 334.73,189.82 334.62,189.72 v2(334.16,189.72)
  L21_SIGNAL w0.105: 334.73,189.82 334.73,190.84 335.3,191.41 338.06,191.41 338.65,190.81 338.65,188.05 338.94,187.76 341.09,187.76 342.36,189.03 342.36,190.19 342.86,190.68 343.94,190.68 344.54,190.09 344.81,190.09 344.97,189.92 344.97,189.66 345.43,189.19 346.27,189.19 v2(346.6,188.86)
  BOTTOM w0.16: UNK8U408.E2 v2(334.16,189.72)
S8_OUT_RX0_CH2_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: v2(347.25,188.21) 346.93,188.53 345.81,188.53
  L21_SIGNAL w0.102: v2(335.66,189.72) 335.2,189.72 335.09,189.82
  L21_SIGNAL w0.105: 335.09,189.82 335.09,190.69 335.45,191.04 337.9,191.04 338.28,190.66 338.28,187.89 338.79,187.39 341.24,187.39 342.73,188.88 342.73,190.03 343.01,190.32 343.79,190.32 345.57,188.53 345.81,188.53
  BOTTOM w0.16: UNK8U408.E1 v2(335.66,189.72)
S8_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK8R176.1 331.8,193.7 331.8,192.62 332.28,192.14 332.28,191.59 UNK8U408.B6
S8_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK8R178.1 332.64,193.86 332.77,193.73 332.77,193.51 332.66,193.4 332.47,193.4 332.17,193.1 332.17,192.78 332.66,192.29 332.66,191.72 UNK8U408.A6
S8_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK8R178.2 UNK8R176.2 UNK8C318.1
S8_OUT_RX0_CH3_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: v2(346.6,188.21) 346.28,188.53 345.74,188.53
  L19_SIGNAL w0.102: v2(337.22,180.5) 337.05,180.67
  L19_SIGNAL w0.105: 337.05,180.67 337.05,183.91 336.55,184.42 336.55,185.39 336.87,185.72 342.19,185.72 345.01,188.53 345.74,188.53
  BOTTOM w0.132: v2(337.22,180.5) 337.06,180.34 337.06,179.8 336.57,179.31 335,179.31 UNK8U409.B2
S8_OUT_RX0_CH3_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(336.51,180.5) 336.68,180.67
  L19_SIGNAL w0.105: 336.68,180.67 336.68,183.76 336.18,184.26 336.18,185.54 336.72,186.08 342.04,186.08 342.93,186.97 342.93,187.12 342.82,187.22 342.82,187.37 342.97,187.52 343.12,187.52 343.22,187.41 343.37,187.41 343.52,187.56 343.52,187.71 343.41,187.81 343.41,187.96 343.56,188.11 343.71,188.11 343.82,188.01 343.97,188.01 344.11,188.16 344.11,188.3 344.01,188.41 344.01,188.56 344.16,188.71 344.31,188.71 344.41,188.6 344.56,188.6 344.86,188.9 345.91,188.9 v2(345.95,188.86)
  BOTTOM w0.132: v2(336.51,180.5) 336.68,180.34 336.68,179.96 336.41,179.69 335.19,179.69 UNK8U409.B1
S8_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK8R1089.1 335.29,182.21 335.29,181.48 334.94,181.13 334.44,181.13 334.15,180.85 334.15,180.14 UNK8U409.B4
S8_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK8U409.A4 333.78,180.27 333.78,181 334.28,181.51 334.79,181.51 334.92,181.64 334.92,181.81 334.81,181.93 334.45,181.93 334.38,182 334.38,182.21 334.46,182.3 UNK8R1088.1
S8_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK8R1089.2 UNK8R1088.2 UNK8C302.1
S8_OUT_RX0_CH4_ABC_CASE+: length 20.2
  L21_SIGNAL w0.076: 345.68,187.88 346.28,187.88 v2(346.6,187.56)
  L21_SIGNAL w0.102: v2(337.22,177.8) 337.05,177.97
  L21_SIGNAL w0.105: 345.68,187.88 345.64,187.84 343.67,187.84 343.37,187.53 343.37,187.03 342.33,186 341.86,186 338.69,182.83 338.69,179.27 338.18,178.76 337.46,178.76 337.05,178.34 337.05,177.97
  BOTTOM w0.132: v2(337.22,177.8) 337.05,177.97 337.05,178.51 336.56,179.01 335.02,179.01 UNK8U409.D2
S8_OUT_RX0_CH4_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 345.63,188.21 v2(345.95,188.21)
  L21_SIGNAL w0.102: v2(336.51,177.8) 336.68,177.97
  L21_SIGNAL w0.105: 336.68,177.97 336.68,178.5 337.31,179.13 338.03,179.13 338.33,179.43 338.33,180.87 338.22,180.98 337.94,180.98 337.84,181.08 337.84,181.29 337.94,181.4 338.22,181.4 338.33,181.5 338.33,181.71 338.22,181.82 337.94,181.82 337.84,181.92 337.84,182.13 337.94,182.24 338.22,182.24 338.33,182.34 338.33,182.99 341.7,186.36 342.18,186.36 343,187.18 343,187.69 343.52,188.21 345.63,188.21
  BOTTOM w0.132: UNK8U409.D1 335.18,178.63 336.4,178.63 336.68,178.36 336.68,177.96 v2(336.51,177.8)
S8_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK8U409.B5 333.41,179.9 333.41,180.41
  BOTTOM w0.132: 333.41,180.41 333.41,181.26 333.82,181.67 333.82,182.13 UNK8R180.1
S8_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK8R182.1 333.45,182.13 333.45,181.83 333.2,181.57 332.82,181.57 332.69,181.44 332.69,181.25 332.82,181.12 332.91,181.12 333.04,181 333.04,180.27 UNK8U409.A5
S8_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK8R182.2 UNK8R180.2 UNK8C320.1
S8_OUT_RX0_CH5_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: v2(347.25,187.56) 346.93,187.23 346.27,187.23
  L19_SIGNAL w0.102: 334.73,178.05 334.62,178.15 v2(334.16,178.15)
  L19_SIGNAL w0.105: 346.27,187.23 346.23,187.18 345.71,187.18 343.27,184.74 343.27,183.33 339.04,179.11 339.04,178.35 337.59,176.89 335.25,176.89 334.73,177.41 334.73,178.05
  BOTTOM w0.16: UNK8U409.E2 v2(334.16,178.15)
S8_OUT_RX0_CH5_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: 335.09,178.05 335.2,178.15 v2(335.66,178.15)
  L19_SIGNAL w0.105: 335.09,178.05 335.09,177.56 335.4,177.26 337.44,177.26 338.68,178.5 338.68,179.26 341.06,181.64 341.06,181.79 340.88,181.97 340.88,182.12 341.02,182.27 341.17,182.27 341.35,182.09 341.5,182.09 341.65,182.24 341.65,182.38 341.47,182.57 341.47,182.71 341.62,182.86 341.77,182.86 341.95,182.68 342.1,182.68 342.25,182.83 342.25,182.98 342.06,183.16 342.06,183.31 342.21,183.46 342.36,183.46 342.54,183.28 342.69,183.28 342.9,183.48 342.9,184.89 345.56,187.55 345.95,187.55 v2(345.95,187.56)
  BOTTOM w0.16: UNK8U409.E1 v2(335.66,178.15)
S8_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK8U409.B6 332.28,180.03 332.28,180.57 331.8,181.06 331.8,182.13 UNK8R666.1
S8_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK8U409.A6 332.66,180.15 332.66,180.16 332.66,180.72 332.17,181.21 332.17,181.53 332.47,181.84 332.66,181.84 332.77,181.94 332.77,182.17 332.64,182.3 UNK8R664.1
S8_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK8C924.1 UNK8R666.2 UNK8R664.2
S8_PAD_SZQ: length 24.9
  L21_SIGNAL w0.102: v2(352.45,179.76) 352.45,178.49 355.2,175.74 355.2,171.86 363.89,163.18 363.89,161.31 UNK8K113.5
S8_PM_SAR0: length 236.6
  L33_SIGNAL w0.091: v3(357.14,146.64) 354.65,149.12 316.51,149.12 314.09,151.55 277.83,151.55 277.42,151.96 251.02,151.96 247.03,155.95 223.23,155.95 219.29,159.89 218.57,159.89 208.36,170.1 208.36,234.86 200.16,243.06 UNK8K34.3
  vias: v2(353.1,188.86)
S8_SPI_CK_ABCD_CASE: length 133.1
  L15_SIGNAL w0.091: v2(355.05,181.7) 355.87,181.7 356.07,181.5 358.99,181.5 359.37,181.87 370.53,181.87 371.6,180.8 449.28,180.8 450.55,179.53 465.1,179.53 465.84,180.26 465.84,182.8 466.88,183.85 482.15,183.85 UNK8K2.6
S8_SPI_CK_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK8K2.5 481.72,179.12 479.19,179.12 478.45,179.86 478.45,181.2 UNK8K3.6
S8_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK8K3.7 475.25,186.6 460.54,186.6 459.4,185.46 459.4,178.9 460.83,177.47 460.83,172.52 458.75,170.43 UNK8U18.6
S8_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK8U19.6 476.37,170.43 476.85,170.91 UNK8K3.5
S8_SPI_CZ_ABCD_CASE: length 138.4
  L15_SIGNAL w0.076: 354.73,179.58 354.73,181.38 v2(354.4,181.7)
  L15_SIGNAL w0.091: UNK8K2.3 484.68,181.08 484.68,179.96 481.87,177.14 451.02,177.14 450.25,177.91 368.47,177.91 366.51,179.87 359.51,179.87 359.25,179.6 357.63,179.6 357.3,179.27 355.04,179.27 354.73,179.58
S8_SPI_CZ_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK8K2.4 485.3,181.7 481.15,181.7 UNK8K3.3
S8_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: UNK8K3.2 478.45,186.6 463.58,186.6 462.57,185.59 462.57,178.39 v3(468,172.97)
  BOTTOM w0.16: v3(468,172.97) UNK8U18.1
S8_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK8K3.4 480.05,174.89 481.97,172.97 UNK8U19.1 UNK8R205.2
S8_SPI_DI_ABCD_CASE: length 118.7
  L15_SIGNAL w0.091: UNK8K4.6 468.76,181.05 468.76,179.93 467.72,178.89 450.14,178.89 448.79,180.24 370.97,180.24 369.71,181.5 359.6,181.5 358.7,180.59 356.17,180.59 v2(355.7,181.06)
S8_SPI_DI_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK8K5.6 465.75,181.2 465.75,179.86 466.49,179.12 469.02,179.12 UNK8K4.5
S8_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK8U18.5 458.87,169.16 462.57,172.86 462.57,183.42 UNK8K5.7
S8_SPI_DI_D_CASE: length 18.5
  TOP w0.16: UNK8K5.5 469.7,175.04 472.53,175.04 473.51,174.06 v3(473.51,169.16)
  BOTTOM w0.16: UNK8U19.5 v3(473.51,169.16)
S8_SPI_DO_ABCD_CASE: length 123.7
  L15_SIGNAL w0.076: 355.92,179.96 355.58,179.96 355.38,180.16 355.38,180.73 v2(355.05,181.06)
  L15_SIGNAL w0.091: 355.92,179.96 356.57,179.96 356.79,180.19 359.16,180.19 359.44,180.47 369.49,180.47 371.53,178.44 471.65,178.44 472.62,179.4 472.62,181.72 UNK8K4.3
S8_SPI_DO_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK8K5.3 468.45,181.7 472.6,181.7 UNK8K4.4
S8_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: UNK8K5.2 468.92,183.42 468.92,177.32 470.62,175.62 470.62,172.47 469.85,171.7 UNK8U18.2
S8_SPI_DO_D_CASE: length 24.7
  TOP w0.16: v3(486.82,171.7) 481.45,171.7 474.21,178.94 469.01,178.94 UNK8K5.4
  BOTTOM w0.16: UNK8U19.2 v3(486.82,171.7)
S8_SPI_HLD_ABCD_CASE: length 115.9
  L15_SIGNAL w0.076: 356.07,182.68 355.38,182.68 v2(355.05,182.36)
  L15_SIGNAL w0.091: 356.07,182.68 356.73,182.68 357.06,182.36 358.61,182.36 359.08,182.83 359.08,183.25 359.77,183.93 371.18,183.93 371.68,183.44 443.28,183.44 450.14,190.3 458.01,190.3 459.41,188.9 459.41,184.39 UNK8K6.3
S8_SPI_HLD_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK8K7.3 455.75,181.7 459.9,181.7 UNK8K6.4
S8_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK8K7.2 456.22,183.42 456.22,178.78 459.49,175.51 459.49,172.31 458.87,171.7 UNK8U18.7 UNK8R202.1
S8_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: v3(472.54,171.7) 471.9,172.34 462.91,172.34 UNK8K7.4
  BOTTOM w0.16: UNK8U19.7 v3(472.54,171.7)
S8_SPI_WPZ_ABCD_CASE: length 110.8
  L15_SIGNAL w0.091: v2(355.7,182.36) 355.82,182.24 356.42,182.24 356.79,181.87 358.73,181.87 359.22,182.36 370.85,182.36 371.09,182.6 443.53,182.6 450.39,189.46 455.52,189.46 456.36,188.62 456.36,184.24 UNK8K6.6
S8_SPI_WPZ_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK8K6.5 456.32,179.12 453.79,179.12 453.05,179.86 453.05,181.2 UNK8K7.6
S8_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v3(468,170.43) 462.81,170.43 453.05,180.19 453.05,183.4 UNK8K7.7
  BOTTOM w0.16: v3(468,170.43) UNK8U18.3
S8_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: UNK8K7.5 465.04,167 483.39,167 v3(486.82,170.43)
  BOTTOM w0.16: UNK8U19.3 v3(486.82,170.43) UNK8R207.2
S8_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK8R164.2 343.94,174.06 344.19,174.3 UNK8U31.6
S8_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK8U31.5 344.6,173.9 343.84,173.14 UNK8R163.2
S8_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK8U31.16 347.91,173.9 UNK8R165.2
S8_USB_D_AB_CASE+: length 15.4
  L21_SIGNAL w0.13: v2(345.95,186.26) 345.56,185.86 344.52,185.86 343.42,184.76 343.42,184.05 343.55,183.92 343.86,183.92 343.99,183.79 343.99,183.53 343.86,183.41 343.55,183.41 343.42,183.28 343.42,183.02 343.55,182.89 343.86,182.89 343.99,182.76 343.99,182.5 343.86,182.37 343.55,182.37 343.42,182.24 343.42,181.3 345.94,178.78 345.94,176.56 v2(346.01,176.49)
  BOTTOM w0.165: UNK8U31.10 345.88,176.36 v2(346.01,176.49)
S8_USB_D_AB_CASE-: length 15.4
  L21_SIGNAL w0.13: v2(346.6,186.26) 346.13,186.73 345.73,186.73 345.25,186.25 344.78,186.25 344.73,186.31 344.34,186.31 342.98,184.94 342.98,181.11 345.49,178.6 345.49,176.63 v2(345.35,176.49)
  BOTTOM w0.165: UNK8U31.9 345.48,176.36 v2(345.35,176.49)
S8_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK8U31.8 343.85,175.1 UNK8R160.2
S8_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK8U31.7 343.85,174.7 UNK8R161.2
S8_USER_3V3: length 2.6
  BOTTOM w0.305: UNK8R207.1 v3(489.2,170.43) ; UNK8R205.1 v3(489.2,172.97) ; UNK8R200.1 v3(469.39,172.97) ; UNK8R203.1 v3(469.39,170.43)
  vias: v3(452.86,174.24) v3(452.86,172.97) v3(452.86,171.7) v3(453.34,175.84) v3(465.84,162.08) v3(467.5,162.35) v3(471.29,174.24) v3(471.54,172.97) v3(471.54,171.7) v3(471.76,175.84)
S8_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: UNK8K32.3 357.03,170.19 356.33,170.9 356.33,176.15 359.01,178.84 359.01,183.18 358.02,184.17 355.57,184.17 355.35,183.95 v2(355.05,183.65)
S8_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK8K32.4 UNK8R135.1
S8_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK8R135.2 UNK8R136.2 UNK8C267.1 356.55,164.48 357.49,163.54 357.49,160.49 356.93,159.93 UNK8Y1.3
S8_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: v2(355.7,183.65) 357,183.65 357.6,183.06 357.6,179.33 354.98,176.7 354.98,170.89 354.28,170.19 UNK8K32.6
S8_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK8K32.5 UNK8R137.1
S8_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK8Y1.1 351.29,162.72 351.29,164.07 351.69,164.48 UNK8C268.1 UNK8R136.1 UNK8R137.2
S8_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(354.03,197.96) 354.03,207.56 353.31,208.29 v2(352.49,208.29)
  BOTTOM w0.16: v2(352.49,208.29) 352.19,208.59 UNK8U449.7 ; UNK8K29.7 v2(354.03,197.96)
S8_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 349.6,189.25 v2(349.2,188.86)
  BOTTOM w0.16: 349.6,189.25 349.85,189.51 349.85,191.04 350.61,191.79 351.11,191.79 352.71,193.39 352.71,199.49 353.38,200.16 UNK8K29.6
S8_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK8K29.5 353.88,202.36 353.19,203.05 UNK8Y2.1 353.19,206.93 UNK8C271.1
S8_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK8U449.2 351.69,211.81 UNK8R973.2 351.92,213.09 UNK8R923.1
S8_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(349.84,197.96) 349.84,207.56 350.56,208.29 v2(351.38,208.29)
  BOTTOM w0.16: UNK8K29.2 v2(349.84,197.96) ; v2(351.38,208.29) 351.69,208.59 UNK8U449.8
S8_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: v2(349.2,189.51) 349.2,191.87 351.34,194.01 351.34,199.45 350.64,200.16 UNK8K29.3
S8_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK8K29.4 349.99,202.36 350.69,203.05 UNK8Y2.2 350.69,206.93 UNK8C272.1
S8_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK8U449.1 351.19,211.78 UNK8R973.1 350.92,213.09 UNK8R652.1
SA_RCBIT_01: length 124.6
  L36_UDB w0.203: v3(78.49,295.82) 89.12,295.82 99.91,285.03 K107.8 165.81,286.51 172.52,286.51 UNK2K107.8 175.46,286.51 182.17,286.51 UNK3K107.8 185.12,286.51 191.82,286.51 UNK4K107.8
  BOTTOM w0.203: U74.16 77.97,295.3 v3(78.49,295.82)
SA_RCBIT_02: length 130.7
  L36_UDB w0.203: v3(77.22,295.82) 78.85,294.18 89.56,294.18 109.6,274.14 163.04,274.14 K34.8 165.81,274.31 172.52,274.31 UNK2K34.8 175.46,274.31 182.17,274.31 UNK3K34.8 185.12,274.31 191.82,274.31 UNK4K34.8
  BOTTOM w0.203: U74.15 v3(77.22,295.82)
SA_RCBIT_03: length 417.9
  L31_SIGNAL w0.203: UNK4K96.12 373.48,237.18 373.48,268.18 UNK3K96.12 ; K96.12 207.86,231.93 205.79,234 205.79,270.87 UNK2K96.12
  L36_UDB w0.203: UNK2K96.12 206.27,271.35 111.05,271.35 88.93,293.47 77.57,293.47 75.95,295.1 v3(75.95,295.82) ; UNK4K96.12 370.57,234.27 370.57,227.63 367.94,225 363.22,225 360.48,227.74 340.44,227.74 339.04,226.34 339.04,225.27 338.06,224.28 320.8,224.28 319.97,225.12 313.3,225.12 310.72,227.69 300.59,227.69 299.37,226.47 299.37,224.88 298.77,224.28 281.22,224.28 279.91,225.6 272.19,225.6 270.15,227.64 260.65,227.64 259.78,226.78 259.78,226.17 257.86,224.25 241.07,224.25 240.02,225.3 232.13,225.3 229.78,227.66 220.63,227.66 219.72,226.75 219.72,225.69 218.15,224.11 215.13,224.11 210.11,229.13 K96.12
  BOTTOM w0.203: U74.14 76.57,295.2 v3(75.95,295.82)
SA_RCBIT_04: length 130.3
  L36_UDB w0.203: v3(85.65,287.83) 85.65,286.21 104.93,266.93 122.1,266.93 140.57,248.46 UNK5K34.8 165.81,249.93 172.52,249.93 UNK6K34.8 175.46,249.93 182.17,249.93 UNK7K34.8 185.12,249.93 191.82,249.93 UNK8K34.8
  BOTTOM w0.203: v3(85.65,287.83) 86.17,288.35 U72.16
SA_RCBIT_05: length 294
  L36_UDB w0.203: v2(354.03,254.76) 351.36,254.76 350.78,254.18 340.35,254.18 340.08,253.91 314.88,253.91 v2(314.03,254.76) 311.36,254.76 310.51,253.91 274.88,253.91 v2(274.04,254.76) 271.36,254.76 270.78,254.18 260.35,254.18 260.08,253.91 234.88,253.91 v2(234.04,254.76) 231.36,254.76 230.73,254.13 220.3,254.13 220.08,253.91 211.18,253.91 208.6,251.33 141.63,251.33 124.05,268.91 103.84,268.91 86.92,285.83 v3(86.92,287.83)
  BOTTOM w0.203: UNK3K29.8 v2(314.03,254.76) ; UNK4K29.8 v2(354.03,254.76) ; UNK2K29.8 v2(274.04,254.76) ; K29.8 v2(234.04,254.76) ; U72.15 v3(86.92,287.83)
SA_RCBIT_06: length 121.8
  L36_UDB w0.203: v3(88.19,287.83) 91.85,284.18 93.14,284.18 107.65,269.67 124.51,269.67 132.69,261.49 163.49,261.49 UNK5K107.8 165.81,262.12 172.52,262.12 UNK6K107.8 175.46,262.12 182.17,262.12 UNK7K107.8 185.12,262.12 191.82,262.12 UNK8K107.8
  BOTTOM w0.203: U72.14 87.57,288.45 v3(88.19,287.83)
SA_RCBIT_07: length 657.7
  L31_SIGNAL w0.203: UNK4K5.8 465.75,250.1 465.75,243.13 463.07,240.45 463.07,221.02 UNK3K5.8 ; UNK2K5.8 97.31,221.02 97.31,240.45 99.99,243.13 99.99,250.1 K5.8
  L36_UDB w0.203: UNK4K5.8 462.3,253.55 450.53,253.55 442.66,245.68 442.66,142.76 425.99,126.1 156.86,126.1 133.3,149.66 133.3,183.57 120.01,196.85 103.58,196.85 99.97,200.46 99.97,218.37 UNK2K5.8 ; UNK3K5.8 465.61,221.41 468.3,221.41 469.98,223.09 493.6,223.09 498.32,227.81 v3(498.32,229.64)
  BOTTOM w0.203: v3(498.32,229.64) 497.8,229.12 U77.16
SA_RCBIT_08: length 656.2
  L31_SIGNAL w0.203: K6.8 93.63,250.11 93.63,221.54 UNK2K6.8 ; UNK3K6.8 459.39,221.54 459.39,250.11 UNK4K6.8
  L36_UDB w0.203: UNK4K6.8 456.48,253.02 450.75,253.02 443.2,245.46 443.2,142.54 426.22,125.56 156.64,125.56 132.54,149.66 132.54,181.03 120.27,193.29 105.41,193.29 93.57,205.13 93.57,218.41 UNK2K6.8 ; UNK3K6.8 462.44,224.59 469.73,224.59 470.19,225.04 475.46,225.04 476.5,226.09 494.59,226.09 497.05,228.55 v3(497.05,229.64)
  BOTTOM w0.203: U77.15 v3(497.05,229.64)
SA_RCBIT_09: length 662.4
  L31_SIGNAL w0.203: UNK3K7.8 452.19,220.68 452.19,241.92 453.03,242.76 453.03,250.12 UNK4K7.8 ; UNK2K7.8 86.43,220.68 86.43,241.92 87.27,242.76 87.27,250.12 K7.8
  L36_UDB w0.203: UNK2K7.8 87.29,218.34 87.29,211.38 91.69,206.99 91.69,194.82 96.51,189.99 121.92,189.99 131.65,180.26 131.65,149.78 156.41,125.02 426.44,125.02 443.74,142.32 443.74,243.99 UNK4K7.8 ; UNK3K7.8 453.9,222.4 455.98,222.4 462.41,228.83 494.97,228.83 v3(495.78,229.64)
  BOTTOM w0.203: U77.14 496.4,229.02 v3(495.78,229.64)
SA_RCBIT_10: length 656.2
  L31_SIGNAL w0.203: UNK4K4.8 472.06,250.14 472.06,243.08 473.44,241.7 473.44,234.51 470.5,231.57 UNK3K4.8 ; UNK2K4.8 104.74,231.57 107.68,234.51 107.68,241.7 106.3,243.08 106.3,250.14 K4.8
  L36_UDB w0.203: UNK2K4.8 106.3,218.39 106.3,211.24 109.16,208.37 109.16,200.53 111.82,197.87 120.65,197.87 134.06,184.45 134.06,149.66 157.08,126.63 425.77,126.63 442.12,142.99 442.12,245.89 450.31,254.08 468.12,254.08 UNK4K4.8 ; UNK3K4.8 472.75,222.2 487.6,222.2 491.06,218.74 502.57,218.74 v3(505.48,221.66)
  BOTTOM w0.203: v3(505.48,221.66) 506,222.18 U75.16
SA_RCBIT_11: length 650.3
  L31_SIGNAL w0.203: K3.8 112.75,250.04 112.75,235.69 110.59,233.53 110.59,224.28 111.94,222.93 111.94,220.8 UNK2K3.8 ; UNK4K3.8 478.51,250.04 478.51,235.69 476.35,233.53 476.35,227.99 477.7,226.64 477.7,220.8 UNK3K3.8
  L36_UDB w0.203: UNK4K3.8 473.94,254.61 450.09,254.61 441.58,246.1 441.58,143.21 425.55,127.17 157.31,127.17 134.82,149.66 134.82,187.63 123.06,199.39 121.08,199.39 112.69,207.78 112.69,218.35 UNK2K3.8 ; UNK3K3.8 478.24,221.34 487.3,221.34 490.73,217.91 503,217.91 v3(506.75,221.66)
  BOTTOM w0.203: v3(506.75,221.66) U75.15
SA_RCBIT_12: length 647.2
  L31_SIGNAL w0.203: UNK4K2.8 484.87,250.03 484.87,221.62 UNK3K2.8 ; K2.8 119.11,250.03 119.11,221.62 UNK2K2.8
  L36_UDB w0.203: UNK2K2.8 119.02,218.37 119.02,212.17 135.59,195.61 135.59,149.66 157.53,127.71 425.32,127.71 441.04,143.43 441.04,246.33 450.6,255.88 479.02,255.88 UNK4K2.8 ; UNK3K2.8 484.71,218.44 489.03,218.44 491.13,216.33 504.52,216.33 508.02,219.83 v3(508.02,221.66)
  BOTTOM w0.203: U75.14 507.4,222.28 v3(508.02,221.66)
SA_RCBIT_13: length 323.5
  L36_UDB w0.203: v2(353.63,235.59) 352.4,235.59 350.5,237.49 341.24,237.49 340.3,238.43 339.18,238.43 338.55,239.06 335.6,239.06 335.22,238.68 333.72,238.68 332.13,240.27 331.03,240.27 329.19,238.43 318.51,238.43 317.09,237.01 315.05,237.01 v2(313.63,235.59) 312.4,235.59 310.5,237.49 301.24,237.49 300.3,238.43 299.18,238.43 298.55,239.06 295.6,239.06 295.22,238.68 293.72,238.68 292.13,240.27 291.03,240.27 289.19,238.43 278.51,238.43 277.09,237.01 275.05,237.01 v2(273.63,235.59) 272.4,235.59 270.5,237.49 261.24,237.49 260.3,238.43 259.18,238.43 258.55,239.06 255.6,239.06 255.22,238.68 253.72,238.68 252.13,240.27 251.03,240.27 249.19,238.43 238.51,238.43 237.09,237.01 235.05,237.01 v2(233.63,235.59) 232.4,235.59 230.5,237.49 223.73,237.49 221.87,235.64 139.27,235.64 131.78,243.13 131.78,256.26 121.87,266.17 102.92,266.17 86.99,282.1 v3(78.49,282.1)
  BOTTOM w0.203: UNK4K32.8 v2(353.63,235.59) ; UNK3K32.8 v2(313.63,235.59) ; v3(78.49,282.1) 77.97,281.58 U80.16 ; K32.8 v2(233.63,235.59) ; UNK2K32.8 v2(273.63,235.59)
SA_RCBIT_14: length 305.7
  L36_UDB w0.203: UNK4K39.8 340.2,223.81 320.52,223.81 319.72,224.61 302.72,224.61 UNK3K39.8 300.2,223.81 280.52,223.81 279.72,224.61 262.72,224.61 UNK2K39.8 260.2,223.81 240.52,223.81 239.72,224.61 222.72,224.61 K39.8 220.44,223.56 140.73,223.56 129.84,234.44 129.84,254.53 119.66,264.72 103.35,264.72 87.66,280.42 78.9,280.42 v3(77.22,282.1)
  BOTTOM w0.203: U80.15 v3(77.22,282.1)
SA_RCBIT_15: length 345.6
  L36_UDB w0.203: UNK4K113.4 365.49,217.93 329.81,217.93 UNK3K113.4 326.36,221.38 319.62,221.38 318.99,220.75 318.99,218.75 318.2,217.96 289.78,217.96 UNK2K113.4 286.35,221.39 279.64,221.39 278.99,220.75 278.99,218.75 278.12,217.88 249.86,217.88 K113.4 246.36,221.38 239.62,221.38 238.99,220.75 238.99,218.75 238.08,217.83 154.08,217.83 150.77,221.14 141.83,221.14 129.06,233.91 129.06,254.15 119.23,263.98 102.95,263.98 87.27,279.65 77.34,279.65 75.95,281.05 v3(75.95,282.1)
  BOTTOM w0.203: U80.14 76.57,281.48 v3(75.95,282.1)
SA_RCBIT_16: length 335.2
  L36_UDB w0.203: v3(85.65,274.12) 85.65,271.42 99.57,257.51 120.93,257.51 125.04,253.39 125.04,211.45 138.23,198.27 138.23,187.35 155.5,170.08 176.48,170.08 178.43,168.13 198.7,168.13 201.69,165.14 211.43,165.14 UNK5K96.12 213.54,165.14 217.96,165.14 220.33,167.51 240.93,167.51 243.33,165.11 251.46,165.11 UNK6K96.12 253.54,165.14 257.96,165.14 260.33,167.51 280.93,167.51 283.33,165.11 291.46,165.11 UNK7K96.12 293.54,165.14 297.96,165.14 300.33,167.51 320.93,167.51 323.33,165.11 331.46,165.11 UNK8K96.12
  BOTTOM w0.203: U405.16 86.17,274.64 v3(85.65,274.12)
SA_RCBIT_17: length 357.4
  L36_UDB w0.203: v3(86.92,274.12) 86.92,271.47 100.23,258.17 121.46,258.17 126.44,253.19 126.44,211.15 139.06,198.53 139.06,194.74 155.38,178.43 209.19,178.43 211.03,180.27 212.13,180.27 213.72,178.68 215.22,178.68 215.6,179.06 218.55,179.06 219.18,178.43 220.3,178.43 221.24,177.49 230.5,177.49 232.4,175.59 v2(233.63,175.59) 235.05,177.01 237.09,177.01 238.51,178.43 249.19,178.43 251.03,180.27 252.13,180.27 253.72,178.68 255.22,178.68 255.6,179.06 258.55,179.06 259.18,178.43 260.3,178.43 261.24,177.49 270.5,177.49 272.4,175.59 v2(273.63,175.59) 275.05,177.01 277.09,177.01 278.51,178.43 289.19,178.43 291.03,180.27 292.13,180.27 293.72,178.68 295.22,178.68 295.6,179.06 298.55,179.06 299.18,178.43 300.3,178.43 301.24,177.49 310.5,177.49 312.4,175.59 v2(313.63,175.59) 315.05,177.01 317.09,177.01 318.51,178.43 329.19,178.43 331.03,180.27 332.13,180.27 333.72,178.68 335.22,178.68 335.6,179.06 338.55,179.06 339.18,178.43 340.3,178.43 341.24,177.49 350.5,177.49 352.4,175.59 v2(353.63,175.59)
  BOTTOM w0.203: UNK7K32.8 v2(313.63,175.59) ; UNK5K32.8 v2(233.63,175.59) ; UNK6K32.8 v2(273.63,175.59) ; UNK8K32.8 v2(353.63,175.59) ; v3(86.92,274.12) U405.15
SA_RCBIT_18: length 334.2
  L36_UDB w0.203: v3(88.19,274.12) 100.2,262.1 119.84,262.1 127.23,254.71 127.23,211.48 143.36,195.35 210.17,195.35 211.61,193.91 220.08,193.91 220.35,194.18 230.78,194.18 231.36,194.76 v2(234.04,194.76) 234.88,193.91 260.08,193.91 260.35,194.18 270.78,194.18 271.36,194.76 v2(274.04,194.76) 274.88,193.91 310.51,193.91 311.36,194.76 v2(314.03,194.76) 314.88,193.91 340.08,193.91 340.35,194.18 350.78,194.18 351.36,194.76 v2(354.03,194.76)
  BOTTOM w0.203: v3(88.19,274.12) 87.57,274.74 U405.14 ; UNK5K29.8 v2(234.04,194.76) ; UNK6K29.8 v2(274.04,194.76) ; UNK7K29.8 v2(314.03,194.76) ; UNK8K29.8 v2(354.03,194.76)
