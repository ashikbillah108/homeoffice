# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UT6_UW12: length 183.4
  TOP w0.254: UTL6.A11 481.84,13.46 484.63,13.46 485.13,12.97 UT6_SW2.4
  L31_SIGNAL w0.203: UTL6.A11 482.45,12.85 496.51,12.85 503.96,20.31 503.96,106.68 522.58,125.3 530.43,125.3 SK7.8
UT6_UW13: length 221.2
  TOP w0.254: UT6_SW2.3 v3(487.67,10.05)
  L15_SIGNAL w0.203: UTL6.B12 483.87,16.51 483.87,13.84 v3(487.67,10.05)
  L31_SIGNAL w0.203: v3(544.93,197.34) 543.15,195.56 543.15,177.57 536.52,170.94 536.52,144.07 501.68,109.22 501.68,33.4 488.11,19.84 484.66,19.84 UTL6.B12
  BOTTOM w0.203: R952.2 545.94,198.04 545.24,197.34 v3(544.93,197.34)
UT6_UW14: length 192.7
  TOP w0.254: UT6_SW2.2 490.21,13.09 489.71,13.59 486.79,13.59 UTL6.A13
  L31_SIGNAL w0.203: UTL6.A13 486.77,13.61 496.19,13.61 503.2,20.62 503.2,106.98 522.27,126.06 528.57,126.06 547.55,145.03 547.55,153.87 549.91,156.24 SK6.8
UT6_UW15: length 213.5
  TOP w0.254: UTL6.B14 488.95,16.51 490.86,16.51 491.49,15.88 491.49,13.97 492.75,12.71 UT6_SW2.1
  L31_SIGNAL w0.203: v3(544.93,195.94) 543.89,194.9 543.89,177.16 538.38,171.65 538.38,143.15 502.36,107.14 502.36,32.46 UTL6.B14
  BOTTOM w0.203: R950.2 545.94,196.64 545.24,195.94 v3(544.93,195.94)
UT7_UW00: length 4.3
  TOP w0.254: UTL7.A01 570.88,415.94 UT7_SW1.8
UT7_UW01: length 6.9
  TOP w0.254: UT7_SW1.7 568.34,415.94 567.69,415.29 567.69,412.75 UTL7.B02
UT7_UW02: length 4.3
  TOP w0.254: UT7_SW1.6 565.8,415.94 UTL7.A03
UT7_UW03: length 6.9
  TOP w0.254: UT7_SW1.5 563.26,416.06 562.61,415.42 562.61,412.75 UTL7.B03
UT7_UW04: length 3.8
  TOP w0.254: UTL7.A04 560.72,414.64 UT7_SW1.4
UT7_UW05: length 6.9
  TOP w0.254: UTL7.B05 557.53,412.75 557.53,415.29 558.18,415.94 UT7_SW1.3
UT7_UW06: length 3.8
  TOP w0.254: UTL7.A06 556.26,415.42 555.64,416.04 UT7_SW1.2
UT7_UW07: length 7.4
  TOP w0.254: UTL7.B06 554.99,412.75 554.99,415.04 553.1,416.93 UT7_SW1.1
UT7_UW08: length 240.8
  TOP w0.254: UT7_SW2.8 548.65,416.42 549.27,415.8 551.94,415.8 UTL7.A07
  L17_SIGNAL w0.203: v2(499.53,225.77) 499.53,231.44 500.13,232.03 500.13,391.93 526.02,417.83 549.91,417.83 UTL7.A07
  BOTTOM w0.203: v2(499.53,225.77) 499.66,225.64 U76.5
UT7_UW09: length 252
  TOP w0.254: UT7_SW2.7 v3(546.11,419.21)
  L15_SIGNAL w0.203: v3(546.11,419.21) 549.91,415.42 549.91,412.75 UTL7.B08
  L17_SIGNAL w0.203: v2(501.52,204.74) 503.3,206.52 503.3,208.79 518.67,224.16 518.67,399.92 526.67,407.92 547.62,407.92 UTL7.B08
  BOTTOM w0.203: v2(501.52,204.74) 501.65,204.87 U454.1
UT7_UW10: length 236
  TOP w0.254: UTL7.A09 547.12,415.54 544.32,415.54 543.57,416.29 UT7_SW2.6
  L17_SIGNAL w0.203: v2(499.53,224.51) 500.22,225.2 500.22,230.98 500.76,231.52 500.76,391.67 526.29,417.19 545.46,417.19 UTL7.A09
  BOTTOM w0.203: U76.3 499.66,224.64 v2(499.53,224.51)
UT7_UW11: length 247.1
  TOP w0.254: UT7_SW2.5 v3(541.03,419.21)
  L15_SIGNAL w0.203: UTL7.B10 544.83,412.75 544.83,415.42 v3(541.03,419.21)
  L17_SIGNAL w0.203: UTL7.B10 543.31,408.69 526.35,408.69 517.91,400.24 517.91,224.73 v2(499.53,206.36)
  BOTTOM w0.203: v2(499.53,206.36) 499.66,206.48 U454.3
UT7_UW12: length 230.7
  TOP w0.254: UTL7.A11 541.78,415.8 538.99,415.8 538.49,416.29 UT7_SW2.4
  L17_SIGNAL w0.203: UTL7.A11 541.15,416.43 526.48,416.43 502.41,392.36 502.41,232.03 500.89,230.5 500.89,223.53 v2(501.52,222.9)
  BOTTOM w0.203: U76.1 501.65,223.03 v2(501.52,222.9)
UT7_UW13: length 220.3
  TOP w0.254: UT7_SW2.3 v3(535.95,419.21)
  L15_SIGNAL w0.203: v3(535.95,419.21) 539.75,415.42 539.75,412.75 UTL7.B12
  L17_SIGNAL w0.203: UTL7.B12 538.99,409.45 526.16,409.45 505.59,388.87 505.59,231.52 503.94,229.87 v2(503.94,226.59)
  BOTTOM w0.203: U76.9 503.49,226.14 v2(503.94,226.59)
UT7_UW14: length 223.3
  TOP w0.254: UT7_SW2.2 533.41,416.17 533.91,415.67 536.83,415.67 UTL7.A13
  L17_SIGNAL w0.203: UTL7.A13 536.83,415.67 526.8,415.67 503.17,392.05 503.17,231.78 502.67,231.27 502.67,224.96 v2(503.94,223.69)
  BOTTOM w0.203: v2(503.94,223.69) 503.49,224.14 U76.13
UT7_UW15: length 215.4
  TOP w0.254: UT7_SW2.1 530.87,416.55 532.13,415.29 532.13,413.38 532.76,412.75 534.67,412.75 UTL7.B14
  L17_SIGNAL w0.203: UTL7.B14 534.54,410.08 525.9,410.08 504.95,389.14 504.95,231.9 503.3,230.25 503.3,225.78 v2(503.94,225.14)
  BOTTOM w0.203: U76.11 v2(503.94,225.14)
UT8_UW00: length 224.7
  TOP w0.254: UTL8.A01 128.92,415.94 UT8_SW1.8
  L33_SIGNAL w0.203: SK4.8 49.48,263.07 53.01,266.6 53.01,297.65 58.8,303.44 58.8,394.18 85.24,420.62 120.4,420.62 UTL8.A01
UT8_UW01: length 164.3
  TOP w0.254: UT8_SW1.7 126.38,415.94 125.73,415.29 125.73,412.75 UTL8.B02
  L33_SIGNAL w0.203: v2(84.1,292.77) 84.1,296.96 91.47,304.32 112.8,304.32 133.45,324.97 133.45,404.16 127.91,409.7 126.24,409.7 UTL8.B02
  BOTTOM w0.203: U73.9 83.65,292.32 v2(84.1,292.77)
UT8_UW02: length 234.7
  TOP w0.254: UT8_SW1.6 123.84,415.94 UTL8.A03
  L33_SIGNAL w0.203: SK1.8 48.21,246.95 48.21,256.49 53.9,262.18 53.9,297.28 59.69,303.07 59.69,394.26 85.48,420.05 115.89,420.05 UTL8.A03
UT8_UW03: length 165.9
  TOP w0.254: UTL8.B03 120.65,412.75 120.65,415.42 121.3,416.06 UT8_SW1.5
  L33_SIGNAL w0.203: UTL8.B03 124.43,408.97 127.79,408.97 132.84,403.91 132.84,328.47 109.3,304.93 91.08,304.93 83.36,297.21 83.36,292.06 v2(84.1,291.32)
  BOTTOM w0.203: U73.11 v2(84.1,291.32)
UT8_UW04: length 225
  TOP w0.254: UTL8.A04 118.76,414.64 UT8_SW1.4
  L33_SIGNAL w0.203: UTL8.A04 115.26,418.14 84.43,418.14 60.6,394.31 60.6,264.41 61.14,263.88 61.14,247.7 SK2.8
UT8_UW05: length 170.1
  TOP w0.254: UT8_SW1.3 116.22,415.94 115.57,415.29 115.57,412.75 UTL8.B05
  L33_SIGNAL w0.203: UTL8.B05 120.1,408.22 127.75,408.22 132.28,403.68 132.28,332.26 105.51,305.49 90.85,305.49 82.8,297.44 82.8,291.17 v2(84.1,289.86)
  BOTTOM w0.203: v2(84.1,289.86) 83.65,290.32 U73.13
UT8_UW06: length 200
  TOP w0.254: UTL8.A06 114.3,415.42 113.68,416.04 UT8_SW1.2
  L33_SIGNAL w0.203: UTL8.A06 110.72,417.6 84.66,417.6 61.52,394.46 61.52,265.31 SK3.8
UT8_UW07: length 159.5
  TOP w0.254: UTL8.B06 113.03,412.75 113.03,415.04 111.14,416.93 UT8_SW1.1
  L33_SIGNAL w0.203: v2(81.69,289.07) 81.08,289.68 81.08,403.46 85.34,407.73 110.55,407.73 UTL8.B06
  BOTTOM w0.203: v2(81.69,289.07) 81.82,289.2 U73.1
UT8_UW08: length 201
  TOP w0.254: UT8_SW2.8 106.69,416.42 107.31,415.8 109.98,415.8 UTL8.A07
  L33_SIGNAL w0.203: v2(79.7,264.51) 79.7,268.43 78.54,269.6 78.54,274.15 68.05,284.64 68.05,300.43 76.45,308.84 76.45,408.6 84.89,417.04 108.74,417.04 UTL8.A07
  BOTTOM w0.203: U414.5 79.83,264.39 v2(79.7,264.51)
UT8_UW09: length 159.2
  TOP w0.254: UT8_SW2.7 v3(104.15,419.21)
  L15_SIGNAL w0.203: UTL8.B08 107.95,412.75 107.95,415.42 v3(104.15,419.21)
  L33_SIGNAL w0.203: v2(79.7,290.69) 80.37,291.36 80.37,297.48 79.07,298.78 79.07,301.85 80.44,303.23 80.44,403.73 85.08,408.36 106.1,408.36 UTL8.B08
  BOTTOM w0.203: v2(79.7,290.69) 79.83,290.82 U73.3
UT8_UW10: length 196.4
  TOP w0.254: UT8_SW2.6 101.61,416.29 102.36,415.54 105.16,415.54 UTL8.A09
  L33_SIGNAL w0.203: UTL8.A09 104.19,416.51 85.11,416.51 76.99,408.38 76.99,306.97 68.58,298.56 68.58,284.86 79.07,274.37 79.07,269.98 80.37,268.68 80.37,263.92 v2(79.7,263.26)
  BOTTOM w0.203: v2(79.7,263.26) 79.83,263.38 U414.3
UT8_UW11: length 153.2
  TOP w0.254: UT8_SW2.5 v3(99.07,419.21)
  L15_SIGNAL w0.203: UTL8.B10 102.87,412.75 102.87,415.42 v3(99.07,419.21)
  L33_SIGNAL w0.203: UTL8.B10 101.55,408.89 84.86,408.89 79.91,403.95 79.91,303.45 78.54,302.07 78.54,298.4 79.7,297.24 v2(79.7,291.94)
  BOTTOM w0.203: U73.5 79.83,291.82 v2(79.7,291.94)
UT8_UW12: length 191.4
  TOP w0.254: UTL8.A11 99.82,415.8 97.03,415.8 96.53,416.29 UT8_SW2.4
  L33_SIGNAL w0.203: UTL8.A11 99.69,415.93 85.35,415.93 77.56,408.14 77.56,306.73 69.15,298.32 69.15,285.1 81.08,273.18 81.08,262.25 v2(81.69,261.64)
  BOTTOM w0.203: v2(81.69,261.64) 81.82,261.77 U414.1
UT8_UW13: length 168.5
  TOP w0.254: UT8_SW2.3 v3(93.99,419.21)
  L15_SIGNAL w0.203: v3(93.99,419.21) 97.79,415.42 97.79,412.75 UTL8.B12
  L33_SIGNAL w0.203: UTL8.B12 97.08,409.5 84.6,409.5 79.3,404.2 79.3,303.78 75.08,299.57 75.08,293.29 81.08,287.3 81.08,275.97 v2(81.69,275.36)
  BOTTOM w0.203: v2(81.69,275.36) 81.82,275.49 U79.1
UT8_UW14: length 166.8
  TOP w0.254: UT8_SW2.2 91.45,416.17 91.95,415.67 94.87,415.67 UTL8.A13
  L33_SIGNAL w0.203: v2(79.7,278.23) 79.7,283.67 71.07,292.3 71.07,299.42 78.16,306.5 78.16,407.9 85.6,415.34 95.2,415.34 UTL8.A13
  BOTTOM w0.203: U79.5 79.83,278.1 v2(79.7,278.23)
UT8_UW15: length 163.1
  TOP w0.254: UT8_SW2.1 88.91,416.55 90.17,415.29 90.17,413.38 90.8,412.75 92.71,412.75 UTL8.B14
  L33_SIGNAL w0.203: UTL8.B14 92.61,410.11 84.35,410.11 78.69,404.45 78.69,306.28 71.61,299.19 71.61,292.53 80.37,283.77 80.37,277.64 v2(79.7,276.97)
  BOTTOM w0.203: U79.3 79.83,277.1 v2(79.7,276.97)
N16793879: length 2.9
  L33_SIGNAL w0.076: 226.44,244.63 226.93,244.63 v2(227.26,244.96)
  L33_SIGNAL w0.091: 226.44,244.63 226.39,244.58 224.93,244.58 v2(224.66,244.3)
N16802127: length 1.4
  TOP w0.203: R172.1 v1(214.66,252.22)
  BOTTOM w0.16: v1(214.66,252.22) 214.9,252.22 215.16,251.95 U408.A1
N16802132: length 0.6
  TOP w0.305: v1(212.16,251.22) 212.23,251.29 R661.1
N16802143: length 1.4
  TOP w0.16: R662.1 v1(214.66,240.65)
  BOTTOM w0.16: U409.A1 215.16,240.39 214.9,240.65 v1(214.66,240.65)
N16802148: length 0.6
  TOP w0.305: R663.1 212.23,239.72 v1(212.16,239.65)
N16802203: length 1.1
  TOP w0.254: R672.1 214.13,239.12 v1(214.16,239.15)
  BOTTOM w0.16: U409.C2 v1(214.16,239.15)
N16802583: length 1.1
  TOP w0.254: v1(214.16,250.72) 214.13,250.69 R659.1
  BOTTOM w0.16: U408.C2 v1(214.16,250.72)
N17350989: length 3.6
  BOTTOM w0.508: R510.2 R511.1 U108.1
N17351004: length 14
  TOP w0.508: TP_MUX_3V3.1 219.85,265.29 v2(227.1,265.29) v2(227.86,265.29)
N17351006: length 2.5
  BOTTOM w0.508: U108.3 220.34,263.27 219.8,263.81 R509.1
N17351151: length 0.8
  BOTTOM w0.16: U31.15 R162.1
N17525467: length 8
  TOP w0.508: CON1.2 J2.2
N17525501: length 16.1
  TOP w0.508: CON1.1 22.21,147.83 13.32,147.83 J1.2
N17573836: length 2.5
  BOTTOM w0.16: U19.8 R204.1
N17574098: length 2.8
  BOTTOM w0.16: U18.8 R201.1
N17578091: length 0.9
  BOTTOM w0.16: SR3.2 v3(37.71,246.09)
N17578095: length 0.9
  BOTTOM w0.16: SR4.2 v3(40.08,256.75)
N17578103: length 0.9
  BOTTOM w0.16: SR5.2 v3(49.53,246.09)
N17578107: length 3.5
  BOTTOM w0.16: SR5.1 SC4.1 SK1.7
N17578109: length 0.9
  BOTTOM w0.16: SR6.2 v3(47.16,256.75)
N17578111: length 3.5
  BOTTOM w0.16: SK1.6 SC1.1 SR2.2
N17578117: length 0.9
  BOTTOM w0.16: SR2.1 v3(49.53,252.31)
N17578119: length 3.5
  BOTTOM w0.16: SR3.1 SC6.1 SK1.2
N17578121: length 3.5
  BOTTOM w0.16: SK1.3 SC2.1 SR1.2
N17578131: length 3.4
  BOTTOM w0.16: SK1.5 SC3.1 SR6.1
N17578138: length 0.9
  BOTTOM w0.16: SR9.2 v3(55.49,246.09)
N17578142: length 0.9
  BOTTOM w0.16: SR10.2 v3(57.86,256.75)
N17578153: length 3.5
  BOTTOM w0.16: SR11.1 SC10.1 SK2.7
N17578155: length 0.9
  BOTTOM w0.16: SR11.2 v3(67.31,246.09)
N17578165: length 0.9
  BOTTOM w0.16: SR12.2 v3(64.94,256.75)
N17578169: length 3.5
  BOTTOM w0.16: SK2.6 SC7.1 SR8.2
N17578175: length 0.9
  BOTTOM w0.16: SR8.1 v3(67.31,252.31)
N17578179: length 3.5
  BOTTOM w0.16: SK2.2 SC12.1 SR9.1
N17578181: length 3.4
  BOTTOM w0.16: SR12.1 SC9.1 SK2.5
N17578183: length 3.5
  BOTTOM w0.16: SR7.2 SC8.1 SK2.3
N17578209: length 0.9
  BOTTOM w0.16: SR7.1 v3(55.49,252.31)
N17578211: length 3.4
  BOTTOM w0.16: SK2.4 SC11.1 SR10.1
N17578235: length 3.4
  BOTTOM w0.16: SR4.1 SC5.1 SK1.4
N17578245: length 0.9
  BOTTOM w0.16: SR1.1 v3(37.71,252.31)
N17578251: length 0.9
  BOTTOM w0.16: SR18.2 v3(57.68,274.92)
N17578253: length 0.9
  BOTTOM w0.16: SR14.2 v3(67.13,264.26)
N17578257: length 3.5
  BOTTOM w0.16: SR14.1 SC17.1 SK3.7
N17578263: length 0.9
  BOTTOM w0.16: SR17.2 v3(55.31,264.26)
N17578267: length 0.9
  BOTTOM w0.16: SR13.1 v3(67.13,270.48)
N17578271: length 3.5
  BOTTOM w0.16: SK3.6 SC14.1 SR13.2
N17578275: length 0.9
  BOTTOM w0.16: SR15.2 v3(64.76,274.92)
N17578283: length 3.4
  BOTTOM w0.16: SR15.1 SC13.1 SK3.5
N17578291: length 3.5
  BOTTOM w0.16: SK3.3 SC15.1 SR16.2
N17578297: length 3.5
  BOTTOM w0.16: SK3.2 SC18.1 SR17.1
N17578299: length 0.9
  BOTTOM w0.16: SR16.1 v3(55.31,270.48)
N17578323: length 3.4
  BOTTOM w0.16: SK3.4 SC16.1 SR18.1
N17578329: length 0.9
  BOTTOM w0.16: SR23.2 v3(37.53,264.26)
N17578337: length 0.9
  BOTTOM w0.16: SR24.2 v3(39.9,274.92)
N17578341: length 0.9
  BOTTOM w0.16: SR20.2 v3(49.35,264.26)
N17578345: length 3.5
  BOTTOM w0.16: SR20.1 SC23.1 SK4.7
N17578351: length 3.4
  BOTTOM w0.16: SR21.1 SC19.1 SK4.5
N17578353: length 3.5
  BOTTOM w0.16: SK4.2 SC24.1 SR23.1
N17578355: length 0.9
  BOTTOM w0.16: SR19.1 v3(49.35,270.48)
N17578359: length 3.5
  BOTTOM w0.16: SR19.2 SC20.1 SK4.6
N17578363: length 0.9
  BOTTOM w0.16: SR21.2 v3(46.98,274.92)
N17578379: length 3.5
  BOTTOM w0.16: SK4.3 SC21.1 SR22.2
N17578383: length 3.4
  BOTTOM w0.16: SR24.1 SC22.1 SK4.4
N17578387: length 0.9
  BOTTOM w0.16: SR22.1 v3(37.53,270.48)
N17782373: length 1
  BOTTOM w0.16: U449.6 R980.1
N17782417: length 2
  BOTTOM w0.16: U449.9 R981.2 R982.2
N17785968: length 1
  BOTTOM w0.305: U450.6 R983.1
N17786012: length 2
  BOTTOM w0.305: R985.2 R984.2 U450.9
N17786363: length 1
  BOTTOM w0.305: U451.6 R986.1
N17786399: length 2
  BOTTOM w0.305: U451.9 R987.2 R988.2
N17929646: length 8.2
  L19_SIGNAL w0.076: v2(229.86,241.7) 229.53,241.38 225.85,241.38 225.83,241.4
  L19_SIGNAL w0.102: 225.83,241.4 225.35,241.4 223.77,239.83 v2(223.77,239.01)
  BOTTOM w0.16: R1090.1 v2(223.77,239.01)
N17930230: length 2.2
  BOTTOM w0.16: K113.1 R1091.1
N17932221: length 184.5
  TOP w0.16: v3(285.67,295.33) RD1.2 U14.2 ; U15.2 RD9.2 v3(455.1,277.11)
  L21_SIGNAL w0.102: v3(455.1,277.11) 424.87,277.11 407.09,294.89 370.48,294.89 366.67,298.7 289.94,298.7 286.57,295.33 v3(285.67,295.33)
N17932243: length 184.7
  TOP w0.16: U15.1 457.49,279.04 456.9,279.63 RD10.2 v3(455.1,279.63) ; v3(285.67,297.86) RD2.2 287.23,297.86 288.05,297.04 U14.1
  L21_SIGNAL w0.102: v3(455.1,279.63) 425.27,279.63 405.49,299.42 287.22,299.42 v3(285.67,297.86)
N17932245: length 1.7
  TOP w0.305: U14.6 RD4.1
N17932247: length 1.7
  TOP w0.305: U14.5 RD6.1
N17932257: length 3.2
  TOP w0.305: RD8.2 RD5.2 287.35,291.54 288.05,292.24 U14.4
N17932289: length 2.4
  TOP w0.305: U14.3 RD3.2 RD7.2
N17932337: length 2.4
  TOP w0.16: RD11.2 RD15.2 U15.3
N17932339: length 2.3
  TOP w0.16: RD16.2 RD13.2 U15.4
N17932349: length 1.7
  TOP w0.16: U15.6 RD12.1
N17932351: length 1.7
  TOP w0.16: U15.5 RD14.1
N17981963: length 4.5
  BOTTOM w0.16: U454.2 500.02,205.98 499.69,205.66 498.32,205.66 497.8,205.14 U453.1
N17981973: length 5.9
  BOTTOM w0.16: U454.4 498.53,206.98 497.05,205.51 U453.2
N18039645: length 1.3
  BOTTOM w0.305: R331.2 MU4.3
N18039715: length 1.3
  BOTTOM w0.305: MU4.1 C299.2
N18039717: length 5.6
  BOTTOM w0.305: MU4.6 219.72,287.77 C301.1 C300.1 ; C300.1 MR18.1 ; C300.1 220.67,287.56 MU4.5
N18039727: length 2.2
  BOTTOM w0.305: MBD1.2 C298.2 MU4.4
N18039793: length 5.8
  BOTTOM w0.254: MR1.2 MR7.2 233.49,282.25 233.11,282.62 233.11,284.02 233.57,284.47 MU1.4
N18039813: length 8.1
  BOTTOM w0.381: MR8.1 227.59,295.57 229.17,293.99 MU3.2
  BOTTOM w0.508: MR8.1 224.77,294.53 MR9.1
N18039885: length 1.6
  BOTTOM w0.508: MR13.2 MK2.1
N18039895: length 11.2
  BOTTOM w0.508: MK2.3 MK4.4 225.24,287.83 225.87,287.19 225.87,283.89 ; 225.87,283.89 MK1.3 ; 225.87,283.89 225.87,281.92 225.3,281.35 MK3.3
N18039909: length 1.3
  BOTTOM w0.508: MK3.1 MR14.1
N18039916: length 1.6
  BOTTOM w0.508: MR16.2 MK4.1
N18039964: length 1.1
  BOTTOM w0.508: MR9.2 MR10.1
N18039966: length 1.6
  BOTTOM w0.508: MR11.2 MK1.1
N18100710: length 3.6
  BOTTOM w0.508: UNK2U108.1 UNK2R511.1 UNK2R510.2
N18100716: length 14
  TOP w0.508: v2(267.86,265.29) v2(267.1,265.29) 259.85,265.29 UNK2TP_MUX_3V3.1
N18100717: length 2.5
  BOTTOM w0.508: UNK2R509.1 259.8,263.81 260.34,263.27 UNK2U108.3
N18100756: length 0.8
  BOTTOM w0.16: UNK2U31.15 UNK2R162.1
N18101409: length 2.9
  L33_SIGNAL w0.076: 266.44,244.63 266.93,244.63 v2(267.25,244.96)
  L33_SIGNAL w0.091: 266.44,244.63 266.39,244.58 264.93,244.58 v2(264.66,244.3)
N18101478: length 1.3
  BOTTOM w0.305: UNK2R331.2 UNK2MU4.3
N18101512: length 1.3
  BOTTOM w0.305: UNK2MU4.1 UNK2C299.2
N18101513: length 5.6
  BOTTOM w0.305: UNK2C300.1 260.67,287.56 UNK2MU4.5 ; UNK2C300.1 UNK2MR18.1 ; UNK2C300.1 UNK2C301.1 259.72,287.77 UNK2MU4.6
N18101518: length 2.2
  BOTTOM w0.305: UNK2MU4.4 262.95,289.14 UNK2C298.2 UNK2MBD1.2
N18101547: length 5.8
  BOTTOM w0.254: UNK2MU1.4 273.57,284.47 273.11,284.02 273.11,282.62 273.49,282.25 UNK2MR7.2 UNK2MR1.2
N18101557: length 8.1
  BOTTOM w0.381: UNK2MU3.2 269.17,293.99 267.59,295.57 UNK2MR8.1
  BOTTOM w0.508: UNK2MR9.1 264.77,294.53 UNK2MR8.1
N18101594: length 1.6
  BOTTOM w0.508: UNK2MR13.2 UNK2MK2.1
N18101599: length 11.2
  BOTTOM w0.508: UNK2MK2.3 UNK2MK4.4 265.24,287.83 265.87,287.19 265.87,283.89 ; 265.87,283.89 265.87,281.92 265.3,281.35 UNK2MK3.3 ; 265.87,283.89 UNK2MK1.3
N18101606: length 1.3
  BOTTOM w0.508: UNK2MK3.1 UNK2MR14.1
N18101610: length 1.6
  BOTTOM w0.508: UNK2MR16.2 UNK2MK4.1
N18101631: length 1.1
  BOTTOM w0.508: UNK2MR9.2 UNK2MR10.1
N18101632: length 1.6
  BOTTOM w0.508: UNK2MR11.2 UNK2MK1.1
N18101659: length 1
  BOTTOM w0.16: UNK2U449.6 UNK2R980.1
N18101670: length 2
  BOTTOM w0.16: UNK2R982.2 UNK2R981.2 UNK2U449.9
N18101811: length 8.2
  L19_SIGNAL w0.076: v2(269.85,241.7) 269.53,241.38 265.85,241.38 265.83,241.4
  L19_SIGNAL w0.102: v2(263.77,239.01) 263.77,239.83 265.35,241.4 265.83,241.4
  BOTTOM w0.16: UNK2R1090.1 v2(263.77,239.01)
N18101818: length 2.2
  BOTTOM w0.16: UNK2K113.1 UNK2R1091.1
N18103944: length 1.4
  TOP w0.203: UNK2R172.1 v1(254.66,252.22)
  BOTTOM w0.16: UNK2U408.A1 255.16,251.95 254.9,252.22 v1(254.66,252.22)
N18103947: length 0.6
  TOP w0.305: v1(252.16,251.22) 252.23,251.29 UNK2R661.1
N18103951: length 1.4
  TOP w0.16: UNK2R662.1 v1(254.66,240.65)
  BOTTOM w0.16: v1(254.66,240.65) 254.9,240.65 255.16,240.39 UNK2U409.A1
N18103954: length 0.6
  TOP w0.305: UNK2R663.1 252.23,239.72 v1(252.16,239.65)
N18103979: length 1.1
  TOP w0.254: UNK2R672.1 254.13,239.12 v1(254.16,239.15)
  BOTTOM w0.16: UNK2U409.C2 v1(254.16,239.15)
N18104018: length 1.1
  TOP w0.254: v1(254.16,250.72) 254.13,250.69 UNK2R659.1
  BOTTOM w0.16: UNK2U408.C2 v1(254.16,250.72)
N18104833: length 2.5
  BOTTOM w0.16: UNK2U19.8 UNK2R204.1
N18104928: length 2.8
  BOTTOM w0.16: UNK2U18.8 UNK2R201.1
N18104988: length 1
  BOTTOM w0.305: UNK2U450.6 UNK2R983.1
N18104999: length 2
  BOTTOM w0.305: UNK2R985.2 UNK2R984.2 UNK2U450.9
N18105006: length 1
  BOTTOM w0.305: UNK2U451.6 UNK2R986.1
N18105013: length 2
  BOTTOM w0.305: UNK2R988.2 UNK2R987.2 UNK2U451.9
N18105072: length 1
  BOTTOM w0.305: UNK2U452.6 UNK2R989.1
N18105079: length 2
  BOTTOM w0.305: UNK2U452.9 UNK2R990.2 UNK2R991.2
N18105089: length 0.9
  BOTTOM w0.305: UNK2C1066.2 285.4,274.07 UNK2U452.1
N18105091: length 0.9
  BOTTOM w0.305: UNK2U452.2 285.9,274.07 UNK2C1067.2
N18109027: length 3.6
  BOTTOM w0.508: UNK3U108.1 UNK3R511.1 UNK3R510.2
N18109033: length 14
  TOP w0.508: UNK3TP_MUX_3V3.1 299.85,265.29 v2(307.1,265.29) v2(307.86,265.29)
N18109034: length 2.5
  BOTTOM w0.508: UNK3R509.1 299.8,263.81 300.34,263.27 UNK3U108.3
N18109073: length 0.8
  BOTTOM w0.16: UNK3U31.15 UNK3R162.1
N18109726: length 2.9
  L33_SIGNAL w0.076: 306.44,244.63 306.93,244.63 v2(307.25,244.96)
  L33_SIGNAL w0.091: v2(304.65,244.3) 304.93,244.58 306.39,244.58 306.44,244.63
N18109795: length 1.3
  BOTTOM w0.305: UNK3R331.2 UNK3MU4.3
N18109829: length 1.3
  BOTTOM w0.305: UNK3MU4.1 UNK3C299.2
N18109830: length 5.6
  BOTTOM w0.305: UNK3C300.1 300.67,287.56 UNK3MU4.5 ; UNK3C300.1 UNK3C301.1 299.72,287.77 UNK3MU4.6 ; UNK3C300.1 UNK3MR18.1
N18109835: length 2.2
  BOTTOM w0.305: UNK3MU4.4 302.95,289.14 UNK3C298.2 UNK3MBD1.2
N18109864: length 5.8
  BOTTOM w0.254: UNK3MU1.4 313.57,284.47 313.11,284.02 313.11,282.62 313.49,282.25 UNK3MR7.2 UNK3MR1.2
N18109874: length 8.1
  BOTTOM w0.381: UNK3MR8.1 307.59,295.57 309.17,293.99 UNK3MU3.2
  BOTTOM w0.508: UNK3MR9.1 304.77,294.53 UNK3MR8.1
N18109911: length 1.6
  BOTTOM w0.508: UNK3MR13.2 UNK3MK2.1
N18109916: length 11.2
  BOTTOM w0.508: 305.87,283.89 305.87,281.92 305.3,281.35 UNK3MK3.3 ; 305.87,283.89 305.87,287.19 305.24,287.83 UNK3MK4.4 UNK3MK2.3 ; 305.87,283.89 UNK3MK1.3
N18109923: length 1.3
  BOTTOM w0.508: UNK3MK3.1 UNK3MR14.1
N18109927: length 1.6
  BOTTOM w0.508: UNK3MR16.2 UNK3MK4.1
N18109948: length 1.1
  BOTTOM w0.508: UNK3MR9.2 UNK3MR10.1
N18109949: length 1.6
  BOTTOM w0.508: UNK3MR11.2 UNK3MK1.1
N18109976: length 1
  BOTTOM w0.16: UNK3U449.6 UNK3R980.1
N18109987: length 2
  BOTTOM w0.16: UNK3U449.9 UNK3R981.2 UNK3R982.2
N18110128: length 8.2
  L19_SIGNAL w0.076: 305.83,241.4 305.85,241.38 309.53,241.38 v2(309.85,241.7)
  L19_SIGNAL w0.102: v2(303.77,239.01) 303.77,239.83 305.35,241.4 305.83,241.4
  BOTTOM w0.16: UNK3R1090.1 v2(303.77,239.01)
N18110135: length 2.2
  BOTTOM w0.16: UNK3K113.1 UNK3R1091.1
N18112261: length 1.4
  TOP w0.203: UNK3R172.1 v1(294.66,252.22)
  BOTTOM w0.16: v1(294.66,252.22) 294.9,252.22 295.16,251.95 UNK3U408.A1
N18112264: length 0.6
  TOP w0.305: v1(292.16,251.22) 292.23,251.29 UNK3R661.1
N18112268: length 1.4
  TOP w0.16: UNK3R662.1 v1(294.66,240.65)
  BOTTOM w0.16: UNK3U409.A1 295.16,240.39 294.9,240.65 v1(294.66,240.65)
N18112271: length 0.6
  TOP w0.305: UNK3R663.1 292.23,239.72 v1(292.16,239.65)
N18112296: length 1.1
  TOP w0.254: v1(294.16,239.15) 294.13,239.12 UNK3R672.1
  BOTTOM w0.16: UNK3U409.C2 v1(294.16,239.15)
N18112335: length 1.1
  TOP w0.254: v1(294.16,250.72) 294.13,250.69 UNK3R659.1
  BOTTOM w0.16: UNK3U408.C2 v1(294.16,250.72)
N18113150: length 2.5
  BOTTOM w0.16: UNK3U19.8 UNK3R204.1
N18113245: length 2.8
  BOTTOM w0.16: UNK3U18.8 UNK3R201.1
N18113305: length 1
  BOTTOM w0.305: UNK3U450.6 UNK3R983.1
N18113316: length 2
  BOTTOM w0.305: UNK3R985.2 UNK3R984.2 UNK3U450.9
N18113323: length 1
  BOTTOM w0.305: UNK3U451.6 UNK3R986.1
N18113330: length 2
  BOTTOM w0.305: UNK3R988.2 UNK3R987.2 UNK3U451.9
N18113389: length 1
  BOTTOM w0.305: UNK3U452.6 UNK3R989.1
N18113396: length 2
  BOTTOM w0.305: UNK3R991.2 UNK3R990.2 UNK3U452.9
N18113406: length 0.9
  BOTTOM w0.305: UNK3U452.1 325.4,274.07 UNK3C1066.2
N18113408: length 0.9
  BOTTOM w0.305: UNK3U452.2 325.9,274.07 UNK3C1067.2
N18117344: length 3.6
  BOTTOM w0.508: UNK4R510.2 UNK4R511.1 UNK4U108.1
N18117350: length 14
  TOP w0.508: UNK4TP_MUX_3V3.1 339.85,265.29 v2(347.1,265.29) v2(347.86,265.29)
N18117351: length 2.5
  BOTTOM w0.508: UNK4U108.3 340.34,263.27 339.8,263.81 UNK4R509.1
N18117390: length 0.8
  BOTTOM w0.16: UNK4U31.15 UNK4R162.1
N18118043: length 2.9
  L33_SIGNAL w0.076: v2(347.25,244.96) 346.93,244.63 346.44,244.63
  L33_SIGNAL w0.091: 346.44,244.63 346.39,244.58 344.93,244.58 v2(344.65,244.3)
N18118112: length 1.3
  BOTTOM w0.305: UNK4R331.2 UNK4MU4.3
N18118146: length 1.3
  BOTTOM w0.305: UNK4MU4.1 UNK4C299.2
N18118147: length 5.6
  BOTTOM w0.305: UNK4MU4.6 339.72,287.77 UNK4C301.1 UNK4C300.1 ; UNK4MU4.5 340.67,287.56 UNK4C300.1 ; UNK4C300.1 UNK4MR18.1
N18118152: length 2.2
  BOTTOM w0.305: UNK4MU4.4 342.95,289.14 UNK4C298.2 UNK4MBD1.2
N18118181: length 5.8
  BOTTOM w0.254: UNK4MR1.2 UNK4MR7.2 353.48,282.25 353.11,282.62 353.11,284.02 353.57,284.47 UNK4MU1.4
N18118191: length 8.1
  BOTTOM w0.381: UNK4MR8.1 347.59,295.57 349.17,293.99 UNK4MU3.2
  BOTTOM w0.508: UNK4MR8.1 344.77,294.53 UNK4MR9.1
N18118228: length 1.6
  BOTTOM w0.508: UNK4MR13.2 UNK4MK2.1
N18118233: length 11.2
  BOTTOM w0.508: 345.87,283.89 345.87,281.92 345.3,281.35 UNK4MK3.3 ; 345.87,283.89 345.87,287.19 345.24,287.83 UNK4MK4.4 UNK4MK2.3 ; 345.87,283.89 UNK4MK1.3
N18118240: length 1.3
  BOTTOM w0.508: UNK4MK3.1 UNK4MR14.1
N18118244: length 1.6
  BOTTOM w0.508: UNK4MR16.2 UNK4MK4.1
N18118265: length 1.1
  BOTTOM w0.508: UNK4MR9.2 UNK4MR10.1
N18118266: length 1.6
  BOTTOM w0.508: UNK4MR11.2 UNK4MK1.1
N18118293: length 1
  BOTTOM w0.16: UNK4U449.6 UNK4R980.1
N18118304: length 2
  BOTTOM w0.16: UNK4U449.9 UNK4R981.2 UNK4R982.2
N18118445: length 8.2
  L19_SIGNAL w0.076: 345.83,241.4 345.85,241.38 349.53,241.38 v2(349.85,241.7)
  L19_SIGNAL w0.102: 345.83,241.4 345.35,241.4 343.77,239.83 v2(343.77,239.01)
  BOTTOM w0.16: UNK4R1090.1 v2(343.77,239.01)
N18118452: length 2.2
  BOTTOM w0.16: UNK4K113.1 UNK4R1091.1
N18120578: length 1.4
  TOP w0.203: UNK4R172.1 v1(334.66,252.22)
  BOTTOM w0.16: v1(334.66,252.22) 334.89,252.22 335.16,251.95 UNK4U408.A1
N18120581: length 0.6
  TOP w0.305: v1(332.16,251.22) 332.23,251.29 UNK4R661.1
N18120585: length 1.4
  TOP w0.16: UNK4R662.1 v1(334.66,240.65)
  BOTTOM w0.16: v1(334.66,240.65) 334.89,240.65 335.16,240.39 UNK4U409.A1
N18120588: length 0.6
  TOP w0.305: UNK4R663.1 332.23,239.72 v1(332.16,239.65)
N18120613: length 1.1
  TOP w0.254: v1(334.16,239.15) 334.13,239.12 UNK4R672.1
  BOTTOM w0.16: UNK4U409.C2 v1(334.16,239.15)
N18120652: length 1.1
  TOP w0.254: UNK4R659.1 334.13,250.69 v1(334.16,250.72)
  BOTTOM w0.16: UNK4U408.C2 v1(334.16,250.72)
N18121467: length 2.5
  BOTTOM w0.16: UNK4U19.8 UNK4R204.1
N18121562: length 2.8
  BOTTOM w0.16: UNK4U18.8 UNK4R201.1
N18121622: length 1
  BOTTOM w0.305: UNK4U450.6 UNK4R983.1
N18121633: length 2
  BOTTOM w0.305: UNK4R985.2 UNK4R984.2 UNK4U450.9
N18121640: length 1
  BOTTOM w0.305: UNK4U451.6 UNK4R986.1
N18121647: length 2
  BOTTOM w0.305: UNK4U451.9 UNK4R987.2 UNK4R988.2
N18121706: length 1
  BOTTOM w0.305: UNK4U452.6 UNK4R989.1
N18121713: length 2
  BOTTOM w0.305: UNK4U452.9 UNK4R990.2 UNK4R991.2
N18121723: length 0.9
  BOTTOM w0.305: UNK4C1066.2 365.4,274.07 UNK4U452.1
N18121725: length 0.9
  BOTTOM w0.305: UNK4U452.2 365.9,274.07 UNK4C1067.2
N18125661: length 3.6
  BOTTOM w0.508: UNK5R510.2 UNK5R511.1 UNK5U108.1
N18125667: length 14
  TOP w0.508: v2(227.86,205.29) v2(227.1,205.29) 219.85,205.29 UNK5TP_MUX_3V3.1
N18125668: length 2.5
  BOTTOM w0.508: UNK5R509.1 219.8,203.81 220.34,203.27 UNK5U108.3
N18125707: length 0.8
  BOTTOM w0.16: UNK5U31.15 UNK5R162.1
N18126360: length 2.9
  L33_SIGNAL w0.076: 226.44,184.63 226.93,184.63 v2(227.26,184.96)
  L33_SIGNAL w0.091: v2(224.66,184.3) 224.93,184.58 226.39,184.58 226.44,184.63
N18126429: length 1.3
  BOTTOM w0.305: UNK5R331.2 UNK5MU4.3
N18126463: length 1.3
  BOTTOM w0.305: UNK5MU4.1 UNK5C299.2
N18126464: length 5.6
  BOTTOM w0.305: UNK5MU4.5 240.99,141.7 UNK5C300.1 ; UNK5C300.1 UNK5MR18.1 ; UNK5C300.1 UNK5C301.1 241.94,141.49 UNK5MU4.6
N18126469: length 2.2
  BOTTOM w0.305: UNK5MU4.4 238.71,140.12 UNK5C298.2 UNK5MBD1.2
N18126498: length 5.8
  BOTTOM w0.254: UNK5MR1.2 UNK5MR7.2 228.18,147.01 228.55,146.64 228.55,145.24 228.09,144.79 UNK5MU1.4
N18126508: length 8.1
  BOTTOM w0.381: UNK5MR8.1 234.07,133.69 232.49,135.27 UNK5MU3.2
  BOTTOM w0.508: UNK5MR8.1 236.89,134.73 UNK5MR9.1
N18126545: length 1.6
  BOTTOM w0.508: UNK5MR13.2 UNK5MK2.1
N18126550: length 11.2
  BOTTOM w0.508: 235.79,145.37 235.79,147.34 236.36,147.91 UNK5MK3.3 ; 235.79,145.37 235.79,142.07 236.42,141.43 UNK5MK4.4 UNK5MK2.3 ; 235.79,145.37 UNK5MK1.3
N18126557: length 1.3
  BOTTOM w0.508: UNK5MK3.1 UNK5MR14.1
N18126561: length 1.6
  BOTTOM w0.508: UNK5MR16.2 UNK5MK4.1
N18126582: length 1.1
  BOTTOM w0.508: UNK5MR9.2 UNK5MR10.1
N18126583: length 1.6
  BOTTOM w0.508: UNK5MR11.2 UNK5MK1.1
N18126610: length 1
  BOTTOM w0.16: UNK5U449.6 UNK5R980.1
N18126621: length 2
  BOTTOM w0.16: UNK5R982.2 UNK5R981.2 UNK5U449.9
N18126762: length 8.2
  L19_SIGNAL w0.076: v2(229.86,181.7) 229.53,181.38 225.85,181.38 225.83,181.4
  L19_SIGNAL w0.102: 225.83,181.4 225.35,181.4 223.77,179.83 v2(223.77,179.01)
  BOTTOM w0.16: UNK5R1090.1 v2(223.77,179.01)
N18126769: length 2.2
  BOTTOM w0.16: UNK5R1091.1 UNK5K113.1
N18128895: length 1.4
  TOP w0.203: UNK5R172.1 v1(214.66,192.22)
  BOTTOM w0.16: v1(214.66,192.22) 214.9,192.22 215.16,191.95 UNK5U408.A1
N18128898: length 0.6
  TOP w0.305: UNK5R661.1 212.23,191.29 v1(212.16,191.22)
N18128902: length 1.4
  TOP w0.16: UNK5R662.1 v1(214.66,180.65)
  BOTTOM w0.16: UNK5U409.A1 215.16,180.39 214.9,180.65 v1(214.66,180.65)
N18128905: length 0.6
  TOP w0.305: v1(212.16,179.65) 212.23,179.72 UNK5R663.1
N18128930: length 1.1
  TOP w0.254: v1(214.16,179.15) 214.13,179.12 UNK5R672.1
  BOTTOM w0.16: UNK5U409.C2 v1(214.16,179.15)
N18128969: length 1.1
  TOP w0.254: UNK5R659.1 214.13,190.69 v1(214.16,190.72)
  BOTTOM w0.16: UNK5U408.C2 v1(214.16,190.72)
N18129784: length 2.5
  BOTTOM w0.16: UNK5U19.8 UNK5R204.1
N18129879: length 2.8
  BOTTOM w0.16: UNK5U18.8 UNK5R201.1
N18129939: length 1
  BOTTOM w0.305: UNK5U450.6 UNK5R983.1
N18129950: length 2
  BOTTOM w0.305: UNK5R985.2 UNK5R984.2 UNK5U450.9
N18129957: length 1
  BOTTOM w0.305: UNK5U451.6 UNK5R986.1
N18129964: length 2
  BOTTOM w0.305: UNK5R988.2 UNK5R987.2 UNK5U451.9
N18130023: length 1
  BOTTOM w0.305: UNK5U452.6 UNK5R989.1
N18130030: length 2
  BOTTOM w0.305: UNK5R991.2 UNK5R990.2 UNK5U452.9
N18130040: length 0.9
  BOTTOM w0.305: UNK5C1066.2 245.4,214.07 UNK5U452.1
N18130042: length 0.9
  BOTTOM w0.305: UNK5U452.2 245.9,214.07 UNK5C1067.2
N18133978: length 3.6
  BOTTOM w0.508: UNK6U108.1 UNK6R511.1 UNK6R510.2
N18133984: length 14
  TOP w0.508: UNK6TP_MUX_3V3.1 259.85,205.29 v2(267.1,205.29) v2(267.86,205.29)
N18133985: length 2.5
  BOTTOM w0.508: UNK6U108.3 260.34,203.27 259.8,203.81 UNK6R509.1
N18134024: length 0.8
  BOTTOM w0.16: UNK6U31.15 UNK6R162.1
N18134677: length 2.9
  L33_SIGNAL w0.076: 266.44,184.63 266.93,184.63 v2(267.25,184.96)
  L33_SIGNAL w0.091: v2(264.66,184.3) 264.93,184.58 266.39,184.58 266.44,184.63
N18134746: length 1.3
  BOTTOM w0.305: UNK6R331.2 UNK6MU4.3
N18134780: length 1.3
  BOTTOM w0.305: UNK6MU4.1 UNK6C299.2
N18134781: length 5.6
  BOTTOM w0.305: UNK6C300.1 UNK6MR18.1 ; UNK6C300.1 280.99,141.7 UNK6MU4.5 ; UNK6C300.1 UNK6C301.1 281.94,141.49 UNK6MU4.6
N18134786: length 2.2
  BOTTOM w0.305: UNK6MBD1.2 UNK6C298.2 278.71,140.12 UNK6MU4.4
N18134815: length 5.8
  BOTTOM w0.254: UNK6MR1.2 UNK6MR7.2 268.17,147.01 268.55,146.64 268.55,145.24 268.09,144.79 UNK6MU1.4
N18134825: length 8.1
  BOTTOM w0.381: UNK6MR8.1 274.07,133.69 272.49,135.27 UNK6MU3.2
  BOTTOM w0.508: UNK6MR9.1 276.89,134.73 UNK6MR8.1
N18134862: length 1.6
  BOTTOM w0.508: UNK6MR13.2 UNK6MK2.1
N18134867: length 11.2
  BOTTOM w0.508: 275.79,145.37 275.79,142.07 276.42,141.43 UNK6MK4.4 UNK6MK2.3 ; 275.79,145.37 UNK6MK1.3 ; 275.79,145.37 275.79,147.34 276.36,147.91 UNK6MK3.3
N18134874: length 1.3
  BOTTOM w0.508: UNK6MK3.1 UNK6MR14.1
N18134878: length 1.6
  BOTTOM w0.508: UNK6MR16.2 UNK6MK4.1
N18134899: length 1.1
  BOTTOM w0.508: UNK6MR9.2 UNK6MR10.1
N18134900: length 1.6
  BOTTOM w0.508: UNK6MR11.2 UNK6MK1.1
N18134927: length 1
  BOTTOM w0.16: UNK6U449.6 UNK6R980.1
N18134938: length 2
  BOTTOM w0.16: UNK6U449.9 UNK6R981.2 UNK6R982.2
N18135079: length 8.2
  L19_SIGNAL w0.076: 265.83,181.4 265.85,181.38 269.53,181.38 v2(269.85,181.7)
  L19_SIGNAL w0.102: v2(263.77,179.01) 263.77,179.83 265.35,181.4 265.83,181.4
  BOTTOM w0.16: UNK6R1090.1 v2(263.77,179.01)
N18135086: length 2.2
  BOTTOM w0.16: UNK6R1091.1 UNK6K113.1
N18137212: length 1.4
  TOP w0.203: UNK6R172.1 v1(254.66,192.22)
  BOTTOM w0.16: v1(254.66,192.22) 254.9,192.22 255.16,191.95 UNK6U408.A1
N18137215: length 0.6
  TOP w0.305: v1(252.16,191.22) 252.23,191.29 UNK6R661.1
N18137219: length 1.4
  TOP w0.16: UNK6R662.1 v1(254.66,180.65)
  BOTTOM w0.16: v1(254.66,180.65) 254.9,180.65 255.16,180.39 UNK6U409.A1
N18137222: length 0.6
  TOP w0.305: v1(252.16,179.65) 252.23,179.72 UNK6R663.1
N18137247: length 1.1
  TOP w0.254: UNK6R672.1 254.13,179.12 v1(254.16,179.15)
  BOTTOM w0.16: UNK6U409.C2 v1(254.16,179.15)
N18137286: length 1.1
  TOP w0.254: UNK6R659.1 254.13,190.69 v1(254.16,190.72)
  BOTTOM w0.16: UNK6U408.C2 v1(254.16,190.72)
N18138101: length 2.5
  BOTTOM w0.16: UNK6U19.8 UNK6R204.1
N18138196: length 2.8
  BOTTOM w0.16: UNK6U18.8 UNK6R201.1
N18138256: length 1
  BOTTOM w0.305: UNK6U450.6 UNK6R983.1
N18138267: length 2
  BOTTOM w0.305: UNK6U450.9 UNK6R984.2 UNK6R985.2
N18138274: length 1
  BOTTOM w0.305: UNK6U451.6 UNK6R986.1
N18138281: length 2
  BOTTOM w0.305: UNK6R988.2 UNK6R987.2 UNK6U451.9
N18138340: length 1
  BOTTOM w0.305: UNK6U452.6 UNK6R989.1
N18138347: length 2
  BOTTOM w0.305: UNK6R991.2 UNK6R990.2 UNK6U452.9
N18138357: length 0.9
  BOTTOM w0.305: UNK6U452.1 285.4,214.07 UNK6C1066.2
N18138359: length 0.9
  BOTTOM w0.305: UNK6U452.2 285.9,214.07 UNK6C1067.2
N18142295: length 3.6
  BOTTOM w0.508: UNK7U108.1 UNK7R511.1 UNK7R510.2
N18142301: length 14
  TOP w0.508: v2(307.86,205.29) v2(307.1,205.29) 299.85,205.29 UNK7TP_MUX_3V3.1
N18142302: length 2.5
  BOTTOM w0.508: UNK7U108.3 300.34,203.27 299.8,203.81 UNK7R509.1
N18142341: length 0.8
  BOTTOM w0.16: UNK7U31.15 UNK7R162.1
N18142994: length 2.9
  L33_SIGNAL w0.076: v2(307.25,184.96) 306.93,184.63 306.44,184.63
  L33_SIGNAL w0.091: 306.44,184.63 306.39,184.58 304.93,184.58 v2(304.65,184.3)
N18143063: length 1.3
  BOTTOM w0.305: UNK7R331.2 UNK7MU4.3
N18143097: length 1.3
  BOTTOM w0.305: UNK7MU4.1 UNK7C299.2
N18143098: length 5.6
  BOTTOM w0.305: UNK7MU4.6 321.94,141.49 UNK7C301.1 UNK7C300.1 ; UNK7C300.1 320.99,141.7 UNK7MU4.5 ; UNK7C300.1 UNK7MR18.1
N18143103: length 2.2
  BOTTOM w0.305: UNK7MU4.4 318.71,140.12 UNK7C298.2 UNK7MBD1.2
N18143132: length 5.8
  BOTTOM w0.254: UNK7MU1.4 308.09,144.79 308.55,145.24 308.55,146.64 308.17,147.01 UNK7MR7.2 UNK7MR1.2
N18143142: length 8.1
  BOTTOM w0.381: UNK7MR8.1 314.07,133.69 312.49,135.27 UNK7MU3.2
  BOTTOM w0.508: UNK7MR9.1 316.89,134.73 UNK7MR8.1
N18143179: length 1.6
  BOTTOM w0.508: UNK7MR13.2 UNK7MK2.1
N18143184: length 11.2
  BOTTOM w0.508: UNK7MK2.3 UNK7MK4.4 316.42,141.43 315.79,142.07 315.79,145.37 ; UNK7MK3.3 316.36,147.91 315.79,147.34 315.79,145.37 ; 315.79,145.37 UNK7MK1.3
N18143191: length 1.3
  BOTTOM w0.508: UNK7MK3.1 UNK7MR14.1
N18143195: length 1.6
  BOTTOM w0.508: UNK7MR16.2 UNK7MK4.1
N18143216: length 1.1
  BOTTOM w0.508: UNK7MR9.2 UNK7MR10.1
N18143217: length 1.6
  BOTTOM w0.508: UNK7MR11.2 UNK7MK1.1
N18143244: length 1
  BOTTOM w0.16: UNK7U449.6 UNK7R980.1
N18143255: length 2
  BOTTOM w0.16: UNK7U449.9 UNK7R981.2 UNK7R982.2
N18143396: length 8.2
  L19_SIGNAL w0.076: v2(309.85,181.7) 309.53,181.38 305.85,181.38 305.83,181.4
  L19_SIGNAL w0.102: v2(303.77,179.01) 303.77,179.83 305.35,181.4 305.83,181.4
  BOTTOM w0.16: UNK7R1090.1 v2(303.77,179.01)
N18143403: length 2.2
  BOTTOM w0.16: UNK7R1091.1 UNK7K113.1
N18145529: length 1.4
  TOP w0.203: UNK7R172.1 v1(294.66,192.22)
  BOTTOM w0.16: v1(294.66,192.22) 294.9,192.22 295.16,191.95 UNK7U408.A1
N18145532: length 0.6
  TOP w0.305: UNK7R661.1 292.23,191.29 v1(292.16,191.22)
N18145536: length 1.4
  TOP w0.16: UNK7R662.1 v1(294.66,180.65)
  BOTTOM w0.16: v1(294.66,180.65) 294.9,180.65 295.16,180.39 UNK7U409.A1
N18145539: length 0.6
  TOP w0.305: v1(292.16,179.65) 292.23,179.72 UNK7R663.1
N18145564: length 1.1
  TOP w0.254: v1(294.16,179.15) 294.13,179.12 UNK7R672.1
  BOTTOM w0.16: UNK7U409.C2 v1(294.16,179.15)
N18145603: length 1.1
  TOP w0.254: UNK7R659.1 294.13,190.69 v1(294.16,190.72)
  BOTTOM w0.16: UNK7U408.C2 v1(294.16,190.72)
N18146418: length 2.5
  BOTTOM w0.16: UNK7U19.8 UNK7R204.1
N18146513: length 2.8
  BOTTOM w0.16: UNK7U18.8 UNK7R201.1
N18146573: length 1
  BOTTOM w0.305: UNK7U450.6 UNK7R983.1
N18146584: length 2
  BOTTOM w0.305: UNK7U450.9 UNK7R984.2 UNK7R985.2
N18146591: length 1
  BOTTOM w0.305: UNK7U451.6 UNK7R986.1
N18146598: length 2
  BOTTOM w0.305: UNK7U451.9 UNK7R987.2 UNK7R988.2
N18146657: length 1
  BOTTOM w0.305: UNK7U452.6 UNK7R989.1
N18146664: length 2
  BOTTOM w0.305: UNK7R991.2 UNK7R990.2 UNK7U452.9
N18146674: length 0.9
  BOTTOM w0.305: UNK7U452.1 325.4,214.07 UNK7C1066.2
N18146676: length 0.9
  BOTTOM w0.305: UNK7C1067.2 325.9,214.07 UNK7U452.2
N18150612: length 3.6
  BOTTOM w0.508: UNK8U108.1 UNK8R511.1 UNK8R510.2
N18150618: length 14
  TOP w0.508: v2(347.86,205.29) v2(347.1,205.29) 339.85,205.29 UNK8TP_MUX_3V3.1
N18150619: length 2.5
  BOTTOM w0.508: UNK8U108.3 340.34,203.27 339.8,203.81 UNK8R509.1
N18150658: length 0.8
  BOTTOM w0.16: UNK8U31.15 UNK8R162.1
N18151311: length 2.9
  L33_SIGNAL w0.076: 346.44,184.63 346.93,184.63 v2(347.25,184.96)
  L33_SIGNAL w0.091: v2(344.65,184.3) 344.93,184.58 346.39,184.58 346.44,184.63
N18151380: length 1.3
  BOTTOM w0.305: UNK8R331.2 UNK8MU4.3
N18151414: length 1.3
  BOTTOM w0.305: UNK8MU4.1 UNK8C299.2
N18151415: length 5.6
  BOTTOM w0.305: UNK8MU4.6 361.94,141.49 UNK8C301.1 UNK8C300.1 ; UNK8MU4.5 360.99,141.7 UNK8C300.1 ; UNK8C300.1 UNK8MR18.1
N18151420: length 2.2
  BOTTOM w0.305: UNK8MBD1.2 UNK8C298.2 UNK8MU4.4
N18151449: length 5.8
  BOTTOM w0.254: UNK8MU1.4 348.09,144.79 348.55,145.24 348.55,146.64 348.17,147.01 UNK8MR7.2 UNK8MR1.2
N18151459: length 8.1
  BOTTOM w0.381: UNK8MU3.2 352.49,135.27 354.07,133.69 UNK8MR8.1
  BOTTOM w0.508: UNK8MR9.1 356.89,134.73 UNK8MR8.1
N18151496: length 1.6
  BOTTOM w0.508: UNK8MR13.2 UNK8MK2.1
N18151501: length 11.2
  BOTTOM w0.508: UNK8MK1.3 355.79,145.37 ; 355.79,145.37 355.79,147.34 356.36,147.91 UNK8MK3.3 ; 355.79,145.37 355.79,142.07 356.42,141.43 UNK8MK4.4 UNK8MK2.3
N18151508: length 1.3
  BOTTOM w0.508: UNK8MK3.1 UNK8MR14.1
N18151512: length 1.6
  BOTTOM w0.508: UNK8MR16.2 UNK8MK4.1
N18151533: length 1.1
  BOTTOM w0.508: UNK8MR9.2 UNK8MR10.1
N18151534: length 1.6
  BOTTOM w0.508: UNK8MR11.2 UNK8MK1.1
N18151561: length 1
  BOTTOM w0.16: UNK8U449.6 UNK8R980.1
N18151572: length 2
  BOTTOM w0.16: UNK8U449.9 UNK8R981.2 UNK8R982.2
N18151713: length 8.2
  L19_SIGNAL w0.076: v2(349.85,181.7) 349.53,181.38 345.85,181.38 345.83,181.4
  L19_SIGNAL w0.102: 345.83,181.4 345.35,181.4 343.77,179.83 v2(343.77,179.01)
  BOTTOM w0.16: UNK8R1090.1 v2(343.77,179.01)
N18151720: length 2.2
  BOTTOM w0.16: UNK8R1091.1 UNK8K113.1
N18153846: length 1.4
  TOP w0.203: UNK8R172.1 v1(334.66,192.22)
  BOTTOM w0.16: UNK8U408.A1 335.16,191.95 334.89,192.22 v1(334.66,192.22)
N18153849: length 0.6
  TOP w0.305: UNK8R661.1 332.23,191.29 v1(332.16,191.22)
N18153853: length 1.4
  TOP w0.16: UNK8R662.1 v1(334.66,180.65)
  BOTTOM w0.16: v1(334.66,180.65) 334.89,180.65 335.16,180.39 UNK8U409.A1
N18153856: length 0.6
  TOP w0.305: UNK8R663.1 332.23,179.72 v1(332.16,179.65)
N18153881: length 1.1
  TOP w0.254: UNK8R672.1 334.13,179.12 v1(334.16,179.15)
  BOTTOM w0.16: UNK8U409.C2 v1(334.16,179.15)
N18153920: length 1.1
  TOP w0.254: UNK8R659.1 334.13,190.69 v1(334.16,190.72)
  BOTTOM w0.16: UNK8U408.C2 v1(334.16,190.72)
N18154735: length 2.5
  BOTTOM w0.16: UNK8U19.8 UNK8R204.1
N18154830: length 2.8
  BOTTOM w0.16: UNK8U18.8 UNK8R201.1
N18154890: length 1
  BOTTOM w0.305: UNK8U450.6 UNK8R983.1
N18154901: length 2
  BOTTOM w0.305: UNK8U450.9 UNK8R984.2 UNK8R985.2
N18154908: length 1
  BOTTOM w0.305: UNK8U451.6 UNK8R986.1
N18154915: length 2
  BOTTOM w0.305: UNK8U451.9 UNK8R987.2 UNK8R988.2
N18154974: length 1
  BOTTOM w0.305: UNK8U452.6 UNK8R989.1
N18154981: length 2
  BOTTOM w0.305: UNK8U452.9 UNK8R990.2 UNK8R991.2
N18154991: length 0.9
  BOTTOM w0.305: UNK8C1066.2 365.4,214.07 UNK8U452.1
N18154993: length 0.9
  BOTTOM w0.305: UNK8U452.2 365.9,214.07 UNK8C1067.2
N18278718: length 1
  BOTTOM w0.305: U452.6 R989.1
N18278732: length 2
  BOTTOM w0.305: U452.9 R990.2 R991.2
N18278758: length 0.9
  BOTTOM w0.305: C1066.2 245.4,274.07 U452.1
N18278790: length 0.9
  BOTTOM w0.305: C1067.2 245.9,274.07 U452.2
N18477102: length 7.2
  BOTTOM w0.16: U79.6 80.26,278.6 80.06,278.8 78.71,278.8 76.57,276.65 U80.3
N18477108: length 5.6
  BOTTOM w0.16: U79.4 78.69,277.6 77.22,276.12 U80.2
N18477229: length 5.9
  BOTTOM w0.16: U79.10 85.09,278.1 86.92,279.93 U405.2
N18477291: length 5.7
  BOTTOM w0.16: U79.8 82.32,279.37 82.65,279.7 85.52,279.7 86.17,280.35 U405.1
N18477301: length 7.4
  BOTTOM w0.16: U79.12 85.36,277.1 87.57,279.31 U405.3
N18479086: length 5.9
  BOTTOM w0.16: U415.2 86.92,266.22 85.09,264.39 U414.10
N18479100: length 7.2
  BOTTOM w0.16: U414.6 80.26,264.88 80.06,265.08 78.71,265.08 76.57,262.93 U413.3
N18479120: length 4.2
  BOTTOM w0.16: U414.2 80.26,262.88 80.06,262.69 78.71,262.69 77.97,261.94 U413.1
N18479142: length 5.6
  BOTTOM w0.16: U413.2 77.22,262.41 78.69,263.88 U414.4
N18479202: length 5.7
  BOTTOM w0.16: U414.8 82.32,265.65 82.65,265.99 85.52,265.99 86.17,266.63 U415.1
N18479218: length 7.4
  BOTTOM w0.16: U415.3 87.57,265.6 85.36,263.38 U414.12
N18480061: length 2
  BOTTOM w0.16: U403.13 539.15,221.17 538.75,220.78 R601.1
N18480064: length 3.3
  BOTTOM w0.16: U403.11 540.94,219.9 540.41,219.38 R602.1
N18480115: length 26
  BOTTOM w0.305: R939.1 R937.1 R938.1 R940.1 534.61,223.49 537.49,226.37 C895.1 ; C895.1 C894.1 BD1721.2 547.54,226.37 547.94,225.97 R936.1 R934.1 R933.1 R935.1 ; C895.1 U403.20
N18480820: length 26
  BOTTOM w0.305: R943.1 R941.1 R942.1 R944.1 547.56,212.64 547.16,213.03 BD1722.2 C983.1 C984.1 ; C984.1 537.11,213.03 534.23,210.16 R948.1 R946.1 R945.1 R947.1 ; C984.1 U434.20
N18480908: length 2.1
  BOTTOM w0.16: U434.4 543.73,209.84 R758.1
N18480914: length 2.1
  BOTTOM w0.16: U434.6 543.73,208.84 R753.1
N18480920: length 2.2
  BOTTOM w0.16: U434.8 542.82,207.84 543.41,207.24 R755.1
N18480930: length 2
  BOTTOM w0.16: U434.17 538.77,209.84 538.37,210.24 R757.1
N18480954: length 2.2
  BOTTOM w0.16: U434.2 542.82,210.84 543.41,211.43 R751.1
N18480970: length 1.8
  BOTTOM w0.16: U434.15 R752.1
N18480990: length 2
  BOTTOM w0.16: R754.1 538.37,207.44 538.77,207.84 U434.13
N18480996: length 3.3
  BOTTOM w0.16: R756.1 540.03,206.04 540.55,206.57 U434.11
N18482064: length 10.9
  BOTTOM w0.305: U435.20 C986.1 C985.1 BD1723.2 547.16,198.94 547.56,198.54 R952.1 R950.1
N18482160: length 2.1
  BOTTOM w0.16: R766.1 543.73,195.74 U435.4
N18482210: length 2.2
  BOTTOM w0.16: R759.1 543.41,197.34 542.82,196.74 U435.2
N19145542: length 0.9
  BOTTOM w0.16: SR30.2 v3(560.34,173.14)
N19145546: length 0.9
  BOTTOM w0.16: SR26.2 v3(569.79,162.48)
N19145550: length 3.5
  BOTTOM w0.16: SR26.1 SC29.1 SK5.7
N19145556: length 0.9
  BOTTOM w0.16: SR29.2 v3(557.97,162.48)
N19145558: length 3.5
  BOTTOM w0.16: SR29.1 SC30.1 SK5.2
N19145560: length 0.9
  BOTTOM w0.16: SR25.1 v3(569.79,168.7)
N19145564: length 3.5
  BOTTOM w0.16: SK5.6 SC26.1 SR25.2
N19145568: length 0.9
  BOTTOM w0.16: SR27.2 v3(567.42,173.14)
N19145576: length 3.4
  BOTTOM w0.16: SR27.1 SC25.1 SK5.5
N19145584: length 3.5
  BOTTOM w0.16: SK5.3 SC27.1 SR28.2
N19145590: length 3.4
  BOTTOM w0.16: SK5.4 SC28.1 SR30.1
N19145592: length 0.9
  BOTTOM w0.16: SR28.1 v3(557.97,168.7)
N19145780: length 0.9
  BOTTOM w0.16: SR36.2 v3(543.83,173.14)
N19145784: length 0.9
  BOTTOM w0.16: SR35.2 v3(541.46,162.48)
N19145790: length 0.9
  BOTTOM w0.16: SR33.2 v3(550.91,173.14)
N19145800: length 0.9
  BOTTOM w0.16: SR32.2 v3(553.28,162.48)
N19145804: length 3.5
  BOTTOM w0.16: SR32.1 SC35.1 SK6.7
N19145813: length 3.5
  BOTTOM w0.16: SK6.3 SC33.1 SR34.2
N19145817: length 3.4
  BOTTOM w0.16: SR33.1 SC31.1 SK6.5
N19145819: length 3.5
  BOTTOM w0.16: SR35.1 SC36.1 SK6.2
N19145821: length 0.9
  BOTTOM w0.16: SR31.1 v3(553.28,168.7)
N19145825: length 3.5
  BOTTOM w0.16: SR31.2 SC32.1 SK6.6
N19145869: length 3.4
  BOTTOM w0.16: SK6.4 SC34.1 SR36.1
N19145875: length 0.9
  BOTTOM w0.16: SR34.1 v3(541.46,168.7)
N19146153: length 0.9
  BOTTOM w0.16: SR41.2 v3(541.46,145.97)
N19146155: length 0.9
  BOTTOM w0.16: SR39.2 v3(550.91,156.63)
N19146167: length 0.9
  BOTTOM w0.16: SR42.2 v3(543.83,156.63)
N19146177: length 3.4
  BOTTOM w0.16: SK7.5 SC37.1 SR39.1
N19146179: length 3.5
  BOTTOM w0.16: SK7.3 SC39.1 SR40.2
N19146183: length 3.5
  BOTTOM w0.16: SK7.7 SC41.1 SR38.1
N19146185: length 0.9
  BOTTOM w0.16: SR38.2 v3(553.28,145.97)
N19146193: length 3.5
  BOTTOM w0.16: SK7.2 SC42.1 SR41.1
N19146199: length 3.5
  BOTTOM w0.16: SK7.6 SC38.1 SR37.2
N19146205: length 0.9
  BOTTOM w0.16: SR37.1 v3(553.28,152.19)
N19146217: length 3.4
  BOTTOM w0.16: SR42.1 SC40.1 SK7.4
N19146247: length 0.9
  BOTTOM w0.16: SR40.1 v3(541.46,152.19)
N19146496: length 0.9
  BOTTOM w0.16: SR47.2 v3(557.97,145.97)
N19146500: length 0.9
  BOTTOM w0.16: SR48.2 v3(560.34,156.63)
N19146502: length 0.9
  BOTTOM w0.16: SR44.2 v3(569.79,145.97)
N19146512: length 0.9
  BOTTOM w0.16: SR45.2 v3(567.42,156.63)
N19146518: length 3.5
  BOTTOM w0.16: SK8.6 SC44.1 SR43.2
N19146522: length 0.9
  BOTTOM w0.16: SR43.1 v3(569.79,152.19)
N19146524: length 3.5
  BOTTOM w0.16: SK8.2 SC48.1 SR47.1
N19146526: length 3.4
  BOTTOM w0.16: SR45.1 SC43.1 SK8.5
N19146528: length 3.5
  BOTTOM w0.16: SR46.2 SC45.1 SK8.3
N19146532: length 3.5
  BOTTOM w0.16: SR44.1 SC47.1 SK8.7
N19146554: length 0.9
  BOTTOM w0.16: SR46.1 v3(557.97,152.19)
N19146556: length 3.4
  BOTTOM w0.16: SR48.1 SC46.1 SK8.4
N19656281: length 26
  BOTTOM w0.305: C400.1 C401.1 BD5.2 547.54,239.32 547.94,238.92 R926.1 R927.1 R925.1 R928.1 ; C400.1 537.49,239.32 534.61,236.44 R932.1 R930.1 R929.1 R931.1 ; C400.1 U70.20
N22558607: length 2.2
  BOTTOM w0.16: U70.2 543.2,237.13 543.79,237.72 R400.1
N22558620: length 2.5
  BOTTOM w0.508: U71.3 525.35,146.61 524.81,146.07 R404.1
N22558621:
  vias: v3(522.99,153.29)
N22558623: length 3.6
  BOTTOM w0.508: R402.2 R401.1 U71.1
N23535319:
  vias: v3(41.91,298.45)
N23799274: length 4.2
  BOTTOM w0.16: U73.2 80.26,290.32 80.06,290.12 78.71,290.12 77.97,289.37 U74.1
N23799277: length 5.6
  BOTTOM w0.16: U73.4 78.69,291.32 77.22,289.84 U74.2
N23799280: length 7.2
  BOTTOM w0.16: U74.3 76.57,290.37 78.71,292.52 80.06,292.52 80.26,292.32 U73.6
N23799283: length 5.7
  BOTTOM w0.16: U72.1 86.17,294.07 85.52,293.42 82.65,293.42 82.32,293.09 U73.8
N23799286: length 5.9
  BOTTOM w0.16: U72.2 86.92,293.65 85.09,291.82 U73.10
N23799289: length 7.4
  BOTTOM w0.16: U73.12 85.36,290.82 87.57,293.03 U72.3
N23799348: length 4.2
  BOTTOM w0.16: U77.1 497.8,223.2 498.55,223.94 499.89,223.94 500.09,224.14 U76.2
N23799351: length 5.6
  BOTTOM w0.16: U76.4 498.53,225.14 497.05,223.66 U77.2
N23799354: length 7.2
  BOTTOM w0.16: U77.3 496.4,224.19 498.55,226.34 499.89,226.34 500.09,226.14 U76.6
N23799357: length 5.7
  BOTTOM w0.16: U75.1 506,227.89 505.36,227.25 502.48,227.25 502.15,226.91 U76.8
N23799360: length 5.9
  BOTTOM w0.16: U76.10 504.92,225.64 506.75,227.47 U75.2
N23799363: length 7.4
  BOTTOM w0.16: U75.3 507.4,226.85 505.19,224.64 U76.12
N30783219: length 4.2
  BOTTOM w0.16: U79.2 80.26,276.6 80.06,276.4 78.71,276.4 77.97,275.66 U80.1
N31842551: length 2.1
  BOTTOM w0.16: R589.1 544.11,236.13 U70.4
N31842593: length 2.1
  BOTTOM w0.16: U70.6 544.11,235.13 R590.1
N31842638: length 2.2
  BOTTOM w0.16: U70.8 543.2,234.13 543.79,233.53 R591.1
N31842671: length 2
  BOTTOM w0.16: R592.1 538.75,236.52 539.15,236.13 U70.17
N31842704: length 1.8
  BOTTOM w0.16: U70.15 R593.1
N31842737: length 2
  BOTTOM w0.16: R594.1 538.75,233.73 539.15,234.13 U70.13
N31842770: length 3.3
  BOTTOM w0.16: R595.1 540.41,232.33 540.94,232.86 U70.11
N31842787: length 2.1
  BOTTOM w0.16: U403.4 544.11,223.17 R596.1
N31842830: length 2.1
  BOTTOM w0.16: U403.6 544.11,222.17 R597.1
N31842855: length 2.2
  BOTTOM w0.16: R598.1 543.79,220.58 543.2,221.17 U403.8
N31842884: length 2
  BOTTOM w0.16: R599.1 538.75,223.57 539.15,223.17 U403.17
N31842923: length 2.2
  BOTTOM w0.16: U403.2 543.2,224.17 543.79,224.77 R603.1
N31842948: length 1.8
  BOTTOM w0.16: U403.15 R600.1

## Copper pours and planes (outline as drawn)
DGND on BOTTOM: 306.94,192.04 306.94,203.11 307.68,203.85 308.51,203.85 309.03,204.38 309.03,207.46 308.6,207.89 308.6,213.74 309.72,214.85 314.01,214.85 314.65,214.22 314.65,207.04 316.94,204.75 316.94,193.6 315.94,192.6 313.93,192.6 311.9,190.57 309.23,190.57 309.11,190.7 309.11,190.95 309.48,191.33 311.31,191.33 311.39,191.42 311.39,191.92 310.38,191.92 310.37,191.91 310.36,191.92 307.06,191.92 ; 2 cut-outs
DGND on BOTTOM: 346.94,192.04 346.94,203.11 347.68,203.85 348.51,203.85 349.03,204.38 349.03,207.46 348.6,207.89 348.6,213.74 349.72,214.85 354.01,214.85 354.64,214.22 354.64,207.04 356.94,204.75 356.94,193.6 355.94,192.6 353.93,192.6 351.9,190.57 349.23,190.57 349.11,190.7 349.11,190.95 349.48,191.33 351.31,191.33 351.39,191.42 351.39,191.92 350.38,191.92 350.37,191.91 350.36,191.92 347.06,191.92 ; 2 cut-outs
DGND on BOTTOM: 316.78,243.1 316.78,239.52 315.41,238.15 311.17,238.15 309.69,236.68 309.69,218.41 310.23,217.88 317.87,217.88 318.89,218.9 318.89,223.06 320.73,224.91 320.73,245.04 320.33,245.45 319.28,245.45 318.89,245.05 318.89,243.47 318.61,243.2 316.87,243.2 ; 1 cut-out
DGND on BOTTOM: 236.78,183.1 236.78,179.52 235.41,178.15 231.17,178.15 229.69,176.68 229.69,158.41 230.23,157.88 237.87,157.88 238.89,158.9 238.89,163.06 240.73,164.91 240.73,185.04 240.33,185.45 239.28,185.45 238.89,185.05 238.89,183.47 238.61,183.2 236.87,183.2 ; 1 cut-out
DGND on BOTTOM: 266.94,192.04 266.94,203.11 267.69,203.85 268.51,203.85 269.03,204.38 269.03,207.46 268.6,207.89 268.6,213.74 269.72,214.85 274.01,214.85 274.65,214.22 274.65,207.04 276.94,204.75 276.94,193.6 275.94,192.6 273.93,192.6 271.9,190.57 269.23,190.57 269.11,190.7 269.11,190.95 269.48,191.33 271.31,191.33 271.39,191.42 271.39,191.92 270.38,191.92 270.37,191.91 270.36,191.92 267.06,191.92 ; 2 cut-outs
DGND on BOTTOM: 346.94,252.04 346.94,263.11 347.68,263.85 348.51,263.85 349.03,264.38 349.03,267.46 348.6,267.89 348.6,273.74 349.72,274.85 354.01,274.85 354.64,274.22 354.64,267.04 356.94,264.75 356.94,253.6 355.94,252.6 353.93,252.6 351.9,250.57 349.23,250.57 349.11,250.7 349.11,250.95 349.48,251.33 351.31,251.33 351.39,251.42 351.39,251.92 350.38,251.92 350.37,251.91 350.36,251.92 347.06,251.92 ; 2 cut-outs
DGND on BOTTOM: 356.78,243.1 356.78,239.52 355.41,238.15 351.17,238.15 349.69,236.68 349.69,218.41 350.23,217.88 357.87,217.88 358.89,218.9 358.89,223.06 360.73,224.91 360.73,245.04 360.33,245.45 359.28,245.45 358.89,245.05 358.89,243.47 358.61,243.2 356.87,243.2 ; 1 cut-out
DGND on BOTTOM: 276.78,183.1 276.78,179.52 275.41,178.15 271.17,178.15 269.69,176.68 269.69,158.41 270.23,157.88 277.87,157.88 278.89,158.9 278.89,163.06 280.73,164.91 280.73,185.04 280.33,185.45 279.28,185.45 278.89,185.05 278.89,183.47 278.61,183.2 276.87,183.2 ; 1 cut-out
