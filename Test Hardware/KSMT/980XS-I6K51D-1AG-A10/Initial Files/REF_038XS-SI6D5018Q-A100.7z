# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D41104: length 379
  L19_SIGNAL w0.254: v2(348.55,188.86) 347.24,190.17
  L19_SIGNAL w0.508: 347.24,190.17 347.24,191.23 347.83,191.82 347.83,193.79 349.51,195.47 350.23,195.47 350.63,195.07 352.92,195.07 353.3,195.45 356.26,195.45 357.76,193.95 370.34,193.95 383.05,206.67 383.05,299.91 387.39,304.25 387.39,320.83 391.68,325.12 501.49,325.12 511.98,335.61 511.98,343.72 520.98,352.72 520.98,365.64 527.45,372.12 559.28,372.12 560.06,372.89 560.06,379.72 D411.04
D41105: length 431.5
  L33_SIGNAL w0.091: UNK8K39.2 344.26,177.51 343.15,178.62 343.15,193.43 342.25,194.33 342.25,200.41 340.22,202.44 340.22,208.88 339.06,210.04 339.06,216.53 338.62,216.97 338.62,226.26 340.49,228.13 340.49,233.03 337.74,235.78 335.33,235.78 333.23,237.87 333.23,241.66 331.77,243.13 331.77,246.45 330.18,248.03 330.18,254.63 332.03,256.48 332.03,257.49 331.42,258.11 331.42,264.38 332.19,265.15 332.19,291.3 342.93,302.04 432.93,302.04 448.88,317.98 495.2,317.98 502.88,325.66 502.88,373.59 516.83,387.55 554.79,387.55 D411.05
D41106: length 364.8
  L33_SIGNAL w0.076: v2(353.1,189.51) 353.43,189.83 353.43,191.08
  L33_SIGNAL w0.091: 353.43,191.08 353.02,191.49 353.02,202.13 355.34,204.45 355.34,212.29 358.51,215.45 358.51,223.54 356.11,225.94 356.11,237.52 358.9,240.31 358.9,243.06 358.21,243.75 358.21,249.12 354.49,252.84 354.49,268.9 355,269.41 355,279.96 355.83,280.79 355.83,282.17 357.53,283.87 359.49,283.87 370.23,294.61 381.53,294.61 383.4,296.48 433.94,296.48 443.37,305.92 499.52,305.92 507.49,313.89 507.49,354.32 527.57,374.41 549.67,374.41 D411.06
D41107: length 398.5
  L23_SIGNAL w0.091: v2(344,199) 343.27,198.27 343.27,186 344.28,184.98 345.04,184.98 345.3,184.73 345.73,184.73 v2(345.95,184.96)
  L33_SIGNAL w0.091: v2(344,199) 344,200.69 341.23,203.46 341.23,209.94 340.81,210.36 340.81,215.94 339.26,217.5 339.26,225.99 339.6,226.33 339.6,226.72 340.85,227.97 340.85,235.18 338.32,237.71 338.32,253.75 339.07,254.51 339.96,254.51 340.85,255.4 340.85,267.97 338.95,269.87 338.95,288.2 352.37,301.62 433.11,301.62 449.05,317.56 498.49,317.56 503.3,322.37 503.3,372.74 517.62,387.07 550.19,387.07 D411.07
D41108: length 365.9
  L33_SIGNAL w0.076: 352.78,191.08 352.78,187.88 v2(353.1,187.56)
  L33_SIGNAL w0.091: D411.08 545.08,374.9 527.05,374.9 507.07,354.92 507.07,315.65 500.11,308.7 445.56,308.7 433.76,296.9 383.09,296.9 381.24,295.05 370,295.05 359.46,284.51 357.53,284.51 354.58,281.56 354.58,269.61 354.04,269.07 354.04,264.34 353.48,263.77 353.48,252.22 354.23,251.46 355.25,251.46 357.76,248.95 357.76,239.82 355.21,237.27 355.21,228.35 350.24,223.38 350.24,222.23 349.36,221.35 349.36,218.53 350.09,217.81 352.36,217.81 354.93,215.24 354.93,204.63 352.59,202.29 352.59,191.27 352.78,191.08
D41109: length 386.7
  L33_SIGNAL w0.076: 347.63,191.08 347.63,189.04 347.58,188.99 347.58,185.93 v2(347.25,185.61)
  L33_SIGNAL w0.091: 347.63,191.08 347.63,198.58 342.81,203.4 342.81,209.42 341.23,211.01 341.23,216.03 341.17,216.09 341.17,216.1 340.73,216.54 340.73,221.36 339.96,222.12 339.96,226.57 341.23,227.84 341.23,236.21 338.74,238.7 338.74,253.52 339.33,254.11 340.2,254.11 341.24,255.15 341.24,270.38 340.65,270.97 340.65,283.7 342.11,285.17 342.11,288.9 354.42,301.2 433.28,301.2 449.22,317.14 498.73,317.14 503.71,322.13 503.71,371.89 516.88,385.06 547.12,385.06 D411.09
D41110: length 365.5
  L33_SIGNAL w0.076: 352.13,191.08 352.13,189.18 v2(352.45,188.86)
  L33_SIGNAL w0.091: D411.10 542.09,376.99 527.62,376.99 506.65,356.03 506.65,315.95 499.82,309.12 445.39,309.12 433.59,297.32 382.92,297.32 381.08,295.48 369.09,295.48 358.57,284.96 356.54,284.96 352.73,281.16 350.41,281.16 349.13,279.88 349.13,271.37 349.77,270.74 349.77,265.43 347.06,262.72 347.06,253.73 343.23,249.9 343.23,240.7 349.87,234.06 350.31,233.63 351.27,232.67 351.27,225.68 349.87,224.28 349.87,222.38 348.85,221.36 348.85,218.47 350.66,216.66 352.03,216.66 354.51,214.18 354.51,204.8 351.39,201.69 351.39,192.28 352.13,191.54 352.13,191.08
D41111: length 379.6
  L33_SIGNAL w0.076: 348.53,191.08 349.53,190.08 349.53,188.53 v2(349.85,188.21)
  L33_SIGNAL w0.091: 348.53,191.08 348.05,191.56 348.05,201.13 343.23,205.95 343.23,209.8 342.81,210.22 342.81,218.39 341.29,219.91 341.29,221.04 342.12,221.87 342.12,228.22 342.27,228.37 342.27,231.81 341.87,232.21 341.87,236.17 339.19,238.84 339.19,253.36 339.52,253.69 340.91,253.69 342.32,255.1 342.32,266.63 341.61,267.33 341.61,269.2 342.38,269.96 342.38,282.15 344.86,284.63 344.86,290.02 355.62,300.78 433.46,300.78 446.83,314.16 499.35,314.16 504.13,318.94 504.13,371.04 517.65,384.56 542.54,384.56 D411.11
D41112: length 336.4
  L33_SIGNAL w0.091: D411.12 537.46,377.44 526.79,377.44 506.23,356.88 506.23,316.15 499.63,309.55 445.19,309.55 433.37,297.73 382.67,297.73 381.84,296.9 369.9,296.9 358.5,285.5 356.39,285.5 353.08,282.19 349.44,282.19 348.5,281.25 348.5,264.92 346.6,263.02 346.6,254.79 342.79,250.99 342.79,239.33 344.34,237.78 344.34,236.73 345.48,235.59 345.48,234.6 348.74,231.34 348.74,228.47 347.58,227.32 347.58,222.16 348.47,221.27 348.47,218.33 353.18,213.63 v2(353.18,211.1)
  BOTTOM w0.16: v2(353.18,211.1) 352.69,210.61 UNK8U449.4
D41113: length 362.1
  L33_SIGNAL w0.076: v2(350.5,189.51) 350.83,189.83 350.83,191.08
  L33_SIGNAL w0.091: 350.83,191.08 349.52,192.39 349.52,193.72 348.92,194.32 348.92,202.03 346.49,204.45 346.49,211.78 345.2,213.08 345.2,218.41 343.6,220.02 343.6,220.03 342.87,220.76 342.87,227.93 343.12,228.18 343.12,229.73 344.07,230.68 344.07,235.21 340.81,238.47 340.81,251.59 343.05,253.83 343.05,255.36 344.23,256.53 344.23,257.49 343.16,258.56 343.16,266.32 343.94,267.1 343.94,270.6 344.64,271.3 344.64,281.67 346,283.03 346,286.57 351.38,291.95 359.33,291.95 366.14,298.75 368.96,298.75 370.15,299.95 433.8,299.95 447.18,313.32 499.7,313.32 504.97,318.59 504.97,359.68 527.35,382.06 537,382.06 D411.13
D41114: length 332.2
  L33_SIGNAL w0.091: D411.14 534.47,379.53 527.61,379.53 505.81,357.73 505.81,316.33 499.45,309.97 445.01,309.97 434.16,299.11 383.39,299.11 382.42,298.15 369.72,298.15 357.56,285.98 356.11,285.98 354.5,284.37 350.28,284.37 348.7,282.79 347.32,282.79 346.52,281.99 346.52,267.16 345.02,265.67 345.02,253.74 342.43,251.14 342.43,251.13 342.25,250.96 342.25,239.27 343.92,237.61 343.92,236.55 344.91,235.57 344.91,228.61 345.3,228.22 345.3,222.61 347.08,220.83 347.08,217.21 352.19,212.1 v2(352.19,211.11)
  BOTTOM w0.16: UNK8U449.3 v2(352.19,211.11)
D41115: length 364.5
  L33_SIGNAL w0.076: 349.29,191.08 350.18,190.19 350.18,189.18 v2(349.85,188.86)
  L33_SIGNAL w0.091: D411.15 532.37,382.51 516.88,382.51 504.55,370.19 504.55,318.77 499.53,313.74 447.01,313.74 433.63,300.36 369.76,300.36 368.52,299.12 355.77,299.12 353.42,296.77 352.7,296.77 345.39,289.46 345.39,284.48 342.74,281.83 342.74,269.81 342.69,269.75 342.69,254.94 340.34,252.6 340.34,238.29 342.56,236.07 342.56,233.15 343.06,232.65 343.06,232.1 342.69,231.73 342.69,228.27 342.5,228.08 342.5,220.6 343.23,219.88 343.23,213.14 345.2,211.17 345.2,204.57 348.5,201.27 348.5,194.15 349.1,193.54 349.1,191.27 349.29,191.08
D41116: length 354.2
  L33_SIGNAL w0.076: v2(353.1,186.91) 352.78,187.23 351.67,187.23 351.48,187.42 351.48,191.08
  L33_SIGNAL w0.091: D411.16 529.82,379.96 526.77,379.96 505.39,358.58 505.39,318.42 499.87,312.9 447.35,312.9 433.98,299.53 370.39,299.53 367.49,296.62 366.17,296.62 357.17,287.63 356.24,287.63 355.37,286.77 355.37,286.23 353.97,284.84 347.39,284.84 346.67,284.12 346.67,282.92 345.27,281.52 345.27,267.77 344.59,267.09 344.59,254.69 343.59,253.69 343.59,253.69 341.29,251.39 341.29,251.39 341.28,251.38 341.28,238.6 344.49,235.4 344.49,228.55 343.25,227.31 343.25,222.52 343.27,222.51 343.27,222.43 346.49,219.2 346.49,213.54 348.7,211.33 348.7,207.8 349.33,207.17 349.33,194.5 349.94,193.89 349.94,192.62 351.48,191.08
D41205: length 437
  L33_SIGNAL w0.076: v2(313.76,188.86) 314.19,189.29 314.19,191.08
  L33_SIGNAL w0.091: D412.05 554.79,407.87 524.71,407.87 497.49,380.65 497.49,330.04 493.88,326.42 449.39,326.42 432.94,309.97 326.23,309.97 319.39,303.14 319.39,282.67 319.4,282.67 319.4,282.08 317.17,279.86 317.17,275.5 316.47,274.81 316.47,269.3 315.34,268.16 315.34,253.23 320.51,248.05 320.51,240.6 319.37,239.47 319.37,238.88 316.96,236.47 316.96,226.23 319.39,223.79 319.39,214.28 318.57,213.46 318.57,210.61 317.94,209.98 317.94,207.66 316.84,206.56 316.84,204.76 314.49,202.41 314.49,191.57 314.19,191.27 314.19,191.08
D41206: length 435.5
  L33_SIGNAL w0.091: UNK8K39.7 342.88,164.32 342.88,170.59 341.92,171.55 341.92,175.3 342.71,176.09 342.71,193.25 340.9,195.06 340.9,200.49 339.71,201.68 339.71,208.8 338.64,209.86 338.64,216.34 332.86,222.12 332.86,225.55 331.46,226.94 331.46,235.2 330.06,236.6 330.06,247.64 329.68,248.02 329.68,255.26 330.87,256.46 330.87,259.12 330.87,259.13 330.87,260.13 330.87,260.14 330.87,292.26 341.07,302.46 432.76,302.46 448.7,318.4 494.93,318.4 502.46,325.93 502.46,374.44 522.74,394.73 549.67,394.73 D412.06
D41207: length 434
  L33_SIGNAL w0.076: v2(313.76,187.56) 314.08,187.88 314.54,187.88 314.73,188.07 314.73,190.29 314.57,190.45 314.57,191.08
  L33_SIGNAL w0.091: D412.07 550.19,407.39 525.24,407.39 497.91,380.06 497.91,329.86 494.05,326 449.56,326 433.11,309.55 326.57,309.55 320.79,303.77 320.79,281.81 318.45,279.47 318.45,276.68 317.55,275.78 317.55,267.44 316.48,266.37 316.48,265.24 315.76,264.52 315.76,254.15 316.51,253.4 316.51,252.71 317.46,251.76 318.15,251.76 321,248.91 321,239.24 320.25,238.5 319.62,238.5 317.38,236.26 317.38,226.4 320.55,223.23 320.55,213.43 319.84,212.72 319.84,209.76 319.09,209.01 319.09,207.21 317.26,205.37 317.26,204.59 314.91,202.24 314.91,191.47 314.57,191.13 314.57,191.08
D41208: length 434.6
  L33_SIGNAL w0.091: D412.08 545.08,395.22 522.22,395.22 502.04,375.04 502.04,327.92 495.93,321.81 451.51,321.81 432.59,302.88 339.71,302.88 330.51,293.68 330.51,260.11 330.51,260.09 330.51,259.17 330.51,259.15 330.51,256.98 329.05,255.52 329.05,233.81 330.95,231.9 330.95,192.15 329.55,190.75 329.55,174.22 330.19,173.59 330.19,163.07 328.67,161.54 324.02,161.54 UNK7K113.6
D41209: length 422.5
  L33_SIGNAL w0.076: v2(315.7,188.86) 315.7,191.04
  L33_SIGNAL w0.091: D412.09 547.12,405.38 524.25,405.38 498.33,379.46 498.33,329.69 494.23,325.58 449.73,325.58 433.28,309.13 329.45,309.13 321.27,300.95 321.27,281.77 318.82,279.31 318.82,276.53 318.61,276.32 318.61,270.74 318,270.13 318,267.26 316.92,266.18 316.92,265.08 316.19,264.35 316.19,254.31 316.73,253.77 316.95,253.56 316.95,252.89 317.64,252.2 318.31,252.2 321.45,249.05 321.45,239.06 320.4,238 319.75,238 318.29,236.54 318.29,226.18 320.97,223.5 320.97,209.96 320.09,209.08 320.09,207.17 318.45,205.53 318.45,205.14 315.33,202.02 315.33,192.68 315.7,192.3 315.7,191.04
D41210: length 418.7
  L33_SIGNAL w0.091: v2(317.83,172.39) 321.21,175.77 321.21,185.46 330.59,194.83 330.59,231.75 328.68,233.66 328.68,255.79 330.14,257.25 330.14,259.19 330.14,259.21 330.14,260.05 330.14,260.07 330.14,295.34 338.1,303.3 432.41,303.3 451.34,322.22 495.75,322.22 501.62,328.09 501.62,375.64 523.3,397.31 542.09,397.31 D412.10
  BOTTOM w0.16: UNK7K32.2 v2(317.83,172.39)
D41211: length 418.2
  L33_SIGNAL w0.076: v2(315.7,188.21) 316.07,188.57
  L33_SIGNAL w0.091: D412.11 542.54,404.88 524.77,404.88 498.75,378.86 498.75,329.51 494.4,325.16 449.91,325.16 433.46,308.71 329.8,308.71 322.54,301.46 322.54,275.06 319.8,272.31 319.8,269.82 319.04,269.06 319.04,267.22 317.4,265.58 317.4,264.96 316.61,264.17 316.61,254.49 317.39,253.7 317.39,253.06 317.84,252.62 318.49,252.62 319.38,251.72 320.31,251.72 322.55,249.48 322.55,238.71 322.3,238.45 321.44,238.45 320.57,237.58 319.92,237.58 318.71,236.37 318.71,226.35 321.39,223.67 321.39,208.65 320.61,207.87 320.61,207.1 318.87,205.36 318.87,204.97 316.43,202.53 316.43,188.93 316.07,188.57
D41212: length 424.5
  L33_SIGNAL w0.091: v2(313.63,172.39) 313.63,173.62 320.6,180.58 320.6,186.31 321.61,187.32 321.61,187.33 327.97,193.69 327.98,193.69 330.19,195.9 330.19,198.63 330.22,198.66 330.22,231.53 326.73,235.03 326.73,251.37 323.52,254.58 321.49,254.58 320.48,255.58 320.48,260.95 329.46,269.93 329.46,296.69 336.48,303.72 432.24,303.72 451.17,322.64 495.58,322.64 501.2,328.27 501.2,376.23 522.73,397.76 537.46,397.76 D412.12
  BOTTOM w0.16: UNK7K32.7 v2(313.63,172.39)
D41213: length 417.9
  L33_SIGNAL w0.076: 316.07,186.58 314.08,186.58 v2(313.76,186.91)
  L33_SIGNAL w0.091: 316.07,186.58 316.36,186.58 317.27,187.49 317.27,201.44 321.57,205.74 321.57,207.36 323.19,208.98 324.26,208.98 326.17,210.89 326.17,214.95 326.76,215.54 326.76,216.03 326.6,216.19 326.6,223.18 325.64,224.14 322.92,224.14 319.54,227.51 319.54,235.26 321.9,237.61 322.66,237.61 323.43,238.39 323.43,250.64 321.5,252.57 319.98,252.57 317.46,255.08 317.46,263.58 320.61,266.73 320.61,267.06 323,269.44 323,270.26 325.29,272.54 325.29,298.11 332.54,305.36 431.37,305.36 450.32,324.31 494.75,324.31 499.59,329.15 499.59,377.67 524.3,402.38 537,402.38 D412.13
D41214: length 420.9
  L33_SIGNAL w0.076: v2(311.81,183) 312.13,182.68 315.9,182.68
  L33_SIGNAL w0.091: 315.9,182.68 316.34,182.68
  L33_SIGNAL w0.508: 316.34,182.68 316.67,182.68 319.37,185.38 319.37,199.64 329.43,209.7 329.43,223.7 328.04,225.09 323.55,225.09 320.54,228.1 320.54,234.51 321.77,235.74 323.9,235.74 325.22,237.06 325.22,251.05 322.34,253.94 321.32,253.94 320.79,254.47 319.81,254.47 319.29,254.99 319.29,261.61 323.19,265.5 323.19,266.76 328.88,272.45 328.88,282.67 328.88,298.4 334.82,304.34 431.88,304.34 450.83,323.29 495.28,323.29 500.6,328.61 500.6,376.64 523.82,399.87 534.49,399.87 D412.14
D41215: length 411.9
  L33_SIGNAL w0.076: v2(314.41,187.56) 314.73,187.23 316.02,187.23 316.07,187.28
  L33_SIGNAL w0.091: D412.15 532.37,402.83 523.73,402.83 499.17,378.27 499.17,329.32 494.58,324.73 450.15,324.73 431.2,305.78 331.18,305.78 324.65,299.25 324.65,275.45 323.99,274.79 323.99,272.77 320.11,268.88 320.11,266.87 317.03,263.79 317.03,254.91 319.8,252.14 320.48,252.14 322.97,249.65 322.97,238.53 322.47,238.03 321.73,238.03 319.13,235.43 319.13,226.53 321.88,223.77 325.49,223.77 326.24,223.03 326.24,218.79 325.43,217.98 325.43,216.22 323.86,214.65 323.86,212.91 322.8,211.85 322.8,209.32 321.13,207.65 321.13,206.83 320.51,206.22 320.51,205.28 316.85,201.61 316.85,188.06 316.07,187.28
D41216: length 412.9
  L33_SIGNAL w0.076: 316.07,183.33 314.73,183.33 v2(314.41,183)
  L33_SIGNAL w0.091: 316.07,183.33 316.16,183.33 318.8,185.96 318.8,201.58 320.16,202.95 320.22,202.95 324.33,207.06 324.33,207.6 328.67,211.93 328.67,223.51 327.65,224.52 323.13,224.52 319.96,227.69 319.96,235.09 321.38,236.5 322.82,236.5 324.58,238.27 324.58,250.08 321.64,253.02 321.16,253.02 320.42,253.75 319.52,253.75 318.63,254.64 318.63,263.03 321.22,265.62 321.22,266.88 322.85,268.5 323.92,268.5 326.18,270.76 326.18,271.93 327.14,272.9 327.14,297.93 334.15,304.94 431.55,304.94 450.5,323.89 494.93,323.89 500.01,328.97 500.01,377.07 523.38,400.44 529.98,400.44 D412.16
D41301: length 374.2
  L33_SIGNAL w0.091: v2(277.83,172.39) 281.21,175.77 281.21,185.46 290.59,194.83 290.59,231.75 288.68,233.66 288.68,255.79 290.14,257.25 290.14,259.19 290.14,259.21 290.14,260.05 290.14,260.07 290.14,317.32 297.89,325.07 422.35,325.07 446.77,349.48 488.72,349.48 D413.01
  BOTTOM w0.16: UNK6K32.2 v2(277.83,172.39)
D41302: length 315.2
  L33_SIGNAL w0.076: v2(313.76,189.51) 313.81,189.56 313.81,191.08
  L33_SIGNAL w0.091: 313.81,191.08 313.81,191.26 313.43,191.64 313.43,201.94 316.42,204.93 316.42,206.73 317.52,207.83 317.52,213.87 318.93,215.28 318.93,223.67 316.54,226.05 316.54,236.64 318.92,239.02 318.92,239.6 319.44,240.13 319.44,243.12 318.67,243.89 318.67,249.25 314.91,253.01 314.91,268.68 315.42,269.18 315.42,278.03 316.73,279.34 316.73,294.89 317.11,295.27 317.11,304.41 325.63,312.93 426.97,312.93 428.5,311.4 433.04,311.4 452.89,331.25 485.42,331.25 486.45,332.28 486.45,334.05 D413.02
D41303: length 380.3
  L33_SIGNAL w0.091: UNK6K113.6 284.02,161.54 288.67,161.54 290.19,163.07 290.19,173.59 289.55,174.22 289.55,190.75 290.95,192.15 290.95,231.9 289.05,233.81 289.05,255.52 290.51,256.98 290.51,259.15 290.51,259.17 290.51,260.09 290.51,260.11 290.51,316.67 298.49,324.65 422.95,324.65 447.31,349.01 484.11,349.01 D413.03
D41304: length 310.8
  L33_SIGNAL w0.076: v2(313.11,189.51) 313.43,189.83 313.43,191.08
  L33_SIGNAL w0.091: D413.04 481.4,334.08 481.4,332.52 480.57,331.69 452.73,331.69 432.95,311.91 428.75,311.91 427.31,313.35 325.29,313.35 315.46,303.52 315.46,282.71 315.77,282.41 315.77,280.37 315,279.61 315,269.41 314.49,268.9 314.49,252.84 318.21,249.12 318.21,243.75 318.9,243.06 318.9,240.31 316.11,237.52 316.11,225.89 318.51,223.49 318.51,215.45 315.35,212.29 315.35,204.45 313.02,202.13 313.02,191.49 313.43,191.08
D41305: length 369
  L33_SIGNAL w0.091: UNK7K39.7 302.88,164.32 302.88,170.59 301.92,171.55 301.92,175.3 302.71,176.09 302.71,193.25 300.9,195.06 300.9,200.49 299.71,201.68 299.71,208.8 298.64,209.86 298.64,216.34 292.86,222.12 292.86,225.55 291.46,226.94 291.46,235.2 290.06,236.6 290.06,247.64 289.68,248.02 289.68,255.26 290.87,256.46 290.87,259.12 290.87,259.13 290.87,260.13 290.87,260.14 290.87,316.02 299.09,324.23 423.55,324.23 446.22,346.91 481.13,346.91 D413.05
D41306: length 314
  L33_SIGNAL w0.076: 312.78,191.08 312.78,187.88 v2(313.11,187.56)
  L33_SIGNAL w0.091: 312.78,191.08 312.59,191.27 312.59,202.29 314.93,204.63 314.93,215.24 312.36,217.81 310.09,217.81 309.36,218.53 309.36,221.35 310.24,222.23 310.24,223.38 315.21,228.35 315.21,237.27 317.76,239.82 317.76,248.95 315.25,251.46 314.23,251.46 313.48,252.22 313.48,263.77 314.04,264.34 314.04,269.07 314.58,269.61 314.58,306.2 322.15,313.77 427.66,313.77 429.01,312.42 432.89,312.42 437.1,316.64 437.1,318.23 452.64,333.77 476.01,333.77 D413.06
D41307: length 362.1
  L33_SIGNAL w0.091: D413.07 476.53,346.43 446.76,346.43 424.14,323.81 299.68,323.81 292.19,316.32 292.19,265.15 291.42,264.38 291.42,258.11 292.03,257.49 292.03,256.48 290.18,254.63 290.18,248.03 291.77,246.45 291.77,243.13 293.23,241.66 293.23,237.87 295.33,235.78 297.74,235.78 300.49,233.03 300.49,228.13 298.62,226.26 298.62,216.97 299.06,216.53 299.06,210.04 300.22,208.88 300.22,202.44 302.25,200.41 302.25,194.33 303.15,193.43 303.15,178.62 304.26,177.51 UNK7K39.2
D41308: length 311.7
  L33_SIGNAL w0.076: 312.13,191.08 312.13,189.18 v2(312.46,188.86)
  L33_SIGNAL w0.091: D413.08 471.42,334.26 451.86,334.26 436.26,318.66 436.26,316.38 432.82,312.93 429.26,312.93 428,314.19 321.81,314.19 309.13,301.51 309.13,271.37 309.77,270.74 309.77,265.43 307.06,262.72 307.06,253.73 303.23,249.9 303.23,240.7 309.87,234.06 310.31,233.63 311.27,232.67 311.27,225.68 309.87,224.28 309.87,222.38 308.85,221.36 308.85,218.47 310.66,216.66 312.03,216.66 314.51,214.18 314.51,204.8 311.39,201.69 311.39,192.28 312.13,191.54 312.13,191.08
D41309: length 325.7
  L23_SIGNAL w0.091: v2(304,199) 303.27,198.27 303.27,186 304.28,184.98 305.04,184.98 305.3,184.73 305.73,184.73 v2(305.95,184.96)
  L33_SIGNAL w0.091: v2(304,199) 304,200.69 301.23,203.46 301.23,209.94 300.81,210.36 300.81,215.94 299.26,217.5 299.26,225.99 299.6,226.33 299.6,226.72 300.85,227.97 300.85,235.18 298.32,237.71 298.32,253.75 299.07,254.51 299.96,254.51 300.85,255.4 300.85,267.97 298.95,269.87 298.95,293.99 300.78,295.81 300.78,313.84 310.33,323.4 424.74,323.4 445.76,344.42 473.46,344.42 D413.09
D41310: length 280.7
  L33_SIGNAL w0.091: v2(313.18,211.1) 313.18,213.63 308.47,218.33 308.47,221.27 307.58,222.16 307.58,227.32 308.74,228.47 308.74,231.34 305.48,234.6 305.48,235.59 304.34,236.73 304.34,237.78 302.79,239.33 302.79,250.99 306.6,254.79 306.6,263.02 308.5,264.92 308.5,304.43 321.57,317.51 426.22,317.51 445.07,336.35 468.43,336.35 D413.10
  BOTTOM w0.16: v2(313.18,211.1) 312.69,210.61 UNK7U449.4
D41311: length 314.5
  L33_SIGNAL w0.076: v2(307.25,185.61) 307.58,185.93 307.58,188.99 307.63,189.04 307.63,191.08
  L33_SIGNAL w0.091: 307.63,191.08 307.63,198.58 302.81,203.4 302.81,209.42 301.23,211.01 301.23,216.03 301.17,216.09 301.17,216.1 300.73,216.54 300.73,221.36 299.96,222.12 299.96,226.57 301.23,227.84 301.23,236.21 298.74,238.7 298.74,253.52 299.33,254.11 300.2,254.11 301.24,255.15 301.24,270.38 300.65,270.97 300.65,285.29 301.56,286.21 301.56,292.76 302.4,293.6 302.4,311.29 314.09,322.98 425.34,322.98 446.28,343.92 468.88,343.92 D413.11
D41312: length 275
  L33_SIGNAL w0.091: D413.12 463.8,336.8 444.24,336.8 425.79,318.35 321.65,318.35 306.95,303.65 306.95,297.05 306.52,296.62 306.52,267.16 305.03,265.67 305.03,253.74 302.43,251.14 302.43,251.13 302.25,250.96 302.25,239.27 303.92,237.61 303.92,236.55 304.91,235.57 304.91,228.61 305.3,228.22 305.3,222.61 307.08,220.83 307.08,217.21 312.19,212.1 v2(312.19,211.11)
  BOTTOM w0.16: UNK7U449.3 v2(312.19,211.11)
D41313: length 300.9
  L33_SIGNAL w0.076: v2(309.85,188.86) 310.18,189.18 310.18,190.19 309.29,191.08
  L33_SIGNAL w0.091: D413.13 463.34,341.42 445.82,341.42 426.53,322.14 317.57,322.14 305.05,309.63 305.05,306.32 304.66,305.93 304.66,288.14 303.18,286.65 303.18,281.64 302.74,281.21 302.74,269.81 302.69,269.75 302.69,254.94 300.34,252.6 300.34,238.29 302.56,236.07 302.56,233.15 303.06,232.65 303.06,232.1 302.69,231.73 302.69,228.27 302.5,228.08 302.5,220.6 303.23,219.88 303.23,213.14 305.2,211.17 305.2,204.57 308.5,201.27 308.5,194.15 309.1,193.54 309.1,191.27 309.29,191.08
D41314: length 298.3
  L33_SIGNAL w0.076: 311.48,191.08 311.48,187.42 311.67,187.23 312.78,187.23 v2(313.11,186.91)
  L33_SIGNAL w0.091: D413.14 460.81,338.89 445.32,338.89 427.73,321.3 321.05,321.3 306.36,306.62 306.36,297.48 305.73,296.85 305.73,281.03 305.27,280.57 305.27,267.77 304.59,267.09 304.59,254.69 303.59,253.69 303.59,253.69 301.29,251.39 301.29,251.39 301.28,251.38 301.28,238.6 304.49,235.4 304.49,228.55 303.25,227.31 303.25,222.52 303.27,222.51 303.27,222.43 306.49,219.2 306.49,213.54 308.7,211.33 308.7,207.8 309.33,207.17 309.33,194.5 309.94,193.89 309.94,192.62 311.48,191.08
D41315: length 299.9
  L33_SIGNAL w0.076: v2(309.85,188.21) 309.53,188.53 309.53,190.08 308.53,191.08
  L33_SIGNAL w0.091: D413.15 458.71,341.87 445.25,341.87 425.94,322.56 317.22,322.56 302.91,308.24 302.91,292.86 302.12,292.07 302.12,286.66 302.76,286.03 302.76,282.27 302.38,281.89 302.38,269.96 301.61,269.2 301.61,267.33 302.32,266.63 302.32,255.1 300.91,253.69 299.52,253.69 299.19,253.36 299.19,238.84 301.87,236.17 301.87,232.21 302.27,231.81 302.27,228.37 302.12,228.22 302.12,221.87 301.29,221.04 301.29,219.91 302.81,218.39 302.81,210.22 303.23,209.8 303.23,205.95 308.05,201.13 308.05,191.56 308.53,191.08
D41316: length 290.8
  L33_SIGNAL w0.076: 310.83,191.08 310.83,189.83 v2(310.5,189.51)
  L33_SIGNAL w0.091: 310.83,191.08 309.52,192.39 309.52,193.72 308.92,194.32 308.92,202.03 306.49,204.45 306.49,211.78 305.2,213.08 305.2,218.41 303.6,220.02 303.6,220.03 302.87,220.76 302.87,227.93 303.12,228.18 303.12,229.73 304.07,230.68 304.07,235.21 300.81,238.47 300.81,251.59 303.05,253.83 303.05,255.36 304.23,256.53 304.23,257.49 303.16,258.56 303.16,266.32 303.94,267.1 303.94,270.6 304.64,271.3 304.64,281.27 305.17,281.8 305.17,305.42 305.82,306.07 305.82,306.83 320.7,321.72 427.13,321.72 444.73,339.32 456.16,339.32 D413.16
D41401: length 395.1
  L33_SIGNAL w0.076: v2(273.11,186.91) 272.78,187.23 271.67,187.23 271.48,187.42 271.48,191.08
  L33_SIGNAL w0.091: 271.48,191.08 269.94,192.62 269.94,193.89 269.33,194.5 269.33,207.17 268.7,207.8 268.7,211.33 266.5,213.54 266.5,219.2 263.27,222.43 263.27,222.51 263.25,222.52 263.25,227.31 264.49,228.55 264.49,235.4 261.28,238.6 261.28,251.38 261.29,251.39 261.29,251.39 263.59,253.69 263.59,253.69 264.59,254.69 264.59,267.09 265.27,267.77 265.27,280.76 265.73,281.22 265.73,296.85 266.36,297.48 266.36,321.74 284.73,340.11 291.08,340.11 297.76,346.79 425.36,346.79 448.38,369.8 488.72,369.8 D414.01
D41402: length 384.6
  L33_SIGNAL w0.091: v2(273.63,172.39) 273.63,173.62 280.6,180.58 280.6,186.31 281.61,187.32 281.61,187.33 287.97,193.69 287.98,193.69 290.19,195.9 290.19,198.63 290.22,198.66 290.22,231.53 286.73,235.03 286.73,251.37 283.52,254.58 281.49,254.58 280.48,255.58 280.48,260.95 289.47,269.94 289.47,317.66 297.3,325.49 421.76,325.49 447.67,351.4 485.25,351.4 486.45,352.6 486.45,354.37 D414.02
  BOTTOM w0.16: UNK6K32.7 v2(273.63,172.39)
D41403: length 362.7
  L33_SIGNAL w0.091: D414.03 484.11,369.33 449.1,369.33 425.71,345.95 297.94,345.95 291.59,339.6 285.24,339.6 266.95,321.3 266.95,297.05 266.52,296.62 266.52,267.16 265.03,265.67 265.03,253.74 262.43,251.14 262.43,251.13 262.25,250.96 262.25,239.27 263.92,237.61 263.92,236.55 264.91,235.57 264.91,228.61 265.3,228.22 265.3,222.61 267.08,220.83 267.08,217.21 272.19,212.1 v2(272.19,211.11)
  BOTTOM w0.16: UNK6U449.3 v2(272.19,211.11)
D41404: length 380.2
  L33_SIGNAL w0.076: 275.9,182.68 272.13,182.68 v2(271.81,183)
  L33_SIGNAL w0.091: 275.9,182.68 276.34,182.68
  L33_SIGNAL w0.508: D414.04 481.4,354.4 481.4,352.84 480.53,351.97 447.22,351.97 421.38,326.13 296.92,326.13 288.88,318.09 288.88,272.46 283.19,266.76 283.19,265.5 279.29,261.61 279.29,254.99 279.81,254.47 280.79,254.47 281.32,253.94 282.34,253.94 285.22,251.05 285.22,237.06 283.9,235.74 281.77,235.74 280.54,234.51 280.54,228.1 283.55,225.09 288.04,225.09 289.43,223.7 289.43,209.7 279.37,199.64 279.37,185.38 276.67,182.68 276.34,182.68
D41405: length 356.4
  L33_SIGNAL w0.091: v2(273.18,211.1) 273.18,213.63 268.47,218.33 268.47,221.27 267.58,222.16 267.58,227.32 268.74,228.47 268.74,231.34 265.48,234.6 265.48,235.59 264.34,236.73 264.34,237.78 262.79,239.33 262.79,250.99 266.6,254.79 266.6,263.02 268.5,264.92 268.5,321.84 285.75,339.09 292.1,339.09 298.12,345.11 426.06,345.11 448.18,367.23 481.13,367.23 D414.05
  BOTTOM w0.16: v2(273.18,211.1) 272.69,210.61 UNK6U449.4
D41406: length 371
  L33_SIGNAL w0.076: 276.07,183.33 274.73,183.33 v2(274.41,183)
  L33_SIGNAL w0.091: 276.07,183.33 276.16,183.33 278.8,185.96 278.8,201.58 280.16,202.95 280.22,202.95 284.33,207.06 284.33,207.6 288.67,211.93 288.67,223.51 287.65,224.52 283.13,224.52 279.96,227.69 279.96,235.09 281.38,236.5 282.82,236.5 284.58,238.27 284.58,250.08 281.64,253.02 281.16,253.02 280.42,253.75 279.52,253.75 278.63,254.64 278.63,263.03 281.22,265.62 281.22,266.88 282.85,268.5 283.92,268.5 286.18,270.76 286.18,271.93 287.14,272.9 287.14,317.49 296.36,326.72 420.97,326.72 448.34,354.09 476.01,354.09 D414.06
D41407: length 375.9
  L33_SIGNAL w0.076: v2(272.46,188.86) 272.13,189.18 272.13,191.08
  L33_SIGNAL w0.091: D414.07 476.53,366.75 448.88,366.75 426.41,344.27 298.3,344.27 292.61,338.58 286.26,338.58 270.51,322.83 270.51,306.07 269.13,304.69 269.13,271.37 269.77,270.74 269.77,265.43 267.06,262.72 267.06,253.73 263.23,249.9 263.23,240.7 269.87,234.06 270.31,233.63 271.27,232.67 271.27,225.68 269.87,224.28 269.87,222.38 268.85,221.36 268.85,218.47 270.66,216.66 272.03,216.66 274.51,214.18 274.51,204.8 271.39,201.69 271.39,192.28 272.13,191.54 272.13,191.08
D41408: length 362.6
  L33_SIGNAL w0.076: v2(273.76,186.91) 274.08,186.58 276.07,186.58
  L33_SIGNAL w0.091: 276.07,186.58 276.36,186.58 277.27,187.49 277.27,201.44 281.57,205.74 281.57,207.36 283.19,208.98 284.26,208.98 286.17,210.89 286.17,214.95 286.76,215.54 286.76,216.03 286.6,216.19 286.6,223.18 285.64,224.14 282.92,224.14 279.54,227.51 279.54,235.26 281.9,237.61 282.66,237.61 283.43,238.39 283.43,250.64 281.5,252.57 279.98,252.57 277.46,255.08 277.46,263.58 280.61,266.73 280.61,267.06 283,269.44 283,270.26 285.29,272.54 285.29,291.85 283.97,293.16 283.97,298.96 284.73,299.72 284.73,316.1 305.36,336.73 429.62,336.73 447.47,354.58 471.42,354.58 D414.08
D41409: length 366.6
  L33_SIGNAL w0.076: v2(273.11,187.56) 272.78,187.88 272.78,191.08
  L33_SIGNAL w0.091: D414.09 473.46,364.74 448.06,364.74 426.75,343.43 298.48,343.43 293.12,338.07 286.77,338.07 274.58,325.89 274.58,269.61 274.04,269.07 274.04,264.34 273.48,263.77 273.48,252.22 274.23,251.46 275.25,251.46 277.76,248.95 277.76,239.82 275.21,237.27 275.21,228.35 270.24,223.38 270.24,222.23 269.36,221.35 269.36,218.53 270.09,217.81 272.36,217.81 274.93,215.24 274.93,204.63 272.59,202.29 272.59,191.27 272.78,191.08
D41410: length 356
  L33_SIGNAL w0.076: 276.07,187.28 276.02,187.23 274.73,187.23 v2(274.41,187.56)
  L33_SIGNAL w0.091: D414.10 468.43,356.67 448.29,356.67 429.18,337.57 305.18,337.57 283.21,315.6 283.21,291.51 284.65,290.07 284.65,275.13 283.84,274.32 283.84,272.62 280.11,268.88 280.11,266.87 277.03,263.79 277.03,254.91 279.8,252.14 280.48,252.14 282.97,249.65 282.97,238.53 282.47,238.03 281.73,238.03 279.13,235.43 279.13,226.5 281.85,223.77 285.49,223.77 286.24,223.03 286.24,218.79 285.43,217.98 285.43,216.22 283.86,214.65 283.86,212.91 282.8,211.85 282.8,209.32 281.13,207.65 281.13,206.83 280.52,206.22 280.52,205.28 276.85,201.61 276.85,188.06 276.07,187.28
D41411: length 354.3
  L33_SIGNAL w0.076: v2(273.11,189.51) 273.43,189.83 273.43,191.08
  L33_SIGNAL w0.091: D414.11 468.88,364.24 448.74,364.24 427.1,342.6 298.65,342.6 293.62,337.57 287.27,337.57 275.46,325.75 275.46,282.57 275.78,282.25 275.78,281.11 275,280.33 275,269.41 274.49,268.9 274.49,252.84 278.21,249.12 278.21,243.75 278.9,243.06 278.9,240.31 276.11,237.52 276.11,225.86 278.51,223.47 278.51,215.45 275.35,212.29 275.35,204.45 273.02,202.13 273.02,191.49 273.43,191.08
D41412: length 342.9
  L33_SIGNAL w0.076: v2(275.71,188.21) 276.07,188.57
  L33_SIGNAL w0.091: D414.12 463.8,357.12 447.55,357.12 428.84,338.4 305,338.4 282.54,315.95 282.54,275.06 279.8,272.31 279.8,269.82 279.04,269.06 279.04,267.22 277.4,265.58 277.4,264.96 276.61,264.17 276.61,254.49 277.39,253.7 277.39,253.06 277.84,252.62 278.49,252.62 279.38,251.72 280.31,251.72 282.55,249.48 282.55,238.71 282.3,238.45 281.44,238.45 280.57,237.58 279.92,237.58 278.71,236.37 278.71,226.33 281.39,223.64 281.39,208.65 280.61,207.87 280.61,207.1 278.87,205.36 278.87,204.97 276.43,202.53 276.43,188.93 276.07,188.57
D41413: length 340.7
  L33_SIGNAL w0.076: 274.19,191.08 274.19,189.29 v2(273.76,188.86)
  L33_SIGNAL w0.091: 274.19,191.08 274.19,191.27 274.49,191.57 274.49,202.41 276.84,204.76 276.84,206.56 277.94,207.66 277.94,209.98 278.57,210.61 278.57,213.46 279.39,214.28 279.39,223.77 276.96,226.2 276.96,236.47 279.37,238.88 279.37,239.47 280.51,240.6 280.51,248.05 275.34,253.23 275.34,268.16 276.47,269.3 276.47,274.81 277.49,275.83 277.49,279.97 279.39,281.87 279.39,315.84 304.47,340.92 427.79,340.92 448.62,361.74 463.34,361.74 D414.13
D41414: length 336.5
  L33_SIGNAL w0.076: v2(275.71,188.86) 275.71,191.04
  L33_SIGNAL w0.091: D414.14 460.81,359.21 448.46,359.21 428.49,339.24 304.83,339.24 281.27,315.69 281.27,279.88 279.2,277.81 279.2,275.46 278.61,274.86 278.61,270.74 278,270.13 278,267.26 276.92,266.18 276.92,265.08 276.19,264.35 276.19,254.31 276.73,253.77 276.95,253.56 276.95,252.89 277.64,252.2 278.31,252.2 281.45,249.05 281.45,239.06 280.4,238 279.75,238 278.29,236.54 278.29,226.15 280.97,223.47 280.97,209.96 280.09,209.08 280.09,207.17 278.45,205.53 278.45,205.14 275.33,202.02 275.33,192.68 275.71,192.3 275.71,191.04
D41415: length 342.2
  L33_SIGNAL w0.076: 273.81,191.08 273.81,189.56 v2(273.76,189.51)
  L33_SIGNAL w0.091: D414.15 458.71,362.19 447.88,362.19 427.45,341.76 298.83,341.76 294.13,337.06 287.78,337.06 277.11,326.38 277.11,295.27 276.73,294.89 276.73,281.37 275.42,280.06 275.42,269.18 274.91,268.68 274.91,253.01 278.67,249.25 278.67,243.89 279.44,243.12 279.44,240.13 278.92,239.6 278.92,239.02 276.54,236.64 276.54,226.02 278.93,223.64 278.93,215.28 277.52,213.87 277.52,207.83 276.42,206.73 276.42,204.93 273.43,201.94 273.43,191.64 273.81,191.26 273.81,191.08
D41416: length 334.5
  L33_SIGNAL w0.076: v2(273.76,187.56) 274.08,187.88 274.54,187.88 274.73,188.07 274.73,190.29 274.57,190.45 274.57,191.08
  L33_SIGNAL w0.091: D414.16 456.16,359.64 447.7,359.64 428.14,340.08 304.65,340.08 280.79,316.22 280.79,281.19 278.76,279.15 278.76,275.53 277.49,274.26 277.49,267.38 276.48,266.37 276.48,265.24 275.76,264.52 275.76,254.15 276.51,253.4 276.51,252.71 277.46,251.76 278.15,251.76 281,248.91 281,239.24 280.25,238.5 279.62,238.5 277.38,236.26 277.38,226.37 280.55,223.2 280.55,213.43 279.84,212.72 279.84,209.76 279.09,209.01 279.09,207.21 277.26,205.37 277.26,204.59 274.91,202.24 274.91,191.47 274.57,191.13 274.57,191.08
D41501: length 442.1
  L33_SIGNAL w0.076: 235.71,191.04 v2(235.71,188.86)
  L33_SIGNAL w0.091: 235.71,191.04 235.71,192.3 235.33,192.68 235.33,202.02 238.45,205.14 238.45,205.53 240.09,207.17 240.09,209.08 240.97,209.96 240.97,223.45 238.29,226.13 238.29,236.54 239.75,238 240.4,238 241.45,239.06 241.45,249.05 238.31,252.2 237.64,252.2 236.95,252.89 236.95,253.56 236.73,253.77 236.19,254.31 236.19,264.35 236.92,265.08 236.92,266.18 238,267.26 238,270.13 238.61,270.74 238.61,274.42 239.12,274.93 239.12,277.35 241.27,279.51 241.27,326.11 263.76,348.6 283.57,348.6 290.32,355.35 290.32,375.16 302.67,387.51 422.58,387.51 425.19,390.12 488.72,390.12 D415.01
D41502: length 410.4
  L33_SIGNAL w0.076: 270.83,191.08 270.83,189.83 v2(270.5,189.51)
  L33_SIGNAL w0.091: D415.02 486.45,374.69 486.45,372.92 485.42,371.89 427.89,371.89 422.19,377.59 306.43,377.59 301.75,372.92 301.75,351.79 290.58,340.61 284.23,340.61 265.94,322.33 265.94,306.07 265.17,305.3 265.17,281.33 264.64,280.8 264.64,271.3 263.94,270.6 263.94,267.1 263.16,266.32 263.16,258.56 264.23,257.49 264.23,256.53 263.05,255.36 263.05,253.83 260.81,251.59 260.81,238.47 264.07,235.21 264.07,230.68 263.12,229.73 263.12,228.18 262.87,227.93 262.87,220.76 263.6,220.03 263.6,220.02 265.2,218.41 265.2,213.08 266.5,211.78 266.5,204.45 268.92,202.03 268.92,194.32 269.52,193.72 269.52,192.39 270.83,191.08
D41503: length 438.1
  L33_SIGNAL w0.076: 236.07,188.57 v2(235.71,188.21)
  L33_SIGNAL w0.091: D415.03 484.11,389.65 425.56,389.65 422.58,386.67 302.66,386.67 291.08,375.09 291.08,355.09 284.08,348.09 264.27,348.09 242.54,326.36 242.54,275.06 239.8,272.31 239.8,269.82 239.04,269.06 239.04,267.22 237.4,265.58 237.4,264.96 236.61,264.17 236.61,254.49 237.39,253.7 237.39,253.06 237.84,252.62 238.49,252.62 239.38,251.72 240.31,251.72 242.55,249.48 242.55,238.71 242.3,238.45 241.44,238.45 240.57,237.58 239.92,237.58 238.71,236.37 238.71,226.31 241.39,223.62 241.39,208.65 240.61,207.87 240.61,207.1 238.87,205.36 238.87,204.97 236.43,202.53 236.43,188.93 236.07,188.57
D41504: length 405.4
  L33_SIGNAL w0.076: 269.29,191.08 270.18,190.19 270.18,189.18 v2(269.85,188.86)
  L33_SIGNAL w0.091: 269.29,191.08 269.1,191.27 269.1,193.54 268.5,194.15 268.5,201.27 265.2,204.57 265.2,211.17 263.23,213.14 263.23,219.88 262.5,220.6 262.5,228.08 262.69,228.27 262.69,231.73 263.06,232.1 263.06,232.65 262.56,233.15 262.56,236.07 260.34,238.29 260.34,252.6 262.69,254.94 262.69,269.75 262.74,269.81 262.74,280.36 263.18,280.79 263.18,286.65 264.66,288.14 264.66,305.31 264.16,305.82 264.16,321.56 283.72,341.12 290.07,341.12 300.99,352.04 300.99,373 306,378.01 422.61,378.01 428.29,372.33 480.57,372.33 481.4,373.16 481.4,374.72 D415.04
D41505: length 438.1
  L33_SIGNAL w0.076: v2(234.41,187.56) 234.73,187.23 236.02,187.23 236.07,187.28
  L33_SIGNAL w0.091: 236.07,187.28 236.85,188.06 236.85,201.61 240.52,205.28 240.52,206.22 241.13,206.83 241.13,207.65 242.8,209.32 242.8,211.85 243.86,212.91 243.86,214.65 245.43,216.22 245.43,217.98 246.24,218.79 246.24,223.03 245.49,223.77 241.83,223.77 239.13,226.48 239.13,235.43 241.73,238.03 242.47,238.03 242.97,238.53 242.97,249.65 240.48,252.14 239.8,252.14 237.03,254.91 237.03,263.79 240.11,266.87 240.11,268.88 243.84,272.62 243.84,274.32 244.65,275.13 244.65,327.46 264.78,347.58 284.59,347.58 291.85,354.84 291.85,374.92 302.76,385.83 422.58,385.83 424.29,387.55 481.13,387.55 D415.05
D41506: length 401.2
  L33_SIGNAL w0.076: 268.53,191.08 269.53,190.08 269.53,188.53 v2(269.85,188.21)
  L33_SIGNAL w0.091: D415.06 476.01,374.41 427.02,374.41 423,378.43 305.57,378.43 300.23,373.09 300.23,352.3 289.56,341.63 283.21,341.63 262.91,321.33 262.91,292.86 262.38,292.33 262.38,269.96 261.61,269.2 261.61,267.33 262.32,266.63 262.32,255.1 260.91,253.69 259.52,253.69 259.19,253.36 259.19,238.84 261.87,236.17 261.87,232.21 262.27,231.81 262.27,228.37 262.12,228.22 262.12,221.87 261.29,221.04 261.29,219.91 262.81,218.39 262.81,210.22 263.23,209.8 263.23,205.95 268.05,201.13 268.05,191.56 268.53,191.08
D41507: length 434.3
  L33_SIGNAL w0.076: v2(233.76,186.91) 234.08,186.58 236.07,186.58
  L33_SIGNAL w0.091: D415.07 476.53,387.07 424.65,387.07 422.58,384.99 302.85,384.99 292.61,374.75 292.61,354.58 285.1,347.07 265.28,347.07 245.29,327.08 245.29,272.54 243,270.26 243,269.44 240.61,267.06 240.61,266.73 237.46,263.58 237.46,255.08 239.98,252.57 241.5,252.57 243.43,250.64 243.43,238.39 242.66,237.61 241.9,237.61 239.54,235.26 239.54,227.51 242.92,224.14 245.64,224.14 246.6,223.18 246.6,216.19 246.76,216.03 246.76,215.54 246.17,214.95 246.17,210.89 244.26,208.98 243.19,208.98 241.57,207.36 241.57,205.74 237.27,201.44 237.27,187.49 236.36,186.58 236.07,186.58
D41508: length 398.6
  L33_SIGNAL w0.076: 267.63,191.08 267.63,189.04 267.58,188.99 267.58,185.93 v2(267.25,185.61)
  L33_SIGNAL w0.091: D415.08 471.42,374.9 427.28,374.9 423.33,378.85 305.14,378.85 299.47,373.17 299.47,352.55 289.05,342.14 282.7,342.14 262.4,321.84 262.4,293.6 261.56,292.76 261.56,286.21 260.65,285.29 260.65,270.97 261.24,270.38 261.24,255.15 260.2,254.11 259.33,254.11 258.74,253.52 258.74,238.7 261.23,236.21 261.23,227.84 259.96,226.57 259.96,222.12 260.73,221.36 260.73,216.54 261.17,216.1 261.17,216.09 261.23,216.03 261.23,211.01 262.81,209.42 262.81,203.4 267.63,198.58 267.63,191.08
D41509: length 432
  L33_SIGNAL w0.076: 236.07,183.33 234.73,183.33 v2(234.41,183)
  L33_SIGNAL w0.091: 236.07,183.33 236.16,183.33 238.8,185.96 238.8,201.58 240.16,202.95 240.22,202.95 244.33,207.06 244.33,207.6 248.67,211.93 248.67,223.04 247.19,224.52 243.13,224.52 239.96,227.69 239.96,235.09 241.38,236.5 242.82,236.5 244.58,238.27 244.58,250.08 241.64,253.02 241.16,253.02 240.42,253.75 239.52,253.75 238.63,254.64 238.63,263.03 241.22,265.62 241.22,266.88 242.85,268.5 243.92,268.5 246.18,270.76 246.18,271.93 247.14,272.9 247.14,327.91 265.79,346.56 285.6,346.56 293.37,354.33 293.37,374.58 302.94,384.16 422.58,384.16 423.62,385.19 473.33,385.19 D415.09
D41510: length 396.8
  L23_SIGNAL w0.091: v2(265.96,184.96) 265.73,184.73 265.3,184.73 265.04,184.98 264.28,184.98 263.27,186 263.27,198.27 v2(264,199)
  L33_SIGNAL w0.091: D415.10 468.34,376.9 425.8,376.9 423.33,379.36 304.52,379.36 298.68,373.52 298.68,352.59 288.63,342.54 281.33,342.54 258.95,320.17 258.95,269.87 260.85,267.97 260.85,255.4 259.96,254.51 259.07,254.51 258.32,253.75 258.32,237.71 260.85,235.18 260.85,227.97 259.6,226.72 259.6,226.33 259.26,225.99 259.26,217.5 260.81,215.94 260.81,210.36 261.23,209.94 261.23,203.46 264,200.69 v2(264,199)
D41511: length 430.9
  L33_SIGNAL w0.076: v2(231.81,183) 232.13,182.68 235.9,182.68
  L33_SIGNAL w0.091: 236.34,182.68 235.9,182.68
  L33_SIGNAL w0.508: D415.11 468.82,384.62 424.47,384.62 423.16,383.32 303.04,383.32 294.13,374.41 294.13,354.08 285.94,345.88 266.13,345.88 248.88,328.63 248.88,272.45 243.19,266.76 243.19,265.5 239.29,261.61 239.29,254.99 239.81,254.47 240.79,254.47 241.32,253.94 242.34,253.94 245.22,251.05 245.22,237.06 243.9,235.74 241.77,235.74 240.54,234.51 240.54,228.1 243.55,225.09 247.4,225.09 247.76,225.45 248.92,225.45 249.43,224.95 249.43,209.7 239.37,199.64 239.37,185.38 236.67,182.68 236.34,182.68
D41512: length 423.2
  L33_SIGNAL w0.091: UNK6K39.2 264.26,177.51 263.15,178.62 263.15,193.43 262.25,194.33 262.25,200.41 260.22,202.44 260.22,208.88 259.06,210.04 259.06,216.53 258.62,216.97 258.62,226.26 260.49,228.13 260.49,233.03 257.74,235.78 255.33,235.78 253.23,237.87 253.23,241.66 251.77,243.13 251.77,246.45 250.18,248.03 250.18,254.63 252.03,256.48 252.03,257.49 251.42,258.11 251.42,264.38 252.19,265.15 252.19,300.48 251.46,301.21 251.46,326.14 268.48,343.15 288.29,343.15 297.94,352.81 297.94,373.55 304.23,379.83 424.03,379.83 426.42,377.44 463.8,377.44 D415.12
D41513: length 413.4
  L33_SIGNAL w0.091: D415.13 463.34,382.06 303.56,382.06 295.66,374.16 295.66,353.57 286.77,344.68 266.95,344.68 250.14,327.86 250.14,260.07 250.14,260.05 250.14,259.21 250.14,259.19 250.14,257.25 248.68,255.79 248.68,233.66 250.59,231.75 250.59,194.83 241.21,185.46 241.21,175.77 v2(237.83,172.39)
  BOTTOM w0.16: UNK5K32.2 v2(237.83,172.39)
D41514: length 417.8
  L33_SIGNAL w0.091: D415.14 460.81,379.53 425.17,379.53 424.03,380.67 304.13,380.67 297.18,373.72 297.18,353.06 287.78,343.66 267.97,343.66 251,326.69 251,256.59 249.68,255.26 249.68,248.02 250.06,247.64 250.06,236.6 251.46,235.2 251.46,226.94 252.86,225.55 252.86,222.12 258.64,216.34 258.64,209.86 259.71,208.8 259.71,201.68 260.9,200.49 260.9,195.06 262.71,193.25 262.71,176.09 261.92,175.3 261.92,171.55 262.88,170.59 262.88,164.32 UNK6K39.7
D41515: length 418.2
  L33_SIGNAL w0.091: D415.15 458.71,382.51 303.12,382.51 294.89,374.29 294.89,353.82 286.26,345.19 266.45,345.19 249.53,328.27 249.53,270 240.48,260.95 240.48,255.58 241.49,254.58 243.52,254.58 246.73,251.37 246.73,235.03 250.22,231.53 250.22,198.66 250.19,198.63 250.19,195.9 247.98,193.69 247.97,193.69 241.61,187.33 241.61,187.32 240.6,186.31 240.6,180.58 233.63,173.62 v2(233.63,172.39)
  BOTTOM w0.16: UNK5K32.7 v2(233.63,172.39)
D41516: length 417.5
  L33_SIGNAL w0.091: UNK5K113.6 244.02,161.54 248.67,161.54 250.19,163.07 250.19,173.59 249.55,174.22 249.55,190.75 250.95,192.15 250.95,231.9 249.05,233.81 249.05,255.52 250.51,256.99 250.51,327.22 267.46,344.17 287.27,344.17 296.42,353.31 296.42,373.89 304.04,381.51 424.03,381.51 425.57,379.96 456.16,379.96 D415.16
D41601: length 501
  L33_SIGNAL w0.091: D416.01 488.72,410.44 435.24,410.44 433.79,409 428.4,409 427.06,410.34 349.89,410.34 348.56,409.02 300.81,409.02 278.26,386.46 278.26,359.49 275.52,356.75 255.78,356.75 211,311.96 211,256.59 209.68,255.26 209.68,248.02 210.06,247.64 210.06,236.6 211.46,235.2 211.46,226.94 212.86,225.55 212.86,222.12 218.64,216.34 218.64,209.86 219.71,208.8 219.71,201.68 220.9,200.49 220.9,195.06 222.71,193.25 222.71,176.09 221.92,175.3 221.92,171.55 222.88,170.59 222.88,164.32 UNK5K39.7
D41602: length 453.3
  L33_SIGNAL w0.076: v2(233.76,187.56) 234.08,187.88 234.54,187.88 234.73,188.07 234.73,190.29 234.57,190.45 234.57,191.08
  L33_SIGNAL w0.091: D416.02 486.45,395.01 486.45,393.24 485.42,392.21 431.12,392.21 425.56,397.77 306.74,397.77 289.56,380.59 289.56,355.6 283.06,349.1 263.25,349.1 240.79,326.64 240.79,279.65 238.63,277.5 238.63,275.34 237.49,274.19 237.49,267.38 236.48,266.37 236.48,265.24 235.76,264.52 235.76,254.15 236.51,253.4 236.51,252.71 237.46,251.76 238.15,251.76 241,248.91 241,239.24 240.25,238.5 239.62,238.5 237.38,236.26 237.38,226.35 240.55,223.18 240.55,213.43 239.84,212.72 239.84,209.76 239.09,209.01 239.09,207.21 237.26,205.37 237.26,204.59 234.91,202.24 234.91,191.47 234.57,191.13 234.57,191.08
D41603: length 493.9
  L33_SIGNAL w0.091: D416.03 484.11,409.97 435.69,409.97 434.24,408.53 427.93,408.53 426.95,409.5 350.2,409.5 349.2,408.51 301.32,408.51 278.89,386.08 278.89,359.16 275.95,356.22 256.14,356.22 212.19,312.27 212.19,265.15 211.42,264.38 211.42,258.11 212.03,257.49 212.03,256.48 210.19,254.63 210.19,248.03 211.77,246.45 211.77,243.13 213.23,241.66 213.23,237.87 215.33,235.78 217.74,235.78 220.49,233.03 220.49,228.13 218.62,226.26 218.62,216.97 219.06,216.53 219.06,210.04 220.22,208.88 220.22,202.44 222.25,200.41 222.25,194.33 223.15,193.43 223.15,178.62 224.26,177.51 UNK5K39.2
D41604: length 446
  L33_SIGNAL w0.076: 234.19,191.08 234.19,189.29 v2(233.76,188.86)
  L33_SIGNAL w0.091: 234.19,191.08 234.19,191.27 234.49,191.57 234.49,202.41 236.84,204.76 236.84,206.56 237.94,207.66 237.94,209.98 238.57,210.61 238.57,213.46 239.39,214.28 239.39,223.75 236.96,226.18 236.96,236.47 239.37,238.88 239.37,239.47 240.51,240.6 240.51,248.05 235.34,253.23 235.34,268.16 236.47,269.3 236.47,274.7 237.24,275.46 237.24,278.13 239.39,280.29 239.39,305.44 240.16,306.2 240.16,327.02 262.74,349.61 282.56,349.61 288.8,355.85 288.8,381.01 306.39,398.61 425.64,398.61 431.6,392.65 480.57,392.65 481.4,393.48 481.4,395.04 D416.04
D41605: length 463.2
  L23_SIGNAL w0.091: v2(224,199) 223.27,198.27 223.27,186 224.28,184.98 225.04,184.98 225.3,184.73 225.73,184.73 v2(225.96,184.96)
  L33_SIGNAL w0.091: v2(224,199) 224,200.69 221.23,203.46 221.23,209.94 220.81,210.36 220.81,215.94 219.26,217.5 219.26,225.99 219.6,226.33 219.6,226.72 220.85,227.97 220.85,235.18 218.32,237.71 218.32,253.75 219.07,254.51 219.96,254.51 220.85,255.4 220.85,267.97 218.95,269.87 218.95,318.01 256.65,355.71 276.46,355.71 279.65,358.9 279.65,385.83 301.85,408.03 349.94,408.03 350.58,408.67 426.56,408.67 427.36,407.87 481.13,407.87 D416.05
D41606: length 438.8
  L33_SIGNAL w0.076: v2(233.76,189.51) 233.81,189.56 233.81,191.08
  L33_SIGNAL w0.091: D416.06 476.01,394.73 430.35,394.73 425.63,399.45 306.05,399.45 288.04,381.44 288.04,356.11 282.05,350.12 262.24,350.12 237.11,324.99 237.11,295.27 236.73,294.89 236.73,279.53 235.42,278.22 235.42,269.18 234.91,268.68 234.91,253.01 238.67,249.25 238.67,243.89 239.44,243.12 239.44,240.13 238.92,239.6 238.92,239.02 236.54,236.64 236.54,226.01 238.93,223.62 238.93,215.28 237.52,213.87 237.52,207.83 236.42,206.73 236.42,204.93 233.43,201.94 233.43,191.64 233.81,191.26 233.81,191.08
D41607: length 453.5
  L33_SIGNAL w0.076: 227.63,191.08 227.63,189.04 227.58,188.99 227.58,185.93 v2(227.26,185.61)
  L33_SIGNAL w0.091: D416.07 476.53,407.39 426.97,407.39 426.52,407.83 350.53,407.83 350.24,407.54 302.39,407.54 280.42,385.57 280.42,358.65 276.97,355.2 257.16,355.2 222.4,320.45 222.4,293.6 221.56,292.76 221.56,286.21 220.65,285.29 220.65,270.97 221.24,270.38 221.24,255.15 220.2,254.11 219.33,254.11 218.74,253.52 218.74,238.7 221.23,236.21 221.23,227.84 219.96,226.57 219.96,222.12 220.73,221.36 220.73,216.54 221.17,216.1 221.17,216.09 221.23,216.03 221.23,211.01 222.81,209.42 222.81,203.4 227.63,198.58 227.63,191.08
D41608: length 435.2
  L33_SIGNAL w0.076: v2(233.11,189.51) 233.43,189.83 233.43,191.08
  L33_SIGNAL w0.091: D416.08 471.42,395.22 430.75,395.22 425.68,400.28 305.7,400.28 287.27,381.86 287.27,356.36 281.54,350.63 261.73,350.63 236.35,325.25 236.35,305.69 235.46,304.8 235.46,282.57 235.84,282.19 235.84,280.67 235,279.83 235,269.41 234.49,268.9 234.49,252.84 238.21,249.12 238.21,243.75 238.9,243.06 238.9,240.31 236.11,237.52 236.11,225.84 238.51,223.45 238.51,215.45 235.35,212.29 235.35,204.45 233.02,202.13 233.02,191.49 233.43,191.08
D41609: length 445.1
  L33_SIGNAL w0.076: v2(229.86,188.21) 229.53,188.53 229.53,190.08 228.53,191.08
  L33_SIGNAL w0.091: D416.09 473.46,405.38 428.02,405.38 426.4,406.99 302.92,406.99 281.18,385.25 281.18,358.39 277.48,354.69 257.66,354.69 222.91,319.94 222.91,292.86 222.38,292.33 222.38,269.96 221.61,269.2 221.61,267.33 222.32,266.63 222.32,255.1 220.91,253.69 219.52,253.69 219.19,253.36 219.19,238.84 221.87,236.17 221.87,232.21 222.27,231.81 222.27,228.37 222.12,228.22 222.12,221.87 221.29,221.04 221.29,219.91 222.81,218.39 222.81,210.22 223.23,209.8 223.23,205.95 228.05,201.13 228.05,191.56 228.53,191.08
D41610: length 435.9
  L33_SIGNAL w0.076: 232.78,191.08 232.78,187.88 v2(233.11,187.56)
  L33_SIGNAL w0.091: D416.10 468.43,397.31 429.63,397.31 425.82,401.12 305.35,401.12 286.51,382.28 286.51,356.62 281.03,351.14 261.22,351.14 235.71,325.63 235.71,306.07 234.58,304.94 234.58,269.61 234.04,269.07 234.04,264.34 233.48,263.77 233.48,252.22 234.23,251.46 235.25,251.46 237.76,248.95 237.76,239.82 235.21,237.27 235.21,228.35 230.24,223.38 230.24,222.23 229.36,221.35 229.36,218.53 230.09,217.81 232.36,217.81 234.93,215.24 234.93,204.63 232.59,202.29 232.59,191.27 232.78,191.08
D41611: length 435.5
  L33_SIGNAL w0.076: 229.29,191.08 230.18,190.19 230.18,189.18 v2(229.86,188.86)
  L33_SIGNAL w0.091: 229.29,191.08 229.1,191.27 229.1,193.54 228.5,194.15 228.5,201.27 225.2,204.57 225.2,211.17 223.23,213.14 223.23,219.88 222.5,220.6 222.5,228.08 222.69,228.27 222.69,231.73 223.06,232.1 223.06,232.65 222.56,233.15 222.56,236.07 220.34,238.29 220.34,252.6 222.69,254.94 222.69,269.75 222.74,269.81 222.74,286.22 224.66,288.14 224.66,320.68 258.17,354.18 277.98,354.18 281.94,358.14 281.94,384.82 303.27,406.15 426.42,406.15 427.69,404.88 468.88,404.88 D416.11
D41612: length 433.9
  L33_SIGNAL w0.076: 232.13,191.08 232.13,189.18 v2(232.46,188.86)
  L33_SIGNAL w0.091: D416.12 463.8,397.76 430.25,397.76 426.04,401.96 305,401.96 285.75,382.71 285.75,356.87 280.52,351.64 260.71,351.64 229.13,320.07 229.13,271.37 229.77,270.74 229.77,265.43 227.06,262.72 227.06,253.73 223.23,249.9 223.23,240.7 231.27,232.67 231.27,225.68 229.87,224.28 229.87,222.38 228.85,221.36 228.85,218.47 230.66,216.66 232.03,216.66 234.51,214.18 234.51,204.8 231.39,201.69 231.39,192.28 232.13,191.54 232.13,191.08
D41613: length 432.3
  L33_SIGNAL w0.076: 231.48,191.08 231.48,187.42 231.67,187.23 232.78,187.23 v2(233.11,186.91)
  L33_SIGNAL w0.091: D416.13 463.34,402.38 428.26,402.38 426.17,404.48 303.96,404.48 283.46,383.98 283.46,357.63 279,353.17 259.19,353.17 226.36,320.34 226.36,297.48 225.81,296.93 225.81,282.45 225.27,281.91 225.27,267.77 224.59,267.09 224.59,254.69 223.59,253.69 223.59,253.69 221.29,251.39 221.29,251.39 221.28,251.38 221.28,238.6 224.49,235.4 224.49,228.55 223.25,227.31 223.25,222.52 223.27,222.51 223.27,222.43 226.5,219.2 226.5,213.54 228.7,211.33 228.7,207.8 229.33,207.17 229.33,194.5 229.94,193.89 229.94,192.62 231.48,191.08
D41614: length 402.9
  L33_SIGNAL w0.091: D416.14 460.81,399.85 429,399.85 426.05,402.8 304.66,402.8 284.99,383.13 284.99,357.12 280.02,352.15 260.2,352.15 228.5,320.45 228.5,264.92 226.6,263.02 226.6,254.79 222.79,250.99 222.79,239.33 224.34,237.78 224.34,236.73 225.48,235.59 225.48,234.6 228.74,231.34 228.74,228.47 227.58,227.32 227.58,222.16 228.47,221.27 228.47,218.33 233.18,213.63 v2(233.18,211.1)
  BOTTOM w0.16: UNK5U449.4 232.69,210.61 v2(233.18,211.1)
D41615: length 425.5
  L33_SIGNAL w0.076: v2(230.5,189.51) 230.83,189.83 230.83,191.08
  L33_SIGNAL w0.091: 230.83,191.08 229.52,192.39 229.52,193.72 228.92,194.32 228.92,202.03 226.5,204.45 226.5,211.78 225.2,213.08 225.2,218.41 223.6,220.02 223.6,220.03 222.87,220.76 222.87,227.93 223.12,228.18 223.12,229.73 224.07,230.68 224.07,235.21 220.81,238.47 220.81,251.59 223.05,253.83 223.05,255.36 224.23,256.53 224.23,257.49 223.16,258.56 223.16,266.32 223.94,267.1 223.94,270.6 224.64,271.3 224.64,281.95 225.17,282.48 225.17,320.17 258.68,353.68 278.49,353.68 282.7,357.89 282.7,384.4 303.62,405.31 426.34,405.31 428.83,402.83 458.71,402.83 D416.15
