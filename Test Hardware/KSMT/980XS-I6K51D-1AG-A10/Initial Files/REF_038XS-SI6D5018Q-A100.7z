# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S5_AWG_3SHARE+: length 39.2
  L25_SIGNAL w0.079: 166.97,255.33 166.97,289.55
  L25_SIGNAL w0.091: UNK5K107.3 167.05,255.25 166.97,255.33 ; K109.4 167.05,289.62 166.97,289.55
S5_AWG_3SHARE-: length 39.2
  L25_SIGNAL w0.079: 166.78,289.55 166.78,255.33
  L25_SIGNAL w0.091: 166.78,255.33 166.7,255.25 UNK5K107.6 ; K109.5 166.7,289.62 166.78,289.55
S5_DVDD_DDR_RX: length 13.6
  L17_SIGNAL w0.508: UNK5K39.3 226.46,168.57 229.79,171.91 229.79,178.4
  vias: v2(227.26,179.11) v2(227.91,180.41)
S5_DVDD_DDR_TX: length 18.3
  L23_SIGNAL w0.508: 229.87,178.11 230.72,177.26 230.72,165.43 229.83,164.54 228.06,164.54 UNK5K39.6
  vias: v2(227.91,179.11) v2(228.56,180.41)
S5_ETH_RN_AB_CASE: length 31.5
  TOP w0.381: SITE5.H16 v2(236.36,184.96)
  L15_SIGNAL w0.508: 236.97,184.96 v2(236.36,184.96)
  L15_SIGNAL w0.889: v2(245.9,207.41) 245.9,206.54 245.12,205.76 ; 237.35,184.96 236.97,184.96
  L15_SIGNAL w1.016: 237.35,184.96 238.99,186.59 238.99,203.68 239.66,204.35 244.55,204.35 245.12,204.92 245.12,205.76
  BOTTOM w0.305: UNK5U451.7 245.6,207.72 v2(245.9,207.41)
S5_ETH_RP_AB_CASE: length 31
  L15_SIGNAL w0.305: v2(235.06,184.96) 236.52,186.42
  L15_SIGNAL w0.889: v2(244.79,207.41) 244.55,207.41 243.6,206.46 ; 236.52,186.42 237.02,186.92
  L15_SIGNAL w1.016: 237.02,186.92 237.02,205.77 237.7,206.46 243.6,206.46
  BOTTOM w0.305: UNK5U451.8 245.1,207.72 v2(244.79,207.41)
S5_ETH_TN_AB_CASE: length 26.2
  TOP w0.381: SITE5.G15 v2(236.36,185.61)
  L21_SIGNAL w0.305: v2(236.36,185.61) 236.48,185.48 236.81,185.48
  L21_SIGNAL w0.508: 239.03,187.12 237.39,185.48 236.81,185.48
  L21_SIGNAL w0.889: 239.64,206.7 v2(239.64,207.41)
  L21_SIGNAL w1.016: 239.64,206.7 239.64,206.43 239.03,205.82 239.03,187.12
  BOTTOM w0.305: UNK5U450.7 239.33,207.72 v2(239.64,207.41)
S5_ETH_TP_AB_CASE: length 25.5
  L21_SIGNAL w0.305: 236.49,186.39 235.71,185.61 v2(234.41,185.61)
  L21_SIGNAL w0.762: 237.07,187.15 237.07,186.97 236.49,186.39
  L21_SIGNAL w0.889: v2(238.52,207.41) 238.09,207.41 237.07,206.4
  L21_SIGNAL w1.016: 237.07,187.15 237.07,206.4
  BOTTOM w0.305: v2(238.52,207.41) 238.83,207.72 UNK5U450.8
S5_M_2V5: length 4.8
  BOTTOM w0.508: UNK5C284.1 224.24,135.91 UNK5MU2.6 ; UNK5C284.1 UNK5MR2.1 ; UNK5C284.1 UNK5C285.1
S5_M_3V2: length 24.3
  BOTTOM w0.381: UNK5MU3.7 233.83,135.27 233.7,135.39
  BOTTOM w0.508: UNK5MU2.2 222.97,146.08 UNK5C282.1 UNK5C283.1 224.2,146.16 UNK5MR1.1 227.48,146.16 UNK5MU1.5 226.52,145.05 226.52,139.7 227.37,138.85 229.04,138.85 230.13,137.76 UNK5C289.1 232.41,137.76 233.18,136.99 233.18,135.91 233.7,135.39
S5_MUX_3V3: length 1.5
  TOP w0.508: v2(227.1,207.19) v2(227.86,207.19)
  BOTTOM w0.508: v2(227.1,207.19) UNK5R512.1 v2(227.86,207.19)
  vias: v2(210.56,186.46) v2(210.56,174.89) v2(222.6,172.36) v2(229.83,212.29) v2(236.97,211.41)
S5_OUT_RX0_CH0_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(217.22,192.07) 217.05,192.24
  L21_SIGNAL w0.105: v2(227.26,189.51) 227.26,190.81 225.65,192.41 222.57,192.41 222.47,192.31 222.47,192.15 222.36,192.05 222.15,192.05 222.05,192.15 222.05,192.31 221.94,192.41 221.73,192.41 221.63,192.31 221.63,192.15 221.52,192.05 221.31,192.05 221.21,192.15 221.21,192.31 221.1,192.41 220.9,192.41 220.79,192.31 220.79,192.15 220.69,192.05 220.48,192.05 220.37,192.15 220.37,192.31 220.27,192.41 219.24,192.41 218.53,193.13 218.53,193.83 218.32,194.04 217.17,194.04 217.05,193.92 217.05,192.24
  BOTTOM w0.132: UNK5U408.B2 215,190.88 216.57,190.88 217.06,191.37 217.06,191.91 v2(217.22,192.07)
S5_OUT_RX0_CH0_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: v2(227.91,188.21) 227.91,188.4 227.58,188.72 227.58,188.99 227.62,189.03 227.62,189.81
  L21_SIGNAL w0.102: v2(216.51,192.07) 216.68,192.24
  L21_SIGNAL w0.105: 227.62,189.81 227.62,190.96 225.81,192.78 219.4,192.78 218.89,193.28 218.89,193.98 218.47,194.41 217.02,194.41 216.68,194.08 216.68,192.24
  BOTTOM w0.132: UNK5U408.B1 215.19,191.25 216.41,191.25 216.68,191.52 216.68,191.9 v2(216.51,192.07)
S5_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK5U408.B4 214.15,191.71 214.15,192.41 214.44,192.7 214.94,192.7 215.3,193.05 215.3,193.77 UNK5R647.1
S5_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK5R646.1 214.46,193.86 214.38,193.78 214.38,193.57 214.45,193.5 214.81,193.5 214.92,193.38 214.92,193.21 214.79,193.07 214.28,193.07 213.78,192.57 213.78,191.83 UNK5U408.A4
S5_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK5R647.2 UNK5R646.2 UNK5C309.1
S5_OUT_RX0_CH1_ABC_CASE+: length 20.2
  L19_SIGNAL w0.102: v2(217.22,189.36) 217.05,189.19
  L19_SIGNAL w0.105: v2(226.61,189.51) 225.92,190.19 225,190.19 224.85,190.33 224.57,190.33 224.43,190.19 222.88,190.19 222.59,190.47 222.59,192.13 222.05,192.67 219.22,192.67 218.57,192.02 218.57,188.82 218.01,188.26 217.36,188.26 217.05,188.58 217.05,189.19
  BOTTOM w0.132: v2(217.22,189.36) 217.05,189.53 217.05,190.08 216.56,190.57 215.02,190.57 UNK5U408.D2
S5_OUT_RX0_CH1_ABC_CASE-: length 20.2
  L19_SIGNAL w0.076: v2(227.26,188.86) 226.93,189.18 226.41,189.18
  L19_SIGNAL w0.102: v2(216.51,189.36) 216.68,189.19
  L19_SIGNAL w0.105: 216.68,189.19 216.68,188.42 217.21,187.9 218.17,187.9 218.93,188.67 218.93,191.87 219.37,192.31 221.9,192.31 222.23,191.98 222.23,190.32 222.73,189.82 225.77,189.82 226.41,189.18
  BOTTOM w0.132: v2(216.51,189.36) 216.68,189.53 216.68,189.93 216.41,190.2 215.18,190.2 UNK5U408.D1
S5_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 213.41,191.97 213.41,191.47 UNK5U408.B5
  BOTTOM w0.132: UNK5R168.1 213.82,193.7 213.82,193.24 213.41,192.83 213.41,191.97
S5_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK5U408.A5 213.04,191.84 213.04,192.56 212.91,192.69 212.82,192.69 212.69,192.82 212.69,193.01 212.82,193.14 213.2,193.14 213.45,193.39 213.45,193.7 UNK5R170.1
S5_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK5R170.2 UNK5R168.2 UNK5C310.1
S5_OUT_RX0_CH2_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: 214.73,189.82 214.62,189.72 v2(214.16,189.72)
  L21_SIGNAL w0.105: v2(226.61,188.86) 226.27,189.19 225.43,189.19 224.97,189.66 224.97,189.92 224.81,190.09 224.54,190.09 223.94,190.68 222.86,190.68 222.36,190.19 222.36,189.03 221.09,187.76 218.94,187.76 218.65,188.05 218.65,190.81 218.06,191.41 215.3,191.41 214.73,190.84 214.73,189.82
  BOTTOM w0.16: UNK5U408.E2 v2(214.16,189.72)
S5_OUT_RX0_CH2_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: v2(227.26,188.21) 226.93,188.53 225.81,188.53
  L21_SIGNAL w0.102: 215.09,189.82 215.2,189.72 v2(215.66,189.72)
  L21_SIGNAL w0.105: 225.81,188.53 225.57,188.53 223.79,190.32 223.01,190.32 222.73,190.03 222.73,188.88 221.24,187.39 218.79,187.39 218.28,187.89 218.28,190.66 217.9,191.04 215.45,191.04 215.09,190.69 215.09,189.82
  BOTTOM w0.16: UNK5U408.E1 v2(215.66,189.72)
S5_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK5U408.B6 212.28,191.59 212.28,192.14 211.8,192.62 211.8,193.7 UNK5R176.1
S5_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK5U408.A6 212.66,191.72 212.66,191.73 212.66,192.29 212.17,192.78 212.17,193.1 212.47,193.4 212.66,193.4 212.77,193.51 212.77,193.73 212.64,193.86 UNK5R178.1
S5_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK5C318.1 UNK5R176.2 UNK5R178.2
S5_OUT_RX0_CH3_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 225.74,188.53 226.28,188.53 v2(226.61,188.21)
  L19_SIGNAL w0.102: v2(217.22,180.5) 217.05,180.67
  L19_SIGNAL w0.105: 225.74,188.53 225.01,188.53 222.19,185.72 216.87,185.72 216.55,185.39 216.55,184.42 217.05,183.91 217.05,180.67
  BOTTOM w0.132: v2(217.22,180.5) 217.06,180.34 217.06,179.8 216.57,179.31 215,179.31 UNK5U409.B2
S5_OUT_RX0_CH3_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(216.51,180.5) 216.68,180.67
  L19_SIGNAL w0.105: 216.68,180.67 216.68,183.76 216.18,184.26 216.18,185.54 216.72,186.08 222.04,186.08 222.93,186.97 222.93,187.12 222.82,187.22 222.82,187.37 222.97,187.52 223.12,187.52 223.22,187.41 223.37,187.41 223.52,187.56 223.52,187.71 223.41,187.81 223.41,187.96 223.56,188.11 223.71,188.11 223.82,188.01 223.97,188.01 224.11,188.16 224.11,188.3 224.01,188.41 224.01,188.56 224.16,188.71 224.31,188.71 224.41,188.6 224.56,188.6 224.86,188.9 225.91,188.9 v2(225.96,188.86)
  BOTTOM w0.132: UNK5U409.B1 215.19,179.69 216.41,179.69 216.68,179.96 216.68,180.34 v2(216.51,180.5)
S5_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK5U409.B4 214.15,180.14 214.15,180.85 214.44,181.13 214.94,181.13 215.3,181.48 215.3,182.21 UNK5R1089.1
S5_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK5R1088.1 214.46,182.3 214.38,182.21 214.38,182 214.45,181.93 214.81,181.93 214.92,181.81 214.92,181.64 214.79,181.51 214.28,181.51 213.78,181 213.78,180.27 UNK5U409.A4
S5_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK5R1089.2 UNK5R1088.2 UNK5C302.1
S5_OUT_RX0_CH4_ABC_CASE+: length 20.2
  L21_SIGNAL w0.076: v2(226.61,187.56) 226.28,187.88 225.68,187.88
  L21_SIGNAL w0.102: v2(217.22,177.8) 217.05,177.97
  L21_SIGNAL w0.105: 217.05,177.97 217.05,178.34 217.46,178.76 218.18,178.76 218.69,179.27 218.69,182.83 221.86,186 222.33,186 223.37,187.03 223.37,187.53 223.67,187.84 225.64,187.84 225.68,187.88
  BOTTOM w0.132: UNK5U409.D2 215.02,179.01 216.56,179.01 217.05,178.51 217.05,177.97 v2(217.22,177.8)
S5_OUT_RX0_CH4_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 225.63,188.21 v2(225.96,188.21)
  L21_SIGNAL w0.102: v2(216.51,177.8) 216.68,177.97
  L21_SIGNAL w0.105: 216.68,177.97 216.68,178.5 217.31,179.13 218.03,179.13 218.33,179.43 218.33,180.87 218.22,180.98 217.94,180.98 217.84,181.08 217.84,181.29 217.94,181.4 218.22,181.4 218.33,181.5 218.33,181.71 218.22,181.82 217.94,181.82 217.84,181.92 217.84,182.13 217.94,182.24 218.22,182.24 218.33,182.34 218.33,182.99 221.7,186.36 222.18,186.36 223,187.18 223,187.69 223.52,188.21 225.63,188.21
  BOTTOM w0.132: v2(216.51,177.8) 216.68,177.96 216.68,178.36 216.41,178.63 215.18,178.63 UNK5U409.D1
S5_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK5U409.B5 213.41,179.9 213.41,180.41
  BOTTOM w0.132: UNK5R180.1 213.82,182.13 213.82,181.67 213.41,181.26 213.41,180.41
S5_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK5U409.A5 213.04,180.27 213.04,181 212.91,181.12 212.82,181.12 212.69,181.25 212.69,181.44 212.82,181.57 213.2,181.57 213.45,181.83 213.45,182.13 UNK5R182.1
S5_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK5R182.2 UNK5R180.2 UNK5C320.1
S5_OUT_RX0_CH5_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 226.27,187.23 226.93,187.23 v2(227.26,187.56)
  L19_SIGNAL w0.102: 214.73,178.05 214.62,178.15 v2(214.16,178.15)
  L19_SIGNAL w0.105: 226.27,187.23 226.23,187.18 225.71,187.18 223.27,184.74 223.27,183.33 219.04,179.11 219.04,178.35 217.59,176.89 215.25,176.89 214.73,177.41 214.73,178.05
  BOTTOM w0.16: UNK5U409.E2 v2(214.16,178.15)
S5_OUT_RX0_CH5_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(215.66,178.15) 215.2,178.15 215.09,178.05
  L19_SIGNAL w0.105: 215.09,178.05 215.09,177.56 215.4,177.26 217.44,177.26 218.68,178.5 218.68,179.26 221.06,181.64 221.06,181.79 220.88,181.97 220.88,182.12 221.02,182.27 221.17,182.27 221.35,182.09 221.5,182.09 221.65,182.24 221.65,182.38 221.47,182.57 221.47,182.71 221.62,182.86 221.77,182.86 221.95,182.68 222.1,182.68 222.25,182.83 222.25,182.98 222.06,183.16 222.06,183.31 222.21,183.46 222.36,183.46 222.54,183.28 222.69,183.28 222.9,183.48 222.9,184.89 225.56,187.55 225.95,187.55 v2(225.96,187.56)
  BOTTOM w0.16: UNK5U409.E1 v2(215.66,178.15)
S5_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK5R666.1 211.8,182.13 211.8,181.06 212.28,180.57 212.28,180.03 UNK5U409.B6
S5_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK5U409.A6 212.66,180.15 212.66,180.16 212.66,180.72 212.17,181.21 212.17,181.53 212.47,181.84 212.66,181.84 212.77,181.94 212.77,182.17 212.64,182.3 UNK5R664.1
S5_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK5C924.1 UNK5R666.2 UNK5R664.2
S5_PAD_SZQ: length 24.9
  L21_SIGNAL w0.102: UNK5K113.5 243.89,161.31 243.89,163.18 235.2,171.86 235.2,175.74 232.46,178.49 v2(232.46,179.76)
S5_PM_SAR0: length 134.7
  L33_SIGNAL w0.091: UNK5K34.3 172.3,240.17 172.3,235.3 201.2,206.41 201.2,168 211.34,157.86 213.45,157.86 215.75,155.56 215.75,152.67 218.81,149.62 234.16,149.62 v3(237.14,146.64)
  vias: v2(233.11,188.86)
S5_SPI_CK_ABCD_CASE: length 138.9
  L15_SIGNAL w0.091: v2(235.06,181.7) 235.87,181.7 236.58,181 236.58,179.09 234.24,176.75 233.21,176.75 232.02,175.56 227.58,175.56 227.28,175.25 224.74,175.25 224.08,175.92 219.46,175.92 217.78,174.24 210.92,174.24 204.8,168.12 143.95,168.12 131.7,180.37 123.7,180.37 122.43,179.1 116.84,179.1 115.86,180.07 115.86,181.22 UNK5K2.6
S5_SPI_CK_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK5K2.5 115.96,179.12 113.43,179.12 112.69,179.86 112.69,181.2 UNK5K3.6
S5_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK5U18.6 92.99,170.43 95.07,172.52 95.07,177.47 93.64,178.9 93.64,185.46 94.78,186.6 109.49,186.6 UNK5K3.7
S5_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK5K3.5 111.09,170.91 110.61,170.43 UNK5U19.6
S5_SPI_CZ_ABCD_CASE: length 128.6
  L15_SIGNAL w0.076: 234.73,179.58 234.73,181.38 v2(234.41,181.7)
  L15_SIGNAL w0.091: 234.73,179.58 233.63,178.48 229.72,178.48 229.14,177.9 227.12,177.9 226.54,178.48 225.6,178.48 222.2,181.88 211.25,181.88 202.76,173.4 144.79,173.4 132.33,185.85 123.69,185.85 UNK5K2.3
S5_SPI_CZ_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK5K3.3 115.39,181.7 119.54,181.7 UNK5K2.4
S5_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: UNK5K3.2 112.69,186.6 97.82,186.6 96.81,185.59 96.81,178.39 v3(102.24,172.97)
  BOTTOM w0.16: v3(102.24,172.97) UNK5U18.1
S5_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK5R205.2 UNK5U19.1 116.21,172.97 114.29,174.89 UNK5K3.4
S5_SPI_DI_ABCD_CASE: length 150.4
  L15_SIGNAL w0.091: v2(235.71,181.06) 236.07,180.69 236.07,179.24 234.11,177.29 233.04,177.29 232.08,176.32 227.08,176.32 226.69,175.94 225.07,175.94 223.44,177.57 219.46,177.57 217.3,175.41 210.13,175.41 204.42,169.7 144.32,169.7 130.8,183.22 125.17,183.22 121.53,179.59 119.4,179.59 118.99,179.99 118.99,182.79 117.93,183.85 110.42,183.85 108.27,181.7 105.84,181.7 UNK5K4.6
S5_SPI_DI_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK5K4.5 103.26,179.12 100.73,179.12 99.99,179.86 99.99,181.2 UNK5K5.6
S5_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK5U18.5 93.11,169.16 96.81,172.86 96.81,183.42 UNK5K5.7
S5_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v3(107.75,169.16) 107.75,174.06 106.77,175.04 103.94,175.04 UNK5K5.5
  BOTTOM w0.16: UNK5U19.5 v3(107.75,169.16)
S5_SPI_DO_ABCD_CASE: length 149.9
  L15_SIGNAL w0.076: v2(235.06,181.06) 235.38,180.73 235.38,179.6
  L15_SIGNAL w0.091: UNK5K4.3 107.94,183.28 110.67,186.01 117.93,186.01 119.35,184.58 119.35,182.65 120.22,181.79 121.99,181.79 125.31,185.1 131.13,185.1 145.5,170.73 202.53,170.73 210.62,178.82 210.62,179.96 210.97,180.31 212.72,180.31 213.11,179.93 213.11,177.9 213.82,177.19 217.73,177.19 218.83,178.29 223.76,178.29 224.26,177.79 226.34,177.79 226.8,177.33 229.54,177.33 230.01,177.79 233.88,177.79 235.38,179.29 235.38,179.6
S5_SPI_DO_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK5K5.3 102.69,181.7 106.84,181.7 UNK5K4.4
S5_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: UNK5K5.2 103.16,183.42 103.16,177.32 104.86,175.62 104.86,172.47 104.09,171.7 UNK5U18.2
S5_SPI_DO_D_CASE: length 24.7
  TOP w0.16: v3(121.06,171.7) 115.69,171.7 108.45,178.94 103.25,178.94 UNK5K5.4
  BOTTOM w0.16: UNK5U19.2 v3(121.06,171.7)
S5_SPI_HLD_ABCD_CASE: length 170.3
  L15_SIGNAL w0.076: v2(235.06,182.36) 235.38,182.68 236.07,182.68
  L15_SIGNAL w0.091: UNK5K6.3 93.64,181.2 93.64,179.51 95.96,177.19 131.19,177.19 145.44,162.94 219.48,162.94 222.81,166.27 222.81,169.24 224.89,171.32 228.02,171.32 229.87,173.17 232.85,173.17 235,175.32 235.97,175.32 237.71,177.06 237.71,181.71 236.73,182.68 236.07,182.68
S5_SPI_HLD_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK5K6.4 94.14,181.7 89.99,181.7 UNK5K7.3
S5_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK5R202.1 UNK5U18.7 93.11,171.7 93.73,172.31 93.73,175.51 90.46,178.78 90.46,183.42 UNK5K7.2
S5_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK5K7.4 97.15,172.34 106.14,172.34 v3(106.78,171.7)
  BOTTOM w0.16: UNK5U19.7 v3(106.78,171.7)
S5_SPI_WPZ_ABCD_CASE: length 167.9
  L15_SIGNAL w0.091: UNK5K6.6 93.14,183.9 95.84,183.9 96.81,182.93 96.81,179.6 97.98,178.44 131.55,178.44 145.29,164.69 209.75,164.69 210.11,165.05 218.27,165.05 219.96,166.74 219.96,168.22 225.63,173.88 232.92,173.88 235,175.97 236.09,175.97 237.31,177.19 237.31,181.35 236.42,182.24 235.82,182.24 v2(235.71,182.36)
S5_SPI_WPZ_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK5K7.6 87.29,181.2 87.29,179.86 88.03,179.12 90.56,179.12 UNK5K6.5
S5_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v3(102.24,170.43) 97.05,170.43 87.29,180.19 87.29,183.4 UNK5K7.7
  BOTTOM w0.16: v3(102.24,170.43) UNK5U18.3
S5_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: v3(121.06,170.43) 117.63,167 99.28,167 UNK5K7.5
  BOTTOM w0.16: UNK5U19.3 v3(121.06,170.43) UNK5R207.2
S5_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK5U31.6 224.19,174.3 223.94,174.06 UNK5R164.2
S5_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK5R163.2 223.84,173.14 224.6,173.9 UNK5U31.5
S5_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK5U31.16 227.91,173.9 UNK5R165.2
S5_USB_D_AB_CASE+: length 15.4
  L21_SIGNAL w0.13: v2(226.01,176.49) 225.94,176.56 225.94,178.78 223.42,181.3 223.42,182.24 223.55,182.37 223.86,182.37 223.99,182.5 223.99,182.76 223.86,182.89 223.55,182.89 223.42,183.02 223.42,183.28 223.55,183.41 223.86,183.41 223.99,183.53 223.99,183.79 223.86,183.92 223.55,183.92 223.42,184.05 223.42,184.76 224.52,185.86 225.56,185.86 v2(225.96,186.26)
  BOTTOM w0.165: UNK5U31.10 225.88,176.36 v2(226.01,176.49)
S5_USB_D_AB_CASE-: length 15.4
  L21_SIGNAL w0.13: v2(226.61,186.26) 226.13,186.73 225.73,186.73 225.26,186.25 224.78,186.25 224.73,186.31 224.34,186.31 222.98,184.94 222.98,181.11 225.49,178.6 225.49,176.63 v2(225.35,176.49)
  BOTTOM w0.165: v2(225.35,176.49) 225.48,176.36 UNK5U31.9
S5_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK5R160.2 223.85,175.1 UNK5U31.8
S5_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK5R161.2 223.85,174.7 UNK5U31.7
S5_USER_3V3: length 2.6
  BOTTOM w0.305: UNK5R207.1 v3(123.44,170.43) ; UNK5R205.1 v3(123.44,172.97) ; UNK5R200.1 v3(103.63,172.97) ; UNK5R203.1 v3(103.63,170.43)
  vias: v3(87.1,174.24) v3(87.1,172.97) v3(87.1,171.7) v3(87.58,175.84) v3(100.08,162.08) v3(101.74,162.35) v3(105.53,174.24) v3(105.78,172.97) v3(105.78,171.7) v3(106,175.84)
S5_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(235.06,183.65) 235.35,183.95 235.57,184.17 238.02,184.17 239.01,183.18 239.01,178.84 236.33,176.15 236.33,170.9 237.03,170.19 UNK5K32.3
S5_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK5K32.4 UNK5R135.1
S5_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK5R135.2 UNK5R136.2 UNK5C267.1 236.55,164.48 237.49,163.54 237.49,160.49 236.93,159.93 UNK5Y1.3
S5_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: v2(235.71,183.65) 237.01,183.65 237.6,183.06 237.6,179.33 234.98,176.7 234.98,170.89 234.28,170.19 UNK5K32.6
S5_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK5K32.5 UNK5R137.1
S5_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK5R137.2 UNK5R136.1 UNK5C268.1 231.69,164.48 231.29,164.07 231.29,162.72 UNK5Y1.1
S5_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(232.49,208.29) 233.31,208.29 234.04,207.56 v2(234.04,197.96)
  BOTTOM w0.16: v2(232.49,208.29) 232.19,208.59 UNK5U449.7 ; UNK5K29.7 v2(234.04,197.96)
S5_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 229.6,189.25 v2(229.21,188.86)
  BOTTOM w0.16: UNK5K29.6 233.38,200.16 232.71,199.49 232.71,193.39 231.11,191.79 230.61,191.79 229.86,191.04 229.86,189.51 229.6,189.25
S5_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK5K29.5 233.88,202.36 233.19,203.05 UNK5Y2.1 233.19,206.93 UNK5C271.1
S5_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK5U449.2 231.69,211.81 UNK5R973.2 231.92,213.09 UNK5R923.1
S5_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(231.38,208.29) 230.56,208.29 229.84,207.56 v2(229.84,197.96)
  BOTTOM w0.16: UNK5K29.2 v2(229.84,197.96) ; v2(231.38,208.29) 231.69,208.59 UNK5U449.8
S5_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: UNK5K29.3 230.64,200.16 231.34,199.45 231.34,194.01 229.21,191.87 v2(229.21,189.51)
S5_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK5K29.4 229.99,202.36 230.69,203.05 UNK5Y2.2 230.69,206.93 UNK5C272.1
S5_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK5R652.1 230.92,213.09 UNK5R973.1 231.19,211.78 UNK5U449.1
S6_0V5: length 41.7
  BOTTOM w0.305: 268.42,137 268.22,137.2 UNK6C288.1 268.17,137.18 267.99,137
  BOTTOM w0.381: UNK6MU3.3 269.49,135.92 269.37,136.04
  BOTTOM w0.508: UNK6MR2.2 UNK6MR6.1 UNK6MR5.1 UNK6MR4.1 ; UNK6MR4.1 UNK6MR3.1 267.34,134.78 UNK6C286.1 267.34,136.35 267.99,137 ; UNK6MR4.1 267.41,133.3 267.87,132.84 280.15,132.84 283.37,136.06 283.37,143.22 282.48,144.1 UNK6MK1.4 ; 269.37,136.04 269.37,136.05 268.42,137
S6_0V25: length 2.8
  BOTTOM w0.508: UNK6MK4.3 277.21,142.63 UNK6MR19.1 279.78,142.63 UNK6MR18.2
S6_0V75: length 4.9
  BOTTOM w0.381: UNK6MU3.6 UNK6MR10.2
  BOTTOM w0.508: UNK6MK2.4 276.81,138.44 UNK6C290.1 UNK6MR10.2
S6_1AWG_SHARE+: length 17.9
  L21_SIGNAL w0.102: UNK6K107.2 180.64,255.87 180.64,242.43 UNK6K34.4
S6_3V3_ETH_MUX: length 7.8
  BOTTOM w0.254: UNK6R987.1 UNK6C1080.1 v2(283.75,209.49) ; v2(284.55,213.3) UNK6C1081.1 UNK6R990.1 ; UNK6R984.1 UNK6C1077.1 276.97,209.95
  BOTTOM w0.305: UNK6R984.1 277.01,208.86 UNK6U450.10 ; UNK6U452.10 284.08,212.67 UNK6R990.1 ; UNK6R987.1 283.27,208.86 UNK6U451.10
  BOTTOM w0.508: v2(276.97,210.47) 276.97,209.95
S6_3V3_RX0_MIPI: length 13.4
  TOP w0.305: UNK6R661.2 252.78,188.06 253.12,187.72 v1(253.66,187.72)
  TOP w0.381: v1(254.66,191.72) 254.87,191.5 254.87,188.23 254.36,187.72 v1(253.66,187.72)
  BOTTOM w0.381: v1(253.66,187.72) UNK6C922.2
  BOTTOM w0.508: UNK6BDB5.2 251.5,185.91 251.82,185.59 253.3,185.59 253.66,185.95 UNK6C922.2
S6_3V3_RX1_MIPI: length 13.4
  TOP w0.305: UNK6R663.2 252.78,176.49 253.12,176.15 v1(253.66,176.15)
  TOP w0.381: v1(253.66,176.15) 254.36,176.15 254.87,176.66 254.87,179.94 v1(254.66,180.15)
  BOTTOM w0.381: v1(253.66,176.15) UNK6C923.2
  BOTTOM w0.508: UNK6BDB6.2 251.5,174.35 251.82,174.02 253.3,174.02 253.66,174.38 UNK6C923.2
S6_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK6C262.1 264.61,172.36 265.48,173.24 UNK6U31.4
  BOTTOM w0.305: UNK6BD21.2 UNK6C262.1
S6_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 269.83,210.83 UNK6C1074.1 UNK6R981.1
  BOTTOM w0.356: UNK6R981.1 269.86,209.73 UNK6U449.10
  BOTTOM w0.508: UNK6BD1728.2 269.83,210.83
S6_AWG_2SHARE+: length 212.9
  L21_SIGNAL w0.102: 176.71,252.94 176.82,253.05 UNK6K107.4 ; v2(284.3,210.18) 284.52,210.18 284.81,209.89
  L21_SIGNAL w0.105: 284.81,209.89 287.33,209.89 288.06,210.62 288.06,211.78 287.02,212.82 271.46,212.82 269.26,215.03 213.49,215.03 209.87,218.64 203.89,218.64 202.93,217.68 202.93,211.65 202.49,211.21 201.36,211.21 200.83,211.73 200.83,217.51 199.69,218.65 188.82,218.65 187.82,217.65 187.82,201.82 187.11,201.11 171,201.11 170.39,201.72 170.39,232.31 176.71,238.64 176.71,252.94
  BOTTOM w0.132: v2(284.3,210.18) 284.51,210.18 284.64,210.05 284.64,209.54 UNK6U451.1
S6_AWG_2SHARE-: length 212.9
  L21_SIGNAL w0.102: v2(284.78,210.66) 284.78,210.44 284.96,210.26 ; UNK6K107.5 176.24,253.05 176.35,252.94
  L21_SIGNAL w0.105: 176.35,252.94 176.35,252.3 176.24,252.19 176.03,252.19 175.93,252.09 175.93,251.88 176.03,251.77 176.24,251.77 176.35,251.67 176.35,238.79 170.02,232.46 170.02,201.57 170.85,200.74 187.26,200.74 188.19,201.67 188.19,217.5 188.98,218.28 199.54,218.28 200.47,217.35 200.47,211.58 201.2,210.84 202.64,210.84 203.3,211.5 203.3,217.53 204.05,218.28 209.72,218.28 213.33,214.66 269.1,214.66 271.31,212.45 286.87,212.45 287.69,211.63 287.69,210.77 287.18,210.26 284.96,210.26
  BOTTOM w0.132: UNK6U451.2 285.02,209.57 285.02,210.2 284.78,210.44 v2(284.78,210.66)
S6_AWG_3SHARE+: length 39.2
  L25_SIGNAL w0.079: 176.63,255.33 176.63,289.55
  L25_SIGNAL w0.091: K110.4 176.71,289.62 176.63,289.55 ; UNK6K107.3 176.71,255.25 176.63,255.33
S6_AWG_3SHARE-: length 39.2
  L25_SIGNAL w0.079: 176.43,255.33 176.43,289.55
  L25_SIGNAL w0.091: K110.5 176.35,289.62 176.43,289.55 ; 176.43,255.33 176.35,255.25 UNK6K107.6
S6_DVDD_DDR_RX: length 13.6
  L17_SIGNAL w0.508: 269.79,178.4 269.79,171.91 266.46,168.57 UNK6K39.3
  vias: v2(267.25,179.11) v2(267.9,180.41)
S6_DVDD_DDR_TX: length 18.3
  L23_SIGNAL w0.508: 269.87,178.11 270.72,177.26 270.72,165.43 269.83,164.54 268.06,164.54 UNK6K39.6
  vias: v2(267.9,179.11) v2(268.55,180.41)
S6_ETH_RN_AB_CASE: length 31.5
  TOP w0.381: SITE6.H16 v2(276.36,184.96)
  L15_SIGNAL w0.508: 276.97,184.96 v2(276.36,184.96)
  L15_SIGNAL w0.889: v2(285.9,207.41) 285.9,206.54 285.12,205.76 ; 277.35,184.96 276.97,184.96
  L15_SIGNAL w1.016: 277.35,184.96 278.99,186.59 278.99,203.68 279.66,204.35 284.55,204.35 285.12,204.92 285.12,205.76
  BOTTOM w0.305: v2(285.9,207.41) 285.6,207.72 UNK6U451.7
S6_ETH_RP_AB_CASE: length 31
  L15_SIGNAL w0.305: v2(275.06,184.96) 276.52,186.42
  L15_SIGNAL w0.889: 276.52,186.42 277.02,186.92 ; 283.6,206.46 284.55,207.41 v2(284.79,207.41)
  L15_SIGNAL w1.016: 277.02,186.92 277.02,205.77 277.7,206.46 283.6,206.46
  BOTTOM w0.305: v2(284.79,207.41) 285.1,207.72 UNK6U451.8
S6_ETH_TN_AB_CASE: length 26.2
  TOP w0.381: SITE6.G15 v2(276.36,185.61)
  L21_SIGNAL w0.305: 276.81,185.48 276.48,185.48 v2(276.36,185.61)
  L21_SIGNAL w0.508: 276.81,185.48 277.39,185.48 279.03,187.12
  L21_SIGNAL w0.889: 279.64,206.7 v2(279.64,207.41)
  L21_SIGNAL w1.016: 279.03,187.12 279.03,205.82 279.64,206.43 279.64,206.7
  BOTTOM w0.305: UNK6U450.7 279.33,207.72 v2(279.64,207.41)
S6_ETH_TP_AB_CASE: length 25.5
  L21_SIGNAL w0.305: v2(274.41,185.61) 275.71,185.61 276.49,186.39
  L21_SIGNAL w0.762: 277.07,187.15 277.07,186.97 276.49,186.39
  L21_SIGNAL w0.889: v2(278.52,207.41) 278.09,207.41 277.07,206.4
  L21_SIGNAL w1.016: 277.07,187.15 277.07,206.4
  BOTTOM w0.305: UNK6U450.8 278.83,207.72 v2(278.52,207.41)
S6_M_2V5: length 4.8
  BOTTOM w0.508: UNK6MR2.1 UNK6C284.1 ; UNK6C284.1 264.24,135.91 UNK6MU2.6 ; UNK6C284.1 UNK6C285.1
S6_M_3V2: length 24.3
  BOTTOM w0.381: UNK6MU3.7 273.83,135.27 273.7,135.39
  BOTTOM w0.508: 273.7,135.39 273.18,135.91 273.18,136.99 272.41,137.76 UNK6C289.1 270.13,137.76 269.04,138.85 267.37,138.85 266.52,139.7 266.52,145.05 UNK6MU1.5 267.48,146.16 UNK6MR1.1 264.2,146.16 UNK6C283.1 UNK6C282.1 262.97,146.08 UNK6MU2.2
S6_MUX_3V3: length 1.5
  TOP w0.508: v2(267.1,207.19) v2(267.86,207.19)
  BOTTOM w0.508: v2(267.1,207.19) UNK6R512.1 v2(267.86,207.19)
  vias: v2(250.56,186.46) v2(250.56,174.89) v2(262.6,172.36) v2(269.83,212.29) v2(276.97,211.41)
S6_OUT_RX0_CH0_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(257.22,192.07) 257.05,192.24
  L21_SIGNAL w0.105: 257.05,192.24 257.05,193.92 257.17,194.04 258.32,194.04 258.53,193.83 258.53,193.13 259.24,192.41 260.27,192.41 260.37,192.31 260.37,192.15 260.48,192.05 260.69,192.05 260.79,192.15 260.79,192.31 260.9,192.41 261.1,192.41 261.21,192.31 261.21,192.15 261.31,192.05 261.52,192.05 261.63,192.15 261.63,192.31 261.73,192.41 261.94,192.41 262.05,192.31 262.05,192.15 262.15,192.05 262.36,192.05 262.47,192.15 262.47,192.31 262.57,192.41 265.65,192.41 267.25,190.81 v2(267.25,189.51)
  BOTTOM w0.132: v2(257.22,192.07) 257.06,191.91 257.06,191.37 256.57,190.88 255,190.88 UNK6U408.B2
S6_OUT_RX0_CH0_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 267.62,189.81 267.62,189.03 267.58,188.99 267.58,188.72 267.9,188.4 v2(267.9,188.21)
  L21_SIGNAL w0.102: v2(256.51,192.07) 256.68,192.24
  L21_SIGNAL w0.105: 256.68,192.24 256.68,194.08 257.02,194.41 258.47,194.41 258.89,193.98 258.89,193.28 259.4,192.78 265.81,192.78 267.62,190.96 267.62,189.81
  BOTTOM w0.132: UNK6U408.B1 255.19,191.25 256.41,191.25 256.68,191.52 256.68,191.9 v2(256.51,192.07)
S6_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK6U408.B4 254.15,191.71 254.15,192.41 254.44,192.7 254.94,192.7 255.3,193.05 255.3,193.77 UNK6R647.1
S6_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK6R646.1 254.46,193.86 254.38,193.78 254.38,193.57 254.45,193.5 254.81,193.5 254.92,193.38 254.92,193.21 254.79,193.07 254.28,193.07 253.78,192.57 253.78,191.83 UNK6U408.A4
S6_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK6R647.2 UNK6R646.2 UNK6C309.1
S6_OUT_RX0_CH1_ABC_CASE+: length 20.2
  L19_SIGNAL w0.102: v2(257.22,189.36) 257.05,189.19
  L19_SIGNAL w0.105: v2(266.61,189.51) 265.92,190.19 265,190.19 264.85,190.33 264.57,190.33 264.43,190.19 262.88,190.19 262.59,190.47 262.59,192.13 262.05,192.67 259.22,192.67 258.57,192.02 258.57,188.82 258.01,188.26 257.36,188.26 257.05,188.58 257.05,189.19
  BOTTOM w0.132: UNK6U408.D2 255.02,190.57 256.56,190.57 257.05,190.08 257.05,189.53 v2(257.22,189.36)
S6_OUT_RX0_CH1_ABC_CASE-: length 20.2
  L19_SIGNAL w0.076: v2(267.25,188.86) 266.93,189.18 266.41,189.18
  L19_SIGNAL w0.102: v2(256.51,189.36) 256.68,189.19
  L19_SIGNAL w0.105: 266.41,189.18 265.77,189.82 262.73,189.82 262.23,190.32 262.23,191.98 261.9,192.31 259.37,192.31 258.93,191.87 258.93,188.67 258.17,187.9 257.21,187.9 256.68,188.42 256.68,189.19
  BOTTOM w0.132: v2(256.51,189.36) 256.68,189.53 256.68,189.93 256.41,190.2 255.18,190.2 UNK6U408.D1
S6_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: 253.41,191.97 253.41,191.47 UNK6U408.B5
  BOTTOM w0.132: 253.41,191.97 253.41,192.83 253.82,193.24 253.82,193.7 UNK6R168.1
S6_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK6U408.A5 253.04,191.84 253.04,192.56 252.91,192.69 252.82,192.69 252.69,192.82 252.69,193.01 252.82,193.14 253.2,193.14 253.45,193.39 253.45,193.7 UNK6R170.1
S6_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK6C310.1 UNK6R168.2 UNK6R170.2
S6_OUT_RX0_CH2_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(254.16,189.72) 254.62,189.72 254.73,189.82
  L21_SIGNAL w0.105: 254.73,189.82 254.73,190.84 255.3,191.41 258.06,191.41 258.65,190.81 258.65,188.05 258.94,187.76 261.09,187.76 262.36,189.03 262.36,190.19 262.86,190.68 263.94,190.68 264.54,190.09 264.81,190.09 264.97,189.92 264.97,189.66 265.43,189.19 266.27,189.19 v2(266.61,188.86)
  BOTTOM w0.16: UNK6U408.E2 v2(254.16,189.72)
S6_OUT_RX0_CH2_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: v2(267.25,188.21) 266.93,188.53 265.81,188.53
  L21_SIGNAL w0.102: 255.09,189.82 255.2,189.72 v2(255.66,189.72)
  L21_SIGNAL w0.105: 265.81,188.53 265.57,188.53 263.79,190.32 263.01,190.32 262.73,190.03 262.73,188.88 261.24,187.39 258.79,187.39 258.28,187.89 258.28,190.66 257.9,191.04 255.45,191.04 255.09,190.69 255.09,189.82
  BOTTOM w0.16: UNK6U408.E1 v2(255.66,189.72)
S6_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK6R176.1 251.8,193.7 251.8,192.62 252.28,192.14 252.28,191.59 UNK6U408.B6
S6_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK6R178.1 252.64,193.86 252.77,193.73 252.77,193.51 252.66,193.4 252.47,193.4 252.17,193.1 252.17,192.78 252.66,192.29 252.66,191.72 UNK6U408.A6
S6_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK6R178.2 UNK6R176.2 UNK6C318.1
S6_OUT_RX0_CH3_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 265.74,188.53 266.28,188.53 v2(266.61,188.21)
  L19_SIGNAL w0.102: v2(257.22,180.5) 257.05,180.67
  L19_SIGNAL w0.105: 265.74,188.53 265.01,188.53 262.19,185.72 256.87,185.72 256.55,185.39 256.55,184.42 257.05,183.91 257.05,180.67
  BOTTOM w0.132: v2(257.22,180.5) 257.06,180.34 257.06,179.8 256.57,179.31 255,179.31 UNK6U409.B2
S6_OUT_RX0_CH3_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(256.51,180.5) 256.68,180.67
  L19_SIGNAL w0.105: v2(265.96,188.86) 265.91,188.9 264.86,188.9 264.56,188.6 264.41,188.6 264.31,188.71 264.16,188.71 264.01,188.56 264.01,188.41 264.11,188.3 264.11,188.16 263.97,188.01 263.82,188.01 263.71,188.11 263.56,188.11 263.41,187.96 263.41,187.81 263.52,187.71 263.52,187.56 263.37,187.41 263.22,187.41 263.12,187.52 262.97,187.52 262.82,187.37 262.82,187.22 262.93,187.12 262.93,186.97 262.04,186.08 256.72,186.08 256.18,185.54 256.18,184.26 256.68,183.76 256.68,180.67
  BOTTOM w0.132: UNK6U409.B1 255.19,179.69 256.41,179.69 256.68,179.96 256.68,180.34 v2(256.51,180.5)
S6_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK6R1089.1 255.3,182.21 255.3,181.48 254.94,181.13 254.44,181.13 254.15,180.85 254.15,180.14 UNK6U409.B4
S6_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK6U409.A4 253.78,180.27 253.78,181 254.28,181.51 254.79,181.51 254.92,181.64 254.92,181.81 254.81,181.93 254.45,181.93 254.38,182 254.38,182.21 254.46,182.3 UNK6R1088.1
S6_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK6C302.1 UNK6R1088.2 UNK6R1089.2
S6_OUT_RX0_CH4_ABC_CASE+: length 20.2
  L21_SIGNAL w0.076: v2(266.61,187.56) 266.28,187.88 265.68,187.88
  L21_SIGNAL w0.102: v2(257.22,177.8) 257.05,177.97
  L21_SIGNAL w0.105: 257.05,177.97 257.05,178.34 257.46,178.76 258.18,178.76 258.69,179.27 258.69,182.83 261.86,186 262.33,186 263.37,187.03 263.37,187.53 263.67,187.84 265.64,187.84 265.68,187.88
  BOTTOM w0.132: v2(257.22,177.8) 257.05,177.97 257.05,178.51 256.56,179.01 255.02,179.01 UNK6U409.D2
S6_OUT_RX0_CH4_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 265.63,188.21 v2(265.96,188.21)
  L21_SIGNAL w0.102: v2(256.51,177.8) 256.68,177.97
  L21_SIGNAL w0.105: 265.63,188.21 263.52,188.21 263,187.69 263,187.18 262.18,186.36 261.7,186.36 258.33,182.99 258.33,182.34 258.22,182.24 257.94,182.24 257.84,182.13 257.84,181.92 257.94,181.82 258.22,181.82 258.33,181.71 258.33,181.5 258.22,181.4 257.94,181.4 257.84,181.29 257.84,181.08 257.94,180.98 258.22,180.98 258.33,180.87 258.33,179.43 258.03,179.13 257.31,179.13 256.68,178.5 256.68,177.97
  BOTTOM w0.132: v2(256.51,177.8) 256.68,177.96 256.68,178.36 256.41,178.63 255.18,178.63 UNK6U409.D1
S6_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK6U409.B5 253.41,179.9 253.41,180.41
  BOTTOM w0.132: 253.41,180.41 253.41,181.26 253.82,181.67 253.82,182.13 UNK6R180.1
S6_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK6R182.1 253.45,182.13 253.45,181.83 253.2,181.57 252.82,181.57 252.69,181.44 252.69,181.25 252.82,181.12 252.91,181.12 253.04,181 253.04,180.27 UNK6U409.A5
S6_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK6R182.2 UNK6R180.2 UNK6C320.1
S6_OUT_RX0_CH5_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 266.27,187.23 266.93,187.23 v2(267.25,187.56)
  L19_SIGNAL w0.102: v2(254.16,178.15) 254.62,178.15 254.73,178.05
  L19_SIGNAL w0.105: 266.27,187.23 266.23,187.18 265.71,187.18 263.27,184.74 263.27,183.33 259.04,179.11 259.04,178.35 257.59,176.89 255.25,176.89 254.73,177.41 254.73,178.05
  BOTTOM w0.16: UNK6U409.E2 v2(254.16,178.15)
S6_OUT_RX0_CH5_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(255.66,178.15) 255.2,178.15
  L19_SIGNAL w0.105: v2(265.96,187.56) 265.95,187.55 265.56,187.55 262.9,184.89 262.9,183.48 262.69,183.28 262.54,183.28 262.36,183.46 262.21,183.46 262.06,183.31 262.06,183.16 262.25,182.98 262.25,182.83 262.1,182.68 261.95,182.68 261.77,182.86 261.62,182.86 261.47,182.71 261.47,182.57 261.65,182.38 261.65,182.24 261.5,182.09 261.35,182.09 261.17,182.27 261.02,182.27 260.88,182.12 260.88,181.97 261.06,181.79 261.06,181.64 258.68,179.26 258.68,178.5 257.44,177.26 255.4,177.26 255.09,177.56 255.09,178.05 255.2,178.15
  BOTTOM w0.16: UNK6U409.E1 v2(255.66,178.15)
S6_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.076: UNK6U409.B6 252.28,180.03
  BOTTOM w0.132: UNK6R666.1 251.8,182.13 251.8,181.06 252.28,180.57 252.28,180.03
S6_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK6U409.A6 252.66,180.15 252.66,180.16 252.66,180.72 252.17,181.21 252.17,181.53 252.47,181.84 252.66,181.84 252.77,181.94 252.77,182.17 252.64,182.3 UNK6R664.1
S6_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK6C924.1 UNK6R666.2 UNK6R664.2
S6_PAD_SZQ: length 24.9
  L21_SIGNAL w0.102: UNK6K113.5 283.89,161.31 283.89,163.18 275.2,171.86 275.2,175.74 272.46,178.49 v2(272.46,179.76)
S6_PM_SAR0: length 167.7
  L33_SIGNAL w0.091: v3(277.14,146.64) 274.65,149.12 236.48,149.12 234.02,151.58 222.86,151.58 220.72,153.73 219.62,153.73 218.3,155.05 217.57,155.05 216.61,156 216.61,156.73 208.03,165.32 206.85,165.32 203.32,168.85 203.32,209.44 180.68,232.08 180.68,241.45 UNK6K34.3
  vias: v2(273.11,188.86)
S6_SPI_CK_ABCD_CASE: length 187.4
  L15_SIGNAL w0.091: v2(275.06,181.7) 275.87,181.7 276.58,181 276.58,179.09 274.65,177.17 274.65,170.46 269.77,165.58 269.77,161.93 265.95,158.12 258.02,158.12 257.31,157.41 251.7,157.41 247.9,153.62 219.65,153.62 218.96,152.93 159.31,152.93 155.87,149.49 141.35,149.49 139.58,147.73 122.81,147.73 122.43,147.35 116.84,147.35 115.86,148.32 115.86,149.47 UNK6K2.6
S6_SPI_CK_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK6K2.5 115.96,147.37 113.43,147.37 112.69,148.11 112.69,149.45 UNK6K3.6
S6_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK6K3.7 109.49,154.85 94.78,154.85 93.64,153.71 93.64,147.15 95.07,145.72 95.07,140.77 92.99,138.68 UNK6U18.6
S6_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK6U19.6 110.61,138.68 111.09,139.16 UNK6K3.5
S6_SPI_CZ_ABCD_CASE: length 171
  L15_SIGNAL w0.076: 274.73,179.58 274.73,181.38 v2(274.41,181.7)
  L15_SIGNAL w0.091: UNK6K2.3 123.82,154.22 152.42,154.22 155.95,157.75 247.5,157.75 252.42,162.67 259.12,162.67 262.22,165.78 262.22,170.63 269.64,178.05 273.2,178.05 274.73,179.58
S6_SPI_CZ_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK6K3.3 115.39,149.95 119.54,149.95 UNK6K2.4
S6_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: UNK6K3.2 112.69,154.85 97.82,154.85 96.81,153.84 96.81,146.64 v3(102.24,141.22)
  BOTTOM w0.16: v3(102.24,141.22) UNK6U18.1
S6_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK6K3.4 114.29,143.14 116.21,141.22 UNK6U19.1 UNK6R205.2
S6_SPI_DI_ABCD_CASE: length 196.7
  L15_SIGNAL w0.091: UNK6K4.6 105.84,149.95 108.27,149.95 110.42,152.1 117.93,152.1 118.99,151.04 118.99,148.24 119.4,147.84 121.53,147.84 123.19,149.49 130.21,149.49 132.87,152.15 155.98,152.15 158.72,154.89 219.41,154.89 220.34,155.83 248.37,155.83 251.03,158.48 251.03,159.07 252.11,160.15 266.04,160.15 267.56,161.66 267.56,167.56 268.5,168.5 268.5,169.49 274.14,175.13 274.14,177.32 276.07,179.24 276.07,180.69 v2(275.71,181.06)
S6_SPI_DI_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK6K5.6 99.99,149.45 99.99,148.11 100.73,147.37 103.26,147.37 UNK6K4.5
S6_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK6U18.5 93.11,137.41 96.81,141.11 96.81,151.67 UNK6K5.7
S6_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v3(107.75,137.41) 107.75,142.31 106.77,143.29 103.94,143.29 UNK6K5.5
  BOTTOM w0.16: UNK6U19.5 v3(107.75,137.41)
S6_SPI_DO_ABCD_CASE: length 188.1
  L15_SIGNAL w0.076: v2(275.06,181.06) 275.38,180.73 275.38,179.6
  L15_SIGNAL w0.091: UNK6K4.3 107.94,151.53 110.67,154.26 117.93,154.26 119.35,152.83 119.35,150.9 120.22,150.04 123.04,150.04 125.15,152.15 131.78,152.15 132.47,152.84 154.04,152.84 156.67,155.47 219.14,155.47 220.03,156.36 228.09,156.36 228.96,157.23 247.71,157.23 251.86,161.37 261.17,161.37 265.32,165.52 265.32,167.18 266.77,168.63 266.77,169.87 273.25,176.35 273.25,177.16 275.38,179.29 275.38,179.6
S6_SPI_DO_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK6K5.3 102.69,149.95 106.84,149.95 UNK6K4.4
S6_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: UNK6U18.2 104.09,139.95 104.86,140.72 104.86,145.82 103.16,147.52 103.16,151.67 UNK6K5.2
S6_SPI_DO_D_CASE: length 24.7
  TOP w0.16: UNK6K5.4 103.25,147.19 108.45,147.19 115.69,139.95 v3(121.06,139.95)
  BOTTOM w0.16: UNK6U19.2 v3(121.06,139.95)
S6_SPI_HLD_ABCD_CASE: length 224.3
  L15_SIGNAL w0.076: 276.07,182.68 275.38,182.68 v2(275.06,182.36)
  L15_SIGNAL w0.091: UNK6K6.3 93.64,149.45 93.64,147.76 95.96,145.44 135.23,145.44 135.39,145.29 156.39,145.29 160.84,149.73 234.19,149.73 235.64,151.18 248.72,151.18 250.2,152.67 258.34,152.67 259.29,153.61 276.09,153.61 279.47,156.99 279.47,176.7 277.71,178.47 277.71,181.71 276.73,182.68 276.07,182.68
S6_SPI_HLD_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK6K6.4 94.14,149.95 89.99,149.95 UNK6K7.3
S6_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK6R202.1 UNK6U18.7 93.11,139.95 93.73,140.56 93.73,143.76 90.46,147.03 90.46,151.67 UNK6K7.2
S6_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK6K7.4 97.15,140.59 106.14,140.59 v3(106.78,139.95)
  BOTTOM w0.16: UNK6U19.7 v3(106.78,139.95)
S6_SPI_WPZ_ABCD_CASE: length 221.8
  L15_SIGNAL w0.091: v2(275.71,182.36) 275.82,182.24 276.42,182.24 277.31,181.35 277.31,177.79 278.71,176.4 278.71,158.36 276.05,155.7 259.45,155.7 258.81,155.07 251.51,155.07 248.36,151.92 160.78,151.92 155.55,146.69 97.98,146.69 96.81,147.85 96.81,151.18 95.84,152.15 93.14,152.15 UNK6K6.6
S6_SPI_WPZ_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK6K7.6 87.29,149.45 87.29,148.11 88.03,147.37 90.56,147.37 UNK6K6.5
S6_SPI_WPZ_C_CASE: length 27
  TOP w0.16: UNK6K7.7 87.29,151.65 87.29,148.44 97.05,138.68 v3(102.24,138.68)
  BOTTOM w0.16: v3(102.24,138.68) UNK6U18.3
S6_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: v3(121.06,138.68) 117.63,135.25 99.28,135.25 UNK6K7.5
  BOTTOM w0.16: UNK6U19.3 v3(121.06,138.68) UNK6R207.2
S6_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK6U31.6 264.19,174.3 263.94,174.06 UNK6R164.2
S6_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK6R163.2 263.84,173.14 264.6,173.9 UNK6U31.5
S6_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK6R165.2 267.91,173.9 UNK6U31.16
S6_USB_D_AB_CASE+: length 15.4
  L21_SIGNAL w0.13: v2(266.01,176.49) 265.94,176.56 265.94,178.78 263.42,181.3 263.42,182.24 263.55,182.37 263.86,182.37 263.99,182.5 263.99,182.76 263.86,182.89 263.55,182.89 263.42,183.02 263.42,183.28 263.55,183.41 263.86,183.41 263.99,183.53 263.99,183.79 263.86,183.92 263.55,183.92 263.42,184.05 263.42,184.76 264.52,185.86 265.56,185.86 v2(265.96,186.26)
  BOTTOM w0.165: UNK6U31.10 265.88,176.36 v2(266.01,176.49)
S6_USB_D_AB_CASE-: length 15.4
  L21_SIGNAL w0.13: v2(266.61,186.26) 266.13,186.73 265.73,186.73 265.25,186.25 264.78,186.25 264.73,186.31 264.34,186.31 262.98,184.94 262.98,181.11 265.49,178.6 265.49,176.63 v2(265.35,176.49)
  BOTTOM w0.165: UNK6U31.9 265.48,176.36 v2(265.35,176.49)
S6_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK6U31.8 263.85,175.1 UNK6R160.2
S6_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK6U31.7 263.85,174.7 UNK6R161.2
S6_USER_3V3: length 2.6
  BOTTOM w0.305: UNK6R205.1 v3(123.44,141.22) ; UNK6R200.1 v3(103.63,141.22) ; UNK6R203.1 v3(103.63,138.68) ; UNK6R207.1 v3(123.44,138.68)
  vias: v3(87.1,142.49) v3(87.1,141.22) v3(87.1,139.95) v3(87.58,144.09) v3(100.08,130.33) v3(101.74,130.6) v3(105.53,142.49) v3(105.78,141.22) v3(105.78,139.95) v3(106,144.09)
S6_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: UNK6K32.3 277.03,170.19 276.33,170.9 276.33,176.15 279.01,178.84 279.01,183.18 278.02,184.17 275.57,184.17 275.35,183.95 v2(275.06,183.65)
S6_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK6K32.4 UNK6R135.1
S6_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK6R135.2 UNK6R136.2 UNK6C267.1 276.55,164.48 277.49,163.54 277.49,160.49 276.93,159.93 UNK6Y1.3
S6_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: UNK6K32.6 274.28,170.19 274.98,170.89 274.98,176.7 277.6,179.33 277.6,183.06 277.01,183.65 v2(275.71,183.65)
S6_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK6K32.5 UNK6R137.1
S6_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK6Y1.1 271.29,162.72 271.29,164.07 271.69,164.48 UNK6C268.1 UNK6R136.1 UNK6R137.2
S6_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(274.04,197.96) 274.04,207.56 273.31,208.29 v2(272.49,208.29)
  BOTTOM w0.16: UNK6U449.7 272.19,208.59 v2(272.49,208.29) ; UNK6K29.7 v2(274.04,197.96)
S6_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 269.6,189.25 v2(269.2,188.86)
  BOTTOM w0.16: UNK6K29.6 273.38,200.16 272.71,199.49 272.71,193.39 271.11,191.79 270.61,191.79 269.85,191.04 269.85,189.51 269.6,189.25
S6_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK6K29.5 273.88,202.36 273.19,203.05 UNK6Y2.1 273.19,206.93 UNK6C271.1
S6_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK6R923.1 271.92,213.09 UNK6R973.2 271.69,211.81 UNK6U449.2
S6_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(271.38,208.29) 270.56,208.29 269.84,207.56 v2(269.84,197.96)
  BOTTOM w0.16: UNK6U449.8 271.69,208.59 v2(271.38,208.29) ; UNK6K29.2 v2(269.84,197.96)
S6_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: v2(269.2,189.51) 269.2,191.87 271.34,194.01 271.34,199.45 270.64,200.16 UNK6K29.3
S6_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK6K29.4 269.99,202.36 270.69,203.05 UNK6Y2.2 270.69,206.93 UNK6C272.1
S6_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK6U449.1 271.19,211.78 UNK6R973.1 270.92,213.09 UNK6R652.1
S7_0V5: length 41.7
  BOTTOM w0.305: 308.42,137 308.22,137.2 UNK7C288.1 308.17,137.18 307.99,137
  BOTTOM w0.381: 309.37,136.04 309.49,135.92 UNK7MU3.3
  BOTTOM w0.508: 307.99,137 307.34,136.35 UNK7C286.1 307.34,134.78 UNK7MR3.1 UNK7MR4.1 ; UNK7MR4.1 UNK7MR5.1 UNK7MR6.1 UNK7MR2.2 ; UNK7MR4.1 307.41,133.3 307.87,132.84 320.15,132.84 323.37,136.06 323.37,143.22 322.48,144.1 UNK7MK1.4 ; 308.42,137 309.37,136.05 309.37,136.04
S7_0V25: length 2.8
  BOTTOM w0.508: UNK7MK4.3 317.21,142.63 UNK7MR19.1 319.78,142.63 UNK7MR18.2
S7_0V75: length 4.9
  BOTTOM w0.381: UNK7MU3.6 UNK7MR10.2
  BOTTOM w0.508: UNK7MK2.4 316.81,138.44 UNK7C290.1 UNK7MR10.2
S7_1AWG_SHARE+: length 17.9
  L21_SIGNAL w0.102: UNK7K34.4 190.3,242.43 190.3,255.87 UNK7K107.2
S7_3V3_ETH_MUX: length 7.8
  BOTTOM w0.254: 316.97,209.95 UNK7C1077.1 UNK7R984.1 ; v2(324.55,213.3) UNK7C1081.1 UNK7R990.1 ; v2(323.75,209.49) UNK7C1080.1 UNK7R987.1
  BOTTOM w0.305: UNK7U450.10 317.01,208.86 UNK7R984.1 ; UNK7U451.10 323.27,208.86 UNK7R987.1 ; UNK7U452.10 324.08,212.67 UNK7R990.1
  BOTTOM w0.508: v2(316.97,210.47) 316.97,209.95
S7_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v1(293.66,187.72) 293.12,187.72 292.78,188.06 UNK7R661.2
  TOP w0.381: v1(293.66,187.72) 294.36,187.72 294.87,188.23 294.87,191.5 v1(294.66,191.72)
  BOTTOM w0.381: v1(293.66,187.72) UNK7C922.2
  BOTTOM w0.508: UNK7BDB5.2 291.5,185.91 291.82,185.59 293.3,185.59 293.66,185.95 UNK7C922.2
S7_3V3_RX1_MIPI: length 13.4
  TOP w0.305: v1(293.66,176.15) 293.12,176.15 292.78,176.49 UNK7R663.2
  TOP w0.381: v1(293.66,176.15) 294.36,176.15 294.87,176.66 294.87,179.94 v1(294.66,180.15)
  BOTTOM w0.381: v1(293.66,176.15) UNK7C923.2
  BOTTOM w0.508: UNK7BDB6.2 291.5,174.35 291.82,174.02 293.3,174.02 293.66,174.38 UNK7C923.2
S7_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK7U31.4 305.48,173.24 304.6,172.36 UNK7C262.1
  BOTTOM w0.305: UNK7BD21.2 UNK7C262.1
S7_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: UNK7R981.1 UNK7C1074.1 309.83,210.83
  BOTTOM w0.356: UNK7U449.10 309.86,209.73 UNK7R981.1
  BOTTOM w0.508: UNK7BD1728.2 309.83,210.83
S7_AWG_2SHARE+: length 212.9
  L21_SIGNAL w0.102: v2(324.3,210.18) 324.52,210.18 324.81,209.89 ; 186.37,252.94 186.47,253.05 UNK7K107.4
  L21_SIGNAL w0.105: 186.37,252.94 186.37,238.15 173.15,224.93 173.15,217.17 174.18,216.13 184.38,216.13 185.3,217.05 185.3,219.89 186.56,221.16 210.35,221.16 215.05,216.46 270.28,216.46 271.71,215.03 309.26,215.03 311.46,212.82 327.02,212.82 328.06,211.78 328.06,210.62 327.33,209.89 324.81,209.89
  BOTTOM w0.132: v2(324.3,210.18) 324.51,210.18 324.64,210.05 324.64,209.54 UNK7U451.1
S7_AWG_2SHARE-: length 212.9
  L21_SIGNAL w0.102: 324.96,210.26 324.78,210.44 v2(324.78,210.66) ; 186,252.94 185.89,253.05 UNK7K107.5
  L21_SIGNAL w0.105: 186,252.94 186,252.18 185.89,252.07 185.68,252.07 185.58,251.97 185.58,251.76 185.68,251.65 185.89,251.65 186,251.55 186,238.3 172.78,225.08 172.78,217.02 174.03,215.76 184.54,215.76 185.66,216.89 185.66,219.74 186.72,220.79 210.2,220.79 214.9,216.09 270.13,216.09 271.56,214.66 309.1,214.66 311.31,212.45 326.87,212.45 327.69,211.63 327.69,210.77 327.18,210.26 324.96,210.26
  BOTTOM w0.132: v2(324.78,210.66) 324.78,210.44 325.02,210.2 325.02,209.57 UNK7U451.2
S7_AWG_3SHARE+: length 39.2
  L25_SIGNAL w0.079: 186.28,255.33 186.28,289.55
  L25_SIGNAL w0.091: 186.28,255.33 186.36,255.25 UNK7K107.3 ; 186.28,289.55 186.36,289.62 K111.4
S7_AWG_3SHARE-: length 39.2
  L25_SIGNAL w0.079: 186.09,289.55 186.09,255.33
  L25_SIGNAL w0.091: K111.5 186.01,289.62 186.09,289.55 ; UNK7K107.6 186.01,255.25 186.09,255.33
S7_DVDD_DDR_RX: length 13.6
  L17_SIGNAL w0.508: 309.79,178.4 309.79,171.91 306.46,168.57 UNK7K39.3
  vias: v2(307.25,179.11) v2(307.9,180.41)
S7_DVDD_DDR_TX: length 18.3
  L23_SIGNAL w0.508: UNK7K39.6 308.06,164.54 309.83,164.54 310.72,165.43 310.72,177.26 309.87,178.11
  vias: v2(307.9,179.11) v2(308.55,180.41)
S7_ETH_RN_AB_CASE: length 31.5
  TOP w0.381: SITE7.H16 v2(316.35,184.96)
  L15_SIGNAL w0.508: 316.97,184.96 v2(316.35,184.96)
  L15_SIGNAL w0.889: v2(325.9,207.41) 325.9,206.54 325.12,205.76 ; 317.35,184.96 316.97,184.96
  L15_SIGNAL w1.016: 325.12,205.76 325.12,204.92 324.55,204.35 319.66,204.35 318.99,203.68 318.99,186.59 317.35,184.96
  BOTTOM w0.305: UNK7U451.7 325.6,207.72 v2(325.9,207.41)
S7_ETH_RP_AB_CASE: length 31
  L15_SIGNAL w0.305: v2(315.05,184.96) 316.52,186.42
  L15_SIGNAL w0.889: v2(324.79,207.41) 324.55,207.41 323.6,206.46 ; 316.52,186.42 317.02,186.92
  L15_SIGNAL w1.016: 317.02,186.92 317.02,205.77 317.7,206.46 323.6,206.46
  BOTTOM w0.305: v2(324.79,207.41) 325.1,207.72 UNK7U451.8
S7_ETH_TN_AB_CASE: length 26.2
  TOP w0.381: SITE7.G15 v2(316.35,185.61)
  L21_SIGNAL w0.305: 316.81,185.48 316.48,185.48 v2(316.35,185.61)
  L21_SIGNAL w0.508: 319.03,187.12 317.39,185.48 316.81,185.48
  L21_SIGNAL w0.889: 319.64,206.7 v2(319.64,207.41)
  L21_SIGNAL w1.016: 319.03,187.12 319.03,205.82 319.64,206.43 319.64,206.7
  BOTTOM w0.305: v2(319.64,207.41) 319.33,207.72 UNK7U450.7
S7_ETH_TP_AB_CASE: length 25.5
  L21_SIGNAL w0.305: v2(314.41,185.61) 315.7,185.61 316.49,186.39
  L21_SIGNAL w0.762: 317.07,187.15 317.07,186.97 316.49,186.39
  L21_SIGNAL w0.889: 317.07,206.4 318.09,207.41 v2(318.52,207.41)
  L21_SIGNAL w1.016: 317.07,187.15 317.07,206.4
  BOTTOM w0.305: UNK7U450.8 318.83,207.72 v2(318.52,207.41)
S7_M_2V5: length 4.8
  BOTTOM w0.508: UNK7MU2.6 304.24,135.91 UNK7C284.1 ; UNK7MR2.1 UNK7C284.1 ; UNK7C284.1 UNK7C285.1
S7_M_3V2: length 24.3
  BOTTOM w0.381: UNK7MU3.7 313.83,135.27 313.7,135.39
  BOTTOM w0.508: 313.7,135.39 313.18,135.91 313.18,136.99 312.41,137.76 UNK7C289.1 310.13,137.76 309.04,138.85 307.37,138.85 306.52,139.7 306.52,145.05 UNK7MU1.5 307.48,146.16 UNK7MR1.1 304.2,146.16 UNK7C283.1 UNK7C282.1 302.97,146.08 UNK7MU2.2
S7_MUX_3V3: length 1.5
  TOP w0.508: v2(307.1,207.19) v2(307.86,207.19)
  BOTTOM w0.508: v2(307.86,207.19) UNK7R512.1 v2(307.1,207.19)
  vias: v2(290.56,186.46) v2(290.56,174.89) v2(302.6,172.36) v2(309.83,212.29) v2(316.97,211.41)
