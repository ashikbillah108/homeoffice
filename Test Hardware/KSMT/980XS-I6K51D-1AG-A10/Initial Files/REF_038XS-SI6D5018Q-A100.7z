# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D20404: length 244.5
  L25_SIGNAL w0.076: v2(346.6,182.35) 346.26,182.7 345.7,182.7
  L25_SIGNAL w0.091: D204.04 461.01,39.37 456.13,39.37 441.96,53.54 441.96,107.44 420.12,129.29 371.6,129.29 370.08,130.81 350.27,130.81 344.73,136.35 344.73,145.53 344.08,146.18 343.03,146.18 342.31,146.89 342.31,157.62 343.1,158.41 343.1,163.86 343.98,164.74 346.49,164.74 347.56,165.81 347.56,168.19 344.29,171.46 344.29,180.86 345.21,181.78 345.21,182.38 345.53,182.7 345.7,182.7
D20405: length 383.5
  L31_SIGNAL w0.076: 225.73,181.38 226.93,181.38 v2(227.26,181.7)
  L31_SIGNAL w0.091: 225.73,181.38 225.47,181.38 225.2,181.11 225.2,178.89 227.3,176.79 227.3,170.03 229.69,167.64 229.69,165.7 228.84,164.85 227.76,164.85 227.17,164.27 225.87,164.27 225.35,163.75 225.35,160.96 224.61,160.22 224.61,150.45 220.44,146.28 220.44,129.16 226.85,122.76 v3(229.87,122.76)
  L33_SIGNAL w0.091: v3(229.87,122.76) 229.84,122.76 229.23,122.15 229.23,120.65 230.72,119.16 230.72,114.97 233.91,111.79 286.56,111.79 291.1,116.32 299.37,116.32 301.8,113.88 301.8,112.93 302.95,111.79 369.16,111.79 375.79,105.16 419.14,105.16 427.1,97.19 427.1,50.82 445.92,32 461.26,32 D204.05
D20406: length 358.6
  L29_SIGNAL w0.076: 265.73,181.38 266.93,181.38 v2(267.25,181.7)
  L29_SIGNAL w0.091: D204.06 466.16,39.3 466.16,41.21 465.35,42.02 456.26,42.02 436.07,62.21 436.07,88.67 419.63,105.11 355.21,105.11 354.1,104 248.02,104 244.91,107.11 244.91,125.27 251.36,131.72 251.69,131.72 260.44,140.48 260.44,146.28 264.61,150.45 264.61,160.22 265.35,160.96 265.35,163.75 265.87,164.27 267.17,164.27 267.76,164.85 268.84,164.85 269.69,165.7 269.69,167.64 267.3,170.03 267.3,176.79 265.2,178.89 265.2,181.11 265.47,181.38 265.73,181.38
D20407: length 295.8
  L27_SIGNAL w0.076: 305.73,181.38 306.93,181.38 v2(307.25,181.7)
  L27_SIGNAL w0.091: 305.73,181.38 305.47,181.38 305.2,181.11 305.2,178.89 307.3,176.79 307.3,170.03 309.69,167.64 309.69,165.7 308.84,164.85 307.76,164.85 307.17,164.27 305.87,164.27 305.35,163.75 305.35,160.96 304.61,160.22 304.61,150.45 300.44,146.28 300.44,127.56 304.3,123.7 304.3,115.77 304.54,115.53 304.54,107.55 307.77,104.33 420.48,104.33 450.02,74.78 450.02,51.74 458.88,42.88 466.8,42.88 468.7,40.98 468.7,36.76 D204.07
D20408: length 250.2
  L25_SIGNAL w0.076: 345.73,181.38 346.93,181.38 v2(347.25,181.7)
  L25_SIGNAL w0.091: D204.08 468.61,41.93 454.41,41.93 442.59,53.75 442.59,107.82 420.62,129.79 371.93,129.79 370.41,131.32 353.82,131.32 346.54,138.6 346.54,146.34 344.61,148.28 344.61,160.22 345.35,160.96 345.35,163.75 345.87,164.27 347.17,164.27 347.76,164.85 348.84,164.85 349.69,165.7 349.69,167.64 347.3,170.03 347.3,176.79 345.2,178.89 345.2,181.11 345.47,181.38 345.73,181.38
D20409: length 387.2
  L31_SIGNAL w0.076: 225.73,180.73 226.28,180.73 v2(226.61,181.06)
  L31_SIGNAL w0.091: v3(234.18,108.66) 234.04,108.66 233.38,109.32 233.38,112.17 231.65,113.89 231.65,122.24 224.44,129.45 223.35,129.45 221.22,131.59 221.22,143.4 224.68,146.86 224.68,147.08 227.03,149.43 227.03,160.91 227.59,161.47 227.59,163.69 228.3,164.4 229.07,164.4 230.38,165.71 230.38,174.22 225.57,179.03 225.57,180.57 225.73,180.73
  L33_SIGNAL w0.091: v3(234.18,108.66) 234.79,108.05 372.17,108.05 375.44,104.77 418.62,104.77 426.47,96.93 426.47,50.56 445.65,31.37 470.79,31.37 D204.09
D20410: length 366
  L29_SIGNAL w0.076: 265.73,180.73 266.28,180.73 v2(266.61,181.06)
  L29_SIGNAL w0.091: 265.73,180.73 265.57,180.57 265.57,179.03 270.38,174.22 270.38,165.71 269.07,164.4 268.3,164.4 267.59,163.69 267.59,161.47 267.03,160.91 267.03,149.43 264.68,147.08 264.68,146.86 261.22,143.4 261.22,140.59 251.89,131.27 251.54,131.27 245.39,125.12 245.39,107.37 248.38,104.38 353.94,104.38 355.04,105.47 419.88,105.47 436.5,88.85 436.5,64.1 456.22,44.38 475.28,44.38 476.32,43.33 476.32,39.3 D204.10
D20411: length 302.8
  L27_SIGNAL w0.076: 305.73,180.73 306.28,180.73 v2(306.6,181.06)
  L27_SIGNAL w0.091: D204.11 478.75,36.87 478.75,41.15 476.47,43.43 459.06,43.43 450.5,52 450.5,74.97 420.76,104.7 308.04,104.7 305,107.74 305,124.08 301.22,127.86 301.22,143.4 304.68,146.86 304.68,147.08 307.03,149.43 307.03,160.91 307.59,161.47 307.59,163.69 308.3,164.4 309.07,164.4 310.38,165.71 310.38,174.22 305.57,179.03 305.57,180.57 305.73,180.73
D20412: length 256
  L25_SIGNAL w0.076: 345.73,180.73 346.28,180.73 v2(346.6,181.06)
  L25_SIGNAL w0.091: 345.73,180.73 345.57,180.57 345.57,179.03 350.38,174.22 350.38,165.71 349.07,164.4 348.3,164.4 347.59,163.69 347.59,161.47 347.03,160.91 347.03,140.14 355.35,131.83 420.88,131.83 443.23,109.47 443.23,53.77 454.61,42.39 478.31,42.39 D204.12
D20413: length 394.1
  L31_SIGNAL w0.076: 226.13,179.02 226.13,179.96 226.26,180.08 226.86,180.08 226.93,180.15 226.93,180.73 v2(227.26,181.06)
  L31_SIGNAL w0.091: 226.13,179.02 226.13,179.01 230.75,174.4 230.75,164.99 229.67,163.92 229.67,161.86 229.12,161.31 229.12,157.75 228.42,157.06 228.42,146.56 226.42,144.55 226.42,128.18 232.03,122.57 232.03,114.12 234.18,111.97 v3(234.18,110.18)
  L33_SIGNAL w0.091: D204.13 480.31,30.73 445.39,30.73 425.83,50.29 425.83,96.66 418.1,104.39 375.28,104.39 372.01,107.67 233.83,107.67 233.3,108.2 233.3,109.32 234.16,110.18 v3(234.18,110.18)
D20414: length 372.1
  L29_SIGNAL w0.076: v2(267.25,181.06) 266.93,180.73 266.93,180.15 266.86,180.08 266.26,180.08 266.13,179.96 266.13,179.02
  L29_SIGNAL w0.091: 266.13,179.02 266.13,179.01 270.75,174.4 270.75,164.99 269.67,163.92 269.67,161.86 269.12,161.31 269.12,157.75 268.42,157.06 268.42,148.41 262.74,142.72 262.74,140.72 248.28,126.26 248.28,107.44 250.97,104.76 353.78,104.76 354.86,105.84 420.12,105.84 436.93,89.03 436.93,66.13 456.06,47 485.58,47 486.39,46.2 486.39,39.39 D204.14
D20415: length 308.8
  L27_SIGNAL w0.076: v2(307.25,181.06) 306.93,180.73 306.93,180.15 306.86,180.08 306.26,180.08 306.13,179.96 306.13,179.02
  L27_SIGNAL w0.091: D204.15 488.99,36.79 488.99,41.26 486.26,43.99 459.24,43.99 450.99,52.24 450.99,75.1 420.89,105.2 308.17,105.2 305.46,107.91 305.46,129.19 306.42,130.15 306.42,144.55 308.42,146.56 308.42,157.06 309.12,157.75 309.12,161.31 309.67,161.86 309.67,163.92 310.75,164.99 310.75,174.4 306.13,179.01 306.13,179.02
D20416: length 261
  L25_SIGNAL w0.076: v2(347.25,181.06) 346.93,180.73 346.93,180.15 346.86,180.08 346.26,180.08 346.13,179.96 346.13,179.02
  L25_SIGNAL w0.091: D204.16 488.1,42.76 455.21,42.76 443.67,54.3 443.67,109.67 421.03,132.31 371.24,132.31 370.69,132.86 360.27,132.86 348.42,144.71 348.42,157.06 349.12,157.75 349.12,161.31 349.67,161.86 349.67,163.92 350.75,164.99 350.75,174.4 346.13,179.01 346.13,179.02
D20501: length 275.7
  L13_SIGNAL w0.091: D205.01 526.81,96.52 519.46,103.87 519.46,116.66 501.24,134.87 477.77,134.87 476.94,135.71 463.5,135.71 463.01,135.23 381.33,135.23 370.69,145.87 370.69,146.76 365.58,151.87 363.96,151.87 360.54,155.28 360.54,163.28 356.96,166.86 356.96,176.1 359.13,178.27 360,178.27 362.78,181.05 362.78,187.25 356.04,193.98 356.04,202.2 356.68,202.84 356.68,204.13 357.3,204.75 357.3,205.53 359.13,207.36 359.13,207.79 359.84,208.5 359.84,211.53 359.54,211.82 359.54,215.79 360.38,216.62 360.78,216.62 362.57,218.42 UNK4K113.6
D20502: length 312.9
  L13_SIGNAL w0.091: D205.02 529.95,98.15 527.65,98.15 520.34,105.45 520.34,117.01 500.86,136.5 484.12,136.5 482.55,138.07 477.6,138.07 476.05,136.52 467.15,136.52 466.73,136.95 382.81,136.95 367.89,151.87 366.8,151.87 365.4,153.26 365.4,154.5 361.43,158.47 361.43,163.7 358.34,166.8 358.34,175.98 359.83,177.47 360.47,177.47 361.3,178.31 362.75,178.31 363.62,179.18 363.62,188.26 356.96,194.92 356.96,201.9 357.52,202.46 357.52,203.72 360.74,206.94 360.74,207.73 361.36,208.35 361.36,210.82 361.07,211.11 361.07,215.64 364.1,218.67 364.1,223.39 363.34,224.16 362.96,224.16 358.31,228.8 358.31,236.13 361.42,239.24 361.42,246.65 359.21,248.85 v2(355.7,248.85)
D20503: length 316.5
  L13_SIGNAL w0.091: v2(355.7,248.2) 358.08,248.2 361.05,245.24 361.05,239.4 360.22,238.56 359.58,238.56 357.38,236.36 357.38,227.46 361.36,223.48 361.36,217.83 360.57,217.04 360.11,217.04 359.09,216.02 359.09,211.95 358.58,211.44 358.58,208.14 356.88,206.45 356.88,204.93 356.26,204.31 356.26,203.01 355.68,202.42 355.68,195.55 355.25,195.13 355.25,193.17 361.55,186.88 361.55,181.32 356.56,176.33 356.56,166.68 359.58,163.66 359.58,155.73 361.54,153.76 361.54,152.22 362.31,151.46 364.39,151.46 370.08,145.77 370.08,144.63 379.9,134.81 463.23,134.81 463.68,135.25 476.76,135.25 477.57,134.44 499.66,134.44 519.04,115.07 519.04,103.7 527.66,95.07 531.95,95.07 D205.03
D20504: length 297.6
  L13_SIGNAL w0.091: D205.04 534.54,97.66 527.45,97.66 519.91,105.2 519.91,116.83 501.42,135.33 477.9,135.33 477.09,136.14 464.07,136.14 463.68,136.54 380.76,136.54 371.2,146.1 371.2,146.86 363.75,154.31 363.75,155.63 360.92,158.46 360.92,163.49 357.37,167.04 357.37,175.84 359.43,177.9 360.24,177.9 363.2,180.86 363.2,187.39 356.45,194.13 356.45,201.93 357.1,202.57 357.1,203.89 360.32,207.11 360.32,209.26 360.94,209.88 360.94,210.65 360.65,210.94 360.65,215.82 363.58,218.75 363.58,223.15 363.09,223.64 361.85,223.64 357.83,227.65 v2(357.83,232.39)
  BOTTOM w0.16: UNK4K32.2 v2(357.83,232.39)
D20505: length 324.2
  L13_SIGNAL w0.076: v2(354.4,247.56) 354.73,247.23 355.84,247.23
  L13_SIGNAL w0.091: 355.84,247.23 356.9,247.23 360.67,243.46 360.67,240.92 358.89,239.14 358.89,238.5 356.96,236.57 356.96,227.29 360.94,223.31 360.94,218.12 360.5,217.68 360.14,217.68 358.66,216.2 358.66,212.87 357.55,211.75 357.55,207.73 356.46,206.64 356.46,205.1 355.84,204.48 355.84,203.23 355.31,202.7 355.31,195.94 354.89,195.51 354.89,192.98 361.13,186.74 361.13,181.46 359.78,180.11 358.58,180.11 356.17,177.7 356.17,166.47 359.2,163.44 359.2,156.11 358.94,155.84 358.94,154.57 360.96,152.54 360.96,151.92 361.87,151 362.99,151 379.61,134.39 463.55,134.39 463.93,134.77 476.61,134.77 477.42,133.96 499.52,133.96 518.62,114.86 518.62,102.05 527.68,92.99 534.95,92.99 D205.05
D20506: length 332
  L13_SIGNAL w0.076: v2(353.75,247.56) 354.08,247.88 354.54,247.88 354.73,248.07 354.73,250.29 354.57,250.45
  L13_SIGNAL w0.091: 354.57,250.45 354.57,251.13 354.91,251.47 356.34,251.47 358.19,249.63 360.22,249.63 362.57,247.27 362.57,238.89 358.72,235.04 358.72,229.02 363.21,224.54 364.99,224.54 366.23,223.29 366.23,218.97 361.49,214.22 361.49,211.28 361.78,210.99 361.78,208.15 361.16,207.53 361.16,205.92 358.37,203.13 358.37,202.38 357.44,201.45 357.44,195.12 364.84,187.73 364.84,179.12 363.62,177.9 361.71,177.9 360.21,176.4 359.83,176.4 358.76,175.33 358.76,166.9 361.41,164.24 362.45,164.24 363.69,163 363.69,157.94 365.95,155.68 366.82,155.68 368.05,154.45 368.05,153.57 384.24,137.37 466.71,137.37 467.31,137.97 476.73,137.97 477.29,138.53 482.83,138.53 483.34,138.02 487.22,138.02 488.29,136.96 501.01,136.96 520.78,117.19 520.78,106.87 527.47,100.18 539.9,100.18 D205.06
D20507: length 329.5
  L13_SIGNAL w0.076: 355.8,246.58 354.08,246.58 v2(353.75,246.91)
  L13_SIGNAL w0.091: 355.8,246.58 356.79,246.58 359.27,244.09 359.27,240.67 357.8,239.2 357.8,237.92 356.54,236.67 356.54,227.12 360.49,223.16 360.49,218.52 360.22,218.24 360.11,218.24 358.03,216.16 357.48,216.16 355.42,214.1 355.42,203.33 354.93,202.84 354.93,196.22 354.52,195.81 354.52,192.81 359.4,187.93 359.4,181.46 354.57,176.63 354.57,167.47 358.83,163.22 358.83,156.73 358.57,156.47 358.57,154.35 358.99,153.94 358.99,152.49 359.61,151.86 360.5,151.86 361.74,150.62 362.71,150.62 371.35,141.99 371.35,140.82 378.24,133.93 463.69,133.93 464.08,134.32 476.43,134.32 477.95,132.79 500.09,132.79 518.2,114.68 518.2,101.88 527.54,92.53 539.57,92.53 D205.07
D20508: length 340.9
  L13_SIGNAL w0.091: v2(353.75,248.85) 354.19,249.29 354.19,251.27 354.76,251.84 360.54,251.84 362.94,249.44 362.94,238.74 359.14,234.94 359.14,229.24 363.46,224.92 367.25,224.92 369.08,223.09 369.08,218.53 367.39,216.84 364.7,216.84 363.52,215.67 363.52,212.45 362.77,211.69 362.77,208.34 361.58,207.14 361.58,205.74 358.84,203.01 358.84,202.13 358.46,201.75 358.46,194.67 359.25,193.88 360.09,193.88 365.25,188.71 365.25,178.94 363.75,177.43 361.83,177.43 359.18,174.78 359.18,168.13 364.1,163.21 364.1,158.05 365.94,156.21 366.8,156.21 368.63,154.38 368.63,153.67 384.51,137.79 466.14,137.79 467.64,139.29 487.04,139.29 488.95,137.39 501.19,137.39 521.21,117.37 521.21,107.15 527.68,100.69 544.47,100.69 D205.08
D20509: length 335.1
  L13_SIGNAL w0.076: v2(354.4,243) 354.73,243.33 356.07,243.33
  L13_SIGNAL w0.091: 356.07,243.33 356.86,243.33 358.75,241.44 358.75,240.86 356.11,238.22 356.11,226.95 359.4,223.67 359.4,218.14 357.87,216.61 356.22,216.61 355,215.39 355,203.5 354.55,203.05 354.55,196.68 353.41,195.54 353.41,192.71 354.65,191.47 355.34,191.47 358.92,187.88 358.92,182.35 354.14,177.57 354.14,167.31 358.45,163.01 358.45,158 357.28,156.84 357.28,154.53 358.51,153.3 358.51,152.44 361.68,149.28 362.69,149.28 370.84,141.12 370.84,140.54 378.62,132.76 463.24,132.76 464.34,133.86 474.73,133.86 476.25,132.33 499.98,132.33 517.78,114.53 517.78,100.8 527.92,90.66 542.78,90.66 D205.09
D20510: length 346.1
  L13_SIGNAL w0.091: D205.10 547.55,102.69 527.56,102.69 521.64,108.61 521.64,117.57 501.37,137.85 491.03,137.85 488.34,140.54 468.2,140.54 466.67,139.01 385.17,139.01 366.61,157.57 366.61,163.53 366.2,163.93 363.94,163.93 359.6,168.28 359.6,174.67 361.4,176.47 364.29,176.47 365.67,177.86 365.67,188.93 360.26,194.34 359.55,194.34 358.87,195.02 358.87,201.6 363.19,205.92 363.19,210.29 364.01,211.12 364.01,214.61 365.82,216.42 367.56,216.42 369.5,218.36 369.5,223.27 367.47,225.3 363.84,225.3 359.56,229.58 359.56,234.12 361.98,236.53 362.38,236.53 363.46,237.62 363.46,250.44 361.69,252.22 354.57,252.22 353.81,251.45 353.81,249.56 v2(353.75,249.5)
D20511: length 356
  L13_SIGNAL w0.076: v2(351.8,243) 352.13,242.68 356.07,242.68
  L13_SIGNAL w0.091: 356.07,242.68 356.27,242.68
  L13_SIGNAL w0.508: 356.27,242.68 356.67,242.68 357.37,241.98 357.37,240.41 354.93,237.97 354.93,227.2 358.76,223.36 358.76,218.42 357.9,217.55 354.07,217.55 353.01,216.49 353.01,212.28 354.36,210.93 354.36,203.95 353.16,202.75 353.16,196.1 349.84,192.78 348.38,192.78 347.99,192.39 347.99,192.08 347.4,191.49 346.52,191.49 343.93,188.9 343.93,181.01 350.89,174.05 350.89,166.4 350,165.51 350,161.19 349.11,160.3 349.11,158.43 349.87,157.67 354.42,157.67 355.12,156.97 355.12,154.52 358.95,150.69 358.95,149.53 359.89,148.59 360.07,148.59 361.14,147.52 361.14,146.2 362.04,145.3 362.73,145.3 362.76,145.28 364.3,145.28 369.07,140.51 369.07,140.06 376.98,132.14 464.04,132.14 465,133.1 469.89,133.1 473.33,129.67 475.62,129.67 477.58,131.63 499.66,131.63 517.2,114.09 517.2,100.35 527.63,89.92 547.12,89.92 D205.11
D20512: length 350.2
  L13_SIGNAL w0.076: 353.43,251.08 353.43,249.83 v2(353.1,249.5)
  L13_SIGNAL w0.091: D205.12 552.12,103.2 527.77,103.2 522.07,108.9 522.07,118.82 501.85,139.04 490.47,139.04 487.68,141.83 467.54,141.83 465.09,139.38 385.56,139.38 368.8,156.14 368.8,163.92 368.37,164.35 364.08,164.35 359.98,168.45 359.98,174.47 361.56,176.05 364.46,176.05 366.73,178.32 366.73,189.27 361.86,194.13 361,194.13 360.42,194.72 359.81,194.72 359.32,195.2 359.32,201.46 363.61,205.74 363.61,208.38 366.17,210.94 366.17,214.44 369.95,218.22 369.95,225.53 370.48,226.06 370.48,231.99 364.73,237.73 364.73,251.21 363.35,252.59 354.18,252.59 353.43,251.84 353.43,251.08
D20513: length 338.6
  L13_SIGNAL w0.076: 344.73,190.69 345.12,191.08
  L13_SIGNAL w0.091: 345.12,191.08 349.24,195.2 349.24,207.39 350.64,208.79 350.64,212.98 349.4,214.22 349.4,220.43 350.11,221.14 350.11,223.52 353.63,227.04 v2(353.63,232.39) ; 344.73,190.69 342.23,188.19 342.23,178.44 347.57,173.09 347.57,162.24 347.08,161.75 347.08,158.76 349.78,156.06 353.39,156.06 354.46,154.99 354.46,152.76 357.43,149.78 357.43,148.39 361.09,144.73 362.49,144.73 368.78,138.44 368.78,138.17 375.45,131.51 433.34,131.51 435.23,129.61 472.37,129.61 473.07,128.91 477.52,128.91 478.74,130.12 497.97,130.12 516.53,111.56 516.53,98.84 527.49,87.88 550.16,87.88 D205.13
  BOTTOM w0.16: UNK4K32.7 v2(353.63,232.39)
D20514: length 368.5
  L13_SIGNAL w0.091: D205.14 555.14,105.26 526.34,105.26 522.53,109.07 522.53,118.88 501.94,139.47 491.77,139.47 488.16,143.08 468.15,143.08 465.63,140.56 451.82,140.56 451.05,139.8 387.12,139.8 370.37,156.55 370.37,163.58 368.95,165 363.96,165 360.59,168.36 360.59,174.55 361.69,175.64 365.46,175.64 367.67,177.85 367.67,190.44 363.6,194.5 361.34,194.5 360.48,195.36 360.48,200.9 369.42,209.84 369.42,217.09 370.37,218.05 370.37,225.14 370.85,225.61 370.85,232.9 366.89,236.85 366.89,249.56 362.77,253.69 360.22,253.69 354.19,259.71 354.19,267.59 352.19,269.6 v2(352.19,271.11)
  BOTTOM w0.16: UNK4U449.3 v2(352.19,271.11)
D20515: length 360.3
  L13_SIGNAL w0.076: v2(347.25,245.61) 346.93,245.93 345.83,245.93
  L13_SIGNAL w0.091: D205.15 554.76,87.4 527.38,87.4 516.11,98.67 516.11,111.32 497.81,129.62 479.25,129.62 477.14,127.51 469.73,127.51 468.15,129.08 435.1,129.08 434.02,130.16 376.17,130.16 372.21,134.12 371.06,134.12 363.4,141.79 363.4,143.08 362.35,144.12 361.11,144.12 353.21,152.02 353.21,154.82 352.63,155.4 348.72,155.4 346.33,157.78 346.33,159.26 345.26,160.33 345.26,161.11 345.37,161.22 345.37,167.27 344.82,167.82 344.82,175.25 341.02,179.05 341.02,187.62 348.78,195.37 348.78,220.4 349.69,221.32 349.69,224.79 350.09,225.19 350.09,227.9 349.17,228.82 349.17,235.93 345.18,239.92 345.18,245.61 345.49,245.93 345.83,245.93
D20516: length 354.6
  L13_SIGNAL w0.091: D205.16 559.74,105.74 526.54,105.74 522.96,109.32 522.96,119.05 502.1,139.9 492.02,139.9 488.42,143.51 467.89,143.51 466.19,141.81 452.35,141.81 450.76,140.22 387.31,140.22 370.79,156.74 370.79,163.75 370.17,164.37 370.17,172.48 368.62,174.03 368.62,194.35 370.17,195.9 370.17,217.25 370.79,217.87 370.79,225.04 371.21,225.46 371.21,233.17 367.65,236.73 367.65,250.32 363.84,254.13 360.53,254.13 354.83,259.83 354.83,267.72 353.18,269.36 v2(353.18,271.1)
  BOTTOM w0.16: UNK4U449.4 352.69,270.61 v2(353.18,271.1)
D20601: length 369.5
  L13_SIGNAL w0.091: D206.01 526.54,76.2 512.34,90.4 512.34,109.68 498.56,123.46 435.32,123.46 432.38,126.39 358.85,126.39 346.89,138.35 346.89,140.21 334.01,153.09 334.01,161.16 330.63,164.54 330.63,172.71 329.05,174.29 329.05,194.14 330.7,195.79 330.7,197.74 331.02,198.07 331.02,204.22 338.13,211.33 338.13,225.48 340.36,227.71 340.36,230.85 341.37,231.86 341.37,236.07 341.11,236.33 341.11,253.62 342.38,254.89 342.38,257.38 v2(344,259)
  L23_SIGNAL w0.091: v2(345.95,244.96) 345.73,244.73 345.3,244.73 345.04,244.98 344.28,244.98 343.27,246 343.27,258.27 v2(344,259)
D20602: length 361.8
  L13_SIGNAL w0.076: v2(352.45,248.85) 352.13,249.18 352.13,251.08
  L13_SIGNAL w0.091: 352.13,251.08 352.13,251.54 351.81,251.87 350.75,251.87 349.93,252.69 346.15,252.69 342.67,249.21 342.67,236.55 342.25,236.14 342.25,233.45 343.06,232.65 343.06,231.79 342.25,230.99 342.25,225.58 341.59,224.92 340.35,224.92 339.01,223.58 339.01,210.06 340.07,209 340.07,206.27 340.83,205.51 340.83,195.34 339.97,194.48 336.57,194.48 336.1,194.94 334.07,194.94 329.93,190.8 329.93,174.71 331.51,173.13 331.51,167.47 334.88,164.09 334.88,154.5 340.03,149.35 342.11,149.35 343.61,147.85 344.37,147.85 347.88,144.35 348.79,144.35 365.91,127.23 432.8,127.23 435.73,124.29 498.91,124.29 513.18,110.03 513.18,92.22 527.58,77.83 529.95,77.83 D206.02
D20603: length 378.2
  L13_SIGNAL w0.091: v2(313.18,271.1) 313.18,269.36 314.83,267.72 314.83,259.83 320.53,254.13 323.84,254.13 327.65,250.32 327.65,236.73 331.21,233.17 331.21,225.46 330.79,225.04 330.79,217.87 330.17,217.25 330.17,195.9 328.62,194.35 328.62,174.03 330.17,172.48 330.17,164.37 330.79,163.75 330.79,154.14 333.45,151.49 334.04,151.49 346.3,139.22 346.3,134.7 355.03,125.97 432.19,125.97 437.64,120.52 499.03,120.52 511.92,107.63 511.92,90.21 527.38,74.75 531.95,74.75 D206.03
  BOTTOM w0.16: v2(313.18,271.1) 312.69,270.61 UNK3U449.4
D20604: length 365.4
  L13_SIGNAL w0.076: 352.78,251.08 352.78,247.88 v2(353.1,247.56)
  L13_SIGNAL w0.091: D206.04 534.54,77.34 527.47,77.34 512.76,92.05 512.76,109.85 498.74,123.88 435.56,123.88 432.63,126.81 360.44,126.81 347.5,139.75 347.5,141.73 340.31,148.91 339.9,148.91 334.46,154.36 334.46,163.93 331.09,167.3 331.09,172.9 329.5,174.48 329.5,193.95 331.12,195.56 331.12,197.5 331.44,197.82 331.44,204.04 338.57,211.17 338.57,225.17 340.86,227.46 340.86,230.5 341.87,231.52 341.87,237.62 342.19,237.94 342.19,250.38 344.92,253.11 351.32,253.11 352.78,251.65 352.78,251.08
D20605: length 405.2
  L13_SIGNAL w0.091: v2(312.19,271.11) 312.19,269.6 314.19,267.59 314.19,259.71 320.22,253.69 322.77,253.69 326.89,249.56 326.89,236.85 330.85,232.9 330.85,225.61 330.37,225.14 330.37,218.05 329.42,217.09 329.42,209.84 320.48,200.9 320.48,195.36 321.34,194.5 323.6,194.5 327.67,190.44 327.67,177.85 325.46,175.64 321.69,175.64 320.59,174.55 320.59,168.36 323.96,165 328.95,165 330.37,163.58 330.37,153.8 333.05,151.12 333.72,151.12 345.82,139.01 345.82,134.54 349.33,131.04 349.33,129.97 353.75,125.55 431.93,125.55 437.38,120.1 498.86,120.1 511.5,107.46 511.5,88.94 527.78,72.67 534.95,72.67 D206.05
  BOTTOM w0.16: UNK3U449.3 v2(312.19,271.11)
D20606: length 369.3
  L13_SIGNAL w0.076: 351.48,251.08 351.48,247.42 351.67,247.23 352.78,247.23 v2(353.1,246.91)
  L13_SIGNAL w0.091: 351.48,251.08 351.23,251.33 345.3,251.33 343.03,249.06 343.03,236.59 343.69,235.92 343.69,232.88 343.48,232.67 343.48,231.62 342.67,230.81 342.67,225.4 341.8,224.54 340.98,224.54 339.84,223.39 339.84,222.12 341.24,220.73 341.24,195.22 340.12,194.11 336.38,194.11 335.19,192.92 335.19,178 336.17,177.02 338.42,177.02 340.89,174.55 340.89,171.97 340.32,171.4 340.32,167.93 337.79,165.4 337.27,165.4 336.54,164.67 336.54,153.58 338.2,151.92 341.1,151.92 348.18,144.83 351.26,144.83 363.5,132.59 363.5,132.23 368.08,127.65 432.97,127.65 435.91,124.71 499.09,124.71 513.6,110.2 513.6,93.66 527.41,79.86 539.9,79.86 D206.06
D20607: length 397.7
  L13_SIGNAL w0.076: v2(313.11,249.5) 313.43,249.83 313.43,251.08
  L13_SIGNAL w0.091: D206.07 539.57,72.21 527.64,72.21 511.08,88.77 511.08,107.29 498.69,119.68 437.11,119.68 431.66,125.13 352.26,125.13 344.68,132.71 344.68,138.84 328.8,154.72 328.8,163.92 328.37,164.35 324.08,164.35 319.98,168.45 319.98,174.47 321.56,176.05 324.46,176.05 326.73,178.32 326.73,189.27 321.86,194.13 321,194.13 320.42,194.72 319.81,194.72 319.32,195.2 319.32,201.46 323.61,205.74 323.61,208.38 326.17,210.94 326.17,214.44 329.95,218.22 329.95,225.53 330.48,226.06 330.48,231.99 324.73,237.73 324.73,251.21 323.35,252.59 314.18,252.59 313.43,251.84 313.43,251.08
D20608: length 356.4
  L13_SIGNAL w0.076: v2(350.5,249.5) 350.18,249.83 346.32,249.83
  L13_SIGNAL w0.091: 346.32,249.83 344.82,249.83 343.4,248.41 343.4,240.03 344.29,239.14 344.29,238.51 343.91,238.12 343.91,236.23 344.06,236.08 344.06,231.68 343.04,230.65 343.04,224.55 342.48,224 342.48,210.65 342.76,210.38 342.76,195.6 340.85,193.69 339.52,193.69 338.16,192.33 338.16,177.87 341.31,174.73 341.31,171.79 340.83,171.32 340.83,167.92 338.66,165.75 338.66,155.32 340.06,153.92 340.51,153.92 342.67,151.76 343.21,151.76 345.63,149.35 348.16,149.35 351.24,146.27 351.85,146.27 363.52,134.59 363.52,134.16 369.62,128.07 433.15,128.07 436.08,125.13 499.26,125.13 514.02,110.37 514.02,93.85 527.51,80.37 544.47,80.37 D206.08
D20609: length 407.7
  L13_SIGNAL w0.091: v2(313.76,249.5) 313.81,249.56 313.81,251.45 314.57,252.22 321.69,252.22 323.46,250.44 323.46,237.62 322.38,236.53 321.98,236.53 319.56,234.12 319.56,229.58 323.84,225.3 327.47,225.3 329.5,223.27 329.5,218.36 327.56,216.42 325.82,216.42 324.01,214.61 324.01,211.12 323.19,210.29 323.19,205.92 318.87,201.6 318.87,195.02 319.55,194.34 320.26,194.34 325.67,188.93 325.67,177.86 324.29,176.47 321.4,176.47 319.6,174.67 319.6,168.28 323.94,163.93 326.2,163.93 326.61,163.53 326.61,156.27 343.43,139.45 343.43,133.35 352.07,124.71 431.44,124.71 436.89,119.27 498.51,119.27 510.67,107.11 510.67,87.02 527.63,70.05 542.49,70.05 D206.09
D20610: length 329.5
  L13_SIGNAL w0.091: UNK4K39.2 344.26,224.51 342.9,223.15 342.9,210.82 343.3,210.43 343.3,198.55 344.34,197.51 344.34,196.55 340.76,192.97 340.24,192.97 338.58,191.31 338.58,178.86 341.72,175.72 341.72,171.62 341.26,171.16 341.26,167.79 339.14,165.66 339.14,156.11 339.64,155.6 341.6,155.6 347.34,149.86 349.73,149.86 352.53,147.07 352.53,146.35 358.95,139.93 359.59,139.93 371.03,128.49 433.32,128.49 436.25,125.55 499.43,125.55 514.44,110.55 514.44,95.55 527.62,82.37 547.55,82.37 D206.10
D20611: length 410.9
  L13_SIGNAL w0.091: D206.11 547.12,69.6 527.5,69.6 510.25,86.85 510.25,105.12 499.03,116.33 439.17,116.33 431.2,124.29 351.04,124.29 342.29,133.05 342.29,139.17 327.71,153.75 327.08,153.75 324.87,155.96 324.87,157.89 324.1,158.65 324.1,163.18 319.18,168.11 319.18,174.78 321.83,177.43 323.75,177.43 325.25,178.94 325.25,188.71 320.09,193.88 319.25,193.88 318.46,194.67 318.46,201.75 318.84,202.13 318.84,203.01 321.58,205.74 321.58,207.14 322.77,208.34 322.77,211.69 323.52,212.45 323.52,215.67 324.7,216.84 327.39,216.84 329.08,218.53 329.08,223.09 327.25,224.92 323.46,224.92 319.14,229.24 319.14,234.94 322.94,238.74 322.94,249.44 320.54,251.84 314.76,251.84 314.19,251.27 314.19,249.29 v2(313.76,248.85)
D20612: length 328.8
  L13_SIGNAL w0.091: UNK4K39.7 344.26,209.34 344.11,209.2 344.11,206.84 344.82,206.14 344.82,194.97 342.4,192.55 340.41,192.55 339,191.14 339,179.04 342.14,175.89 342.14,171.94 342.27,171.81 342.27,165.27 341.25,164.25 340.51,164.25 340,163.74 340,161.52 340.76,160.76 340.76,158.35 347.47,151.64 348.62,151.64 351.27,148.99 352.21,148.99 372.29,128.91 433.49,128.91 436.43,125.97 499.61,125.97 514.86,110.72 514.86,95.73 527.7,82.88 552.12,82.88 D206.12
D20613: length 416.4
  L13_SIGNAL w0.076: 314.57,250.45 314.73,250.29 314.73,248.07 314.54,247.88 314.08,247.88 v2(313.76,247.56)
  L13_SIGNAL w0.091: 314.57,250.45 314.57,251.13 314.91,251.47 316.34,251.47 318.19,249.63 320.22,249.63 322.57,247.27 322.57,238.89 318.73,235.04 318.73,229.02 323.21,224.54 324.99,224.54 326.24,223.29 326.24,218.97 321.49,214.22 321.49,211.28 321.78,210.99 321.78,208.15 321.16,207.53 321.16,205.92 318.37,203.13 318.37,202.38 317.44,201.45 317.44,195.12 324.84,187.73 324.84,179.12 323.62,177.9 321.71,177.9 320.21,176.4 319.83,176.4 318.76,175.33 318.76,166.9 321.41,164.24 322.45,164.24 323.69,163 323.69,159.18 322.93,158.42 322.93,155.39 326.51,151.82 328.96,151.82 341.81,138.96 341.81,132.89 350.82,123.88 431.01,123.88 438.98,115.91 498.86,115.91 509.83,104.95 509.83,85.46 527.72,67.56 550.16,67.56 D206.13
D20614: length 366.1
  L13_SIGNAL w0.076: 345.81,249.18 349.53,249.18 v2(349.85,248.85)
  L13_SIGNAL w0.091: D206.14 555.14,84.94 527.41,84.94 515.28,97.07 515.28,110.9 499.78,126.39 436.6,126.39 433.67,129.32 374.54,129.32 371.86,132 371.19,132 364.15,139.04 363.15,139.04 355.25,146.94 355.25,148 353.52,149.73 352.3,149.73 350.01,152.02 347.61,152.02 346.65,152.98 346.65,154.88 342.25,159.27 342.25,163.96 342.7,164.4 342.7,171.74 343.06,172.1 343.06,172.65 342.56,173.15 342.56,176.07 340.19,178.44 340.19,190.95 341.37,192.13 343.63,192.13 345.23,193.73 345.23,211.06 344.95,211.34 344.95,221.16 345.34,221.55 345.34,224.3 346.06,225.02 347.11,225.02 347.55,225.46 347.55,227.96 344.67,230.85 344.67,236.35 344.41,236.6 344.41,238 344.67,238.25 344.67,239.39 343.78,240.28 343.78,247.78 345.18,249.18 345.81,249.18
D20615: length 410.7
  L13_SIGNAL w0.091: v2(315.7,248.85) 319.21,248.85 321.42,246.65 321.42,239.24 318.31,236.13 318.31,228.8 322.96,224.16 323.34,224.16 324.1,223.39 324.1,218.67 321.07,215.64 321.07,211.11 321.36,210.82 321.36,208.35 320.74,207.73 320.74,206.94 317.52,203.72 317.52,202.46 316.96,201.9 316.96,194.92 323.62,188.26 323.62,179.18 322.75,178.31 321.3,178.31 320.47,177.47 319.83,177.47 318.34,175.98 318.34,166.8 321.43,163.7 321.43,154.61 324.91,151.13 328.35,151.13 341.27,138.2 341.27,132.03 349.85,123.46 430.8,123.46 438.76,115.49 498.69,115.49 509.41,104.77 509.41,85.28 527.61,67.08 554.76,67.08 D206.15
D20616: length 370.8
  L13_SIGNAL w0.076: v2(349.85,248.2) 349.53,248.53 345.68,248.53
  L13_SIGNAL w0.091: 345.68,248.53 345.29,248.53 344.16,247.4 344.16,240.42 346.95,237.63 347.28,237.3 347.28,230.11 349.67,227.72 349.67,225.48 349.19,225 348.16,225 347.57,224.42 347.57,221.6 346.35,220.38 346.35,193.83 344.23,191.71 341.54,191.71 340.61,190.78 340.61,178.88 343.83,175.65 343.83,172.28 343.12,171.56 343.12,164.17 342.67,163.73 342.67,162.74 344.51,160.89 344.51,158.66 346.46,156.72 346.46,155.64 349.7,152.4 350.27,152.4 352.55,150.11 354.57,150.11 361.04,143.64 362.16,143.64 362.93,142.87 362.93,140.86 371.15,132.63 371.96,132.63 374.84,129.74 433.84,129.74 436.78,126.81 499.95,126.81 515.69,111.07 515.69,97.24 527.52,85.42 559.74,85.42 D206.16
D20701: length 383.3
  L13_SIGNAL w0.076: v2(307.25,245.61) 306.93,245.93 305.83,245.93
  L13_SIGNAL w0.091: 305.83,245.93 305.49,245.93 305.18,245.61 305.18,239.92 309.17,235.93 309.17,228.82 310.09,227.9 310.09,225.19 309.69,224.79 309.69,221.32 308.78,220.4 308.78,195.37 301.02,187.62 301.02,179.05 304.82,175.25 304.82,167.82 305.37,167.27 305.37,161.22 304.44,160.3 304.44,158.9 306.47,156.87 306.47,155.62 307.66,154.43 307.85,154.43 309.56,152.72 309.56,152.59 312.55,149.61 313.56,149.61 315.61,147.56 315.61,147 317.78,144.83 317.78,141.66 330.2,129.24 330.2,123.18 347.07,106.31 498.25,106.31 505.26,99.3 505.26,76.82 526.21,55.88 D207.01
D20702: length 392.6
  L13_SIGNAL w0.076: 316.07,242.68 312.13,242.68 v2(311.81,243)
  L13_SIGNAL w0.091: 316.07,242.68 316.27,242.68
  L13_SIGNAL w0.508: 316.27,242.68 316.67,242.68 317.37,241.98 317.37,240.41 314.93,237.97 314.93,227.2 318.76,223.36 318.76,218.42 317.9,217.55 314.07,217.55 313.01,216.49 313.01,212.28 314.36,210.93 314.36,203.95 313.16,202.75 313.16,196.1 309.84,192.78 308.38,192.78 307.99,192.39 307.99,192.08 307.4,191.49 306.52,191.49 303.93,188.9 303.93,181.01 310.89,174.05 310.89,166.4 310,165.51 310,161.19 309.11,160.3 309.11,156.48 309.87,155.73 313.77,155.73 314.68,154.82 314.68,150.92 319.68,145.91 319.68,142.93 321.23,141.38 324.18,141.38 329.34,136.23 329.34,135.59 336.29,128.63 336.29,121.79 350.66,107.42 498.77,107.42 506.27,99.93 506.27,78.8 527.72,57.34 529.78,57.34 D207.02
D20703: length 401.9
  L13_SIGNAL w0.076: 305.68,248.53 309.53,248.53 v2(309.85,248.2)
  L13_SIGNAL w0.091: 305.68,248.53 305.29,248.53 304.16,247.4 304.16,240.42 306.95,237.63 307.28,237.3 307.28,230.11 309.67,227.72 309.67,225.48 309.19,225 308.16,225 307.57,224.42 307.57,221.6 306.35,220.38 306.35,193.83 304.23,191.71 301.54,191.71 300.61,190.78 300.61,178.88 303.83,175.65 303.83,172.28 303.12,171.56 303.12,164.17 302.67,163.73 302.67,161.67 302.31,161.31 302.31,156.67 305.05,153.92 307.72,153.92 308.51,153.14 308.51,151.8 310.17,150.14 311.18,150.14 316.38,144.93 316.38,142.16 323.47,135.08 323.47,126.34 343.92,105.89 497.98,105.89 504.84,99.03 504.84,76.65 527.06,54.43 531.95,54.43 D207.03
D20704: length 375.2
  L13_SIGNAL w0.076: 305.12,191.08 304.73,190.69
  L13_SIGNAL w0.091: 305.12,191.08 309.24,195.2 309.24,207.39 310.64,208.79 310.64,212.98 309.4,214.22 309.4,220.43 310.11,221.14 310.11,223.52 313.63,227.04 v2(313.63,232.39) ; D207.04 534.27,56.75 527.38,56.75 505.68,78.44 505.68,99.51 498.46,106.73 347.29,106.73 330.73,123.29 330.73,130.91 319.05,142.6 319.05,145.64 316.36,148.33 315.47,148.33 313.31,150.5 313.31,151.13 310.39,154.05 309.75,154.05 307.08,156.72 307.08,161.75 307.57,162.24 307.57,173.09 302.23,178.44 302.23,188.19 304.73,190.69
  BOTTOM w0.16: UNK3K32.7 v2(313.63,232.39)
D20705: length 409.2
  L13_SIGNAL w0.076: v2(309.85,248.85) 309.53,249.18 305.81,249.18
  L13_SIGNAL w0.091: 305.81,249.18 305.18,249.18 303.78,247.78 303.78,240.28 304.67,239.39 304.67,238.25 304.41,238 304.41,236.6 304.67,236.35 304.67,230.85 307.55,227.96 307.55,225.46 307.11,225.02 306.06,225.02 305.34,224.3 305.34,221.55 304.95,221.16 304.95,211.34 305.23,211.06 305.23,193.73 303.63,192.13 301.37,192.13 300.19,190.95 300.19,178.44 302.56,176.07 302.56,173.15 303.06,172.65 303.06,172.1 302.7,171.74 302.7,164.4 302.25,163.96 302.25,162.41 301.19,161.35 301.19,158.17 301.77,157.59 301.77,155.17 304.8,152.15 307.47,152.15 313.64,145.97 313.64,135.48 343.67,105.45 497.82,105.45 504.42,98.84 504.42,75.39 527.47,52.35 534.95,52.35 D207.05
D20706: length 387
  L13_SIGNAL w0.076: 316.07,243.33 314.73,243.33 v2(314.41,243)
  L13_SIGNAL w0.091: 316.07,243.33 316.86,243.33 318.75,241.44 318.75,240.86 316.11,238.22 316.11,226.95 319.4,223.67 319.4,218.14 317.87,216.61 316.22,216.61 315,215.39 315,203.5 314.55,203.05 314.55,196.68 313.41,195.54 313.41,192.71 314.65,191.47 315.34,191.47 318.92,187.88 318.92,182.35 314.14,177.57 314.14,167.31 318.45,163.01 318.45,158 316.74,156.29 316.74,149.68 319.15,147.27 319.93,147.27 337.13,130.07 337.13,124.89 353.96,108.07 499.1,108.07 506.88,100.29 506.88,80.12 527.47,59.54 539.9,59.54 D207.06
D20707: length 383.7
  L13_SIGNAL w0.091: D207.07 539.57,51.89 527.29,51.89 504,75.18 504,98.65 497.63,105.03 339.88,105.03 313.13,131.78 313.13,144.55 305.92,151.76 303.4,151.76 301.37,153.8 301.37,157.36 300.76,157.97 300.76,160.76 300,161.52 300,163.74 300.51,164.25 301.25,164.25 302.27,165.27 302.27,171.81 302.14,171.94 302.14,175.89 299,179.04 299,191.14 300.41,192.55 302.4,192.55 304.82,194.97 304.82,206.14 304.11,206.84 304.11,209.2 304.26,209.34 UNK3K39.7
D20708: length 395
  L13_SIGNAL w0.076: 315.8,246.58 314.08,246.58 v2(313.76,246.91)
  L13_SIGNAL w0.091: D207.08 544.47,60.05 527.55,60.05 507.3,80.3 507.3,102.07 498.49,110.88 438.49,110.88 433.04,116.33 346.46,116.33 338.28,124.51 338.28,130.99 320.58,148.68 320.15,148.68 319.2,149.63 319.2,150.1 317.51,151.79 317.51,155.41 318.83,156.73 318.83,163.22 314.57,167.47 314.57,176.63 319.4,181.46 319.4,187.93 314.52,192.81 314.52,195.81 314.93,196.22 314.93,202.84 315.42,203.33 315.42,214.1 317.48,216.16 318.03,216.16 320.11,218.24 320.22,218.24 320.49,218.52 320.49,223.16 316.54,227.12 316.54,236.67 317.8,237.92 317.8,239.2 319.27,240.67 319.27,244.09 316.79,246.58 315.8,246.58
D20709: length 397.1
  L13_SIGNAL w0.091: UNK3K39.2 304.26,224.51 302.9,223.15 302.9,210.82 303.3,210.43 303.3,198.55 304.34,197.51 304.34,196.55 300.76,192.97 300.24,192.97 298.58,191.31 298.58,178.86 301.72,175.72 301.72,171.62 301.26,171.16 301.26,167.79 299.14,165.66 299.14,153.49 303.63,149 306.58,149 309.25,146.33 309.25,145.06 312.55,141.76 312.55,128.54 336.47,104.61 497.36,104.61 503.59,98.38 503.59,73.32 527.17,49.73 542.49,49.73 D207.09
D20710: length 398.2
  L13_SIGNAL w0.076: v2(314.41,247.56) 314.73,247.23 315.84,247.23
  L13_SIGNAL w0.091: 315.84,247.23 316.9,247.23 320.67,243.46 320.67,240.92 318.89,239.14 318.89,238.5 316.96,236.57 316.96,227.29 320.94,223.31 320.94,218.12 320.5,217.68 320.14,217.68 318.66,216.2 318.66,212.87 317.55,211.75 317.55,207.73 316.46,206.64 316.46,205.1 315.84,204.48 315.84,203.23 315.31,202.7 315.31,195.94 314.89,195.51 314.89,192.98 321.13,186.74 321.13,181.46 319.78,180.11 318.58,180.11 316.17,177.7 316.17,166.47 319.2,163.44 319.2,156.49 318.61,155.91 318.61,152.19 321.75,149.05 322.28,149.05 338.76,132.56 338.76,127.69 347.18,119.27 430.8,119.27 438.76,111.3 498.66,111.3 507.72,102.25 507.72,81.89 527.56,62.05 547.55,62.05 D207.10
D20711: length 434.2
  L13_SIGNAL w0.076: 306.32,249.83 310.18,249.83 v2(310.5,249.5)
  L13_SIGNAL w0.091: D207.11 547.12,49.28 527.04,49.28 503.17,73.15 503.17,98.19 497.17,104.19 336.26,104.19 311.05,129.41 311.05,142.47 305.77,147.75 301.45,147.75 298.66,150.54 298.66,165.75 300.83,167.92 300.83,171.32 301.31,171.79 301.31,174.73 298.16,177.87 298.16,192.33 299.52,193.69 300.85,193.69 302.76,195.6 302.76,210.38 302.48,210.65 302.48,224 303.04,224.55 303.04,230.65 304.06,231.68 304.06,236.08 303.91,236.23 303.91,238.12 304.29,238.51 304.29,239.14 303.4,240.03 303.4,248.41 304.82,249.83 306.32,249.83
D20712: length 404.2
  L13_SIGNAL w0.091: v2(315.7,248.2) 318.08,248.2 321.05,245.24 321.05,239.4 320.22,238.56 319.58,238.56 317.38,236.36 317.38,227.46 321.36,223.48 321.36,217.83 320.57,217.04 320.11,217.04 319.09,216.02 319.09,211.95 318.58,211.44 318.58,208.14 316.88,206.45 316.88,204.93 316.26,204.31 316.26,203.01 315.68,202.42 315.68,195.55 315.25,195.13 315.25,193.17 321.55,186.88 321.55,181.32 316.56,176.33 316.56,166.68 319.58,163.66 319.58,156.11 319.09,155.62 319.09,152.22 320.71,150.61 322.74,150.61 334.06,139.29 334.06,138.35 334.65,137.76 335.6,137.76 339.22,134.14 339.22,127.89 347.42,119.68 431.01,119.68 438.98,111.72 498.84,111.72 508.15,102.41 508.15,82.09 527.68,62.56 552.12,62.56 D207.12
D20713: length 463.8
  L13_SIGNAL w0.076: 311.48,251.08 311.48,247.42 311.67,247.23 312.78,247.23 v2(313.11,246.91)
  L13_SIGNAL w0.091: 311.48,251.08 311.23,251.33 305.3,251.33 303.03,249.06 303.03,236.59 303.69,235.92 303.69,232.88 303.48,232.67 303.48,231.62 302.67,230.81 302.67,225.4 301.8,224.54 300.98,224.54 299.84,223.39 299.84,222.12 301.24,220.73 301.24,195.22 300.12,194.11 296.38,194.11 295.19,192.92 295.19,178 296.17,177.02 298.42,177.02 300.89,174.55 300.89,171.97 300.32,171.4 300.32,167.93 297.79,165.4 297.27,165.4 296.54,164.67 296.54,151.64 300.9,147.28 301.84,147.28 307.52,141.6 307.52,133.05 308.58,131.99 308.58,128.11 332.92,103.77 496.95,103.77 502.75,97.98 502.75,61.08 516.58,47.24 550.16,47.24 D207.13
D20714: length 372.5
  L13_SIGNAL w0.091: D207.14 555.14,64.62 527.54,64.62 508.57,83.59 508.57,102.58 499.01,112.14 439.17,112.14 431.2,120.1 350.53,120.1 340.36,130.28 340.36,135 336.36,139 336.36,140.32 334.49,142.19 333.17,142.19 325.78,149.58 324.33,149.58 322.94,150.98 321.88,150.98 320.54,152.32 320.54,163.28 316.96,166.86 316.96,176.1 319.13,178.27 320,178.27 322.78,181.05 322.78,187.25 316.04,193.98 316.04,202.2 316.68,202.84 316.68,204.13 317.3,204.75 317.3,205.53 319.13,207.36 319.13,207.79 319.84,208.5 319.84,211.53 319.54,211.82 319.54,215.79 320.38,216.62 320.78,216.62 322.57,218.42 UNK3K113.6
D20715: length 470.1
  L13_SIGNAL w0.076: 312.13,251.08 312.13,249.18 v2(312.46,248.85)
  L13_SIGNAL w0.091: 312.13,251.08 312.13,251.54 311.81,251.87 310.75,251.87 309.93,252.69 306.15,252.69 302.67,249.21 302.67,236.55 302.25,236.14 302.25,233.45 303.06,232.65 303.06,231.79 302.25,230.99 302.25,225.58 301.59,224.92 300.35,224.92 299.01,223.58 299.01,210.06 300.07,209 300.07,206.27 300.83,205.51 300.83,195.34 299.97,194.48 296.57,194.48 296.1,194.94 294.07,194.94 289.93,190.8 289.93,174.71 291.51,173.13 291.51,167.47 294.88,164.09 294.88,152.31 306.91,140.28 306.91,129.18 332.74,103.35 496.76,103.35 502.33,97.79 502.33,60.9 516.47,46.76 554.76,46.76 D207.15
D20716: length 395
  L13_SIGNAL w0.091: v2(317.83,232.39) 317.83,227.65 321.85,223.64 323.09,223.64 323.58,223.15 323.58,218.75 320.65,215.82 320.65,210.94 320.94,210.65 320.94,209.88 320.32,209.26 320.32,207.11 317.1,203.89 317.1,202.57 316.45,201.93 316.45,194.13 323.2,187.39 323.2,180.86 320.24,177.9 319.43,177.9 317.37,175.84 317.37,167.04 320.92,163.49 320.92,152.58 321.79,151.71 323.77,151.71 325.4,150.09 327.36,150.09 340.79,136.65 340.79,130.53 350.8,120.52 431.44,120.52 436.89,115.07 498.51,115.07 508.99,104.6 508.99,83.76 527.65,65.1 559.74,65.1 D207.16
  BOTTOM w0.16: UNK3K32.2 v2(317.83,232.39)
D20814: length 476.4
  L13_SIGNAL w0.091: D208.14 555.14,44.3 517.75,44.3 501.49,60.55 501.49,97.28 496.25,102.51 329.37,102.51 304.65,127.23 304.65,138.61 294.01,149.25 294.01,161.16 290.63,164.54 290.63,172.71 289.05,174.29 289.05,194.14 290.7,195.79 290.7,197.74 291.02,198.07 291.02,204.22 298.13,211.33 298.13,225.48 300.36,227.71 300.36,230.85 301.37,231.86 301.37,236.07 301.11,236.33 301.11,253.62 302.38,254.89 302.38,257.38 v2(304,259)
  L23_SIGNAL w0.091: v2(305.95,244.96) 305.73,244.73 305.3,244.73 305.04,244.98 304.28,244.98 303.27,246 303.27,258.27 v2(304,259)
D20816: length 471.1
  L13_SIGNAL w0.076: v2(313.11,247.56) 312.78,247.88 312.78,251.08
  L13_SIGNAL w0.091: 312.78,251.08 312.78,251.65 311.32,253.11 304.92,253.11 302.19,250.38 302.19,237.94 301.87,237.62 301.87,231.52 300.86,230.5 300.86,227.46 298.57,225.17 298.57,211.17 291.44,204.04 291.44,197.82 291.12,197.5 291.12,195.56 289.5,193.95 289.5,174.48 291.09,172.9 291.09,167.3 294.46,163.93 294.46,150.98 306.4,139.04 306.4,126.14 329.61,102.93 496.52,102.93 501.91,97.54 501.91,60.73 517.86,44.78 559.74,44.78 D208.16
D20901: length 415.6
  L13_SIGNAL w0.091: v3(243.59,306.5) 243.84,306.5 246.23,308.9 295.97,308.9 304.04,316.97 421.52,316.97 427.19,311.29 434.32,311.29 440.07,317.04 515.64,317.04 524.11,325.51 565.97,325.51 567.76,327.3 567.76,331.54 D209.01
  L31_SIGNAL w0.091: v2(235.06,239.75) 237.92,239.75 240.95,242.78 240.95,252.96 240.65,253.27 240.65,264.68 241.69,265.72 241.69,269.82 242.59,270.72 242.59,282.04 242.98,282.43 242.98,305.89 v3(243.59,306.5)
D20902: length 401.2
  L29_SIGNAL w0.091: D209.02 562.86,326.64 513.08,326.64 500.25,313.82 439.52,313.82 432.16,321.18 268.85,321.18 266.89,319.22 266.89,304.34 275.08,296.16 275.08,295.41 276.99,293.5 276.99,289.57 282.59,283.97 282.59,270.72 281.69,269.82 281.69,265.72 280.65,264.68 280.65,253.27 280.95,252.96 280.95,242.78 277.92,239.75 v2(275.06,239.75)
D20903: length 359.2
  L27_SIGNAL w0.091: v2(315.05,239.75) 317.92,239.75 320.95,242.78 320.95,252.96 320.65,253.27 320.65,264.68 321.69,265.72 321.69,269.82 322.59,270.72 322.59,282.04 322.98,282.43 322.98,288.78 322.51,289.25 322.51,290.13 318.66,293.99 317.39,293.99 316.96,294.41 316.96,295.8 316.64,296.13 315.25,296.13 314.07,297.31 313.7,297.31 310.21,300.79 309.77,300.79 306.98,303.58 306.98,315.95 308.06,317.03 425.72,317.03 427.12,315.63 427.12,314.64 429.25,312.51 432.97,312.51 437.49,317.03 501.06,317.03 512.71,328.68 561.53,328.68 562.61,329.76 562.61,331.47 D209.03
D20904: length 270.5
  L25_SIGNAL w0.091: D209.04 555.75,324.61 511.43,324.61 500.38,313.56 449.33,313.56 440.85,305.08 377.98,305.08 362.98,290.08 362.98,282.43 362.59,282.04 362.59,270.72 361.69,269.82 361.69,265.72 360.65,264.68 360.65,253.27 360.95,252.96 360.95,242.78 357.92,239.75 v2(355.05,239.75)
D20905: length 405.5
  L13_SIGNAL w0.091: D209.05 557.48,331.42 557.48,327.28 556.59,326.39 524.13,326.39 515.23,317.49 439.85,317.49 434.04,311.68 427.32,311.68 421.63,317.37 303.84,317.37 299.31,312.85 247.57,312.85 244.04,309.32 244.04,308.48 v3(243.59,308.03)
  L31_SIGNAL w0.091: v3(243.59,308.03) 243.33,308.03 242.58,307.28 242.58,283.09 241.3,281.8 241.3,267.68 239.45,265.83 239.45,252.83 240.54,251.74 240.54,244.34 236.6,240.4 v2(235.71,240.4)
D20906: length 389.2
  L29_SIGNAL w0.091: D209.06 554.74,328.68 514.43,328.68 500.05,314.3 439.72,314.3 432.47,321.55 268.59,321.55 266.45,319.4 266.45,304.22 274.7,295.96 274.7,294.97 276.48,293.19 276.48,289.05 281.3,284.24 281.3,267.68 279.45,265.83 279.45,252.83 280.54,251.74 280.54,244.34 276.6,240.4 v2(275.71,240.4)
D20907: length 346.7
  L27_SIGNAL w0.091: D209.07 552.45,331.47 552.45,329.82 551.79,329.16 512.19,329.16 500.53,317.49 437.22,317.49 432.71,312.98 429.6,312.98 427.59,314.99 427.59,315.91 425.92,317.58 307.85,317.58 306.42,316.15 306.42,303.42 309.41,300.43 310.06,300.43 313.56,296.93 313.84,296.93 322.58,288.18 322.58,283.09 321.3,281.8 321.3,267.68 319.45,265.83 319.45,252.83 320.54,251.74 320.54,244.34 316.6,240.4 v2(315.7,240.4)
D20908: length 259.7
  L25_SIGNAL w0.091: v2(355.7,240.4) 356.6,240.4 360.54,244.34 360.54,251.74 359.45,252.83 359.45,265.83 361.3,267.68 361.3,281.8 362.58,283.09 362.58,291.07 376.96,305.45 440.7,305.45 449.17,313.93 500.23,313.93 511.8,325.5 546.48,325.5 D209.08
D20909: length 398.2
  L13_SIGNAL w0.091: D209.09 547.55,331.65 547.55,329.9 546.58,328.93 525.7,328.93 514.77,318 439.64,318 433.83,312.19 427.37,312.19 425.23,314.33 425.22,314.33 424.9,314.66 424.9,314.66 421.81,317.75 303.15,317.75 300.74,320.17 295.15,320.17 292.61,317.63 251.56,317.63 240.44,306.5 v3(239.27,306.5)
  L31_SIGNAL w0.076: v2(234.41,240.4) 234.73,240.73 235.91,240.73
  L31_SIGNAL w0.091: 235.91,240.73 237.1,241.92 237.1,242.51 239.4,244.81 239.4,252.18 239.03,252.54 239.03,268.08 240.79,269.84 240.79,304.98 v3(239.27,306.5)
D20910: length 378
  L29_SIGNAL w0.076: v2(274.41,240.4) 274.73,240.73 275.91,240.73
  L29_SIGNAL w0.091: 275.91,240.73 277.1,241.92 277.1,242.51 279.4,244.81 279.4,252.18 279.03,252.54 279.03,268.08 280.79,269.84 280.79,283.85 275.84,288.8 275.84,292.86 274.16,294.55 274.16,295.69 273.15,296.69 272.45,296.69 266.01,303.13 266.01,319.58 268.37,321.94 432.74,321.94 437.72,316.97 499.85,316.97 512.06,329.18 545.08,329.18 D209.10
D20911: length 333.4
  L27_SIGNAL w0.076: 315.91,240.73 314.73,240.73 v2(314.41,240.4)
  L27_SIGNAL w0.091: D209.11 542.01,331.19 513.35,331.19 500.1,317.94 450.68,317.94 448.18,320.43 428.6,320.43 426.19,318.01 307.39,318.01 305.96,316.58 305.96,303.17 312.6,296.53 313.71,296.53 321.25,288.99 321.25,282.8 320.79,282.35 320.79,269.84 319.03,268.08 319.03,252.54 319.4,252.18 319.4,244.81 317.1,242.51 317.1,241.92 315.91,240.73
D20912: length 250.9
  L25_SIGNAL w0.076: v2(354.4,240.4) 354.73,240.73 355.91,240.73
  L25_SIGNAL w0.091: D209.12 537.21,326.39 512.17,326.39 500.08,314.29 449.02,314.29 440.54,305.82 375.29,305.82 361.25,291.77 361.25,282.8 360.79,282.35 360.79,269.84 359.03,268.08 359.03,252.54 359.4,252.18 359.4,244.81 357.1,242.51 357.1,241.92 355.91,240.73
D20913: length 389.3
  L13_SIGNAL w0.091: v3(239.27,308.03) 242.14,310.9 242.14,311.96 248.19,318.01 292.1,318.01 294.64,320.55 300.99,320.55 303.4,318.13 424.56,318.13 430.07,312.62 433.65,312.62 439.46,318.43 514.69,318.43 527.73,331.47 537.21,331.47 D209.13
  L31_SIGNAL w0.076: v2(232.46,245.61) 232.78,245.28 232.78,244.82 232.97,244.63 235.38,244.63
  L31_SIGNAL w0.091: 235.38,244.63 235.91,244.09 237.12,244.09 238.99,245.96 238.99,252.07 238.55,252.5 238.55,266.62 237.79,267.38 237.79,267.85 239.78,269.84 239.78,271.74 239.4,272.13 239.4,302.19 238.4,303.18 238.4,307.44 238.99,308.03 v3(239.27,308.03)
D20914: length 371.7
  L29_SIGNAL w0.076: 275.38,244.63 272.97,244.63 272.78,244.82 272.78,245.28 v2(272.46,245.61)
  L29_SIGNAL w0.091: 275.38,244.63 275.91,244.09 277.12,244.09 278.99,245.96 278.99,252.07 278.55,252.5 278.55,266.62 277.79,267.38 277.79,267.85 279.78,269.84 279.78,271.74 279.4,272.13 279.4,284.48 275.34,288.54 275.34,290.58 271.36,294.55 271.36,297.14 263.91,304.6 263.91,320.17 266.05,322.31 433.1,322.31 437.93,317.47 499.64,317.47 513.76,331.6 534.54,331.6 D209.14
D20915: length 324.7
  L27_SIGNAL w0.076: v2(312.46,245.61) 312.78,245.28 312.78,244.82 312.97,244.63 315.38,244.63
  L27_SIGNAL w0.091: 315.38,244.63 315.91,244.09 317.12,244.09 318.99,245.96 318.99,252.07 318.55,252.5 318.55,266.62 317.79,267.38 317.79,267.85 319.78,269.84 319.78,271.74 319.4,272.13 319.4,281.92 320.82,283.34 320.82,288.91 313.56,296.16 312.35,296.16 305.5,303.01 305.5,316.78 307.21,318.49 425.86,318.49 428.3,320.93 448.39,320.93 450.91,318.41 499.57,318.41 512.9,331.74 532.4,331.74 D209.15
D20916: length 243
  L25_SIGNAL w0.076: 355.38,244.63 352.97,244.63 352.78,244.82 352.78,245.28 v2(352.45,245.61)
  L25_SIGNAL w0.091: D209.16 529.34,328.68 511.18,328.68 499.49,316.99 451.1,316.99 442.74,308.63 376.03,308.63 360.82,293.42 360.82,283.34 359.4,281.92 359.4,272.13 359.78,271.74 359.78,269.84 357.79,267.85 357.79,267.38 358.55,266.62 358.55,252.5 358.99,252.07 358.99,245.96 357.12,244.09 355.91,244.09 355.38,244.63
D21001: length 426.3
  L13_SIGNAL w0.091: v3(239.27,310.7) 240.26,310.7 247.95,318.39 291.59,318.39 294.12,320.91 301.14,320.91 303.53,318.52 427.25,318.52 429.92,321.2 507.89,321.2 530.86,344.17 565.3,344.17 567.51,346.38 567.51,351.61 D210.01
  L31_SIGNAL w0.076: v2(233.11,245.61) 233.43,245.28 235.51,245.28
  L31_SIGNAL w0.091: v3(239.27,310.7) 237.72,309.15 237.72,300.68 237.24,300.19 237.24,295.53 236.73,295.02 236.73,293.62 238.15,292.21 238.15,281.05 238.63,280.56 238.63,270.31 237.32,269 237.32,253.16 238.62,251.86 238.62,246.35 236.77,244.5 236.28,244.5 235.51,245.28
D21002: length 408.2
  L29_SIGNAL w0.076: 275.51,245.28 273.43,245.28 v2(273.11,245.61)
  L29_SIGNAL w0.091: 275.51,245.28 276.28,244.5 276.77,244.5 278.62,246.35 278.62,251.86 277.32,253.16 277.32,269 278.63,270.31 278.63,280.56 278.15,281.05 278.15,282.4 274.57,285.97 274.57,289.81 274.07,290.32 273.3,290.32 272.51,291.11 272.51,292.51 270.52,294.5 270.52,296.56 263.27,303.81 263.27,320.29 265.66,322.69 433.36,322.69 438.12,317.93 499.45,317.93 528.48,346.96 562.86,346.96 D210.02
D21003: length 363.2
  L27_SIGNAL w0.076: 315.51,245.28 313.43,245.28 v2(313.11,245.61)
  L27_SIGNAL w0.091: D210.03 562.61,351.79 562.61,350.02 561.58,348.99 524.57,348.99 496.89,321.31 304.07,321.31 303.6,320.84 303.6,303.4 310.46,296.55 310.46,295.59 313.87,292.18 313.87,292.18 314.41,291.64 314.41,291.64 317.33,288.73 317.33,283.17 318.09,282.4 318.09,281.1 318.63,280.56 318.63,270.31 317.32,269 317.32,253.16 318.62,251.86 318.62,246.35 316.77,244.5 316.28,244.5 315.51,245.28
D21004: length 282.8
  L25_SIGNAL w0.076: v2(353.1,245.61) 353.43,245.28 355.51,245.28
  L25_SIGNAL w0.091: D210.04 555.12,344.3 555.12,342.52 554.23,341.63 523.37,341.63 499.09,317.36 450.95,317.36 442.59,308.99 374.04,308.99 358.26,293.2 358.26,282.51 358.15,282.4 358.15,281.05 358.63,280.56 358.63,270.31 357.32,269 357.32,253.16 358.62,251.86 358.62,246.35 356.77,244.5 356.28,244.5 355.51,245.28
D21005: length 412.2
  L13_SIGNAL w0.091: v3(239.27,312.22) 242.67,315.62 242.67,316.35 247.93,321.61 505.76,321.61 530.87,346.71 556.59,346.71 557.48,347.6 557.48,351.74 D210.05
  L31_SIGNAL w0.076: 235.83,245.93 233.43,245.93 v2(233.11,246.26)
  L31_SIGNAL w0.091: v3(239.27,312.22) 239.25,312.22 237.31,310.28 237.31,301.12 236.6,300.42 236.6,297.18 235.58,296.16 235.58,293.37 236.96,292 236.96,279.34 237.53,278.77 237.53,270.01 236.91,269.39 236.91,252.86 237.54,252.23 237.54,247.4 236.07,245.93 235.83,245.93
D21006: length 395.2
  L29_SIGNAL w0.076: 275.83,245.93 273.43,245.93 v2(273.11,246.26)
  L29_SIGNAL w0.091: D210.06 554.74,349 529.9,349 499.27,318.36 438.3,318.36 433.59,323.08 265.42,323.08 262.76,320.42 262.76,303.76 269.7,296.82 269.7,294.69 272.15,292.24 272.15,290.59 272.88,289.85 273.77,289.85 274.07,289.56 274.07,284.2 276.96,281.31 276.96,279.34 277.53,278.77 277.53,270.01 276.91,269.39 276.91,252.86 277.54,252.23 277.54,247.4 276.07,245.93 275.83,245.93
