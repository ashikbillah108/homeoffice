# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#4335  -  []  229.5 208.8 0 top
NOREF#4336  -  []  351.84 244.96 0 top
NOREF#4337  -  []  310.18 251.08 0 top
NOREF#4338  -  []  219.33 256.13 0 top
NOREF#4339  -  []  248.21 271.73 90 top
NOREF#4340  -  []  65.94 249.91 0 top
NOREF#4341  -  []  235.44 254.76 90 top
NOREF#4342  -  []  344.09 231.46 0 top
NOREF#4343  -  []  115.04 154.45 0 top
NOREF#4344  -  []  303.95 232.9 90 top
NOREF#4345  -  []  461.07 229.22 90 top
NOREF#4346  -  []  279.44 140.92 0 top
NOREF#4347  -  []  354.44 144.1 0 top
NOREF#4348  -  []  486.95 189.85 0 top
NOREF#4349  -  []  351.84 246.26 0 top
NOREF#4350  -  []  350.83 178.82 0 top
NOREF#4351  -  []  310.91 187.88 0 top
NOREF#4352  -  []  475.18 165.47 90 top
NOREF#4353  -  []  274.78 242.68 0 top
NOREF#4354  -  []  347.94 181.7 0 top
NOREF#4355  -  []  275.91 223.58 90 top
NOREF#4356  -  []  467.84 138.36 90 top
NOREF#4357  -  []  95.79 253.35 0 top
NOREF#4358  -  []  310.84 243.37 90 top
NOREF#4359  -  []  251.16 180.15 0 top
NOREF#4360  -  []  101.59 244.1 0 top
NOREF#4361  -  []  264.09 231.46 0 top
NOREF#4362  -  []  233.17 291.16 0 top
NOREF#4363  -  []  245.73 273.87 90 top
NOREF#4364  -  []  230.86 245.29 0 top
NOREF#4365  -  []  486.4 148.85 0 top
NOREF#4366  -  []  121.88 138.36 90 top
NOREF#4367  -  []  264.96 135.09 0 top
NOREF#4368  -  []  269.53 184.02 90 top
NOREF#4369  -  []  267.27 186.26 0 top
NOREF#4370  -  []  84.1 292.77 0 top
NOREF#4371  -  []  224.09 171.46 0 top
NOREF#4372  -  []  312.12 249.88 90 top
NOREF#4373  -  []  467.84 205.05 0 top
NOREF#4374  -  []  79.1 290.69 0 top
NOREF#4375  -  []  270.18 251.08 0 top
NOREF#4376  -  []  352.45 190.18 90 top
NOREF#4377  -  []  253.09 243.93 0 top
NOREF#4378  -  []  309.59 186.58 0 top
NOREF#4379  -  []  229.5 268.8 0 top
NOREF#4380  -  []  367.88 272.03 90 top
NOREF#4381  -  []  45.98 272.89 0 top
NOREF#4382  -  []  224.52 289.22 90 top
NOREF#4383  -  []  215.16 179.65 90 top
NOREF#4384  -  []  456.55 145.82 0 top
NOREF#4385  -  []  305.48 235.27 0 top
NOREF#4386  -  []  311.21 187.56 0 top
NOREF#4387  -  []  228.57 244.96 0 top
NOREF#4388  -  []  310.73 166.09 90 top
NOREF#4389  -  []  291.96 182 90 top
NOREF#4390  -  []  354.73 191.08 0 top
NOREF#4391  -  []  333.39 183.61 0 top
NOREF#4392  -  []  55.46 268.47 0 top
NOREF#4393  -  []  273.36 181.38 90 top
NOREF#4394  -  []  348.01 233.3 90 top
NOREF#4395  -  []  346.93 238.18 90 top
NOREF#4396  -  []  247.88 212.03 90 top
NOREF#4397  -  []  283.98 267.75 0 top
NOREF#4398  -  []  121.88 234.26 0 top
NOREF#4399  -  []  293.61 182 90 top
NOREF#4400  -  []  478.18 136.82 0 top
NOREF#4401  -  []  308.93 240.73 0 top
NOREF#4402  -  []  352.05 245.29 90 top
NOREF#4403  -  []  343.95 234.38 90 top
NOREF#4404  -  []  310.73 166.09 0 top
NOREF#4405  -  []  356.11 234.13 90 top
NOREF#4406  -  []  308.23 178.18 0 top
NOREF#4407  -  []  322.33 173.13 90 top
NOREF#4408  -  []  263.09 174.38 0 top
NOREF#4409  -  []  233.66 269.1 90 top
NOREF#4410  -  []  547.04 237.35 0 top
NOREF#4411  -  []  346.97 185.94 90 top
NOREF#4412  -  []  230.73 166.09 90 top
NOREF#4413  -  []  240.04 137.42 90 top
NOREF#4414  -  []  305.33 133.69 0 top
NOREF#4415  -  []  360.04 137.42 90 top
NOREF#4416  -  []  349.59 185.93 0 top
NOREF#4417  -  []  282.33 173.13 90 top
NOREF#4418  -  []  232.14 182.07 90 top
NOREF#4419  -  []  215.58 243.29 90 top
NOREF#4420  -  []  228.27 245.93 0 top
NOREF#4421  -  []  316.47 209.49 0 top
NOREF#4422  -  []  304.91 173.9 0 top
NOREF#4423  -  []  284.05 212.03 90 top
NOREF#4424  -  []  324.49 208.86 0 top
NOREF#4425  -  []  361.13 267.92 90 top
NOREF#4426  -  []  250.56 180.75 0 top
NOREF#4427  -  []  307.58 184.06 0 top
NOREF#4428  -  []  270.82 241.42 90 top
NOREF#4429  -  []  242.56 209.25 90 top
NOREF#4430  -  []  475.7 151.25 90 top
NOREF#4431  -  []  271.84 186.26 0 top
NOREF#4432  -  []  353.1 250.18 90 top
NOREF#4433  -  []  478.18 168.57 0 top
NOREF#4434  -  []  214.38 254.86 0 top
NOREF#4435  -  []  312.78 189.88 90 top
NOREF#4436  -  []  350.5 243.67 90 top
NOREF#4437  -  []  286.03 214.19 0 top
NOREF#4438  -  []  501.84 222 90 top
NOREF#4439  -  []  350.13 208.11 90 top
NOREF#4440  -  []  340.66 166.14 0 top
NOREF#4441  -  []  305.95 188.86 90 top
NOREF#4442  -  []  229.53 244.02 0 top
NOREF#4443  -  []  214.38 243.29 0 top
NOREF#4444  -  []  89.64 154.45 0 top
NOREF#4445  -  []  291.16 240.15 0 top
NOREF#4446  -  []  276.22 282.25 90 top
NOREF#4447  -  []  266.97 185.94 90 top
NOREF#4448  -  []  301.29 292.89 90 top
NOREF#4449  -  []  322.91 267.92 0 top
NOREF#4450  -  []  255.71 193.56 90 top
NOREF#4451  -  []  267.05 133.3 0 top
NOREF#4452  -  []  225.68 245.29 90 top
NOREF#4453  -  []  226.45 147.01 90 top
NOREF#4454  -  []  262.56 286.27 0 top
NOREF#4455  -  []  310.84 247.15 0 top
NOREF#4456  -  []  121.88 204.4 90 top
NOREF#4457  -  []  357.95 143.53 90 top
NOREF#4458  -  []  271.19 243 0 top
NOREF#4459  -  []  48.16 247.71 0 top
NOREF#4460  -  []  264.52 285.16 0 top
NOREF#4461  -  []  350.18 242.62 0 top
NOREF#4462  -  []  557.76 149.79 90 top
NOREF#4463  -  []  368.21 271.73 90 top
NOREF#4464  -  []  480.6 221.6 0 top
NOREF#4465  -  []  468.1 154.45 0 top
NOREF#4466  -  []  361.44 190.47 0 top
NOREF#4467  -  []  266.94 264.26 0 top
NOREF#4468  -  []  349.59 245.93 0 top
NOREF#4469  -  []  231.81 181.72 90 top
NOREF#4470  -  []  306.54 134.31 90 top
NOREF#4471  -  []  274.44 144.1 0 top
NOREF#4472  -  []  230.89 182.68 90 top
NOREF#4473  -  []  240.81 218.16 0 top
NOREF#4474  -  []  355.44 254.76 90 top
NOREF#4475  -  []  215.58 254.86 90 top
NOREF#4476  -  []  272.13 238.82 90 top
NOREF#4477  -  []  224.96 135.09 0 top
NOREF#4478  -  []  352.13 240.12 90 top
NOREF#4479  -  []  352.23 167.99 90 top
NOREF#4480  -  []  340.67 289.14 0 top
NOREF#4481  -  []  351.19 243 0 top
NOREF#4482  -  []  255.16 179.65 90 top
NOREF#4483  -  []  270.82 189.88 90 top
NOREF#4484  -  []  270.54 240.4 0 top
NOREF#4485  -  []  271.16 245.61 0 top
NOREF#4486  -  []  227.59 178.18 90 top
NOREF#4487  -  []  329.83 263.63 90 top
NOREF#4488  -  []  48.53 248.1 0 top
NOREF#4489  -  []  314.44 144.1 0 top
NOREF#4490  -  []  238.32 142.99 0 top
NOREF#4491  -  []  212.13 14.79 0 top
NOREF#4492  -  []  345.68 245.93 0 top
NOREF#4493  -  []  344.96 135.09 0 top
NOREF#4494  -  []  232.13 238.82 90 top
NOREF#4495  -  []  270.84 243.37 0 top
NOREF#4496  -  []  299.87 207.91 0 top
NOREF#4497  -  []  311.49 182.62 0 top
NOREF#4498  -  []  83.8 278.73 90 top
NOREF#4499  -  []  315.44 254.76 90 top
NOREF#4500  -  []  121.88 202.51 0 top
NOREF#4501  -  []  271.54 244.64 0 top
NOREF#4502  -  []  82.32 262.5 90 top
NOREF#4503  -  []  335.71 193.56 90 top
NOREF#4504  -  []  351.8 181.72 90 top
NOREF#4505  -  []  287.65 160.09 90 top
NOREF#4506  -  []  333.54 179.12 90 top
NOREF#4507  -  []  280.04 140.12 0 top
NOREF#4508  -  []  84.1 276.15 0 top
NOREF#4509  -  []  347.64 182.03 0 top
NOREF#4510  -  []  351.54 246.58 0 top
NOREF#4511  -  []  467.9 158.1 0 top
NOREF#4512  -  []  457.6 186.2 0 top
NOREF#4513  -  []  277.95 138.2 90 top
NOREF#4514  -  []  303.71 288.65 90 top
NOREF#4515  -  []  291.16 247.72 90 top
NOREF#4516  -  []  357.71 207.75 0 top
NOREF#4517  -  []  345.88 175.27 0 top
NOREF#4518  -  []  349.89 186.26 0 top
NOREF#4519  -  []  352.23 232.39 90 top
NOREF#4520  -  []  311.81 239.12 90 top
NOREF#4521  -  []  233.36 241.38 90 top
NOREF#4522  -  []  232.14 251.08 0 top
NOREF#4523  -  []  267.58 183.28 0 top
NOREF#4524  -  []  117.42 192.22 90 top
NOREF#4525  -  []  290.61 192.27 0 top
NOREF#4526  -  []  231.08 209.73 0 top
NOREF#4527  -  []  49.74 247.71 90 top
NOREF#4528  -  []  309.59 186.59 90 top
NOREF#4529  -  []  251.83 203.63 0 top
NOREF#4530  -  []  122.18 204.72 0 top
NOREF#4531  -  []  475.45 189.85 0 top
NOREF#4532  -  []  559.22 132.9 90 top
NOREF#4533  -  []  331.96 253.56 90 top
NOREF#4534  -  []  480.18 234.57 0 top
NOREF#4535  -  []  313.66 209.1 90 top
NOREF#4536  -  []  310.5 190.18 90 top
NOREF#4537  -  []  275.91 163.58 90 top
NOREF#4538  -  []  474.41 227.5 0 top
NOREF#4539  -  []  214.36 181.55 0 top
NOREF#4540  -  []  547.34 225.47 0 top
NOREF#4541  -  []  266.61 179.76 90 top
NOREF#4542  -  []  220.33 189.91 0 top
NOREF#4543  -  []  229.59 186.59 90 top
NOREF#4544  -  []  225.33 133.69 0 top
NOREF#4545  -  []  114.29 188.2 0 top
NOREF#4546  -  []  233.46 183.33 0 top
NOREF#4547  -  []  252.78 179.12 90 top
NOREF#4548  -  []  237.71 267.75 0 top
NOREF#4549  -  []  335.38 242.3 90 top
NOREF#4550  -  []  363.98 207.75 90 top
NOREF#4551  -  []  121.19 253.35 0 top
NOREF#4552  -  []  284.38 273.87 0 top
NOREF#4553  -  []  478.18 200.32 90 top
NOREF#4554  -  []  234.91 223.58 0 top
NOREF#4555  -  []  476.65 154.45 0 top
NOREF#4556  -  []  259.41 221.54 90 top
NOREF#4557  -  []  114.29 180.6 0 top
NOREF#4558  -  []  225.68 185.93 0 top
NOREF#4559  -  []  307.41 133.69 0 top
NOREF#4560  -  []  237.14 144.1 90 top
NOREF#4561  -  []  235.91 223.58 90 top
NOREF#4562  -  []  271.54 184.64 0 top
NOREF#4563  -  []  230.24 240.08 0 top
NOREF#4564  -  []  273.63 146.07 0 top
NOREF#4565  -  []  315.98 242.68 90 top
NOREF#4566  -  []  320.48 269.12 0 top
NOREF#4567  -  []  332.54 183.29 90 top
NOREF#4568  -  []  352.45 182.37 90 top
NOREF#4569  -  []  535.51 222.55 90 top
NOREF#4570  -  []  335.83 259.63 0 top
NOREF#4571  -  []  227.64 241.38 90 top
NOREF#4572  -  []  222.86 166.14 0 top
NOREF#4573  -  []  313.99 268.8 90 top
NOREF#4574  -  []  354.91 223.58 0 top
NOREF#4575  -  []  332.33 193.86 90 top
NOREF#4576  -  []  158.1 2.28 90 top
NOREF#4577  -  []  356.07 267.24 0 top
NOREF#4578  -  []  349.89 185.61 0 top
NOREF#4579  -  []  567.63 170.72 90 top
NOREF#4580  -  []  313.03 294.95 0 top
NOREF#4581  -  []  266.93 178.18 90 top
NOREF#4582  -  []  307.64 181.38 90 top
NOREF#4583  -  []  463.95 186.2 0 top
NOREF#4584  -  []  349.83 269.1 90 top
NOREF#4585  -  []  350.83 182.62 0 top
NOREF#4586  -  []  320.81 158.66 90 top
NOREF#4587  -  []  243.72 211.73 90 top
NOREF#4588  -  []  271.44 240.08 90 top
NOREF#4589  -  []  228.93 208.11 0 top
NOREF#4590  -  []  324.68 214.19 0 top
NOREF#4591  -  []  225.05 145.8 0 top
NOREF#4592  -  []  268.93 240.74 90 top
NOREF#4593  -  []  278.71 140.12 90 top
NOREF#4594  -  []  480.8 154.45 0 top
NOREF#4595  -  []  265.96 248.85 0 top
NOREF#4596  -  []  211.16 251.72 0 top
NOREF#4597  -  []  214.36 241.55 0 top
NOREF#4598  -  []  306.92 189.88 90 top
NOREF#4599  -  []  230.24 185.28 0 top
NOREF#4600  -  []  303.71 283.19 0 top
NOREF#4601  -  []  307.9 184.36 90 top
NOREF#4602  -  []  305.95 248.85 0 top
NOREF#4603  -  []  295.38 253.86 90 top
NOREF#4604  -  []  343.09 174.94 0 top
NOREF#4605  -  []  244.79 271.56 90 top
NOREF#4606  -  []  252.66 253.56 90 top
NOREF#4607  -  []  228.24 238.18 0 top
NOREF#4608  -  []  304.09 231.46 0 top
NOREF#4609  -  []  213.54 250.69 90 top
NOREF#4610  -  []  251.33 267.13 0 top
NOREF#4611  -  []  229.46 145.44 90 top
NOREF#4612  -  []  114.42 234.57 0 top
NOREF#4613  -  []  347.64 240.73 90 top
NOREF#4614  -  []  229.5 268.8 90 top
NOREF#4615  -  []  503.03 224.14 90 top
NOREF#4616  -  []  270.55 134.62 90 top
NOREF#4617  -  []  311.8 190.18 90 top
NOREF#4618  -  []  486.4 156.45 0 top
NOREF#4619  -  []  230.54 240.4 0 top
NOREF#4620  -  []  212.96 243.2 0 top
NOREF#4621  -  []  453.45 186.2 0 top
NOREF#4622  -  []  108.65 164 0 top
NOREF#4623  -  []  229.23 241.06 0 top
NOREF#4624  -  []  223.09 233.82 0 top
NOREF#4625  -  []  37.68 266.27 0 top
NOREF#4626  -  []  347.9 242.38 90 top
NOREF#4627  -  []  304.41 231.76 90 top
NOREF#4628  -  []  231.21 187.56 0 top
NOREF#4629  -  []  547.34 234.23 0 top
NOREF#4630  -  []  253.1 178.82 90 top
NOREF#4631  -  []  231.81 241.72 90 top
NOREF#4632  -  []  367.65 220.09 90 top
NOREF#4633  -  []  158.31 290.38 90 top
NOREF#4634  -  []  310.19 238.82 90 top
NOREF#4635  -  []  293.61 242 90 top
NOREF#4636  -  []  343.09 232.9 0 top
NOREF#4637  -  []  267.63 187.24 90 top
NOREF#4638  -  []  226.93 249.88 90 top
NOREF#4639  -  []  456.64 200.91 90 top
NOREF#4640  -  []  228.01 173.3 90 top
NOREF#4641  -  []  287.07 268.22 90 top
NOREF#4642  -  []  348.44 202.36 0 top
NOREF#4643  -  []  310.24 185.28 0 top
NOREF#4644  -  []  311.16 239.12 90 top
NOREF#4645  -  []  230.84 243.37 90 top
NOREF#4646  -  []  269.89 186.91 0 top
NOREF#4647  -  []  271.48 191.08 0 top
NOREF#4648  -  []  242.91 267.92 90 top
NOREF#4649  -  []  280.81 208.22 90 top
NOREF#4650  -  []  346.54 133.3 90 top
NOREF#4651  -  []  255.38 182.3 90 top
NOREF#4652  -  []  268.93 208.11 0 top
NOREF#4653  -  []  229.53 178.82 90 top
NOREF#4654  -  []  121.88 140.9 90 top
NOREF#4655  -  []  269.59 185.94 90 top
NOREF#4656  -  []  356.29 209.25 90 top
NOREF#4657  -  []  310.84 238.82 90 top
NOREF#4658  -  []  463 151.25 90 top
NOREF#4659  -  []  468.14 172.97 0 top
NOREF#4660  -  []  216.33 16.13 90 top
NOREF#4661  -  []  324.38 273.87 0 top
NOREF#4662  -  []  225.96 188.86 0 top
NOREF#4663  -  []  308.23 238.18 0 top
NOREF#4664  -  []  306.97 186.58 0 top
NOREF#4665  -  []  350.83 243.37 90 top
NOREF#4666  -  []  109.42 197.22 0 top
NOREF#4667  -  []  317.71 267.75 0 top
NOREF#4668  -  []  467.84 173.3 0 top
NOREF#4669  -  []  108.69 154.45 0 top
NOREF#4670  -  []  270.73 226.09 0 top
NOREF#4671  -  []  251.64 253.86 90 top
NOREF#4672  -  []  252.45 178.82 0 top
NOREF#4673  -  []  67.52 247.71 90 top
NOREF#4674  -  []  363.72 271.73 90 top
NOREF#4675  -  []  222.63 289.44 0 top
NOREF#4676  -  []  342.86 226.14 0 top
NOREF#4677  -  []  333.22 190.39 90 top
NOREF#4678  -  []  103.34 158.1 0 top
NOREF#4679  -  []  311.15 190.18 90 top
NOREF#4680  -  []  475.18 197.22 90 top
NOREF#4681  -  []  363.55 213.3 0 top
NOREF#4682  -  []  108.49 189.85 0 top
NOREF#4683  -  []  223.95 234.38 90 top
NOREF#4684  -  []  268.57 244.96 0 top
NOREF#4685  -  []  57.46 273.28 0 top
NOREF#4686  -  []  272.78 189.88 90 top
NOREF#4687  -  []  268.27 185.93 0 top
NOREF#4688  -  []  300.66 166.14 0 top
NOREF#4689  -  []  300.66 166.14 0 top
NOREF#4690  -  []  215.71 242 90 top
NOREF#4691  -  []  325.1 268.22 0 top
NOREF#4692  -  []  294.66 192.79 0 top
NOREF#4693  -  []  214.36 243.2 0 top
NOREF#4694  -  []  474.41 132.25 0 top
NOREF#4695  -  []  303.27 175.18 0 top
NOREF#4696  -  []  255.58 243.29 90 top
NOREF#4697  -  []  347.64 242.02 0 top
NOREF#4698  -  []  112.42 200.32 0 top
NOREF#4699  -  []  217.83 211.13 0 top
NOREF#4700  -  []  269.59 246.58 90 top
NOREF#4701  -  []  350.18 251.08 0 top
NOREF#4702  -  []  93.31 194.11 0 top
NOREF#4703  -  []  224.09 231.46 0 top
NOREF#4704  -  []  269.53 238.82 90 top
NOREF#4705  -  []  312.13 183.41 0 top
NOREF#4706  -  []  295.01 242 90 top
NOREF#4707  -  []  317.95 138.2 90 top
NOREF#4708  -  []  302.95 286.63 90 top
NOREF#4709  -  []  343.09 234.38 0 top
NOREF#4710  -  []  273.76 243.65 0 top
NOREF#4711  -  []  271.55 285.02 0 top
NOREF#4712  -  []  311.11 293.99 90 top
NOREF#4713  -  []  231.49 242.62 0 top
NOREF#4714  -  []  264.41 171.76 90 top
NOREF#4715  -  []  108.65 132.25 0 top
NOREF#4716  -  []  476.65 186.2 0 top
NOREF#4717  -  []  345.68 185.29 90 top
NOREF#4718  -  []  486.4 251.7 0 top
NOREF#4719  -  []  535.51 218.36 90 top
NOREF#4720  -  []  302.96 165.63 90 top
NOREF#4721  -  []  235.08 243 0 top
NOREF#4722  -  []  275.91 223.58 0 top
NOREF#4723  -  []  341.29 292.89 90 top
NOREF#4724  -  []  263.95 172.9 90 top
NOREF#4725  -  []  227.63 187.88 0 top
NOREF#4726  -  []  300.66 226.14 0 top
NOREF#4727  -  []  348.57 244.96 0 top
NOREF#4728  -  []  254.68 253.86 90 top
NOREF#4729  -  []  236.11 234.13 90 top
NOREF#4730  -  []  334.31 253.56 90 top
NOREF#4731  -  []  346.45 147.01 90 top
NOREF#4732  -  []  310.54 240.4 0 top
NOREF#4733  -  []  233.11 190.18 90 top
NOREF#4734  -  []  103.59 246.5 90 top
NOREF#4735  -  []  266.54 133.3 90 top
NOREF#4736  -  []  227.56 144.79 90 top
NOREF#4737  -  []  307.9 238.48 90 top
NOREF#4738  -  []  101.59 219.95 0 top
NOREF#4739  -  []  214.68 253.86 90 top
NOREF#4740  -  []  541.25 164.1 90 top
NOREF#4741  -  []  269.83 269.1 90 top
NOREF#4742  -  []  225.48 233.73 90 top
NOREF#4743  -  []  285.4 272.03 90 top
NOREF#4744  -  []  474.25 221.6 0 top
NOREF#4745  -  []  267.94 241.05 0 top
NOREF#4746  -  []  263.34 286.27 90 top
NOREF#4747  -  []  307.85 138.1 0 top
NOREF#4748  -  []  210.56 180.75 0 top
NOREF#4749  -  []  314.44 141.43 0 top
NOREF#4750  -  []  225.83 145.8 90 top
NOREF#4751  -  []  487.64 173.3 0 top
NOREF#4752  -  []  272.13 183.41 90 top
NOREF#4753  -  []  333.54 239.12 90 top
NOREF#4754  -  []  224.41 171.76 90 top
NOREF#4755  -  []  100.39 154.45 0 top
NOREF#4756  -  []  253.54 239.12 90 top
NOREF#4757  -  []  232.46 182.37 90 top
NOREF#4758  -  []  546.66 209.01 90 top
NOREF#4759  -  []  263.27 288.24 90 top
NOREF#4760  -  []  269.59 186.58 0 top
NOREF#4761  -  []  227.94 241.05 0 top
NOREF#4762  -  []  130.05 258.76 90 top
NOREF#4763  -  []  271.49 242.62 0 top
NOREF#4764  -  []  88.89 180.6 0 top
NOREF#4765  -  []  283.72 211.73 90 top
NOREF#4766  -  []  271.81 239.12 90 top
NOREF#4767  -  []  244.68 214.19 0 top
NOREF#4768  -  []  362.56 269.73 0 top
NOREF#4769  -  []  130.05 284.16 90 top
NOREF#4770  -  []  309.59 245.29 90 top
NOREF#4771  -  []  455.67 274.94 90 top
NOREF#4772  -  []  271.69 209.1 0 top
NOREF#4773  -  []  487.64 172.65 90 top
NOREF#4774  -  []  356.37 267.56 0 top
NOREF#4775  -  []  253.1 238.82 90 top
NOREF#4776  -  []  303.27 173.14 0 top
NOREF#4777  -  []  227.27 246.26 0 top
NOREF#4778  -  []  259.33 256.13 0 top
NOREF#4779  -  []  272.13 183.41 0 top
NOREF#4780  -  []  251.96 253.56 90 top
NOREF#4781  -  []  294.68 253.86 90 top
NOREF#4782  -  []  252.54 243.29 90 top
NOREF#4783  -  []  275.44 254.76 90 top
NOREF#4784  -  []  343.27 173.14 0 top
NOREF#4785  -  []  343.09 233.82 0 top
NOREF#4786  -  []  104.54 249.7 0 top
NOREF#4787  -  []  272.79 183.41 0 top
NOREF#4788  -  []  247.07 208.22 90 top
NOREF#4789  -  []  236.65 267.92 0 top
NOREF#4790  -  []  232.46 240.42 90 top
NOREF#4791  -  []  352.45 180.42 90 top
NOREF#4792  -  []  363.45 211.37 0 top
NOREF#4793  -  []  449.05 186.2 0 top
NOREF#4794  -  []  48.35 266.27 0 top
NOREF#4795  -  []  355.98 242.68 90 top
NOREF#4796  -  []  540.55 192.84 90 top
NOREF#4797  -  []  217.83 218.13 0 top
NOREF#4798  -  []  304.42 175.77 0 top
NOREF#4799  -  []  349.53 184.02 90 top
NOREF#4800  -  []  346.54 134.31 90 top
NOREF#4801  -  []  281.44 250.47 0 top
NOREF#4802  -  []  467.84 172.65 90 top
NOREF#4803  -  []  350.83 242.62 0 top
NOREF#4804  -  []  94.04 249.7 0 top
NOREF#4805  -  []  351.54 244.64 0 top
NOREF#4806  -  []  308.55 178.48 90 top
NOREF#4807  -  []  295.56 240.9 90 top
NOREF#4808  -  []  486.95 253.35 0 top
NOREF#4809  -  []  343.95 174.94 90 top
NOREF#4810  -  []  343.27 233.14 0 top
NOREF#4811  -  []  120.64 180.6 0 top
NOREF#4812  -  []  568.42 147.59 0 top
NOREF#4813  -  []  66.13 266.27 0 top
NOREF#4814  -  []  483.18 192.22 90 top
NOREF#4815  -  []  350.82 241.42 90 top
NOREF#4816  -  []  312.14 191.08 0 top
NOREF#4817  -  []  320.37 135.17 90 top
NOREF#4818  -  []  226.91 144.24 90 top
NOREF#4819  -  []  272.23 230.19 90 top
NOREF#4820  -  []  112.42 168.57 0 top
NOREF#4821  -  []  320.81 218.16 90 top
NOREF#4822  -  []  306.94 264.26 0 top
NOREF#4823  -  []  281.04 135.78 0 top
NOREF#4824  -  []  242.64 267.56 0 top
NOREF#4825  -  []  313.11 250.18 90 top
NOREF#4826  -  []  340.33 189.91 0 top
NOREF#4827  -  []  487.94 172.97 0 top
NOREF#4828  -  []  228.23 242.08 90 top
NOREF#4829  -  []  227.63 247.23 90 top
NOREF#4830  -  []  310.24 240.08 0 top
NOREF#4831  -  []  213.99 242.3 90 top
NOREF#4832  -  []  331.34 243.29 0 top
NOREF#4833  -  []  49.56 268.08 90 top
NOREF#4834  -  []  122.81 253.42 90 top
NOREF#4835  -  []  57.64 254.33 90 top
NOREF#4836  -  []  354.78 242.68 0 top
NOREF#4837  -  []  348.57 245.61 0 top
NOREF#4838  -  []  351.11 292.69 90 top
NOREF#4839  -  []  268.93 240.09 90 top
NOREF#4840  -  []  232.13 241.42 90 top
NOREF#4841  -  []  270.73 226.09 90 top
R135  0-5-S4  [R0402]  238.73 225.44 180 bottom
R136  1M-1-S4  [R0402]  235.73 225.44 0 bottom
R137  0-5-S4  [R0402]  232.73 225.44 0 bottom
R160  38.3-1-S2  [R0201_MINI]  223.52 235.18 0 bottom
R161  38.3-1-S2  [R0201_MINI]  223.52 234.62 0 bottom
R162  4.7K-1-S2  [R0201_MINI]  228.01 234.55 90 bottom
R163  0-5-S2  [R0201_MINI]  223.52 233.14 0 bottom
R164  0-5-S2  [R0201_MINI]  223.52 234.06 0 bottom
R165  0-5-S2  [R0201_MINI]  228.01 233.55 90 bottom
R168  42.2-1-S2  [R0201]  213.99 254.16 90 bottom
R170  42.2-1-S2  [R0201]  213.29 254.16 90 bottom
R172  0-5-S2  [R0201]  214.96 252.79 0 top
R176  42.2-1-S2  [R0201]  211.64 254.16 90 bottom
R178  42.2-1-S2  [R0201]  212.33 254.16 90 bottom
R180  42.2-1-S2  [R0201]  213.99 242.6 90 bottom
R182  42.2-1-S2  [R0201]  213.29 242.6 90 bottom
R200  4.7K-1-S2  [R0201]  102.68 236.47 180 bottom
R201  0-5-S4  [R0402]  87.6 236.47 180 bottom
R202  NC/4.7K-1-S4  [R0402]  87.6 235.2 180 bottom
R203  4.7K-1-S2  [R0201]  102.68 233.93 180 bottom
R204  0-5-S4  [R0402]  106.28 236.47 180 bottom
R205  4.7K-1-S2  [R0201]  122.48 236.47 180 bottom
R206  NC/4.7K-1-S4  [R0402]  106.28 235.2 180 bottom
R207  4.7K-1-S2  [R0201]  122.48 233.93 180 bottom
R331  10K-1-S2-WA  [R0201]  221.62 293.49 270 bottom
R400  249-1-S4  [R0402]  544.81 237.72 0 bottom
R401  523-1-S4  [R0402]  526.26 151.45 90 bottom
R402  1.2K-1-S4  [R0402]  523.51 150.95 0 bottom
R403  0-5-S4  [R0402]  523.49 153.29 180 bottom
R404  0-5-S4  [R0402]  524.31 145.26 180 bottom
R405  4.7K-1-S2  [R0201]  81.69 288.77 90 bottom
R406  4.7K-1-S2  [R0201]  79.4 290.69 0 bottom
R407  4.7K-1-S2  [R0201]  79.4 291.94 0 bottom
R408  4.7K-1-S2  [R0201]  84.4 292.77 180 bottom
R409  4.7K-1-S2  [R0201]  84.4 291.32 180 bottom
R410  4.7K-1-S2  [R0201]  84.4 289.86 180 bottom
R411  4.7K-1-S2  [R0201]  501.52 222.6 90 bottom
R412  4.7K-1-S2  [R0201]  504.24 226.59 180 bottom
R413  4.7K-1-S2  [R0201]  504.24 225.14 180 bottom
R414  4.7K-1-S2  [R0201]  504.24 223.69 180 bottom
R415  4.7K-1-S2  [R0201]  499.23 224.51 0 bottom
R416  4.7K-1-S2  [R0201]  499.23 225.77 0 bottom
R420  4.7K-1-S2  [R0201]  79.4 276.97 0 bottom
R422  4.7K-1-S2  [R0201]  81.69 275.06 90 bottom
R509  0-5-S4  [R0402]  219 264.31 90 bottom
R510  1.2K-1-S4  [R0402]  224.69 265.11 270 bottom
R511  523-1-S4  [R0402]  225.19 262.36 0 bottom
R512  0-5-S8  [R0805]  227.48 266.24 270 bottom
R589  249-1-S4  [R0402]  544.81 236.33 0 bottom
R590  249-1-S4  [R0402]  544.81 234.93 0 bottom
R591  249-1-S4  [R0402]  544.81 233.53 0 bottom
R592  249-1-S4  [R0402]  537.74 236.52 180 bottom
R593  249-1-S4  [R0402]  537.74 235.13 180 bottom
R594  249-1-S4  [R0402]  537.74 233.73 180 bottom
R595  249-1-S4  [R0402]  537.74 232.33 180 bottom
R596  249-1-S4  [R0402]  544.81 223.37 0 bottom
R597  249-1-S4  [R0402]  544.81 221.97 0 bottom
R598  249-1-S4  [R0402]  544.81 220.58 0 bottom
R599  249-1-S4  [R0402]  537.74 223.57 180 bottom
R600  249-1-S4  [R0402]  537.74 222.17 180 bottom
R601  249-1-S4  [R0402]  537.74 220.78 180 bottom
R602  249-1-S4  [R0402]  537.74 219.38 180 bottom
R603  249-1-S4  [R0402]  544.81 224.77 0 bottom
R646  42.2-1-S2  [R0201]  214.68 254.16 90 bottom
R647  42.2-1-S2  [R0201]  215.38 254.16 90 bottom
R648  4.7K-1-S2  [R0201]  79.4 278.23 0 bottom
R649  4.7K-1-S2  [R0201]  84.4 279.05 180 bottom
R650  4.7K-1-S2  [R0201]  84.4 277.6 180 bottom
R652  1M-1-S4  [R0402]  230.85 273.67 90 bottom
R658  4.7K-1-S2  [R0201]  84.4 276.15 180 bottom
R659  10K-1-S2-WA  [R0201]  213.54 250.99 90 top
R661  4.7K-1-S2  [R0201]  212.78 250.99 270 top
R662  0-5-S2  [R0201]  214.96 241.23 0 top
R663  4.7K-1-S2  [R0201]  212.78 239.42 270 top
R664  42.2-1-S2  [R0201]  212.33 242.6 90 bottom
R666  42.2-1-S2  [R0201]  211.64 242.6 90 bottom
R672  10K-1-S2-WA  [R0201]  213.54 239.42 90 top
R709  4.7K-1-S2  [R0201]  84.4 265.34 180 bottom
R710  4.7K-1-S2  [R0201]  84.4 263.88 180 bottom
R711  4.7K-1-S2  [R0201]  79.4 264.51 0 bottom
R712  4.7K-1-S2  [R0201]  81.69 261.34 90 bottom
R713  4.7K-1-S2  [R0201]  79.4 263.26 0 bottom
R714  4.7K-1-S2  [R0201]  84.4 262.43 180 bottom
R751  249-1-S4  [R0402]  544.43 211.43 0 bottom
R752  249-1-S4  [R0402]  537.36 208.84 180 bottom
R753  249-1-S4  [R0402]  544.43 208.64 0 bottom
R754  249-1-S4  [R0402]  537.36 207.44 180 bottom
R755  249-1-S4  [R0402]  544.43 207.24 0 bottom
R756  249-1-S4  [R0402]  537.36 206.04 180 bottom
R757  249-1-S4  [R0402]  537.36 210.24 180 bottom
R758  249-1-S4  [R0402]  544.43 210.04 0 bottom
R759  249-1-S4  [R0402]  544.43 197.34 0 bottom
R766  249-1-S4  [R0402]  544.43 195.94 0 bottom
R849  100-1-S4  [R0402]  238.58 271.17 0 bottom
R923  1M-1-S4  [R0402]  232 273.67 90 bottom
R925  4.7K-1-S2  [R0201]  547.64 235.63 180 bottom
R926  4.7K-1-S2  [R0201]  547.64 238.42 180 bottom
R927  4.7K-1-S2  [R0201]  547.64 237.02 180 bottom
R928  4.7K-1-S2  [R0201]  547.64 234.23 180 bottom
R929  4.7K-1-S2  [R0201]  534.91 233.03 0 bottom
R930  4.7K-1-S2  [R0201]  534.91 234.43 0 bottom
R931  4.7K-1-S2  [R0201]  534.91 231.63 0 bottom
R932  4.7K-1-S2  [R0201]  534.91 235.83 0 bottom
R933  4.7K-1-S2  [R0201]  547.64 222.67 180 bottom
R934  4.7K-1-S2  [R0201]  547.64 224.07 180 bottom
R935  4.7K-1-S2  [R0201]  547.64 221.28 180 bottom
R936  4.7K-1-S2  [R0201]  547.64 225.47 180 bottom
R937  4.7K-1-S2  [R0201]  534.91 220.08 0 bottom
R938  4.7K-1-S2  [R0201]  534.91 221.48 0 bottom
R939  4.7K-1-S2  [R0201]  534.91 218.68 0 bottom
R940  4.7K-1-S2  [R0201]  534.91 222.87 0 bottom
R941  4.7K-1-S2  [R0201]  547.26 209.34 180 bottom
R942  4.7K-1-S2  [R0201]  547.26 210.74 180 bottom
R943  4.7K-1-S2  [R0201]  547.26 207.94 180 bottom
R944  4.7K-1-S2  [R0201]  547.26 212.13 180 bottom
R945  4.7K-1-S2  [R0201]  534.53 206.74 0 bottom
R946  4.7K-1-S2  [R0201]  534.53 208.14 0 bottom
R947  4.7K-1-S2  [R0201]  534.53 205.35 0 bottom
R948  4.7K-1-S2  [R0201]  534.53 209.54 0 bottom
R950  4.7K-1-S2  [R0201]  547.26 196.64 180 bottom
R952  4.7K-1-S2  [R0201]  547.26 198.04 180 bottom
R973  NC/0-5-S4  [R0402]  231.42 272.04 0 bottom
R980  10K-1-S2-WA  [R0201]  233.66 269.4 90 bottom
R981  NC/4.7K-1-S2  [R0201]  229.83 269.4 270 bottom
R982  0-5-S2  [R0201]  229.53 268.44 0 bottom
R983  10K-1-S2-WA  [R0201]  240.81 268.52 90 bottom
R984  NC/4.7K-1-S2  [R0201]  236.97 268.52 270 bottom
R985  0-5-S2  [R0201]  236.67 267.56 0 bottom
R986  10K-1-S2-WA  [R0201]  247.07 268.52 90 bottom
R987  NC/4.7K-1-S2  [R0201]  243.24 268.52 270 bottom
R988  0-5-S2  [R0201]  242.94 267.56 0 bottom
R989  10K-1-S2-WA  [R0201]  247.88 272.33 90 bottom
R990  NC/4.7K-1-S2  [R0201]  244.05 272.33 270 bottom
R991  0-5-S2  [R0201]  243.75 271.37 0 bottom
R1088  42.2-1-S2  [R0201]  214.68 242.6 90 bottom
R1089  42.2-1-S2  [R0201]  215.38 242.6 90 bottom
R1090  240-1-S4  [R0402]  222.76 239.01 180 bottom
R1091  59-1-S4  [R0402]  242.07 224.79 180 bottom
R1093  4.7K-1-S2  [R0201]  501.52 204.44 90 bottom
R1097  4.7K-1-S2  [R0201]  499.23 206.36 0 bottom
RB1  10K-1-S2-WA  [R0201]  212.72 15.11 0 bottom
RB2  10K-1-S2-WA  [R0201]  212.72 13.4 0 bottom
RB501  0-5-S4  [R0402]  452.89 130.81 180 bottom
RB502  0-5-S4  [R0402]  554.49 130.81 180 bottom
RB507  0-5-S4  [R0402]  554.49 298.45 180 bottom
RB508  0-5-S4  [R0402]  452.89 298.45 180 bottom
RB509  0-5-S4  [R0402]  411.48 130.81 180 bottom
RB510  0-5-S4  [R0402]  424.18 288.29 180 bottom
RB511  0-5-S4  [R0402]  170.18 130.81 180 bottom
RB512  0-5-S4  [R0402]  157.48 288.29 0 bottom
RB513  0-5-S4  [R0402]  127.77 130.81 180 bottom
RB514  0-5-S4  [R0402]  109.99 300.99 180 bottom
RB515  0-5-S4  [R0402]  27.17 130.81 180 bottom
RB516  0-5-S4  [R0402]  27.17 298.45 180 bottom
RD1  10K-1-S2-WA  [R0201]  286.56 295.63 270 top
RD2  10K-1-S2-WA  [R0201]  286.56 297.56 90 top
RD3  10K-1-S2-WA  [R0201]  286.56 293.76 90 top
RD4  NC/10K-1-S4  [R0402]  296.42 294.06 0 top
RD5  10K-1-S2-WA  [R0201]  286.56 291.84 270 top
RD6  NC/10K-1-S4  [R0402]  296.42 292.79 0 top
RD7  NC/10K-1-S4  [R0402]  285.17 294.06 0 top
RD8  NC/10K-1-S4  [R0402]  285.17 291.54 0 top
RD9  10K-1-S2-WA  [R0201]  456 277.41 270 top
RD10  10K-1-S2-WA  [R0201]  456 279.33 90 top
RD11  NC/10K-1-S4  [R0402]  454.6 275.84 0 top
RD12  NC/10K-1-S4  [R0402]  465.86 275.84 0 top
RD13  10K-1-S2-WA  [R0201]  457.79 273.15 180 top
RD14  NC/10K-1-S4  [R0402]  465.86 274.57 0 top
RD15  10K-1-S2-WA  [R0201]  456 275.54 90 top
RD16  NC/10K-1-S4  [R0402]  456.13 273.15 0 top
RD19  0-5-S4  [R0402]  285.17 297.86 0 top
RD20  0-5-S4  [R0402]  285.17 295.33 0 top
S1_DPS_SW1  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  43.05 178.44 270 bottom
S1_DPS_SW2  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  64.64 178.44 270 bottom
S1_DPS_SW3  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  43.05 151.76 270 bottom
S1_DPS_SW4  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  64.64 151.76 270 bottom
S1_DPS_SW5  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  64.64 205.1 270 bottom
S1_DPS_SW6  SW-SLIDE-8-S2.54  [SW8X2_2P54MM_16P_SMD]  43.05 205.1 270 bottom
S1_USER_3V3  VTP-2X1  [VTP_2P_100]  99.07 223.1 270 top
S1_VREF_OUT  TP01  [TP_040_T]  224.52 282.62 270 top
S2_USER_3V3  VTP-2X1  [VTP_2P_100]  99.07 191.35 270 top
S2_VREF_OUT  TP01  [TP_040_T]  264.52 282.62 270 top
S3_USER_3V3  VTP-2X1  [VTP_2P_100]  464.83 191.35 270 top
S3_VREF_OUT  TP01  [TP_040_T]  304.52 282.62 270 top
S4_USER_3V3  VTP-2X1  [VTP_2P_100]  464.83 223.1 270 top
S4_VREF_OUT  TP01  [TP_040_T]  344.52 282.62 270 top
S5_USER_3V3  VTP-2X1  [VTP_2P_100]  99.07 159.6 270 top
S5_VREF_OUT  TP01  [TP_040_T]  237.14 146.64 270 top
S6_USER_3V3  VTP-2X1  [VTP_2P_100]  99.07 127.85 270 top
S6_VREF_OUT  TP01  [TP_040_T]  277.14 146.64 270 top
S7_USER_3V3  VTP-2X1  [VTP_2P_100]  464.83 127.85 270 top
S7_VREF_OUT  TP01  [TP_040_T]  317.14 146.64 270 top
S8_USER_3V3  VTP-2X1  [VTP_2P_100]  464.83 159.6 270 top
S8_VREF_OUT  TP01  [TP_040_T]  357.14 146.64 270 top
SA1  SHORT  [DEFAULT_SHORT_SMALL]  225.71 251.64 180 top
SA2  SHORT  [DEFAULT_SHORT_SMALL]  225.71 252.15 180 top
SA7  SHORT  [DEFAULT_SHORT_SMALL]  224.03 245.86 90 top
SA8  SHORT  [DEFAULT_SHORT_SMALL]  225.3 245.86 90 top
SA9  SHORT  [DEFAULT_SHORT_SMALL]  226.07 238 180 top
SA10  SHORT  [DEFAULT_SHORT_SMALL]  226.07 237.49 180 top
SA15  SHORT  [DEFAULT_SHORT_SMALL]  237.49 250.16 90 top
SA16  SHORT  [DEFAULT_SHORT_SMALL]  236.98 250.16 90 top
SA17  SHORT  [DEFAULT_SHORT_SMALL]  233.21 238.53 0 top
SA18  SHORT  [DEFAULT_SHORT_SMALL]  233.21 237.92 0 top
SA19  SHORT  [DEFAULT_SHORT_SMALL]  224.08 243.68 270 top
SA20  SHORT  [DEFAULT_SHORT_SMALL]  223.49 243.68 270 top
SA21  SHORT  [DEFAULT_SHORT_SMALL]  239.27 250.18 90 top
SA22  SHORT  [DEFAULT_SHORT_SMALL]  240.54 250.2 90 top
SA23  SHORT  [DEFAULT_SHORT_SMALL]  233.41 237.52 270 top
SA24  SHORT  [DEFAULT_SHORT_SMALL]  234.06 237.52 270 top
SC1  NC  [C0402_UNBGA_V2]  48.95 250.3 0 bottom
SC2  NC  [C0402_UNBGA_V2]  38.28 250.3 180 bottom
SC3  NC  [C0402_UNBGA_V2]  46.58 254.72 0 bottom
SC4  NC  [C0402_UNBGA_V2]  48.95 248.1 0 bottom
SC5  NC  [C0402_UNBGA_V2]  40.65 254.72 180 bottom
SC6  NC  [C0402_UNBGA_V2]  38.28 248.1 180 bottom
SC7  NC  [C0402_UNBGA_V2]  66.73 250.3 0 bottom
SC8  NC  [C0402_UNBGA_V2]  56.06 250.3 180 bottom
SC9  NC  [C0402_UNBGA_V2]  64.36 254.72 0 bottom
SC10  NC  [C0402_UNBGA_V2]  66.73 248.1 0 bottom
SC11  NC  [C0402_UNBGA_V2]  58.43 254.72 180 bottom
SC12  NC  [C0402_UNBGA_V2]  56.06 248.1 180 bottom
SC13  NC  [C0402_UNBGA_V2]  64.18 272.89 0 bottom
SC14  NC  [C0402_UNBGA_V2]  66.55 268.47 0 bottom
SC15  NC  [C0402_UNBGA_V2]  55.88 268.47 180 bottom
SC16  NC  [C0402_UNBGA_V2]  58.25 272.89 180 bottom
SC17  NC  [C0402_UNBGA_V2]  66.55 266.27 0 bottom
SC18  NC  [C0402_UNBGA_V2]  55.88 266.27 180 bottom
SC19  NC  [C0402_UNBGA_V2]  46.4 272.89 0 bottom
SC20  NC  [C0402_UNBGA_V2]  48.77 268.47 0 bottom
SC21  NC  [C0402_UNBGA_V2]  38.1 268.47 180 bottom
SC22  NC  [C0402_UNBGA_V2]  40.47 272.89 180 bottom
SC23  NC  [C0402_UNBGA_V2]  48.77 266.27 0 bottom
SC24  NC  [C0402_UNBGA_V2]  38.1 266.27 180 bottom
SC25  NC  [C0402_UNBGA_V2]  566.84 171.11 0 bottom
SC26  NC  [C0402_UNBGA_V2]  569.21 166.69 0 bottom
SC27  NC  [C0402_UNBGA_V2]  558.55 166.69 180 bottom
SC28  NC  [C0402_UNBGA_V2]  560.92 171.11 180 bottom
SC29  NC  [C0402_UNBGA_V2]  569.21 164.49 0 bottom
SC30  NC  [C0402_UNBGA_V2]  558.55 164.49 180 bottom
SC31  NC  [C0402_UNBGA_V2]  550.33 171.11 0 bottom
SC32  NC  [C0402_UNBGA_V2]  552.7 166.69 0 bottom
SC33  NC  [C0402_UNBGA_V2]  542.04 166.69 180 bottom
SC34  NC  [C0402_UNBGA_V2]  544.41 171.11 180 bottom
SC35  NC  [C0402_UNBGA_V2]  552.7 164.49 0 bottom
SC36  NC  [C0402_UNBGA_V2]  542.04 164.49 180 bottom
SC37  NC  [C0402_UNBGA_V2]  550.33 154.6 0 bottom
SC38  NC  [C0402_UNBGA_V2]  552.7 150.18 0 bottom
SC39  NC  [C0402_UNBGA_V2]  542.04 150.18 180 bottom
SC40  NC  [C0402_UNBGA_V2]  544.41 154.6 180 bottom
SC41  NC  [C0402_UNBGA_V2]  552.7 147.98 0 bottom
SC42  NC  [C0402_UNBGA_V2]  542.04 147.98 180 bottom
SC43  NC  [C0402_UNBGA_V2]  566.84 154.6 0 bottom
SC44  NC  [C0402_UNBGA_V2]  569.21 150.18 0 bottom
SC45  NC  [C0402_UNBGA_V2]  558.55 150.18 180 bottom
SC46  NC  [C0402_UNBGA_V2]  560.92 154.6 180 bottom
SC47  NC  [C0402_UNBGA_V2]  569.21 147.98 0 bottom
SC48  NC  [C0402_UNBGA_V2]  558.55 147.98 180 bottom
SCREW1  V93KMFHOLE  [PG_VG93K_F_FULLOUTLINE]  290.83 214.63 0 top
SITE1  SI6D50-BGA234-11X11  [SK_BGA11X11_234P_0P65MM_JG]  230.83 244.63 0 top
SITE2  SI6D50-BGA234-11X11  [SK_BGA11X11_234P_0P65MM_JG]  270.83 244.63 0 top
SITE3  SI6D50-BGA234-11X11  [SK_BGA11X11_234P_0P65MM_JG]  310.83 244.63 0 top
SITE4  SI6D50-BGA234-11X11  [SK_BGA11X11_234P_0P65MM_JG]  350.83 244.63 0 top
SITE5  SI6D50-BGA234-11X11  [SK_BGA11X11_234P_0P65MM_JG]  230.83 184.63 0 top
SITE6  SI6D50-BGA234-11X11  [SK_BGA11X11_234P_0P65MM_JG]  270.83 184.63 0 top
SITE7  SI6D50-BGA234-11X11  [SK_BGA11X11_234P_0P65MM_JG]  310.83 184.63 0 top
SITE8  SI6D50-BGA234-11X11  [SK_BGA11X11_234P_0P65MM_JG]  350.83 184.63 0 top
SK1  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  43.62 248.5 270 bottom
SK2  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  61.4 248.5 270 bottom
SK3  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  61.22 266.67 270 bottom
SK4  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  43.44 266.67 270 bottom
SK5  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  563.88 164.89 270 bottom
SK6  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  547.37 164.89 270 bottom
SK7  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  547.37 148.38 270 bottom
SK8  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  563.88 148.38 270 bottom
SR1  0-5-S4  [R0402]  38.21 251.42 0 bottom
SR2  0-5-S4  [R0402]  49.03 251.42 180 bottom
SR3  0-5-S4  [R0402]  38.21 246.97 180 bottom
SR4  0-5-S4  [R0402]  40.58 255.86 180 bottom
SR5  0-5-S4  [R0402]  49.03 246.97 0 bottom
SR6  0-5-S4  [R0402]  46.66 255.86 0 bottom
SR7  0-5-S4  [R0402]  55.99 251.42 0 bottom
SR8  0-5-S4  [R0402]  66.81 251.42 180 bottom
SR9  0-5-S4  [R0402]  55.99 246.97 180 bottom
SR10  0-5-S4  [R0402]  58.36 255.86 180 bottom
SR11  0-5-S4  [R0402]  66.81 246.97 0 bottom
SR12  0-5-S4  [R0402]  64.44 255.86 0 bottom
SR13  0-5-S4  [R0402]  66.63 269.59 180 bottom
SR14  0-5-S4  [R0402]  66.63 265.14 0 bottom
SR15  0-5-S4  [R0402]  64.26 274.03 0 bottom
SR16  0-5-S4  [R0402]  55.81 269.59 0 bottom
SR17  0-5-S4  [R0402]  55.81 265.14 180 bottom
SR18  0-5-S4  [R0402]  58.18 274.03 180 bottom
SR19  0-5-S4  [R0402]  48.85 269.59 180 bottom
SR20  0-5-S4  [R0402]  48.85 265.14 0 bottom
SR21  0-5-S4  [R0402]  46.48 274.03 0 bottom
SR22  0-5-S4  [R0402]  38.03 269.59 0 bottom
SR23  0-5-S4  [R0402]  38.03 265.14 180 bottom
SR24  0-5-S4  [R0402]  40.4 274.03 180 bottom
SR25  0-5-S4  [R0402]  569.29 167.81 180 bottom
SR26  0-5-S4  [R0402]  569.29 163.37 0 bottom
SR27  0-5-S4  [R0402]  566.92 172.26 0 bottom
SR28  0-5-S4  [R0402]  558.47 167.81 0 bottom
SR29  0-5-S4  [R0402]  558.47 163.37 180 bottom
SR30  0-5-S4  [R0402]  560.84 172.26 180 bottom
SR31  0-5-S4  [R0402]  552.78 167.81 180 bottom
SR32  0-5-S4  [R0402]  552.78 163.37 0 bottom
SR33  0-5-S4  [R0402]  550.41 172.26 0 bottom
SR34  0-5-S4  [R0402]  541.96 167.81 0 bottom
SR35  0-5-S4  [R0402]  541.96 163.37 180 bottom
SR36  0-5-S4  [R0402]  544.33 172.26 180 bottom
SR37  0-5-S4  [R0402]  552.78 151.3 180 bottom
SR38  0-5-S4  [R0402]  552.78 146.86 0 bottom
SR39  0-5-S4  [R0402]  550.41 155.75 0 bottom
SR40  0-5-S4  [R0402]  541.96 151.3 0 bottom
SR41  0-5-S4  [R0402]  541.96 146.86 180 bottom
SR42  0-5-S4  [R0402]  544.33 155.75 180 bottom
SR43  0-5-S4  [R0402]  569.29 151.3 180 bottom
SR44  0-5-S4  [R0402]  569.29 146.86 0 bottom
SR45  0-5-S4  [R0402]  566.92 155.75 0 bottom
SR46  0-5-S4  [R0402]  558.47 151.3 0 bottom
SR47  0-5-S4  [R0402]  558.47 146.86 180 bottom
SR48  0-5-S4  [R0402]  560.84 155.75 180 bottom
SSI6D50D  REF-CODE-CHIP  [CHIP_CODE]  107.25 430.51 0 top
STP1  TP01  [TP_040_T]  37.71 252.31 0 top
STP2  TP01  [TP_040_T]  49.53 252.31 0 top
STP3  TP01  [TP_040_T]  37.71 246.08 0 top
STP4  TP01  [TP_040_T]  40.08 256.75 0 top
STP5  TP01  [TP_040_T]  49.53 246.08 0 top
STP6  TP01  [TP_040_T]  47.16 256.75 0 top
STP7  TP01  [TP_040_T]  55.49 252.31 0 top
STP8  TP01  [TP_040_T]  67.31 252.31 0 top
STP9  TP01  [TP_040_T]  55.49 246.08 0 top
STP10  TP01  [TP_040_T]  57.86 256.75 0 top
STP11  TP01  [TP_040_T]  67.31 246.08 0 top
STP12  TP01  [TP_040_T]  64.94 256.75 0 top
STP13  TP01  [TP_040_T]  64.76 274.92 0 top
STP14  TP01  [TP_040_T]  67.13 264.25 0 top
STP15  TP01  [TP_040_T]  55.31 264.25 0 top
STP16  TP01  [TP_040_T]  57.68 274.92 0 top
STP17  TP01  [TP_040_T]  55.31 270.48 0 top
STP18  TP01  [TP_040_T]  67.13 270.48 0 top
STP19  TP01  [TP_040_T]  46.98 274.92 0 top
STP20  TP01  [TP_040_T]  49.35 264.25 0 top
STP21  TP01  [TP_040_T]  37.53 264.25 0 top
STP22  TP01  [TP_040_T]  39.9 274.92 0 top
STP23  TP01  [TP_040_T]  37.53 270.48 0 top
STP24  TP01  [TP_040_T]  49.35 270.48 0 top
STP25  TP01  [TP_040_T]  567.42 173.14 0 top
STP26  TP01  [TP_040_T]  569.79 162.48 0 top
STP27  TP01  [TP_040_T]  557.97 162.48 0 top
STP28  TP01  [TP_040_T]  560.34 173.14 0 top
STP29  TP01  [TP_040_T]  557.97 168.7 0 top
STP30  TP01  [TP_040_T]  569.79 168.7 0 top
STP31  TP01  [TP_040_T]  550.91 173.14 0 top
STP32  TP01  [TP_040_T]  553.28 162.48 0 top
STP33  TP01  [TP_040_T]  541.46 162.48 0 top
STP34  TP01  [TP_040_T]  543.83 173.14 0 top
STP35  TP01  [TP_040_T]  541.46 168.7 0 top
STP36  TP01  [TP_040_T]  553.28 168.7 0 top
STP37  TP01  [TP_040_T]  550.91 156.63 0 top
STP38  TP01  [TP_040_T]  553.28 145.97 0 top
STP39  TP01  [TP_040_T]  541.46 145.97 0 top
STP40  TP01  [TP_040_T]  541.46 152.19 0 top
STP41  TP01  [TP_040_T]  543.83 156.63 0 top
STP42  TP01  [TP_040_T]  553.28 152.19 0 top
STP43  TP01  [TP_040_T]  567.42 156.63 0 top
STP44  TP01  [TP_040_T]  569.79 145.97 0 top
STP45  TP01  [TP_040_T]  557.97 145.97 0 top
STP46  TP01  [TP_040_T]  557.97 152.19 0 top
STP47  TP01  [TP_040_T]  560.34 156.63 0 top
STP48  TP01  [TP_040_T]  569.79 152.19 0 top
SW5  SW-SLIDE-8-S2.54-TRI-EN  [SW_8PX1_2P54MM_SMD]  119.31 264.16 270 top
SW10  SW-SLIDE-8-S2.54-TRI-EN  [SW_8PX1_2P54MM_SMD]  119.31 289.56 270 top
TP_DPS1  TP01  [TP_040_T]  204.47 240.03 0 top
TP_DPS2  TP01  [TP_040_T]  233.93 277.62 0 top
TP_DPS3  TP01  [TP_040_T]  215.42 281.69 0 top
TP_DPS4  TP01  [TP_040_T]  243.87 277.62 0 top
TP_DPS5  TP01  [TP_040_T]  221.51 277.62 0 top
TP_DPS6  TP01  [TP_040_T]  243.87 281.69 0 top
TP_DPS7  TP01  [TP_040_T]  215.42 277.62 0 top
TP_DPS8  TP01  [TP_040_T]  227.6 277.62 180 top
TP_MUX_3V3  TP01  [TP_040_T]  215.65 269.49 180 top
U14  ADT7410TRZ-SO8  [SO8_244X127MM]  291.15 294.7 0 top
U15  ADT7410TRZ-SO8  [SO8_244X127MM]  460.58 276.47 0 top
U17  XC6203E-0.4A-33-SOT89  [SOT89]  104.66 227.24 180 bottom
U18  SK-SO8-1.27-DEDIPROG-V2  [SK_SO8_1P27MM_DEDIPROG_V2]  95.31 234.57 270 bottom
U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  114.42 234.57 270 bottom
U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  226.08 234.5 90 bottom
U70  74HC244BQ-DHVQFN20  [VQFN2P6X4P6_20P_0P5MM_EP]  541.19 235.38 180 bottom
U71  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  524.38 148.11 270 bottom
U72  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  88.54 292.21 270 bottom
U73  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  82.07 291.32 90 bottom
U74  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  75.59 291.44 90 bottom
U75  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  508.38 226.03 270 bottom
U76  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  501.9 225.14 90 bottom
U77  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  495.42 225.27 90 bottom
U79  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  82.07 277.6 90 bottom
U80  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  75.59 277.73 90 bottom
U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  221.84 264.24 180 bottom
U403  74HC244BQ-DHVQFN20  [VQFN2P6X4P6_20P_0P5MM_EP]  541.19 222.42 180 bottom
U405  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  88.54 278.49 270 bottom
U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  213.16 249.72 180 bottom
U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  213.16 238.15 180 bottom
U413  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  75.59 264.01 90 bottom
U414  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  82.07 263.88 90 bottom
U415  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  88.54 264.77 270 bottom
U434  74HC244BQ-DHVQFN20  [VQFN2P6X4P6_20P_0P5MM_EP]  540.8 209.09 180 bottom
U435  74HC244BQ-DHVQFN20  [VQFN2P6X4P6_20P_0P5MM_EP]  540.8 194.99 180 bottom
U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  231.94 269.73 270 bottom
U450  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  239.08 268.86 270 bottom
U451  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  245.35 268.86 270 bottom
U452  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  246.15 272.67 270 bottom
U453  ULN2003AIPW-TSSOP16  [TSSOP16_228X065MM]  495.43 206.88 90 bottom
U454  74HC04BQ-DHVQFN14  [SO14_0P5_14P_74HC14]  501.9 206.98 90 bottom
UB1  AT24C04N-SO8  [SO8_206X050]  218.95 15.49 180 bottom
UBIT_3V3_UP  TP01  [TP_040_T]  522.78 153.29 270 top
UNK2BD9  BD120-1.5A-S4-MU  [FB0402]  264.66 243.83 270 bottom
UNK2BD21  BD120-1.5A-S4-MU  [FB0402]  262.95 232.36 0 bottom
UNK2BD1728  BD120-1.5A-S4-MU  [FB0402]  269.83 271.82 270 bottom
UNK2BD1729  BD120-1.5A-S4-MU  [FB0402]  276.97 270.94 270 bottom
UNK2BDB5  BD120-1.5A-S4-MU  [FB0402]  251.03 246.46 0 bottom
UNK2BDB6  BD120-1.5A-S4-MU  [FB0402]  251.03 234.89 0 bottom
UNK2C262  0.1U-16-X7S-S2-MU  [C0201]  264.41 232.06 270 bottom
UNK2C264  NC/10U-16-X7R-S8-SS  [C0805]  267.48 269.95 90 bottom
UNK2C267  33P-50-N-S2-MU  [C0201]  276.23 224.18 270 bottom
UNK2C268  33P-50-N-S2-MU  [C0201]  275.23 224.18 270 bottom
UNK2C270  NC/10U-16-X7R-S8-SS  [C0805]  264.95 259 0 bottom
UNK2C271  12P-50-N-S4-MU  [C0402]  272.95 267.19 180 bottom
UNK2C272  12P-50-N-S4-MU  [C0402]  270.93 267.19 0 bottom
UNK2C278  1U-10-X7S-S4-TDK  [C0402]  272.87 289.3 0 bottom
UNK2C279  1U-10-X7S-S4-TDK  [C0402]  272.87 288.11 0 bottom
UNK2C280  0.1U-16-X-S4-MU  [C0402]  272.87 286.91 0 bottom
UNK2C281  0.1U-16-X-S4-MU  [C0402]  272.87 285.72 0 bottom
UNK2C282  1U-10-X7S-S4-TDK  [C0402]  278.7 282.67 270 bottom
UNK2C283  0.1U-16-X-S4-MU  [C0402]  277.54 282.67 270 bottom
UNK2C284  1U-10-X7S-S4-TDK  [C0402]  277.62 294.04 90 bottom
UNK2C285  0.1U-16-X-S4-MU  [C0402]  278.81 294.04 90 bottom
UNK2C286  0.1U-16-X-S4-MU  [C0402]  273.82 293.54 180 bottom
UNK2C288  1000P-50-X7R-S2-MU  [C0201]  273.49 291.76 270 bottom
UNK2C289  0.1U-16-X-S4-MU  [C0402]  271.21 291 270 bottom
UNK2C290  NC/0.1U-16-X7R-S4-TY  [C0402]  264.35 292.22 180 bottom
UNK2C298  0.1U-16-X7S-S2-MU  [C0201]  262.95 288.84 90 bottom
UNK2C299  0.1U-16-X7S-S2-MU  [C0201]  260.02 293.16 180 bottom
UNK2C300  0.1U-16-X-S4-MU  [C0402]  260.67 287.06 270 bottom
UNK2C301  1U-10-X7S-S4-TDK  [C0402]  259.51 287.06 270 bottom
UNK2C302  10P-50-N-S2-MU  [C0201]  254.98 243.61 0 bottom
UNK2C309  10P-50-N-S2-MU  [C0201]  254.98 255.18 0 bottom
UNK2C310  10P-50-N-S2-MU  [C0201]  253.69 255.18 180 bottom
UNK2C318  10P-50-N-S2-MU  [C0201]  251.94 255.18 0 bottom
UNK2C320  10P-50-N-S2-MU  [C0201]  253.69 243.61 180 bottom
UNK2C332  2.2U-16-X7R-S6-TY  [C0603]  109.1 194.9 270 bottom
UNK2C333  0.1U-16-X-S4-MU  [C0402]  107.7 195.08 270 bottom
UNK2C334  10U-16-X7R-S8-SS  [C0805]  100.08 194.78 90 bottom
UNK2C335  0.1U-16-X-S4-MU  [C0402]  101.74 194.6 90 bottom
UNK2C336  4.7U-25-X7R-S8-TY  [C0805]  87.58 208.54 270 bottom
UNK2C337  0.1U-16-X-S4-MU  [C0402]  87.6 205.99 180 bottom
UNK2C338  4.7U-25-X7R-S8-TY  [C0805]  106 208.54 270 bottom
UNK2C339  0.1U-16-X-S4-MU  [C0402]  106.03 205.99 180 bottom
UNK2C475  4.7U-6.3-X-S4-MU  [C0402]  265.86 265.11 270 bottom
UNK2C476  1U-10-X7S-S4-TDK  [C0402]  259 268.25 90 bottom
UNK2C477  10U-25-X-S6-MU  [C0603]  260.32 268.76 90 bottom
UNK2C478  22U-16-X5R-SA-SS  [C1206]  263.32 268.5 0 bottom
UNK2C922  0.1U-16-X-S4-MU  [C0402]  253.16 246.46 0 bottom
UNK2C923  0.1U-16-X-S4-MU  [C0402]  253.16 234.89 0 bottom
UNK2C924  10P-50-N-S2-MU  [C0201]  251.94 243.61 0 bottom
UNK2C1066  0.01U-10-X7R-S2-YA  [C0201]  284.98 274.19 0 bottom
UNK2C1067  0.01U-10-X7R-S2-YA  [C0201]  286.33 274.19 180 bottom
UNK2C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  269.58 270.27 180 bottom
UNK2C1077  0.1U-16-X7S-S2-MU  [C0201_MINI]  276.72 269.49 180 bottom
UNK2C1080  0.1U-16-X7S-S2-MU  [C0201_MINI]  282.99 269.49 180 bottom
UNK2C1081  0.1U-16-X7S-S2-MU  [C0201_MINI]  283.8 273.3 180 bottom
UNK2CA1  0.1U-16-X-S4-MU  [C0402]  214.86 295.91 0 bottom
UNK2CA2  10U-25-X7R-SA  [C1206]  214.86 297.94 0 bottom
UNK2CA7  10U-25-X7R-SA  [C1206]  285.12 281.69 0 bottom
UNK2CA8  0.1U-16-X-S4-MU  [C0402]  285.12 279.65 0 bottom
UNK2CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  206.72 293.29 0 bottom
UNK2CA20  10U-25-X7R-SA  [C1206]  256.67 281.69 0 bottom
UNK2CA21  0.1U-16-X-S4-MU  [C0402]  256.67 279.65 0 bottom
UNK2CA22  10U-25-X7R-SA  [C1206]  262.76 277.62 0 bottom
UNK2CA23  0.1U-16-X-S4-MU  [C0402]  262.76 275.59 0 bottom
UNK2CA24  10U-25-X7R-SA  [C1206]  256.67 277.62 0 bottom
UNK2CA25  0.1U-16-X-S4-MU  [C0402]  256.67 275.59 0 bottom
UNK2CA26  10U-25-X7R-SA  [C1206]  275.18 277.62 0 bottom
UNK2CA27  0.1U-16-X-S4-MU  [C0402]  275.18 275.59 0 bottom
UNK2CA34  10U-25-X7R-SA  [C1206]  285.12 277.62 0 bottom
UNK2CA35  0.1U-16-X-S4-MU  [C0402]  285.12 275.59 0 bottom
UNK2CA36  0.1U-16-X-S4-MU  [C0402]  268.85 275.59 0 bottom
UNK2CA37  10U-25-X7R-SA  [C1206]  268.85 277.62 0 bottom
UNK2CC1  0.1U-16-X7S-S2-MU  [C0201]  270.19 246.91 180 bottom
UNK2CC2  0.1U-16-X7S-S2-MU  [C0201]  270.5 250.48 90 bottom
UNK2CC3  0.1U-16-X7S-S2-MU  [C0201]  268.87 245.61 180 bottom
UNK2CC4  0.1U-16-X7S-S2-MU  [C0201]  270.19 246.26 180 bottom
UNK2CC5  0.1U-16-X7S-S2-MU  [C0201]  271.16 246.56 90 bottom
UNK2CC6  0.1U-16-X7S-S2-MU  [C0201]  268.87 244.96 180 bottom
UNK2CC7  0.1U-16-X7S-S2-MU  [C0201]  272.14 244.96 0 bottom
UNK2CC8  0.1U-16-X7S-S2-MU  [C0201]  270.5 243.97 270 bottom
UNK2CC9  0.1U-16-X7S-S2-MU  [C0201]  271.16 243.97 270 bottom
UNK2CC12  0.1U-16-X7S-S2-MU  [C0201]  269.85 244.62 270 bottom
UNK2CC13  0.1U-16-X7S-S2-MU  [C0201]  268.24 241.05 180 bottom
UNK2CC14  0.1U-16-X7S-S2-MU  [C0201]  271.46 245.61 0 bottom
UNK2CC15  0.1U-16-X7S-S2-MU  [C0201]  270.19 245.61 180 bottom
UNK2CC16  0.1U-16-X7S-S2-MU  [C0201]  270.84 244.96 180 bottom
UNK2CC70  0.1U-16-X7S-S2-MU  [C0201]  272.46 242.67 270 bottom
UNK2CC71  0.1U-16-X7S-S2-MU  [C0201]  275.38 243 0 bottom
UNK2CC73  0.1U-16-X7S-S2-MU  [C0201]  267.9 242.68 90 bottom
UNK2CC84  0.1U-16-X7S-S2-MU  [C0201]  273.11 250.48 90 bottom
UNK2CC85  0.1U-16-X7S-S2-MU  [C0201]  271.15 250.48 90 bottom
UNK2CC86  0.1U-16-X7S-S2-MU  [C0201]  272.46 250.48 90 bottom
UNK2CC87  0.1U-16-X7S-S2-MU  [C0201]  272.14 246.26 180 bottom
UNK2CC88  0.1U-16-X7S-S2-MU  [C0201]  273.11 244 270 bottom
UNK2CC89  0.1U-16-X7S-S2-MU  [C0201]  267.9 244.66 270 bottom
UNK2CC90  0.1U-16-X7S-S2-MU  [C0201]  271.8 250.48 90 bottom
UNK2CC91  0.1U-16-X7S-S2-MU  [C0201]  274.06 243.65 0 bottom
UNK2CC92  0.1U-16-X7S-S2-MU  [C0201]  272.45 244 270 bottom
UNK2CC96  0.1U-16-X7S-S2-MU  [C0201]  271.51 247.56 180 bottom
UNK2CC101  0.1U-16-X7S-S2-MU  [C0201]  270.84 240.4 0 bottom
UNK2CC103  0.1U-16-X7S-S2-MU  [C0201]  271.81 242.02 90 bottom
UNK2CC105  0.1U-16-X7S-S2-MU  [C0201]  272.46 240.72 270 bottom
UNK2CC107  0.1U-16-X7S-S2-MU  [C0201]  272.76 241.7 0 bottom
UNK2CC112  0.1U-16-X7S-S2-MU  [C0201]  275.06 250.48 90 bottom
UNK2CC130  0.1U-16-X7S-S2-MU  [C0201]  268.24 241.7 180 bottom
UNK2CC133  1U-6.3-X7T-S2-MU  [C0201]  267.25 238.78 270 bottom
UNK2CC134  NC/0.1U-10-X7R-S2-MU  [C0201]  267.9 238.78 270 bottom
UNK2CC182  0.1U-16-X7S-S2-MU  [C0201]  266.61 250.48 90 bottom
UNK2CC194  0.1U-16-X7S-S2-MU  [C0201]  271.49 243 180 bottom
UNK2CC202  0.1U-16-X7S-S2-MU  [C0201]  266.28 245.61 180 bottom
UNK2CC203  0.1U-16-X7S-S2-MU  [C0201]  269.85 239.42 270 bottom
UNK2CC204  0.1U-16-X7S-S2-MU  [C0201]  270.51 239.42 270 bottom
UNK2CC205  0.1U-16-X7S-S2-MU  [C0201]  271.16 239.42 270 bottom
UNK2CC208  0.1U-16-X7S-S2-MU  [C0201]  267.57 246.26 180 bottom
UNK2CC209  0.1U-16-X7S-S2-MU  [C0201]  268.23 247.56 180 bottom
UNK2CC210  0.1U-16-X7S-S2-MU  [C0201]  269.53 240.41 180 bottom
UNK2CC211  0.1U-16-X7S-S2-MU  [C0201]  270.5 242.02 90 bottom
UNK2CC212  0.1U-16-X7S-S2-MU  [C0201]  269.53 241.06 180 bottom
UNK2CC213  0.1U-16-X7S-S2-MU  [C0201]  271.16 242.02 90 bottom
UNK2CC215  0.1U-16-X7S-S2-MU  [C0201]  271.81 239.42 90 bottom
UNK2CC216  0.1U-16-X7S-S2-MU  [C0201]  268.55 238.78 270 bottom
UNK2K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  119.04 216.35 90 bottom
UNK2K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  112.69 216.35 90 bottom
UNK2K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  106.34 216.35 90 bottom
UNK2K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  99.99 216.35 90 bottom
UNK2K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  93.64 216.35 90 bottom
UNK2K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  87.29 216.35 90 bottom
UNK2K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  271.94 258.56 90 bottom
UNK2K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  275.73 231.79 270 bottom
UNK2K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  176.53 269.24 90 bottom
UNK2K39  UA2-5NE-A-V3  [RL_NECUA2_5V_V3]  264.66 224.54 180 bottom
UNK2K96  EC2-5NJ  [RL_NECEC2_10P_5V]  205.22 279.19 270 bottom
UNK2K107  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  176.53 281.43 90 bottom
