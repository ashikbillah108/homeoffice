# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UNK2K113  MFS-E1T05G-A  [RL_MFS-E1T-G_5V]  285.11 221.36 0 bottom
UNK2MBD1  BD120-1.5A-S4-MU  [FB0402]  262.95 290.49 270 bottom
UNK2MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  265.87 284.52 180 bottom
UNK2MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  265.87 289.86 180 bottom
UNK2MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  265.87 281.98 180 bottom
UNK2MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  265.87 287.19 180 bottom
UNK2MR1  1M-1-S4  [R0402_UNBGA_V2]  276.22 282.67 270 bottom
UNK2MR2  1K-0.01-S4  [R0402_UNBGA_V2]  275.91 293.54 180 bottom
UNK2MR3  1K-0.01-S4  [R0402_UNBGA_V2]  273.82 294.56 180 bottom
UNK2MR4  1K-0.01-S4  [R0402_UNBGA_V2]  273.82 295.57 180 bottom
UNK2MR5  1K-0.01-S4  [R0402_UNBGA_V2]  275.91 295.57 0 bottom
UNK2MR6  1K-0.01-S4  [R0402_UNBGA_V2]  275.91 294.56 0 bottom
UNK2MR7  332K-1-S4  [R0402_UNBGA_V2]  275.21 281.82 90 bottom
UNK2MR8  1K-0.01-S4  [R0402_UNBGA_V2]  264.35 295.57 180 bottom
UNK2MR9  499-0.1-S4  [R0402]  264.35 294.46 180 bottom
UNK2MR10  0-5-S4  [R0402]  264.35 293.34 0 bottom
UNK2MR11  750-1-S4  [R0402]  269.3 285.16 180 bottom
UNK2MR12  360-1-S6  [R0603]  269.68 283.89 180 bottom
UNK2MR13  750-1-S4  [R0402]  269.3 290.49 180 bottom
UNK2MR14  1.2K-1-S4  [R0402]  269.05 282.62 0 bottom
UNK2MR15  360-1-S6  [R0603]  269.68 289.22 180 bottom
UNK2MR16  750-1-S4  [R0402]  269.3 287.83 180 bottom
UNK2MR17  360-1-S6  [R0603]  269.68 286.56 180 bottom
UNK2MR18  11K-0.1-S4  [R0402]  261.81 287.06 270 bottom
UNK2MR19  1K-0.01-S4  [R0402_UNBGA_V2]  262.95 287.06 90 bottom
UNK2MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  273.15 283.82 90 bottom
UNK2MU2  KSMT004-SO8  [SO8_244X127MM]  278.06 288.21 90 bottom
UNK2MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  268.92 293.67 180 bottom
UNK2MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  260.67 290.49 0 bottom
UNK2R135  0-5-S4  [R0402]  278.73 225.44 180 bottom
UNK2R136  1M-1-S4  [R0402]  275.73 225.44 0 bottom
UNK2R137  0-5-S4  [R0402]  272.73 225.44 0 bottom
UNK2R160  38.3-1-S2  [R0201_MINI]  263.52 235.18 0 bottom
UNK2R161  38.3-1-S2  [R0201_MINI]  263.52 234.62 0 bottom
UNK2R162  4.7K-1-S2  [R0201_MINI]  268.01 234.55 90 bottom
UNK2R163  0-5-S2  [R0201_MINI]  263.52 233.14 0 bottom
UNK2R164  0-5-S2  [R0201_MINI]  263.52 234.06 0 bottom
UNK2R165  0-5-S2  [R0201_MINI]  268.01 233.55 90 bottom
UNK2R168  42.2-1-S2  [R0201]  253.99 254.16 90 bottom
UNK2R170  42.2-1-S2  [R0201]  253.29 254.16 90 bottom
UNK2R172  0-5-S2  [R0201]  254.96 252.79 0 top
UNK2R176  42.2-1-S2  [R0201]  251.64 254.16 90 bottom
UNK2R178  42.2-1-S2  [R0201]  252.33 254.16 90 bottom
UNK2R180  42.2-1-S2  [R0201]  253.99 242.6 90 bottom
UNK2R182  42.2-1-S2  [R0201]  253.29 242.6 90 bottom
UNK2R200  4.7K-1-S2  [R0201]  102.68 204.72 180 bottom
UNK2R201  0-5-S4  [R0402]  87.6 204.72 180 bottom
UNK2R202  NC/4.7K-1-S4  [R0402]  87.6 203.45 180 bottom
UNK2R203  4.7K-1-S2  [R0201]  102.68 202.18 180 bottom
UNK2R204  0-5-S4  [R0402]  106.28 204.72 180 bottom
UNK2R205  4.7K-1-S2  [R0201]  122.48 204.72 180 bottom
UNK2R206  NC/4.7K-1-S4  [R0402]  106.28 203.45 180 bottom
UNK2R207  4.7K-1-S2  [R0201]  122.48 202.18 180 bottom
UNK2R331  10K-1-S2-WA  [R0201]  261.62 293.49 270 bottom
UNK2R509  0-5-S4  [R0402]  259 264.31 90 bottom
UNK2R510  1.2K-1-S4  [R0402]  264.69 265.11 270 bottom
UNK2R511  523-1-S4  [R0402]  265.19 262.36 0 bottom
UNK2R512  0-5-S8  [R0805]  267.48 266.24 270 bottom
UNK2R646  42.2-1-S2  [R0201]  254.68 254.16 90 bottom
UNK2R647  42.2-1-S2  [R0201]  255.38 254.16 90 bottom
UNK2R652  1M-1-S4  [R0402]  270.85 273.67 90 bottom
UNK2R659  10K-1-S2-WA  [R0201]  253.54 250.99 90 top
UNK2R661  4.7K-1-S2  [R0201]  252.78 250.99 270 top
UNK2R662  0-5-S2  [R0201]  254.96 241.23 0 top
UNK2R663  4.7K-1-S2  [R0201]  252.78 239.42 270 top
UNK2R664  42.2-1-S2  [R0201]  252.33 242.6 90 bottom
UNK2R666  42.2-1-S2  [R0201]  251.64 242.6 90 bottom
UNK2R672  10K-1-S2-WA  [R0201]  253.54 239.42 90 top
UNK2R849  100-1-S4  [R0402]  278.58 271.17 0 bottom
UNK2R923  1M-1-S4  [R0402]  272 273.67 90 bottom
UNK2R973  NC/0-5-S4  [R0402]  271.42 272.04 0 bottom
UNK2R980  10K-1-S2-WA  [R0201]  273.66 269.4 90 bottom
UNK2R981  NC/4.7K-1-S2  [R0201]  269.83 269.4 270 bottom
UNK2R982  0-5-S2  [R0201]  269.53 268.44 0 bottom
UNK2R983  10K-1-S2-WA  [R0201]  280.81 268.52 90 bottom
UNK2R984  NC/4.7K-1-S2  [R0201]  276.97 268.52 270 bottom
UNK2R985  0-5-S2  [R0201]  276.67 267.56 0 bottom
UNK2R986  10K-1-S2-WA  [R0201]  287.07 268.52 90 bottom
UNK2R987  NC/4.7K-1-S2  [R0201]  283.24 268.52 270 bottom
UNK2R988  0-5-S2  [R0201]  282.94 267.56 0 bottom
UNK2R989  10K-1-S2-WA  [R0201]  287.88 272.33 90 bottom
UNK2R990  NC/4.7K-1-S2  [R0201]  284.05 272.33 270 bottom
UNK2R991  0-5-S2  [R0201]  283.75 271.37 0 bottom
UNK2R1088  42.2-1-S2  [R0201]  254.68 242.6 90 bottom
UNK2R1089  42.2-1-S2  [R0201]  255.38 242.6 90 bottom
UNK2R1090  240-1-S4  [R0402]  262.76 239.01 180 bottom
UNK2R1091  59-1-S4  [R0402]  282.07 224.79 180 bottom
UNK2TP_DPS1  TP01  [TP_040_T]  213.61 297.94 0 top
UNK2TP_DPS2  TP01  [TP_040_T]  273.93 277.62 0 top
UNK2TP_DPS3  TP01  [TP_040_T]  255.42 281.69 0 top
UNK2TP_DPS4  TP01  [TP_040_T]  283.87 277.62 0 top
UNK2TP_DPS5  TP01  [TP_040_T]  261.51 277.62 0 top
UNK2TP_DPS6  TP01  [TP_040_T]  283.87 281.69 0 top
UNK2TP_DPS7  TP01  [TP_040_T]  255.42 277.62 0 top
UNK2TP_DPS8  TP01  [TP_040_T]  267.6 277.62 180 top
UNK2TP_MUX_3V3  TP01  [TP_040_T]  255.65 269.49 180 top
UNK2U17  XC6203E-0.4A-33-SOT89  [SOT89]  104.66 195.49 180 bottom
UNK2U18  SK-SO8-1.27-DEDIPROG-V2  [SK_SO8_1P27MM_DEDIPROG_V2]  95.31 202.82 270 bottom
UNK2U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  114.42 202.82 270 bottom
UNK2U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  266.08 234.5 90 bottom
UNK2U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  261.84 264.24 180 bottom
UNK2U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  253.16 249.72 180 bottom
UNK2U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  253.16 238.15 180 bottom
UNK2U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  271.94 269.73 270 bottom
UNK2U450  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  279.08 268.86 270 bottom
UNK2U451  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  285.35 268.86 270 bottom
UNK2U452  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  286.15 272.67 270 bottom
UNK2Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  274.01 221.07 0 bottom
UNK2Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  271.94 265.49 180 bottom
UNK3BD9  BD120-1.5A-S4-MU  [FB0402]  304.65 243.83 270 bottom
UNK3BD21  BD120-1.5A-S4-MU  [FB0402]  302.95 232.36 0 bottom
UNK3BD1728  BD120-1.5A-S4-MU  [FB0402]  309.83 271.82 270 bottom
UNK3BD1729  BD120-1.5A-S4-MU  [FB0402]  316.97 270.94 270 bottom
UNK3BDB5  BD120-1.5A-S4-MU  [FB0402]  291.03 246.46 0 bottom
UNK3BDB6  BD120-1.5A-S4-MU  [FB0402]  291.03 234.89 0 bottom
UNK3C262  0.1U-16-X7S-S2-MU  [C0201]  304.41 232.06 270 bottom
UNK3C264  NC/10U-16-X7R-S8-SS  [C0805]  307.48 269.95 90 bottom
UNK3C267  33P-50-N-S2-MU  [C0201]  316.23 224.18 270 bottom
UNK3C268  33P-50-N-S2-MU  [C0201]  315.23 224.18 270 bottom
UNK3C270  NC/10U-16-X7R-S8-SS  [C0805]  304.95 259 0 bottom
UNK3C271  12P-50-N-S4-MU  [C0402]  312.95 267.19 180 bottom
UNK3C272  12P-50-N-S4-MU  [C0402]  310.93 267.19 0 bottom
UNK3C278  1U-10-X7S-S4-TDK  [C0402]  312.87 289.3 0 bottom
UNK3C279  1U-10-X7S-S4-TDK  [C0402]  312.87 288.11 0 bottom
UNK3C280  0.1U-16-X-S4-MU  [C0402]  312.87 286.91 0 bottom
UNK3C281  0.1U-16-X-S4-MU  [C0402]  312.87 285.72 0 bottom
UNK3C282  1U-10-X7S-S4-TDK  [C0402]  318.7 282.67 270 bottom
UNK3C283  0.1U-16-X-S4-MU  [C0402]  317.54 282.67 270 bottom
UNK3C284  1U-10-X7S-S4-TDK  [C0402]  317.62 294.04 90 bottom
UNK3C285  0.1U-16-X-S4-MU  [C0402]  318.81 294.04 90 bottom
UNK3C286  0.1U-16-X-S4-MU  [C0402]  313.82 293.54 180 bottom
UNK3C288  1000P-50-X7R-S2-MU  [C0201]  313.49 291.76 270 bottom
UNK3C289  0.1U-16-X-S4-MU  [C0402]  311.21 291 270 bottom
UNK3C290  NC/0.1U-16-X7R-S4-TY  [C0402]  304.35 292.22 180 bottom
UNK3C298  0.1U-16-X7S-S2-MU  [C0201]  302.95 288.84 90 bottom
UNK3C299  0.1U-16-X7S-S2-MU  [C0201]  300.02 293.16 180 bottom
UNK3C300  0.1U-16-X-S4-MU  [C0402]  300.67 287.06 270 bottom
UNK3C301  1U-10-X7S-S4-TDK  [C0402]  299.51 287.06 270 bottom
UNK3C302  10P-50-N-S2-MU  [C0201]  294.98 243.61 0 bottom
UNK3C309  10P-50-N-S2-MU  [C0201]  294.98 255.18 0 bottom
UNK3C310  10P-50-N-S2-MU  [C0201]  293.69 255.18 180 bottom
UNK3C318  10P-50-N-S2-MU  [C0201]  291.94 255.18 0 bottom
UNK3C320  10P-50-N-S2-MU  [C0201]  293.69 243.61 180 bottom
UNK3C332  2.2U-16-X7R-S6-TY  [C0603]  474.86 194.9 270 bottom
UNK3C333  0.1U-16-X-S4-MU  [C0402]  473.46 195.08 270 bottom
UNK3C334  10U-16-X7R-S8-SS  [C0805]  465.84 194.78 90 bottom
UNK3C335  0.1U-16-X-S4-MU  [C0402]  467.5 194.6 90 bottom
UNK3C336  4.7U-25-X7R-S8-TY  [C0805]  453.34 208.54 270 bottom
UNK3C337  0.1U-16-X-S4-MU  [C0402]  453.36 205.99 180 bottom
UNK3C338  4.7U-25-X7R-S8-TY  [C0805]  471.76 208.54 270 bottom
UNK3C339  0.1U-16-X-S4-MU  [C0402]  471.79 205.99 180 bottom
UNK3C475  4.7U-6.3-X-S4-MU  [C0402]  305.86 265.11 270 bottom
UNK3C476  1U-10-X7S-S4-TDK  [C0402]  299 268.25 90 bottom
UNK3C477  10U-25-X-S6-MU  [C0603]  300.32 268.76 90 bottom
UNK3C478  22U-16-X5R-SA-SS  [C1206]  303.32 268.5 0 bottom
UNK3C922  0.1U-16-X-S4-MU  [C0402]  293.16 246.46 0 bottom
UNK3C923  0.1U-16-X-S4-MU  [C0402]  293.16 234.89 0 bottom
UNK3C924  10P-50-N-S2-MU  [C0201]  291.94 243.61 0 bottom
UNK3C1066  0.01U-10-X7R-S2-YA  [C0201]  324.98 274.19 0 bottom
UNK3C1067  0.01U-10-X7R-S2-YA  [C0201]  326.33 274.19 180 bottom
UNK3C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  309.58 270.27 180 bottom
UNK3C1077  0.1U-16-X7S-S2-MU  [C0201_MINI]  316.72 269.49 180 bottom
UNK3C1080  0.1U-16-X7S-S2-MU  [C0201_MINI]  322.99 269.49 180 bottom
UNK3C1081  0.1U-16-X7S-S2-MU  [C0201_MINI]  323.8 273.3 180 bottom
UNK3CA1  0.1U-16-X-S4-MU  [C0402]  365.34 295.91 0 bottom
UNK3CA2  10U-25-X7R-SA  [C1206]  365.34 297.94 0 bottom
UNK3CA7  10U-25-X7R-SA  [C1206]  325.12 281.69 0 bottom
UNK3CA8  0.1U-16-X-S4-MU  [C0402]  325.12 279.65 0 bottom
UNK3CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  377.1 293.29 0 bottom
UNK3CA20  10U-25-X7R-SA  [C1206]  296.67 281.69 0 bottom
UNK3CA21  0.1U-16-X-S4-MU  [C0402]  296.67 279.65 0 bottom
UNK3CA22  10U-25-X7R-SA  [C1206]  302.76 277.62 0 bottom
UNK3CA23  0.1U-16-X-S4-MU  [C0402]  302.76 275.59 0 bottom
UNK3CA24  10U-25-X7R-SA  [C1206]  296.67 277.62 0 bottom
UNK3CA25  0.1U-16-X-S4-MU  [C0402]  296.67 275.59 0 bottom
UNK3CA26  10U-25-X7R-SA  [C1206]  315.18 277.62 0 bottom
UNK3CA27  0.1U-16-X-S4-MU  [C0402]  315.18 275.59 0 bottom
UNK3CA34  10U-25-X7R-SA  [C1206]  325.12 277.62 0 bottom
UNK3CA35  0.1U-16-X-S4-MU  [C0402]  325.12 275.59 0 bottom
UNK3CA36  0.1U-16-X-S4-MU  [C0402]  308.85 275.59 0 bottom
UNK3CA37  10U-25-X7R-SA  [C1206]  308.85 277.62 0 bottom
UNK3CC1  0.1U-16-X7S-S2-MU  [C0201]  310.19 246.91 180 bottom
UNK3CC2  0.1U-16-X7S-S2-MU  [C0201]  310.5 250.48 90 bottom
UNK3CC3  0.1U-16-X7S-S2-MU  [C0201]  308.87 245.61 180 bottom
UNK3CC4  0.1U-16-X7S-S2-MU  [C0201]  310.19 246.26 180 bottom
UNK3CC5  0.1U-16-X7S-S2-MU  [C0201]  311.16 246.56 90 bottom
UNK3CC6  0.1U-16-X7S-S2-MU  [C0201]  308.87 244.96 180 bottom
UNK3CC7  0.1U-16-X7S-S2-MU  [C0201]  312.14 244.96 0 bottom
UNK3CC8  0.1U-16-X7S-S2-MU  [C0201]  310.5 243.97 270 bottom
UNK3CC9  0.1U-16-X7S-S2-MU  [C0201]  311.16 243.97 270 bottom
UNK3CC12  0.1U-16-X7S-S2-MU  [C0201]  309.85 244.62 270 bottom
UNK3CC13  0.1U-16-X7S-S2-MU  [C0201]  308.24 241.05 180 bottom
UNK3CC14  0.1U-16-X7S-S2-MU  [C0201]  311.46 245.61 0 bottom
UNK3CC15  0.1U-16-X7S-S2-MU  [C0201]  310.19 245.61 180 bottom
UNK3CC16  0.1U-16-X7S-S2-MU  [C0201]  310.84 244.96 180 bottom
UNK3CC70  0.1U-16-X7S-S2-MU  [C0201]  312.46 242.67 270 bottom
UNK3CC71  0.1U-16-X7S-S2-MU  [C0201]  315.38 243 0 bottom
UNK3CC73  0.1U-16-X7S-S2-MU  [C0201]  307.9 242.68 90 bottom
UNK3CC84  0.1U-16-X7S-S2-MU  [C0201]  313.11 250.48 90 bottom
UNK3CC85  0.1U-16-X7S-S2-MU  [C0201]  311.15 250.48 90 bottom
UNK3CC86  0.1U-16-X7S-S2-MU  [C0201]  312.46 250.48 90 bottom
UNK3CC87  0.1U-16-X7S-S2-MU  [C0201]  312.14 246.26 180 bottom
UNK3CC88  0.1U-16-X7S-S2-MU  [C0201]  313.11 244 270 bottom
UNK3CC89  0.1U-16-X7S-S2-MU  [C0201]  307.9 244.66 270 bottom
UNK3CC90  0.1U-16-X7S-S2-MU  [C0201]  311.8 250.48 90 bottom
UNK3CC91  0.1U-16-X7S-S2-MU  [C0201]  314.05 243.65 0 bottom
UNK3CC92  0.1U-16-X7S-S2-MU  [C0201]  312.45 244 270 bottom
UNK3CC96  0.1U-16-X7S-S2-MU  [C0201]  311.51 247.56 180 bottom
UNK3CC101  0.1U-16-X7S-S2-MU  [C0201]  310.84 240.4 0 bottom
UNK3CC103  0.1U-16-X7S-S2-MU  [C0201]  311.81 242.02 90 bottom
UNK3CC105  0.1U-16-X7S-S2-MU  [C0201]  312.46 240.72 270 bottom
UNK3CC107  0.1U-16-X7S-S2-MU  [C0201]  312.76 241.7 0 bottom
UNK3CC112  0.1U-16-X7S-S2-MU  [C0201]  315.05 250.48 90 bottom
UNK3CC130  0.1U-16-X7S-S2-MU  [C0201]  308.24 241.7 180 bottom
UNK3CC133  1U-6.3-X7T-S2-MU  [C0201]  307.25 238.78 270 bottom
UNK3CC134  NC/0.1U-10-X7R-S2-MU  [C0201]  307.9 238.78 270 bottom
UNK3CC182  0.1U-16-X7S-S2-MU  [C0201]  306.6 250.48 90 bottom
UNK3CC194  0.1U-16-X7S-S2-MU  [C0201]  311.49 243 180 bottom
UNK3CC202  0.1U-16-X7S-S2-MU  [C0201]  306.28 245.61 180 bottom
UNK3CC203  0.1U-16-X7S-S2-MU  [C0201]  309.85 239.42 270 bottom
UNK3CC204  0.1U-16-X7S-S2-MU  [C0201]  310.51 239.42 270 bottom
UNK3CC205  0.1U-16-X7S-S2-MU  [C0201]  311.16 239.42 270 bottom
UNK3CC208  0.1U-16-X7S-S2-MU  [C0201]  307.57 246.26 180 bottom
UNK3CC209  0.1U-16-X7S-S2-MU  [C0201]  308.23 247.56 180 bottom
UNK3CC210  0.1U-16-X7S-S2-MU  [C0201]  309.53 240.41 180 bottom
UNK3CC211  0.1U-16-X7S-S2-MU  [C0201]  310.5 242.02 90 bottom
UNK3CC212  0.1U-16-X7S-S2-MU  [C0201]  309.53 241.06 180 bottom
UNK3CC213  0.1U-16-X7S-S2-MU  [C0201]  311.16 242.02 90 bottom
UNK3CC215  0.1U-16-X7S-S2-MU  [C0201]  311.81 239.42 90 bottom
UNK3CC216  0.1U-16-X7S-S2-MU  [C0201]  308.55 238.78 270 bottom
UNK3K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  484.8 216.35 90 bottom
UNK3K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  478.45 216.35 90 bottom
UNK3K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  472.1 216.35 90 bottom
UNK3K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  465.75 216.35 90 bottom
UNK3K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  459.4 216.35 90 bottom
UNK3K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  453.05 216.35 90 bottom
UNK3K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  311.94 258.56 90 bottom
UNK3K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  315.73 231.79 270 bottom
UNK3K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  186.18 269.24 90 bottom
UNK3K39  UA2-5NE-A-V3  [RL_NECUA2_5V_V3]  304.66 224.54 180 bottom
UNK3K96  EC2-5NJ  [RL_NECEC2_10P_5V]  375.6 279.19 270 bottom
UNK3K107  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  186.18 281.43 90 bottom
UNK3K113  MFS-E1T05G-A  [RL_MFS-E1T-G_5V]  325.11 221.36 0 bottom
UNK3MBD1  BD120-1.5A-S4-MU  [FB0402]  302.95 290.49 270 bottom
UNK3MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  305.87 284.52 180 bottom
UNK3MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  305.87 289.86 180 bottom
UNK3MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  305.87 281.98 180 bottom
UNK3MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  305.87 287.19 180 bottom
UNK3MR1  1M-1-S4  [R0402_UNBGA_V2]  316.22 282.67 270 bottom
UNK3MR2  1K-0.01-S4  [R0402_UNBGA_V2]  315.91 293.54 180 bottom
UNK3MR3  1K-0.01-S4  [R0402_UNBGA_V2]  313.82 294.56 180 bottom
UNK3MR4  1K-0.01-S4  [R0402_UNBGA_V2]  313.82 295.57 180 bottom
UNK3MR5  1K-0.01-S4  [R0402_UNBGA_V2]  315.91 295.57 0 bottom
UNK3MR6  1K-0.01-S4  [R0402_UNBGA_V2]  315.91 294.56 0 bottom
UNK3MR7  332K-1-S4  [R0402_UNBGA_V2]  315.21 281.82 90 bottom
UNK3MR8  1K-0.01-S4  [R0402_UNBGA_V2]  304.35 295.57 180 bottom
UNK3MR9  499-0.1-S4  [R0402]  304.35 294.46 180 bottom
UNK3MR10  0-5-S4  [R0402]  304.35 293.34 0 bottom
UNK3MR11  750-1-S4  [R0402]  309.3 285.16 180 bottom
UNK3MR12  360-1-S6  [R0603]  309.68 283.89 180 bottom
UNK3MR13  750-1-S4  [R0402]  309.3 290.49 180 bottom
UNK3MR14  1.2K-1-S4  [R0402]  309.05 282.62 0 bottom
UNK3MR15  360-1-S6  [R0603]  309.68 289.22 180 bottom
UNK3MR16  750-1-S4  [R0402]  309.3 287.83 180 bottom
UNK3MR17  360-1-S6  [R0603]  309.68 286.56 180 bottom
UNK3MR18  11K-0.1-S4  [R0402]  301.81 287.06 270 bottom
UNK3MR19  1K-0.01-S4  [R0402_UNBGA_V2]  302.95 287.06 90 bottom
UNK3MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  313.15 283.82 90 bottom
UNK3MU2  KSMT004-SO8  [SO8_244X127MM]  318.06 288.21 90 bottom
UNK3MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  308.92 293.67 180 bottom
UNK3MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  300.67 290.49 0 bottom
UNK3R135  0-5-S4  [R0402]  318.73 225.44 180 bottom
UNK3R136  1M-1-S4  [R0402]  315.73 225.44 0 bottom
UNK3R137  0-5-S4  [R0402]  312.73 225.44 0 bottom
UNK3R160  38.3-1-S2  [R0201_MINI]  303.52 235.18 0 bottom
UNK3R161  38.3-1-S2  [R0201_MINI]  303.52 234.62 0 bottom
UNK3R162  4.7K-1-S2  [R0201_MINI]  308.01 234.55 90 bottom
UNK3R163  0-5-S2  [R0201_MINI]  303.52 233.14 0 bottom
UNK3R164  0-5-S2  [R0201_MINI]  303.52 234.06 0 bottom
UNK3R165  0-5-S2  [R0201_MINI]  308.01 233.55 90 bottom
UNK3R168  42.2-1-S2  [R0201]  293.99 254.16 90 bottom
UNK3R170  42.2-1-S2  [R0201]  293.29 254.16 90 bottom
UNK3R172  0-5-S2  [R0201]  294.96 252.79 0 top
UNK3R176  42.2-1-S2  [R0201]  291.64 254.16 90 bottom
UNK3R178  42.2-1-S2  [R0201]  292.33 254.16 90 bottom
UNK3R180  42.2-1-S2  [R0201]  293.99 242.6 90 bottom
UNK3R182  42.2-1-S2  [R0201]  293.29 242.6 90 bottom
UNK3R200  4.7K-1-S2  [R0201]  468.44 204.72 180 bottom
UNK3R201  0-5-S4  [R0402]  453.36 204.72 180 bottom
UNK3R202  NC/4.7K-1-S4  [R0402]  453.36 203.45 180 bottom
UNK3R203  4.7K-1-S2  [R0201]  468.44 202.18 180 bottom
UNK3R204  0-5-S4  [R0402]  472.04 204.72 180 bottom
UNK3R205  4.7K-1-S2  [R0201]  488.24 204.72 180 bottom
UNK3R206  NC/4.7K-1-S4  [R0402]  472.04 203.45 180 bottom
UNK3R207  4.7K-1-S2  [R0201]  488.24 202.18 180 bottom
UNK3R331  10K-1-S2-WA  [R0201]  301.62 293.49 270 bottom
UNK3R509  0-5-S4  [R0402]  299 264.31 90 bottom
UNK3R510  1.2K-1-S4  [R0402]  304.69 265.11 270 bottom
UNK3R511  523-1-S4  [R0402]  305.19 262.36 0 bottom
UNK3R512  0-5-S8  [R0805]  307.48 266.24 270 bottom
UNK3R646  42.2-1-S2  [R0201]  294.68 254.16 90 bottom
UNK3R647  42.2-1-S2  [R0201]  295.38 254.16 90 bottom
UNK3R652  1M-1-S4  [R0402]  310.84 273.67 90 bottom
UNK3R659  10K-1-S2-WA  [R0201]  293.54 250.99 90 top
UNK3R661  4.7K-1-S2  [R0201]  292.78 250.99 270 top
UNK3R662  0-5-S2  [R0201]  294.96 241.23 0 top
UNK3R663  4.7K-1-S2  [R0201]  292.78 239.42 270 top
UNK3R664  42.2-1-S2  [R0201]  292.33 242.6 90 bottom
UNK3R666  42.2-1-S2  [R0201]  291.64 242.6 90 bottom
UNK3R672  10K-1-S2-WA  [R0201]  293.54 239.42 90 top
UNK3R849  100-1-S4  [R0402]  318.58 271.17 0 bottom
UNK3R923  1M-1-S4  [R0402]  312 273.67 90 bottom
UNK3R973  NC/0-5-S4  [R0402]  311.42 272.04 0 bottom
UNK3R980  10K-1-S2-WA  [R0201]  313.66 269.4 90 bottom
UNK3R981  NC/4.7K-1-S2  [R0201]  309.83 269.4 270 bottom
UNK3R982  0-5-S2  [R0201]  309.53 268.44 0 bottom
UNK3R983  10K-1-S2-WA  [R0201]  320.81 268.52 90 bottom
UNK3R984  NC/4.7K-1-S2  [R0201]  316.97 268.52 270 bottom
UNK3R985  0-5-S2  [R0201]  316.67 267.56 0 bottom
UNK3R986  10K-1-S2-WA  [R0201]  327.07 268.52 90 bottom
UNK3R987  NC/4.7K-1-S2  [R0201]  323.24 268.52 270 bottom
UNK3R988  0-5-S2  [R0201]  322.94 267.56 0 bottom
UNK3R989  10K-1-S2-WA  [R0201]  327.88 272.33 90 bottom
UNK3R990  NC/4.7K-1-S2  [R0201]  324.05 272.33 270 bottom
UNK3R991  0-5-S2  [R0201]  323.75 271.37 0 bottom
UNK3R1088  42.2-1-S2  [R0201]  294.68 242.6 90 bottom
UNK3R1089  42.2-1-S2  [R0201]  295.38 242.6 90 bottom
UNK3R1090  240-1-S4  [R0402]  302.76 239.01 180 bottom
UNK3R1091  59-1-S4  [R0402]  322.07 224.79 180 bottom
UNK3TP_DPS1  TP01  [TP_040_T]  364.09 297.94 0 top
UNK3TP_DPS2  TP01  [TP_040_T]  313.93 277.62 0 top
UNK3TP_DPS3  TP01  [TP_040_T]  295.42 281.69 0 top
UNK3TP_DPS4  TP01  [TP_040_T]  323.87 277.62 0 top
UNK3TP_DPS5  TP01  [TP_040_T]  301.51 277.62 0 top
UNK3TP_DPS6  TP01  [TP_040_T]  323.87 281.69 0 top
UNK3TP_DPS7  TP01  [TP_040_T]  295.42 277.62 0 top
UNK3TP_DPS8  TP01  [TP_040_T]  307.6 277.62 180 top
UNK3TP_MUX_3V3  TP01  [TP_040_T]  295.65 269.49 180 top
UNK3U17  XC6203E-0.4A-33-SOT89  [SOT89]  470.42 195.49 180 bottom
UNK3U18  SK-SO8-1.27-DEDIPROG-V2  [SK_SO8_1P27MM_DEDIPROG_V2]  461.07 202.82 270 bottom
UNK3U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  480.18 202.82 270 bottom
UNK3U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  306.08 234.5 90 bottom
UNK3U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  301.84 264.24 180 bottom
UNK3U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  293.16 249.72 180 bottom
UNK3U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  293.16 238.15 180 bottom
UNK3U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  311.94 269.73 270 bottom
UNK3U450  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  319.08 268.86 270 bottom
UNK3U451  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  325.35 268.86 270 bottom
UNK3U452  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  326.15 272.67 270 bottom
UNK3Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  314.01 221.07 0 bottom
UNK3Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  311.94 265.49 180 bottom
UNK4BD9  BD120-1.5A-S4-MU  [FB0402]  344.65 243.83 270 bottom
UNK4BD21  BD120-1.5A-S4-MU  [FB0402]  342.95 232.36 0 bottom
UNK4BD1728  BD120-1.5A-S4-MU  [FB0402]  349.83 271.82 270 bottom
UNK4BD1729  BD120-1.5A-S4-MU  [FB0402]  356.97 270.94 270 bottom
UNK4BDB5  BD120-1.5A-S4-MU  [FB0402]  331.03 246.46 0 bottom
UNK4BDB6  BD120-1.5A-S4-MU  [FB0402]  331.03 234.89 0 bottom
UNK4C262  0.1U-16-X7S-S2-MU  [C0201]  344.41 232.06 270 bottom
UNK4C264  NC/10U-16-X7R-S8-SS  [C0805]  347.48 269.95 90 bottom
UNK4C267  33P-50-N-S2-MU  [C0201]  356.23 224.18 270 bottom
UNK4C268  33P-50-N-S2-MU  [C0201]  355.23 224.18 270 bottom
UNK4C270  NC/10U-16-X7R-S8-SS  [C0805]  344.95 259 0 bottom
UNK4C271  12P-50-N-S4-MU  [C0402]  352.95 267.19 180 bottom
UNK4C272  12P-50-N-S4-MU  [C0402]  350.93 267.19 0 bottom
UNK4C278  1U-10-X7S-S4-TDK  [C0402]  352.87 289.3 0 bottom
UNK4C279  1U-10-X7S-S4-TDK  [C0402]  352.87 288.11 0 bottom
UNK4C280  0.1U-16-X-S4-MU  [C0402]  352.87 286.91 0 bottom
UNK4C281  0.1U-16-X-S4-MU  [C0402]  352.87 285.72 0 bottom
UNK4C282  1U-10-X7S-S4-TDK  [C0402]  358.7 282.67 270 bottom
UNK4C283  0.1U-16-X-S4-MU  [C0402]  357.54 282.67 270 bottom
UNK4C284  1U-10-X7S-S4-TDK  [C0402]  357.62 294.04 90 bottom
UNK4C285  0.1U-16-X-S4-MU  [C0402]  358.81 294.04 90 bottom
UNK4C286  0.1U-16-X-S4-MU  [C0402]  353.82 293.54 180 bottom
UNK4C288  1000P-50-X7R-S2-MU  [C0201]  353.49 291.76 270 bottom
UNK4C289  0.1U-16-X-S4-MU  [C0402]  351.21 291 270 bottom
UNK4C290  NC/0.1U-16-X7R-S4-TY  [C0402]  344.35 292.22 180 bottom
UNK4C298  0.1U-16-X7S-S2-MU  [C0201]  342.95 288.84 90 bottom
UNK4C299  0.1U-16-X7S-S2-MU  [C0201]  340.02 293.16 180 bottom
UNK4C300  0.1U-16-X-S4-MU  [C0402]  340.67 287.06 270 bottom
UNK4C301  1U-10-X7S-S4-TDK  [C0402]  339.51 287.06 270 bottom
UNK4C302  10P-50-N-S2-MU  [C0201]  334.98 243.61 0 bottom
UNK4C309  10P-50-N-S2-MU  [C0201]  334.98 255.18 0 bottom
UNK4C310  10P-50-N-S2-MU  [C0201]  333.69 255.18 180 bottom
UNK4C318  10P-50-N-S2-MU  [C0201]  331.94 255.18 0 bottom
UNK4C320  10P-50-N-S2-MU  [C0201]  333.69 243.61 180 bottom
UNK4C332  2.2U-16-X7R-S6-TY  [C0603]  474.86 226.65 270 bottom
UNK4C333  0.1U-16-X-S4-MU  [C0402]  473.46 226.83 270 bottom
UNK4C334  10U-16-X7R-S8-SS  [C0805]  465.84 226.53 90 bottom
UNK4C335  0.1U-16-X-S4-MU  [C0402]  467.5 226.35 90 bottom
UNK4C336  4.7U-25-X7R-S8-TY  [C0805]  453.34 240.29 270 bottom
UNK4C337  0.1U-16-X-S4-MU  [C0402]  453.36 237.74 180 bottom
UNK4C338  4.7U-25-X7R-S8-TY  [C0805]  471.76 240.29 270 bottom
UNK4C339  0.1U-16-X-S4-MU  [C0402]  471.79 237.74 180 bottom
UNK4C475  4.7U-6.3-X-S4-MU  [C0402]  345.86 265.11 270 bottom
UNK4C476  1U-10-X7S-S4-TDK  [C0402]  339 268.25 90 bottom
UNK4C477  10U-25-X-S6-MU  [C0603]  340.32 268.76 90 bottom
UNK4C478  22U-16-X5R-SA-SS  [C1206]  343.32 268.5 0 bottom
UNK4C922  0.1U-16-X-S4-MU  [C0402]  333.16 246.46 0 bottom
UNK4C923  0.1U-16-X-S4-MU  [C0402]  333.16 234.89 0 bottom
UNK4C924  10P-50-N-S2-MU  [C0201]  331.94 243.61 0 bottom
UNK4C1066  0.01U-10-X7R-S2-YA  [C0201]  364.98 274.19 0 bottom
UNK4C1067  0.01U-10-X7R-S2-YA  [C0201]  366.33 274.19 180 bottom
UNK4C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  349.58 270.27 180 bottom
UNK4C1077  0.1U-16-X7S-S2-MU  [C0201_MINI]  356.72 269.49 180 bottom
UNK4C1080  0.1U-16-X7S-S2-MU  [C0201_MINI]  362.99 269.49 180 bottom
UNK4C1081  0.1U-16-X7S-S2-MU  [C0201_MINI]  363.8 273.3 180 bottom
UNK4CA1  0.1U-16-X-S4-MU  [C0402]  378.44 245.11 0 bottom
UNK4CA2  10U-25-X7R-SA  [C1206]  378.44 247.65 0 bottom
UNK4CA7  10U-25-X7R-SA  [C1206]  365.12 281.69 0 bottom
UNK4CA8  0.1U-16-X-S4-MU  [C0402]  365.12 279.65 0 bottom
UNK4CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  391.97 236.27 270 bottom
UNK4CA20  10U-25-X7R-SA  [C1206]  336.67 281.69 0 bottom
UNK4CA21  0.1U-16-X-S4-MU  [C0402]  336.67 279.65 0 bottom
UNK4CA22  10U-25-X7R-SA  [C1206]  342.76 277.62 0 bottom
UNK4CA23  0.1U-16-X-S4-MU  [C0402]  342.76 275.59 0 bottom
UNK4CA24  10U-25-X7R-SA  [C1206]  336.67 277.62 0 bottom
UNK4CA25  0.1U-16-X-S4-MU  [C0402]  336.67 275.59 0 bottom
UNK4CA26  10U-25-X7R-SA  [C1206]  355.18 277.62 0 bottom
UNK4CA27  0.1U-16-X-S4-MU  [C0402]  355.18 275.59 0 bottom
UNK4CA34  10U-25-X7R-SA  [C1206]  365.12 277.62 0 bottom
UNK4CA35  0.1U-16-X-S4-MU  [C0402]  365.12 275.59 0 bottom
UNK4CA36  0.1U-16-X-S4-MU  [C0402]  348.85 275.59 0 bottom
UNK4CA37  10U-25-X7R-SA  [C1206]  348.85 277.62 0 bottom
UNK4CC1  0.1U-16-X7S-S2-MU  [C0201]  350.19 246.91 180 bottom
UNK4CC2  0.1U-16-X7S-S2-MU  [C0201]  350.5 250.48 90 bottom
UNK4CC3  0.1U-16-X7S-S2-MU  [C0201]  348.87 245.61 180 bottom
UNK4CC4  0.1U-16-X7S-S2-MU  [C0201]  350.19 246.26 180 bottom
UNK4CC5  0.1U-16-X7S-S2-MU  [C0201]  351.15 246.56 90 bottom
UNK4CC6  0.1U-16-X7S-S2-MU  [C0201]  348.87 244.96 180 bottom
UNK4CC7  0.1U-16-X7S-S2-MU  [C0201]  352.14 244.96 0 bottom
UNK4CC8  0.1U-16-X7S-S2-MU  [C0201]  350.5 243.97 270 bottom
UNK4CC9  0.1U-16-X7S-S2-MU  [C0201]  351.15 243.97 270 bottom
UNK4CC12  0.1U-16-X7S-S2-MU  [C0201]  349.85 244.62 270 bottom
UNK4CC13  0.1U-16-X7S-S2-MU  [C0201]  348.24 241.05 180 bottom
UNK4CC14  0.1U-16-X7S-S2-MU  [C0201]  351.45 245.61 0 bottom
UNK4CC15  0.1U-16-X7S-S2-MU  [C0201]  350.19 245.61 180 bottom
UNK4CC16  0.1U-16-X7S-S2-MU  [C0201]  350.84 244.96 180 bottom
UNK4CC70  0.1U-16-X7S-S2-MU  [C0201]  352.45 242.67 270 bottom
UNK4CC71  0.1U-16-X7S-S2-MU  [C0201]  355.38 243 0 bottom
UNK4CC73  0.1U-16-X7S-S2-MU  [C0201]  347.9 242.68 90 bottom
UNK4CC84  0.1U-16-X7S-S2-MU  [C0201]  353.1 250.48 90 bottom
UNK4CC85  0.1U-16-X7S-S2-MU  [C0201]  351.15 250.48 90 bottom
UNK4CC86  0.1U-16-X7S-S2-MU  [C0201]  352.45 250.48 90 bottom
UNK4CC87  0.1U-16-X7S-S2-MU  [C0201]  352.14 246.26 180 bottom
UNK4CC88  0.1U-16-X7S-S2-MU  [C0201]  353.1 244 270 bottom
UNK4CC89  0.1U-16-X7S-S2-MU  [C0201]  347.9 244.66 270 bottom
UNK4CC90  0.1U-16-X7S-S2-MU  [C0201]  351.8 250.48 90 bottom
UNK4CC91  0.1U-16-X7S-S2-MU  [C0201]  354.05 243.65 0 bottom
UNK4CC92  0.1U-16-X7S-S2-MU  [C0201]  352.45 244 270 bottom
UNK4CC96  0.1U-16-X7S-S2-MU  [C0201]  351.51 247.56 180 bottom
UNK4CC101  0.1U-16-X7S-S2-MU  [C0201]  350.84 240.4 0 bottom
UNK4CC103  0.1U-16-X7S-S2-MU  [C0201]  351.8 242.02 90 bottom
UNK4CC105  0.1U-16-X7S-S2-MU  [C0201]  352.45 240.72 270 bottom
UNK4CC107  0.1U-16-X7S-S2-MU  [C0201]  352.75 241.7 0 bottom
UNK4CC112  0.1U-16-X7S-S2-MU  [C0201]  355.05 250.48 90 bottom
UNK4CC130  0.1U-16-X7S-S2-MU  [C0201]  348.24 241.7 180 bottom
UNK4CC133  1U-6.3-X7T-S2-MU  [C0201]  347.25 238.78 270 bottom
UNK4CC134  NC/0.1U-10-X7R-S2-MU  [C0201]  347.9 238.78 270 bottom
UNK4CC182  0.1U-16-X7S-S2-MU  [C0201]  346.6 250.48 90 bottom
UNK4CC194  0.1U-16-X7S-S2-MU  [C0201]  351.49 243 180 bottom
UNK4CC202  0.1U-16-X7S-S2-MU  [C0201]  346.28 245.61 180 bottom
UNK4CC203  0.1U-16-X7S-S2-MU  [C0201]  349.85 239.42 270 bottom
UNK4CC204  0.1U-16-X7S-S2-MU  [C0201]  350.51 239.42 270 bottom
UNK4CC205  0.1U-16-X7S-S2-MU  [C0201]  351.15 239.42 270 bottom
UNK4CC208  0.1U-16-X7S-S2-MU  [C0201]  347.57 246.26 180 bottom
UNK4CC209  0.1U-16-X7S-S2-MU  [C0201]  348.23 247.56 180 bottom
UNK4CC210  0.1U-16-X7S-S2-MU  [C0201]  349.53 240.41 180 bottom
UNK4CC211  0.1U-16-X7S-S2-MU  [C0201]  350.5 242.02 90 bottom
UNK4CC212  0.1U-16-X7S-S2-MU  [C0201]  349.53 241.06 180 bottom
UNK4CC213  0.1U-16-X7S-S2-MU  [C0201]  351.15 242.02 90 bottom
UNK4CC215  0.1U-16-X7S-S2-MU  [C0201]  351.8 239.42 90 bottom
UNK4CC216  0.1U-16-X7S-S2-MU  [C0201]  348.55 238.78 270 bottom
UNK4K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  484.8 248.1 90 bottom
UNK4K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  478.45 248.1 90 bottom
UNK4K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  472.1 248.1 90 bottom
UNK4K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  465.75 248.1 90 bottom
UNK4K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  459.4 248.1 90 bottom
UNK4K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  453.05 248.1 90 bottom
UNK4K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  351.94 258.56 90 bottom
UNK4K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  355.73 231.79 270 bottom
UNK4K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  195.83 269.24 90 bottom
UNK4K39  UA2-5NE-A-V3  [RL_NECUA2_5V_V3]  344.66 224.54 180 bottom
UNK4K96  EC2-5NJ  [RL_NECEC2_10P_5V]  377.87 237.77 180 bottom
UNK4K107  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  195.83 281.43 90 bottom
UNK4K113  MFS-E1T05G-A  [RL_MFS-E1T-G_5V]  365.11 221.36 0 bottom
UNK4MBD1  BD120-1.5A-S4-MU  [FB0402]  342.95 290.49 270 bottom
UNK4MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  345.87 284.52 180 bottom
UNK4MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  345.87 289.86 180 bottom
UNK4MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  345.87 281.98 180 bottom
UNK4MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  345.87 287.19 180 bottom
UNK4MR1  1M-1-S4  [R0402_UNBGA_V2]  356.22 282.67 270 bottom
UNK4MR2  1K-0.01-S4  [R0402_UNBGA_V2]  355.91 293.54 180 bottom
UNK4MR3  1K-0.01-S4  [R0402_UNBGA_V2]  353.82 294.56 180 bottom
UNK4MR4  1K-0.01-S4  [R0402_UNBGA_V2]  353.82 295.57 180 bottom
UNK4MR5  1K-0.01-S4  [R0402_UNBGA_V2]  355.91 295.57 0 bottom
UNK4MR6  1K-0.01-S4  [R0402_UNBGA_V2]  355.91 294.56 0 bottom
UNK4MR7  332K-1-S4  [R0402_UNBGA_V2]  355.21 281.82 90 bottom
UNK4MR8  1K-0.01-S4  [R0402_UNBGA_V2]  344.35 295.57 180 bottom
UNK4MR9  499-0.1-S4  [R0402]  344.35 294.46 180 bottom
UNK4MR10  0-5-S4  [R0402]  344.35 293.34 0 bottom
UNK4MR11  750-1-S4  [R0402]  349.3 285.16 180 bottom
UNK4MR12  360-1-S6  [R0603]  349.68 283.89 180 bottom
UNK4MR13  750-1-S4  [R0402]  349.3 290.49 180 bottom
UNK4MR14  1.2K-1-S4  [R0402]  349.05 282.62 0 bottom
UNK4MR15  360-1-S6  [R0603]  349.68 289.22 180 bottom
UNK4MR16  750-1-S4  [R0402]  349.3 287.83 180 bottom
UNK4MR17  360-1-S6  [R0603]  349.68 286.56 180 bottom
UNK4MR18  11K-0.1-S4  [R0402]  341.81 287.06 270 bottom
UNK4MR19  1K-0.01-S4  [R0402_UNBGA_V2]  342.95 287.06 90 bottom
UNK4MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  353.15 283.82 90 bottom
UNK4MU2  KSMT004-SO8  [SO8_244X127MM]  358.06 288.21 90 bottom
UNK4MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  348.92 293.67 180 bottom
UNK4MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  340.67 290.49 0 bottom
UNK4R135  0-5-S4  [R0402]  358.73 225.44 180 bottom
UNK4R136  1M-1-S4  [R0402]  355.73 225.44 0 bottom
UNK4R137  0-5-S4  [R0402]  352.73 225.44 0 bottom
UNK4R160  38.3-1-S2  [R0201_MINI]  343.52 235.18 0 bottom
UNK4R161  38.3-1-S2  [R0201_MINI]  343.52 234.62 0 bottom
UNK4R162  4.7K-1-S2  [R0201_MINI]  348.01 234.55 90 bottom
UNK4R163  0-5-S2  [R0201_MINI]  343.52 233.14 0 bottom
UNK4R164  0-5-S2  [R0201_MINI]  343.52 234.06 0 bottom
UNK4R165  0-5-S2  [R0201_MINI]  348.01 233.55 90 bottom
UNK4R168  42.2-1-S2  [R0201]  333.99 254.16 90 bottom
UNK4R170  42.2-1-S2  [R0201]  333.29 254.16 90 bottom
UNK4R172  0-5-S2  [R0201]  334.96 252.79 0 top
UNK4R176  42.2-1-S2  [R0201]  331.64 254.16 90 bottom
UNK4R178  42.2-1-S2  [R0201]  332.33 254.16 90 bottom
UNK4R180  42.2-1-S2  [R0201]  333.99 242.6 90 bottom
UNK4R182  42.2-1-S2  [R0201]  333.29 242.6 90 bottom
UNK4R200  4.7K-1-S2  [R0201]  468.44 236.47 180 bottom
UNK4R201  0-5-S4  [R0402]  453.36 236.47 180 bottom
UNK4R202  NC/4.7K-1-S4  [R0402]  453.36 235.2 180 bottom
UNK4R203  4.7K-1-S2  [R0201]  468.44 233.93 180 bottom
UNK4R204  0-5-S4  [R0402]  472.04 236.47 180 bottom
UNK4R205  4.7K-1-S2  [R0201]  488.24 236.47 180 bottom
UNK4R206  NC/4.7K-1-S4  [R0402]  472.04 235.2 180 bottom
UNK4R207  4.7K-1-S2  [R0201]  488.24 233.93 180 bottom
UNK4R331  10K-1-S2-WA  [R0201]  341.62 293.49 270 bottom
UNK4R509  0-5-S4  [R0402]  339 264.31 90 bottom
UNK4R510  1.2K-1-S4  [R0402]  344.69 265.11 270 bottom
UNK4R511  523-1-S4  [R0402]  345.19 262.36 0 bottom
UNK4R512  0-5-S8  [R0805]  347.48 266.24 270 bottom
UNK4R646  42.2-1-S2  [R0201]  334.68 254.16 90 bottom
UNK4R647  42.2-1-S2  [R0201]  335.38 254.16 90 bottom
UNK4R652  1M-1-S4  [R0402]  350.84 273.67 90 bottom
UNK4R659  10K-1-S2-WA  [R0201]  333.54 250.99 90 top
UNK4R661  4.7K-1-S2  [R0201]  332.78 250.99 270 top
UNK4R662  0-5-S2  [R0201]  334.96 241.23 0 top
UNK4R663  4.7K-1-S2  [R0201]  332.78 239.42 270 top
UNK4R664  42.2-1-S2  [R0201]  332.33 242.6 90 bottom
UNK4R666  42.2-1-S2  [R0201]  331.64 242.6 90 bottom
UNK4R672  10K-1-S2-WA  [R0201]  333.54 239.42 90 top
UNK4R849  100-1-S4  [R0402]  358.58 271.17 0 bottom
UNK4R923  1M-1-S4  [R0402]  352 273.67 90 bottom
UNK4R973  NC/0-5-S4  [R0402]  351.42 272.04 0 bottom
UNK4R980  10K-1-S2-WA  [R0201]  353.66 269.4 90 bottom
UNK4R981  NC/4.7K-1-S2  [R0201]  349.83 269.4 270 bottom
UNK4R982  0-5-S2  [R0201]  349.53 268.44 0 bottom
UNK4R983  10K-1-S2-WA  [R0201]  360.81 268.52 90 bottom
UNK4R984  NC/4.7K-1-S2  [R0201]  356.97 268.52 270 bottom
UNK4R985  0-5-S2  [R0201]  356.67 267.56 0 bottom
UNK4R986  10K-1-S2-WA  [R0201]  367.07 268.52 90 bottom
UNK4R987  NC/4.7K-1-S2  [R0201]  363.24 268.52 270 bottom
UNK4R988  0-5-S2  [R0201]  362.94 267.56 0 bottom
UNK4R989  10K-1-S2-WA  [R0201]  367.88 272.33 90 bottom
UNK4R990  NC/4.7K-1-S2  [R0201]  364.05 272.33 270 bottom
UNK4R991  0-5-S2  [R0201]  363.75 271.37 0 bottom
UNK4R1088  42.2-1-S2  [R0201]  334.68 242.6 90 bottom
UNK4R1089  42.2-1-S2  [R0201]  335.38 242.6 90 bottom
UNK4R1090  240-1-S4  [R0402]  342.76 239.01 180 bottom
UNK4R1091  59-1-S4  [R0402]  362.07 224.79 180 bottom
UNK4TP_DPS1  TP01  [TP_040_T]  377.19 247.65 0 top
UNK4TP_DPS2  TP01  [TP_040_T]  353.93 277.62 0 top
UNK4TP_DPS3  TP01  [TP_040_T]  335.42 281.69 0 top
UNK4TP_DPS4  TP01  [TP_040_T]  363.87 277.62 0 top
UNK4TP_DPS5  TP01  [TP_040_T]  341.51 277.62 0 top
UNK4TP_DPS6  TP01  [TP_040_T]  363.87 281.69 0 top
UNK4TP_DPS7  TP01  [TP_040_T]  335.42 277.62 0 top
UNK4TP_DPS8  TP01  [TP_040_T]  347.6 277.62 180 top
UNK4TP_MUX_3V3  TP01  [TP_040_T]  335.65 269.49 180 top
UNK4U17  XC6203E-0.4A-33-SOT89  [SOT89]  470.42 227.24 180 bottom
UNK4U18  SK-SO8-1.27-DEDIPROG-V2  [SK_SO8_1P27MM_DEDIPROG_V2]  461.07 234.57 270 bottom
UNK4U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  480.18 234.57 270 bottom
UNK4U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  346.08 234.5 90 bottom
UNK4U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  341.84 264.24 180 bottom
UNK4U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  333.16 249.72 180 bottom
UNK4U409  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  333.16 238.15 180 bottom
UNK4U449  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  351.94 269.73 270 bottom
UNK4U450  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  359.08 268.86 270 bottom
UNK4U451  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  365.35 268.86 270 bottom
UNK4U452  TS3USB3000RSER-UQFN10  [UQFN2P05X1P55_10P_0P5MM]  366.15 272.67 270 bottom
UNK4Y1  XTAL24M-S5032-SIWARD-12P  [XTAL_S_DUAL1]  354.01 221.07 0 bottom
UNK4Y2  XTAL32.768K-S3215-MCD-12.5P  [XTAL_3P2X1P5MM_2P_MC]  351.94 265.49 180 bottom
UNK5BD9  BD120-1.5A-S4-MU  [FB0402]  224.66 183.84 270 bottom
UNK5BD21  BD120-1.5A-S4-MU  [FB0402]  222.95 172.36 0 bottom
UNK5BD1728  BD120-1.5A-S4-MU  [FB0402]  229.83 211.82 270 bottom
UNK5BD1729  BD120-1.5A-S4-MU  [FB0402]  236.97 210.94 270 bottom
UNK5BDB5  BD120-1.5A-S4-MU  [FB0402]  211.03 186.46 0 bottom
UNK5BDB6  BD120-1.5A-S4-MU  [FB0402]  211.03 174.89 0 bottom
UNK5C262  0.1U-16-X7S-S2-MU  [C0201]  224.41 172.06 270 bottom
UNK5C264  NC/10U-16-X7R-S8-SS  [C0805]  227.48 209.95 90 bottom
UNK5C267  33P-50-N-S2-MU  [C0201]  236.23 164.18 270 bottom
UNK5C268  33P-50-N-S2-MU  [C0201]  235.23 164.18 270 bottom
UNK5C270  NC/10U-16-X7R-S8-SS  [C0805]  224.95 199 0 bottom
UNK5C271  12P-50-N-S4-MU  [C0402]  232.95 207.19 180 bottom
UNK5C272  12P-50-N-S4-MU  [C0402]  230.93 207.19 0 bottom
UNK5C278  1U-10-X7S-S4-TDK  [C0402]  228.79 139.96 180 bottom
UNK5C279  1U-10-X7S-S4-TDK  [C0402]  228.79 141.15 180 bottom
UNK5C280  0.1U-16-X-S4-MU  [C0402]  228.79 142.35 180 bottom
UNK5C281  0.1U-16-X-S4-MU  [C0402]  228.79 143.54 180 bottom
UNK5C282  1U-10-X7S-S4-TDK  [C0402]  222.96 146.59 90 bottom
UNK5C283  0.1U-16-X-S4-MU  [C0402]  224.12 146.59 90 bottom
UNK5C284  1U-10-X7S-S4-TDK  [C0402]  224.04 135.22 270 bottom
UNK5C285  0.1U-16-X-S4-MU  [C0402]  222.85 135.22 270 bottom
UNK5C286  0.1U-16-X-S4-MU  [C0402]  227.84 135.72 0 bottom
UNK5C288  1000P-50-X7R-S2-MU  [C0201]  228.17 137.5 90 bottom
UNK5C289  0.1U-16-X-S4-MU  [C0402]  230.45 138.26 90 bottom
UNK5C290  NC/0.1U-16-X7R-S4-TY  [C0402]  237.31 137.04 0 bottom
UNK5C298  0.1U-16-X7S-S2-MU  [C0201]  238.71 140.42 270 bottom
UNK5C299  0.1U-16-X7S-S2-MU  [C0201]  241.64 136.1 0 bottom
UNK5C300  0.1U-16-X-S4-MU  [C0402]  240.99 142.2 90 bottom
UNK5C301  1U-10-X7S-S4-TDK  [C0402]  242.15 142.2 90 bottom
UNK5C302  10P-50-N-S2-MU  [C0201]  214.98 183.61 0 bottom
UNK5C309  10P-50-N-S2-MU  [C0201]  214.98 195.18 0 bottom
UNK5C310  10P-50-N-S2-MU  [C0201]  213.69 195.18 180 bottom
UNK5C318  10P-50-N-S2-MU  [C0201]  211.94 195.18 0 bottom
UNK5C320  10P-50-N-S2-MU  [C0201]  213.69 183.61 180 bottom
UNK5C332  2.2U-16-X7R-S6-TY  [C0603]  109.1 163.15 270 bottom
UNK5C333  0.1U-16-X-S4-MU  [C0402]  107.7 163.33 270 bottom
UNK5C334  10U-16-X7R-S8-SS  [C0805]  100.08 163.03 90 bottom
UNK5C335  0.1U-16-X-S4-MU  [C0402]  101.74 162.85 90 bottom
UNK5C336  4.7U-25-X7R-S8-TY  [C0805]  87.58 176.79 270 bottom
UNK5C337  0.1U-16-X-S4-MU  [C0402]  87.6 174.24 180 bottom
UNK5C338  4.7U-25-X7R-S8-TY  [C0805]  106 176.79 270 bottom
UNK5C339  0.1U-16-X-S4-MU  [C0402]  106.03 174.24 180 bottom
UNK5C475  4.7U-6.3-X-S4-MU  [C0402]  225.86 205.11 270 bottom
UNK5C476  1U-10-X7S-S4-TDK  [C0402]  219 208.25 90 bottom
UNK5C477  10U-25-X-S6-MU  [C0603]  220.32 208.76 90 bottom
UNK5C478  22U-16-X5R-SA-SS  [C1206]  223.32 208.5 0 bottom
UNK5C922  0.1U-16-X-S4-MU  [C0402]  213.16 186.46 0 bottom
UNK5C923  0.1U-16-X-S4-MU  [C0402]  213.16 174.89 0 bottom
UNK5C924  10P-50-N-S2-MU  [C0201]  211.94 183.61 0 bottom
UNK5C1066  0.01U-10-X7R-S2-YA  [C0201]  244.98 214.19 0 bottom
UNK5C1067  0.01U-10-X7R-S2-YA  [C0201]  246.33 214.19 180 bottom
UNK5C1074  0.1U-16-X7S-S2-MU  [C0201_MINI]  229.58 210.27 180 bottom
UNK5C1077  0.1U-16-X7S-S2-MU  [C0201_MINI]  236.72 209.49 180 bottom
UNK5C1080  0.1U-16-X7S-S2-MU  [C0201_MINI]  242.99 209.49 180 bottom
UNK5C1081  0.1U-16-X7S-S2-MU  [C0201_MINI]  243.8 213.3 180 bottom
UNK5CA1  0.1U-16-X-S4-MU  [C0402]  221.73 155.04 0 bottom
UNK5CA2  10U-25-X7R-SA  [C1206]  221.73 157.07 0 bottom
UNK5CA7  10U-25-X7R-SA  [C1206]  241 154.53 0 bottom
UNK5CA8  0.1U-16-X-S4-MU  [C0402]  241 152.5 0 bottom
UNK5CA19  470U-25-E-S10.4X10.4  [EC_10P3X10_S]  214.88 143.83 180 bottom
UNK5CA20  10U-25-X7R-SA  [C1206]  231.37 153.01 0 bottom
UNK5CA21  0.1U-16-X-S4-MU  [C0402]  231.37 150.98 0 bottom
UNK5CA22  10U-25-X7R-SA  [C1206]  241 149.86 0 bottom
UNK5CA23  0.1U-16-X-S4-MU  [C0402]  241 147.83 0 bottom
UNK5CA24  10U-25-X7R-SA  [C1206]  221.73 153.01 0 bottom
UNK5CA25  0.1U-16-X-S4-MU  [C0402]  221.73 150.98 0 bottom
UNK5CA26  10U-25-X7R-SA  [C1206]  226.55 157.07 0 bottom
UNK5CA27  0.1U-16-X-S4-MU  [C0402]  226.55 155.04 0 bottom
UNK5CA34  10U-25-X7R-SA  [C1206]  245.82 154.53 0 bottom
UNK5CA35  0.1U-16-X-S4-MU  [C0402]  245.82 152.5 0 bottom
UNK5CA36  0.1U-16-X-S4-MU  [C0402]  226.55 150.98 0 bottom
UNK5CA37  10U-25-X7R-SA  [C1206]  226.55 153.01 0 bottom
UNK5CC1  0.1U-16-X7S-S2-MU  [C0201]  230.19 186.91 180 bottom
UNK5CC2  0.1U-16-X7S-S2-MU  [C0201]  230.5 190.48 90 bottom
UNK5CC3  0.1U-16-X7S-S2-MU  [C0201]  228.87 185.61 180 bottom
UNK5CC4  0.1U-16-X7S-S2-MU  [C0201]  230.19 186.26 180 bottom
UNK5CC5  0.1U-16-X7S-S2-MU  [C0201]  231.16 186.56 90 bottom
UNK5CC6  0.1U-16-X7S-S2-MU  [C0201]  228.87 184.96 180 bottom
UNK5CC7  0.1U-16-X7S-S2-MU  [C0201]  232.14 184.96 0 bottom
UNK5CC8  0.1U-16-X7S-S2-MU  [C0201]  230.5 183.97 270 bottom
UNK5CC9  0.1U-16-X7S-S2-MU  [C0201]  231.16 183.97 270 bottom
UNK5CC12  0.1U-16-X7S-S2-MU  [C0201]  229.86 184.62 270 bottom
UNK5CC13  0.1U-16-X7S-S2-MU  [C0201]  228.24 181.06 180 bottom
UNK5CC14  0.1U-16-X7S-S2-MU  [C0201]  231.46 185.61 0 bottom
UNK5CC15  0.1U-16-X7S-S2-MU  [C0201]  230.19 185.61 180 bottom
UNK5CC16  0.1U-16-X7S-S2-MU  [C0201]  230.84 184.96 180 bottom
UNK5CC70  0.1U-16-X7S-S2-MU  [C0201]  232.46 182.67 270 bottom
UNK5CC71  0.1U-16-X7S-S2-MU  [C0201]  235.38 183 0 bottom
UNK5CC73  0.1U-16-X7S-S2-MU  [C0201]  227.91 182.68 90 bottom
UNK5CC84  0.1U-16-X7S-S2-MU  [C0201]  233.11 190.48 90 bottom
UNK5CC85  0.1U-16-X7S-S2-MU  [C0201]  231.15 190.48 90 bottom
UNK5CC86  0.1U-16-X7S-S2-MU  [C0201]  232.46 190.48 90 bottom
UNK5CC87  0.1U-16-X7S-S2-MU  [C0201]  232.14 186.26 180 bottom
UNK5CC88  0.1U-16-X7S-S2-MU  [C0201]  233.11 184 270 bottom
UNK5CC89  0.1U-16-X7S-S2-MU  [C0201]  227.91 184.66 270 bottom
UNK5CC90  0.1U-16-X7S-S2-MU  [C0201]  231.8 190.48 90 bottom
UNK5CC91  0.1U-16-X7S-S2-MU  [C0201]  234.06 183.65 0 bottom
UNK5CC92  0.1U-16-X7S-S2-MU  [C0201]  232.45 184 270 bottom
UNK5CC96  0.1U-16-X7S-S2-MU  [C0201]  231.51 187.56 180 bottom
UNK5CC101  0.1U-16-X7S-S2-MU  [C0201]  230.84 180.4 0 bottom
UNK5CC103  0.1U-16-X7S-S2-MU  [C0201]  231.81 182.02 90 bottom
UNK5CC105  0.1U-16-X7S-S2-MU  [C0201]  232.46 180.72 270 bottom
UNK5CC107  0.1U-16-X7S-S2-MU  [C0201]  232.76 181.7 0 bottom
UNK5CC112  0.1U-16-X7S-S2-MU  [C0201]  235.06 190.48 90 bottom
UNK5CC130  0.1U-16-X7S-S2-MU  [C0201]  228.24 181.7 180 bottom
UNK5CC133  1U-6.3-X7T-S2-MU  [C0201]  227.26 178.78 270 bottom
UNK5CC134  NC/0.1U-10-X7R-S2-MU  [C0201]  227.91 178.78 270 bottom
UNK5CC182  0.1U-16-X7S-S2-MU  [C0201]  226.61 190.48 90 bottom
UNK5CC194  0.1U-16-X7S-S2-MU  [C0201]  231.49 183 180 bottom
UNK5CC202  0.1U-16-X7S-S2-MU  [C0201]  226.28 185.61 180 bottom
UNK5CC203  0.1U-16-X7S-S2-MU  [C0201]  229.86 179.42 270 bottom
UNK5CC204  0.1U-16-X7S-S2-MU  [C0201]  230.51 179.42 270 bottom
UNK5CC205  0.1U-16-X7S-S2-MU  [C0201]  231.16 179.42 270 bottom
UNK5CC208  0.1U-16-X7S-S2-MU  [C0201]  227.57 186.26 180 bottom
UNK5CC209  0.1U-16-X7S-S2-MU  [C0201]  228.23 187.56 180 bottom
UNK5CC210  0.1U-16-X7S-S2-MU  [C0201]  229.53 180.41 180 bottom
UNK5CC211  0.1U-16-X7S-S2-MU  [C0201]  230.5 182.02 90 bottom
UNK5CC212  0.1U-16-X7S-S2-MU  [C0201]  229.53 181.06 180 bottom
UNK5CC213  0.1U-16-X7S-S2-MU  [C0201]  231.16 182.02 90 bottom
UNK5CC215  0.1U-16-X7S-S2-MU  [C0201]  231.81 179.42 90 bottom
UNK5CC216  0.1U-16-X7S-S2-MU  [C0201]  228.56 178.78 270 bottom
UNK5K2  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  119.04 184.6 90 bottom
UNK5K3  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  112.69 184.6 90 bottom
UNK5K4  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  106.34 184.6 90 bottom
UNK5K5  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  99.99 184.6 90 bottom
UNK5K6  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  93.64 184.6 90 bottom
UNK5K7  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  87.29 184.6 90 bottom
UNK5K29  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  231.94 198.56 90 bottom
UNK5K32  G6K-2F-Y-5V-A  [RL_G6K2F-Y_5V_OMRON]  235.73 171.79 270 bottom
UNK5K34  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  166.88 244.86 90 bottom
UNK5K39  UA2-5NE-A-V3  [RL_NECUA2_5V_V3]  224.66 164.54 180 bottom
UNK5K96  EC2-5NJ  [RL_NECEC2_10P_5V]  215.03 157.73 90 bottom
UNK5K107  G6K-2P-Y5VDC-A  [RL_OMRONG6K2PY_5V]  166.88 257.05 90 bottom
UNK5K113  MFS-E1T05G-A  [RL_MFS-E1T-G_5V]  245.11 161.36 0 bottom
UNK5MBD1  BD120-1.5A-S4-MU  [FB0402]  238.71 138.77 90 bottom
UNK5MK1  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  235.79 144.74 0 bottom
UNK5MK2  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  235.79 139.4 0 bottom
UNK5MK3  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  235.79 147.28 0 bottom
UNK5MK4  AQY221R2MY-V2  [RL_AQY221R2MY_5V_V2]  235.79 142.07 0 bottom
UNK5MR1  1M-1-S4  [R0402_UNBGA_V2]  225.44 146.59 90 bottom
UNK5MR2  1K-0.01-S4  [R0402_UNBGA_V2]  225.75 135.72 0 bottom
UNK5MR3  1K-0.01-S4  [R0402_UNBGA_V2]  227.84 134.7 0 bottom
UNK5MR4  1K-0.01-S4  [R0402_UNBGA_V2]  227.84 133.69 0 bottom
UNK5MR5  1K-0.01-S4  [R0402_UNBGA_V2]  225.75 133.69 180 bottom
UNK5MR6  1K-0.01-S4  [R0402_UNBGA_V2]  225.75 134.7 180 bottom
UNK5MR7  332K-1-S4  [R0402_UNBGA_V2]  226.45 147.44 270 bottom
UNK5MR8  1K-0.01-S4  [R0402_UNBGA_V2]  237.31 133.69 0 bottom
UNK5MR9  499-0.1-S4  [R0402]  237.31 134.8 0 bottom
UNK5MR10  0-5-S4  [R0402]  237.31 135.92 180 bottom
UNK5MR11  750-1-S4  [R0402]  232.36 144.1 0 bottom
UNK5MR12  360-1-S6  [R0603]  231.98 145.37 0 bottom
UNK5MR13  750-1-S4  [R0402]  232.36 138.77 0 bottom
UNK5MR14  1.2K-1-S4  [R0402]  232.61 146.64 180 bottom
UNK5MR15  360-1-S6  [R0603]  231.98 140.04 0 bottom
UNK5MR16  750-1-S4  [R0402]  232.36 141.43 0 bottom
UNK5MR17  360-1-S6  [R0603]  231.98 142.7 0 bottom
UNK5MR18  11K-0.1-S4  [R0402]  239.85 142.2 90 bottom
UNK5MR19  1K-0.01-S4  [R0402_UNBGA_V2]  238.71 142.2 270 bottom
UNK5MU1  KSMT002-0.15A-A-SC70-5  [SC70_5P]  228.51 145.44 270 bottom
UNK5MU2  KSMT004-SO8  [SO8_244X127MM]  223.6 141.05 270 bottom
UNK5MU3  KSMT003-MSOP8  [SO8_172X0P65MM]  232.74 135.59 0 bottom
UNK5MU4  MAX6070AAUT30+T-SOT23  [SOT23_6P_0P95X2P7MM_H1P45MM]  240.99 138.77 180 bottom
UNK5R135  0-5-S4  [R0402]  238.73 165.44 180 bottom
UNK5R136  1M-1-S4  [R0402]  235.73 165.44 0 bottom
UNK5R137  0-5-S4  [R0402]  232.73 165.44 0 bottom
UNK5R160  38.3-1-S2  [R0201_MINI]  223.52 175.18 0 bottom
UNK5R161  38.3-1-S2  [R0201_MINI]  223.52 174.62 0 bottom
UNK5R162  4.7K-1-S2  [R0201_MINI]  228.01 174.55 90 bottom
UNK5R163  0-5-S2  [R0201_MINI]  223.52 173.14 0 bottom
UNK5R164  0-5-S2  [R0201_MINI]  223.52 174.06 0 bottom
UNK5R165  0-5-S2  [R0201_MINI]  228.01 173.55 90 bottom
UNK5R168  42.2-1-S2  [R0201]  213.99 194.16 90 bottom
UNK5R170  42.2-1-S2  [R0201]  213.29 194.16 90 bottom
UNK5R172  0-5-S2  [R0201]  214.96 192.79 0 top
UNK5R176  42.2-1-S2  [R0201]  211.64 194.16 90 bottom
UNK5R178  42.2-1-S2  [R0201]  212.33 194.16 90 bottom
UNK5R180  42.2-1-S2  [R0201]  213.99 182.6 90 bottom
UNK5R182  42.2-1-S2  [R0201]  213.29 182.6 90 bottom
UNK5R200  4.7K-1-S2  [R0201]  102.68 172.97 180 bottom
UNK5R201  0-5-S4  [R0402]  87.6 172.97 180 bottom
UNK5R202  NC/4.7K-1-S4  [R0402]  87.6 171.7 180 bottom
UNK5R203  4.7K-1-S2  [R0201]  102.68 170.43 180 bottom
UNK5R204  0-5-S4  [R0402]  106.28 172.97 180 bottom
UNK5R205  4.7K-1-S2  [R0201]  122.48 172.97 180 bottom
UNK5R206  NC/4.7K-1-S4  [R0402]  106.28 171.7 180 bottom
UNK5R207  4.7K-1-S2  [R0201]  122.48 170.43 180 bottom
UNK5R331  10K-1-S2-WA  [R0201]  240.04 135.77 90 bottom
UNK5R509  0-5-S4  [R0402]  219 204.31 90 bottom
UNK5R510  1.2K-1-S4  [R0402]  224.69 205.11 270 bottom
UNK5R511  523-1-S4  [R0402]  225.19 202.36 0 bottom
UNK5R512  0-5-S8  [R0805]  227.48 206.24 270 bottom
UNK5R646  42.2-1-S2  [R0201]  214.68 194.16 90 bottom
UNK5R647  42.2-1-S2  [R0201]  215.38 194.16 90 bottom
UNK5R652  1M-1-S4  [R0402]  230.85 213.67 90 bottom
UNK5R659  10K-1-S2-WA  [R0201]  213.54 190.99 90 top
UNK5R661  4.7K-1-S2  [R0201]  212.78 190.99 270 top
UNK5R662  0-5-S2  [R0201]  214.96 181.23 0 top
UNK5R663  4.7K-1-S2  [R0201]  212.78 179.42 270 top
UNK5R664  42.2-1-S2  [R0201]  212.33 182.6 90 bottom
UNK5R666  42.2-1-S2  [R0201]  211.64 182.6 90 bottom
UNK5R672  10K-1-S2-WA  [R0201]  213.54 179.42 90 top
UNK5R849  100-1-S4  [R0402]  238.58 211.17 0 bottom
UNK5R923  1M-1-S4  [R0402]  232 213.67 90 bottom
UNK5R973  NC/0-5-S4  [R0402]  231.42 212.04 0 bottom
UNK5R980  10K-1-S2-WA  [R0201]  233.66 209.4 90 bottom
UNK5R981  NC/4.7K-1-S2  [R0201]  229.83 209.4 270 bottom
UNK5R982  0-5-S2  [R0201]  229.53 208.44 0 bottom
UNK5R983  10K-1-S2-WA  [R0201]  240.81 208.52 90 bottom
UNK5R984  NC/4.7K-1-S2  [R0201]  236.97 208.52 270 bottom
UNK5R985  0-5-S2  [R0201]  236.67 207.56 0 bottom
UNK5R986  10K-1-S2-WA  [R0201]  247.07 208.52 90 bottom
UNK5R987  NC/4.7K-1-S2  [R0201]  243.24 208.52 270 bottom
UNK5R988  0-5-S2  [R0201]  242.94 207.56 0 bottom
UNK5R989  10K-1-S2-WA  [R0201]  247.88 212.33 90 bottom
UNK5R990  NC/4.7K-1-S2  [R0201]  244.05 212.33 270 bottom
UNK5R991  0-5-S2  [R0201]  243.75 211.37 0 bottom
UNK5R1088  42.2-1-S2  [R0201]  214.68 182.6 90 bottom
UNK5R1089  42.2-1-S2  [R0201]  215.38 182.6 90 bottom
UNK5R1090  240-1-S4  [R0402]  222.76 179.01 180 bottom
UNK5R1091  59-1-S4  [R0402]  242.07 164.79 180 bottom
UNK5TP_DPS1  TP01  [TP_040_T]  220.48 157.07 0 top
UNK5TP_DPS2  TP01  [TP_040_T]  225.3 157.07 180 top
UNK5TP_DPS3  TP01  [TP_040_T]  230.12 153.01 180 top
UNK5TP_DPS4  TP01  [TP_040_T]  244.57 154.53 0 top
UNK5TP_DPS5  TP01  [TP_040_T]  239.75 149.86 0 top
UNK5TP_DPS6  TP01  [TP_040_T]  239.75 154.53 0 top
UNK5TP_DPS7  TP01  [TP_040_T]  220.48 153.01 0 top
UNK5TP_DPS8  TP01  [TP_040_T]  225.3 153.01 180 top
UNK5TP_MUX_3V3  TP01  [TP_040_T]  215.65 209.49 180 top
UNK5U17  XC6203E-0.4A-33-SOT89  [SOT89]  104.66 163.74 180 bottom
UNK5U18  SK-SO8-1.27-DEDIPROG-V2  [SK_SO8_1P27MM_DEDIPROG_V2]  95.31 171.07 270 bottom
UNK5U19  SK-SO8-1.27-ICSOCKET-6X8-V2  [SK_SO8_1P27MM_SDQ54CBAA_V2]  114.42 171.07 270 bottom
UNK5U31  FSUSB73UMX-UMLP16  [SW_UMLP2P6X1P8_12P_0P4MM]  226.08 174.5 90 bottom
UNK5U108  R1173H001B-1A-A-SOT-89-5  [SOT_89_5]  221.84 204.24 180 bottom
UNK5U408  CBTL06GP213EE-TFBGA50  [TFBGA9X9_50P_0P5MM]  213.16 189.72 180 bottom
