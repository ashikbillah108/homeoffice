# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Nets (continued)
Pads without a net: BGA234-11X11-P0.65 1; CSDPS303 A17 B17 C17 D17; CSDPS307 A17 B17 C17 D17; CSDPS310 A17 B17 C17 D17; CSDPS314 A17 B17 C17 D17; CSDPS319 A17 B17 C17 D17; CSDPS323 A17 B17 C17 D17; CSDPS426 A17 D17; CSDPS430 A17 D17; D101 17 A17 B17; D102 17 A17 B17; D103 17 A17 B17; D104 17 A17 B17; D105 17 A17 B17; D106 17 A17 B17; D107 17 A17 B17; D108 17 A17 B17; D109 17 A17 B17; D110 17 A17 B17; D111 17 A17 B17; D112 17 A17 B17; D113 17 A17 B17; D114 17 A17 B17; D115 17 A17 B17; D116 17 A17 B17; D117 17 A17 B17; D118 17 A17 B17; D119 17 A17 B17; D120 17 A17 B17; D121 17 A17 B17; D122 17 A17 B17; D123 17 A17 B17; D124 17 A17 B17; D125 17 A17 B17; D126 17 A17 B17; D127 17 A17 B17; D128 17 A17 B17; D129 17 A17 B17; D130 17 A17 B17; D131 17 A17 B17; D132 17 A17 B17; D201 17 A17 B17; D202 17 A17 B17; D203 17 A17 B17; D204 17 A17 B17; D205 17 A17 B17; D206 17 A17 B17; D207 17 A17 B17; D208 17 A17 B17; D209 17 A17 B17; D210 17 A17 B17; D211 17 A17 B17; D212 17 A17 B17; D213 17 A17 B17; D214 17 A17 B17; D215 17 A17 B17; D216 17 A17 B17; D217 17 A17 B17; D218 17 A17 B17; D219 17 A17 B17; D220 17 A17 B17; D221 17 A17 B17; D222 17 A17 B17; D223 17 A17 B17; D224 17 A17 B17; D225 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D226/D626 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16; D227 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17; D228 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17; D229 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D230/D630 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16; D325 17 A17 B17; D326 17 A17 B17; D327 17 A17 B17; D328 17 A17 B17; D329 17 A17 B17; D330 17 A17 B17; D331 17 A17 B17; D332 17 A17 B17; D409 17 A17 B17; D410 17 A17 B17; D411 17 A17 B17; D412 17 A17 B17; D413 17 A17 B17; D414 17 A17 B17; D415 17 A17 B17; D416 17 A17 B17; D417 17 A17 B17; D418 17 A17 B17; D419 17 A17 B17; D420 17 A17 B17; D421 17 A17 B17; D422 17 A17 B17; D423 17 A17 B17; D424 17 A17 B17; D425 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; D427 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17; D428 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17; D429 01 02 03 04 05 06 07 08 09 10 11 12 13 14 15 16 17 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17; DPS1 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS2 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS3 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS8 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; FD7 1; FD8 1; FD9 1; FD10 1; FD11 1; FD12 1; FD13 1; FD14 1; FD15 1; FD16 1; JP1 1 NC1 NC2; K34 5 6 7; K96 3 10; K107 7; LOGO1 1; LOGO2 1; MU2 1 3 5 7 8; MU3 1 5 8; SCREW1 GH1 GH2 GH3 GH4; SITE1 NUT1 NUT2 NUT3 NUT4; SITE2 NUT1 NUT2 NUT3 NUT4; SITE3 NUT1 NUT2 NUT3 NUT4; SITE4 NUT1 NUT2 NUT3 NUT4; SITE5 NUT1 NUT2 NUT3 NUT4; SITE6 NUT1 NUT2 NUT3 NUT4; SITE7 NUT1 NUT2 NUT3 NUT4; SITE8 NUT1 NUT2 NUT3 NUT4; SSI6D50D 1; SW5 1 2 3 4 5 7 8; SW10 6 7 8; U31 11 12 13 14; U72 4 5 6 7 10 11 12 13; U74 4 5 6 7 10 11 12 13; U75 4 5 6 7 10 11 12 13; U77 4 5 6 7 10 11 12 13; U80 4 5 6 7 10 11 12 13; U405 4 5 6 7 10 11 12 13; U408 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; U409 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; U413 4 5 6 7 10 11 12 13; U415 4 5 6 7 10 11 12 13; U435 3 5 6 7 8 9 11 12 13 14 15 17; U452 3 4; U453 3 4 5 6 7 10 11 12 13 14; U454 5 6 8 9 10 11 12 13; UNK2K34 5 6 7; UNK2K96 3 10; UNK2K107 7; UNK2MU2 1 3 5 7 8; UNK2MU3 1 5 8; UNK2U31 11 12 13 14; UNK2U408 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK2U409 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK2U452 3 4; UNK3K34 5 6 7; UNK3K96 3 10; UNK3K107 7; UNK3MU2 1 3 5 7 8; UNK3MU3 1 5 8; UNK3U31 11 12 13 14; UNK3U408 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK3U409 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK3U452 3 4; UNK4K34 5 6 7; UNK4K96 3 10; UNK4K107 7; UNK4MU2 1 3 5 7 8; UNK4MU3 1 5 8; UNK4U31 11 12 13 14; UNK4U408 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK4U409 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK4U452 3 4; UNK5K34 5 6 7; UNK5K96 3 10; UNK5K107 7; UNK5MU2 1 3 5 7 8; UNK5MU3 1 5 8; UNK5U31 11 12 13 14; UNK5U408 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK5U409 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK5U452 3 4; UNK6K34 5 6 7; UNK6K96 3 10; UNK6K107 7; UNK6MU2 1 3 5 7 8; UNK6MU3 1 5 8; UNK6U31 11 12 13 14; UNK6U408 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK6U409 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK6U452 3 4; UNK7K34 5 6 7; UNK7K96 3 10; UNK7K107 7; UNK7MU2 1 3 5 7 8; UNK7MU3 1 5 8; UNK7U31 11 12 13 14; UNK7U408 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK7U409 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK7U452 3 4; UNK8K34 5 6 7; UNK8K96 3 10; UNK8K107 7; UNK8MU2 1 3 5 7 8; UNK8MU3 1 5 8; UNK8U31 11 12 13 14; UNK8U408 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK8U409 A8 A9 F1 F2 F8 F9 H1 H2 H3 H5 H6 H8 H9 J1 J2 J3 J5 J6 J7 J8 J9; UNK8U452 3 4; UNK038XS-SI6D5018Q-A100 1; UNK980XS-SI6D50-1AG- 1; UTL1 A17 B17; UTL2 A17 B17; UTL3 A17 B17; UTL4 A17 B17; UTL5 A17 B17; UTL6 A17 B17; UTL7 A17 B17; UTL8 A17 B17; VP1 1; WW71169460 1

## Via types
v1: diameter 0.399, hole 0.203, TOP to BOTTOM, 392 vias
v2: diameter 0.406, hole 0.203, TOP to BOTTOM, 5537 vias
v3: diameter 0.61, hole 0.305, TOP to BOTTOM, 8016 vias
v4: diameter 0.457, hole 0.203, TOP to BOTTOM, 8 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
DGND: length 1420.9
  TOP w0.305: v1(334.16,191.22) 334.09,191.29 UNK8R659.2 ; UNK5R672.2 214.09,179.72 v1(214.16,179.65) ; RD3.1 v3(286.56,292.8) RD5.1 ; v1(334.16,239.65) 334.09,239.72 UNK4R672.2 ; UNK6R672.2 254.09,179.72 v1(254.16,179.65) ; UNK5R659.2 214.09,191.29 v1(214.16,191.22) ; R659.2 214.09,251.29 v1(214.16,251.22) ; UNK6R659.2 254.09,191.29 v1(254.16,191.22) ; v1(254.16,239.65) 254.09,239.72 UNK2R672.2 ; UNK2R659.2 254.09,251.29 v1(254.16,251.22) ; v1(294.16,239.65) 294.09,239.72 UNK3R672.2 ; UNK4R659.2 334.09,251.29 v1(334.16,251.22) ; UNK7R659.2 294.09,191.29 v1(294.16,191.22) ; CD2.1 v3(465.17,277.12) ; R672.2 214.09,239.72 v1(214.16,239.65) ; v1(294.16,179.65) 294.09,179.72 UNK7R672.2 ; v1(294.16,251.22) 294.09,251.29 UNK3R659.2 ; CD1.1 v3(295.73,295.34) 295.72,295.33 U14.7 ; UNK8R672.2 334.09,179.72 v1(334.16,179.65) ; RD13.1 v3(458.75,273.15)
  TOP w0.508: UT8_SW2.12 UT8_SW2.11 v3(93.99,421.53) ; v3(116.22,421.53) UT8_SW1.11 UT8_SW1.12 ; UT7_SW1.10 UT7_SW1.9 v3(553.1,421.53) ; UT2_SW2.10 UT2_SW2.9 v3(345.43,7.73) ; UT2_SW1.16 UT2_SW1.15 v3(307.96,7.73) ; v3(160.64,7.73) UT1_SW1.15 UT1_SW1.16 ; v3(251.47,421.53) UT4_SW2.15 UT4_SW2.16 ; v3(558.18,421.53) UT7_SW1.11 UT7_SW1.12 ; v3(465.17,277.12) 465.16,277.11 U15.7 ; v3(193.03,7.73) UT1_SW2.11 UT1_SW2.12 ; UT2_SW2.16 UT2_SW2.15 v3(330.19,7.73) ; v3(318.12,7.73) UT2_SW1.11 UT2_SW1.12 ; v3(470.52,7.73) UT6_SW1.9 UT6_SW1.10 ; UT8_SW1.16 UT8_SW1.15 v3(126.38,421.53) ; v3(487.67,7.73) UT6_SW2.11 UT6_SW2.12 ; UT6_SW2.14 UT6_SW2.13 v3(482.59,7.73) ; v3(236.23,421.53) UT4_SW2.9 UT4_SW2.10 ; v2(347.1,210.9) v2(347.86,210.9) ; v3(393.71,421.53) UT3_SW2.13 UT3_SW2.14 ; UT1_SW2.16 UT1_SW2.15 v3(182.87,7.73) ; UT4_SW1.16 UT4_SW1.15 v3(273.7,421.53) ; v3(294.88,138.31) v3(294.88,139.58) v3(294.88,140.85) ; v2(265.9,199.38) v2(265.9,198.62) ; v3(35.55,7.73) UT5_SW2.15 UT5_SW2.16 ; v2(345.9,259.38) v2(345.9,258.62) ; UT4_SW1.12 UT4_SW1.11 v3(263.54,421.53) ; UT4_SW1.10 UT4_SW1.9 v3(258.46,421.53) ; v3(121.3,421.53) UT8_SW1.13 UT8_SW1.14 ; v3(535.95,421.53) UT7_SW2.11 UT7_SW2.12 ; UT4_SW2.14 UT4_SW2.13 v3(246.39,421.53) ; v3(23.48,7.73) UT5_SW1.11 UT5_SW1.12 ; v3(563.26,421.53) UT7_SW1.13 UT7_SW1.14 ; UT3_SW1.10 UT3_SW1.9 v3(405.78,421.53) ; v3(546.11,421.53) UT7_SW2.15 UT7_SW2.16 ; v3(383.55,421.53) UT3_SW2.9 UT3_SW2.10 ; v3(88.91,421.53) UT8_SW2.9 UT8_SW2.10 ; v3(522.35,148.11) v3(524.38,148.11) v3(526.41,148.11) ; v3(13.32,7.73) UT5_SW1.15 UT5_SW1.16 ; v2(267.1,210.9) v2(267.86,210.9) ; UT2_SW2.12 UT2_SW2.11 v3(340.35,7.73) ; v2(305.9,259.38) v2(305.9,258.62) ; v2(307.1,270.9) v2(307.86,270.9) ; v2(227.1,270.9) v2(227.86,270.9) ; UT1_SW2.14 UT1_SW2.13 v3(187.95,7.73) ; v3(541.03,421.53) UT7_SW2.13 UT7_SW2.14 ; v3(334.88,138.31) v3(334.88,139.58) v3(334.88,140.85) ; v2(224.57,269.01) v2(224.57,268) ; v2(267.1,270.9) v2(267.86,270.9) ; v2(345.9,199.38) v2(345.9,198.62) ; v3(477.51,7.73) UT6_SW2.15 UT6_SW2.16 ; UT2_SW1.10 UT2_SW1.9 v3(323.2,7.73) ; v2(344.57,209.01) v2(344.57,208) ; v3(214.88,140.85) v3(214.88,139.58) v3(214.88,138.31) ; UT1_SW2.10 UT1_SW2.9 v3(198.11,7.73) ; v2(264.57,269.01) v2(264.57,268) ; v2(265.9,259.38) v2(265.9,258.62) ; v3(254.88,140.85) v3(254.88,139.58) v3(254.88,138.31) ; v2(305.9,199.38) v2(305.9,198.62) ; v3(175.88,7.73) UT1_SW1.9 UT1_SW1.10 ; v3(40.63,7.73) UT5_SW2.13 UT5_SW2.14 ; v3(111.14,421.53) UT8_SW1.9 UT8_SW1.10 ; UT1_SW1.12 UT1_SW1.11 v3(170.8,7.73) ; UT8_SW2.14 UT8_SW2.13 v3(99.07,421.53) ; v3(455.28,7.73) UT6_SW1.15 UT6_SW1.16 ; v3(165.72,7.73) UT1_SW1.13 UT1_SW1.14 ; UT3_SW2.12 UT3_SW2.11 v3(388.63,421.53) ; v3(519.61,150.83) v3(520.62,150.83) ; v3(104.15,421.53) UT8_SW2.15 UT8_SW2.16 ; UT7_SW1.16 UT7_SW1.15 v3(568.34,421.53) ; v3(241.31,421.53) UT4_SW2.11 UT4_SW2.12 ; v3(421.02,421.53) UT3_SW1.15 UT3_SW1.16 ; UT3_SW2.16 UT3_SW2.15 v3(398.79,421.53) ; v2(304.57,269.01) v2(304.57,268) ; v3(415.94,421.53) UT3_SW1.13 UT3_SW1.14 ; UT4_SW1.14 UT4_SW1.13 v3(268.62,421.53) ; v2(304.57,209.01) v2(304.57,208) ; v2(224.57,209.01) v2(224.57,208) ; UT6_SW1.14 UT6_SW1.13 v3(460.36,7.73) ; v2(344.57,269.01) v2(344.57,268) ; v3(410.86,421.53) UT3_SW1.11 UT3_SW1.12 ; v3(492.75,7.73) UT6_SW2.9 UT6_SW2.10 ; v2(307.1,210.9) v2(307.86,210.9) ; v3(465.44,7.73) UT6_SW1.11 UT6_SW1.12 ; UT5_SW1.14 UT5_SW1.13 v3(18.4,7.73) ; UT2_SW2.14 UT2_SW2.13 v3(335.27,7.73) ; v2(227.1,210.9) v2(227.86,210.9) ; UT5_SW2.12 UT5_SW2.11 v3(45.71,7.73) ; v2(225.9,199.38) v2(225.9,198.62) ; v2(225.9,259.38) v2(225.9,258.62) ; v3(28.56,7.73) UT5_SW1.9 UT5_SW1.10 ; UT7_SW2.10 UT7_SW2.9 v3(530.87,421.53) ; v2(264.57,209.01) v2(264.57,208) ; v3(313.04,7.73) UT2_SW1.13 UT2_SW1.14 ; UT5_SW2.10 UT5_SW2.9 v3(50.79,7.73) ; v2(347.1,270.9) v2(347.86,270.9)
  TOP w0.991: JP1.2 v3(108.41,259.08)
  L03_DPS w0.203: v2(230.76,192.5) 231.39,191.87 5SA2.1 ; 6SA2.1 271.39,191.87 v2(270.76,192.5) ; v2(350.76,192.5) 351.39,191.87 8SA2.1 ; 2SA2.1 v2(267.13,252.15) ; 7SA2.1 311.39,191.87 v2(310.76,192.5) ; 3SA2.1 v2(307.13,252.15) ; SA2.1 v2(227.13,252.15) ; 4SA2.1 v2(347.13,252.15)
  L05_DPS w0.076: 355.97,185.93 352.13,185.93 v2(351.8,186.26) ; v2(351.8,246.26) 352.13,245.93 355.97,245.93 ; v2(311.81,246.26) 312.13,245.93 315.97,245.93 ; 235.97,185.93 232.13,185.93 v2(231.81,186.26) ; 315.97,185.93 312.13,185.93 v2(311.81,186.26) ; 275.97,185.93 272.13,185.93 v2(271.81,186.26) ; v2(271.81,246.26) 272.13,245.93 275.97,245.93 ; v2(231.81,246.26) 232.13,245.93 235.97,245.93
  L05_DPS w0.203: 275.97,245.93 277.49,247.45 2SA15.1 ; v2(306.6,250.8) 304.71,250.8 303.49,249.59 3SA20.1 ; 8SA20.1 343.49,189.59 344.71,190.81 v2(346.6,190.81) ; 355.97,185.93 357.49,187.45 357.49,189.1 359.49,191.1 8SA15.1 ; 2SA20.1 263.49,249.59 264.71,250.8 v2(266.61,250.8) ; 7SA20.1 303.49,189.59 304.71,190.81 v2(306.6,190.81) ; 4SA20.1 343.49,249.59 344.71,250.8 v2(346.6,250.8) ; SA20.1 223.49,249.59 224.71,250.8 v2(226.61,250.8) ; 5SA20.1 223.49,189.59 224.71,190.81 v2(226.61,190.81) ; v2(266.61,190.81) 264.71,190.81 263.49,189.59 6SA20.1 ; 3SA15.1 317.49,247.45 315.97,245.93 ; 235.97,185.93 237.49,187.45 237.49,189.1 239.49,191.1 5SA15.1 ; SA15.1 237.49,247.45 235.97,245.93 ; 4SA15.1 357.49,247.45 355.97,245.93 ; 7SA15.1 319.49,191.1 317.49,189.1 317.49,187.45 315.97,185.93 ; 6SA15.1 279.49,191.1 277.49,189.1 277.49,187.45 275.97,185.93
  L07_DPS w0.203: v2(268.55,238.45) 269.09,237.92 2SA18.1 ; v2(348.55,238.45) 349.09,237.92 4SA18.1 ; SA18.1 229.09,237.92 v2(228.56,238.45) ; 6SA18.1 274.76,192.46 v2(273.11,190.81) ; v2(308.55,238.45) 309.09,237.92 3SA18.1 ; v2(233.11,190.81) 234.76,192.46 5SA18.1 ; 8SA18.1 354.76,192.46 v2(353.1,190.81) ; v2(313.11,190.81) 314.76,192.46 7SA18.1
  L09_DPS w0.076: v2(353.75,241.71) 354.08,241.38 354.08,239.41 354.06,239.39 ; 225.92,241.44 225.98,241.38 227.58,241.38 v2(227.91,241.7) ; v2(313.76,241.71) 314.08,241.38 314.08,239.41 314.06,239.39 ; v2(307.9,241.7) 307.58,241.38 305.98,241.38 305.92,241.44 ; 234.32,178.81 234.32,178.83 234.08,179.07 234.08,181.38 v2(233.76,181.71) ; v2(273.76,241.71) 274.08,241.38 274.08,239.41 274.06,239.39 ; v2(273.76,181.71) 274.08,181.38 274.08,179.07 274.32,178.83 274.32,178.81 ; v2(267.9,181.7) 267.58,181.38 265.55,181.38 ; v2(267.9,241.7) 267.58,241.38 265.98,241.38 265.92,241.44 ; v2(307.9,181.7) 307.58,181.38 305.55,181.38 ; v2(233.76,241.71) 234.08,241.38 234.08,239.41 234.06,239.39 ; 345.92,241.44 345.98,241.38 347.58,241.38 v2(347.9,241.7) ; 354.32,178.81 354.32,178.83 354.08,179.07 354.08,181.38 v2(353.75,181.71) ; v2(347.9,181.7) 347.58,181.38 345.55,181.38 ; v2(227.91,181.7) 227.58,181.38 225.55,181.38 ; v2(313.76,181.71) 314.08,181.38 314.08,179.07 314.32,178.83 314.32,178.81
  L09_DPS w0.203: 225.55,181.38 224.14,181.38 223.4,182.12 5SA7.1 ; 3SA24.1 314.06,239.39 ; 4SA7.1 344.03,242.04 344.51,241.55 345.81,241.55 345.92,241.44 ; 2SA7.1 264.03,242.04 264.51,241.55 265.81,241.55 265.92,241.44 ; 3SA7.1 304.03,242.04 304.51,241.55 305.81,241.55 305.92,241.44 ; 314.32,178.81 7SA24.1 ; 225.92,241.44 225.81,241.55 224.51,241.55 224.03,242.04 SA7.1 ; 8SA7.1 343.4,182.12 344.14,181.38 345.55,181.38 ; 234.32,178.81 5SA24.1 ; 7SA7.1 303.4,182.12 304.14,181.38 305.55,181.38 ; 6SA7.1 263.4,182.12 264.14,181.38 265.55,181.38 ; 354.32,178.81 8SA24.1 ; 234.06,239.39 SA24.1 ; 4SA24.1 354.06,239.39 ; 2SA24.1 274.06,239.39 ; 274.32,178.81 6SA24.1
  L11_DPS w0.076: 274.06,238.81 274.08,238.83 274.08,241.38 v2(273.76,241.71) ; v2(353.75,181.71) 354.08,181.38 354.08,179.45 ; 314.08,179.45 314.08,181.38 v2(313.76,181.71) ; 274.08,179.45 274.08,181.38 v2(273.76,181.71) ; v2(311.81,246.26) 312.13,246.58 316.07,246.58 ; v2(233.76,241.71) 234.08,241.38 234.08,238.83 234.06,238.81 ; v2(271.81,246.26) 272.13,246.58 276.07,246.58 ; 234.08,179.45 234.08,181.38 v2(233.76,181.71) ; v2(310.5,187.56) 310.18,187.88 310.18,189.81 310.12,189.87 ; v2(313.76,241.71) 314.08,241.38 314.08,238.83 314.06,238.81 ; 356.07,246.58 352.13,246.58 v2(351.8,246.26) ; 350.12,189.87 350.18,189.81 350.18,187.88 v2(350.5,187.56) ; v2(270.5,187.56) 270.18,187.88 270.18,189.81 270.12,189.87 ; 354.06,238.81 354.08,238.83 354.08,241.38 v2(353.75,241.71) ; 236.07,246.58 232.13,246.58 v2(231.81,246.26) ; 230.12,189.87 230.18,189.81 230.18,187.88 v2(230.5,187.56)
  L11_DPS w0.203: 234.08,179.45 234.08,178.29 235.03,177.34 5SA10.1 ; SA22.1 240.54,248.67 238.45,246.58 236.07,246.58 ; 8SA22.1 351.75,195.43 349.67,193.35 349.67,190.32 350.12,189.87 ; 354.08,179.45 354.08,178.29 355.03,177.34 8SA10.1 ; SA10.1 232.74,237.49 234.06,238.81 ; 314.08,179.45 314.08,178.29 315.03,177.34 7SA10.1 ; 314.06,238.81 312.74,237.49 3SA10.1 ; 4SA22.1 360.54,248.67 358.45,246.58 356.07,246.58 ; 276.07,246.58 278.45,246.58 280.54,248.67 2SA22.1 ; 2SA10.1 272.74,237.49 274.06,238.81 ; 6SA10.1 275.03,177.34 274.08,178.29 274.08,179.45 ; 7SA22.1 311.75,195.43 309.67,193.35 309.67,190.32 310.12,189.87 ; 230.12,189.87 229.67,190.32 229.67,193.35 231.75,195.43 5SA22.1 ; 4SA10.1 352.74,237.49 354.06,238.81 ; 3SA22.1 320.54,248.67 318.45,246.58 316.07,246.58 ; 6SA22.1 271.75,195.43 269.67,193.35 269.67,190.32 270.12,189.87
  L17_SIGNAL w0.091: 183.91,212.01 183.95,212.01
  BOTTOM w0.16: SC47.2 v3(569.79,147.98) ; SC40.2 v3(543.83,154.6) ; SC30.2 v3(557.97,164.49) ; SC28.2 v3(560.34,171.11) ; SC45.2 v3(557.97,150.18) ; SC33.2 v3(541.46,166.69) ; SC26.2 v3(569.79,166.69) ; SC32.2 v3(553.28,166.69) ; SC36.2 v3(541.46,164.49) ; SC43.2 v3(567.42,154.6) ; SC38.2 v3(553.28,150.18) ; SC29.2 v3(569.79,164.49) ; SC25.2 v3(567.42,171.11) ; SC34.2 v3(543.83,171.11) ; SC37.2 v3(550.91,154.6) ; SC42.2 v3(541.46,147.98) ; SC41.2 v3(553.28,147.98) ; SC48.2 v3(557.97,147.98) ; SC39.2 v3(541.46,150.18) ; SC31.2 v3(550.91,171.11) ; SC35.2 v3(553.28,164.49) ; SC44.2 v3(569.79,150.18) ; SC27.2 v3(557.97,166.69) ; SC46.2 v3(560.34,154.6)
  BOTTOM w0.229: UNK4U31.1 346.68,233.03 346.92,232.8 346.92,232.23 v2(346.81,232.12) ; U31.1 226.68,233.03 226.92,232.8 226.92,232.23 v2(226.81,232.12) ; UNK6U31.1 266.68,173.03 266.92,172.8 266.92,172.23 v2(266.81,172.12) ; UNK2U31.1 266.68,233.03 266.92,232.8 266.92,232.23 v2(266.81,232.12) ; UNK5U31.1 226.68,173.03 226.92,172.8 226.92,172.23 v2(226.81,172.12) ; UNK7U31.1 306.68,173.03 306.92,172.8 306.92,172.23 v2(306.81,172.12) ; UNK3U31.1 306.68,233.03 306.92,232.8 306.92,232.23 v2(306.81,232.12) ; UNK8U31.1 346.68,173.03 346.92,172.8 346.92,172.23 v2(346.81,172.12)
  BOTTOM w0.254: UNK4C1081.2 v2(363.04,273.3) ; v1(254.16,189.22) 254.16,188.97 254.41,188.72 UNK6U408.G2 ; v1(252.16,189.22) 252.16,188.97 251.91,188.72 UNK6U408.G8 ; UNK5U408.G2 214.41,188.72 214.16,188.97 v1(214.16,189.22) ; v1(252.16,237.65) 252.16,237.4 251.91,237.15 v1(251.66,237.15) ; U408.G8 211.91,248.72 212.16,248.97 v1(212.16,249.22) ; U408.G2 214.41,248.72 214.16,248.97 v1(214.16,249.22) ; UNK3U408.G8 291.91,248.72 292.16,248.97 v1(292.16,249.22) ; v2(296.08,182.88) 296.08,183.28 295.74,183.61 UNK7C302.2 ; v1(252.16,249.22) 252.16,248.97 251.91,248.72 UNK2U408.G8 ; v1(332.16,189.22) 332.16,188.97 331.91,188.72 UNK8U408.G8 ; v1(292.16,189.22) 292.16,188.97 291.91,188.72 UNK7U408.G8 ; UNK6C1080.2 v2(282.23,209.49) ; UNK2C1080.2 v2(282.23,269.49) ; v1(292.16,237.65) 292.16,237.4 291.91,237.15 v1(291.66,237.15) ; UNK7MU1.2 v3(310.14,145.44) ; v1(211.66,177.15) 211.91,177.15 212.16,177.4 v1(212.16,177.65) ; v1(252.16,177.65) 252.16,177.4 251.91,177.15 v1(251.66,177.15) ; v2(296.08,242.88) 296.08,243.28 295.74,243.61 UNK3C302.2 ; UNK6C1081.2 v2(283.04,213.3) ; UNK4C302.2 335.74,243.61 336.08,243.28 v2(336.08,242.88) ; UNK7C1077.2 v2(315.97,209.49) ; v1(211.66,237.15) 211.91,237.15 212.16,237.4 v1(212.16,237.65) ; UNK6U409.G2 254.41,177.15 254.16,177.4 v1(254.16,177.65) ; UNK5U408.G8 211.91,188.72 212.16,188.97 v1(212.16,189.22) ; UNK4C1077.2 v2(355.97,269.49) ; UNK6C302.2 255.74,183.61 256.08,183.28 v2(256.08,182.88) ; v1(214.16,177.65) 214.16,177.4 214.41,177.15 UNK5U409.G2 ; v1(291.66,177.15) 291.91,177.15 292.16,177.4 v1(292.16,177.65) ; v2(336.08,182.88) 336.08,183.28 335.74,183.61 UNK8C302.2 ; UNK2C1081.2 v2(283.04,273.3) ; v1(331.66,177.15) 331.91,177.15 332.16,177.4 v1(332.16,177.65) ; UNK2U409.G2 254.41,237.15 254.16,237.4 v1(254.16,237.65) ; UNK3C1080.2 v2(322.23,269.49) ; UNK6C1077.2 v2(275.97,209.49) ; v1(334.16,177.65) 334.16,177.4 334.41,177.15 UNK8U409.G2 ; U409.G2 214.41,237.15 214.16,237.4 v1(214.16,237.65) ; v2(216.08,182.88) 216.08,183.28 215.74,183.61 UNK5C302.2 ; v1(294.16,249.22) 294.16,248.97 294.41,248.72 UNK3U408.G2 ; UNK5C1077.2 v2(235.97,209.49) ; MU1.2 v3(231.52,283.82) ; UNK3U409.G2 294.41,237.15 294.16,237.4 v1(294.16,237.65) ; UNK2MU1.2 v3(271.52,283.82) ; UNK8C1081.2 v2(363.04,213.3) ; UNK3C1081.2 v2(323.04,273.3) ; UNK2C302.2 255.74,243.61 256.08,243.28 v2(256.08,242.88) ; v1(254.16,249.22) 254.16,248.97 254.41,248.72 UNK2U408.G2 ; v2(216.08,242.88) 216.08,243.28 215.74,243.61 C302.2 ; v1(294.16,177.65) 294.16,177.4 294.41,177.15 UNK7U409.G2 ; v1(331.66,237.15) 331.91,237.15 332.16,237.4 v1(332.16,237.65) ; v1(332.16,249.22) 332.16,248.97 331.91,248.72 UNK4U408.G8 ; UNK7C1081.2 v2(323.04,213.3) ; UNK8C1077.2 v2(355.97,209.49) ; UNK2C1077.2 v2(275.97,269.49) ; UNK7U408.G2 294.41,188.72 294.16,188.97 v1(294.16,189.22) ; UNK8C1080.2 v2(362.23,209.49) ; UNK4U409.G2 334.41,237.15 334.16,237.4 v1(334.16,237.65) ; UNK8U408.G2 334.41,188.72 334.16,188.97 v1(334.16,189.22) ; UNK5MU1.2 v3(230.14,145.44) ; C1080.2 v2(242.23,269.49) ; UNK8MU1.2 v3(350.14,145.44) ; UNK5C1080.2 v2(242.23,209.49) ; C1077.2 v2(235.97,269.49) ; UNK7C1080.2 v2(322.23,209.49) ; UNK4C1080.2 v2(362.23,269.49) ; UNK3C1077.2 v2(315.97,269.49) ; UNK3MU1.2 v3(311.52,283.82) ; v1(334.16,249.22) 334.16,248.97 334.41,248.72 UNK4U408.G2 ; C1081.2 v2(243.04,273.3) ; UNK5C1081.2 v2(243.04,213.3) ; UNK6MU1.2 v3(270.14,145.44) ; UNK4MU1.2 v3(351.52,283.82)
  BOTTOM w0.305: v2(247.88,212.63) 247.85,212.67 UNK5U452.5 ; U434.G2 541.05,210.59 U434.1 ; v2(280.81,208.82) 280.77,208.86 UNK6U450.5 ; UNK8MU4.2 v3(360.99,136.1) UNK8C299.1 ; v2(367.07,208.82) 367.04,208.86 UNK8U451.5 ; v2(335.98,194.43) 335.98,194.7 335.71,194.97 335.49,194.97 UNK8C309.2 ; U73.7 81.82,292.07 v3(82.07,291.82) ; UNK2C299.1 v3(260.67,293.16) UNK2MU4.2 ; U434.G1 541.05,207.59 U434.10 ; v2(265.36,232.12) 265,231.76 UNK2C262.2 ; UNK4U450.5 360.77,268.86 v2(360.81,268.82) ; UNK3U450.5 320.77,268.86 v2(320.81,268.82) ; UNK5C299.1 v3(240.99,136.1) UNK5MU4.2 ; v3(82.07,278.11) 81.82,278.36 U79.7 ; v2(320.81,208.82) 320.77,208.86 UNK7U450.5 ; C299.1 v3(220.67,293.16) MU4.2 ; UNK3MU4.2 v3(300.67,293.16) UNK3C299.1 ; v2(255.98,254.43) 255.98,254.7 255.71,254.97 255.49,254.97 UNK2C309.2 ; U450.5 240.77,268.86 v2(240.81,268.82) ; U403.10 541.44,220.92 U403.G1 ; UNK5C309.2 215.49,194.97 215.71,194.97 215.98,194.7 v2(215.98,194.43) ; U76.7 501.65,225.9 v3(501.9,225.65) ; UNK4C262.2 345,231.76 v2(345.36,232.12) ; U435.10 541.05,193.49 U435.G1 ; U434.19 v3(539.65,211.54) ; UNK8C262.2 345,171.76 v2(345.36,172.12) ; UNK2U452.5 287.85,272.67 v2(287.88,272.63) ; U414.7 81.82,264.64 v3(82.07,264.39) ; U435.1 541.05,196.49 U435.G2 ; U452.5 247.85,272.67 v2(247.88,272.63) ; v2(367.88,212.63) 367.85,212.67 UNK8U452.5 ; UNK4U451.5 367.04,268.86 v2(367.07,268.82) ; UNK4C309.2 335.49,254.97 335.71,254.97 335.98,254.7 v2(335.98,254.43) ; UNK5C262.2 225,171.76 v2(225.36,172.12) ; UNK6U451.5 287.04,208.86 v2(287.07,208.82) ; UNK3C309.2 295.49,254.97 295.71,254.97 295.98,254.7 v2(295.98,254.43) ; U70.G2 541.44,236.88 U70.1 ; v2(225.36,232.12) 225,231.76 C262.2 ; v2(327.07,268.82) 327.04,268.86 UNK3U451.5 ; U451.5 247.04,268.86 v2(247.07,268.82) ; UNK3U452.5 327.85,272.67 v2(327.88,272.63) ; C298.1 v3(222.95,287.56) ; UNK7C309.2 295.49,194.97 295.71,194.97 295.98,194.7 v2(295.98,194.43) ; UNK7C299.1 v3(320.99,136.1) UNK7MU4.2 ; v2(360.81,208.82) 360.77,208.86 UNK8U450.5 ; UNK6MU4.2 v3(280.99,136.1) UNK6C299.1 ; U454.7 501.65,207.74 v3(501.9,207.49) ; UNK7C298.1 v3(318.71,141.7) ; UNK2U450.5 280.77,268.86 v2(280.81,268.82) ; v2(287.88,212.63) 287.85,212.67 UNK6U452.5 ; v2(215.98,254.43) 215.98,254.7 215.71,254.97 215.49,254.97 C309.2 ; UNK3C262.2 305,231.76 v2(305.36,232.12) ; UNK7U451.5 327.04,208.86 v2(327.07,208.82) ; v2(240.81,208.82) 240.77,208.86 UNK5U450.5 ; UNK4C298.1 v3(342.95,287.56) ; v2(367.88,272.63) 367.85,272.67 UNK4U452.5 ; v2(247.07,208.82) 247.04,208.86 UNK5U451.5 ; U70.19 v3(540.03,237.83) ; UNK6C309.2 255.49,194.97 255.71,194.97 255.98,194.7 v2(255.98,194.43) ; UNK4MU4.2 v3(340.67,293.16) UNK4C299.1 ; U403.G2 541.44,223.92 U403.1 ; UNK3C298.1 v3(302.95,287.56) ; UNK2C298.1 v3(262.95,287.56) ; UNK6C298.1 v3(278.71,141.7) ; UNK6C262.2 265,171.76 v2(265.36,172.12) ; v2(305.36,172.12) 305,171.76 UNK7C262.2 ; U435.19 v3(539.65,197.44) ; UNK5C298.1 v3(238.71,141.7) ; UNK2U451.5 287.04,268.86 v2(287.07,268.82) ; U403.19 v3(540.03,224.87) ; UNK8C298.1 v3(358.71,141.7) ; UNK7U452.5 327.85,212.67 v2(327.88,212.63) ; U70.10 541.44,233.88 U70.G1
  BOTTOM w0.356: UNK3U449.5 313.63,269.73 UNK3R980.2 ; UNK5R980.2 233.63,209.73 UNK5U449.5 ; R980.2 233.63,269.73 U449.5 ; UNK7U449.5 313.63,209.73 UNK7R980.2 ; UNK8U449.5 353.63,209.73 UNK8R980.2 ; UNK4U449.5 353.63,269.73 UNK4R980.2 ; UNK6U449.5 273.63,209.73 UNK6R980.2 ; UNK2U449.5 273.63,269.73 UNK2R980.2
  BOTTOM w0.381: UNK3MU3.4 v3(309.98,292.69) ; UNK6MU3.4 v3(271.68,136.57) ; UNK8MU3.4 v3(351.68,136.57) ; UNK5MU3.4 v3(231.68,136.57) ; UNK7MU3.4 v3(311.68,136.57) ; MU3.4 v3(229.98,292.69) ; UNK4MU3.4 v3(349.98,292.69) ; UNK2MU3.4 v3(269.98,292.69)
  BOTTOM w0.508: UNK6Y1.2 v2(276.23,163.79) ; UNK8R1090.2 v2(341.74,179.01) ; UNK3CA25.2 v3(297.96,275.59) ; UNK5MR6.2 225.25,134.63 v3(225.25,133.69) ; v2(347.86,270.9) UNK4C264.2 v2(347.1,270.9) ; UNK3CA21.2 v3(297.96,279.65) ; UNK7CA35.2 v3(327.11,152.5) ; CA36.2 v3(230.14,275.59) ; v3(394.95,236.27) v3(396.22,236.27) v3(397.49,236.27) ; v3(377.1,298.81) v3(377.1,297.54) v3(377.1,296.27) ; UNK7CA21.2 v3(312.66,150.98) ; UNK3MR6.2 316.41,294.63 v3(316.41,295.57) ; UNK7BD9.2 v2(304.65,182.02) ; UNK3CA1.2 v3(366.63,295.91) ; UNK2R1090.2 v2(261.74,239.01) ; v2(307.1,210.9) UNK7C264.2 v2(307.86,210.9) ; UNK8MR6.2 345.25,134.63 v3(345.25,133.69) ; UNK5Y1.4 v4(230.04,159.93) ; UNK2Y1.4 v4(270.04,219.93) ; UNK4CA8.2 v3(366.41,279.65) ; UNK4U19.4 v3(486.82,232.66) ; U17.1 v3(106.16,224.24) ; UNK5U19.4 v3(121.06,169.16) ; UNK6U18.4 v3(102.24,137.41) ; v2(345.9,258.62) UNK4C270.2 v2(345.9,259.38) ; CA8.2 v3(246.41,279.65) ; UNK7U17.1 v3(471.92,128.99) ; v2(305.9,259.38) UNK3C270.2 v2(305.9,258.62) ; v3(254.88,138.31) v3(254.88,139.58) v3(254.88,140.85) ; U18.4 v3(102.24,232.66) ; v2(307.1,270.9) UNK3C264.2 v2(307.86,270.9) ; UNK4MR6.2 356.41,294.63 v3(356.41,295.57) ; UNK8Y1.4 v4(350.04,159.93) ; v3(519.61,150.83) C403.2 v3(520.62,150.83) ; UNK8CA23.2 v3(362.29,147.83) ; UNK8U19.4 v3(486.82,169.16) ; v2(305.9,198.62) UNK7C270.2 v2(305.9,199.38) ; Y1.4 v4(230.04,219.93) ; UNK5U18.4 v3(102.24,169.16) ; v3(294.88,138.31) v3(294.88,139.58) v3(294.88,140.85) ; v2(225.9,259.38) C270.2 v2(225.9,258.62) ; v2(265.9,198.62) UNK6C270.2 v2(265.9,199.38) ; UNK5CA35.2 v3(247.11,152.5) ; UNK6CA8.2 v3(282.29,152.5) ; UNK2Y1.2 v2(276.23,223.79) ; UNK6CA21.2 v3(272.66,150.98) ; v2(345.9,199.38) UNK8C270.2 v2(345.9,198.62) ; UNK2CA35.2 v3(286.41,275.59) ; Y1.2 v2(236.23,223.79) ; UNK6U19.4 v3(121.06,137.41) ; CA35.2 v3(246.41,275.59) ; v2(224.57,209.01) UNK5C478.2 v2(224.57,208) ; UNK4CA35.2 v3(366.41,275.59) ; v2(344.57,268) UNK4C478.2 v2(344.57,269.01) ; UNK6MU2.4 v3(265.51,142.64) ; UNK5CA27.2 v3(227.84,155.04) ; UNK5CA1.2 v3(223.02,155.04) ; UNK3U17.1 v3(471.92,192.49) ; UNK3BD9.2 v2(304.65,242.02) ; v2(347.1,210.9) UNK8C264.2 v2(347.86,210.9) ; UNK2CA23.2 v3(264.05,275.59) ; UNK7CA25.2 v3(303.02,150.98) ; UNK6CA23.2 v3(282.29,147.83) ; UNK6Y1.4 v4(270.04,159.93) ; v2(267.86,210.9) UNK6C264.2 v2(267.1,210.9) ; UNK8CA36.2 v3(347.84,150.98) ; UNK4R1090.2 v2(341.74,239.01) ; UNK4BD9.2 v2(344.65,242.02) ; v2(304.57,209.01) UNK7C478.2 v2(304.57,208) ; UNK5CA25.2 v3(223.02,150.98) ; v2(225.9,199.38) UNK5C270.2 v2(225.9,198.62) ; v2(264.57,209.01) UNK6C478.2 v2(264.57,208) ; v2(264.57,269.01) UNK2C478.2 v2(264.57,268) ; v2(344.57,209.01) UNK8C478.2 v2(344.57,208) ; v2(227.1,270.9) C264.2 v2(227.86,270.9) ; UNK8CA35.2 v3(367.11,152.5) ; UNK4MU2.4 v3(356.15,286.62) ; UNK6CA36.2 v3(267.84,150.98) ; UNK7CA36.2 v3(307.84,150.98) ; UNK2MR6.2 276.41,294.63 v3(276.41,295.57) ; UNK3R1090.2 v2(301.74,239.01) ; v3(334.88,138.31) v3(334.88,139.58) v3(334.88,140.85) ; v3(270.14,275.59) UNK2CA36.2 ; UNK5BD9.2 v2(224.66,182.02) ; UNK6U17.1 v3(106.16,128.99) ; UNK7Y1.4 v4(310.04,159.93) ; UNK8CA25.2 v3(343.02,150.98) ; v2(304.57,268) UNK3C478.2 v2(304.57,269.01) ; v3(350.14,275.59) UNK4CA36.2 ; U19.4 v3(121.06,232.66) ; UNK5CA8.2 v3(242.29,152.5) ; UNK7R1090.2 v2(301.74,179.01) ; v3(186.68,230.89) v3(185.41,230.89) v3(184.14,230.89) ; UNK8CA8.2 v3(362.29,152.5) ; v3(214.88,140.85) v3(214.88,139.58) v3(214.88,138.31) ; UNK3CA35.2 v3(326.41,275.59) ; UNK4U18.4 v3(468,232.66) ; v3(305.25,133.69) 305.25,134.63 UNK7MR6.2 ; UNK5R1090.2 v2(221.74,179.01) ; UNK2CA1.2 v3(216.15,295.91) ; v2(227.86,210.9) UNK5C264.2 v2(227.1,210.9) ; BD9.2 v2(224.66,242.02) ; v3(316.47,275.59) UNK3CA27.2 ; UNK7CA8.2 v3(322.29,152.5) ; UNK6CA1.2 v3(263.02,155.04) ; v2(265.9,259.38) UNK2C270.2 v2(265.9,258.62) ; UNK2BD9.2 v2(264.66,242.02) ; v3(276.47,275.59) UNK2CA27.2 ; UNK6R1090.2 v2(261.74,179.01) ; UNK8CA27.2 v3(347.84,155.04) ; UNK3U19.4 v3(486.82,200.91) ; CA23.2 v3(224.05,275.59) ; UNK6CA25.2 v3(263.02,150.98) ; UNK2CA21.2 v3(257.96,279.65) ; MR6.2 236.41,294.63 v3(236.41,295.57) ; UNK6MR6.2 265.25,134.63 v3(265.25,133.69) ; v3(356.47,275.59) UNK4CA27.2 ; UNK4CA1.2 v3(379.73,245.11) ; UNK7U18.4 v3(468,137.41) ; UNK4Y1.4 v4(350.04,219.93) ; CA25.2 v3(217.96,275.59) ; UNK2U19.4 v3(121.06,200.91) ; UNK7Y1.2 v2(316.23,163.79) ; UNK4CA25.2 v3(337.96,275.59) ; UNK3Y1.4 v4(310.04,219.93) ; UNK3U18.4 v3(468,200.91) ; R1090.2 v2(221.74,239.01) ; UNK8U18.4 v3(468,169.16) ; UNK7CA23.2 v3(322.29,147.83) ; CA1.2 v3(207.01,237.49) ; v3(206.72,296.27) v3(206.72,297.54) v3(206.72,298.81) ; v2(224.57,268) C478.2 v2(224.57,269.01) ; UNK2CA8.2 v3(286.41,279.65) ; UNK5CA21.2 v3(232.66,150.98) ; v3(236.47,275.59) CA27.2 ; v2(267.86,270.9) UNK2C264.2 v2(267.1,270.9) ; MU2.4 v3(236.15,286.62) ; UNK8Y1.2 v2(356.23,163.79) ; UNK8CA21.2 v3(352.66,150.98) ; UNK5U17.1 v3(106.16,160.74) ; UNK5CA36.2 v3(227.84,150.98) ; UNK5CA23.2 v3(242.29,147.83) ; UNK6CA35.2 v3(287.11,152.5) ; UNK3CA8.2 v3(326.41,279.65) ; UNK2U17.1 v3(106.16,192.49) ; UNK8BD9.2 v2(344.65,182.02) ; UNK7CA27.2 v3(307.84,155.04) ; UNK2MU2.4 v3(276.15,286.62) ; v3(310.14,275.59) UNK3CA36.2 ; UNK4U17.1 v3(471.92,224.24) ; UNK5Y1.2 v2(236.23,163.79) ; UNK3Y1.2 v2(316.23,223.79) ; UNK2U18.4 v3(102.24,200.91) ; UNK4Y1.2 v2(356.23,223.79) ; UNK5MU2.4 v3(225.51,142.64) ; UNK2CA25.2 v3(257.96,275.59) ; UNK8MU2.4 v3(345.51,142.64) ; UNK6CA27.2 v3(267.84,155.04) ; UNK7U19.4 v3(486.82,137.41) ; UNK3MU2.4 v3(316.15,286.62) ; UNK7CA1.2 v3(303.02,155.04) ; UNK7MU2.4 v3(305.51,142.64) ; UNK4CA23.2 v3(344.05,275.59) ; UNK3CA23.2 v3(304.05,275.59) ; UNK4CA21.2 v3(337.96,279.65) ; UNK8U17.1 v3(471.92,160.74) ; UNK6BD9.2 v2(264.66,182.02) ; CA21.2 v3(217.96,279.65) ; UNK8CA1.2 v3(343.02,155.04)
  BOTTOM w0.584: U75.8 v3(510.75,230.4) ; U77.8 v3(493.05,220.9) ; U74.8 v3(73.21,287.07) ; U405.8 v3(90.92,282.86) ; U453.8 493.05,202.74 v3(493.05,202.74) ; U80.8 v3(73.21,273.36) ; U413.8 v3(73.21,259.64) ; U72.8 v3(90.92,296.58) ; U415.8 v3(90.92,269.15)
  vias: v1(210.66,249.22) v1(210.66,237.65) v1(210.66,189.22) v1(210.66,177.65) v1(211.16,250.72) v1(211.16,239.15) v1(211.16,190.72) v1(211.16,179.15) v1(211.66,250.72) v1(211.66,239.15) v1(211.66,190.72) v1(211.66,179.15) v1(212.16,248.22) v1(212.16,236.65) v1(212.16,188.22) v1(212.16,176.65) v1(213.66,248.22) v1(213.66,236.65) v1(213.66,188.22) v1(213.66,176.65) v1(216.16,251.72) v1(216.16,249.72) v1(216.16,246.62) v1(216.16,240.15) v1(216.16,238.15) v1(216.16,191.72) v1(216.16,189.72) v1(216.16,186.62) v1(216.16,180.15) v1(216.16,178.15) v1(217.57,251.72) v1(217.57,249.72) v1(217.57,246.62) v1(217.57,240.15) v1(217.57,238.15) v1(217.57,191.72) v1(217.57,189.72) v1(217.57,186.62) v1(217.57,180.15) v1(217.57,178.15) v1(250.66,249.22) v1(250.66,237.65) v1(250.66,189.22) v1(250.66,177.65) v1(251.16,250.72) v1(251.16,239.15) v1(251.16,190.72) v1(251.16,179.15) v1(251.66,250.72) v1(251.66,239.15) v1(251.66,190.72) v1(251.66,179.15) v1(252.16,248.22) v1(252.16,236.65) v1(252.16,188.22) v1(252.16,176.65) v1(253.66,248.22) v1(253.66,236.65) v1(253.66,188.22) v1(253.66,176.65) v1(256.16,251.72) v1(256.16,249.72) v1(256.16,246.62) v1(256.16,240.15) v1(256.16,238.15) v1(256.16,191.72) v1(256.16,189.72) v1(256.16,186.62) v1(256.16,180.15) v1(256.16,178.15) v1(257.57,251.72) v1(257.57,249.72) v1(257.57,246.62) v1(257.57,240.15) v1(257.57,238.15) v1(257.57,191.72) v1(257.57,189.72) v1(257.57,186.62) v1(257.57,180.15) v1(257.57,178.15) v1(290.66,249.22) v1(290.66,237.65) v1(290.66,189.22) v1(290.66,177.65) v1(291.16,250.72) v1(291.16,239.15) v1(291.16,190.72) v1(291.16,179.15) v1(291.66,250.72) v1(291.66,239.15) v1(291.66,190.72) v1(291.66,179.15) v1(292.16,248.22) v1(292.16,236.65) v1(292.16,188.22) v1(292.16,176.65) v1(293.66,248.22) v1(293.66,236.65) v1(293.66,188.22) v1(293.66,176.65) v1(296.16,251.72) v1(296.16,249.72) v1(296.16,246.62) v1(296.16,240.15) v1(296.16,238.15) v1(296.16,191.72) v1(296.16,189.72) v1(296.16,186.62) v1(296.16,180.15) v1(296.16,178.15) v1(297.57,251.72) v1(297.57,249.72) v1(297.57,246.62) v1(297.57,240.15) v1(297.57,238.15) v1(297.57,191.72) v1(297.57,189.72) v1(297.57,186.62) v1(297.57,180.15) v1(297.57,178.15) v1(330.66,249.22) v1(330.66,237.65) v1(330.66,189.22) v1(330.66,177.65) v1(331.16,250.72) v1(331.16,239.15) v1(331.16,190.72) v1(331.16,179.15) v1(331.66,250.72) v1(331.66,239.15) v1(331.66,190.72) v1(331.66,179.15) v1(332.16,248.22) v1(332.16,236.65) v1(332.16,188.22) v1(332.16,176.65) v1(333.66,248.22) v1(333.66,236.65) v1(333.66,188.22) v1(333.66,176.65) v1(336.16,251.72) v1(336.16,249.72) v1(336.16,246.62) v1(336.16,240.15) v1(336.16,238.15) v1(336.16,191.72) v1(336.16,189.72) v1(336.16,186.62) v1(336.16,180.15) v1(336.16,178.15) v1(337.57,251.72) v1(337.57,249.72) v1(337.57,246.62) v1(337.57,240.15) v1(337.57,238.15) v1(337.57,191.72) v1(337.57,189.72) v1(337.57,186.62) v1(337.57,180.15) v1(337.57,178.15) v2(211.58,299.97) v2(211.58,287.78) v2(211.58,285.75) v2(211.58,283.72) v2(211.58,281.69) v2(211.58,279.65) v2(211.58,277.62) v2(211.58,275.59) v2(211.58,273.56) v2(211.58,271.53) v2(211.58,269.49) v2(211.58,267.46) v2(211.58,265.43) v2(211.58,257.3) v2(211.58,224.79) v2(211.58,222.76) v2(211.58,215.59) v2(211.58,213.56) v2(211.58,211.53) v2(211.58,209.49) v2(211.58,207.46) v2(211.58,205.43) v2(211.58,197.3) v2(211.58,136.34) v2(211.58,134.31) v2(211.58,132.28) v2(211.58,130.25) v2(212.24,255.18) v2(212.24,243.61) v2(212.24,195.18) v2(212.24,183.61) v2(212.66,246.46) v2(212.66,234.89) v2(212.66,186.46) v2(212.66,174.89) v2(213.39,255.18) v2(213.39,243.61) v2(213.39,195.18) v2(213.39,183.61) v2(213.61,299.97) v2(213.61,293.88) v2(213.61,291.85) v2(213.61,289.81) v2(213.61,287.78) v2(213.61,285.75) v2(213.61,283.72) v2(213.61,281.69) v2(213.61,279.65) v2(213.61,277.62) v2(213.61,275.59) v2(213.61,273.56) v2(213.61,271.53) v2(213.61,269.49) v2(213.61,267.46) v2(213.61,265.43) v2(213.61,224.79) v2(213.61,222.76) v2(213.61,215.59) v2(213.61,213.56) v2(213.61,211.53) v2(213.61,209.49) v2(213.61,207.46) v2(213.61,205.43) v2(213.61,136.34) v2(213.61,134.31) v2(213.61,132.28) v2(213.61,130.25) v2(215.65,299.97) v2(215.65,293.88) v2(215.65,291.85) v2(215.65,289.81) v2(215.65,287.78) v2(215.65,285.75) v2(215.65,283.72) v2(215.65,273.56) v2(215.65,271.53) v2(215.65,267.46) v2(215.65,265.43) v2(215.65,245.11) v2(215.65,234.95) v2(215.65,224.79) v2(215.65,222.76) v2(215.65,215.59) v2(215.65,213.56) v2(215.65,211.53) v2(215.65,207.46) v2(215.65,205.43) v2(215.65,185.11) v2(215.65,174.95) v2(215.65,136.34) v2(215.65,134.31) v2(215.65,132.28) v2(215.65,130.25) v2(217.68,299.97) v2(217.68,297.94) v2(217.68,295.91) v2(217.68,293.88) v2(217.68,291.85) v2(217.68,289.81) v2(217.68,287.78) v2(217.68,285.75) v2(217.68,283.72) v2(217.68,273.56) v2(217.68,271.53) v2(217.68,269.49) v2(217.68,265.43) v2(217.68,245.11) v2(217.68,243.08) v2(217.68,234.95) v2(217.68,224.79) v2(217.68,222.76) v2(217.68,215.59) v2(217.68,213.56) v2(217.68,211.53) v2(217.68,209.49) v2(217.68,205.43) v2(217.68,185.11) v2(217.68,183.08) v2(217.68,174.95) v2(217.68,136.34) v2(217.68,134.31) v2(217.68,132.28) v2(217.68,130.25) v2(219,268.75) v2(219,208.75) v2(219.71,299.97) v2(219.71,297.94) v2(219.71,295.91) v2(219.71,283.72) v2(219.71,281.69) v2(219.71,279.65) v2(219.71,277.62) v2(219.71,275.59) v2(219.71,273.56) v2(219.71,271.53) v2(219.71,253.24) v2(219.71,251.21) v2(219.71,249.17) v2(219.71,246.89) v2(219.71,245.11) v2(219.71,243.08) v2(219.71,241.05) v2(219.71,239.01) v2(219.71,236.98) v2(219.71,234.95) v2(219.71,215.59) v2(219.71,213.56) v2(219.71,211.53) v2(219.71,193.24) v2(219.71,191.21) v2(219.71,189.17) v2(219.71,186.89) v2(219.71,185.11) v2(219.71,183.08) v2(219.71,181.05) v2(219.71,179.01) v2(219.71,176.98) v2(219.71,174.95) v2(219.71,160.73) v2(219.71,158.69) v2(219.71,150.57) v2(219.71,136.34) v2(219.71,134.31) v2(219.71,132.28) v2(219.71,130.25) v2(220.32,269.61) v2(220.32,209.61) v2(221.74,299.97) v2(221.74,297.94) v2(221.74,295.91) v2(221.74,283.72) v2(221.74,281.69) v2(221.74,279.65) v2(221.74,273.56) v2(221.74,271.53) v2(221.74,257.3) v2(221.74,255.27) v2(221.74,253.24) v2(221.74,251.21) v2(221.74,249.17) v2(221.74,247.14) v2(221.74,245.11) v2(221.74,241.05) v2(221.74,228.85) v2(221.74,220.73) v2(221.74,218.69) v2(221.74,215.59) v2(221.74,213.56) v2(221.74,211.53) v2(221.74,197.3) v2(221.74,195.27) v2(221.74,193.24) v2(221.74,191.21) v2(221.74,189.17) v2(221.74,187.14) v2(221.74,185.11) v2(221.74,181.05) v2(221.74,168.85) v2(221.74,160.73) v2(221.74,158.69) v2(221.74,148.53) v2(221.74,146.5) v2(221.74,132.28) v2(221.74,130.25) v2(221.84,266.27) v2(221.84,264.24) v2(221.84,262.2) v2(221.84,206.27) v2(221.84,204.24) v2(221.84,202.2) v2(223.24,235.18) v2(223.24,234.62) v2(223.24,175.18) v2(223.24,174.62) v2(223.77,299.97) v2(223.77,297.94) v2(223.77,279.65) v2(223.77,273.56) v2(223.77,271.53) v2(223.77,257.3) v2(223.77,255.27) v2(223.77,253.24) v2(223.77,251.21) v2(223.77,228.85) v2(223.77,220.73) v2(223.77,218.69) v2(223.77,215.59) v2(223.77,213.56) v2(223.77,211.53) v2(223.77,197.3) v2(223.77,195.27) v2(223.77,193.24) v2(223.77,191.21) v2(223.77,168.85) v2(223.77,160.73) v2(223.77,158.69) v2(223.77,150.57) v2(223.77,148.53) v2(223.77,132.28) v2(223.77,130.25) v2(224.96,236.88) v2(224.96,176.88) v2(225.69,262.36) v2(225.69,202.36) v2(225.81,299.97) v2(225.81,297.94) v2(225.81,279.65) v2(225.81,277.62) v2(225.81,275.59) v2(225.81,273.56) v2(225.81,271.53) v2(225.81,269.49) v2(225.81,267.46) v2(225.86,264.61) v2(225.81,228.85) v2(225.81,220.73) v2(225.81,218.69) v2(225.81,215.59) v2(225.81,213.56) v2(225.81,211.53) v2(225.81,209.49) v2(225.81,207.46) v2(225.86,204.61) v2(225.81,168.85) v2(225.81,160.73) v2(225.81,158.69) v2(225.81,132.28) v2(225.81,130.25) v2(225.96,245.61) v2(225.96,185.61) v2(226.41,236.88) v2(226.41,176.88) v2(227.13,192.15) v2(227.26,246.26) v2(227.26,238.45) v2(227.26,186.26) v2(227.26,178.46) v2(227.84,299.97) v2(227.84,297.94) v2(227.84,279.65) v2(227.84,273.56) v2(227.84,228.85) v2(227.84,220.73) v2(227.84,218.69) v2(227.84,215.59) v2(227.84,213.56) v2(227.84,160.73) v2(227.84,158.69) v2(227.84,148.53) v2(227.84,130.25) v2(227.91,247.56) v2(227.91,244.31) v2(227.91,243.66) v2(227.91,243.01) v2(227.91,241.06) v2(227.91,238.45) v2(227.91,187.56) v2(227.91,184.31) v2(227.91,183.66) v2(227.91,183.01) v2(227.91,181.06) v2(227.91,178.46) v2(228.01,234.83) v2(228.01,174.83) v2(228.56,245.61) v2(228.56,244.96) v2(228.56,244.31) v2(228.56,243.66) v2(228.56,243.01) v2(228.56,242.36) v2(228.56,185.61) v2(228.56,184.96) v2(228.56,184.31) v2(228.56,183.66) v2(228.56,183.01) v2(228.56,182.36) v2(228.56,178.46) v2(228.65,252.12) v2(228.65,192.12) v2(228.71,233) v2(228.71,173) v2(229.24,270.27) v2(229.21,248.2) v2(229.21,247.56) v2(229.21,244.31) v2(229.21,243.66) v2(229.21,243.01) v2(229.21,242.36) v2(229.21,241.71) v2(229.21,241.06) v2(229.21,240.41) v2(229.24,210.27) v2(229.21,188.21) v2(229.21,187.56) v2(229.21,184.31) v2(229.21,183.66) v2(229.21,183.01) v2(229.21,182.36) v2(229.21,181.71) v2(229.21,181.06) v2(229.21,180.41) v2(229.87,299.97) v2(229.87,297.94) v2(229.87,281.69) v2(229.87,279.65) v2(229.86,247.56) v2(229.86,246.91) v2(229.86,246.26) v2(229.86,245.61) v2(229.86,244.31) v2(229.86,243.66) v2(229.86,243.01) v2(229.86,242.36) v2(229.86,239.1) v2(229.87,228.85) v2(229.87,215.59) v2(229.86,187.56) v2(229.86,186.91) v2(229.86,186.26) v2(229.86,185.61) v2(229.86,184.31) v2(229.86,183.66) v2(229.86,183.01) v2(229.86,182.36) v2(229.86,179.11) v2(229.87,168.85) v2(229.87,156.66) v2(229.87,148.53) v2(229.87,130.25) v2(230.04,218.49) v2(230.04,158.49) v2(230.5,250.8) v2(230.5,247.56) v2(230.5,244.96) v2(230.5,243.65) v2(230.5,243.01) v2(230.5,242.36) v2(230.5,239.1) v2(230.5,190.81) v2(230.5,184.96) v2(230.5,183.65) v2(230.5,183.01) v2(230.5,182.36) v2(230.5,179.11) v2(230.76,252.5) v2(230.85,274.17) v2(230.85,214.17) v2(231.15,250.8) v2(231.16,247.56) v2(231.16,246.91) v2(231.16,243.65) v2(231.16,243.01) v2(231.15,242.36) v2(231.16,240.4) v2(231.16,239.1) v2(231.15,190.81) v2(231.16,187.56) v2(231.16,186.91) v2(231.16,183.65) v2(231.16,183.01) v2(231.15,182.36) v2(231.16,180.41) v2(231.16,179.11) v2(231.43,267.19) v2(231.43,207.19) v2(231.8,250.8) v2(231.81,245.61) v2(231.81,244.31) v2(231.81,243.66) v2(231.81,242.35) v2(231.81,240.4) v2(231.81,239.75) v2(231.8,190.81) v2(231.81,185.61) v2(231.81,184.31) v2(231.81,183.66) v2(231.81,182.35) v2(231.81,180.41) v2(231.81,179.76) v2(231.9,299.97) v2(231.9,297.94) v2(231.9,281.69) v2(231.9,279.65) v2(231.9,277.62) v2(231.9,275.59) v2(231.9,236.98) v2(231.9,215.59) v2(231.9,176.98) v2(231.9,156.66) v2(231.9,148.53) v2(231.9,130.25) v2(232,274.17) v2(232.03,259.97) v2(232.03,257.94) v2(232.03,255.91) v2(232.03,253.87) v2(232.08,218.49) v2(232,214.17) v2(232.03,199.97) v2(232.03,197.94) v2(232.03,195.91) v2(232.03,193.87) v2(232.08,158.49) v2(232.45,267.19) v2(232.46,250.8) v2(232.46,244.96) v2(232.46,243.65) v2(232.46,242.35) v2(232.46,240.4) v2(232.45,207.19) v2(232.46,190.81) v2(232.46,184.96) v2(232.46,183.65) v2(232.46,182.35) v2(232.46,180.41) v2(233.11,250.8) v2(233.11,243.65) v2(233.11,243.01) v2(233.11,242.36) v2(233.11,241.71) v2(233.11,241.06) v2(233.11,183.65) v2(233.11,183.01) v2(233.11,182.36) v2(233.11,181.71) v2(233.11,181.06) v2(233.66,269.74) v2(233.66,209.74) v2(233.76,244.31) v2(233.76,243) v2(233.76,242.36) v2(233.76,184.31) v2(233.76,183) v2(233.76,182.36) v2(233.93,299.97) v2(233.93,297.94) v2(233.93,281.69) v2(233.93,279.65) v2(233.93,273.56) v2(233.93,253.24) v2(233.93,215.59) v2(233.93,213.56) v2(233.93,193.24) v2(233.93,156.66) v2(233.93,154.63) v2(233.93,152.6) v2(233.93,150.57) v2(233.93,130.25) v2(234.11,218.49) v2(234.11,158.49) v2(234.41,244.96) v2(234.41,243.65) v2(234.41,184.96) v2(234.41,183.65) v2(235.06,250.8) v2(235.06,190.81) v2(235.23,223.79) v2(235.23,163.79) v2(235.66,236.42) v2(235.66,234.39) v2(235.66,232.36) v2(235.66,230.33) v2(235.66,176.42) v2(235.66,174.39) v2(235.66,172.36) v2(235.66,170.33) v2(235.71,243) v2(235.71,183) v2(235.97,299.97) v2(235.97,297.94) v2(235.97,279.65) v2(235.97,273.56) v2(235.97,271.53) v2(235.97,265.43) v2(235.97,253.24) v2(235.97,215.59) v2(235.97,213.56) v2(235.97,211.53) v2(235.97,205.43) v2(235.97,193.24) v2(235.97,156.66) v2(235.97,154.63) v2(235.97,152.6) v2(235.97,150.57) v2(235.97,130.25) v2(236.14,218.49) v2(236.14,158.49) v2(236.82,237.58) v2(236.82,177.58) v2(238,299.97) v2(238,297.94) v2(238,295.91) v2(238,279.65) v2(238,277.62) v2(238,275.59) v2(238,273.56) v2(238,265.43) v2(238,263.4) v2(238,261.37) v2(238,259.33) v2(238,257.3) v2(238,255.27) v2(238,253.24) v2(238,251.21) v2(238,222.76) v2(238,220.73) v2(238,218.69) v2(238,215.59) v2(238,213.56) v2(238,205.43) v2(238,203.4) v2(238,201.37) v2(238,199.33) v2(238,197.3) v2(238,195.27) v2(238,193.24) v2(238,191.21) v2(238,162.76) v2(238,160.73) v2(238,158.69) v2(238,156.66) v2(238,152.6) v2(238,150.57) v2(238,130.25) v2(238.25,239.01) v2(238.25,179.01) v2(238.3,242.82) v2(238.3,241.05) v2(238.3,182.82) v2(238.3,181.05) v2(240.03,299.97) v2(240.03,297.94) v2(240.03,295.91) v2(240.03,293.88) v2(240.03,281.69) v2(240.03,279.65) v2(240.03,277.62) v2(240.03,275.59) v2(240.03,273.56) v2(240.03,265.43) v2(240.03,263.4) v2(240.03,261.37) v2(240.03,259.33) v2(240.03,257.3) v2(240.03,255.27) v2(240.03,253.24) v2(240.03,251.21) v2(240.03,249.17) v2(240.03,247.14) v2(240.03,245.11) v2(240.03,243.08) v2(240.03,241.05) v2(240.03,239.01) v2(240.03,236.98) v2(240.03,222.76) v2(240.03,220.73) v2(240.03,218.69) v2(240.03,215.59) v2(240.03,213.56) v2(240.03,205.43) v2(240.03,203.4) v2(240.03,201.37) v2(240.03,199.33) v2(240.03,197.3) v2(240.03,195.27) v2(240.03,193.24) v2(240.03,191.21) v2(240.03,189.17) v2(240.03,187.14) v2(240.03,185.11) v2(240.03,183.08) v2(240.03,181.05) v2(240.03,179.01) v2(240.03,176.98) v2(240.03,162.76) v2(240.03,160.73) v2(240.03,158.69) v2(240.03,156.66) v2(240.03,146.5) v2(240.03,130.25) v2(241.57,224.79) v2(241.57,164.79) v2(242.06,299.97) v2(242.06,297.94) v2(242.06,295.91) v2(242.06,293.88) v2(242.06,291.85) v2(242.06,289.81) v2(242.06,287.78) v2(242.06,285.75) v2(242.06,283.72) v2(242.06,281.69) v2(242.06,279.65) v2(242.06,277.62) v2(242.06,275.59) v2(242.06,273.56) v2(242.06,271.53) v2(242.06,265.43) v2(242.06,263.4) v2(242.06,253.24) v2(242.06,251.21) v2(242.06,249.17) v2(242.06,247.14) v2(242.06,245.11) v2(242.06,243.08) v2(242.06,241.05) v2(242.06,239.01) v2(242.06,236.98) v2(242.06,234.95) v2(242.06,215.59) v2(242.06,213.56) v2(242.06,211.53) v2(242.06,205.43) v2(242.06,203.4) v2(242.06,193.24) v2(242.06,191.21) v2(242.06,189.17) v2(242.06,187.14) v2(242.06,185.11) v2(242.06,183.08) v2(242.06,181.05) v2(242.06,179.01) v2(242.06,176.98) v2(242.06,174.95) v2(242.06,156.66) v2(242.06,146.5) v2(242.06,132.28) v2(242.06,130.25) v2(243.74,270.18) v2(243.74,210.18) v2(244.09,299.97) v2(244.09,297.94) v2(244.09,295.91) v2(244.09,293.88) v2(244.09,291.85) v2(244.09,289.81) v2(244.09,287.78) v2(244.09,285.75) v2(244.09,283.72) v2(244.09,265.43) v2(244.09,253.24) v2(244.09,251.21) v2(244.09,249.17) v2(244.09,247.14) v2(244.09,245.11) v2(244.09,243.08) v2(244.09,241.05) v2(244.09,239.01) v2(244.09,236.98) v2(244.09,234.95) v2(244.09,215.59) v2(244.09,205.43) v2(244.09,193.24) v2(244.09,191.21) v2(244.09,189.17) v2(244.09,187.14) v2(244.09,185.11) v2(244.09,183.08) v2(244.09,181.05) v2(244.09,179.01) v2(244.09,176.98) v2(244.09,174.95) v2(244.09,156.66) v2(244.09,150.57) v2(244.09,148.53) v2(244.09,146.5) v2(244.09,144.47) v2(244.09,142.44) v2(244.09,140.41) v2(244.09,138.37) v2(244.09,136.34) v2(244.09,134.31) v2(244.09,132.28) v2(244.09,130.25) v2(244.68,274.19) v2(244.68,214.19) v2(244.78,271.22) v2(244.78,211.22) v2(246.13,299.97) v2(246.13,297.94) v2(246.13,295.91) v2(246.13,293.88) v2(246.13,291.85) v2(246.13,289.81) v2(246.13,287.78) v2(246.13,285.75) v2(246.13,283.72) v2(246.13,265.43) v2(246.13,253.24) v2(246.13,251.21) v2(246.13,249.17) v2(246.13,247.14) v2(246.13,245.11) v2(246.13,243.08) v2(246.13,241.05) v2(246.13,239.01) v2(246.13,236.98) v2(246.13,234.95) v2(246.13,215.59) v2(246.13,205.43) v2(246.13,193.24) v2(246.13,191.21) v2(246.13,189.17) v2(246.13,187.14) v2(246.13,185.11) v2(246.13,183.08) v2(246.13,181.05) v2(246.13,179.01) v2(246.13,176.98) v2(246.13,174.95) v2(246.13,156.66) v2(246.13,150.57) v2(246.13,148.53) v2(246.13,146.5) v2(246.13,144.47) v2(246.13,142.44) v2(246.13,140.41) v2(246.13,138.37) v2(246.13,136.34) v2(246.13,134.31) v2(246.13,132.28) v2(246.13,130.25) v2(246.63,274.19) v2(246.63,214.19) v2(248.16,299.97) v2(248.16,297.94) v2(248.16,295.91) v2(248.16,293.88) v2(248.16,291.85) v2(248.16,289.81) v2(248.16,287.78) v2(248.16,285.75) v2(248.16,283.72) v2(248.16,281.69) v2(248.16,279.65) v2(248.16,277.62) v2(248.16,275.59) v2(248.16,273.56) v2(248.16,269.49) v2(248.16,267.46) v2(248.16,265.43) v2(248.16,255.27) v2(248.16,253.24) v2(248.16,251.21) v2(248.16,249.17) v2(248.16,247.14) v2(248.16,245.11) v2(248.16,243.08) v2(248.16,241.05) v2(248.16,239.01) v2(248.16,236.98) v2(248.16,234.95) v2(248.16,215.59) v2(248.16,213.56) v2(248.16,209.49) v2(248.16,207.46) v2(248.16,205.43) v2(248.16,195.27) v2(248.16,193.24) v2(248.16,191.21) v2(248.16,189.17) v2(248.16,187.14) v2(248.16,185.11) v2(248.16,183.08) v2(248.16,181.05) v2(248.16,179.01) v2(248.16,176.98) v2(248.16,174.95) v2(248.16,156.66) v2(248.16,152.6) v2(248.16,150.57) v2(248.16,148.53) v2(248.16,146.5) v2(248.16,144.47) v2(248.16,142.44) v2(248.16,140.41) v2(248.16,138.37) v2(248.16,136.34) v2(248.16,134.31) v2(248.16,132.28) v2(248.16,130.25) v2(248.65,224.79) v2(251.58,299.97) v2(251.58,297.94) v2(251.58,295.91) v2(251.58,293.88) v2(251.58,291.85) v2(251.58,289.81) v2(251.58,287.78) v2(251.58,285.75) v2(251.58,283.72) v2(251.58,281.69) v2(251.58,279.65) v2(251.58,277.62) v2(251.58,275.59) v2(251.58,273.56) v2(251.58,271.53) v2(251.58,269.49) v2(251.58,267.46) v2(251.58,265.43) v2(251.58,257.3) v2(251.58,224.79) v2(251.58,222.76) v2(251.58,215.59) v2(251.58,213.56) v2(251.58,211.53) v2(251.58,209.49) v2(251.58,207.46) v2(251.58,205.43) v2(251.58,197.3) v2(251.58,136.34) v2(251.58,134.31) v2(251.58,132.28) v2(251.58,130.25) v2(252.24,255.18) v2(252.24,243.61) v2(252.24,195.18) v2(252.24,183.61) v2(252.66,246.46) v2(252.66,234.89) v2(252.66,186.46) v2(252.66,174.89) v2(253.39,255.18) v2(253.39,243.61) v2(253.39,195.18) v2(253.39,183.61) v2(253.61,299.97) v2(253.61,297.94) v2(253.61,295.91) v2(253.61,293.88) v2(253.61,291.85) v2(253.61,289.81) v2(253.61,287.78) v2(253.61,285.75) v2(253.61,283.72) v2(253.61,281.69) v2(253.61,279.65) v2(253.61,277.62) v2(253.61,275.59) v2(253.61,273.56) v2(253.61,271.53) v2(253.61,269.49) v2(253.61,267.46) v2(253.61,265.43) v2(253.61,224.79) v2(253.61,222.76) v2(253.61,215.59) v2(253.61,213.56) v2(253.61,211.53) v2(253.61,209.49) v2(253.61,207.46) v2(253.61,205.43) v2(253.61,136.34) v2(253.61,134.31) v2(253.61,132.28) v2(253.61,130.25) v2(255.65,299.97) v2(255.65,297.94) v2(255.65,295.91) v2(255.65,293.88) v2(255.65,291.85) v2(255.65,289.81) v2(255.65,287.78) v2(255.65,285.75) v2(255.65,283.72) v2(255.65,273.56) v2(255.65,271.53) v2(255.65,267.46) v2(255.65,265.43) v2(255.65,245.11) v2(255.65,234.95) v2(255.65,224.79) v2(255.65,222.76) v2(255.65,215.59) v2(255.65,213.56) v2(255.65,211.53) v2(255.65,207.46) v2(255.65,205.43) v2(255.65,185.11) v2(255.65,174.95) v2(255.65,136.34) v2(255.65,134.31) v2(255.65,132.28) v2(255.65,130.25) v2(257.68,299.97) v2(257.68,297.94) v2(257.68,295.91) v2(257.68,293.88) v2(257.68,283.72) v2(257.68,273.56) v2(257.68,271.53) v2(257.68,269.49) v2(257.68,265.43) v2(257.68,245.11) v2(257.68,243.08) v2(257.68,234.95) v2(257.68,224.79) v2(257.68,222.76) v2(257.68,215.59) v2(257.68,213.56) v2(257.68,211.53) v2(257.68,209.49) v2(257.68,205.43) v2(257.68,185.11) v2(257.68,183.08) v2(257.68,174.95) v2(257.68,136.34) v2(257.68,134.31) v2(257.68,132.28) v2(257.68,130.25) v2(259,268.75) v2(259,208.75) v2(259.71,299.97) v2(259.71,297.94) v2(259.71,295.91) v2(259.71,283.72) v2(259.71,281.69) v2(259.71,279.65) v2(259.71,277.62) v2(259.71,275.59) v2(259.71,273.56) v2(259.71,271.53) v2(259.71,253.24) v2(259.71,251.21) v2(259.71,249.17) v2(259.71,246.89) v2(259.71,245.11) v2(259.71,243.08) v2(259.71,241.05) v2(259.71,239.01) v2(259.71,236.98) v2(259.71,234.95) v2(259.71,215.59) v2(259.71,213.56) v2(259.71,211.53) v2(259.71,193.24) v2(259.71,191.21) v2(259.71,189.17) v2(259.71,186.89) v2(259.71,185.11) v2(259.71,183.08) v2(259.71,181.05) v2(259.71,179.01) v2(259.71,176.98) v2(259.71,174.95) v2(259.71,160.73) v2(259.71,158.69) v2(259.71,150.57) v2(259.71,136.34) v2(259.71,134.31) v2(259.71,132.28) v2(259.71,130.25) v2(260.32,269.61) v2(260.32,209.61) v2(261.74,299.97) v2(261.74,297.94) v2(261.74,283.72) v2(261.74,281.69) v2(261.74,279.65) v2(261.74,273.56) v2(261.74,271.53) v2(261.74,257.3) v2(261.74,255.27) v2(261.74,253.24) v2(261.74,251.21) v2(261.74,249.17) v2(261.74,247.14) v2(261.74,245.11) v2(261.74,241.05) v2(261.74,228.85) v2(261.74,220.73) v2(261.74,218.69) v2(261.74,215.59) v2(261.74,213.56) v2(261.74,211.53) v2(261.74,197.3) v2(261.74,195.27) v2(261.74,193.24) v2(261.74,191.21) v2(261.74,189.17) v2(261.74,187.14) v2(261.74,185.11) v2(261.74,181.05) v2(261.74,168.85) v2(261.74,160.73) v2(261.74,158.69) v2(261.74,148.53) v2(261.74,146.5) v2(261.74,132.28) v2(261.74,130.25) v2(261.84,266.27) v2(261.84,264.24) v2(261.84,262.2) v2(261.84,206.27) v2(261.84,204.24) v2(261.84,202.2) v2(263.24,235.18) v2(263.24,234.62) v2(263.24,175.18) v2(263.24,174.62) v2(263.77,299.97) v2(263.77,297.94) v2(263.77,279.65) v2(263.77,273.56) v2(263.77,271.53) v2(263.77,257.3) v2(263.77,255.27) v2(263.77,253.24) v2(263.77,251.21) v2(263.77,228.85) v2(263.77,220.73) v2(263.77,218.69) v2(263.77,215.59) v2(263.77,213.56) v2(263.77,211.53) v2(263.77,197.3) v2(263.77,195.27) v2(263.77,193.24) v2(263.77,191.21) v2(263.77,168.85) v2(263.77,160.73) v2(263.77,158.69) v2(263.77,152.6) v2(263.77,150.57) v2(263.77,148.53) v2(263.77,132.28) v2(263.77,130.25) v2(264.96,236.88) v2(264.96,176.88) v2(265.69,262.36) v2(265.69,202.36) v2(265.81,299.97) v2(265.81,297.94) v2(265.81,279.65) v2(265.81,277.62) v2(265.81,275.59) v2(265.81,273.56) v2(265.81,271.53) v2(265.81,269.49) v2(265.81,267.46) v2(265.86,264.61) v2(265.81,228.85) v2(265.81,220.73) v2(265.81,218.69) v2(265.81,215.59) v2(265.81,213.56) v2(265.81,211.53) v2(265.81,209.49) v2(265.81,207.46) v2(265.86,204.61) v2(265.81,168.85) v2(265.81,160.73) v2(265.81,158.69) v2(265.81,132.28) v2(265.81,130.25) v2(265.96,245.61) v2(265.96,185.61) v2(266.41,236.88) v2(266.41,176.88) v2(267.13,192.15) v2(267.25,246.26) v2(267.25,238.45) v2(267.25,186.26) v2(267.25,178.46) v2(267.84,299.97) v2(267.84,297.94) v2(267.84,279.65) v2(267.84,273.56) v2(267.84,228.85) v2(267.84,220.73) v2(267.84,218.69) v2(267.84,215.59) v2(267.84,213.56) v2(267.84,160.73) v2(267.84,158.69) v2(267.84,148.53) v2(267.84,130.25) v2(267.9,247.56) v2(267.9,244.31) v2(267.9,243.66) v2(267.9,243.01) v2(267.9,241.06) v2(267.9,238.45) v2(267.9,187.56) v2(267.9,184.31) v2(267.9,183.66) v2(267.9,183.01) v2(267.9,181.06) v2(267.9,178.46) v2(268.01,234.83) v2(268.01,174.83) v2(268.55,245.61) v2(268.55,244.96) v2(268.55,244.31) v2(268.55,243.66) v2(268.55,243.01) v2(268.55,242.36) v2(268.55,185.61) v2(268.55,184.96) v2(268.55,184.31) v2(268.55,183.66) v2(268.55,183.01) v2(268.55,182.36) v2(268.55,178.46) v2(268.65,252.12) v2(268.65,192.12) v2(268.71,233) v2(268.71,173) v2(269.24,270.27) v2(269.2,248.2) v2(269.2,247.56) v2(269.2,244.31) v2(269.2,243.66) v2(269.2,243.01) v2(269.2,242.36) v2(269.2,241.71) v2(269.2,241.06) v2(269.2,240.41) v2(269.24,210.27) v2(269.2,188.21) v2(269.2,187.56) v2(269.2,184.31) v2(269.2,183.66) v2(269.2,183.01) v2(269.2,182.36) v2(269.2,181.71) v2(269.2,181.06) v2(269.2,180.41) v2(269.87,299.97) v2(269.87,297.94) v2(269.87,281.69) v2(269.87,279.65) v2(269.85,247.56) v2(269.85,246.91) v2(269.85,246.26) v2(269.85,245.61) v2(269.85,244.31) v2(269.85,243.66) v2(269.85,243.01) v2(269.85,242.36) v2(269.85,239.1) v2(269.87,228.85) v2(269.87,215.59) v2(269.85,187.56) v2(269.85,186.91) v2(269.85,186.26) v2(269.85,185.61) v2(269.85,184.31) v2(269.85,183.66) v2(269.85,183.01) v2(269.85,182.36) v2(269.85,179.11) v2(269.87,168.85) v2(269.87,156.66) v2(269.87,148.53) v2(269.87,130.25) v2(270.04,218.49) v2(270.04,158.49) v2(270.5,250.8) v2(270.5,247.56) v2(270.5,244.96) v2(270.5,243.65) v2(270.5,243.01) v2(270.5,242.36) v2(270.5,239.1) v2(270.5,190.81) v2(270.5,184.96) v2(270.5,183.65) v2(270.5,183.01) v2(270.5,182.36) v2(270.5,179.11) v2(270.76,252.5) v2(270.85,274.17) v2(270.85,214.17) v2(271.15,250.8) v2(271.16,247.56) v2(271.16,246.91) v2(271.16,243.65) v2(271.16,243.01) v2(271.15,242.36) v2(271.16,240.4) v2(271.16,239.1) v2(271.15,190.81) v2(271.16,187.56) v2(271.16,186.91) v2(271.16,183.65) v2(271.16,183.01) v2(271.15,182.36) v2(271.16,180.41) v2(271.16,179.11) v2(271.43,267.19) v2(271.43,207.19) v2(271.8,250.8) v2(271.81,245.61) v2(271.81,244.31) v2(271.81,243.66) v2(271.81,242.35) v2(271.81,240.4) v2(271.81,239.75) v2(271.8,190.81) v2(271.81,185.61) v2(271.81,184.31) v2(271.81,183.66) v2(271.81,182.35) v2(271.81,180.41) v2(271.81,179.76) v2(271.9,299.97) v2(271.9,297.94) v2(271.9,279.65) v2(271.9,277.62) v2(271.9,275.59) v2(271.9,236.98) v2(271.9,215.59) v2(271.9,176.98) v2(271.9,156.66) v2(271.9,148.53) v2(271.9,130.25) v2(272,274.17) v2(272.03,259.97) v2(272.03,257.94) v2(272.03,255.91) v2(272.03,253.87) v2(272.08,218.49) v2(272,214.17) v2(272.03,199.97) v2(272.03,197.94) v2(272.03,195.91) v2(272.03,193.87) v2(272.08,158.49) v2(272.45,267.19) v2(272.46,250.8) v2(272.46,244.96) v2(272.46,243.65) v2(272.46,242.35) v2(272.46,240.4) v2(272.45,207.19) v2(272.46,190.81) v2(272.46,184.96) v2(272.46,183.65) v2(272.46,182.35) v2(272.46,180.41) v2(273.11,250.8) v2(273.11,243.65) v2(273.11,243.01) v2(273.11,242.36) v2(273.11,241.71) v2(273.11,241.06) v2(273.11,183.65) v2(273.11,183.01) v2(273.11,182.36) v2(273.11,181.71) v2(273.11,181.06) v2(273.66,269.74) v2(273.66,209.74) v2(273.76,244.31) v2(273.76,243) v2(273.76,242.36) v2(273.76,184.31) v2(273.76,183) v2(273.76,182.36) v2(273.93,299.97) v2(273.93,297.94) v2(273.93,281.69) v2(273.93,279.65) v2(273.93,273.56) v2(273.93,253.24) v2(273.93,215.59) v2(273.93,213.56) v2(273.93,193.24) v2(273.93,156.66) v2(273.93,154.63) v2(273.93,152.6) v2(273.93,150.57) v2(273.93,130.25) v2(274.11,218.49) v2(274.11,158.49) v2(274.41,244.96) v2(274.41,243.65) v2(274.41,184.96) v2(274.41,183.65) v2(275.06,250.8) v2(275.06,190.81) v2(275.23,223.79) v2(275.23,163.79) v2(275.66,236.42) v2(275.66,234.39) v2(275.66,232.36) v2(275.66,230.33) v2(275.66,176.42) v2(275.66,174.39) v2(275.66,172.36) v2(275.66,170.33) v2(275.71,243) v2(275.71,183) v2(275.97,299.97) v2(275.97,297.94) v2(275.97,279.65) v2(275.97,273.56) v2(275.97,271.53) v2(275.97,265.43) v2(275.97,253.24) v2(275.97,215.59) v2(275.97,213.56) v2(275.97,211.53) v2(275.97,205.43) v2(275.97,193.24) v2(275.97,156.66) v2(275.97,154.63) v2(275.97,152.6) v2(275.97,150.57) v2(275.97,130.25) v2(276.14,218.49) v2(276.14,158.49) v2(276.82,237.58) v2(276.82,177.58) v2(278,299.97) v2(278,297.94) v2(278,295.91) v2(278,279.65) v2(278,277.62) v2(278,275.59) v2(278,273.56) v2(278,265.43) v2(278,263.4) v2(278,261.37) v2(278,259.33) v2(278,257.3) v2(278,255.27) v2(278,253.24) v2(278,251.21) v2(278,222.76) v2(278,220.73) v2(278,218.69) v2(278,215.59) v2(278,213.56) v2(278,205.43) v2(278,203.4) v2(278,201.37) v2(278,199.33) v2(278,197.3) v2(278,195.27) v2(278,193.24) v2(278,191.21) v2(278,162.76) v2(278,160.73) v2(278,158.69) v2(278,156.66) v2(278,152.6) v2(278,150.57) v2(278,130.25) v2(278.25,239.01) v2(278.25,179.01) v2(278.3,242.82) v2(278.3,241.05) v2(278.3,182.82) v2(278.3,181.05) v2(280.03,299.97) v2(280.03,297.94) v2(280.03,295.91) v2(280.03,293.88) v2(280.03,281.69) v2(280.03,279.65) v2(280.03,277.62) v2(280.03,275.59) v2(280.03,273.56) v2(280.03,265.43) v2(280.03,263.4) v2(280.03,261.37) v2(280.03,259.33) v2(280.03,257.3) v2(280.03,255.27) v2(280.03,253.24) v2(280.03,251.21) v2(280.03,249.17) v2(280.03,247.14) v2(280.03,245.11) v2(280.03,243.08) v2(280.03,241.05) v2(280.03,239.01) v2(280.03,236.98) v2(280.03,222.76) v2(280.03,220.73) v2(280.03,218.69) v2(280.03,215.59) v2(280.03,213.56) v2(280.03,205.43) v2(280.03,203.4) v2(280.03,201.37) v2(280.03,199.33) v2(280.03,197.3) v2(280.03,195.27) v2(280.03,193.24) v2(280.03,191.21) v2(280.03,189.17) v2(280.03,187.14) v2(280.03,185.11) v2(280.03,183.08) v2(280.03,181.05) v2(280.03,179.01) v2(280.03,176.98) v2(280.03,162.76) v2(280.03,160.73) v2(280.03,158.69) v2(280.03,156.66) v2(280.03,146.5) v2(280.03,130.25) v2(281.57,224.79) v2(281.57,164.79) v2(282.06,299.97) v2(282.06,297.94) v2(282.06,295.91) v2(282.06,293.88) v2(282.06,291.85) v2(282.06,289.81) v2(282.06,287.78) v2(282.06,285.75) v2(282.06,283.72) v2(282.06,281.69) v2(282.06,279.65) v2(282.06,277.62) v2(282.06,275.59) v2(282.06,273.56) v2(282.06,271.53) v2(282.06,265.43) v2(282.06,263.4) v2(282.06,253.24) v2(282.06,251.21) v2(282.06,249.17) v2(282.06,247.14) v2(282.06,245.11) v2(282.06,243.08) v2(282.06,241.05) v2(282.06,239.01) v2(282.06,236.98) v2(282.06,234.95) v2(282.06,215.59) v2(282.06,213.56) v2(282.06,211.53) v2(282.06,205.43) v2(282.06,203.4) v2(282.06,193.24) v2(282.06,191.21) v2(282.06,189.17) v2(282.06,187.14) v2(282.06,185.11) v2(282.06,183.08) v2(282.06,181.05) v2(282.06,179.01) v2(282.06,176.98) v2(282.06,174.95) v2(282.06,156.66) v2(282.06,146.5) v2(282.06,132.28) v2(282.06,130.25) v2(283.74,270.18) v2(283.74,210.18) v2(284.09,299.97) v2(284.09,289.81) v2(284.09,287.78) v2(284.09,285.75) v2(284.09,283.72) v2(284.09,265.43) v2(284.09,253.24) v2(284.09,251.21) v2(284.09,249.17) v2(284.09,247.14) v2(284.09,245.11) v2(284.09,243.08) v2(284.09,241.05) v2(284.09,239.01) v2(284.09,236.98) v2(284.09,234.95) v2(284.09,215.59) v2(284.09,205.43) v2(284.09,193.24) v2(284.09,191.21) v2(284.09,189.17) v2(284.09,187.14) v2(284.09,185.11) v2(284.09,183.08) v2(284.09,181.05) v2(284.09,179.01) v2(284.09,176.98) v2(284.09,174.95) v2(284.09,156.66) v2(284.09,150.57) v2(284.09,148.53) v2(284.09,146.5) v2(284.09,144.47) v2(284.09,142.44) v2(284.09,140.41) v2(284.09,138.37) v2(284.09,136.34) v2(284.09,134.31) v2(284.09,132.28) v2(284.09,130.25) v2(284.68,274.19) v2(284.68,214.19) v2(284.78,271.22) v2(284.78,211.22) v2(286.13,299.97) v2(286.13,289.81) v2(286.13,287.78) v2(286.13,285.75) v2(286.13,283.72) v2(286.13,265.43) v2(286.13,253.24) v2(286.13,251.21) v2(286.13,249.17) v2(286.13,247.14) v2(286.13,245.11) v2(286.13,243.08) v2(286.13,241.05) v2(286.13,239.01) v2(286.13,236.98) v2(286.13,234.95) v2(286.13,215.59) v2(286.13,205.43) v2(286.13,193.24) v2(286.13,191.21) v2(286.13,189.17) v2(286.13,187.14) v2(286.13,185.11) v2(286.13,183.08) v2(286.13,181.05) v2(286.13,179.01) v2(286.13,176.98) v2(286.13,174.95) v2(286.13,156.66) v2(286.13,150.57) v2(286.13,148.53) v2(286.13,146.5) v2(286.13,144.47) v2(286.13,142.44) v2(286.13,140.41) v2(286.13,138.37) v2(286.13,136.34) v2(286.13,134.31) v2(286.13,132.28) v2(286.13,130.25) v2(286.63,274.19) v2(286.63,214.19) v2(288.16,299.97) v2(288.16,297.94) v2(288.16,289.81) v2(288.16,287.78) v2(288.16,285.75) v2(288.16,283.72) v2(288.16,281.69) v2(288.16,279.65) v2(288.16,277.62) v2(288.16,275.59) v2(288.16,273.56) v2(288.16,269.49) v2(288.16,267.46) v2(288.16,265.43) v2(288.16,255.27) v2(288.16,253.24) v2(288.16,251.21) v2(288.16,249.17) v2(288.16,247.14) v2(288.16,245.11) v2(288.16,243.08) v2(288.16,241.05) v2(288.16,239.01) v2(288.16,236.98) v2(288.16,234.95) v2(288.16,215.59) v2(288.16,213.56) v2(288.16,209.49) v2(288.16,207.46) v2(288.16,205.43) v2(288.16,195.27) v2(288.16,193.24) v2(288.16,191.21) v2(288.16,189.17) v2(288.16,187.14) v2(288.16,185.11) v2(288.16,183.08) v2(288.16,181.05) v2(288.16,179.01) v2(288.16,176.98) v2(288.16,174.95) v2(288.16,156.66) v2(288.16,152.6) v2(288.16,150.57) v2(288.16,148.53) v2(288.16,146.5) v2(288.16,144.47) v2(288.16,142.44) v2(288.16,140.41) v2(288.16,138.37) v2(288.16,136.34) v2(288.16,134.31) v2(288.16,132.28) v2(288.16,130.25) v2(291.58,299.97) v2(291.58,297.94) v2(291.58,289.81) v2(291.58,287.78) v2(291.58,285.75) v2(291.58,283.72) v2(291.58,281.69) v2(291.58,279.65) v2(291.58,277.62) v2(291.58,275.59) v2(291.58,273.56) v2(291.58,271.53) v2(291.58,269.49) v2(291.58,267.46) v2(291.58,265.43) v2(291.58,257.3) v2(291.58,224.79) v2(291.58,222.76) v2(291.58,215.59) v2(291.58,213.56) v2(291.58,211.53) v2(291.58,209.49) v2(291.58,207.46) v2(291.58,205.43) v2(291.58,197.3) v2(291.58,136.34) v2(291.58,134.31) v2(291.58,132.28) v2(291.58,130.25) v2(292.24,255.18) v2(292.24,243.61) v2(292.24,195.18) v2(292.24,183.61) v2(292.66,246.46) v2(292.66,234.89) v2(292.66,186.46) v2(292.66,174.89) v2(293.39,255.18) v2(293.39,243.61) v2(293.39,195.18) v2(293.39,183.61) v2(293.61,299.97) v2(293.61,297.94) v2(293.61,289.81) v2(293.61,287.78) v2(293.61,285.75) v2(293.61,283.72) v2(293.61,281.69) v2(293.61,279.65) v2(293.61,277.62) v2(293.61,275.59) v2(293.61,273.56) v2(293.61,271.53) v2(293.61,269.49) v2(293.61,267.46) v2(293.61,265.43) v2(293.61,224.79) v2(293.61,222.76) v2(293.61,215.59) v2(293.61,213.56) v2(293.61,211.53) v2(293.61,209.49) v2(293.61,207.46) v2(293.61,205.43) v2(293.61,136.34) v2(293.61,134.31) v2(293.61,132.28) v2(293.61,130.25) v2(295.65,299.97) v2(295.65,297.94) v2(295.65,291.85) v2(295.65,289.81) v2(295.65,287.78) v2(295.65,285.75) v2(295.65,283.72) v2(295.65,273.56) v2(295.65,271.53) v2(295.65,267.46) v2(295.65,265.43) v2(295.65,245.11) v2(295.65,234.95) v2(295.65,224.79) v2(295.65,222.76) v2(295.65,215.59) v2(295.65,213.56) v2(295.65,211.53) v2(295.65,207.46) v2(295.65,205.43) v2(295.65,185.11) v2(295.65,174.95) v2(295.65,136.34) v2(295.65,134.31) v2(295.65,132.28) v2(295.65,130.25) v2(297.68,299.97) v2(297.68,297.94) v2(297.68,283.72) v2(297.68,273.56) v2(297.68,271.53) v2(297.68,269.49) v2(297.68,265.43) v2(297.68,245.11) v2(297.68,243.08) v2(297.68,234.95) v2(297.68,224.79) v2(297.68,222.76) v2(297.68,215.59) v2(297.68,213.56) v2(297.68,211.53) v2(297.68,209.49) v2(297.68,205.43) v2(297.68,185.11) v2(297.68,183.08) v2(297.68,174.95) v2(297.68,136.34) v2(297.68,134.31) v2(297.68,132.28) v2(297.68,130.25) v2(299,268.75) v2(299,208.75) v2(299.71,299.97) v2(299.71,297.94) v2(299.71,295.91) v2(299.71,283.72) v2(299.71,281.69) v2(299.71,279.65) v2(299.71,277.62) v2(299.71,275.59) v2(299.71,273.56) v2(299.71,271.53) v2(299.71,253.24) v2(299.71,251.21) v2(299.71,249.17) v2(299.71,246.89) v2(299.71,245.11) v2(299.71,243.08) v2(299.71,241.05) v2(299.71,239.01) v2(299.71,236.98) v2(299.71,234.95) v2(299.71,215.59) v2(299.71,213.56) v2(299.71,211.53) v2(299.71,193.24) v2(299.71,191.21) v2(299.71,189.17) v2(299.71,186.89) v2(299.71,185.11) v2(299.71,183.08) v2(299.71,181.05) v2(299.71,179.01) v2(299.71,176.98) v2(299.71,174.95) v2(299.71,160.73) v2(299.71,158.69) v2(299.71,150.57) v2(299.71,136.34) v2(299.71,134.31) v2(299.71,132.28) v2(299.71,130.25) v2(300.32,269.61) v2(300.32,209.61) v2(301.74,299.97) v2(301.74,297.94) v2(301.74,283.72) v2(301.74,281.69) v2(301.74,279.65) v2(301.74,273.56) v2(301.74,271.53) v2(301.74,257.3) v2(301.74,255.27) v2(301.74,253.24) v2(301.74,251.21) v2(301.74,249.17) v2(301.74,247.14) v2(301.74,245.11) v2(301.74,241.05) v2(301.74,228.85) v2(301.74,220.73) v2(301.74,218.69) v2(301.74,215.59) v2(301.74,213.56) v2(301.74,211.53) v2(301.74,197.3) v2(301.74,195.27) v2(301.74,193.24) v2(301.74,191.21) v2(301.74,189.17) v2(301.74,187.14) v2(301.74,185.11) v2(301.74,181.05) v2(301.74,168.85) v2(301.74,160.73) v2(301.74,158.69) v2(301.74,148.53) v2(301.74,146.5) v2(301.74,132.28) v2(301.74,130.25) v2(301.84,266.27) v2(301.84,264.24) v2(301.84,262.2) v2(301.84,206.27) v2(301.84,204.24) v2(301.84,202.2) v2(303.24,235.18) v2(303.24,234.62) v2(303.24,175.18) v2(303.24,174.62) v2(303.77,299.97) v2(303.77,297.94) v2(303.77,279.65) v2(303.77,273.56) v2(303.77,271.53) v2(303.77,257.3) v2(303.77,255.27) v2(303.77,253.24) v2(303.77,251.21) v2(303.77,228.85) v2(303.77,220.73) v2(303.77,218.69) v2(303.77,215.59) v2(303.77,213.56) v2(303.77,211.53) v2(303.77,197.3) v2(303.77,195.27) v2(303.77,193.24) v2(303.77,191.21) v2(303.77,168.85) v2(303.77,160.73) v2(303.77,158.69) v2(303.77,150.57) v2(303.77,148.53) v2(303.77,132.28) v2(303.77,130.25) v2(304.96,236.88) v2(304.96,176.88) v2(305.69,262.36) v2(305.69,202.36) v2(305.81,299.97) v2(305.81,297.94) v2(305.81,279.65) v2(305.81,277.62) v2(305.81,275.59) v2(305.81,273.56) v2(305.81,271.53) v2(305.81,269.49) v2(305.81,267.46) v2(305.86,264.61) v2(305.81,228.85) v2(305.81,220.73) v2(305.81,218.69) v2(305.81,215.59) v2(305.81,213.56) v2(305.81,211.53) v2(305.81,209.49) v2(305.81,207.46) v2(305.86,204.61) v2(305.81,168.85) v2(305.81,160.73) v2(305.81,158.69) v2(305.81,132.28) v2(305.81,130.25) v2(305.95,245.61) v2(305.95,185.61) v2(306.41,236.88) v2(306.41,176.88) v2(307.13,192.15) v2(307.25,246.26) v2(307.25,238.45) v2(307.25,186.26) v2(307.25,178.46) v2(307.84,299.97) v2(307.84,297.94) v2(307.84,279.65) v2(307.84,273.56) v2(307.84,228.85) v2(307.84,220.73) v2(307.84,218.69) v2(307.84,215.59) v2(307.84,213.56) v2(307.84,160.73) v2(307.84,158.69) v2(307.84,148.53) v2(307.84,130.25) v2(307.9,247.56) v2(307.9,244.31) v2(307.9,243.66) v2(307.9,243.01) v2(307.9,241.06) v2(307.9,238.45) v2(307.9,187.56) v2(307.9,184.31) v2(307.9,183.66) v2(307.9,183.01) v2(307.9,181.06) v2(307.9,178.46) v2(308.01,234.83) v2(308.01,174.83) v2(308.55,245.61) v2(308.55,244.96) v2(308.55,244.31) v2(308.55,243.66) v2(308.55,243.01) v2(308.55,242.36) v2(308.55,185.61) v2(308.55,184.96) v2(308.55,184.31) v2(308.55,183.66) v2(308.55,183.01) v2(308.55,182.36) v2(308.55,178.46) v2(308.65,252.12) v2(308.65,192.12) v2(308.71,233) v2(308.71,173) v2(309.24,270.27) v2(309.2,248.2) v2(309.2,247.56) v2(309.2,244.31) v2(309.2,243.66) v2(309.2,243.01) v2(309.2,242.36) v2(309.2,241.71) v2(309.2,241.06) v2(309.2,240.41) v2(309.24,210.27) v2(309.2,188.21) v2(309.2,187.56) v2(309.2,184.31) v2(309.2,183.66) v2(309.2,183.01) v2(309.2,182.36) v2(309.2,181.71) v2(309.2,181.06) v2(309.2,180.41) v2(309.87,299.97) v2(309.87,297.94) v2(309.87,281.69) v2(309.87,279.65) v2(309.85,247.56) v2(309.85,246.91) v2(309.85,246.26) v2(309.85,245.61) v2(309.85,244.31) v2(309.85,243.66) v2(309.85,243.01) v2(309.85,242.36) v2(309.85,239.1) v2(309.87,228.85) v2(309.87,215.59) v2(309.85,187.56) v2(309.85,186.91) v2(309.85,186.26) v2(309.85,185.61) v2(309.85,184.31) v2(309.85,183.66) v2(309.85,183.01) v2(309.85,182.36) v2(309.85,179.11) v2(309.87,168.85) v2(309.87,156.66) v2(309.87,148.53) v2(309.87,130.25) v2(310.04,218.49) v2(310.04,158.49) v2(310.5,250.8) v2(310.5,247.56) v2(310.5,244.96) v2(310.5,243.65) v2(310.5,243.01) v2(310.5,242.36) v2(310.5,239.1) v2(310.5,190.81) v2(310.5,184.96) v2(310.5,183.65) v2(310.5,183.01) v2(310.5,182.36) v2(310.5,179.11) v2(310.76,252.5) v2(310.84,274.17) v2(310.84,214.17) v2(311.15,250.8) v2(311.16,247.56) v2(311.16,246.91) v2(311.16,243.65) v2(311.16,243.01) v2(311.15,242.36) v2(311.16,240.4) v2(311.16,239.1) v2(311.15,190.81) v2(311.16,187.56) v2(311.16,186.91) v2(311.16,183.65) v2(311.16,183.01) v2(311.15,182.36) v2(311.16,180.41) v2(311.16,179.11) v2(311.43,267.19) v2(311.43,207.19) v2(311.8,250.8) v2(311.81,245.61) v2(311.81,244.31) v2(311.81,243.66) v2(311.81,242.35) v2(311.81,240.4) v2(311.81,239.75) v2(311.8,190.81) v2(311.81,185.61) v2(311.81,184.31) v2(311.81,183.66) v2(311.81,182.35) v2(311.81,180.41) v2(311.81,179.76) v2(311.9,299.97) v2(311.9,297.94) v2(311.9,279.65) v2(311.9,277.62) v2(311.9,275.59) v2(311.9,236.98) v2(311.9,215.59) v2(311.9,176.98) v2(311.9,156.66) v2(311.9,148.53) v2(311.9,130.25) v2(312,274.17) v2(312.03,259.97) v2(312.03,257.94) v2(312.03,255.91) v2(312.03,253.87) v2(312.08,218.49) v2(312,214.17) v2(312.03,199.97) v2(312.03,197.94) v2(312.03,195.91) v2(312.03,193.87) v2(312.08,158.49) v2(312.45,267.19) v2(312.46,250.8) v2(312.46,244.96) v2(312.46,243.65) v2(312.46,242.35) v2(312.46,240.4) v2(312.45,207.19) v2(312.46,190.81) v2(312.46,184.96) v2(312.46,183.65) v2(312.46,182.35) v2(312.46,180.41) v2(313.11,250.8) v2(313.11,243.65) v2(313.11,243.01) v2(313.11,242.36) v2(313.11,241.71) v2(313.11,241.06) v2(313.11,183.65) v2(313.11,183.01) v2(313.11,182.36) v2(313.11,181.71) v2(313.11,181.06) v2(313.66,269.74) v2(313.66,209.74) v2(313.76,244.31) v2(313.76,243) v2(313.76,242.36) v2(313.76,184.31) v2(313.76,183) v2(313.76,182.36) v2(313.93,299.97) v2(313.93,297.94) v2(313.93,281.69) v2(313.93,279.65) v2(313.93,273.56) v2(313.93,253.24) v2(313.93,215.59) v2(313.93,213.56) v2(313.93,193.24) v2(313.93,156.66) v2(313.93,154.63) v2(313.93,152.6) v2(313.93,150.57) v2(313.93,130.25) v2(314.11,218.49) v2(314.11,158.49) v2(314.41,244.96) v2(314.41,243.65) v2(314.41,184.96) v2(314.41,183.65) v2(315.05,250.8) v2(315.05,190.81) v2(315.23,223.79) v2(315.23,163.79) v2(315.66,236.42) v2(315.66,234.39) v2(315.66,232.36) v2(315.66,230.33) v2(315.66,176.42) v2(315.66,174.39) v2(315.66,172.36) v2(315.66,170.33) v2(315.7,243) v2(315.7,183) v2(315.97,299.97) v2(315.97,297.94) v2(315.97,279.65) v2(315.97,273.56) v2(315.97,271.53) v2(315.97,265.43) v2(315.97,253.24) v2(315.97,215.59) v2(315.97,213.56) v2(315.97,211.53) v2(315.97,205.43) v2(315.97,193.24) v2(315.97,156.66) v2(315.97,154.63) v2(315.97,152.6) v2(315.97,150.57) v2(315.97,130.25) v2(316.14,218.49) v2(316.14,158.49) v2(316.81,237.58) v2(316.81,177.58) v2(318,299.97) v2(318,297.94) v2(318,295.91) v2(318,279.65) v2(318,277.62) v2(318,275.59) v2(318,273.56) v2(318,265.43) v2(318,263.4) v2(318,261.37) v2(318,259.33) v2(318,257.3) v2(318,255.27) v2(318,253.24) v2(318,251.21) v2(318,222.76) v2(318,220.73) v2(318,218.69) v2(318,215.59) v2(318,213.56) v2(318,205.43) v2(318,203.4) v2(318,201.37) v2(318,199.33) v2(318,197.3) v2(318,195.27) v2(318,193.24) v2(318,191.21) v2(318,162.76) v2(318,160.73) v2(318,158.69) v2(318,156.66) v2(318,152.6) v2(318,150.57) v2(318,130.25) v2(318.25,239.01) v2(318.25,179.01) v2(318.3,242.82) v2(318.3,241.05) v2(318.3,182.82) v2(318.3,181.05) v2(320.03,299.97) v2(320.03,297.94) v2(320.03,295.91) v2(320.03,293.88) v2(320.03,281.69) v2(320.03,279.65) v2(320.03,277.62) v2(320.03,275.59) v2(320.03,273.56) v2(320.03,265.43) v2(320.03,263.4) v2(320.03,261.37) v2(320.03,259.33) v2(320.03,257.3) v2(320.03,255.27) v2(320.03,253.24) v2(320.03,251.21) v2(320.03,249.17) v2(320.03,247.14) v2(320.03,245.11) v2(320.03,243.08) v2(320.03,241.05) v2(320.03,239.01) v2(320.03,236.98) v2(320.03,222.76) v2(320.03,220.73) v2(320.03,218.69) v2(320.03,215.59) v2(320.03,213.56) v2(320.03,205.43) v2(320.03,203.4) v2(320.03,201.37) v2(320.03,199.33) v2(320.03,197.3) v2(320.03,195.27) v2(320.03,193.24) v2(320.03,191.21) v2(320.03,189.17) v2(320.03,187.14) v2(320.03,185.11) v2(320.03,183.08) v2(320.03,181.05) v2(320.03,179.01) v2(320.03,176.98) v2(320.03,162.76) v2(320.03,160.73) v2(320.03,158.69) v2(320.03,156.66) v2(320.03,146.5) v2(320.03,130.25) v2(321.57,224.79) v2(321.57,164.79) v2(322.06,299.97) v2(322.06,297.94) v2(322.06,295.91) v2(322.06,293.88) v2(322.06,291.85) v2(322.06,289.81) v2(322.06,287.78) v2(322.06,285.75) v2(322.06,283.72) v2(322.06,281.69) v2(322.06,279.65) v2(322.06,277.62) v2(322.06,275.59) v2(322.06,273.56) v2(322.06,271.53) v2(322.06,265.43) v2(322.06,263.4) v2(322.06,253.24) v2(322.06,251.21) v2(322.06,249.17) v2(322.06,247.14) v2(322.06,245.11) v2(322.06,243.08) v2(322.06,241.05) v2(322.06,239.01) v2(322.06,236.98) v2(322.06,234.95) v2(322.06,215.59) v2(322.06,213.56) v2(322.06,211.53) v2(322.06,205.43) v2(322.06,203.4) v2(322.06,193.24) v2(322.06,191.21) v2(322.06,189.17) v2(322.06,187.14) v2(322.06,185.11) v2(322.06,183.08) v2(322.06,181.05) v2(322.06,179.01) v2(322.06,176.98) v2(322.06,174.95) v2(322.06,156.66) v2(322.06,146.5) v2(322.06,132.28) v2(322.06,130.25) v2(323.74,270.18) v2(323.74,210.18) v2(324.09,299.97) v2(324.09,297.94) v2(324.09,295.91) v2(324.09,293.88) v2(324.09,291.85) v2(324.09,289.81) v2(324.09,287.78) v2(324.09,285.75) v2(324.09,283.72) v2(324.09,265.43) v2(324.09,253.24) v2(324.09,251.21) v2(324.09,249.17) v2(324.09,247.14) v2(324.09,245.11) v2(324.09,243.08) v2(324.09,241.05) v2(324.09,239.01) v2(324.09,236.98) v2(324.09,234.95) v2(324.09,215.59) v2(324.09,205.43) v2(324.09,193.24) v2(324.09,191.21) v2(324.09,189.17) v2(324.09,187.14) v2(324.09,185.11) v2(324.09,183.08) v2(324.09,181.05) v2(324.09,179.01) v2(324.09,176.98) v2(324.09,174.95) v2(324.09,156.66) v2(324.09,150.57) v2(324.09,148.53) v2(324.09,146.5) v2(324.09,144.47) v2(324.09,142.44) v2(324.09,140.41) v2(324.09,138.37) v2(324.09,136.34) v2(324.09,134.31) v2(324.09,132.28) v2(324.09,130.25) v2(324.68,274.19) v2(324.68,214.19) v2(324.78,271.22) v2(324.78,211.22) v2(326.13,299.97) v2(326.13,297.94) v2(326.13,295.91) v2(326.13,293.88) v2(326.13,291.85) v2(326.13,289.81) v2(326.13,287.78) v2(326.13,285.75) v2(326.13,283.72) v2(326.13,265.43) v2(326.13,253.24) v2(326.13,251.21) v2(326.13,249.17) v2(326.13,247.14) v2(326.13,245.11) v2(326.13,243.08) v2(326.13,241.05) v2(326.13,239.01) v2(326.13,236.98) v2(326.13,234.95) v2(326.13,215.59) v2(326.13,205.43) v2(326.13,193.24) v2(326.13,191.21) v2(326.13,189.17) v2(326.13,187.14) v2(326.13,185.11) v2(326.13,183.08) v2(326.13,181.05) v2(326.13,179.01) v2(326.13,176.98) v2(326.13,174.95) v2(326.13,156.66) v2(326.13,150.57) v2(326.13,148.53) v2(326.13,146.5) v2(326.13,144.47) v2(326.13,142.44) v2(326.13,140.41) v2(326.13,138.37) v2(326.13,136.34) v2(326.13,134.31) v2(326.13,132.28) v2(326.13,130.25) v2(326.63,274.19) v2(326.63,214.19) v2(328.16,299.97) v2(328.16,297.94) v2(328.16,295.91) v2(328.16,293.88) v2(328.16,291.85) v2(328.16,289.81) v2(328.16,287.78) v2(328.16,285.75) v2(328.16,283.72) v2(328.16,281.69) v2(328.16,279.65) v2(328.16,277.62) v2(328.16,275.59) v2(328.16,273.56) v2(328.16,269.49) v2(328.16,267.46) v2(328.16,265.43) v2(328.16,255.27) v2(328.16,253.24) v2(328.16,251.21) v2(328.16,249.17) v2(328.16,247.14) v2(328.16,245.11) v2(328.16,243.08) v2(328.16,241.05) v2(328.16,239.01) v2(328.16,236.98) v2(328.16,234.95) v2(328.16,215.59) v2(328.16,213.56) v2(328.16,209.49) v2(328.16,207.46) v2(328.16,205.43) v2(328.16,195.27) v2(328.16,193.24) v2(328.16,191.21) v2(328.16,189.17) v2(328.16,187.14) v2(328.16,185.11) v2(328.16,183.08) v2(328.16,181.05) v2(328.16,179.01) v2(328.16,176.98) v2(328.16,174.95) v2(328.16,156.66) v2(328.16,152.6) v2(328.16,150.57) v2(328.16,148.53) v2(328.16,146.5) v2(328.16,144.47) v2(328.16,142.44) v2(328.16,140.41) v2(328.16,138.37) v2(328.16,136.34) v2(328.16,134.31) v2(328.16,132.28) v2(328.16,130.25) v2(331.58,299.97) v2(331.58,297.94) v2(331.58,295.91) v2(331.58,293.88) v2(331.58,291.85) v2(331.58,289.81) v2(331.58,287.78) v2(331.58,285.75) v2(331.58,283.72) v2(331.58,281.69) v2(331.58,279.65) v2(331.58,277.62) v2(331.58,275.59) v2(331.58,273.56) v2(331.58,271.53) v2(331.58,269.49) v2(331.58,267.46) v2(331.58,265.43) v2(331.58,257.3) v2(331.58,224.79) v2(331.58,222.76) v2(331.58,215.59) v2(331.58,213.56) v2(331.58,211.53) v2(331.58,209.49) v2(331.58,207.46) v2(331.58,205.43) v2(331.58,197.3) v2(331.58,136.34) v2(331.58,134.31) v2(331.58,132.28) v2(331.58,130.25) v2(332.24,255.18) v2(332.24,243.61) v2(332.24,195.18) v2(332.24,183.61) v2(332.66,246.46) v2(332.66,234.89) v2(332.66,186.46) v2(332.66,174.89) v2(333.39,255.18) v2(333.39,243.61) v2(333.39,195.18) v2(333.39,183.61) v2(333.61,299.97) v2(333.61,297.94) v2(333.61,295.91) v2(333.61,293.88) v2(333.61,291.85) v2(333.61,289.81) v2(333.61,287.78) v2(333.61,285.75) v2(333.61,283.72) v2(333.61,281.69) v2(333.61,279.65) v2(333.61,277.62) v2(333.61,275.59) v2(333.61,273.56) v2(333.61,271.53) v2(333.61,269.49) v2(333.61,267.46) v2(333.61,265.43) v2(333.61,224.79) v2(333.61,222.76) v2(333.61,215.59) v2(333.61,213.56) v2(333.61,211.53) v2(333.61,209.49) v2(333.61,207.46) v2(333.61,205.43) v2(333.61,136.34) v2(333.61,134.31) v2(333.61,132.28) v2(333.61,130.25) v2(335.65,299.97) v2(335.65,297.94) v2(335.65,295.91) v2(335.65,293.88) v2(335.65,291.85) v2(335.65,289.81) v2(335.65,287.78) v2(335.65,285.75) v2(335.65,283.72) v2(335.65,273.56) v2(335.65,271.53) v2(335.65,267.46) v2(335.65,265.43) v2(335.65,245.11) v2(335.65,234.95) v2(335.65,224.79) v2(335.65,222.76) v2(335.65,215.59) v2(335.65,213.56) v2(335.65,211.53) v2(335.65,207.46) v2(335.65,205.43) v2(335.65,185.11) v2(335.65,174.95) v2(335.65,136.34) v2(335.65,134.31) v2(335.65,132.28) v2(335.65,130.25) v2(337.68,299.97) v2(337.68,297.94) v2(337.68,295.91) v2(337.68,293.88) v2(337.68,283.72) v2(337.68,273.56) v2(337.68,271.53) v2(337.68,269.49) v2(337.68,265.43) v2(337.68,245.11) v2(337.68,243.08) v2(337.68,234.95) v2(337.68,224.79) v2(337.68,222.76) v2(337.68,215.59) v2(337.68,213.56) v2(337.68,211.53) v2(337.68,209.49) v2(337.68,205.43) v2(337.68,185.11) v2(337.68,183.08) v2(337.68,174.95) v2(337.68,136.34) v2(337.68,134.31) v2(337.68,132.28) v2(337.68,130.25) v2(339,268.75) v2(339,208.75) v2(339.71,299.97) v2(339.71,297.94) v2(339.71,295.91) v2(339.71,283.72) v2(339.71,281.69) v2(339.71,279.65) v2(339.71,277.62) v2(339.71,275.59) v2(339.71,273.56) v2(339.71,271.53) v2(339.71,253.24) v2(339.71,251.21) v2(339.71,249.17) v2(339.71,246.89) v2(339.71,245.11) v2(339.71,243.08) v2(339.71,241.05) v2(339.71,239.01) v2(339.71,236.98) v2(339.71,234.95) v2(339.71,215.59) v2(339.71,213.56) v2(339.71,211.53) v2(339.71,193.24) v2(339.71,191.21) v2(339.71,189.17) v2(339.71,186.89) v2(339.71,185.11) v2(339.71,183.08) v2(339.71,181.05) v2(339.71,179.01) v2(339.71,176.98) v2(339.71,174.95) v2(339.71,160.73) v2(339.71,158.69) v2(339.71,150.57) v2(339.71,136.34) v2(339.71,134.31) v2(339.71,132.28) v2(339.71,130.25) v2(340.32,269.61) v2(340.32,209.61) v2(341.74,299.97) v2(341.74,297.94) v2(341.74,283.72) v2(341.74,281.69) v2(341.74,279.65) v2(341.74,273.56) v2(341.74,271.53) v2(341.74,257.3) v2(341.74,255.27) v2(341.74,253.24) v2(341.74,251.21) v2(341.74,249.17) v2(341.74,247.14) v2(341.74,245.11) v2(341.74,241.05) v2(341.74,228.85) v2(341.74,220.73) v2(341.74,218.69) v2(341.74,215.59) v2(341.74,213.56) v2(341.74,211.53) v2(341.74,197.3) v2(341.74,195.27) v2(341.74,193.24) v2(341.74,191.21) v2(341.74,189.17) v2(341.74,187.14) v2(341.74,185.11) v2(341.74,181.05) v2(341.74,168.85) v2(341.74,160.73) v2(341.74,158.69) v2(341.74,148.53) v2(341.74,146.5) v2(341.74,132.28) v2(341.74,130.25) v2(341.84,266.27) v2(341.84,264.24) v2(341.84,262.2) v2(341.84,206.27) v2(341.84,204.24) v2(341.84,202.2) v2(343.24,235.18) v2(343.24,234.62) v2(343.24,175.18) v2(343.24,174.62) v2(343.77,299.97) v2(343.77,297.94) v2(343.77,279.65) v2(343.77,273.56) v2(343.77,271.53) v2(343.77,257.3) v2(343.77,255.27) v2(343.77,253.24) v2(343.77,251.21) v2(343.77,228.85) v2(343.77,220.73) v2(343.77,218.69) v2(343.77,215.59) v2(343.77,213.56) v2(343.77,211.53) v2(343.77,197.3) v2(343.77,195.27) v2(343.77,193.24) v2(343.77,191.21) v2(343.77,168.85) v2(343.77,160.73) v2(343.77,158.69) v2(343.77,150.57) v2(343.77,148.53) v2(343.77,132.28) v2(343.77,130.25) v2(344.96,236.88) v2(344.96,176.88) v2(345.69,262.36) v2(345.69,202.36) v2(345.81,299.97) v2(345.81,297.94) v2(345.81,279.65) v2(345.81,277.62) v2(345.81,275.59) v2(345.81,273.56) v2(345.81,271.53) v2(345.81,269.49) v2(345.81,267.46) v2(345.86,264.61) v2(345.81,228.85) v2(345.81,220.73) v2(345.81,218.69) v2(345.81,215.59) v2(345.81,213.56) v2(345.81,211.53) v2(345.81,209.49) v2(345.81,207.46) v2(345.86,204.61) v2(345.81,168.85) v2(345.81,160.73) v2(345.81,158.69) v2(345.81,132.28) v2(345.81,130.25) v2(345.95,245.61) v2(345.95,185.61) v2(346.41,236.88) v2(346.41,176.88) v2(347.13,192.15) v2(347.25,246.26) v2(347.25,238.45) v2(347.25,186.26) v2(347.25,178.46) v2(347.84,299.97) v2(347.84,297.94) v2(347.84,279.65) v2(347.84,273.56) v2(347.84,228.85) v2(347.84,220.73) v2(347.84,218.69) v2(347.84,215.59) v2(347.84,213.56) v2(347.84,160.73) v2(347.84,158.69) v2(347.84,148.53) v2(347.84,130.25) v2(347.9,247.56) v2(347.9,244.31) v2(347.9,243.66) v2(347.9,243.01) v2(347.9,241.06) v2(347.9,238.45) v2(347.9,187.56) v2(347.9,184.31) v2(347.9,183.66) v2(347.9,183.01) v2(347.9,181.06) v2(347.9,178.46) v2(348.01,234.83) v2(348.01,174.83) v2(348.55,245.61) v2(348.55,244.96) v2(348.55,244.31) v2(348.55,243.66) v2(348.55,243.01) v2(348.55,242.36) v2(348.55,185.61) v2(348.55,184.96) v2(348.55,184.31) v2(348.55,183.66) v2(348.55,183.01) v2(348.55,182.36) v2(348.55,178.46) v2(348.65,252.12) v2(348.65,192.12) v2(348.71,233) v2(348.71,173) v2(349.24,270.27) v2(349.2,248.2) v2(349.2,247.56) v2(349.2,244.31) v2(349.2,243.66) v2(349.2,243.01) v2(349.2,242.36) v2(349.2,241.71) v2(349.2,241.06) v2(349.2,240.41) v2(349.24,210.27) v2(349.2,188.21) v2(349.2,187.56) v2(349.2,184.31) v2(349.2,183.66) v2(349.2,183.01) v2(349.2,182.36) v2(349.2,181.71) v2(349.2,181.06) v2(349.2,180.41) v2(349.87,299.97) v2(349.87,297.94) v2(349.87,281.69) v2(349.87,279.65) v2(349.85,247.56) v2(349.85,246.91) v2(349.85,246.26) v2(349.85,245.61) v2(349.85,244.31) v2(349.85,243.66) v2(349.85,243.01) v2(349.85,242.36) v2(349.85,239.1) v2(349.87,228.85) v2(349.87,215.59) v2(349.85,187.56) v2(349.85,186.91) v2(349.85,186.26) v2(349.85,185.61) v2(349.85,184.31) v2(349.85,183.66) v2(349.85,183.01) v2(349.85,182.36) v2(349.85,179.11) v2(349.87,168.85) v2(349.87,156.66) v2(349.87,148.53) v2(349.87,130.25) v2(350.04,218.49) v2(350.04,158.49) v2(350.5,250.8) v2(350.5,247.56) v2(350.5,244.96) v2(350.5,243.65) v2(350.5,243.01) v2(350.5,242.36) v2(350.5,239.1) v2(350.5,190.81) v2(350.5,184.96) v2(350.5,183.65) v2(350.5,183.01) v2(350.5,182.36) v2(350.5,179.11) v2(350.76,252.5) v2(350.84,274.17) v2(350.84,214.17) v2(351.15,250.8) v2(351.15,247.56) v2(351.15,246.91) v2(351.15,243.65) v2(351.15,243.01) v2(351.15,242.36) v2(351.15,240.4) v2(351.15,239.1) v2(351.15,190.81) v2(351.15,187.56) v2(351.15,186.91) v2(351.15,183.65) v2(351.15,183.01) v2(351.15,182.36) v2(351.15,180.41) v2(351.15,179.11) v2(351.43,267.19) v2(351.43,207.19) v2(351.8,250.8) v2(351.8,245.61) v2(351.8,244.31) v2(351.8,243.66) v2(351.8,242.35) v2(351.8,240.4) v2(351.8,239.75) v2(351.8,190.81) v2(351.8,185.61) v2(351.8,184.31) v2(351.8,183.66) v2(351.8,182.35) v2(351.8,180.41) v2(351.8,179.76) v2(351.9,299.97) v2(351.9,297.94) v2(351.9,279.65) v2(351.9,277.62) v2(351.9,275.59) v2(351.9,236.98) v2(351.9,215.59) v2(351.9,176.98) v2(351.9,156.66) v2(351.9,148.53) v2(351.9,130.25) v2(352,274.17) v2(352.03,259.97) v2(352.03,257.94) v2(352.03,255.91) v2(352.03,253.87) v2(352.08,218.49) v2(352,214.17) v2(352.03,199.97) v2(352.03,197.94) v2(352.03,195.91) v2(352.03,193.87) v2(352.08,158.49) v2(352.45,267.19) v2(352.45,250.8) v2(352.45,244.96) v2(352.45,243.65) v2(352.45,242.35) v2(352.45,240.4) v2(352.45,207.19) v2(352.45,190.81) v2(352.45,184.96) v2(352.45,183.65) v2(352.45,182.35) v2(352.45,180.41) v2(353.1,250.8) v2(353.1,243.65) v2(353.1,243.01) v2(353.1,242.36) v2(353.1,241.71) v2(353.1,241.06) v2(353.1,183.65) v2(353.1,183.01) v2(353.1,182.36) v2(353.1,181.71) v2(353.1,181.06) v2(353.66,269.74) v2(353.66,209.74) v2(353.75,244.31) v2(353.75,243) v2(353.75,242.36) v2(353.75,184.31) v2(353.75,183) v2(353.75,182.36) v2(353.93,299.97) v2(353.93,297.94) v2(353.93,281.69) v2(353.93,279.65) v2(353.93,273.56) v2(353.93,253.24) v2(353.93,215.59) v2(353.93,213.56) v2(353.93,193.24) v2(353.93,156.66) v2(353.93,154.63) v2(353.93,152.6) v2(353.93,150.57) v2(353.93,130.25) v2(354.11,218.49) v2(354.11,158.49) v2(354.4,244.96) v2(354.4,243.65) v2(354.4,184.96) v2(354.4,183.65) v2(355.05,250.8) v2(355.05,190.81) v2(355.23,223.79) v2(355.23,163.79) v2(355.66,236.42) v2(355.66,234.39) v2(355.66,232.36) v2(355.66,230.33) v2(355.66,176.42) v2(355.66,174.39) v2(355.66,172.36) v2(355.66,170.33) v2(355.7,243) v2(355.7,183) v2(355.97,299.97) v2(355.97,297.94) v2(355.97,279.65) v2(355.97,273.56) v2(355.97,271.53) v2(355.97,265.43) v2(355.97,253.24) v2(355.97,215.59) v2(355.97,213.56) v2(355.97,211.53) v2(355.97,205.43) v2(355.97,193.24) v2(355.97,156.66) v2(355.97,154.63) v2(355.97,152.6) v2(355.97,150.57) v2(355.97,130.25) v2(356.14,218.49) v2(356.14,158.49) v2(356.81,237.58) v2(356.81,177.58) v2(358,299.97) v2(358,297.94) v2(358,295.91) v2(358,279.65) v2(358,277.62) v2(358,275.59) v2(358,273.56) v2(358,265.43) v2(358,263.4) v2(358,261.37) v2(358,259.33) v2(358,257.3) v2(358,255.27) v2(358,253.24) v2(358,251.21) v2(358,222.76) v2(358,220.73) v2(358,218.69) v2(358,215.59) v2(358,213.56) v2(358,205.43) v2(358,203.4) v2(358,201.37) v2(358,199.33) v2(358,197.3) v2(358,195.27) v2(358,193.24) v2(358,191.21) v2(358,162.76) v2(358,160.73) v2(358,158.69) v2(358,156.66) v2(358,152.6) v2(358,150.57) v2(358,130.25) v2(358.25,239.01) v2(358.25,179.01) v2(358.3,242.82) v2(358.3,241.05) v2(358.3,182.82) v2(358.3,181.05) v2(360.03,299.97) v2(360.03,297.94) v2(360.03,295.91) v2(360.03,293.88) v2(360.03,281.69) v2(360.03,279.65) v2(360.03,277.62) v2(360.03,275.59) v2(360.03,273.56) v2(360.03,265.43) v2(360.03,263.4) v2(360.03,261.37) v2(360.03,259.33) v2(360.03,257.3) v2(360.03,255.27) v2(360.03,253.24) v2(360.03,251.21) v2(360.03,249.17) v2(360.03,247.14) v2(360.03,245.11) v2(360.03,243.08) v2(360.03,241.05) v2(360.03,239.01) v2(360.03,236.98) v2(360.03,222.76) v2(360.03,220.73) v2(360.03,218.69) v2(360.03,215.59) v2(360.03,213.56) v2(360.03,205.43) v2(360.03,203.4) v2(360.03,201.37) v2(360.03,199.33) v2(360.03,197.3) v2(360.03,195.27) v2(360.03,193.24) v2(360.03,191.21) v2(360.03,189.17) v2(360.03,187.14) v2(360.03,185.11) v2(360.03,183.08) v2(360.03,181.05) v2(360.03,179.01) v2(360.03,176.98) v2(360.03,162.76) v2(360.03,160.73) v2(360.03,158.69) v2(360.03,156.66) v2(360.03,146.5) v2(360.03,130.25) v2(361.57,224.79) v2(361.57,164.79) v2(362.06,299.97) v2(362.06,297.94) v2(362.06,295.91) v2(362.06,293.88) v2(362.06,291.85) v2(362.06,289.81) v2(362.06,287.78) v2(362.06,285.75) v2(362.06,283.72) v2(362.06,281.69) v2(362.06,279.65) v2(362.06,277.62) v2(362.06,275.59) v2(362.06,273.56) v2(362.06,271.53) v2(362.06,265.43) v2(362.06,263.4) v2(362.06,253.24) v2(362.06,251.21) v2(362.06,249.17) v2(362.06,247.14) v2(362.06,245.11) v2(362.06,243.08) v2(362.06,241.05) v2(362.06,239.01) v2(362.06,236.98) v2(362.06,234.95) v2(362.06,215.59) v2(362.06,213.56) v2(362.06,211.53) v2(362.06,205.43) v2(362.06,203.4) v2(362.06,193.24) v2(362.06,191.21) v2(362.06,189.17) v2(362.06,187.14) v2(362.06,185.11) v2(362.06,183.08) v2(362.06,181.05) v2(362.06,179.01) v2(362.06,176.98) v2(362.06,174.95) v2(362.06,156.66) v2(362.06,146.5) v2(362.06,132.28) v2(362.06,130.25) v2(363.74,270.18) v2(363.74,210.18) v2(364.09,299.97) v2(364.09,293.88) v2(364.09,291.85) v2(364.09,289.81) v2(364.09,287.78) v2(364.09,285.75) v2(364.09,283.72) v2(364.09,265.43) v2(364.09,253.24) v2(364.09,251.21) v2(364.09,249.17) v2(364.09,247.14) v2(364.09,245.11) v2(364.09,243.08) v2(364.09,241.05) v2(364.09,239.01) v2(364.09,236.98) v2(364.09,234.95) v2(364.09,215.59) v2(364.09,205.43) v2(364.09,193.24) v2(364.09,191.21) v2(364.09,189.17) v2(364.09,187.14) v2(364.09,185.11) v2(364.09,183.08) v2(364.09,181.05) v2(364.09,179.01) v2(364.09,176.98) v2(364.09,174.95) v2(364.09,156.66) v2(364.09,150.57) v2(364.09,148.53) v2(364.09,146.5) v2(364.09,144.47) v2(364.09,142.44) v2(364.09,140.41) v2(364.09,138.37) v2(364.09,136.34) v2(364.09,134.31) v2(364.09,132.28) v2(364.09,130.25) v2(364.68,274.19) v2(364.68,214.19) v2(364.78,271.22) v2(364.78,211.22) v2(366.13,299.97) v2(366.13,293.88) v2(366.13,291.85) v2(366.13,289.81) v2(366.13,287.78) v2(366.13,285.75) v2(366.13,283.72) v2(366.13,265.43) v2(366.13,253.24) v2(366.13,251.21) v2(366.13,249.17) v2(366.13,247.14) v2(366.13,245.11) v2(366.13,243.08) v2(366.13,241.05) v2(366.13,239.01) v2(366.13,236.98) v2(366.13,234.95) v2(366.13,215.59) v2(366.13,205.43) v2(366.13,193.24) v2(366.13,191.21) v2(366.13,189.17) v2(366.13,187.14) v2(366.13,185.11) v2(366.13,183.08) v2(366.13,181.05) v2(366.13,179.01) v2(366.13,176.98) v2(366.13,174.95) v2(366.13,156.66) v2(366.13,150.57) v2(366.13,148.53) v2(366.13,146.5) v2(366.13,144.47) v2(366.13,142.44) v2(366.13,140.41) v2(366.13,138.37) v2(366.13,136.34) v2(366.13,134.31) v2(366.13,132.28) v2(366.13,130.25) v2(366.63,274.19) v2(366.63,214.19) v2(368.16,299.97) v2(368.16,297.94) v2(368.16,295.91) v2(368.16,293.88) v2(368.16,291.85) v2(368.16,289.81) v2(368.16,287.78) v2(368.16,285.75) v2(368.16,283.72) v2(368.16,281.69) v2(368.16,279.65) v2(368.16,277.62) v2(368.16,275.59) v2(368.16,273.56) v2(368.16,269.49) v2(368.16,267.46) v2(368.16,265.43) v2(368.16,255.27) v2(368.16,253.24) v2(368.16,251.21) v2(368.16,249.17) v2(368.16,247.14) v2(368.16,245.11) v2(368.16,243.08) v2(368.16,241.05) v2(368.16,239.01) v2(368.16,236.98) v2(368.16,234.95) v2(368.16,215.59) v2(368.16,213.56) v2(368.16,209.49) v2(368.16,207.46) v2(368.16,205.43) v2(368.16,195.27) v2(368.16,193.24) v2(368.16,191.21) v2(368.16,189.17) v2(368.16,187.14) v2(368.16,185.11) v2(368.16,183.08) v2(368.16,181.05) v2(368.16,179.01) v2(368.16,176.98) v2(368.16,174.95) v2(368.16,156.66) v2(368.16,152.6) v2(368.16,150.57) v2(368.16,148.53) v2(368.16,146.5) v2(368.16,144.47) v2(368.16,142.44) v2(368.16,140.41) v2(368.16,138.37) v2(368.16,136.34) v2(368.16,134.31) v2(368.16,132.28) v2(368.16,130.25) v3(8.89,290.83) v3(8.89,285.75) v3(8.89,280.67) v3(8.89,275.59) v3(8.89,270.51) v3(8.89,265.43) v3(8.89,260.35) v3(8.89,255.27) v3(8.89,250.19) v3(8.89,245.11) v3(8.89,240.03) v3(8.89,234.95) v3(8.89,229.87) v3(8.89,224.79) v3(8.89,204.47) v3(8.89,199.39) v3(8.89,194.31) v3(8.89,189.23) v3(8.89,184.15) v3(8.89,179.07) v3(8.89,173.99) v3(8.89,168.91) v3(8.89,163.83) v3(8.89,158.75) v3(8.89,143.51) v3(8.89,138.43) v3(8.89,122.76) v3(8.89,121.99) v3(8.89,121.23) v3(8.89,118.56) v3(8.89,117.8) v3(8.89,117.04) v3(8.89,114.37) v3(8.89,113.61) v3(8.89,112.85) v3(8.89,110.18) v3(8.89,109.42) v3(8.89,108.66) v3(9.66,320.6) v3(9.66,319.84) v3(9.66,319.08) v3(9.66,316.41) v3(9.66,315.65) v3(9.66,314.89) v3(9.66,312.22) v3(9.66,311.46) v3(9.66,310.7) v3(9.66,308.03) v3(9.66,307.27) v3(9.66,306.5) v3(11.43,293.37) v3(11.43,288.29) v3(11.43,283.21) v3(11.43,278.13) v3(11.43,273.05) v3(11.43,267.97) v3(11.43,262.89) v3(11.43,257.81) v3(11.43,252.73) v3(11.43,247.65) v3(11.43,242.57) v3(11.43,237.49) v3(11.43,232.41) v3(11.43,227.33) v3(11.43,222.25) v3(11.43,217.17) v3(11.43,212.09) v3(11.43,207.01) v3(11.43,201.93) v3(11.43,196.85) v3(11.43,191.77) v3(11.43,186.69) v3(11.43,181.61) v3(11.43,176.53) v3(11.43,171.45) v3(11.43,166.37) v3(11.43,161.29) v3(11.43,156.21) v3(11.43,146.05) v3(11.43,140.97) v3(11.43,135.89) v3(13.2,122.76) v3(13.2,121.99) v3(13.2,121.23) v3(13.2,118.56) v3(13.2,117.8) v3(13.2,117.04) v3(13.2,114.37) v3(13.2,113.61) v3(13.2,112.85) v3(13.2,110.18) v3(13.2,109.42) v3(13.2,108.66) v3(13.97,320.6) v3(13.97,319.84) v3(13.97,319.08) v3(13.97,316.41) v3(13.97,315.65) v3(13.97,314.89) v3(13.97,312.22) v3(13.97,311.46) v3(13.97,310.7) v3(13.97,308.03) v3(13.97,307.27) v3(13.97,306.5) v3(13.97,290.83) v3(13.97,285.75) v3(13.97,280.67) v3(13.97,275.59) v3(13.97,270.51) v3(13.97,265.43) v3(13.97,260.35) v3(13.97,255.27) v3(13.97,250.19) v3(13.97,245.11) v3(13.97,240.03) v3(13.97,234.95) v3(13.97,229.87) v3(13.97,224.79) v3(13.97,219.71) v3(13.97,214.63) v3(13.97,209.55) v3(13.97,204.47) v3(13.97,199.39) v3(13.97,194.31) v3(13.97,189.23) v3(13.97,184.15) v3(13.97,179.07) v3(13.97,173.99) v3(13.97,168.91) v3(13.97,163.83) v3(13.97,158.75) v3(13.97,143.51) v3(13.97,138.43) v3(13.97,133.35) v3(16.51,298.45) v3(16.51,293.37) v3(16.51,288.29) v3(16.51,283.21) v3(16.51,278.13) v3(16.51,273.05) v3(16.51,267.97) v3(16.51,262.89) v3(16.51,257.81) v3(16.51,252.73) v3(16.51,247.65) v3(16.51,242.57) v3(16.51,237.49) v3(16.51,232.41) v3(16.51,227.33) v3(16.51,222.25) v3(16.51,217.17) v3(16.51,212.09) v3(16.51,207.01) v3(16.51,201.93) v3(16.51,196.85) v3(16.51,191.77) v3(16.51,186.69) v3(16.51,181.61) v3(16.51,176.53) v3(16.51,171.45) v3(16.51,166.37) v3(16.51,161.29) v3(16.51,156.21) v3(16.51,151.13) v3(16.51,146.05) v3(16.51,140.97) v3(16.51,135.89) v3(16.51,130.81) v3(17.52,122.76) v3(17.52,121.99) v3(17.52,121.23) v3(17.52,118.56) v3(17.52,117.8) v3(17.52,117.04) v3(17.52,114.37) v3(17.52,113.61) v3(17.52,112.85) v3(17.52,110.18) v3(17.52,109.42) v3(17.52,108.66) v3(18.29,320.6) v3(18.29,319.84) v3(18.29,319.08) v3(18.29,316.41) v3(18.29,315.65) v3(18.29,314.89) v3(18.29,312.22) v3(18.29,311.46) v3(18.29,310.7) v3(18.29,308.03) v3(18.29,307.27) v3(18.29,306.5) v3(19.05,300.99) v3(19.05,290.83) v3(19.05,285.75) v3(19.05,280.67) v3(19.05,275.59) v3(19.05,270.51) v3(19.05,265.43) v3(19.05,260.35) v3(19.05,255.27) v3(19.05,250.19) v3(19.05,245.11) v3(19.05,240.03) v3(19.05,234.95) v3(19.05,229.87) v3(19.05,224.79) v3(19.05,219.71) v3(19.05,214.63) v3(19.05,209.55) v3(19.05,204.47) v3(19.05,199.39) v3(19.05,194.31) v3(19.05,189.23) v3(19.05,184.15) v3(19.05,179.07) v3(19.05,173.99) v3(19.05,168.91) v3(19.05,163.83) v3(19.05,158.75) v3(19.05,153.67) v3(19.05,148.59) v3(19.05,143.51) v3(19.05,138.43) v3(19.05,128.27) v3(21.59,293.37) v3(21.59,288.29) v3(21.59,283.21) v3(21.59,278.13) v3(21.59,273.05) v3(21.59,267.97) v3(21.59,262.89) v3(21.59,257.81) v3(21.59,252.73) v3(21.59,247.65) v3(21.59,242.57) v3(21.59,237.49) v3(21.59,232.41) v3(21.59,227.33) v3(21.59,222.25) v3(21.59,217.17) v3(21.59,212.09) v3(21.59,207.01) v3(21.59,201.93) v3(21.59,196.85) v3(21.59,191.77) v3(21.59,146.05) v3(21.59,140.97) v3(21.59,135.89) v3(21.84,122.76) v3(21.84,121.99) v3(21.84,121.23) v3(21.84,118.56) v3(21.84,117.8) v3(21.84,117.04) v3(21.84,114.37) v3(21.84,113.61) v3(21.84,112.85) v3(21.84,110.18) v3(21.84,109.42) v3(21.84,108.66) v3(22.61,320.6) v3(22.61,319.84) v3(22.61,319.08) v3(22.61,316.41) v3(22.61,315.65) v3(22.61,314.89) v3(22.61,312.22) v3(22.61,311.46) v3(22.61,310.7) v3(22.61,308.03) v3(22.61,307.27) v3(22.61,306.5) v3(24.13,300.99) v3(24.13,290.83) v3(24.13,285.75) v3(24.13,280.67) v3(24.13,275.59) v3(24.13,270.51) v3(24.13,265.43) v3(24.13,260.35) v3(24.13,255.27) v3(24.13,250.19) v3(24.13,245.11) v3(24.13,240.03) v3(24.13,234.95) v3(24.13,229.87) v3(24.13,224.79) v3(24.13,219.71) v3(24.13,214.63) v3(24.13,209.55) v3(24.13,204.47) v3(24.13,199.39) v3(24.13,194.31) v3(24.13,189.23) v3(24.13,143.51) v3(24.13,138.43) v3(24.13,128.27) v3(26.16,122.76) v3(26.16,121.99) v3(26.16,121.23) v3(26.16,118.56) v3(26.16,117.8) v3(26.16,117.04) v3(26.16,114.37) v3(26.16,113.61) v3(26.16,112.85) v3(26.16,110.18) v3(26.16,109.42) v3(26.16,108.66) v3(26.67,298.45) v3(26.67,293.37) v3(26.67,288.29) v3(26.67,283.21) v3(26.67,278.13) v3(26.67,273.05) v3(26.67,267.97) v3(26.67,262.89) v3(26.67,257.81) v3(26.67,252.73) v3(26.67,247.65) v3(26.67,242.57) v3(26.67,237.49) v3(26.67,232.41) v3(26.67,227.33) v3(26.67,222.25) v3(26.67,217.17) v3(26.67,212.09) v3(26.67,207.01) v3(26.67,201.93) v3(26.67,196.85) v3(26.67,191.77) v3(26.67,146.05) v3(26.67,140.97) v3(26.67,135.89) v3(26.67,130.81) v3(26.93,320.6) v3(26.93,319.84) v3(26.93,319.08) v3(26.93,316.41) v3(26.93,315.65) v3(26.93,314.89) v3(26.93,312.22) v3(26.93,311.46) v3(26.93,310.7) v3(26.93,308.03) v3(26.93,307.27) v3(26.93,306.5) v3(29.21,300.99) v3(29.21,295.91) v3(29.21,290.83) v3(29.21,285.75) v3(29.21,280.67) v3(29.21,275.59) v3(29.21,270.51) v3(29.21,265.43) v3(29.21,260.35) v3(29.21,255.27) v3(29.21,250.19) v3(29.21,245.11) v3(29.21,240.03) v3(29.21,234.95) v3(29.21,229.87) v3(29.21,224.79) v3(29.21,219.71) v3(29.21,214.63) v3(29.21,209.55) v3(29.21,204.47) v3(29.21,199.39) v3(29.21,194.31) v3(29.21,189.23) v3(29.21,184.15) v3(29.21,179.07) v3(29.21,173.99) v3(29.21,168.91) v3(29.21,163.83) v3(29.21,158.75) v3(29.21,153.67) v3(29.21,148.59) v3(29.21,143.51) v3(29.21,138.43) v3(29.21,133.35) v3(29.21,128.27) v3(30.48,122.76) v3(30.48,121.99) v3(30.48,121.23) v3(30.48,118.56) v3(30.48,117.8) v3(30.48,117.04) v3(30.48,114.37) v3(30.48,113.61) v3(30.48,112.85) v3(30.48,110.18) v3(30.48,109.42) v3(30.48,108.66) v3(31.25,320.6) v3(31.25,319.84) v3(31.25,319.08) v3(31.25,316.41) v3(31.25,315.65) v3(31.25,314.89) v3(31.25,312.22) v3(31.25,311.46) v3(31.25,310.7) v3(31.25,308.03) v3(31.25,307.27) v3(31.25,306.5) v3(31.75,298.45) v3(31.75,293.37) v3(31.75,288.29) v3(31.75,283.21) v3(31.75,278.13) v3(31.75,273.05) v3(31.75,267.97) v3(31.75,262.89) v3(31.75,257.81) v3(31.75,252.73) v3(31.75,247.65) v3(31.75,242.57) v3(31.75,237.49) v3(31.75,232.41) v3(31.75,227.33) v3(31.75,222.25) v3(31.75,217.17) v3(31.75,212.09) v3(31.75,207.01) v3(31.75,201.93) v3(31.75,196.85) v3(31.75,191.77) v3(31.75,186.69) v3(31.75,181.61) v3(31.75,176.53) v3(31.75,171.45) v3(31.75,166.37) v3(31.75,161.29) v3(31.75,156.21) v3(31.75,151.13) v3(31.75,146.05) v3(31.75,140.97) v3(31.75,135.89) v3(31.75,130.81) v3(34.29,300.99) v3(34.29,295.91) v3(34.29,290.83) v3(34.29,285.75) v3(34.29,280.67) v3(34.29,275.59) v3(34.29,270.51) v3(34.29,265.43) v3(34.29,260.35) v3(34.29,255.27) v3(34.29,250.19) v3(34.29,245.11) v3(34.29,240.03) v3(34.29,234.95) v3(34.29,229.87) v3(34.29,224.79) v3(34.29,219.71) v3(34.29,214.63) v3(34.29,209.55) v3(34.29,204.47) v3(34.29,199.39) v3(34.29,194.31) v3(34.29,189.23) v3(34.29,184.15) v3(34.29,179.07) v3(34.29,173.99) v3(34.29,168.91) v3(34.29,163.83) v3(34.29,158.75) v3(34.29,153.67) v3(34.29,148.59) v3(34.29,143.51) v3(34.29,138.43) v3(34.29,133.35) v3(34.29,128.27) v3(34.79,122.76) v3(34.79,121.99) v3(34.79,121.23) v3(34.79,118.56) v3(34.79,117.8) v3(34.79,117.04) v3(34.79,114.37) v3(34.79,113.61) v3(34.79,112.85) v3(34.79,110.18) v3(34.79,109.42) v3(34.79,108.66) v3(35.56,320.6) v3(35.56,319.84) v3(35.56,319.08) v3(35.56,316.41) v3(35.56,315.65) v3(35.56,314.89) v3(35.56,312.22) v3(35.56,311.46) v3(35.56,310.7) v3(35.56,308.03) v3(35.56,307.27) v3(35.56,306.5) v3(36.83,298.45) v3(36.83,293.37) v3(36.83,288.29) v3(36.83,283.21) v3(36.83,278.13) v3(36.83,273.05) v3(36.83,257.81) v3(36.83,242.57) v3(36.83,237.49) v3(36.83,232.41) v3(36.83,227.33) v3(36.83,222.25) v3(36.83,217.17) v3(36.83,191.77) v3(36.83,166.37) v3(36.83,135.89) v3(36.83,130.81) v3(37.66,268.47) v3(37.66,266.27) v3(37.84,250.3) v3(37.84,248.1) v3(39.11,122.76) v3(39.11,121.99) v3(39.11,121.23) v3(39.11,118.56) v3(39.11,117.8) v3(39.11,117.04) v3(39.11,114.37) v3(39.11,113.61) v3(39.11,112.85) v3(39.11,110.18) v3(39.11,109.42) v3(39.11,108.66) v3(39.37,300.99) v3(39.37,295.91) v3(39.37,290.83) v3(39.37,285.75) v3(39.37,280.67) v3(39.37,260.35) v3(39.37,240.03) v3(39.37,234.95) v3(39.37,229.87) v3(39.37,224.79) v3(39.37,219.71) v3(39.37,163.83) v3(39.37,138.43) v3(39.37,133.35) v3(39.37,128.27) v3(39.88,320.6) v3(39.88,319.84) v3(39.88,319.08) v3(39.88,316.41) v3(39.88,315.65) v3(39.88,314.89) v3(39.88,312.22) v3(39.88,311.46) v3(39.88,310.7) v3(39.88,308.03) v3(39.88,307.27) v3(39.88,306.5) v3(40.03,272.89) v3(40.21,254.72) v3(41.91,293.37) v3(41.91,288.29) v3(41.91,283.21) v3(41.91,278.13) v3(41.91,257.81) v3(41.91,242.57) v3(41.91,237.49) v3(41.91,232.41) v3(41.91,227.33) v3(41.91,222.25) v3(41.91,217.17) v3(41.91,191.77) v3(41.91,166.37) v3(41.91,135.89) v3(41.91,130.81) v3(43.43,122.76) v3(43.43,121.99) v3(43.43,121.23) v3(43.43,118.56) v3(43.43,117.8) v3(43.43,117.04) v3(43.43,114.37) v3(43.43,113.61) v3(43.43,112.85) v3(43.43,110.18) v3(43.43,109.42) v3(43.43,108.66) v3(44.2,320.6) v3(44.2,319.84) v3(44.2,319.08) v3(44.2,316.41) v3(44.2,315.65) v3(44.2,314.89) v3(44.2,312.22) v3(44.2,311.46) v3(44.2,310.7) v3(44.2,308.03) v3(44.2,307.27) v3(44.2,306.5) v3(44.45,300.99) v3(44.45,295.91) v3(44.45,290.83) v3(44.45,285.75) v3(44.45,280.67) v3(44.45,275.59) v3(44.45,260.35) v3(44.45,240.03) v3(44.45,234.95) v3(44.45,229.87) v3(44.45,224.79) v3(44.45,219.71) v3(44.45,163.83) v3(44.45,138.43) v3(44.45,133.35) v3(44.45,128.27) v3(46.84,272.89) v3(46.99,298.45) v3(46.99,293.37) v3(46.99,288.29) v3(46.99,283.21) v3(46.99,278.13) v3(47.02,254.72) v3(46.99,242.57) v3(46.99,237.49) v3(46.99,232.41) v3(46.99,227.33) v3(46.99,222.25) v3(46.99,217.17) v3(46.99,191.77) v3(46.99,166.37) v3(46.99,135.89) v3(46.99,130.81) v3(47.75,122.76) v3(47.75,121.99) v3(47.75,121.23) v3(47.75,118.56) v3(47.75,117.8) v3(47.75,117.04) v3(47.75,114.37) v3(47.75,113.61) v3(47.75,112.85) v3(47.75,110.18) v3(47.75,109.42) v3(47.75,108.66) v3(48.52,320.6) v3(48.52,319.84) v3(48.52,319.08) v3(48.52,316.41) v3(48.52,315.65) v3(48.52,314.89) v3(48.52,312.22) v3(48.52,311.46) v3(48.52,310.7) v3(48.52,308.03) v3(48.52,307.27) v3(48.52,306.5) v3(49.21,268.47) v3(49.21,266.27) v3(49.39,250.3) v3(49.39,248.1) v3(49.53,300.99) v3(49.53,295.91) v3(49.53,290.83) v3(49.53,285.75) v3(49.53,280.67) v3(49.53,275.59) v3(49.53,260.35) v3(49.53,255.27) v3(49.53,240.03) v3(49.53,234.95) v3(49.53,229.87) v3(49.53,224.79) v3(49.53,219.71) v3(49.53,163.83) v3(49.53,138.43) v3(49.53,133.35) v3(49.53,128.27) v3(52.07,298.45) v3(52.07,293.37) v3(52.07,288.29) v3(52.07,283.21) v3(52.07,278.13) v3(52.07,273.05) v3(52.07,267.97) v3(52.07,262.89) v3(52.07,257.81) v3(52.07,252.73) v3(52.07,247.65) v3(52.07,242.57) v3(52.07,237.49) v3(52.07,232.41) v3(52.07,227.33) v3(52.07,222.25) v3(52.07,217.17) v3(52.07,212.09) v3(52.07,207.01) v3(52.07,201.93) v3(52.07,196.85) v3(52.07,191.77) v3(52.07,186.69) v3(52.07,181.61) v3(52.07,176.53) v3(52.07,171.45) v3(52.07,166.37) v3(52.07,161.29) v3(52.07,156.21) v3(52.07,151.13) v3(52.07,146.05) v3(52.07,140.97) v3(52.07,135.89) v3(52.07,130.81) v3(52.07,122.76) v3(52.07,121.99) v3(52.07,121.23) v3(52.07,118.56) v3(52.07,117.8) v3(52.07,117.04) v3(52.07,114.37) v3(52.07,113.61) v3(52.07,112.85) v3(52.07,110.18) v3(52.07,109.42) v3(52.07,108.66) v3(52.84,320.6) v3(52.84,319.84) v3(52.84,319.08) v3(52.84,316.41) v3(52.84,315.65) v3(52.84,314.89) v3(52.84,312.22) v3(52.84,311.46) v3(52.84,310.7) v3(52.84,308.03) v3(52.84,307.27) v3(52.84,306.5) v3(54.61,300.99) v3(54.61,295.91) v3(54.61,290.83) v3(54.61,285.75) v3(54.61,280.67) v3(54.61,275.59) v3(54.61,260.35) v3(54.61,255.27) v3(54.61,240.03) v3(54.61,234.95) v3(54.61,229.87) v3(54.61,224.79) v3(54.61,219.71) v3(54.61,214.63) v3(54.61,209.55) v3(54.61,204.47) v3(54.61,199.39) v3(54.61,194.31) v3(54.61,189.23) v3(54.61,184.15) v3(54.61,179.07) v3(54.61,173.99) v3(54.61,168.91) v3(54.61,163.83) v3(54.61,158.75) v3(54.61,153.67) v3(54.61,148.59) v3(54.61,143.51) v3(54.61,138.43) v3(54.61,133.35) v3(54.61,128.27) v3(55.44,268.47) v3(55.44,266.27) v3(55.62,250.3) v3(55.62,248.1) v3(56.38,122.76) v3(56.38,121.99) v3(56.38,121.23) v3(56.38,118.56) v3(56.38,117.8) v3(56.38,117.04) v3(56.38,114.37) v3(56.38,113.61) v3(56.38,112.85) v3(56.38,110.18) v3(56.38,109.42) v3(56.38,108.66) v3(57.15,320.6) v3(57.15,319.84) v3(57.15,319.08) v3(57.15,316.41) v3(57.15,315.65) v3(57.15,314.89) v3(57.15,312.22) v3(57.15,311.46) v3(57.15,310.7) v3(57.15,308.03) v3(57.15,307.27) v3(57.15,306.5) v3(57.15,298.45) v3(57.15,293.37) v3(57.15,288.29) v3(57.15,283.21) v3(57.15,278.13) v3(57.15,242.57) v3(57.15,237.49) v3(57.15,232.41) v3(57.15,227.33) v3(57.15,222.25) v3(57.15,217.17) v3(57.15,191.77) v3(57.15,166.37) v3(57.15,135.89) v3(57.15,130.81) v3(57.81,272.89) v3(57.99,254.72) v3(59.69,300.99) v3(59.69,295.91) v3(59.69,290.83) v3(59.69,285.75) v3(59.69,280.67) v3(59.69,275.59) v3(59.69,260.35) v3(59.69,240.03) v3(59.69,234.95) v3(59.69,229.87) v3(59.69,224.79) v3(59.69,219.71) v3(59.69,163.83) v3(59.69,138.43) v3(59.69,133.35) v3(59.69,128.27) v3(62.23,298.45) v3(62.23,293.37) v3(62.23,288.29) v3(62.23,283.21) v3(62.23,278.13) v3(62.23,257.81) v3(62.23,242.57) v3(62.23,237.49) v3(62.23,232.41) v3(62.23,227.33) v3(62.23,222.25) v3(62.23,217.17) v3(62.23,191.77) v3(62.23,166.37) v3(62.23,135.89) v3(62.23,130.81) v3(64.62,272.89) v3(64.77,300.99) v3(64.77,295.91) v3(64.77,290.83) v3(64.77,285.75) v3(64.77,280.67) v3(64.77,260.35) v3(64.77,240.03) v3(64.77,234.95) v3(64.77,229.87) v3(64.77,224.79) v3(64.77,219.71) v3(64.77,163.83) v3(64.77,138.43) v3(64.77,133.35) v3(64.77,128.27) v3(64.8,254.72) v3(66.99,268.47) v3(66.99,266.27) v3(67.17,250.3) v3(67.17,248.1) v3(67.31,298.45) v3(67.31,293.37) v3(67.31,288.29) v3(67.31,283.21) v3(67.31,278.13) v3(67.31,273.05) v3(67.31,257.81) v3(67.31,242.57) v3(67.31,237.49) v3(67.31,232.41) v3(67.31,227.33) v3(67.31,222.25) v3(67.31,217.17) v3(67.31,191.77) v3(67.31,166.37) v3(67.31,135.89) v3(67.31,130.81) v3(69.85,300.99) v3(69.85,295.91) v3(69.85,290.83) v3(69.85,285.75) v3(69.85,280.67) v3(69.85,275.59) v3(69.85,270.51) v3(69.85,265.43) v3(69.85,260.35) v3(69.85,255.27) v3(69.85,250.19) v3(69.85,245.11) v3(69.85,240.03) v3(69.85,234.95) v3(69.85,229.87) v3(69.85,224.79) v3(69.85,219.71) v3(69.85,163.83) v3(69.85,138.43) v3(69.85,133.35) v3(69.85,128.27) v3(72.39,298.45) v3(72.39,257.81) v3(72.39,252.73) v3(72.39,247.65) v3(72.39,242.57) v3(72.39,237.49) v3(72.39,232.41) v3(72.39,227.33) v3(72.39,222.25) v3(72.39,217.17) v3(72.39,191.77) v3(72.39,166.37) v3(72.39,135.89) v3(72.39,130.81) v3(74.21,296.14) v3(74.21,282.43) v3(74.21,268.71) v3(74.93,300.99) v3(74.93,285.75) v3(74.93,270.51) v3(74.93,255.27) v3(74.93,250.19) v3(74.93,245.11) v3(74.93,240.03) v3(74.93,234.95) v3(74.93,229.87) v3(74.93,224.79) v3(74.93,219.71) v3(74.93,214.63) v3(74.93,209.55) v3(74.93,204.47) v3(74.93,199.39) v3(74.93,194.31) v3(74.93,189.23) v3(74.93,184.15) v3(74.93,179.07) v3(74.93,173.99) v3(74.93,168.91) v3(74.93,163.83) v3(74.93,158.75) v3(74.93,153.67) v3(74.93,148.59) v3(74.93,143.51) v3(74.93,138.43) v3(74.93,133.35) v3(74.93,128.27) v3(77.47,298.45) v3(77.47,273.05) v3(77.47,257.81) v3(77.47,252.73) v3(77.47,247.65) v3(77.47,242.57) v3(77.47,237.49) v3(77.47,232.41) v3(77.47,227.33) v3(77.47,222.25) v3(77.47,217.17) v3(77.47,212.09) v3(77.47,207.01) v3(77.47,201.93) v3(77.47,196.85) v3(77.47,191.77) v3(77.47,186.69) v3(77.47,181.61) v3(77.47,176.53) v3(77.47,171.45) v3(77.47,166.37) v3(77.47,161.29) v3(77.47,156.21) v3(77.47,151.13) v3(77.47,146.05) v3(77.47,140.97) v3(77.47,135.89) v3(77.47,130.81) v3(80.01,300.99) v3(80.01,285.75) v3(80.01,270.51) v3(80.01,255.27) v3(80.01,250.19) v3(80.01,245.11) v3(80.01,240.03) v3(80.01,234.95) v3(80.01,229.87) v3(80.01,224.79) v3(80.01,219.71) v3(80.01,214.63) v3(80.01,209.55) v3(80.01,204.47) v3(80.01,199.39) v3(80.01,194.31) v3(80.01,189.23) v3(80.01,184.15) v3(80.01,179.07) v3(80.01,173.99) v3(80.01,168.91) v3(80.01,163.83) v3(80.01,158.75) v3(80.01,153.67) v3(80.01,148.59) v3(80.01,143.51) v3(80.01,138.43) v3(80.01,133.35) v3(80.01,128.27) v3(82.07,290.81) v3(82.07,277.09) v3(82.07,263.38) v3(82.55,298.45) v3(82.55,283.21) v3(82.55,257.81) v3(82.55,252.73) v3(82.55,247.65) v3(82.55,242.57) v3(82.55,237.49) v3(82.55,232.41) v3(82.55,227.33) v3(82.55,222.25) v3(82.55,217.17) v3(82.55,212.09) v3(82.55,207.01) v3(82.55,201.93) v3(82.55,196.85) v3(82.55,191.77) v3(82.55,186.69) v3(82.55,181.61) v3(82.55,176.53) v3(82.55,171.45) v3(82.55,166.37) v3(82.55,161.29) v3(82.55,156.21) v3(82.55,151.13) v3(82.55,146.05) v3(82.55,140.97) v3(82.55,135.89) v3(82.55,130.81) v3(82.55,122.76) v3(82.55,121.99) v3(82.55,121.23) v3(82.55,118.56) v3(82.55,117.8) v3(82.55,117.04) v3(82.55,114.37) v3(82.55,113.61) v3(82.55,112.85) v3(82.55,110.18) v3(82.55,109.42) v3(82.55,108.66) v3(82.6,287.59) v3(82.6,273.88) v3(82.6,260.16) v3(83.32,320.6) v3(83.32,319.84) v3(83.32,319.08) v3(83.32,316.41) v3(83.32,315.65) v3(83.32,314.89) v3(83.32,312.22) v3(83.32,311.46) v3(83.32,310.7) v3(83.32,308.03) v3(83.32,307.27) v3(83.32,306.5) v3(83.74,287.59) v3(83.74,273.88) v3(83.74,260.16) v3(85.09,300.99) v3(85.09,285.75) v3(85.09,270.51) v3(85.09,255.27) v3(85.09,240.03) v3(85.09,234.95) v3(85.09,229.87) v3(85.09,224.79) v3(85.09,209.55) v3(85.09,204.47) v3(85.09,199.39) v3(85.09,194.31) v3(85.09,173.99) v3(85.09,168.91) v3(85.09,163.83) v3(85.09,158.75) v3(85.09,143.51) v3(85.09,138.43) v3(85.09,133.35) v3(85.09,128.27) v3(86.86,122.76) v3(86.86,121.99) v3(86.86,121.23) v3(86.86,118.56) v3(86.86,117.8) v3(86.86,117.04) v3(86.86,114.37) v3(86.86,113.61) v3(86.86,112.85) v3(86.86,110.18) v3(86.86,109.42) v3(86.86,108.66) v3(87.63,320.6) v3(87.63,319.84) v3(87.63,319.08) v3(87.63,316.41) v3(87.63,315.65) v3(87.63,314.89) v3(87.63,312.22) v3(87.63,311.46) v3(87.63,310.7) v3(87.63,308.03) v3(87.63,307.27) v3(87.63,306.5) v3(87.63,298.45) v3(87.63,283.21) v3(87.58,241.24) v3(87.63,227.33) v3(87.63,222.25) v3(87.58,209.49) v3(87.63,191.77) v3(87.58,177.74) v3(87.63,166.37) v3(87.63,161.29) v3(87.58,145.99) v3(87.63,135.89) v3(87.63,130.81) v3(88.1,237.74) v3(88.1,205.99) v3(88.1,174.24) v3(88.1,142.49) v3(89.92,287.53) v3(89.92,273.81) v3(89.92,260.1) v3(90.17,300.99) v3(90.17,270.51) v3(90.17,255.27) v3(90.17,224.79) v3(90.17,194.31) v3(90.17,163.83) v3(90.17,158.75) v3(90.17,133.35) v3(90.17,128.27) v3(91.18,122.76) v3(91.18,121.99) v3(91.18,121.23) v3(91.18,118.56) v3(91.18,117.8) v3(91.18,117.04) v3(91.18,114.37) v3(91.18,113.61) v3(91.18,112.85) v3(91.18,110.18) v3(91.18,109.42) v3(91.18,108.66) v3(91.95,320.6) v3(91.95,319.84) v3(91.95,319.08) v3(91.95,316.41) v3(91.95,315.65) v3(91.95,314.89) v3(91.95,312.22) v3(91.95,311.46) v3(91.95,310.7) v3(91.95,308.03) v3(91.95,307.27) v3(91.95,306.5) v3(92.71,298.45) v3(92.71,293.37) v3(92.71,288.29) v3(92.71,283.21) v3(92.71,278.13) v3(92.71,273.05) v3(92.71,267.97) v3(92.71,262.89) v3(92.71,257.81) v3(92.71,222.25) v3(92.71,191.77) v3(92.71,161.29) v3(92.71,130.81) v3(95.25,300.99) v3(95.25,295.91) v3(95.25,290.83) v3(95.25,285.75) v3(95.25,280.67) v3(95.25,275.59) v3(95.25,270.51) v3(95.25,265.43) v3(95.25,260.35) v3(95.25,255.27) v3(95.25,224.79) v3(95.25,158.75) v3(95.25,133.35) v3(95.25,128.27) v3(95.5,122.76) v3(95.5,121.99) v3(95.5,121.23) v3(95.5,118.56) v3(95.5,117.8) v3(95.5,117.04) v3(95.5,114.37) v3(95.5,113.61) v3(95.5,112.85) v3(95.5,110.18) v3(95.5,109.42) v3(95.5,108.66) v3(96.27,320.6) v3(96.27,319.84) v3(96.27,319.08) v3(96.27,316.41) v3(96.27,315.65) v3(96.27,314.89) v3(96.27,312.22) v3(96.27,311.46) v3(96.27,310.7) v3(96.27,308.03) v3(96.27,307.27) v3(96.27,306.5) v3(97.79,298.45) v3(97.79,293.37) v3(97.79,288.29) v3(97.79,283.21) v3(97.79,278.13) v3(97.79,273.05) v3(97.79,267.97) v3(97.79,262.89) v3(97.79,257.81) v3(97.79,130.81) v3(99.82,122.76) v3(99.82,121.99) v3(99.82,121.23) v3(99.82,118.56) v3(99.82,117.8) v3(99.82,117.04) v3(99.82,114.37) v3(99.82,113.61) v3(99.82,112.85) v3(99.82,110.18) v3(99.82,109.42) v3(99.82,108.66) v3(100.08,227.48) v3(100.08,195.73) v3(100.08,163.98) v3(100.08,132.23) v3(100.33,300.99) v3(100.33,295.91) v3(100.33,290.83) v3(100.33,285.75) v3(100.33,280.67) v3(100.33,275.59) v3(100.33,270.51) v3(100.59,320.6) v3(100.59,319.84) v3(100.59,319.08) v3(100.59,316.41) v3(100.59,315.65) v3(100.59,314.89) v3(100.59,312.22) v3(100.59,311.46) v3(100.59,310.7) v3(100.59,308.03) v3(100.59,307.27) v3(100.59,306.5) v3(101.74,226.85) v3(101.74,195.1) v3(101.74,163.35) v3(101.74,131.6) v3(102.87,298.45) v3(102.87,293.37) v3(102.87,288.29) v3(102.87,283.21) v3(102.87,278.13) v3(102.87,273.05) v3(102.87,267.97) v3(102.87,135.89) v3(104.14,122.76) v3(104.14,121.99) v3(104.14,121.23) v3(104.14,118.56) v3(104.14,117.8) v3(104.14,117.04) v3(104.14,114.37) v3(104.14,113.61) v3(104.14,112.85) v3(104.14,110.18) v3(104.14,109.42) v3(104.14,108.66) v3(104.91,320.6) v3(104.91,319.84) v3(104.91,319.08) v3(104.91,316.41) v3(104.91,315.65) v3(104.91,314.89) v3(104.91,312.22) v3(104.91,311.46) v3(104.91,310.7) v3(104.91,308.03) v3(104.91,307.27) v3(104.91,306.5) v3(105.41,300.99) v3(105.41,295.91) v3(105.41,290.83) v3(105.41,285.75) v3(105.41,280.67) v3(105.41,275.59) v3(105.41,270.51) v3(105.41,158.75) v3(105.41,138.43) v3(105.41,128.27) v3(106,241.24) v3(106,209.49) v3(106,177.74) v3(106,145.99) v3(106.53,237.74) v3(106.53,205.99) v3(106.53,174.24) v3(106.53,142.49) v3(107.7,226.33) v3(107.7,194.58) v3(107.7,162.83) v3(107.7,131.08) v3(107.95,298.45) v3(107.95,293.37) v3(107.95,288.29) v3(107.95,283.21) v3(107.95,278.13) v3(107.95,273.05) v3(107.95,267.97) v3(107.95,222.25) v3(108.45,122.76) v3(108.45,121.99) v3(108.45,121.23) v3(108.45,118.56) v3(108.45,117.8) v3(108.45,117.04) v3(108.45,114.37) v3(108.45,113.61) v3(108.45,112.85) v3(108.45,110.18) v3(108.45,109.42) v3(108.45,108.66) v3(109.1,225.8) v3(109.1,194.05) v3(109.1,162.3) v3(109.1,130.55) v3(109.22,320.6) v3(109.22,319.84) v3(109.22,319.08) v3(109.22,316.41) v3(109.22,315.65) v3(109.22,314.89) v3(109.22,312.22) v3(109.22,311.46) v3(109.22,310.7) v3(109.22,308.03) v3(109.22,307.27) v3(109.22,306.5) v3(109.49,300.99) v3(110.49,295.91) v3(110.49,290.83) v3(110.49,285.75) v3(110.49,280.67) v3(110.49,275.59) v3(110.49,270.51) v3(110.49,265.43) v3(110.49,260.35) v3(110.49,255.27) v3(110.49,158.75) v3(110.49,133.35) v3(110.49,128.27) v3(112.77,122.76) v3(112.77,121.99) v3(112.77,121.23) v3(112.77,118.56) v3(112.77,117.8) v3(112.77,117.04) v3(112.77,114.37) v3(112.77,113.61) v3(112.77,112.85) v3(112.77,110.18) v3(112.77,109.42) v3(112.77,108.66) v3(113.03,278.13) v3(113.03,222.25) v3(113.03,130.81) v3(113.54,320.6) v3(113.54,319.84) v3(113.54,319.08) v3(113.54,316.41) v3(113.54,315.65) v3(113.54,314.89) v3(113.54,312.22) v3(113.54,311.46) v3(113.54,310.7) v3(113.54,308.03) v3(113.54,307.27) v3(113.54,306.5) v3(114.29,280.67) v3(114.29,255.27) v3(115.43,280.67) v3(115.43,255.27) v3(115.57,300.99) v3(115.57,275.59) v3(115.57,158.75) v3(115.57,133.35) v3(115.57,128.27) v3(116.57,280.67) v3(116.57,255.27) v3(117.09,122.76) v3(117.09,121.99) v3(117.09,121.23) v3(117.09,118.56) v3(117.09,117.8) v3(117.09,117.04) v3(117.09,114.37) v3(117.09,113.61) v3(117.09,112.85) v3(117.09,110.18) v3(117.09,109.42) v3(117.09,108.66) v3(117.86,320.6) v3(117.86,319.84) v3(117.86,319.08) v3(117.86,316.41) v3(117.86,315.65) v3(117.86,314.89) v3(117.86,312.22) v3(117.86,311.46) v3(117.86,310.7) v3(117.86,308.03) v3(117.86,307.27) v3(117.86,306.5) v3(118.11,278.13) v3(118.11,222.25) v3(118.11,191.77) v3(118.11,161.29) v3(118.11,130.81) v3(120.65,300.99) v3(120.65,275.59) v3(120.65,224.79) v3(120.65,194.31) v3(120.65,163.83) v3(120.65,158.75) v3(120.65,133.35) v3(120.65,128.27) v3(121.41,122.76) v3(121.41,121.99) v3(121.41,121.23) v3(121.41,118.56) v3(121.41,117.8) v3(121.41,117.04) v3(121.41,114.37) v3(121.41,113.61) v3(121.41,112.85) v3(121.41,110.18) v3(121.41,109.42) v3(121.41,108.66) v3(122.18,320.6) v3(122.18,319.84) v3(122.18,319.08) v3(122.18,316.41) v3(122.18,315.65) v3(122.18,314.89) v3(122.18,312.22) v3(122.18,311.46) v3(122.18,310.7) v3(122.18,308.03) v3(122.18,307.27) v3(122.18,306.5) v3(123.19,278.13) v3(123.19,252.73) v3(123.19,247.65) v3(123.19,242.57) v3(123.19,227.33) v3(123.19,222.25) v3(123.19,207.01) v3(123.19,196.85) v3(123.19,191.77) v3(123.19,186.69) v3(123.19,176.53) v3(123.19,166.37) v3(123.19,161.29) v3(123.19,156.21) v3(123.19,151.13) v3(123.19,146.05) v3(123.19,135.89) v3(123.19,130.81) v3(125.73,300.99) v3(125.73,285.75) v3(125.73,280.67) v3(125.73,275.59) v3(125.73,270.51) v3(125.73,265.43) v3(125.73,255.27) v3(125.73,250.19) v3(125.73,245.11) v3(125.73,240.03) v3(125.73,234.95) v3(125.73,229.87) v3(125.73,224.79) v3(125.73,219.71) v3(125.73,214.63) v3(125.73,209.55) v3(125.73,204.47) v3(125.73,199.39) v3(125.73,194.31) v3(125.73,189.23) v3(125.73,184.15) v3(125.73,179.07) v3(125.73,173.99) v3(125.73,168.91) v3(125.73,163.83) v3(125.73,158.75) v3(125.73,153.67) v3(125.73,148.59) v3(125.73,143.51) v3(125.73,138.43) v3(125.73,133.35) v3(125.73,128.27) v3(125.73,122.76) v3(125.73,121.99) v3(125.73,121.23) v3(125.73,118.56) v3(125.73,117.8) v3(125.73,117.04) v3(125.73,114.37) v3(125.73,113.61) v3(125.73,112.85) v3(125.73,110.18) v3(125.73,109.42) v3(125.73,108.66) v3(126.5,320.6) v3(126.5,319.84) v3(126.5,319.08) v3(126.5,316.41) v3(126.5,315.65) v3(126.5,314.89) v3(126.5,312.22) v3(126.5,311.46) v3(126.5,310.7) v3(126.5,308.03) v3(126.5,307.27) v3(126.5,306.5) v3(127.27,130.81) v3(128.27,298.45) v3(128.27,293.37) v3(128.27,288.29) v3(128.27,283.21) v3(128.27,278.13) v3(128.27,273.05) v3(128.27,267.97) v3(128.27,262.89) v3(128.27,257.81) v3(128.27,252.73) v3(128.27,247.65) v3(128.27,242.57) v3(128.27,237.49) v3(128.27,232.41) v3(128.27,227.33) v3(128.27,222.25) v3(128.27,217.17) v3(128.27,212.09) v3(128.27,207.01) v3(128.27,201.93) v3(128.27,196.85) v3(128.27,191.77) v3(128.27,186.69) v3(128.27,181.61) v3(128.27,176.53) v3(128.27,171.45) v3(128.27,166.37) v3(128.27,161.29) v3(128.27,156.21) v3(128.27,151.13) v3(128.27,146.05) v3(128.27,140.97) v3(128.27,135.89) v3(130.04,122.76) v3(130.04,121.99) v3(130.04,121.23) v3(130.04,118.56) v3(130.04,117.8) v3(130.04,117.04) v3(130.04,114.37) v3(130.04,113.61) v3(130.04,112.85) v3(130.04,110.18) v3(130.04,109.42) v3(130.04,108.66) v3(130.81,320.6) v3(130.81,319.84) v3(130.81,319.08) v3(130.81,316.41) v3(130.81,315.65) v3(130.81,314.89) v3(130.81,312.22) v3(130.81,311.46) v3(130.81,310.7) v3(130.81,308.03) v3(130.81,307.27) v3(130.81,306.5) v3(130.81,300.99) v3(130.81,295.91) v3(130.81,290.83) v3(130.81,285.75) v3(130.81,280.67) v3(130.81,275.59) v3(130.81,270.51) v3(130.81,265.43) v3(130.81,260.35) v3(130.81,255.27) v3(130.81,250.19) v3(130.81,245.11) v3(130.81,240.03) v3(130.81,234.95) v3(130.81,229.87) v3(130.81,224.79) v3(130.81,219.71) v3(130.81,214.63) v3(130.81,209.55) v3(130.81,204.47) v3(130.81,199.39) v3(130.81,194.31) v3(130.81,189.23) v3(130.81,184.15) v3(130.81,179.07) v3(130.81,173.99) v3(130.81,168.91) v3(130.81,163.83) v3(130.81,158.75) v3(130.81,153.67) v3(130.81,148.59) v3(130.81,143.51) v3(130.81,138.43) v3(130.81,133.35) v3(130.81,128.27) v3(156.21,285.75) v3(156.21,283.21) v3(156.21,280.67) v3(156.21,278.13) v3(156.21,275.59) v3(156.21,273.05) v3(156.21,270.51) v3(156.21,267.97) v3(156.21,265.43) v3(156.21,262.89) v3(156.21,260.35) v3(156.21,257.81) v3(156.21,255.27) v3(156.21,252.73) v3(156.21,250.19) v3(156.21,247.65) v3(156.21,245.11) v3(156.21,237.49) v3(156.21,191.77) v3(156.21,184.15) v3(156.21,181.61) v3(156.21,179.07) v3(156.21,176.53) v3(156.21,173.99) v3(156.21,171.45) v3(156.21,168.91) v3(156.21,166.37) v3(156.21,163.83) v3(156.21,161.29) v3(156.21,158.75) v3(156.21,156.21) v3(156.21,153.67) v3(156.21,151.13) v3(156.21,148.59) v3(156.21,146.05) v3(156.21,143.51) v3(156.21,140.97) v3(156.21,138.43) v3(156.21,135.89) v3(156.21,122.76) v3(156.21,121.99) v3(156.21,121.23) v3(156.21,118.56) v3(156.21,117.8) v3(156.21,117.04) v3(156.21,114.37) v3(156.21,113.61) v3(156.21,112.85) v3(156.21,110.18) v3(156.21,109.42) v3(156.21,108.66) v3(156.98,320.6) v3(156.98,319.84) v3(156.98,319.08) v3(156.98,316.41) v3(156.98,315.65) v3(156.98,314.89) v3(156.98,312.22) v3(156.98,311.46) v3(156.98,310.7) v3(156.98,308.03) v3(156.98,307.27) v3(156.98,306.5) v3(157.98,288.29) v3(158.75,285.75) v3(158.75,283.21) v3(158.75,280.67) v3(158.75,278.13) v3(158.75,275.59) v3(158.75,273.05) v3(158.75,270.51) v3(158.75,267.97) v3(158.75,265.43) v3(158.75,262.89) v3(158.75,260.35) v3(158.75,257.81) v3(158.75,255.27) v3(158.75,252.73) v3(158.75,250.19) v3(158.75,247.65) v3(158.75,245.11) v3(158.75,237.49) v3(158.75,191.77) v3(158.75,184.15) v3(158.75,181.61) v3(158.75,179.07) v3(158.75,176.53) v3(158.75,173.99) v3(158.75,171.45) v3(158.75,168.91) v3(158.75,166.37) v3(158.75,163.83) v3(158.75,161.29) v3(158.75,158.75) v3(158.75,156.21) v3(158.75,153.67) v3(158.75,151.13) v3(158.75,148.59) v3(158.75,146.05) v3(158.75,143.51) v3(158.75,140.97) v3(158.75,138.43) v3(158.75,135.89) v3(160.52,122.76) v3(160.52,121.99) v3(160.52,121.23) v3(160.52,118.56) v3(160.52,117.8) v3(160.52,117.04) v3(160.52,114.37) v3(160.52,113.61) v3(160.52,112.85) v3(160.52,110.18) v3(160.52,109.42) v3(160.52,108.66) v3(161.29,320.6) v3(161.29,319.84) v3(161.29,319.08) v3(161.29,316.41) v3(161.29,315.65) v3(161.29,314.89) v3(161.29,312.22) v3(161.29,311.46) v3(161.29,310.7) v3(161.29,308.03) v3(161.29,307.27) v3(161.29,306.5) v3(161.29,298.45) v3(161.29,295.91) v3(161.29,293.37) v3(161.29,290.83) v3(161.29,288.29) v3(161.29,285.75) v3(161.29,283.21) v3(161.29,280.67) v3(161.29,278.13) v3(161.29,275.59) v3(161.29,273.05) v3(161.29,270.51) v3(161.29,267.97) v3(161.29,265.43) v3(161.29,262.89) v3(161.29,260.35) v3(161.29,257.81) v3(161.29,255.27) v3(161.29,252.73) v3(161.29,250.19) v3(161.29,247.65) v3(161.29,245.11) v3(161.29,237.49) v3(161.29,191.77) v3(161.29,184.15) v3(161.29,181.61) v3(161.29,179.07) v3(161.29,176.53) v3(161.29,173.99) v3(161.29,171.45) v3(161.29,168.91) v3(161.29,166.37) v3(161.29,163.83) v3(161.29,161.29) v3(161.29,158.75) v3(161.29,156.21) v3(161.29,153.67) v3(161.29,151.13) v3(161.29,148.59) v3(161.29,146.05) v3(161.29,143.51) v3(161.29,140.97) v3(161.29,138.43) v3(161.29,135.89) v3(161.29,133.35) v3(161.29,130.81) v3(163.83,237.49) v3(163.83,234.95) v3(163.83,194.31) v3(163.83,191.77) v3(163.83,189.23) v3(163.83,186.69) v3(163.83,184.15) v3(163.83,181.61) v3(163.83,179.07) v3(163.83,176.53) v3(163.83,173.99) v3(163.83,171.45) v3(163.83,168.91) v3(163.83,166.37) v3(163.83,163.83) v3(163.83,161.29) v3(163.83,158.75) v3(163.83,156.21) v3(163.83,153.67) v3(163.83,151.13) v3(163.83,148.59) v3(163.83,146.05) v3(163.83,143.51) v3(163.83,140.97) v3(163.83,138.43) v3(163.83,135.89) v3(164.84,122.76) v3(164.84,121.99) v3(164.84,121.23) v3(164.84,118.56) v3(164.84,117.8) v3(164.84,117.04) v3(164.84,114.37) v3(164.84,113.61) v3(164.84,112.85) v3(164.84,110.18) v3(164.84,109.42) v3(164.84,108.66) v3(165.61,320.6) v3(165.61,319.84) v3(165.61,319.08) v3(165.61,316.41) v3(165.61,315.65) v3(165.61,314.89) v3(165.61,312.22) v3(165.61,311.46) v3(165.61,310.7) v3(165.61,308.03) v3(165.61,307.27) v3(165.61,306.5) v3(166.37,237.49) v3(166.37,234.95) v3(166.37,232.41) v3(166.37,229.87) v3(166.37,227.33) v3(166.37,224.79) v3(166.37,222.25) v3(166.37,219.71) v3(166.37,217.17) v3(166.37,214.63) v3(166.37,212.09) v3(166.37,209.55) v3(166.37,207.01) v3(166.37,204.47) v3(166.37,201.93) v3(166.37,199.39) v3(166.37,196.85) v3(166.37,194.31) v3(166.37,191.77) v3(166.37,189.23) v3(166.37,186.69) v3(166.37,184.15) v3(166.37,181.61) v3(166.37,179.07) v3(166.37,176.53) v3(166.37,173.99) v3(166.37,171.45) v3(166.37,168.91) v3(166.37,166.37) v3(166.37,163.83) v3(166.37,161.29) v3(166.37,158.75) v3(166.37,156.21) v3(166.37,153.67) v3(166.37,151.13) v3(166.37,148.59) v3(166.37,146.05) v3(166.37,143.51) v3(166.37,140.97) v3(166.37,138.43) v3(166.37,135.89) v3(168.91,237.49) v3(168.91,234.95) v3(168.91,232.41) v3(168.91,229.87) v3(168.91,227.33) v3(168.91,224.79) v3(168.91,222.25) v3(168.91,219.71) v3(168.91,217.17) v3(168.91,214.63) v3(168.91,212.09) v3(168.91,209.55) v3(168.91,207.01) v3(168.91,204.47) v3(168.91,201.93) v3(168.91,199.39) v3(168.91,196.85) v3(168.91,194.31) v3(168.91,191.77) v3(168.91,189.23) v3(168.91,186.69) v3(168.91,184.15) v3(168.91,181.61) v3(168.91,179.07) v3(168.91,176.53) v3(168.91,173.99) v3(168.91,171.45) v3(168.91,168.91) v3(168.91,166.37) v3(168.91,163.83) v3(168.91,161.29) v3(168.91,158.75) v3(168.91,156.21) v3(168.91,153.67) v3(168.91,151.13) v3(168.91,148.59) v3(168.91,146.05) v3(168.91,143.51) v3(168.91,140.97) v3(168.91,138.43) v3(168.91,135.89) v3(168.91,133.35) v3(169.16,122.76) v3(169.16,121.99) v3(169.16,121.23) v3(169.16,118.56) v3(169.16,117.8) v3(169.16,117.04) v3(169.16,114.37) v3(169.16,113.61) v3(169.16,112.85) v3(169.16,110.18) v3(169.16,109.42) v3(169.16,108.66) v3(169.68,130.81) v3(169.93,320.6) v3(169.93,319.84) v3(169.93,319.08) v3(169.93,316.41) v3(169.93,315.65) v3(169.93,314.89) v3(169.93,312.22) v3(169.93,311.46) v3(169.93,310.7) v3(169.93,308.03) v3(169.93,307.27) v3(169.93,306.5) v3(171.45,237.49) v3(171.45,234.95) v3(171.45,232.41) v3(171.45,229.87) v3(171.45,227.33) v3(171.45,224.79) v3(171.45,222.25) v3(171.45,219.71) v3(171.45,217.17) v3(171.45,214.63) v3(171.45,212.09) v3(171.45,209.55) v3(171.45,207.01) v3(171.45,204.47) v3(171.45,201.93) v3(171.45,199.39) v3(171.45,196.85) v3(171.45,194.31) v3(171.45,191.77) v3(171.45,189.23) v3(171.45,186.69) v3(171.45,184.15) v3(171.45,181.61) v3(171.45,179.07) v3(171.45,176.53) v3(171.45,173.99) v3(171.45,171.45) v3(171.45,168.91) v3(171.45,166.37) v3(171.45,163.83) v3(171.45,161.29) v3(171.45,158.75) v3(171.45,156.21) v3(171.45,153.67) v3(171.45,151.13) v3(171.45,148.59) v3(171.45,146.05) v3(171.45,143.51) v3(171.45,140.97) v3(171.45,138.43) v3(171.45,135.89) v3(171.45,133.35) v3(173.48,122.76) v3(173.48,121.99) v3(173.48,121.23) v3(173.48,118.56) v3(173.48,117.8) v3(173.48,117.04) v3(173.48,114.37) v3(173.48,113.61) v3(173.48,112.85) v3(173.48,110.18) v3(173.48,109.42) v3(173.48,108.66) v3(173.99,237.49) v3(173.99,234.95) v3(173.99,232.41) v3(173.99,229.87) v3(173.99,227.33) v3(173.99,224.79) v3(173.99,222.25) v3(173.99,219.71) v3(173.99,217.17) v3(173.99,214.63) v3(173.99,212.09) v3(173.99,209.55) v3(173.99,207.01) v3(173.99,204.47) v3(173.99,201.93) v3(173.99,199.39) v3(173.99,196.85) v3(173.99,194.31) v3(173.99,191.77) v3(173.99,189.23) v3(173.99,186.69) v3(173.99,184.15) v3(173.99,181.61) v3(173.99,179.07) v3(173.99,176.53) v3(173.99,173.99) v3(173.99,171.45) v3(173.99,168.91) v3(173.99,166.37) v3(173.99,163.83) v3(173.99,161.29) v3(173.99,158.75) v3(173.99,156.21) v3(173.99,153.67) v3(173.99,151.13) v3(173.99,148.59) v3(173.99,146.05) v3(173.99,143.51) v3(173.99,140.97) v3(173.99,138.43) v3(173.99,135.89) v3(173.99,133.35) v3(173.99,130.81) v3(174.25,320.6) v3(174.25,319.84) v3(174.25,319.08) v3(174.25,316.41) v3(174.25,315.65) v3(174.25,314.89) v3(174.25,312.22) v3(174.25,311.46) v3(174.25,310.7) v3(174.25,308.03) v3(174.25,307.27) v3(174.25,306.5) v3(176.53,237.49) v3(176.53,234.95) v3(176.53,232.41) v3(176.53,229.87) v3(176.53,227.33) v3(176.53,224.79) v3(176.53,222.25) v3(176.53,219.71) v3(176.53,217.17) v3(176.53,214.63) v3(176.53,212.09) v3(176.53,209.55) v3(176.53,207.01) v3(176.53,204.47) v3(176.53,201.93) v3(176.53,199.39) v3(176.53,196.85) v3(176.53,194.31) v3(176.53,191.77) v3(176.53,189.23) v3(176.53,186.69) v3(176.53,184.15) v3(176.53,181.61) v3(176.53,179.07) v3(176.53,176.53) v3(176.53,173.99) v3(176.53,171.45) v3(176.53,168.91) v3(176.53,166.37) v3(176.53,163.83) v3(176.53,161.29) v3(176.53,158.75) v3(176.53,156.21) v3(176.53,153.67) v3(176.53,151.13) v3(176.53,148.59) v3(176.53,146.05) v3(176.53,143.51) v3(176.53,140.97) v3(176.53,138.43) v3(176.53,135.89) v3(176.53,133.35) v3(176.53,130.81) v3(177.8,122.76) v3(177.8,121.99) v3(177.8,121.23) v3(177.8,118.56) v3(177.8,117.8) v3(177.8,117.04) v3(177.8,114.37) v3(177.8,113.61) v3(177.8,112.85) v3(177.8,110.18) v3(177.8,109.42) v3(177.8,108.66) v3(178.57,320.6) v3(178.57,319.84) v3(178.57,319.08) v3(178.57,316.41) v3(178.57,315.65) v3(178.57,314.89) v3(178.57,312.22) v3(178.57,311.46) v3(178.57,310.7) v3(178.57,308.03) v3(178.57,307.27) v3(178.57,306.5) v3(179.07,237.49) v3(179.07,234.95) v3(179.07,232.41) v3(179.07,229.87) v3(179.07,227.33) v3(179.07,224.79) v3(179.07,222.25) v3(179.07,219.71) v3(179.07,217.17) v3(179.07,214.63) v3(179.07,212.09) v3(179.07,209.55) v3(179.07,207.01) v3(179.07,204.47) v3(179.07,201.93) v3(179.07,199.39) v3(179.07,196.85) v3(179.07,194.31) v3(179.07,191.77) v3(179.07,189.23) v3(179.07,186.69) v3(179.07,184.15) v3(179.07,181.61) v3(179.07,179.07) v3(179.07,176.53) v3(179.07,173.99) v3(179.07,171.45) v3(179.07,168.91) v3(179.07,166.37) v3(179.07,163.83) v3(179.07,161.29) v3(179.07,158.75) v3(179.07,156.21) v3(179.07,153.67) v3(179.07,151.13) v3(179.07,148.59) v3(179.07,146.05) v3(179.07,143.51) v3(179.07,140.97) v3(179.07,138.43) v3(179.07,135.89) v3(179.07,133.35) v3(179.07,130.81) v3(181.61,237.49) v3(181.61,234.95) v3(181.61,232.41) v3(181.61,229.87) v3(181.61,227.33) v3(181.61,224.79) v3(181.61,222.25) v3(181.61,219.71) v3(181.61,217.17) v3(181.61,214.63) v3(181.61,212.09) v3(181.61,209.55) v3(181.61,207.01) v3(181.61,204.47) v3(181.61,201.93) v3(181.61,199.39) v3(181.61,196.85) v3(181.61,194.31) v3(181.61,191.77) v3(181.61,189.23) v3(181.61,186.69) v3(181.61,184.15) v3(181.61,181.61) v3(181.61,179.07) v3(181.61,176.53) v3(181.61,173.99) v3(181.61,171.45) v3(181.61,168.91) v3(181.61,166.37) v3(181.61,163.83) v3(181.61,161.29) v3(181.61,158.75) v3(181.61,156.21) v3(181.61,153.67) v3(181.61,151.13) v3(181.61,148.59) v3(181.61,146.05) v3(181.61,143.51) v3(181.61,140.97) v3(181.61,138.43) v3(181.61,135.89) v3(181.61,133.35) v3(181.61,130.81) v3(182.11,122.76) v3(182.11,121.99) v3(182.11,121.23) v3(182.11,118.56) v3(182.11,117.8) v3(182.11,117.04) v3(182.11,114.37) v3(182.11,113.61) v3(182.11,112.85) v3(182.11,110.18) v3(182.11,109.42) v3(182.11,108.66) v3(182.88,320.6) v3(182.88,319.84) v3(182.88,319.08) v3(182.88,316.41) v3(182.88,315.65) v3(182.88,314.89) v3(182.88,312.22) v3(182.88,311.46) v3(182.88,310.7) v3(182.88,308.03) v3(182.88,307.27) v3(182.88,306.5) v3(184.15,237.49) v3(184.15,224.79) v3(184.15,222.25) v3(184.15,219.71) v3(184.15,217.17) v3(184.15,214.63) v3(184.15,212.09) v3(184.15,209.55) v3(184.15,207.01) v3(184.15,204.47) v3(184.15,201.93) v3(184.15,199.39) v3(184.15,196.85) v3(184.15,194.31) v3(184.15,191.77) v3(184.15,189.23) v3(184.15,186.69) v3(184.15,184.15) v3(184.15,181.61) v3(184.15,179.07) v3(184.15,176.53) v3(184.15,173.99) v3(184.15,171.45) v3(184.15,168.91) v3(184.15,166.37) v3(184.15,163.83) v3(184.15,161.29) v3(184.15,158.75) v3(184.15,156.21) v3(184.15,153.67) v3(184.15,151.13) v3(184.15,148.59) v3(184.15,146.05) v3(184.15,143.51) v3(184.15,140.97) v3(184.15,138.43) v3(184.15,135.89) v3(184.15,133.35) v3(184.15,130.81) v3(186.43,122.76) v3(186.43,121.99) v3(186.43,121.23) v3(186.43,118.56) v3(186.43,117.8) v3(186.43,117.04) v3(186.43,114.37) v3(186.43,113.61) v3(186.43,112.85) v3(186.43,110.18) v3(186.43,109.42) v3(186.43,108.66) v3(186.69,237.49) v3(186.69,224.79) v3(186.69,222.25) v3(186.69,219.71) v3(186.69,217.17) v3(186.69,214.63) v3(186.69,212.09) v3(186.69,209.55) v3(186.69,207.01) v3(186.69,204.47) v3(186.69,201.93) v3(186.69,199.39) v3(186.69,196.85) v3(186.69,194.31) v3(186.69,191.77) v3(186.69,189.23) v3(186.69,186.69) v3(186.69,184.15) v3(186.69,181.61) v3(186.69,179.07) v3(186.69,176.53) v3(186.69,173.99) v3(186.69,171.45) v3(186.69,168.91) v3(186.69,166.37) v3(186.69,163.83) v3(186.69,161.29) v3(186.69,158.75) v3(186.69,156.21) v3(186.69,153.67) v3(186.69,151.13) v3(186.69,148.59) v3(186.69,146.05) v3(186.69,143.51) v3(186.69,140.97) v3(186.69,138.43) v3(186.69,135.89) v3(186.69,133.35) v3(186.69,130.81) v3(187.2,320.6) v3(187.2,319.84) v3(187.2,319.08) v3(187.2,316.41) v3(187.2,315.65) v3(187.2,314.89) v3(187.2,312.22) v3(187.2,311.46) v3(187.2,310.7) v3(187.2,308.03) v3(187.2,307.27) v3(187.2,306.5) v3(189.23,237.49) v3(189.23,224.79) v3(189.23,222.25) v3(189.23,219.71) v3(189.23,217.17) v3(189.23,214.63) v3(189.23,212.09) v3(189.23,209.55) v3(189.23,207.01) v3(189.23,204.47) v3(189.23,201.93) v3(189.23,199.39) v3(189.23,196.85) v3(189.23,194.31) v3(189.23,191.77) v3(189.23,189.23) v3(189.23,186.69) v3(189.23,184.15) v3(189.23,181.61) v3(189.23,179.07) v3(189.23,176.53) v3(189.23,173.99) v3(189.23,171.45) v3(189.23,168.91) v3(189.23,166.37) v3(189.23,163.83) v3(189.23,161.29) v3(189.23,158.75) v3(189.23,156.21) v3(189.23,153.67) v3(189.23,151.13) v3(189.23,148.59) v3(189.23,146.05) v3(189.23,143.51) v3(189.23,140.97) v3(189.23,138.43) v3(189.23,135.89) v3(189.23,133.35) v3(189.23,130.81) v3(190.75,122.76) v3(190.75,121.99) v3(190.75,121.23) v3(190.75,118.56) v3(190.75,117.8) v3(190.75,117.04) v3(190.75,114.37) v3(190.75,113.61) v3(190.75,112.85) v3(190.75,110.18) v3(190.75,109.42) v3(190.75,108.66) v3(191.52,320.6) v3(191.52,319.84) v3(191.52,319.08) v3(191.52,316.41) v3(191.52,315.65) v3(191.52,314.89) v3(191.52,312.22) v3(191.52,311.46) v3(191.52,310.7) v3(191.52,308.03) v3(191.52,307.27) v3(191.52,306.5) v3(191.77,237.49) v3(191.77,224.79) v3(191.77,222.25) v3(191.77,219.71) v3(191.77,217.17) v3(191.77,214.63) v3(191.77,212.09) v3(191.77,209.55) v3(191.77,207.01) v3(191.77,204.47) v3(191.77,201.93) v3(191.77,199.39) v3(191.77,196.85) v3(191.77,194.31) v3(191.77,191.77) v3(191.77,189.23) v3(191.77,186.69) v3(191.77,184.15) v3(191.77,181.61) v3(191.77,179.07) v3(191.77,176.53) v3(191.77,173.99) v3(191.77,171.45) v3(191.77,168.91) v3(191.77,166.37) v3(191.77,163.83) v3(191.77,161.29) v3(191.77,158.75) v3(191.77,156.21) v3(191.77,153.67) v3(191.77,151.13) v3(191.77,148.59) v3(191.77,146.05) v3(191.77,143.51) v3(191.77,140.97) v3(191.77,138.43) v3(191.77,135.89) v3(191.77,133.35) v3(191.77,130.81) v3(194.31,237.49) v3(194.31,224.79) v3(194.31,222.25) v3(194.31,219.71) v3(194.31,217.17) v3(194.31,214.63) v3(194.31,212.09) v3(194.31,209.55) v3(194.31,207.01) v3(194.31,204.47) v3(194.31,201.93) v3(194.31,199.39) v3(194.31,196.85) v3(194.31,194.31) v3(194.31,191.77) v3(194.31,189.23) v3(194.31,186.69) v3(194.31,184.15) v3(194.31,181.61) v3(194.31,179.07) v3(194.31,176.53) v3(194.31,173.99) v3(194.31,171.45) v3(194.31,168.91) v3(194.31,166.37) v3(194.31,163.83) v3(194.31,161.29) v3(194.31,158.75) v3(194.31,156.21) v3(194.31,153.67) v3(194.31,151.13) v3(194.31,148.59) v3(194.31,146.05) v3(194.31,143.51) v3(194.31,140.97) v3(194.31,138.43) v3(194.31,135.89) v3(194.31,133.35) v3(194.31,130.81) v3(195.07,122.76) v3(195.07,121.99) v3(195.07,121.23) v3(195.07,118.56) v3(195.07,117.8) v3(195.07,117.04) v3(195.07,114.37) v3(195.07,113.61) v3(195.07,112.85) v3(195.07,110.18) v3(195.07,109.42) v3(195.07,108.66) v3(195.84,320.6) v3(195.84,319.84) v3(195.84,319.08) v3(195.84,316.41) v3(195.84,315.65) v3(195.84,314.89) v3(195.84,312.22) v3(195.84,311.46) v3(195.84,310.7) v3(195.84,308.03) v3(195.84,307.27) v3(195.84,306.5) v3(196.85,237.49) v3(196.85,234.95) v3(196.85,224.79) v3(196.85,222.25) v3(196.85,219.71) v3(196.85,217.17) v3(196.85,214.63) v3(196.85,212.09) v3(196.85,209.55) v3(196.85,207.01) v3(196.85,204.47) v3(196.85,201.93) v3(196.85,199.39) v3(196.85,196.85) v3(196.85,194.31) v3(196.85,191.77) v3(196.85,189.23) v3(196.85,186.69) v3(196.85,184.15) v3(196.85,181.61) v3(196.85,179.07) v3(196.85,176.53) v3(196.85,173.99) v3(196.85,171.45) v3(196.85,168.91) v3(196.85,166.37) v3(196.85,163.83) v3(196.85,161.29) v3(196.85,158.75) v3(196.85,156.21) v3(196.85,153.67) v3(196.85,151.13) v3(196.85,148.59) v3(196.85,146.05) v3(196.85,143.51) v3(196.85,140.97) v3(196.85,138.43) v3(196.85,135.89) v3(196.85,133.35) v3(196.85,130.81) v3(199.39,237.49) v3(199.39,234.95) v3(199.39,224.79) v3(199.39,222.25) v3(199.39,219.71) v3(199.39,217.17) v3(199.39,214.63) v3(199.39,212.09) v3(199.39,209.55) v3(199.39,207.01) v3(199.39,204.47) v3(199.39,201.93) v3(199.39,199.39) v3(199.39,196.85) v3(199.39,194.31) v3(199.39,191.77) v3(199.39,189.23) v3(199.39,186.69) v3(199.39,184.15) v3(199.39,181.61) v3(199.39,179.07) v3(199.39,176.53) v3(199.39,173.99) v3(199.39,171.45) v3(199.39,168.91) v3(199.39,166.37) v3(199.39,163.83) v3(199.39,161.29) v3(199.39,158.75) v3(199.39,156.21) v3(199.39,153.67) v3(199.39,151.13) v3(199.39,148.59) v3(199.39,146.05) v3(199.39,143.51) v3(199.39,140.97) v3(199.39,138.43) v3(199.39,135.89) v3(199.39,133.35) v3(199.39,130.81) v3(199.39,122.76) v3(199.39,121.99) v3(199.39,121.23) v3(199.39,118.56) v3(199.39,117.8) v3(199.39,117.04) v3(199.39,114.37) v3(199.39,113.61) v3(199.39,112.85) v3(199.39,110.18) v3(199.39,109.42) v3(199.39,108.66) v3(200.16,320.6) v3(200.16,319.84) v3(200.16,319.08) v3(200.16,316.41) v3(200.16,315.65) v3(200.16,314.89) v3(200.16,312.22) v3(200.16,311.46) v3(200.16,310.7) v3(200.16,308.03) v3(200.16,307.27) v3(200.16,306.5) v3(201.93,270.51) v3(201.93,267.97) v3(201.93,265.43) v3(201.93,262.89) v3(201.93,260.35) v3(201.93,257.81) v3(201.93,255.27) v3(201.93,252.73) v3(201.93,250.19) v3(201.93,247.65) v3(201.93,245.11) v3(201.93,242.57) v3(201.93,240.03) v3(201.93,237.49) v3(201.93,234.95) v3(201.93,224.79) v3(201.93,222.25) v3(201.93,219.71) v3(201.93,217.17) v3(201.93,214.63) v3(201.93,212.09) v3(201.93,209.55) v3(201.93,207.01) v3(201.93,204.47) v3(201.93,201.93) v3(201.93,199.39) v3(201.93,196.85) v3(201.93,194.31) v3(201.93,191.77) v3(201.93,189.23) v3(201.93,186.69) v3(201.93,184.15) v3(201.93,181.61) v3(201.93,179.07) v3(201.93,176.53) v3(201.93,173.99) v3(201.93,171.45) v3(201.93,168.91) v3(201.93,166.37) v3(201.93,163.83) v3(201.93,161.29) v3(201.93,158.75) v3(201.93,156.21) v3(201.93,153.67) v3(201.93,151.13) v3(201.93,148.59) v3(201.93,146.05) v3(201.93,143.51) v3(201.93,140.97) v3(201.93,138.43) v3(201.93,135.89) v3(201.93,133.35) v3(201.93,130.81) v3(203.7,122.76) v3(203.7,121.99) v3(203.7,121.23) v3(203.7,118.56) v3(203.7,117.8) v3(203.7,117.04) v3(203.7,114.37) v3(203.7,113.61) v3(203.7,112.85) v3(203.7,110.18) v3(203.7,109.42) v3(203.7,108.66) v3(204.47,320.6) v3(204.47,319.84) v3(204.47,319.08) v3(204.47,316.41) v3(204.47,315.65) v3(204.47,314.89) v3(204.47,312.22) v3(204.47,311.46) v3(204.47,310.7) v3(204.47,308.03) v3(204.47,307.27) v3(204.47,306.5) v3(204.47,270.51) v3(204.47,267.97) v3(204.47,265.43) v3(204.47,262.89) v3(204.47,260.35) v3(204.47,257.81) v3(204.47,255.27) v3(204.47,252.73) v3(204.47,250.19) v3(204.47,247.65) v3(204.47,245.11) v3(204.47,242.57) v3(204.47,234.95) v3(204.47,224.79) v3(204.47,222.25) v3(204.47,219.71) v3(204.47,217.17) v3(204.47,214.63) v3(204.47,212.09) v3(204.47,209.55) v3(204.47,207.01) v3(204.47,204.47) v3(204.47,201.93) v3(204.47,199.39) v3(204.47,196.85) v3(204.47,194.31) v3(204.47,191.77) v3(204.47,189.23) v3(204.47,186.69) v3(204.47,184.15) v3(204.47,181.61) v3(204.47,179.07) v3(204.47,176.53) v3(204.47,173.99) v3(204.47,171.45) v3(204.47,168.91) v3(204.47,166.37) v3(204.47,163.83) v3(204.47,161.29) v3(204.47,158.75) v3(204.47,156.21) v3(204.47,153.67) v3(204.47,151.13) v3(204.47,148.59) v3(204.47,146.05) v3(204.47,143.51) v3(204.47,140.97) v3(204.47,138.43) v3(204.47,135.89) v3(204.47,133.35) v3(204.47,130.81) v3(207.01,270.51) v3(207.01,267.97) v3(207.01,265.43) v3(207.01,262.89) v3(207.01,260.35) v3(207.01,257.81) v3(207.01,255.27) v3(207.01,252.73) v3(207.01,250.19) v3(207.01,247.65) v3(207.01,245.11) v3(207.01,242.57) v3(207.01,240.03) v3(207.01,234.95) v3(207.01,224.79) v3(207.01,222.25) v3(207.01,219.71) v3(207.01,217.17) v3(207.01,214.63) v3(207.01,212.09) v3(207.01,209.55) v3(207.01,207.01) v3(207.01,204.47) v3(207.01,201.93) v3(207.01,199.39) v3(207.01,196.85) v3(207.01,194.31) v3(207.01,191.77) v3(207.01,189.23) v3(207.01,186.69) v3(207.01,184.15) v3(207.01,181.61) v3(207.01,179.07) v3(207.01,176.53) v3(207.01,173.99) v3(207.01,171.45) v3(207.01,168.91) v3(207.01,166.37) v3(207.01,163.83) v3(207.01,161.29) v3(207.01,158.75) v3(207.01,156.21) v3(207.01,153.67) v3(207.01,151.13) v3(207.01,148.59) v3(207.01,146.05) v3(207.01,143.51) v3(207.01,140.97) v3(207.01,138.43) v3(207.01,135.89) v3(207.01,133.35) v3(207.01,130.81) v3(216.15,297.94) v3(217.96,281.69) v3(217.96,277.62) v3(219.51,286.56) v3(220.67,286.56) v3(222.85,134.72) v3(222.96,147.09) v3(223.02,157.07) v3(223.02,153.01) v3(223.85,295.57) v3(223.85,292.22) v3(224.05,277.62) v3(224.04,134.72) v3(224.12,147.09) v3(226.45,147.94) v3(227.84,157.07) v3(227.84,153.01) v3(228.17,138) v3(228.29,143.54) v3(228.29,142.35) v3(228.29,141.15) v3(228.29,139.96) v3(228.34,135.72) v3(228.34,134.7) v3(228.34,133.69) v3(229.87,121.99) v3(229.87,117.8) v3(229.87,113.61) v3(229.87,109.42) v3(230.14,277.62) v3(230.45,138.76) v3(230.64,319.84) v3(230.64,315.65) v3(230.64,312.22) v3(230.64,311.46) v3(230.64,310.7) v3(230.64,308.03) v3(230.64,307.27) v3(230.64,306.5) v3(231.21,290.5) v3(232.66,153.01) v3(233.32,295.57) v3(233.32,294.56) v3(233.32,293.54) v3(233.37,289.3) v3(233.37,288.11) v3(233.37,286.91) v3(233.37,285.72) v3(233.49,291.26) v3(234.18,121.99) v3(234.18,117.8) v3(234.18,113.61) v3(234.18,109.42) v3(234.95,319.84) v3(234.95,315.65) v3(234.95,311.46) v3(234.95,308.03) v3(234.95,307.27) v3(234.95,306.5) v3(235.21,281.32) v3(236.47,277.62) v3(237.54,282.17) v3(237.62,294.54) v3(237.81,137.04) v3(237.81,133.69) v3(238.5,122.76) v3(238.5,121.99) v3(238.5,121.23) v3(238.5,118.56) v3(238.5,117.8) v3(238.5,117.04) v3(238.5,113.61) v3(238.5,109.42) v3(238.7,282.17) v3(238.81,294.54) v3(239.27,319.84) v3(239.27,315.65) v3(239.27,311.46) v3(239.27,307.27) v3(240.99,142.7) v3(242.15,142.7) v3(242.29,154.53) v3(242.29,149.86) v3(242.82,122.76) v3(242.82,121.99) v3(242.82,121.23) v3(242.82,118.56) v3(242.82,117.8) v3(242.82,117.04) v3(242.82,114.37) v3(242.82,113.61) v3(242.82,112.85) v3(242.82,110.18) v3(242.82,109.42) v3(242.82,108.66) v3(243.59,320.6) v3(243.59,319.84) v3(243.59,319.08) v3(243.59,316.41) v3(243.59,315.65) v3(243.59,314.89) v3(243.59,312.22) v3(243.59,311.46) v3(243.59,310.7) v3(243.59,307.27) v3(246.41,281.69) v3(246.41,277.62) v3(247.11,154.53) v3(247.14,122.76) v3(247.14,121.99) v3(247.14,121.23) v3(247.14,118.56) v3(247.14,117.8) v3(247.14,117.04) v3(247.14,114.37) v3(247.14,113.61) v3(247.14,112.85) v3(247.14,110.18) v3(247.14,109.42) v3(247.14,108.66) v3(247.91,320.6) v3(247.91,319.84) v3(247.91,319.08) v3(247.91,316.41) v3(247.91,315.65) v3(247.91,314.89) v3(247.91,312.22) v3(247.91,311.46) v3(247.91,310.7) v3(247.91,308.03) v3(247.91,307.27) v3(247.91,306.5) v3(251.46,122.76) v3(251.46,121.99) v3(251.46,121.23) v3(251.46,118.56) v3(251.46,117.8) v3(251.46,117.04) v3(251.46,114.37) v3(251.46,113.61) v3(251.46,112.85) v3(251.46,110.18) v3(251.46,109.42) v3(251.46,108.66) v3(252.23,320.6) v3(252.23,319.84) v3(252.23,319.08) v3(252.23,316.41) v3(252.23,315.65) v3(252.23,314.89) v3(252.23,312.22) v3(252.23,311.46) v3(252.23,310.7) v3(252.23,308.03) v3(252.23,307.27) v3(252.23,306.5) v3(255.77,121.99) v3(255.77,117.8) v3(255.77,114.37) v3(255.77,113.61) v3(255.77,112.85) v3(255.77,110.18) v3(255.77,109.42) v3(255.77,108.66) v3(256.54,320.6) v3(256.54,319.84) v3(256.54,319.08) v3(256.54,316.41) v3(256.54,315.65) v3(256.54,314.89) v3(256.54,312.22) v3(256.54,311.46) v3(256.54,310.7) v3(256.54,308.03) v3(256.54,307.27) v3(256.54,306.5) v3(257.96,281.69) v3(257.96,277.62) v3(259.51,286.56) v3(260.09,121.99) v3(260.09,117.8) v3(260.09,114.37) v3(260.09,113.61) v3(260.09,112.85) v3(260.09,110.18) v3(260.09,109.42) v3(260.09,108.66) v3(260.67,286.56) v3(260.86,320.6) v3(260.86,319.84) v3(260.86,319.08) v3(260.86,316.41) v3(260.86,315.65) v3(260.86,314.89) v3(260.86,312.22) v3(260.86,311.46) v3(260.86,310.7) v3(260.86,308.03) v3(260.86,307.27) v3(260.86,306.5) v3(262.85,134.72) v3(262.96,147.09) v3(263.02,157.07) v3(263.02,153.01) v3(263.85,295.57) v3(263.85,292.22) v3(264.05,277.62) v3(264.04,134.72) v3(264.12,147.09) v3(264.41,121.99) v3(264.41,117.8) v3(264.41,114.37) v3(264.41,113.61) v3(264.41,112.85) v3(264.41,110.18) v3(264.41,109.42) v3(264.41,108.66) v3(265.18,320.6) v3(265.18,319.84) v3(265.18,319.08) v3(265.18,316.41) v3(265.18,315.65) v3(265.18,314.89) v3(265.18,312.22) v3(265.18,311.46) v3(265.18,310.7) v3(265.18,308.03) v3(265.18,307.27) v3(265.18,306.5) v3(266.45,147.94) v3(267.84,157.07) v3(267.84,153.01) v3(268.17,138) v3(268.29,143.54) v3(268.29,142.35) v3(268.29,141.15) v3(268.29,139.96) v3(268.34,135.72) v3(268.34,134.7) v3(268.34,133.69) v3(268.73,121.99) v3(268.73,117.8) v3(268.73,114.37) v3(268.73,113.61) v3(268.73,112.85) v3(268.73,110.18) v3(268.73,109.42) v3(268.73,108.66) v3(269.5,319.84) v3(269.5,315.65) v3(269.5,311.46) v3(269.5,307.27) v3(270.14,277.62) v3(270.45,138.76) v3(271.21,290.5) v3(272.66,153.01) v3(273.05,121.99) v3(273.05,117.8) v3(273.05,114.37) v3(273.05,113.61) v3(273.05,112.85) v3(273.05,110.18) v3(273.05,109.42) v3(273.05,108.66) v3(273.32,295.57) v3(273.32,294.56) v3(273.32,293.54) v3(273.37,289.3) v3(273.37,288.11) v3(273.37,286.91) v3(273.37,285.72) v3(273.49,291.26) v3(273.82,319.84) v3(273.82,315.65) v3(273.82,311.46) v3(273.82,307.27) v3(275.21,281.32) v3(276.47,277.62) v3(277.36,121.99) v3(277.36,117.8) v3(277.36,114.37) v3(277.36,113.61) v3(277.36,112.85) v3(277.36,110.18) v3(277.36,109.42) v3(277.36,108.66) v3(277.54,282.17) v3(277.62,294.54) v3(277.81,137.04) v3(277.81,133.69) v3(278.13,319.84) v3(278.13,315.65) v3(278.13,311.46) v3(278.13,307.27) v3(278.7,282.17) v3(278.81,294.54) v3(280.99,142.7) v3(282.15,142.7) v3(282.29,154.53) v3(282.29,149.86) v3(286.41,281.69) v3(286.41,277.62) v3(287.11,154.53) v3(297.96,281.69) v3(297.96,277.62) v3(299.51,286.56) v3(300.67,286.56) v3(302.85,134.72) v3(302.96,147.09) v3(303.02,157.07) v3(303.02,153.01) v3(303.53,122.76) v3(303.53,121.99) v3(303.53,121.23) v3(303.53,117.8) v3(303.53,114.37) v3(303.53,113.61) v3(303.53,112.85) v3(303.53,110.18) v3(303.53,109.42) v3(303.53,108.66) v3(303.85,295.57) v3(303.85,292.22) v3(304.05,277.62) v3(304.04,134.72) v3(304.12,147.09) v3(304.3,320.6) v3(304.3,319.84) v3(304.3,319.08) v3(304.3,316.41) v3(304.3,315.65) v3(304.3,314.89) v3(304.3,312.22) v3(304.3,311.46) v3(304.3,310.7) v3(304.3,308.03) v3(304.3,307.27) v3(304.3,306.5) v3(306.45,147.94) v3(307.84,157.07) v3(307.84,153.01) v3(307.84,121.99) v3(307.84,117.8) v3(307.84,114.37) v3(307.84,113.61) v3(307.84,112.85) v3(307.84,110.18) v3(307.84,109.42) v3(307.84,108.66) v3(308.17,138) v3(308.29,143.54) v3(308.29,142.35) v3(308.29,141.15) v3(308.29,139.96) v3(308.34,135.72) v3(308.34,134.7) v3(308.34,133.69) v3(308.61,320.6) v3(308.61,319.84) v3(308.61,319.08) v3(308.61,316.41) v3(308.61,315.65) v3(308.61,314.89) v3(308.61,311.46) v3(308.61,307.27) v3(310.14,277.62) v3(310.45,138.76) v3(311.21,290.5) v3(312.16,121.99) v3(312.16,117.8) v3(312.16,114.37) v3(312.16,113.61) v3(312.16,112.85) v3(312.16,110.18) v3(312.16,109.42) v3(312.16,108.66) v3(312.66,153.01) v3(312.93,320.6) v3(312.93,319.84) v3(312.93,319.08) v3(312.93,316.41) v3(312.93,315.65) v3(312.93,314.89) v3(312.93,311.46) v3(312.93,307.27) v3(313.32,295.57) v3(313.32,294.56) v3(313.32,293.54) v3(313.37,289.3) v3(313.37,288.11) v3(313.37,286.91) v3(313.37,285.72) v3(313.49,291.26) v3(315.21,281.32) v3(316.47,277.62) v3(316.48,121.99) v3(316.48,117.8) v3(316.48,114.37) v3(316.48,113.61) v3(316.48,112.85) v3(316.48,110.18) v3(316.48,109.42) v3(316.48,108.66) v3(317.25,320.6) v3(317.25,319.84) v3(317.25,319.08) v3(317.25,316.41) v3(317.25,315.65) v3(317.25,314.89) v3(317.25,311.46) v3(317.25,307.27) v3(317.54,282.17) v3(317.62,294.54) v3(317.81,137.04) v3(317.81,133.69) v3(318.7,282.17) v3(318.81,294.54) v3(320.8,121.99) v3(320.8,117.8) v3(320.8,114.37) v3(320.8,113.61) v3(320.8,112.85) v3(320.8,110.18) v3(320.8,109.42) v3(320.8,108.66) v3(320.99,142.7) v3(321.57,320.6) v3(321.57,319.84) v3(321.57,319.08) v3(321.57,316.41) v3(321.57,315.65) v3(321.57,314.89) v3(321.57,311.46) v3(321.57,307.27) v3(322.15,142.7) v3(322.29,154.53) v3(322.29,149.86) v3(325.12,121.99) v3(325.12,117.8) v3(325.12,114.37) v3(325.12,113.61) v3(325.12,112.85) v3(325.12,110.18) v3(325.12,109.42) v3(325.12,108.66) v3(325.89,320.6) v3(325.89,319.84) v3(325.89,319.08) v3(325.89,316.41) v3(325.89,315.65) v3(325.89,314.89) v3(325.89,311.46) v3(325.89,307.27) v3(326.41,281.69) v3(326.41,277.62) v3(327.11,154.53) v3(329.43,121.99) v3(329.43,117.8) v3(329.43,114.37) v3(329.43,113.61) v3(329.43,112.85) v3(329.43,110.18) v3(329.43,109.42) v3(329.43,108.66) v3(330.2,320.6) v3(330.2,319.84) v3(330.2,319.08) v3(330.2,316.41) v3(330.2,315.65) v3(330.2,314.89) v3(330.2,311.46) v3(330.2,307.27) v3(333.75,122.76) v3(333.75,121.99) v3(333.75,121.23) v3(333.75,118.56) v3(333.75,117.8) v3(333.75,117.04) v3(333.75,114.37) v3(333.75,113.61) v3(333.75,112.85) v3(333.75,110.18) v3(333.75,109.42) v3(333.75,108.66) v3(334.52,320.6) v3(334.52,319.84) v3(334.52,319.08) v3(334.52,316.41) v3(334.52,315.65) v3(334.52,314.89) v3(334.52,312.22) v3(334.52,311.46) v3(334.52,310.7) v3(334.52,308.03) v3(334.52,307.27) v3(334.52,306.5) v3(337.96,281.69) v3(337.96,277.62) v3(338.07,121.99) v3(338.07,117.8) v3(338.07,113.61) v3(338.07,110.18) v3(338.07,109.42) v3(338.07,108.66) v3(338.84,320.6) v3(338.84,319.84) v3(338.84,319.08) v3(338.84,316.41) v3(338.84,315.65) v3(338.84,314.89) v3(338.84,312.22) v3(338.84,311.46) v3(338.84,310.7) v3(338.84,307.27) v3(339.51,286.56) v3(340.67,286.56) v3(342.39,121.99) v3(342.39,117.8) v3(342.39,113.61) v3(342.39,110.18) v3(342.39,109.42) v3(342.39,108.66) v3(342.85,134.72) v3(342.96,147.09) v3(343.02,157.07) v3(343.02,153.01) v3(343.16,319.84) v3(343.16,315.65) v3(343.16,311.46) v3(343.16,307.27) v3(343.85,295.57) v3(343.85,292.22) v3(344.05,277.62) v3(344.04,134.72) v3(344.12,147.09) v3(346.45,147.94) v3(346.71,121.99) v3(346.71,117.8) v3(346.71,113.61) v3(346.71,110.18) v3(346.71,109.42) v3(346.71,108.66) v3(347.48,319.84) v3(347.48,315.65) v3(347.48,311.46) v3(347.48,307.27) v3(347.84,157.07) v3(347.84,153.01) v3(348.17,138) v3(348.29,143.54) v3(348.29,142.35) v3(348.29,141.15) v3(348.29,139.96) v3(348.34,135.72) v3(348.34,134.7) v3(348.34,133.69) v3(350.14,277.62) v3(350.45,138.76) v3(351.02,121.99) v3(351.02,117.8) v3(351.02,113.61) v3(351.02,109.42) v3(351.02,108.66) v3(351.21,290.5) v3(351.79,319.84) v3(351.79,315.65) v3(351.79,311.46) v3(351.79,307.27) v3(352.66,153.01) v3(353.32,295.57) v3(353.32,294.56) v3(353.32,293.54) v3(353.37,289.3) v3(353.37,288.11) v3(353.37,286.91) v3(353.37,285.72) v3(353.49,291.26) v3(355.21,281.32) v3(356.47,277.62) v3(357.54,282.17) v3(357.62,294.54) v3(357.81,137.04) v3(357.81,133.69) v3(358.7,282.17) v3(358.81,294.54) v3(360.99,142.7) v3(362.15,142.7) v3(362.29,154.53) v3(362.29,149.86) v3(366.41,281.69) v3(366.41,277.62) v3(366.63,297.94) v3(367.11,154.53) v3(372.11,270.51) v3(372.11,267.97) v3(372.11,265.43) v3(372.11,262.89) v3(372.11,260.35) v3(372.11,257.81) v3(372.11,255.27) v3(372.11,252.73) v3(372.11,250.19) v3(372.11,247.65) v3(372.11,245.11) v3(372.11,242.57) v3(372.11,232.41) v3(372.11,229.87) v3(372.11,227.33) v3(372.11,224.79) v3(372.11,222.25) v3(372.11,219.71) v3(372.11,217.17) v3(372.11,214.63) v3(372.11,212.09) v3(372.11,209.55) v3(372.11,207.01) v3(372.11,204.47) v3(372.11,201.93) v3(372.11,199.39) v3(372.11,196.85) v3(372.11,194.31) v3(372.11,191.77) v3(372.11,189.23) v3(372.11,186.69) v3(372.11,184.15) v3(372.11,181.61) v3(372.11,179.07) v3(372.11,176.53) v3(372.11,173.99) v3(372.11,171.45) v3(372.11,168.91) v3(372.11,166.37) v3(372.11,163.83) v3(372.11,161.29) v3(372.11,158.75) v3(372.11,156.21) v3(372.11,153.67) v3(372.11,151.13) v3(372.11,148.59) v3(372.11,146.05) v3(372.11,143.51) v3(372.11,140.97) v3(372.11,138.43) v3(372.11,135.89) v3(372.11,133.35) v3(372.11,130.81) v3(374.65,270.51) v3(374.65,267.97) v3(374.65,265.43) v3(374.65,262.89) v3(374.65,260.35) v3(374.65,257.81) v3(374.65,255.27) v3(374.65,252.73) v3(374.65,250.19) v3(374.65,247.65) v3(374.65,245.11) v3(374.65,242.57) v3(374.65,224.79) v3(374.65,222.25) v3(374.65,219.71) v3(374.65,217.17) v3(374.65,214.63) v3(374.65,212.09) v3(374.65,209.55) v3(374.65,207.01) v3(374.65,204.47) v3(374.65,201.93) v3(374.65,199.39) v3(374.65,196.85) v3(374.65,194.31) v3(374.65,191.77) v3(374.65,189.23) v3(374.65,186.69) v3(374.65,184.15) v3(374.65,181.61) v3(374.65,179.07) v3(374.65,176.53) v3(374.65,173.99) v3(374.65,171.45) v3(374.65,168.91) v3(374.65,166.37) v3(374.65,163.83) v3(374.65,161.29) v3(374.65,158.75) v3(374.65,156.21) v3(374.65,153.67) v3(374.65,151.13) v3(374.65,148.59) v3(374.65,146.05) v3(374.65,143.51) v3(374.65,140.97) v3(374.65,138.43) v3(374.65,135.89) v3(374.65,133.35) v3(374.65,130.81) v3(377.19,270.51) v3(377.19,267.97) v3(377.19,265.43) v3(377.19,262.89) v3(377.19,260.35) v3(377.19,257.81) v3(377.19,255.27) v3(377.19,252.73) v3(377.19,250.19) v3(377.19,242.57) v3(377.19,224.79) v3(377.19,222.25) v3(377.19,219.71) v3(377.19,217.17) v3(377.19,214.63) v3(377.19,212.09) v3(377.19,209.55) v3(377.19,207.01) v3(377.19,204.47) v3(377.19,201.93) v3(377.19,199.39) v3(377.19,196.85) v3(377.19,194.31) v3(377.19,191.77) v3(377.19,189.23) v3(377.19,186.69) v3(377.19,184.15) v3(377.19,181.61) v3(377.19,179.07) v3(377.19,176.53) v3(377.19,173.99) v3(377.19,171.45) v3(377.19,168.91) v3(377.19,166.37) v3(377.19,163.83) v3(377.19,161.29) v3(377.19,158.75) v3(377.19,156.21) v3(377.19,153.67) v3(377.19,151.13) v3(377.19,148.59) v3(377.19,146.05) v3(377.19,143.51) v3(377.19,140.97) v3(377.19,138.43) v3(377.19,135.89) v3(377.19,133.35) v3(377.19,130.81) v3(377.19,122.76) v3(377.19,121.99) v3(377.19,121.23) v3(377.19,118.56) v3(377.19,117.8) v3(377.19,117.04) v3(377.19,114.37) v3(377.19,113.61) v3(377.19,112.85) v3(377.19,110.18) v3(377.19,109.42) v3(377.19,108.66) v3(377.96,320.6) v3(377.96,319.84) v3(377.96,319.08) v3(377.96,316.41) v3(377.96,315.65) v3(377.96,314.89) v3(377.96,312.22) v3(377.96,311.46) v3(377.96,310.7) v3(377.96,308.03) v3(377.96,307.27) v3(377.96,306.5) v3(379.73,270.51) v3(379.73,267.97) v3(379.73,265.43) v3(379.73,262.89) v3(379.73,260.35) v3(379.73,257.81) v3(379.73,255.27) v3(379.73,252.73) v3(379.73,250.19) v3(379.73,247.65) v3(379.73,242.57) v3(379.73,224.79) v3(379.73,222.25) v3(379.73,219.71) v3(379.73,217.17) v3(379.73,214.63) v3(379.73,212.09) v3(379.73,209.55) v3(379.73,207.01) v3(379.73,204.47) v3(379.73,201.93) v3(379.73,199.39) v3(379.73,196.85) v3(379.73,194.31) v3(379.73,191.77) v3(379.73,189.23) v3(379.73,186.69) v3(379.73,184.15) v3(379.73,181.61) v3(379.73,179.07) v3(379.73,176.53) v3(379.73,173.99) v3(379.73,171.45) v3(379.73,168.91) v3(379.73,166.37) v3(379.73,163.83) v3(379.73,161.29) v3(379.73,158.75) v3(379.73,156.21) v3(379.73,153.67) v3(379.73,151.13) v3(379.73,148.59) v3(379.73,146.05) v3(379.73,143.51) v3(379.73,140.97) v3(379.73,138.43) v3(379.73,135.89) v3(379.73,133.35) v3(379.73,130.81) v3(381.5,122.76) v3(381.5,121.99) v3(381.5,121.23) v3(381.5,118.56) v3(381.5,117.8) v3(381.5,117.04) v3(381.5,114.37) v3(381.5,113.61) v3(381.5,112.85) v3(381.5,110.18) v3(381.5,109.42) v3(381.5,108.66) v3(382.27,320.6) v3(382.27,319.84) v3(382.27,319.08) v3(382.27,316.41) v3(382.27,315.65) v3(382.27,314.89) v3(382.27,312.22) v3(382.27,311.46) v3(382.27,310.7) v3(382.27,308.03) v3(382.27,307.27) v3(382.27,306.5) v3(382.27,285.75) v3(382.27,283.21) v3(382.27,280.67) v3(382.27,278.13) v3(382.27,275.59) v3(382.27,273.05) v3(382.27,270.51) v3(382.27,267.97) v3(382.27,265.43) v3(382.27,262.89) v3(382.27,260.35) v3(382.27,257.81) v3(382.27,255.27) v3(382.27,252.73) v3(382.27,250.19) v3(382.27,247.65) v3(382.27,245.11) v3(382.27,242.57) v3(382.27,224.79) v3(382.27,222.25) v3(382.27,219.71) v3(382.27,217.17) v3(382.27,214.63) v3(382.27,212.09) v3(382.27,209.55) v3(382.27,207.01) v3(382.27,204.47) v3(382.27,201.93) v3(382.27,199.39) v3(382.27,196.85) v3(382.27,194.31) v3(382.27,191.77) v3(382.27,189.23) v3(382.27,186.69) v3(382.27,184.15) v3(382.27,181.61) v3(382.27,179.07) v3(382.27,176.53) v3(382.27,173.99) v3(382.27,171.45) v3(382.27,168.91) v3(382.27,166.37) v3(382.27,163.83) v3(382.27,161.29) v3(382.27,158.75) v3(382.27,156.21) v3(382.27,153.67) v3(382.27,151.13) v3(382.27,148.59) v3(382.27,146.05) v3(382.27,143.51) v3(382.27,140.97) v3(382.27,138.43) v3(382.27,135.89) v3(382.27,133.35) v3(382.27,130.81) v3(384.81,298.45) v3(384.81,295.91) v3(384.81,293.37) v3(384.81,290.83) v3(384.81,288.29) v3(384.81,285.75) v3(384.81,283.21) v3(384.81,280.67) v3(384.81,278.13) v3(384.81,275.59) v3(384.81,273.05) v3(384.81,270.51) v3(384.81,267.97) v3(384.81,265.43) v3(384.81,262.89) v3(384.81,260.35) v3(384.81,257.81) v3(384.81,255.27) v3(384.81,252.73) v3(384.81,250.19) v3(384.81,247.65) v3(384.81,245.11) v3(384.81,242.57) v3(384.81,224.79) v3(384.81,222.25) v3(384.81,219.71) v3(384.81,217.17) v3(384.81,214.63) v3(384.81,212.09) v3(384.81,209.55) v3(384.81,207.01) v3(384.81,204.47) v3(384.81,201.93) v3(384.81,199.39) v3(384.81,196.85) v3(384.81,194.31) v3(384.81,191.77) v3(384.81,189.23) v3(384.81,186.69) v3(384.81,184.15) v3(384.81,181.61) v3(384.81,179.07) v3(384.81,176.53) v3(384.81,173.99) v3(384.81,171.45) v3(384.81,168.91) v3(384.81,166.37) v3(384.81,163.83) v3(384.81,161.29) v3(384.81,158.75) v3(384.81,156.21) v3(384.81,153.67) v3(384.81,151.13) v3(384.81,148.59) v3(384.81,146.05) v3(384.81,143.51) v3(384.81,140.97) v3(384.81,138.43) v3(384.81,135.89) v3(384.81,133.35) v3(384.81,130.81) v3(385.82,122.76) v3(385.82,121.99) v3(385.82,121.23) v3(385.82,118.56) v3(385.82,117.8) v3(385.82,117.04) v3(385.82,114.37) v3(385.82,113.61) v3(385.82,112.85) v3(385.82,110.18) v3(385.82,109.42) v3(385.82,108.66) v3(386.59,320.6) v3(386.59,319.84) v3(386.59,319.08) v3(386.59,316.41) v3(386.59,315.65) v3(386.59,314.89) v3(386.59,312.22) v3(386.59,311.46) v3(386.59,310.7) v3(386.59,308.03) v3(386.59,307.27) v3(386.59,306.5) v3(387.35,298.45) v3(387.35,295.91) v3(387.35,293.37) v3(387.35,290.83) v3(387.35,288.29) v3(387.35,285.75) v3(387.35,283.21) v3(387.35,280.67) v3(387.35,278.13) v3(387.35,275.59) v3(387.35,273.05) v3(387.35,270.51) v3(387.35,267.97) v3(387.35,265.43) v3(387.35,262.89) v3(387.35,260.35) v3(387.35,257.81) v3(387.35,255.27) v3(387.35,252.73) v3(387.35,250.19) v3(387.35,247.65) v3(387.35,245.11) v3(387.35,242.57) v3(387.35,224.79) v3(387.35,222.25) v3(387.35,219.71) v3(387.35,217.17) v3(387.35,214.63) v3(387.35,212.09) v3(387.35,209.55) v3(387.35,207.01) v3(387.35,204.47) v3(387.35,201.93) v3(387.35,199.39) v3(387.35,196.85) v3(387.35,194.31) v3(387.35,191.77) v3(387.35,189.23) v3(387.35,186.69) v3(387.35,184.15) v3(387.35,181.61) v3(387.35,179.07) v3(387.35,176.53) v3(387.35,173.99) v3(387.35,171.45) v3(387.35,168.91) v3(387.35,166.37) v3(387.35,163.83) v3(387.35,161.29) v3(387.35,158.75) v3(387.35,156.21) v3(387.35,153.67) v3(387.35,151.13) v3(387.35,148.59) v3(387.35,146.05) v3(387.35,143.51) v3(387.35,140.97) v3(387.35,138.43) v3(387.35,135.89) v3(387.35,133.35) v3(387.35,130.81) v3(389.89,298.45) v3(389.89,295.91) v3(389.89,293.37) v3(389.89,290.83) v3(389.89,288.29) v3(389.89,285.75) v3(389.89,283.21) v3(389.89,280.67) v3(389.89,278.13) v3(389.89,275.59) v3(389.89,273.05) v3(389.89,270.51) v3(389.89,267.97) v3(389.89,265.43) v3(389.89,262.89) v3(389.89,260.35) v3(389.89,257.81) v3(389.89,255.27) v3(389.89,252.73) v3(389.89,250.19) v3(389.89,247.65) v3(389.89,245.11) v3(389.89,242.57) v3(389.89,222.25) v3(389.89,219.71) v3(389.89,217.17) v3(389.89,214.63) v3(389.89,212.09) v3(389.89,209.55) v3(389.89,207.01) v3(389.89,204.47) v3(389.89,201.93) v3(389.89,199.39) v3(389.89,196.85) v3(389.89,194.31) v3(389.89,191.77) v3(389.89,189.23) v3(389.89,186.69) v3(389.89,184.15) v3(389.89,181.61) v3(389.89,179.07) v3(389.89,176.53) v3(389.89,173.99) v3(389.89,171.45) v3(389.89,168.91) v3(389.89,166.37) v3(389.89,163.83) v3(389.89,161.29) v3(389.89,158.75) v3(389.89,156.21) v3(389.89,153.67) v3(389.89,151.13) v3(389.89,148.59) v3(389.89,146.05) v3(389.89,143.51) v3(389.89,140.97) v3(389.89,138.43) v3(389.89,135.89) v3(389.89,133.35) v3(389.89,130.81) v3(390.14,122.76) v3(390.14,121.99) v3(390.14,121.23) v3(390.14,118.56) v3(390.14,117.8) v3(390.14,117.04) v3(390.14,114.37) v3(390.14,113.61) v3(390.14,112.85) v3(390.14,110.18) v3(390.14,109.42) v3(390.14,108.66) v3(390.91,320.6) v3(390.91,319.84) v3(390.91,319.08) v3(390.91,316.41) v3(390.91,315.65) v3(390.91,314.89) v3(390.91,312.22) v3(390.91,311.46) v3(390.91,310.7) v3(390.91,308.03) v3(390.91,307.27) v3(390.91,306.5) v3(392.43,298.45) v3(392.43,295.91) v3(392.43,293.37) v3(392.43,290.83) v3(392.43,288.29) v3(392.43,285.75) v3(392.43,283.21) v3(392.43,280.67) v3(392.43,278.13) v3(392.43,275.59) v3(392.43,273.05) v3(392.43,270.51) v3(392.43,267.97) v3(392.43,265.43) v3(392.43,262.89) v3(392.43,260.35) v3(392.43,257.81) v3(392.43,255.27) v3(392.43,252.73) v3(392.43,250.19) v3(392.43,247.65) v3(392.43,245.11) v3(392.43,242.57) v3(392.43,222.25) v3(392.43,219.71) v3(392.43,217.17) v3(392.43,214.63) v3(392.43,212.09) v3(392.43,209.55) v3(392.43,207.01) v3(392.43,204.47) v3(392.43,201.93) v3(392.43,199.39) v3(392.43,196.85) v3(392.43,194.31) v3(392.43,191.77) v3(392.43,189.23) v3(392.43,186.69) v3(392.43,184.15) v3(392.43,181.61) v3(392.43,179.07) v3(392.43,176.53) v3(392.43,173.99) v3(392.43,171.45) v3(392.43,168.91) v3(392.43,166.37) v3(392.43,163.83) v3(392.43,161.29) v3(392.43,158.75) v3(392.43,156.21) v3(392.43,153.67) v3(392.43,151.13) v3(392.43,148.59) v3(392.43,146.05) v3(392.43,143.51) v3(392.43,140.97) v3(392.43,138.43) v3(392.43,135.89) v3(392.43,133.35) v3(392.43,130.81) v3(394.46,122.76) v3(394.46,121.99) v3(394.46,121.23) v3(394.46,118.56) v3(394.46,117.8) v3(394.46,117.04) v3(394.46,114.37) v3(394.46,113.61) v3(394.46,112.85) v3(394.46,110.18) v3(394.46,109.42) v3(394.46,108.66) v3(394.97,298.45) v3(394.97,295.91) v3(394.97,293.37) v3(394.97,290.83) v3(394.97,288.29) v3(394.97,285.75) v3(394.97,283.21) v3(394.97,280.67) v3(394.97,278.13) v3(394.97,275.59) v3(394.97,273.05) v3(394.97,270.51) v3(394.97,267.97) v3(394.97,265.43) v3(394.97,262.89) v3(394.97,260.35) v3(394.97,257.81) v3(394.97,255.27) v3(394.97,252.73) v3(394.97,250.19) v3(394.97,247.65) v3(394.97,245.11) v3(394.97,242.57) v3(394.97,222.25) v3(394.97,219.71) v3(394.97,217.17) v3(394.97,214.63) v3(394.97,212.09) v3(394.97,209.55) v3(394.97,207.01) v3(394.97,204.47) v3(394.97,201.93) v3(394.97,199.39) v3(394.97,196.85) v3(394.97,194.31) v3(394.97,191.77) v3(394.97,189.23) v3(394.97,186.69) v3(394.97,184.15) v3(394.97,181.61) v3(394.97,179.07) v3(394.97,176.53) v3(394.97,173.99) v3(394.97,171.45) v3(394.97,168.91) v3(394.97,166.37) v3(394.97,163.83) v3(394.97,161.29) v3(394.97,158.75) v3(394.97,156.21) v3(394.97,153.67) v3(394.97,151.13) v3(394.97,148.59) v3(394.97,146.05) v3(394.97,143.51) v3(394.97,140.97) v3(394.97,138.43) v3(394.97,135.89) v3(394.97,133.35) v3(394.97,130.81) v3(395.23,320.6) v3(395.23,319.84) v3(395.23,319.08) v3(395.23,316.41) v3(395.23,315.65) v3(395.23,314.89) v3(395.23,312.22) v3(395.23,311.46) v3(395.23,310.7) v3(395.23,308.03) v3(395.23,307.27) v3(395.23,306.5) v3(397.51,298.45) v3(397.51,295.91) v3(397.51,293.37) v3(397.51,290.83) v3(397.51,288.29) v3(397.51,285.75) v3(397.51,283.21) v3(397.51,280.67) v3(397.51,278.13) v3(397.51,275.59) v3(397.51,273.05) v3(397.51,270.51) v3(397.51,267.97) v3(397.51,265.43) v3(397.51,262.89) v3(397.51,260.35) v3(397.51,257.81) v3(397.51,255.27) v3(397.51,252.73) v3(397.51,250.19) v3(397.51,247.65) v3(397.51,245.11) v3(397.51,242.57) v3(397.51,222.25) v3(397.51,219.71) v3(397.51,217.17) v3(397.51,214.63) v3(397.51,212.09) v3(397.51,209.55) v3(397.51,207.01) v3(397.51,204.47) v3(397.51,201.93) v3(397.51,199.39) v3(397.51,196.85) v3(397.51,194.31) v3(397.51,191.77) v3(397.51,189.23) v3(397.51,186.69) v3(397.51,184.15) v3(397.51,181.61) v3(397.51,179.07) v3(397.51,176.53) v3(397.51,173.99) v3(397.51,171.45) v3(397.51,168.91) v3(397.51,166.37) v3(397.51,163.83) v3(397.51,161.29) v3(397.51,158.75) v3(397.51,156.21) v3(397.51,153.67) v3(397.51,151.13) v3(397.51,148.59) v3(397.51,146.05) v3(397.51,143.51) v3(397.51,140.97) v3(397.51,138.43) v3(397.51,135.89) v3(397.51,133.35) v3(397.51,130.81) v3(398.78,122.76) v3(398.78,121.99) v3(398.78,121.23) v3(398.78,118.56) v3(398.78,117.8) v3(398.78,117.04) v3(398.78,114.37) v3(398.78,113.61) v3(398.78,112.85) v3(398.78,110.18) v3(398.78,109.42) v3(398.78,108.66) v3(399.55,320.6) v3(399.55,319.84) v3(399.55,319.08) v3(399.55,316.41) v3(399.55,315.65) v3(399.55,314.89) v3(399.55,312.22) v3(399.55,311.46) v3(399.55,310.7) v3(399.55,308.03) v3(399.55,307.27) v3(399.55,306.5) v3(400.05,298.45) v3(400.05,295.91) v3(400.05,293.37) v3(400.05,290.83) v3(400.05,288.29) v3(400.05,285.75) v3(400.05,283.21) v3(400.05,280.67) v3(400.05,278.13) v3(400.05,275.59) v3(400.05,273.05) v3(400.05,270.51) v3(400.05,267.97) v3(400.05,265.43) v3(400.05,262.89) v3(400.05,260.35) v3(400.05,257.81) v3(400.05,255.27) v3(400.05,252.73) v3(400.05,250.19) v3(400.05,247.65) v3(400.05,245.11) v3(400.05,242.57) v3(400.05,240.03) v3(400.05,237.49) v3(400.05,234.95) v3(400.05,232.41) v3(400.05,229.87) v3(400.05,227.33) v3(400.05,224.79) v3(400.05,222.25) v3(400.05,219.71) v3(400.05,217.17) v3(400.05,214.63) v3(400.05,212.09) v3(400.05,209.55) v3(400.05,207.01) v3(400.05,204.47) v3(400.05,201.93) v3(400.05,199.39) v3(400.05,196.85) v3(400.05,194.31) v3(400.05,191.77) v3(400.05,189.23) v3(400.05,186.69) v3(400.05,184.15) v3(400.05,181.61) v3(400.05,179.07) v3(400.05,176.53) v3(400.05,173.99) v3(400.05,171.45) v3(400.05,168.91) v3(400.05,166.37) v3(400.05,163.83) v3(400.05,161.29) v3(400.05,158.75) v3(400.05,156.21) v3(400.05,153.67) v3(400.05,151.13) v3(400.05,148.59) v3(400.05,146.05) v3(400.05,143.51) v3(400.05,140.97) v3(400.05,138.43) v3(400.05,135.89) v3(400.05,133.35) v3(400.05,130.81) v3(402.59,298.45) v3(402.59,295.91) v3(402.59,293.37) v3(402.59,290.83) v3(402.59,288.29) v3(402.59,285.75) v3(402.59,283.21) v3(402.59,280.67) v3(402.59,278.13) v3(402.59,275.59) v3(402.59,273.05) v3(402.59,270.51) v3(402.59,267.97) v3(402.59,265.43) v3(402.59,262.89) v3(402.59,260.35) v3(402.59,257.81) v3(402.59,255.27) v3(402.59,252.73) v3(402.59,250.19) v3(402.59,247.65) v3(402.59,245.11) v3(402.59,242.57) v3(402.59,240.03) v3(402.59,237.49) v3(402.59,234.95) v3(402.59,232.41) v3(402.59,229.87) v3(402.59,227.33) v3(402.59,224.79) v3(402.59,222.25) v3(402.59,219.71) v3(402.59,217.17) v3(402.59,214.63) v3(402.59,212.09) v3(402.59,209.55) v3(402.59,207.01) v3(402.59,204.47) v3(402.59,201.93) v3(402.59,199.39) v3(402.59,196.85) v3(402.59,194.31) v3(402.59,191.77) v3(402.59,189.23) v3(402.59,186.69) v3(402.59,184.15) v3(402.59,181.61) v3(402.59,179.07) v3(402.59,176.53) v3(402.59,173.99) v3(402.59,171.45) v3(402.59,168.91) v3(402.59,166.37) v3(402.59,163.83) v3(402.59,161.29) v3(402.59,158.75) v3(402.59,156.21) v3(402.59,153.67) v3(402.59,151.13) v3(402.59,148.59) v3(402.59,146.05) v3(402.59,143.51) v3(402.59,140.97) v3(402.59,138.43) v3(402.59,135.89) v3(402.59,133.35) v3(402.59,130.81) v3(403.09,122.76) v3(403.09,121.99) v3(403.09,121.23) v3(403.09,118.56) v3(403.09,117.8) v3(403.09,117.04) v3(403.09,114.37) v3(403.09,113.61) v3(403.09,112.85) v3(403.09,110.18) v3(403.09,109.42) v3(403.09,108.66) v3(403.86,320.6) v3(403.86,319.84) v3(403.86,319.08) v3(403.86,316.41) v3(403.86,315.65) v3(403.86,314.89) v3(403.86,312.22) v3(403.86,311.46) v3(403.86,310.7) v3(403.86,308.03) v3(403.86,307.27) v3(403.86,306.5) v3(405.13,298.45) v3(405.13,295.91) v3(405.13,293.37) v3(405.13,290.83) v3(405.13,288.29) v3(405.13,285.75) v3(405.13,283.21) v3(405.13,280.67) v3(405.13,278.13) v3(405.13,275.59) v3(405.13,273.05) v3(405.13,270.51) v3(405.13,267.97) v3(405.13,265.43) v3(405.13,262.89) v3(405.13,260.35) v3(405.13,257.81) v3(405.13,255.27) v3(405.13,252.73) v3(405.13,250.19) v3(405.13,247.65) v3(405.13,245.11) v3(405.13,242.57) v3(405.13,240.03) v3(405.13,237.49) v3(405.13,234.95) v3(405.13,232.41) v3(405.13,229.87) v3(405.13,227.33) v3(405.13,224.79) v3(405.13,222.25) v3(405.13,219.71) v3(405.13,217.17) v3(405.13,214.63) v3(405.13,212.09) v3(405.13,209.55) v3(405.13,207.01) v3(405.13,204.47) v3(405.13,201.93) v3(405.13,199.39) v3(405.13,196.85) v3(405.13,194.31) v3(405.13,191.77) v3(405.13,189.23) v3(405.13,186.69) v3(405.13,184.15) v3(405.13,181.61) v3(405.13,179.07) v3(405.13,176.53) v3(405.13,173.99) v3(405.13,171.45) v3(405.13,168.91) v3(405.13,166.37) v3(405.13,163.83) v3(405.13,161.29) v3(405.13,158.75) v3(405.13,156.21) v3(405.13,153.67) v3(405.13,151.13) v3(405.13,148.59) v3(405.13,146.05) v3(405.13,143.51) v3(405.13,140.97) v3(405.13,138.43) v3(405.13,135.89) v3(405.13,133.35) v3(405.13,130.81) v3(407.41,122.76) v3(407.41,121.99) v3(407.41,121.23) v3(407.41,118.56) v3(407.41,117.8) v3(407.41,117.04) v3(407.41,114.37) v3(407.41,113.61) v3(407.41,112.85) v3(407.41,110.18) v3(407.41,109.42) v3(407.41,108.66) v3(407.67,298.45) v3(407.67,295.91) v3(407.67,293.37) v3(407.67,290.83) v3(407.67,288.29) v3(407.67,285.75) v3(407.67,283.21) v3(407.67,280.67) v3(407.67,278.13) v3(407.67,275.59) v3(407.67,273.05) v3(407.67,270.51) v3(407.67,267.97) v3(407.67,265.43) v3(407.67,262.89) v3(407.67,260.35) v3(407.67,257.81) v3(407.67,255.27) v3(407.67,252.73) v3(407.67,250.19) v3(407.67,247.65) v3(407.67,245.11) v3(407.67,242.57) v3(407.67,240.03) v3(407.67,237.49) v3(407.67,234.95) v3(407.67,232.41) v3(407.67,229.87) v3(407.67,227.33) v3(407.67,224.79) v3(407.67,222.25) v3(407.67,219.71) v3(407.67,217.17) v3(407.67,214.63) v3(407.67,212.09) v3(407.67,209.55) v3(407.67,207.01) v3(407.67,204.47) v3(407.67,201.93) v3(407.67,199.39) v3(407.67,196.85) v3(407.67,194.31) v3(407.67,191.77) v3(407.67,189.23) v3(407.67,186.69) v3(407.67,184.15) v3(407.67,181.61) v3(407.67,179.07) v3(407.67,176.53) v3(407.67,173.99) v3(407.67,171.45) v3(407.67,168.91) v3(407.67,166.37) v3(407.67,163.83) v3(407.67,161.29) v3(407.67,158.75) v3(407.67,156.21) v3(407.67,153.67) v3(407.67,151.13) v3(407.67,148.59) v3(407.67,146.05) v3(407.67,143.51) v3(407.67,140.97) v3(407.67,138.43) v3(407.67,135.89) v3(407.67,133.35) v3(407.67,130.81) v3(408.18,320.6) v3(408.18,319.84) v3(408.18,319.08) v3(408.18,316.41) v3(408.18,315.65) v3(408.18,314.89) v3(408.18,312.22) v3(408.18,311.46) v3(408.18,310.7) v3(408.18,308.03) v3(408.18,307.27) v3(408.18,306.5) v3(410.21,298.45) v3(410.21,295.91) v3(410.21,293.37) v3(410.21,290.83) v3(410.21,288.29) v3(410.21,285.75) v3(410.21,283.21) v3(410.21,280.67) v3(410.21,278.13) v3(410.21,275.59) v3(410.21,273.05) v3(410.21,270.51) v3(410.21,267.97) v3(410.21,265.43) v3(410.21,262.89) v3(410.21,260.35) v3(410.21,257.81) v3(410.21,255.27) v3(410.21,252.73) v3(410.21,250.19) v3(410.21,247.65) v3(410.21,245.11) v3(410.21,242.57) v3(410.21,240.03) v3(410.21,237.49) v3(410.21,234.95) v3(410.21,232.41) v3(410.21,229.87) v3(410.21,227.33) v3(410.21,224.79) v3(410.21,222.25) v3(410.21,219.71) v3(410.21,217.17) v3(410.21,214.63) v3(410.21,212.09) v3(410.21,209.55) v3(410.21,207.01) v3(410.21,204.47) v3(410.21,201.93) v3(410.21,199.39) v3(410.21,196.85) v3(410.21,194.31) v3(410.21,191.77) v3(410.21,189.23) v3(410.21,186.69) v3(410.21,184.15) v3(410.21,181.61) v3(410.21,179.07) v3(410.21,176.53) v3(410.21,173.99) v3(410.21,171.45) v3(410.21,168.91) v3(410.21,166.37) v3(410.21,163.83) v3(410.21,161.29) v3(410.21,158.75) v3(410.21,156.21) v3(410.21,153.67) v3(410.21,151.13) v3(410.21,148.59) v3(410.21,146.05) v3(410.21,143.51) v3(410.21,140.97) v3(410.21,138.43) v3(410.21,135.89) v3(410.21,133.35) v3(410.98,130.81) v3(411.73,122.76) v3(411.73,121.99) v3(411.73,121.23) v3(411.73,118.56) v3(411.73,117.8) v3(411.73,117.04) v3(411.73,114.37) v3(411.73,113.61) v3(411.73,112.85) v3(411.73,110.18) v3(411.73,109.42) v3(411.73,108.66) v3(412.5,320.6) v3(412.5,319.84) v3(412.5,319.08) v3(412.5,316.41) v3(412.5,315.65) v3(412.5,314.89) v3(412.5,312.22) v3(412.5,311.46) v3(412.5,310.7) v3(412.5,308.03) v3(412.5,307.27) v3(412.5,306.5) v3(412.75,298.45) v3(412.75,295.91) v3(412.75,293.37) v3(412.75,290.83) v3(412.75,288.29) v3(412.75,285.75) v3(412.75,283.21) v3(412.75,280.67) v3(412.75,278.13) v3(412.75,275.59) v3(412.75,273.05) v3(412.75,270.51) v3(412.75,267.97) v3(412.75,265.43) v3(412.75,262.89) v3(412.75,260.35) v3(412.75,257.81) v3(412.75,255.27) v3(412.75,252.73) v3(412.75,250.19) v3(412.75,247.65) v3(412.75,245.11) v3(412.75,242.57) v3(412.75,240.03) v3(412.75,237.49) v3(412.75,234.95) v3(412.75,232.41) v3(412.75,229.87) v3(412.75,227.33) v3(412.75,224.79) v3(412.75,222.25) v3(412.75,219.71) v3(412.75,217.17) v3(412.75,214.63) v3(412.75,212.09) v3(412.75,209.55) v3(412.75,207.01) v3(412.75,204.47) v3(412.75,201.93) v3(412.75,199.39) v3(412.75,196.85) v3(412.75,194.31) v3(412.75,191.77) v3(412.75,189.23) v3(412.75,186.69) v3(412.75,184.15) v3(412.75,181.61) v3(412.75,179.07) v3(412.75,176.53) v3(412.75,173.99) v3(412.75,171.45) v3(412.75,168.91) v3(412.75,166.37) v3(412.75,163.83) v3(412.75,161.29) v3(412.75,158.75) v3(412.75,156.21) v3(412.75,153.67) v3(412.75,151.13) v3(412.75,148.59) v3(412.75,146.05) v3(412.75,143.51) v3(412.75,140.97) v3(412.75,138.43) v3(412.75,135.89) v3(412.75,133.35) v3(415.29,298.45) v3(415.29,295.91) v3(415.29,293.37) v3(415.29,290.83) v3(415.29,288.29) v3(415.29,285.75) v3(415.29,283.21) v3(415.29,280.67) v3(415.29,278.13) v3(415.29,275.59) v3(415.29,273.05) v3(415.29,270.51) v3(415.29,267.97) v3(415.29,265.43) v3(415.29,262.89) v3(415.29,260.35) v3(415.29,257.81) v3(415.29,255.27) v3(415.29,252.73) v3(415.29,250.19) v3(415.29,247.65) v3(415.29,245.11) v3(415.29,242.57) v3(415.29,240.03) v3(415.29,237.49) v3(415.29,234.95) v3(415.29,232.41) v3(415.29,229.87) v3(415.29,227.33) v3(415.29,224.79) v3(415.29,222.25) v3(415.29,219.71) v3(415.29,217.17) v3(415.29,214.63) v3(415.29,212.09) v3(415.29,209.55) v3(415.29,207.01) v3(415.29,204.47) v3(415.29,201.93) v3(415.29,199.39) v3(415.29,196.85) v3(415.29,194.31) v3(415.29,191.77) v3(415.29,189.23) v3(415.29,186.69) v3(415.29,184.15) v3(415.29,181.61) v3(415.29,179.07) v3(415.29,176.53) v3(415.29,173.99) v3(415.29,171.45) v3(415.29,168.91) v3(415.29,166.37) v3(415.29,163.83) v3(415.29,161.29) v3(415.29,158.75) v3(415.29,156.21) v3(415.29,153.67) v3(415.29,151.13) v3(415.29,148.59) v3(415.29,146.05) v3(415.29,143.51) v3(415.29,140.97) v3(415.29,138.43) v3(415.29,135.89) v3(416.05,122.76) v3(416.05,121.99) v3(416.05,121.23) v3(416.05,118.56) v3(416.05,117.8) v3(416.05,117.04) v3(416.05,114.37) v3(416.05,113.61) v3(416.05,112.85) v3(416.05,110.18) v3(416.05,109.42) v3(416.05,108.66) v3(416.82,320.6) v3(416.82,319.84) v3(416.82,319.08) v3(416.82,316.41) v3(416.82,315.65) v3(416.82,314.89) v3(416.82,312.22) v3(416.82,311.46) v3(416.82,310.7) v3(416.82,308.03) v3(416.82,307.27) v3(416.82,306.5) v3(417.83,298.45) v3(417.83,295.91) v3(417.83,293.37) v3(417.83,290.83) v3(417.83,288.29) v3(417.83,285.75) v3(417.83,283.21) v3(417.83,280.67) v3(417.83,278.13) v3(417.83,275.59) v3(417.83,273.05) v3(417.83,270.51) v3(417.83,267.97) v3(417.83,265.43) v3(417.83,262.89) v3(417.83,260.35) v3(417.83,257.81) v3(417.83,255.27) v3(417.83,252.73) v3(417.83,250.19) v3(417.83,247.65) v3(417.83,245.11) v3(417.83,242.57) v3(417.83,240.03) v3(417.83,237.49) v3(417.83,234.95) v3(417.83,194.31) v3(417.83,191.77) v3(417.83,189.23) v3(417.83,186.69) v3(417.83,184.15) v3(417.83,181.61) v3(417.83,179.07) v3(417.83,176.53) v3(417.83,173.99) v3(417.83,171.45) v3(417.83,168.91) v3(417.83,166.37) v3(417.83,163.83) v3(417.83,161.29) v3(417.83,158.75) v3(417.83,156.21) v3(417.83,153.67) v3(417.83,151.13) v3(417.83,148.59) v3(417.83,146.05) v3(417.83,143.51) v3(417.83,140.97) v3(417.83,138.43) v3(417.83,135.89) v3(420.37,298.45) v3(420.37,295.91) v3(420.37,293.37) v3(420.37,290.83) v3(420.37,288.29) v3(420.37,285.75) v3(420.37,283.21) v3(420.37,280.67) v3(420.37,278.13) v3(420.37,275.59) v3(420.37,273.05) v3(420.37,270.51) v3(420.37,267.97) v3(420.37,265.43) v3(420.37,262.89) v3(420.37,260.35) v3(420.37,257.81) v3(420.37,255.27) v3(420.37,252.73) v3(420.37,250.19) v3(420.37,247.65) v3(420.37,245.11) v3(420.37,237.49) v3(420.37,191.77) v3(420.37,184.15) v3(420.37,181.61) v3(420.37,179.07) v3(420.37,176.53) v3(420.37,173.99) v3(420.37,171.45) v3(420.37,168.91) v3(420.37,166.37) v3(420.37,163.83) v3(420.37,161.29) v3(420.37,158.75) v3(420.37,156.21) v3(420.37,153.67) v3(420.37,151.13) v3(420.37,148.59) v3(420.37,146.05) v3(420.37,143.51) v3(420.37,140.97) v3(420.37,138.43) v3(420.37,135.89) v3(420.37,133.35) v3(420.37,130.81) v3(420.37,122.76) v3(420.37,121.99) v3(420.37,121.23) v3(420.37,118.56) v3(420.37,117.8) v3(420.37,117.04) v3(420.37,114.37) v3(420.37,113.61) v3(420.37,112.85) v3(420.37,110.18) v3(420.37,109.42) v3(420.37,108.66) v3(421.14,320.6) v3(421.14,319.84) v3(421.14,319.08) v3(421.14,316.41) v3(421.14,315.65) v3(421.14,314.89) v3(421.14,312.22) v3(421.14,311.46) v3(421.14,310.7) v3(421.14,308.03) v3(421.14,307.27) v3(421.14,306.5) v3(422.91,283.21) v3(422.91,280.67) v3(422.91,278.13) v3(422.91,275.59) v3(422.91,273.05) v3(422.91,270.51) v3(422.91,267.97) v3(422.91,265.43) v3(422.91,262.89) v3(422.91,260.35) v3(422.91,257.81) v3(422.91,255.27) v3(422.91,252.73) v3(422.91,250.19) v3(422.91,247.65) v3(422.91,245.11) v3(422.91,237.49) v3(422.91,191.77) v3(422.91,184.15) v3(422.91,181.61) v3(422.91,179.07) v3(422.91,176.53) v3(422.91,173.99) v3(422.91,171.45) v3(422.91,168.91) v3(422.91,166.37) v3(422.91,163.83) v3(422.91,161.29) v3(422.91,158.75) v3(422.91,156.21) v3(422.91,153.67) v3(422.91,151.13) v3(422.91,148.59) v3(422.91,146.05) v3(422.91,143.51) v3(422.91,140.97) v3(422.91,138.43) v3(422.91,135.89) v3(423.68,288.29) v3(424.68,122.76) v3(424.68,121.99) v3(424.68,121.23) v3(424.68,118.56) v3(424.68,117.8) v3(424.68,117.04) v3(424.68,114.37) v3(424.68,113.61) v3(424.68,112.85) v3(424.68,110.18) v3(424.68,109.42) v3(424.68,108.66) v3(425.45,320.6) v3(425.45,319.84) v3(425.45,319.08) v3(425.45,316.41) v3(425.45,315.65) v3(425.45,314.89) v3(425.45,312.22) v3(425.45,311.46) v3(425.45,310.7) v3(425.45,308.03) v3(425.45,307.27) v3(425.45,306.5) v3(425.45,283.21) v3(425.45,280.67) v3(425.45,278.13) v3(425.45,275.59) v3(425.45,273.05) v3(425.45,270.51) v3(425.45,267.97) v3(425.45,265.43) v3(425.45,262.89) v3(425.45,260.35) v3(425.45,257.81) v3(425.45,255.27) v3(425.45,252.73) v3(425.45,250.19) v3(425.45,247.65) v3(425.45,245.11) v3(425.45,237.49) v3(425.45,191.77) v3(425.45,184.15) v3(425.45,181.61) v3(425.45,179.07) v3(425.45,176.53) v3(425.45,173.99) v3(425.45,171.45) v3(425.45,168.91) v3(425.45,166.37) v3(425.45,163.83) v3(425.45,161.29) v3(425.45,158.75) v3(425.45,156.21) v3(425.45,153.67) v3(425.45,151.13) v3(425.45,148.59) v3(425.45,146.05) v3(425.45,143.51) v3(425.45,140.97) v3(425.45,138.43) v3(425.45,135.89) v3(450.85,300.99) v3(450.85,295.91) v3(450.85,290.83) v3(450.85,285.75) v3(450.85,280.67) v3(450.85,275.59) v3(450.85,270.51) v3(450.85,265.43) v3(450.85,260.35) v3(450.85,255.27) v3(450.85,240.03) v3(450.85,234.95) v3(450.85,229.87) v3(450.85,224.79) v3(450.85,204.47) v3(450.85,199.39) v3(450.85,194.31) v3(450.85,173.99) v3(450.85,168.91) v3(450.85,163.83) v3(450.85,158.75) v3(450.85,143.51) v3(450.85,138.43) v3(450.85,133.35) v3(450.85,128.27) v3(450.85,122.76) v3(450.85,121.99) v3(450.85,121.23) v3(450.85,118.56) v3(450.85,117.8) v3(450.85,117.04) v3(450.85,114.37) v3(450.85,113.61) v3(450.85,112.85) v3(450.85,110.18) v3(450.85,109.42) v3(450.85,108.66) v3(451.62,320.6) v3(451.62,319.84) v3(451.62,319.08) v3(451.62,316.41) v3(451.62,315.65) v3(451.62,314.89) v3(451.62,312.22) v3(451.62,311.46) v3(451.62,310.7) v3(451.62,308.03) v3(451.62,307.27) v3(451.62,306.5) v3(452.39,298.45) v3(452.39,130.81) v3(453.34,241.24) v3(453.34,209.49) v3(453.34,177.74) v3(453.34,145.99) v3(453.39,293.37) v3(453.39,288.29) v3(453.39,283.21) v3(453.39,278.13) v3(453.39,273.05) v3(453.39,267.97) v3(453.39,262.89) v3(453.39,257.81) v3(453.39,232.41) v3(453.39,227.33) v3(453.39,201.93) v3(453.39,196.85) v3(453.39,191.77) v3(453.39,166.37) v3(453.39,161.29) v3(453.39,135.89) v3(453.86,237.74) v3(453.86,205.99) v3(453.86,174.24) v3(453.86,142.49) v3(454.1,275.84) v3(455.16,122.76) v3(455.16,121.99) v3(455.16,121.23) v3(455.16,118.56) v3(455.16,117.8) v3(455.16,117.04) v3(455.16,114.37) v3(455.16,113.61) v3(455.16,112.85) v3(455.16,110.18) v3(455.16,109.42) v3(455.16,108.66) v3(455.93,320.6) v3(455.93,319.84) v3(455.93,319.08) v3(455.93,316.41) v3(455.93,315.65) v3(455.93,314.89) v3(455.93,312.22) v3(455.93,311.46) v3(455.93,310.7) v3(455.93,308.03) v3(455.93,307.27) v3(455.93,306.5) v3(455.93,300.99) v3(455.93,295.91) v3(455.93,290.83) v3(455.93,285.75) v3(455.93,280.67) v3(455.93,270.51) v3(455.93,265.43) v3(455.93,260.35) v3(455.93,255.27) v3(455.93,224.79) v3(455.93,194.31) v3(455.93,163.83) v3(455.93,158.75) v3(455.93,133.35) v3(455.93,128.27) v3(458.47,298.45) v3(458.47,293.37) v3(458.47,288.29) v3(458.47,283.21) v3(458.47,267.97) v3(458.47,262.89) v3(458.47,257.81) v3(458.47,227.33) v3(458.47,196.85) v3(458.47,191.77) v3(458.47,161.29) v3(458.47,130.81) v3(459.48,122.76) v3(459.48,121.99) v3(459.48,121.23) v3(459.48,118.56) v3(459.48,117.8) v3(459.48,117.04) v3(459.48,114.37) v3(459.48,113.61) v3(459.48,112.85) v3(459.48,110.18) v3(459.48,109.42) v3(459.48,108.66) v3(460.25,320.6) v3(460.25,319.84) v3(460.25,319.08) v3(460.25,316.41) v3(460.25,315.65) v3(460.25,314.89) v3(460.25,312.22) v3(460.25,311.46) v3(460.25,310.7) v3(460.25,308.03) v3(460.25,307.27) v3(460.25,306.5) v3(461.01,300.99) v3(461.01,295.91) v3(461.01,290.83) v3(461.01,285.75) v3(461.01,280.67) v3(461.01,270.51) v3(461.01,265.43) v3(461.01,260.35) v3(461.01,255.27) v3(461.01,224.79) v3(461.01,163.83) v3(461.01,158.75) v3(461.01,133.35) v3(461.01,128.27) v3(463.55,298.45) v3(463.55,293.37) v3(463.55,288.29) v3(463.55,283.21) v3(463.55,273.05) v3(463.55,267.97) v3(463.55,262.89) v3(463.55,257.81) v3(463.55,196.85) v3(463.55,161.29) v3(463.55,130.81) v3(463.8,122.76) v3(463.8,121.99) v3(463.8,121.23) v3(463.8,118.56) v3(463.8,117.8) v3(463.8,117.04) v3(463.8,114.37) v3(463.8,113.61) v3(463.8,112.85) v3(463.8,110.18) v3(463.8,109.42) v3(463.8,108.66) v3(464.57,320.6) v3(464.57,319.84) v3(464.57,319.08) v3(464.57,316.41) v3(464.57,315.65) v3(464.57,314.89) v3(464.57,312.22) v3(464.57,311.46) v3(464.57,310.7) v3(464.57,308.03) v3(464.57,307.27) v3(464.57,306.5) v3(465.84,227.48) v3(465.84,195.73) v3(465.84,163.98) v3(465.84,132.23) v3(466.09,300.99) v3(466.09,295.91) v3(466.09,290.83) v3(466.09,285.75) v3(466.09,280.67) v3(466.09,270.51) v3(466.09,265.43) v3(466.09,260.35) v3(466.09,255.27) v3(467.5,226.85) v3(467.5,195.1) v3(467.5,163.35) v3(467.5,131.6) v3(468.12,122.76) v3(468.12,121.99) v3(468.12,121.23) v3(468.12,118.56) v3(468.12,117.8) v3(468.12,117.04) v3(468.12,114.37) v3(468.12,113.61) v3(468.12,112.85) v3(468.12,110.18) v3(468.12,109.42) v3(468.12,108.66) v3(468.63,298.45) v3(468.63,293.37) v3(468.63,288.29) v3(468.63,283.21) v3(468.63,278.13) v3(468.63,273.05) v3(468.63,267.97) v3(468.63,262.89) v3(468.63,257.81) v3(468.89,320.6) v3(468.89,319.84) v3(468.89,319.08) v3(468.89,316.41) v3(468.89,315.65) v3(468.89,314.89) v3(468.89,312.22) v3(468.89,311.46) v3(468.89,310.7) v3(468.89,308.03) v3(468.89,307.27) v3(468.89,306.5) v3(471.17,300.99) v3(471.17,295.91) v3(471.17,290.83) v3(471.17,285.75) v3(471.17,280.67) v3(471.17,275.59) v3(471.17,270.51) v3(471.17,265.43) v3(471.17,260.35) v3(471.17,255.27) v3(471.17,158.75) v3(471.17,128.27) v3(471.76,241.24) v3(471.76,209.49) v3(471.76,177.74) v3(471.76,145.99) v3(472.29,237.74) v3(472.29,205.99) v3(472.29,174.24) v3(472.29,142.49) v3(472.44,122.76) v3(472.44,121.99) v3(472.44,121.23) v3(472.44,118.56) v3(472.44,117.8) v3(472.44,117.04) v3(472.44,114.37) v3(472.44,113.61) v3(472.44,112.85) v3(472.44,110.18) v3(472.44,109.42) v3(472.44,108.66) v3(473.21,320.6) v3(473.21,319.84) v3(473.21,319.08) v3(473.21,316.41) v3(473.21,315.65) v3(473.21,314.89) v3(473.21,312.22) v3(473.21,311.46) v3(473.21,310.7) v3(473.21,308.03) v3(473.21,307.27) v3(473.21,306.5) v3(473.46,226.33) v3(473.46,194.58) v3(473.46,162.83) v3(473.46,131.08) v3(473.71,298.45) v3(473.71,293.37) v3(473.71,288.29) v3(473.71,283.21) v3(473.71,278.13) v3(473.71,273.05) v3(473.71,267.97) v3(473.71,262.89) v3(473.71,257.81) v3(473.71,196.85) v3(473.71,191.77) v3(473.71,161.29) v3(474.86,225.8) v3(474.86,194.05) v3(474.86,162.3) v3(474.86,130.55) v3(476.25,300.99) v3(476.25,295.91) v3(476.25,290.83) v3(476.25,285.75) v3(476.25,280.67) v3(476.25,275.59) v3(476.25,270.51) v3(476.25,265.43) v3(476.25,260.35) v3(476.25,255.27) v3(476.25,224.79) v3(476.25,194.31) v3(476.25,163.83) v3(476.25,158.75) v3(476.25,133.35) v3(476.25,128.27) v3(476.75,122.76) v3(476.75,121.99) v3(476.75,121.23) v3(476.75,118.56) v3(476.75,117.8) v3(476.75,117.04) v3(476.75,114.37) v3(476.75,113.61) v3(476.75,112.85) v3(476.75,110.18) v3(476.75,109.42) v3(476.75,108.66) v3(477.52,320.6) v3(477.52,319.84) v3(477.52,319.08) v3(477.52,316.41) v3(477.52,315.65) v3(477.52,314.89) v3(477.52,312.22) v3(477.52,311.46) v3(477.52,310.7) v3(477.52,308.03) v3(477.52,307.27) v3(477.52,306.5) v3(478.79,298.45) v3(478.79,293.37) v3(478.79,288.29) v3(478.79,283.21) v3(478.79,278.13) v3(478.79,273.05) v3(478.79,267.97) v3(478.79,262.89) v3(478.79,257.81) v3(478.79,191.77) v3(478.79,161.29) v3(478.79,130.81) v3(481.07,122.76) v3(481.07,121.99) v3(481.07,121.23) v3(481.07,118.56) v3(481.07,117.8) v3(481.07,117.04) v3(481.07,114.37) v3(481.07,113.61) v3(481.07,112.85) v3(481.07,110.18) v3(481.07,109.42) v3(481.07,108.66) v3(481.33,300.99) v3(481.33,295.91) v3(481.33,290.83) v3(481.33,285.75) v3(481.33,280.67) v3(481.33,275.59) v3(481.33,270.51) v3(481.33,265.43) v3(481.33,260.35) v3(481.33,255.27) v3(481.33,224.79) v3(481.33,163.83) v3(481.33,158.75) v3(481.33,133.35) v3(481.33,128.27) v3(481.84,320.6) v3(481.84,319.84) v3(481.84,319.08) v3(481.84,316.41) v3(481.84,315.65) v3(481.84,314.89) v3(481.84,312.22) v3(481.84,311.46) v3(481.84,310.7) v3(481.84,308.03) v3(481.84,307.27) v3(481.84,306.5) v3(483.87,298.45) v3(483.87,293.37) v3(483.87,288.29) v3(483.87,283.21) v3(483.87,278.13) v3(483.87,273.05) v3(483.87,267.97) v3(483.87,262.89) v3(483.87,257.81) v3(483.87,227.33) v3(483.87,196.85) v3(483.87,191.77) v3(483.87,161.29) v3(483.87,130.81) v3(485.39,122.76) v3(485.39,121.99) v3(485.39,121.23) v3(485.39,118.56) v3(485.39,117.8) v3(485.39,117.04) v3(485.39,114.37) v3(485.39,113.61) v3(485.39,112.85) v3(485.39,110.18) v3(485.39,109.42) v3(485.39,108.66) v3(486.16,320.6) v3(486.16,319.84) v3(486.16,319.08) v3(486.16,316.41) v3(486.16,315.65) v3(486.16,314.89) v3(486.16,312.22) v3(486.16,311.46) v3(486.16,310.7) v3(486.16,308.03) v3(486.16,307.27) v3(486.16,306.5) v3(486.41,300.99) v3(486.41,295.91) v3(486.41,290.83) v3(486.41,285.75) v3(486.41,280.67) v3(486.41,275.59) v3(486.41,270.51) v3(486.41,265.43) v3(486.41,260.35) v3(486.41,255.27) v3(486.41,224.79) v3(486.41,194.31) v3(486.41,163.83) v3(486.41,158.75) v3(486.41,133.35) v3(486.41,128.27) v3(488.95,298.45) v3(488.95,293.37) v3(488.95,288.29) v3(488.95,283.21) v3(488.95,278.13) v3(488.95,273.05) v3(488.95,267.97) v3(488.95,262.89) v3(488.95,257.81) v3(488.95,252.73) v3(488.95,247.65) v3(488.95,242.57) v3(488.95,237.49) v3(488.95,232.41) v3(488.95,227.33) v3(488.95,222.25) v3(488.95,217.17) v3(488.95,212.09) v3(488.95,207.01) v3(488.95,196.85) v3(488.95,191.77) v3(488.95,186.69) v3(488.95,181.61) v3(488.95,176.53) v3(488.95,171.45) v3(488.95,166.37) v3(488.95,161.29) v3(488.95,156.21) v3(488.95,151.13) v3(488.95,146.05) v3(488.95,135.89) v3(488.95,130.81) v3(489.71,122.76) v3(489.71,121.99) v3(489.71,121.23) v3(489.71,118.56) v3(489.71,117.8) v3(489.71,117.04) v3(489.71,114.37) v3(489.71,113.61) v3(489.71,112.85) v3(489.71,110.18) v3(489.71,109.42) v3(489.71,108.66) v3(490.48,320.6) v3(490.48,319.84) v3(490.48,319.08) v3(490.48,316.41) v3(490.48,315.65) v3(490.48,314.89) v3(490.48,312.22) v3(490.48,311.46) v3(490.48,310.7) v3(490.48,308.03) v3(490.48,307.27) v3(490.48,306.5) v3(491.49,300.99) v3(491.49,295.91) v3(491.49,290.83) v3(491.49,285.75) v3(491.49,280.67) v3(491.49,275.59) v3(491.49,270.51) v3(491.49,265.43) v3(491.49,260.35) v3(491.49,255.27) v3(491.49,250.19) v3(491.49,245.11) v3(491.49,240.03) v3(491.49,234.95) v3(491.49,229.87) v3(491.49,224.79) v3(491.49,219.71) v3(491.49,214.63) v3(491.49,209.55) v3(491.49,204.47) v3(491.49,199.39) v3(491.49,194.31) v3(491.49,189.23) v3(491.49,184.15) v3(491.49,179.07) v3(491.49,173.99) v3(491.49,168.91) v3(491.49,163.83) v3(491.49,158.75) v3(491.49,153.67) v3(491.49,148.59) v3(491.49,143.51) v3(491.49,138.43) v3(491.49,133.35) v3(491.49,128.27) v3(494.03,298.45) v3(494.03,293.37) v3(494.03,288.29) v3(494.03,283.21) v3(494.03,278.13) v3(494.03,273.05) v3(494.03,267.97) v3(494.03,262.89) v3(494.03,257.81) v3(494.03,252.73) v3(494.03,247.65) v3(494.03,242.57) v3(494.03,237.49) v3(494.03,232.41) v3(494.05,229.97) v3(494.03,217.17) v3(494.05,211.81) v3(494.03,201.93) v3(494.03,196.85) v3(494.03,191.77) v3(494.03,186.69) v3(494.03,181.61) v3(494.03,176.53) v3(494.03,171.45) v3(494.03,166.37) v3(494.03,161.29) v3(494.03,156.21) v3(494.03,151.13) v3(494.03,146.05) v3(494.03,140.97) v3(494.03,135.89) v3(494.03,130.81) v3(494.03,122.76) v3(494.03,121.99) v3(494.03,121.23) v3(494.03,118.56) v3(494.03,117.8) v3(494.03,117.04) v3(494.03,114.37) v3(494.03,113.61) v3(494.03,112.85) v3(494.03,110.18) v3(494.03,109.42) v3(494.03,108.66) v3(494.8,320.6) v3(494.8,319.84) v3(494.8,319.08) v3(494.8,316.41) v3(494.8,315.65) v3(494.8,314.89) v3(494.8,312.22) v3(494.8,311.46) v3(494.8,310.7) v3(494.8,308.03) v3(494.8,307.27) v3(494.8,306.5) v3(496.57,300.99) v3(496.57,295.91) v3(496.57,290.83) v3(496.57,285.75) v3(496.57,280.67) v3(496.57,275.59) v3(496.57,270.51) v3(496.57,265.43) v3(496.57,260.35) v3(496.57,255.27) v3(496.57,250.19) v3(496.57,245.11) v3(496.57,240.03) v3(496.57,234.95) v3(496.57,219.71) v3(496.57,214.63) v3(496.57,199.39) v3(496.57,194.31) v3(496.57,189.23) v3(496.57,184.15) v3(496.57,179.07) v3(496.57,173.99) v3(496.57,168.91) v3(496.57,163.83) v3(496.57,158.75) v3(496.57,153.67) v3(496.57,148.59) v3(496.57,143.51) v3(496.57,138.43) v3(496.57,133.35) v3(496.57,128.27) v3(498.34,122.76) v3(498.34,121.99) v3(498.34,121.23) v3(498.34,118.56) v3(498.34,117.8) v3(498.34,117.04) v3(498.34,114.37) v3(498.34,113.61) v3(498.34,112.85) v3(498.34,110.18) v3(498.34,109.42) v3(498.34,108.66) v3(499.11,320.6) v3(499.11,319.84) v3(499.11,319.08) v3(499.11,316.41) v3(499.11,315.65) v3(499.11,314.89) v3(499.11,312.22) v3(499.11,311.46) v3(499.11,310.7) v3(499.11,308.03) v3(499.11,307.27) v3(499.11,306.5) v3(499.11,298.45) v3(499.11,293.37) v3(499.11,288.29) v3(499.11,283.21) v3(499.11,278.13) v3(499.11,273.05) v3(499.11,267.97) v3(499.11,262.89) v3(499.11,257.81) v3(499.11,252.73) v3(499.11,247.65) v3(499.11,242.57) v3(499.11,237.49) v3(499.11,232.41) v3(499.11,217.17) v3(499.11,212.09) v3(499.11,201.93) v3(499.11,196.85) v3(499.11,191.77) v3(499.11,186.69) v3(499.11,181.61) v3(499.11,176.53) v3(499.11,171.45) v3(499.11,166.37) v3(499.11,161.29) v3(499.11,156.21) v3(499.11,151.13) v3(499.11,146.05) v3(499.11,140.97) v3(499.11,135.89) v3(499.11,130.81) v3(501.65,300.99) v3(501.65,295.91) v3(501.65,290.83) v3(501.65,285.75) v3(501.65,280.67) v3(501.65,275.59) v3(501.65,270.51) v3(501.65,265.43) v3(501.65,260.35) v3(501.65,255.27) v3(501.65,250.19) v3(501.65,245.11) v3(501.65,240.03) v3(501.65,234.95) v3(501.65,229.87) v3(501.65,219.71) v3(501.65,214.63) v3(501.65,199.39) v3(501.65,194.31) v3(501.65,189.23) v3(501.65,184.15) v3(501.65,179.07) v3(501.65,173.99) v3(501.65,168.91) v3(501.65,163.83) v3(501.65,158.75) v3(501.65,153.67) v3(501.65,148.59) v3(501.65,143.51) v3(501.65,138.43) v3(501.65,133.35) v3(501.65,128.27) v3(501.9,224.63) v3(501.9,206.48) v3(502.43,221.42) v3(503.58,221.42) v3(503.58,203.26) v3(504.19,298.45) v3(504.19,293.37) v3(504.19,288.29) v3(504.19,283.21) v3(504.19,278.13) v3(504.19,273.05) v3(504.19,267.97) v3(504.19,262.89) v3(504.19,257.81) v3(504.19,252.73) v3(504.19,247.65) v3(504.19,242.57) v3(504.19,237.49) v3(504.19,232.41) v3(504.19,217.17) v3(504.19,212.09) v3(504.19,207.01) v3(504.19,201.93) v3(504.19,196.85) v3(504.19,191.77) v3(504.19,186.69) v3(504.19,181.61) v3(504.19,176.53) v3(504.19,171.45) v3(504.19,166.37) v3(504.19,161.29) v3(504.19,156.21) v3(504.19,151.13) v3(504.19,146.05) v3(504.19,140.97) v3(504.19,135.89) v3(504.19,130.81) v3(506.73,300.99) v3(506.73,295.91) v3(506.73,290.83) v3(506.73,285.75) v3(506.73,280.67) v3(506.73,275.59) v3(506.73,270.51) v3(506.73,265.43) v3(506.73,260.35) v3(506.73,255.27) v3(506.73,250.19) v3(506.73,245.11) v3(506.73,240.03) v3(506.73,234.95) v3(506.73,214.63) v3(506.73,209.55) v3(506.73,204.47) v3(506.73,199.39) v3(506.73,194.31) v3(506.73,189.23) v3(506.73,184.15) v3(506.73,179.07) v3(506.73,173.99) v3(506.73,168.91) v3(506.73,163.83) v3(506.73,158.75) v3(506.73,153.67) v3(506.73,148.59) v3(506.73,143.51) v3(506.73,138.43) v3(506.73,133.35) v3(506.73,128.27) v3(509.27,298.45) v3(509.27,293.37) v3(509.27,288.29) v3(509.27,283.21) v3(509.27,278.13) v3(509.27,273.05) v3(509.27,267.97) v3(509.27,262.89) v3(509.27,257.81) v3(509.27,252.73) v3(509.27,247.65) v3(509.27,242.57) v3(509.27,237.49) v3(509.27,232.41) v3(509.27,217.17) v3(509.27,212.09) v3(509.27,207.01) v3(509.27,201.93) v3(509.27,196.85) v3(509.27,191.77) v3(509.27,186.69) v3(509.27,181.61) v3(509.27,176.53) v3(509.27,171.45) v3(509.27,166.37) v3(509.27,161.29) v3(509.27,156.21) v3(509.27,151.13) v3(509.27,146.05) v3(509.27,140.97) v3(509.27,135.89) v3(509.27,130.81) v3(509.75,221.35) v3(511.81,300.99) v3(511.81,295.91) v3(511.81,290.83) v3(511.81,285.75) v3(511.81,280.67) v3(511.81,275.59) v3(511.81,270.51) v3(511.81,265.43) v3(511.81,260.35) v3(511.81,255.27) v3(511.81,250.19) v3(511.81,245.11) v3(511.81,240.03) v3(511.81,234.95) v3(511.81,214.63) v3(511.81,209.55) v3(511.81,204.47) v3(511.81,199.39) v3(511.81,194.31) v3(511.81,189.23) v3(511.81,184.15) v3(511.81,179.07) v3(511.81,173.99) v3(511.81,168.91) v3(511.81,163.83) v3(511.81,158.75) v3(511.81,153.67) v3(511.81,148.59) v3(511.81,143.51) v3(511.81,138.43) v3(511.81,133.35) v3(511.81,128.27) v3(514.35,298.45) v3(514.35,293.37) v3(514.35,288.29) v3(514.35,283.21) v3(514.35,278.13) v3(514.35,273.05) v3(514.35,267.97) v3(514.35,262.89) v3(514.35,257.81) v3(514.35,252.73) v3(514.35,247.65) v3(514.35,242.57) v3(514.35,237.49) v3(514.35,232.41) v3(514.35,227.33) v3(514.35,222.25) v3(514.35,217.17) v3(514.35,212.09) v3(514.35,207.01) v3(514.35,201.93) v3(514.35,196.85) v3(514.35,191.77) v3(514.35,186.69) v3(514.35,181.61) v3(514.35,176.53) v3(514.35,171.45) v3(514.35,166.37) v3(514.35,161.29) v3(514.35,156.21) v3(514.35,151.13) v3(514.35,146.05) v3(514.35,140.97) v3(514.35,135.89) v3(514.35,130.81) v3(516.89,300.99) v3(516.89,295.91) v3(516.89,290.83) v3(516.89,285.75) v3(516.89,280.67) v3(516.89,275.59) v3(516.89,270.51) v3(516.89,265.43) v3(516.89,260.35) v3(516.89,255.27) v3(516.89,250.19) v3(516.89,245.11) v3(516.89,240.03) v3(516.89,234.95) v3(516.89,229.87) v3(516.89,224.79) v3(516.89,219.71) v3(516.89,214.63) v3(516.89,209.55) v3(516.89,204.47) v3(516.89,199.39) v3(516.89,194.31) v3(516.89,189.23) v3(516.89,184.15) v3(516.89,179.07) v3(516.89,173.99) v3(516.89,168.91) v3(516.89,163.83) v3(516.89,158.75) v3(516.89,153.67) v3(516.89,148.59) v3(516.89,143.51) v3(516.89,138.43) v3(516.89,133.35) v3(516.89,128.27) v3(519.01,146.58) v3(519.43,298.45) v3(519.43,293.37) v3(519.43,288.29) v3(519.43,283.21) v3(519.43,278.13) v3(519.43,273.05) v3(519.43,267.97) v3(519.43,262.89) v3(519.43,257.81) v3(519.43,252.73) v3(519.43,247.65) v3(519.43,242.57) v3(519.43,237.49) v3(519.43,232.41) v3(519.43,227.33) v3(519.43,222.25) v3(519.43,217.17) v3(519.43,212.09) v3(519.43,207.01) v3(519.43,201.93) v3(519.43,196.85) v3(519.43,191.77) v3(519.43,186.69) v3(519.43,181.61) v3(519.43,176.53) v3(519.43,171.45) v3(519.43,166.37) v3(519.43,161.29) v3(519.43,156.21) v3(519.43,140.97) v3(519.43,135.89) v3(519.43,130.81) v3(519.87,145.26) v3(521.97,300.99) v3(521.97,295.91) v3(521.97,290.83) v3(521.97,285.75) v3(521.97,280.67) v3(521.97,275.59) v3(521.97,270.51) v3(521.97,265.43) v3(521.97,260.35) v3(521.97,255.27) v3(521.97,250.19) v3(521.97,245.11) v3(521.97,240.03) v3(521.97,234.95) v3(521.97,229.87) v3(521.97,224.79) v3(521.97,219.71) v3(521.97,214.63) v3(521.97,209.55) v3(521.97,204.47) v3(521.97,199.39) v3(521.97,194.31) v3(521.97,189.23) v3(521.97,184.15) v3(521.97,179.07) v3(521.97,173.99) v3(521.97,168.91) v3(521.97,163.83) v3(521.97,158.75) v3(521.97,143.51) v3(521.97,138.43) v3(521.97,133.35) v3(521.97,128.27) v3(524.01,152.12) v3(524.51,298.45) v3(524.51,293.37) v3(524.51,288.29) v3(524.51,283.21) v3(524.51,278.13) v3(524.51,273.05) v3(524.51,267.97) v3(524.51,262.89) v3(524.51,257.81) v3(524.51,252.73) v3(524.51,247.65) v3(524.51,242.57) v3(524.51,237.49) v3(524.51,232.41) v3(524.51,227.33) v3(524.51,222.25) v3(524.51,217.17) v3(524.51,212.09) v3(524.51,207.01) v3(524.51,201.93) v3(524.51,196.85) v3(524.51,191.77) v3(524.51,186.69) v3(524.51,181.61) v3(524.51,176.53) v3(524.51,171.45) v3(524.51,166.37) v3(524.51,161.29) v3(524.51,156.21) v3(524.51,140.97) v3(524.51,135.89) v3(524.51,130.81) v3(524.51,122.76) v3(524.51,121.99) v3(524.51,121.23) v3(524.51,118.56) v3(524.51,117.8) v3(524.51,117.04) v3(524.51,114.37) v3(524.51,113.61) v3(524.51,112.85) v3(524.51,110.18) v3(524.51,109.42) v3(524.51,108.66) v3(525.28,320.6) v3(525.28,319.84) v3(525.28,319.08) v3(525.28,316.41) v3(525.28,315.65) v3(525.28,314.89) v3(525.28,312.22) v3(525.28,311.46) v3(525.28,310.7) v3(525.28,308.03) v3(525.28,307.27) v3(525.28,306.5) v3(526.26,151.95) v3(527.05,300.99) v3(527.05,295.91) v3(527.05,290.83) v3(527.05,285.75) v3(527.05,280.67) v3(527.05,275.59) v3(527.05,270.51) v3(527.05,265.43) v3(527.05,260.35) v3(527.05,255.27) v3(527.05,250.19) v3(527.05,245.11) v3(527.05,240.03) v3(527.05,234.95) v3(527.05,229.87) v3(527.05,224.79) v3(527.05,219.71) v3(527.05,214.63) v3(527.05,209.55) v3(527.05,204.47) v3(527.05,199.39) v3(527.05,194.31) v3(527.05,189.23) v3(527.05,184.15) v3(527.05,179.07) v3(527.05,173.99) v3(527.05,168.91) v3(527.05,163.83) v3(527.05,158.75) v3(527.05,153.67) v3(527.05,143.51) v3(527.05,138.43) v3(527.05,133.35) v3(527.05,128.27) v3(528.82,122.76) v3(528.82,121.99) v3(528.82,121.23) v3(528.82,118.56) v3(528.82,117.8) v3(528.82,117.04) v3(528.82,114.37) v3(528.82,113.61) v3(528.82,112.85) v3(528.82,110.18) v3(528.82,109.42) v3(528.82,108.66) v3(529.59,320.6) v3(529.59,319.84) v3(529.59,319.08) v3(529.59,316.41) v3(529.59,315.65) v3(529.59,314.89) v3(529.59,312.22) v3(529.59,311.46) v3(529.59,310.7) v3(529.59,308.03) v3(529.59,307.27) v3(529.59,306.5) v3(529.59,298.45) v3(529.59,293.37) v3(529.59,288.29) v3(529.59,283.21) v3(529.59,278.13) v3(529.59,273.05) v3(529.59,267.97) v3(529.59,262.89) v3(529.59,257.81) v3(529.59,252.73) v3(529.59,247.65) v3(529.59,242.57) v3(529.59,237.49) v3(529.59,232.41) v3(529.59,227.33) v3(529.59,222.25) v3(529.59,217.17) v3(529.59,212.09) v3(529.59,207.01) v3(529.59,201.93) v3(529.59,196.85) v3(529.59,191.77) v3(529.59,186.69) v3(529.59,181.61) v3(529.59,176.53) v3(529.59,171.45) v3(529.59,166.37) v3(529.59,161.29) v3(529.59,156.21) v3(529.59,151.13) v3(529.59,146.05) v3(529.59,140.97) v3(529.59,135.89) v3(529.59,130.81) v3(532.13,300.99) v3(532.13,295.91) v3(532.13,290.83) v3(532.13,285.75) v3(532.13,280.67) v3(532.13,275.59) v3(532.13,270.51) v3(532.13,265.43) v3(532.13,260.35) v3(532.13,255.27) v3(532.13,250.19) v3(532.13,245.11) v3(532.13,240.03) v3(532.13,234.95) v3(532.13,229.87) v3(532.13,224.79) v3(532.13,219.71) v3(532.13,214.63) v3(532.13,209.55) v3(532.13,204.47) v3(532.13,199.39) v3(532.13,194.31) v3(532.13,189.23) v3(532.13,184.15) v3(532.13,179.07) v3(532.13,173.99) v3(532.13,168.91) v3(532.13,163.83) v3(532.13,158.75) v3(532.13,153.67) v3(532.13,148.59) v3(532.13,143.51) v3(532.13,138.43) v3(532.13,133.35) v3(532.13,128.27) v3(533.14,122.76) v3(533.14,121.99) v3(533.14,121.23) v3(533.14,118.56) v3(533.14,117.8) v3(533.14,117.04) v3(533.14,114.37) v3(533.14,113.61) v3(533.14,112.85) v3(533.14,110.18) v3(533.14,109.42) v3(533.14,108.66) v3(533.91,320.6) v3(533.91,319.84) v3(533.91,319.08) v3(533.91,316.41) v3(533.91,315.65) v3(533.91,314.89) v3(533.91,312.22) v3(533.91,311.46) v3(533.91,310.7) v3(533.91,308.03) v3(533.91,307.27) v3(533.91,306.5) v3(534.67,298.45) v3(534.67,293.37) v3(534.67,288.29) v3(534.67,283.21) v3(534.67,278.13) v3(534.67,273.05) v3(534.67,267.97) v3(534.67,262.89) v3(534.67,257.81) v3(534.67,252.73) v3(534.67,247.65) v3(534.67,242.57) v3(534.67,227.33) v3(534.67,217.17) v3(534.67,212.09) v3(534.67,201.93) v3(534.67,196.85) v3(534.67,191.77) v3(534.67,186.69) v3(534.67,181.61) v3(534.67,176.53) v3(534.67,171.45) v3(534.67,166.37) v3(534.67,161.29) v3(534.67,156.21) v3(534.67,151.13) v3(534.67,146.05) v3(534.67,140.97) v3(534.67,135.89) v3(534.67,130.81) v3(537.21,300.99) v3(537.21,295.91) v3(537.21,290.83) v3(537.21,285.75) v3(537.21,280.67) v3(537.21,275.59) v3(537.21,270.51) v3(537.21,265.43) v3(537.21,260.35) v3(537.21,255.27) v3(537.21,250.19) v3(537.21,245.11) v3(537.21,240.03) v3(537.21,229.87) v3(537.21,214.63) v3(537.21,199.39) v3(537.21,189.23) v3(537.21,184.15) v3(537.21,179.07) v3(537.21,173.99) v3(537.21,168.91) v3(537.21,163.83) v3(537.21,158.75) v3(537.21,153.67) v3(537.21,148.59) v3(537.21,143.51) v3(537.21,138.43) v3(537.21,133.35) v3(537.21,128.27) v3(537.46,122.76) v3(537.46,121.99) v3(537.46,121.23) v3(537.46,118.56) v3(537.46,117.8) v3(537.46,117.04) v3(537.46,114.37) v3(537.46,113.61) v3(537.46,112.85) v3(537.46,110.18) v3(537.46,109.42) v3(537.46,108.66) v3(538.13,194.04) v3(538.13,192.65) v3(538.23,320.6) v3(538.23,319.84) v3(538.23,319.08) v3(538.23,316.41) v3(538.23,315.65) v3(538.23,314.89) v3(538.23,312.22) v3(538.23,311.46) v3(538.23,310.7) v3(538.23,308.03) v3(538.23,307.27) v3(538.23,306.5) v3(539.75,298.45) v3(539.75,293.37) v3(539.75,288.29) v3(539.75,283.21) v3(539.75,278.13) v3(539.75,273.05) v3(539.75,267.97) v3(539.75,262.89) v3(539.75,257.81) v3(539.75,252.73) v3(539.75,247.65) v3(539.75,242.57) v3(539.75,217.17) v3(539.75,201.93) v3(539.75,186.69) v3(539.75,181.61) v3(539.75,176.53) v3(539.75,171.45) v3(539.75,166.37) v3(539.75,161.29) v3(539.75,156.21) v3(539.75,140.97) v3(539.75,135.89) v3(539.75,130.81) v3(540.55,214.03) v3(540.55,199.94) v3(540.94,240.32) v3(540.94,227.37) v3(541.78,122.76) v3(541.78,121.99) v3(541.78,121.23) v3(541.78,118.56) v3(541.78,117.8) v3(541.78,117.04) v3(541.78,114.37) v3(541.78,113.61) v3(541.78,112.85) v3(541.78,110.18) v3(541.78,109.42) v3(541.78,108.66) v3(541.82,214.03) v3(541.82,199.94) v3(542.2,240.32) v3(542.2,227.37) v3(542.29,300.99) v3(542.29,295.91) v3(542.29,290.83) v3(542.29,285.75) v3(542.29,280.67) v3(542.29,275.59) v3(542.29,270.51) v3(542.29,265.43) v3(542.29,260.35) v3(542.29,255.27) v3(542.29,250.19) v3(542.29,245.11) v3(542.29,229.87) v3(542.29,189.23) v3(542.29,184.15) v3(542.29,179.07) v3(542.29,173.99) v3(542.29,158.75) v3(542.29,143.51) v3(542.29,138.43) v3(542.29,133.35) v3(542.29,128.27) v3(542.55,320.6) v3(542.55,319.84) v3(542.55,319.08) v3(542.55,316.41) v3(542.55,315.65) v3(542.55,314.89) v3(542.55,312.22) v3(542.55,311.46) v3(542.55,310.7) v3(542.55,308.03) v3(542.55,307.27) v3(542.55,306.5) v3(544.83,298.45) v3(544.83,293.37) v3(544.83,288.29) v3(544.83,283.21) v3(544.83,278.13) v3(544.83,273.05) v3(544.83,267.97) v3(544.83,262.89) v3(544.83,257.81) v3(544.83,252.73) v3(544.83,247.65) v3(544.83,242.57) v3(544.83,217.17) v3(544.83,201.93) v3(544.83,186.69) v3(544.83,181.61) v3(544.83,176.53) v3(544.83,140.97) v3(544.83,135.89) v3(544.83,130.81) v3(544.93,194.54) v3(544.93,193.15) v3(546.1,122.76) v3(546.1,121.99) v3(546.1,121.23) v3(546.1,118.56) v3(546.1,117.8) v3(546.1,117.04) v3(546.1,114.37) v3(546.1,113.61) v3(546.1,112.85) v3(546.1,110.18) v3(546.1,109.42) v3(546.1,108.66) v3(546.2,197.34) v3(546.2,195.94) v3(546.2,194.54) v3(546.2,193.15) v3(546.87,320.6) v3(546.87,319.84) v3(546.87,319.08) v3(546.87,316.41) v3(546.87,315.65) v3(546.87,314.89) v3(546.87,312.22) v3(546.87,311.46) v3(546.87,310.7) v3(546.87,308.03) v3(546.87,307.27) v3(546.87,306.5) v3(547.37,300.99) v3(547.37,295.91) v3(547.37,290.83) v3(547.37,285.75) v3(547.37,280.67) v3(547.37,275.59) v3(547.37,270.51) v3(547.37,265.43) v3(547.37,260.35) v3(547.37,255.27) v3(547.37,250.19) v3(547.37,245.11) v3(547.37,240.03) v3(547.37,229.87) v3(547.37,214.63) v3(547.37,204.47) v3(547.37,189.23) v3(547.37,184.15) v3(547.37,179.07) v3(547.37,173.99) v3(547.37,158.75) v3(547.37,138.43) v3(547.37,133.35) v3(547.37,128.27) v3(549.91,298.45) v3(549.91,293.37) v3(549.91,288.29) v3(549.91,283.21) v3(549.91,278.13) v3(549.91,273.05) v3(549.91,267.97) v3(549.91,262.89) v3(549.91,257.81) v3(549.91,252.73) v3(549.91,247.65) v3(549.91,242.57) v3(549.91,237.49) v3(549.91,232.41) v3(549.91,227.33) v3(549.91,222.25) v3(549.91,217.17) v3(549.91,212.09) v3(549.91,207.01) v3(549.91,201.93) v3(549.91,196.85) v3(549.91,191.77) v3(549.91,186.69) v3(549.91,181.61) v3(549.91,176.53) v3(549.91,140.97) v3(549.91,135.89) v3(549.91,130.81) v3(550.41,122.76) v3(550.41,121.99) v3(550.41,121.23) v3(550.41,118.56) v3(550.41,117.8) v3(550.41,117.04) v3(550.41,114.37) v3(550.41,113.61) v3(550.41,112.85) v3(550.41,110.18) v3(550.41,109.42) v3(550.41,108.66) v3(551.18,320.6) v3(551.18,319.84) v3(551.18,319.08) v3(551.18,316.41) v3(551.18,315.65) v3(551.18,314.89) v3(551.18,312.22) v3(551.18,311.46) v3(551.18,310.7) v3(551.18,308.03) v3(551.18,307.27) v3(551.18,306.5) v3(552.45,300.99) v3(552.45,295.91) v3(552.45,290.83) v3(552.45,285.75) v3(552.45,280.67) v3(552.45,275.59) v3(552.45,270.51) v3(552.45,265.43) v3(552.45,260.35) v3(552.45,255.27) v3(552.45,250.19) v3(552.45,245.11) v3(552.45,240.03) v3(552.45,234.95) v3(552.45,229.87) v3(552.45,224.79) v3(552.45,219.71) v3(552.45,214.63) v3(552.45,209.55) v3(552.45,204.47) v3(552.45,199.39) v3(552.45,194.31) v3(552.45,189.23) v3(552.45,184.15) v3(552.45,179.07) v3(552.45,173.99) v3(552.45,158.75) v3(552.45,143.51) v3(552.45,138.43) v3(552.45,133.35) v3(552.45,128.27) v3(553.99,298.45) v3(553.99,130.81) v3(554.73,122.76) v3(554.73,121.99) v3(554.73,121.23) v3(554.73,118.56) v3(554.73,117.8) v3(554.73,117.04) v3(554.73,114.37) v3(554.73,113.61) v3(554.73,112.85) v3(554.73,110.18) v3(554.73,109.42) v3(554.73,108.66) v3(554.99,293.37) v3(554.99,288.29) v3(554.99,283.21) v3(554.99,278.13) v3(554.99,273.05) v3(554.99,267.97) v3(554.99,262.89) v3(554.99,257.81) v3(554.99,252.73) v3(554.99,247.65) v3(554.99,242.57) v3(554.99,237.49) v3(554.99,232.41) v3(554.99,227.33) v3(554.99,222.25) v3(554.99,217.17) v3(554.99,212.09) v3(554.99,207.01) v3(554.99,201.93) v3(554.99,196.85) v3(554.99,191.77) v3(554.99,186.69) v3(554.99,181.61) v3(554.99,176.53) v3(554.99,171.45) v3(554.99,166.37) v3(554.99,161.29) v3(554.99,156.21) v3(554.99,151.13) v3(554.99,146.05) v3(554.99,140.97) v3(554.99,135.89) v3(555.5,320.6) v3(555.5,319.84) v3(555.5,319.08) v3(555.5,316.41) v3(555.5,315.65) v3(555.5,314.89) v3(555.5,312.22) v3(555.5,311.46) v3(555.5,310.7) v3(555.5,308.03) v3(555.5,307.27) v3(555.5,306.5) v3(557.53,300.99) v3(557.53,290.83) v3(557.53,285.75) v3(557.53,280.67) v3(557.53,275.59) v3(557.53,270.51) v3(557.53,265.43) v3(557.53,260.35) v3(557.53,255.27) v3(557.53,250.19) v3(557.53,245.11) v3(557.53,240.03) v3(557.53,234.95) v3(557.53,229.87) v3(557.53,224.79) v3(557.53,219.71) v3(557.53,214.63) v3(557.53,209.55) v3(557.53,204.47) v3(557.53,199.39) v3(557.53,194.31) v3(557.53,189.23) v3(557.53,184.15) v3(557.53,179.07) v3(557.53,173.99) v3(557.53,158.75) v3(557.53,143.51) v3(557.53,138.43) v3(557.53,128.27) v3(559.05,122.76) v3(559.05,121.99) v3(559.05,121.23) v3(559.05,118.56) v3(559.05,117.8) v3(559.05,117.04) v3(559.05,114.37) v3(559.05,113.61) v3(559.05,112.85) v3(559.05,110.18) v3(559.05,109.42) v3(559.05,108.66) v3(559.82,320.6) v3(559.82,319.84) v3(559.82,319.08) v3(559.82,316.41) v3(559.82,315.65) v3(559.82,314.89) v3(559.82,312.22) v3(559.82,311.46) v3(559.82,310.7) v3(559.82,308.03) v3(559.82,307.27) v3(559.82,306.5) v3(560.07,293.37) v3(560.07,288.29) v3(560.07,283.21) v3(560.07,278.13) v3(560.07,273.05) v3(560.07,267.97) v3(560.07,262.89) v3(560.07,257.81) v3(560.07,252.73) v3(560.07,247.65) v3(560.07,242.57) v3(560.07,237.49) v3(560.07,232.41) v3(560.07,227.33) v3(560.07,222.25) v3(560.07,217.17) v3(560.07,212.09) v3(560.07,207.01) v3(560.07,201.93) v3(560.07,196.85) v3(560.07,191.77) v3(560.07,186.69) v3(560.07,181.61) v3(560.07,176.53) v3(560.07,140.97) v3(560.07,135.89) v3(562.61,300.99) v3(562.61,290.83) v3(562.61,285.75) v3(562.61,280.67) v3(562.61,275.59) v3(562.61,270.51) v3(562.61,265.43) v3(562.61,260.35) v3(562.61,255.27) v3(562.61,250.19) v3(562.61,245.11) v3(562.61,240.03) v3(562.61,234.95) v3(562.61,229.87) v3(562.61,224.79) v3(562.61,219.71) v3(562.61,214.63) v3(562.61,209.55) v3(562.61,204.47) v3(562.61,199.39) v3(562.61,194.31) v3(562.61,189.23) v3(562.61,184.15) v3(562.61,179.07) v3(562.61,158.75) v3(562.61,138.43) v3(562.61,128.27) v3(563.37,122.76) v3(563.37,121.99) v3(563.37,121.23) v3(563.37,118.56) v3(563.37,117.8) v3(563.37,117.04) v3(563.37,114.37) v3(563.37,113.61) v3(563.37,112.85) v3(563.37,110.18) v3(563.37,109.42) v3(563.37,108.66) v3(564.14,320.6) v3(564.14,319.84) v3(564.14,319.08) v3(564.14,316.41) v3(564.14,315.65) v3(564.14,314.89) v3(564.14,312.22) v3(564.14,311.46) v3(564.14,310.7) v3(564.14,308.03) v3(564.14,307.27) v3(564.14,306.5) v3(565.15,298.45) v3(565.15,293.37) v3(565.15,288.29) v3(565.15,283.21) v3(565.15,278.13) v3(565.15,273.05) v3(565.15,267.97) v3(565.15,262.89) v3(565.15,257.81) v3(565.15,252.73) v3(565.15,247.65) v3(565.15,242.57) v3(565.15,237.49) v3(565.15,232.41) v3(565.15,227.33) v3(565.15,222.25) v3(565.15,217.17) v3(565.15,212.09) v3(565.15,207.01) v3(565.15,201.93) v3(565.15,196.85) v3(565.15,191.77) v3(565.15,186.69) v3(565.15,181.61) v3(565.15,176.53) v3(565.15,156.21) v3(565.15,140.97) v3(565.15,135.89) v3(565.15,130.81) v3(567.69,290.83) v3(567.69,285.75) v3(567.69,280.67) v3(567.69,275.59) v3(567.69,270.51) v3(567.69,265.43) v3(567.69,260.35) v3(567.69,255.27) v3(567.69,250.19) v3(567.69,245.11) v3(567.69,240.03) v3(567.69,234.95) v3(567.69,229.87) v3(567.69,224.79) v3(567.69,219.71) v3(567.69,214.63) v3(567.69,209.55) v3(567.69,204.47) v3(567.69,199.39) v3(567.69,194.31) v3(567.69,189.23) v3(567.69,184.15) v3(567.69,179.07) v3(567.69,158.75) v3(567.69,138.43) v3(567.69,122.76) v3(567.69,121.99) v3(567.69,121.23) v3(567.69,118.56) v3(567.69,117.8) v3(567.69,117.04) v3(567.69,114.37) v3(567.69,113.61) v3(567.69,112.85) v3(567.69,110.18) v3(567.69,109.42) v3(567.69,108.66) v3(568.46,320.6) v3(568.46,319.84) v3(568.46,319.08) v3(568.46,316.41) v3(568.46,315.65) v3(568.46,314.89) v3(568.46,312.22) v3(568.46,311.46) v3(568.46,310.7) v3(568.46,308.03) v3(568.46,307.27) v3(568.46,306.5) v3(570.23,293.37) v3(570.23,288.29) v3(570.23,283.21) v3(570.23,278.13) v3(570.23,273.05) v3(570.23,267.97) v3(570.23,262.89) v3(570.23,257.81) v3(570.23,252.73) v3(570.23,247.65) v3(570.23,242.57) v3(570.23,237.49) v3(570.23,232.41) v3(570.23,227.33) v3(570.23,222.25) v3(570.23,217.17) v3(570.23,212.09) v3(570.23,207.01) v3(570.23,201.93) v3(570.23,196.85) v3(570.23,191.77) v3(570.23,186.69) v3(570.23,181.61) v3(570.23,176.53) v3(570.23,171.45) v3(570.23,156.21) v3(570.23,140.97) v3(570.23,135.89) v3(572,122.76) v3(572,121.99) v3(572,121.23) v3(572,118.56) v3(572,117.8) v3(572,117.04) v3(572,114.37) v3(572,113.61) v3(572,112.85) v3(572,110.18) v3(572,109.42) v3(572,108.66) v3(572.77,320.6) v3(572.77,319.84) v3(572.77,319.08) v3(572.77,316.41) v3(572.77,315.65) v3(572.77,314.89) v3(572.77,312.22) v3(572.77,311.46) v3(572.77,310.7) v3(572.77,308.03) v3(572.77,307.27) v3(572.77,306.5) v3(572.77,290.83) v3(572.77,285.75) v3(572.77,280.67) v3(572.77,275.59) v3(572.77,270.51) v3(572.77,265.43) v3(572.77,260.35) v3(572.77,255.27) v3(572.77,250.19) v3(572.77,245.11) v3(572.77,240.03) v3(572.77,234.95) v3(572.77,229.87) v3(572.77,224.79) v3(572.77,204.47) v3(572.77,199.39) v3(572.77,194.31) v3(572.77,189.23) v3(572.77,184.15) v3(572.77,179.07) v3(572.77,173.99) v3(572.77,168.91) v3(572.77,163.83) v3(572.77,158.75) v3(572.77,153.67) v3(572.77,148.59) v3(572.77,143.51) v3(572.77,138.43)
