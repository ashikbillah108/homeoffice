# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Nets (continued)
S6_AWG_2SHARE-: UNK6K107.5 UNK6U451.2
S6_AWG_3SHARE+: K110.4 UNK6K107.3
S6_AWG_3SHARE-: K110.5 UNK6K107.6
S6_DVDD_DDR_RX: SITE6.R4(DVDD_DDR_RX) UNK6CC133.1 UNK6K39.3
S6_DVDD_DDR_TX: SITE6.R5(DVDD_DDR_TX) UNK6CC134.1 UNK6K39.6
S6_ETH_RN_AB_CASE: SITE6.H16(PAD_ETH_RN) UNK6U451.7
S6_ETH_RP_AB_CASE: SITE6.H15(PAD_ETH_RP) UNK6U451.8
S6_ETH_TN_AB_CASE: SITE6.G15(PAD_ETH_TN) UNK6U450.7
S6_ETH_TP_AB_CASE: SITE6.G14(PAD_ETH_TP) UNK6U450.8
S6_M_2V5: UNK6C284.1 UNK6C285.1 UNK6MR2.1 UNK6MU2.6
S6_M_3V2: UNK6C282.1 UNK6C283.1 UNK6C289.1 UNK6MR1.1 UNK6MU1.5 UNK6MU2.2 UNK6MU3.7
S6_MUX_3V3: UNK6BD21.1 UNK6BD1728.1 UNK6BD1729.1 UNK6BDB5.1 UNK6BDB6.1 UNK6R512.1
S6_OUT_RX0_CH0_ABC_CASE+: SITE6.A3(PAD_OUTP_RX0_CH[0]) UNK6U408.B2
S6_OUT_RX0_CH0_ABC_CASE-: SITE6.C4(PAD_OUTN_RX0_CH[0]) UNK6U408.B1
S6_OUT_RX0_CH0_B_CASE+: UNK6R647.1 UNK6U408.B4
S6_OUT_RX0_CH0_B_CASE-: UNK6R646.1 UNK6U408.A4
S6_OUT_RX0_CH0_C_CASE: UNK6C309.1 UNK6R646.2 UNK6R647.2
S6_OUT_RX0_CH1_ABC_CASE+: SITE6.A2(PAD_OUTP_RX0_CH[1]) UNK6U408.D2
S6_OUT_RX0_CH1_ABC_CASE-: SITE6.B3(PAD_OUTN_RX0_CH[1]) UNK6U408.D1
S6_OUT_RX0_CH1_B_CASE+: UNK6R168.1 UNK6U408.B5
S6_OUT_RX0_CH1_B_CASE-: UNK6R170.1 UNK6U408.A5
S6_OUT_RX0_CH1_C_CASE: UNK6C310.1 UNK6R168.2 UNK6R170.2
S6_OUT_RX0_CH2_ABC_CASE+: SITE6.B2(PAD_OUTP_RX0_CH[2]) UNK6U408.E2
S6_OUT_RX0_CH2_ABC_CASE-: SITE6.C3(PAD_OUTN_RX0_CH[2]) UNK6U408.E1
S6_OUT_RX0_CH2_B_CASE+: UNK6R176.1 UNK6U408.B6
S6_OUT_RX0_CH2_B_CASE-: UNK6R178.1 UNK6U408.A6
S6_OUT_RX0_CH2_C_CASE: UNK6C318.1 UNK6R176.2 UNK6R178.2
S6_OUT_RX0_CH3_ABC_CASE+: SITE6.C2(PAD_OUTP_RX0_CH[3]) UNK6U409.B2
S6_OUT_RX0_CH3_ABC_CASE-: SITE6.B1(PAD_OUTN_RX0_CH[3]) UNK6U409.B1
S6_OUT_RX0_CH3_B_CASE+: UNK6R1089.1 UNK6U409.B4
S6_OUT_RX0_CH3_B_CASE-: UNK6R1088.1 UNK6U409.A4
S6_OUT_RX0_CH3_C_CASE: UNK6C302.1 UNK6R1088.2 UNK6R1089.2
S6_OUT_RX0_CH4_ABC_CASE+: SITE6.D2(PAD_OUTP_RX0_CH[4]) UNK6U409.D2
S6_OUT_RX0_CH4_ABC_CASE-: SITE6.C1(PAD_OUTN_RX0_CH[4]) UNK6U409.D1
S6_OUT_RX0_CH4_B_CASE+: UNK6R180.1 UNK6U409.B5
S6_OUT_RX0_CH4_B_CASE-: UNK6R182.1 UNK6U409.A5
S6_OUT_RX0_CH4_C_CASE: UNK6C320.1 UNK6R180.2 UNK6R182.2
S6_OUT_RX0_CH5_ABC_CASE+: SITE6.D3(PAD_OUTP_RX0_CH[5]) UNK6U409.E2
S6_OUT_RX0_CH5_ABC_CASE-: SITE6.D1(PAD_OUTN_RX0_CH[5]) UNK6U409.E1
S6_OUT_RX0_CH5_B_CASE+: UNK6R666.1 UNK6U409.B6
S6_OUT_RX0_CH5_B_CASE-: UNK6R664.1 UNK6U409.A6
S6_OUT_RX0_CH5_C_CASE: UNK6C924.1 UNK6R664.2 UNK6R666.2
S6_PAD_SZQ: SITE6.T11(PAD_SZQ) UNK6K113.5
S6_PM_SAR0: S6_VREF_OUT.1(TP) SITE6.B12(PAD_PM_SAR0) UNK6K34.3 UNK6MK3.4
S6_SPI_CK_ABCD_CASE: SITE6.N15(PAD_SPI0_CK) UNK6K2.6
S6_SPI_CK_B_CASE: UNK6K2.5 UNK6K3.6
S6_SPI_CK_C_CASE: UNK6K3.7 UNK6U18.6
S6_SPI_CK_D_CASE: UNK6K3.5 UNK6U19.6
S6_SPI_CZ_ABCD_CASE: SITE6.N14(PAD_SPI0_CZ) UNK6K2.3
S6_SPI_CZ_B_CASE: UNK6K2.4 UNK6K3.3
S6_SPI_CZ_C_CASE: UNK6K3.2 UNK6R200.2 UNK6U18.1
S6_SPI_CZ_D_CASE: UNK6K3.4 UNK6R205.2 UNK6U19.1
S6_SPI_DI_ABCD_CASE: SITE6.P16(PAD_SPI0_DI) UNK6K4.6
S6_SPI_DI_B_CASE: UNK6K4.5 UNK6K5.6
S6_SPI_DI_C_CASE: UNK6K5.7 UNK6U18.5
S6_SPI_DI_D_CASE: UNK6K5.5 UNK6U19.5
S6_SPI_DO_ABCD_CASE: SITE6.P15(PAD_SPI0_DO) UNK6K4.3
S6_SPI_DO_B_CASE: UNK6K4.4 UNK6K5.3
S6_SPI_DO_C_CASE: UNK6K5.2 UNK6U18.2
S6_SPI_DO_D_CASE: UNK6K5.4 UNK6U19.2
S6_SPI_HLD_ABCD_CASE: SITE6.M15(PAD_SPI0_HLD) UNK6K6.3
S6_SPI_HLD_B_CASE: UNK6K6.4 UNK6K7.3
S6_SPI_HLD_C_CASE: UNK6K7.2 UNK6R202.1 UNK6U18.7
S6_SPI_HLD_D_CASE: UNK6K7.4 UNK6R206.1 UNK6U19.7
S6_SPI_WPZ_ABCD_CASE: SITE6.M16(PAD_SPI0_WPZ) UNK6K6.6
S6_SPI_WPZ_B_CASE: UNK6K6.5 UNK6K7.6
S6_SPI_WPZ_C_CASE: UNK6K7.7 UNK6R203.2 UNK6U18.3
S6_SPI_WPZ_D_CASE: UNK6K7.5 UNK6R207.2 UNK6U19.3
S6_USB2_SEL0: UNK6R164.2 UNK6U31.6
S6_USB2_SEL1: UNK6R163.2 UNK6U31.5
S6_USB2_SELS: UNK6R165.2 UNK6U31.16
S6_USB_D_AB_CASE+: SITE6.F1(PAD_USB_DP) UNK6U31.10
S6_USB_D_AB_CASE-: SITE6.F2(PAD_USB_DM) UNK6U31.9
S6_USB_D_B_CASE+: UNK6R160.2 UNK6U31.8
S6_USB_D_B_CASE-: UNK6R161.2 UNK6U31.7
S6_USER_3V3: S6_USER_3V3.1 UNK6C334.1 UNK6C335.1 UNK6C336.2 UNK6C337.2 UNK6C338.2 UNK6C339.2 UNK6R200.1 UNK6R201.2 UNK6R202.2 UNK6R203.1 UNK6R204.2 UNK6R205.1 UNK6R206.2 UNK6R207.1 UNK6U17.3
S6_XTAL_24M_IN_ABC_CASE: SITE6.K15(PAD_XTAL_24M_IN) UNK6K32.3
S6_XTAL_24M_IN_B_CASE: UNK6K32.4 UNK6R135.1
S6_XTAL_24M_IN_C_CASE: UNK6C267.1 UNK6R135.2 UNK6R136.2 UNK6Y1.3
S6_XTAL_24M_OUT_ABC_CASE: SITE6.K16(PAD_XTAL_24M_OUT) UNK6K32.6
S6_XTAL_24M_OUT_B_CASE: UNK6K32.5 UNK6R137.1
S6_XTAL_24M_OUT_C_CASE: UNK6C268.1 UNK6R136.1 UNK6R137.2 UNK6Y1.1
S6_XTAL_IN_32K_A_CASE: UNK6K29.7 UNK6U449.7
S6_XTAL_IN_32K_ABCD_CASE: SITE6.B6(PAD_XTAL_IN_32K) UNK6K29.6
S6_XTAL_IN_32K_B_CASE: UNK6C271.1 UNK6K29.5 UNK6Y2.1
S6_XTAL_IN_32K_D_CASE: UNK6R923.1 UNK6R973.2 UNK6U449.2
S6_XTAL_OUT_32K_A_CASE: UNK6K29.2 UNK6U449.8
S6_XTAL_OUT_32K_ABCD_CASE: SITE6.A6(PAD_XTAL_OUT_32K) UNK6K29.3
S6_XTAL_OUT_32K_B_CASE: UNK6C272.1 UNK6K29.4 UNK6Y2.2
S6_XTAL_OUT_32K_D_CASE: UNK6R652.1 UNK6R973.1 UNK6U449.1
S7_0V5: UNK7C286.1 UNK7C288.1 UNK7MK1.4 UNK7MR2.2 UNK7MR3.1 UNK7MR4.1 UNK7MR5.1 UNK7MR6.1 UNK7MU3.3
S7_0V25: UNK7MK4.3 UNK7MR18.2 UNK7MR19.1
S7_0V75: UNK7C290.1 UNK7MK2.4 UNK7MR10.2 UNK7MU3.6
S7_1AWG_SHARE+: UNK7K34.4 UNK7K107.2
S7_3V3_ETH_MUX: UNK7BD1729.2 UNK7C1077.1 UNK7C1080.1 UNK7C1081.1 UNK7R984.1 UNK7R987.1 UNK7R990.1 UNK7U450.10 UNK7U451.10 UNK7U452.10
S7_3V3_RX0_MIPI: UNK7BDB5.2 UNK7C922.2 UNK7R661.2 UNK7U408.A2 UNK7U408.J4
S7_3V3_RX1_MIPI: UNK7BDB6.2 UNK7C923.2 UNK7R663.2 UNK7U409.A2 UNK7U409.J4
S7_3V3_USB2_MUX: UNK7BD21.2 UNK7C262.1 UNK7U31.4
S7_3V3_XTAL32K: UNK7BD1728.2 UNK7C1074.1 UNK7R981.1 UNK7U449.10
S7_AWG_2SHARE+: UNK7K107.4 UNK7U451.1
S7_AWG_2SHARE-: UNK7K107.5 UNK7U451.2
S7_AWG_3SHARE+: K111.4 UNK7K107.3
S7_AWG_3SHARE-: K111.5 UNK7K107.6
S7_DVDD_DDR_RX: SITE7.R4(DVDD_DDR_RX) UNK7CC133.1 UNK7K39.3
S7_DVDD_DDR_TX: SITE7.R5(DVDD_DDR_TX) UNK7CC134.1 UNK7K39.6
S7_ETH_RN_AB_CASE: SITE7.H16(PAD_ETH_RN) UNK7U451.7
S7_ETH_RP_AB_CASE: SITE7.H15(PAD_ETH_RP) UNK7U451.8
S7_ETH_TN_AB_CASE: SITE7.G15(PAD_ETH_TN) UNK7U450.7
S7_ETH_TP_AB_CASE: SITE7.G14(PAD_ETH_TP) UNK7U450.8
S7_M_2V5: UNK7C284.1 UNK7C285.1 UNK7MR2.1 UNK7MU2.6
S7_M_3V2: UNK7C282.1 UNK7C283.1 UNK7C289.1 UNK7MR1.1 UNK7MU1.5 UNK7MU2.2 UNK7MU3.7
S7_MUX_3V3: UNK7BD21.1 UNK7BD1728.1 UNK7BD1729.1 UNK7BDB5.1 UNK7BDB6.1 UNK7R512.1
S7_OUT_RX0_CH0_ABC_CASE+: SITE7.A3(PAD_OUTP_RX0_CH[0]) UNK7U408.B2
S7_OUT_RX0_CH0_ABC_CASE-: SITE7.C4(PAD_OUTN_RX0_CH[0]) UNK7U408.B1
S7_OUT_RX0_CH0_B_CASE+: UNK7R647.1 UNK7U408.B4
S7_OUT_RX0_CH0_B_CASE-: UNK7R646.1 UNK7U408.A4
S7_OUT_RX0_CH0_C_CASE: UNK7C309.1 UNK7R646.2 UNK7R647.2
S7_OUT_RX0_CH1_ABC_CASE+: SITE7.A2(PAD_OUTP_RX0_CH[1]) UNK7U408.D2
S7_OUT_RX0_CH1_ABC_CASE-: SITE7.B3(PAD_OUTN_RX0_CH[1]) UNK7U408.D1
S7_OUT_RX0_CH1_B_CASE+: UNK7R168.1 UNK7U408.B5
S7_OUT_RX0_CH1_B_CASE-: UNK7R170.1 UNK7U408.A5
S7_OUT_RX0_CH1_C_CASE: UNK7C310.1 UNK7R168.2 UNK7R170.2
S7_OUT_RX0_CH2_ABC_CASE+: SITE7.B2(PAD_OUTP_RX0_CH[2]) UNK7U408.E2
S7_OUT_RX0_CH2_ABC_CASE-: SITE7.C3(PAD_OUTN_RX0_CH[2]) UNK7U408.E1
S7_OUT_RX0_CH2_B_CASE+: UNK7R176.1 UNK7U408.B6
S7_OUT_RX0_CH2_B_CASE-: UNK7R178.1 UNK7U408.A6
S7_OUT_RX0_CH2_C_CASE: UNK7C318.1 UNK7R176.2 UNK7R178.2
S7_OUT_RX0_CH3_ABC_CASE+: SITE7.C2(PAD_OUTP_RX0_CH[3]) UNK7U409.B2
S7_OUT_RX0_CH3_ABC_CASE-: SITE7.B1(PAD_OUTN_RX0_CH[3]) UNK7U409.B1
S7_OUT_RX0_CH3_B_CASE+: UNK7R1089.1 UNK7U409.B4
S7_OUT_RX0_CH3_B_CASE-: UNK7R1088.1 UNK7U409.A4
S7_OUT_RX0_CH3_C_CASE: UNK7C302.1 UNK7R1088.2 UNK7R1089.2
S7_OUT_RX0_CH4_ABC_CASE+: SITE7.D2(PAD_OUTP_RX0_CH[4]) UNK7U409.D2
S7_OUT_RX0_CH4_ABC_CASE-: SITE7.C1(PAD_OUTN_RX0_CH[4]) UNK7U409.D1
S7_OUT_RX0_CH4_B_CASE+: UNK7R180.1 UNK7U409.B5
S7_OUT_RX0_CH4_B_CASE-: UNK7R182.1 UNK7U409.A5
S7_OUT_RX0_CH4_C_CASE: UNK7C320.1 UNK7R180.2 UNK7R182.2
S7_OUT_RX0_CH5_ABC_CASE+: SITE7.D3(PAD_OUTP_RX0_CH[5]) UNK7U409.E2
S7_OUT_RX0_CH5_ABC_CASE-: SITE7.D1(PAD_OUTN_RX0_CH[5]) UNK7U409.E1
S7_OUT_RX0_CH5_B_CASE+: UNK7R666.1 UNK7U409.B6
S7_OUT_RX0_CH5_B_CASE-: UNK7R664.1 UNK7U409.A6
S7_OUT_RX0_CH5_C_CASE: UNK7C924.1 UNK7R664.2 UNK7R666.2
S7_PAD_SZQ: SITE7.T11(PAD_SZQ) UNK7K113.5
S7_PM_SAR0: S7_VREF_OUT.1(TP) SITE7.B12(PAD_PM_SAR0) UNK7K34.3 UNK7MK3.4
S7_SPI_CK_ABCD_CASE: SITE7.N15(PAD_SPI0_CK) UNK7K2.6
S7_SPI_CK_B_CASE: UNK7K2.5 UNK7K3.6
S7_SPI_CK_C_CASE: UNK7K3.7 UNK7U18.6
S7_SPI_CK_D_CASE: UNK7K3.5 UNK7U19.6
S7_SPI_CZ_ABCD_CASE: SITE7.N14(PAD_SPI0_CZ) UNK7K2.3
S7_SPI_CZ_B_CASE: UNK7K2.4 UNK7K3.3
S7_SPI_CZ_C_CASE: UNK7K3.2 UNK7R200.2 UNK7U18.1
S7_SPI_CZ_D_CASE: UNK7K3.4 UNK7R205.2 UNK7U19.1
S7_SPI_DI_ABCD_CASE: SITE7.P16(PAD_SPI0_DI) UNK7K4.6
S7_SPI_DI_B_CASE: UNK7K4.5 UNK7K5.6
S7_SPI_DI_C_CASE: UNK7K5.7 UNK7U18.5
S7_SPI_DI_D_CASE: UNK7K5.5 UNK7U19.5
S7_SPI_DO_ABCD_CASE: SITE7.P15(PAD_SPI0_DO) UNK7K4.3
S7_SPI_DO_B_CASE: UNK7K4.4 UNK7K5.3
S7_SPI_DO_C_CASE: UNK7K5.2 UNK7U18.2
S7_SPI_DO_D_CASE: UNK7K5.4 UNK7U19.2
S7_SPI_HLD_ABCD_CASE: SITE7.M15(PAD_SPI0_HLD) UNK7K6.3
S7_SPI_HLD_B_CASE: UNK7K6.4 UNK7K7.3
S7_SPI_HLD_C_CASE: UNK7K7.2 UNK7R202.1 UNK7U18.7
S7_SPI_HLD_D_CASE: UNK7K7.4 UNK7R206.1 UNK7U19.7
S7_SPI_WPZ_ABCD_CASE: SITE7.M16(PAD_SPI0_WPZ) UNK7K6.6
S7_SPI_WPZ_B_CASE: UNK7K6.5 UNK7K7.6
S7_SPI_WPZ_C_CASE: UNK7K7.7 UNK7R203.2 UNK7U18.3
S7_SPI_WPZ_D_CASE: UNK7K7.5 UNK7R207.2 UNK7U19.3
S7_USB2_SEL0: UNK7R164.2 UNK7U31.6
S7_USB2_SEL1: UNK7R163.2 UNK7U31.5
S7_USB2_SELS: UNK7R165.2 UNK7U31.16
S7_USB_D_AB_CASE+: SITE7.F1(PAD_USB_DP) UNK7U31.10
S7_USB_D_AB_CASE-: SITE7.F2(PAD_USB_DM) UNK7U31.9
S7_USB_D_B_CASE+: UNK7R160.2 UNK7U31.8
S7_USB_D_B_CASE-: UNK7R161.2 UNK7U31.7
S7_USER_3V3: S7_USER_3V3.1 UNK7C334.1 UNK7C335.1 UNK7C336.2 UNK7C337.2 UNK7C338.2 UNK7C339.2 UNK7R200.1 UNK7R201.2 UNK7R202.2 UNK7R203.1 UNK7R204.2 UNK7R205.1 UNK7R206.2 UNK7R207.1 UNK7U17.3
S7_XTAL_24M_IN_ABC_CASE: SITE7.K15(PAD_XTAL_24M_IN) UNK7K32.3
S7_XTAL_24M_IN_B_CASE: UNK7K32.4 UNK7R135.1
S7_XTAL_24M_IN_C_CASE: UNK7C267.1 UNK7R135.2 UNK7R136.2 UNK7Y1.3
S7_XTAL_24M_OUT_ABC_CASE: SITE7.K16(PAD_XTAL_24M_OUT) UNK7K32.6
S7_XTAL_24M_OUT_B_CASE: UNK7K32.5 UNK7R137.1
S7_XTAL_24M_OUT_C_CASE: UNK7C268.1 UNK7R136.1 UNK7R137.2 UNK7Y1.1
S7_XTAL_IN_32K_A_CASE: UNK7K29.7 UNK7U449.7
S7_XTAL_IN_32K_ABCD_CASE: SITE7.B6(PAD_XTAL_IN_32K) UNK7K29.6
S7_XTAL_IN_32K_B_CASE: UNK7C271.1 UNK7K29.5 UNK7Y2.1
S7_XTAL_IN_32K_D_CASE: UNK7R923.1 UNK7R973.2 UNK7U449.2
S7_XTAL_OUT_32K_A_CASE: UNK7K29.2 UNK7U449.8
S7_XTAL_OUT_32K_ABCD_CASE: SITE7.A6(PAD_XTAL_OUT_32K) UNK7K29.3
S7_XTAL_OUT_32K_B_CASE: UNK7C272.1 UNK7K29.4 UNK7Y2.2
S7_XTAL_OUT_32K_D_CASE: UNK7R652.1 UNK7R973.1 UNK7U449.1
S8_0V5: UNK8C286.1 UNK8C288.1 UNK8MK1.4 UNK8MR2.2 UNK8MR3.1 UNK8MR4.1 UNK8MR5.1 UNK8MR6.1 UNK8MU3.3
S8_0V25: UNK8MK4.3 UNK8MR18.2 UNK8MR19.1
S8_0V75: UNK8C290.1 UNK8MK2.4 UNK8MR10.2 UNK8MU3.6
S8_1AWG_SHARE+: UNK8K34.4 UNK8K107.2
S8_3V3_ETH_MUX: UNK8BD1729.2 UNK8C1077.1 UNK8C1080.1 UNK8C1081.1 UNK8R984.1 UNK8R987.1 UNK8R990.1 UNK8U450.10 UNK8U451.10 UNK8U452.10
S8_3V3_RX0_MIPI: UNK8BDB5.2 UNK8C922.2 UNK8R661.2 UNK8U408.A2 UNK8U408.J4
S8_3V3_RX1_MIPI: UNK8BDB6.2 UNK8C923.2 UNK8R663.2 UNK8U409.A2 UNK8U409.J4
S8_3V3_USB2_MUX: UNK8BD21.2 UNK8C262.1 UNK8U31.4
S8_3V3_XTAL32K: UNK8BD1728.2 UNK8C1074.1 UNK8R981.1 UNK8U449.10
S8_AWG_2SHARE+: UNK8K107.4 UNK8U451.1
S8_AWG_2SHARE-: UNK8K107.5 UNK8U451.2
S8_AWG_3SHARE+: K112.4 UNK8K107.3
S8_AWG_3SHARE-: K112.5 UNK8K107.6
S8_DVDD_DDR_RX: SITE8.R4(DVDD_DDR_RX) UNK8CC133.1 UNK8K39.3
S8_DVDD_DDR_TX: SITE8.R5(DVDD_DDR_TX) UNK8CC134.1 UNK8K39.6
S8_ETH_RN_AB_CASE: SITE8.H16(PAD_ETH_RN) UNK8U451.7
S8_ETH_RP_AB_CASE: SITE8.H15(PAD_ETH_RP) UNK8U451.8
S8_ETH_TN_AB_CASE: SITE8.G15(PAD_ETH_TN) UNK8U450.7
S8_ETH_TP_AB_CASE: SITE8.G14(PAD_ETH_TP) UNK8U450.8
S8_M_2V5: UNK8C284.1 UNK8C285.1 UNK8MR2.1 UNK8MU2.6
S8_M_3V2: UNK8C282.1 UNK8C283.1 UNK8C289.1 UNK8MR1.1 UNK8MU1.5 UNK8MU2.2 UNK8MU3.7
S8_MUX_3V3: UNK8BD21.1 UNK8BD1728.1 UNK8BD1729.1 UNK8BDB5.1 UNK8BDB6.1 UNK8R512.1
S8_OUT_RX0_CH0_ABC_CASE+: SITE8.A3(PAD_OUTP_RX0_CH[0]) UNK8U408.B2
S8_OUT_RX0_CH0_ABC_CASE-: SITE8.C4(PAD_OUTN_RX0_CH[0]) UNK8U408.B1
S8_OUT_RX0_CH0_B_CASE+: UNK8R647.1 UNK8U408.B4
S8_OUT_RX0_CH0_B_CASE-: UNK8R646.1 UNK8U408.A4
S8_OUT_RX0_CH0_C_CASE: UNK8C309.1 UNK8R646.2 UNK8R647.2
S8_OUT_RX0_CH1_ABC_CASE+: SITE8.A2(PAD_OUTP_RX0_CH[1]) UNK8U408.D2
S8_OUT_RX0_CH1_ABC_CASE-: SITE8.B3(PAD_OUTN_RX0_CH[1]) UNK8U408.D1
S8_OUT_RX0_CH1_B_CASE+: UNK8R168.1 UNK8U408.B5
S8_OUT_RX0_CH1_B_CASE-: UNK8R170.1 UNK8U408.A5
S8_OUT_RX0_CH1_C_CASE: UNK8C310.1 UNK8R168.2 UNK8R170.2
S8_OUT_RX0_CH2_ABC_CASE+: SITE8.B2(PAD_OUTP_RX0_CH[2]) UNK8U408.E2
S8_OUT_RX0_CH2_ABC_CASE-: SITE8.C3(PAD_OUTN_RX0_CH[2]) UNK8U408.E1
S8_OUT_RX0_CH2_B_CASE+: UNK8R176.1 UNK8U408.B6
S8_OUT_RX0_CH2_B_CASE-: UNK8R178.1 UNK8U408.A6
S8_OUT_RX0_CH2_C_CASE: UNK8C318.1 UNK8R176.2 UNK8R178.2
S8_OUT_RX0_CH3_ABC_CASE+: SITE8.C2(PAD_OUTP_RX0_CH[3]) UNK8U409.B2
S8_OUT_RX0_CH3_ABC_CASE-: SITE8.B1(PAD_OUTN_RX0_CH[3]) UNK8U409.B1
S8_OUT_RX0_CH3_B_CASE+: UNK8R1089.1 UNK8U409.B4
S8_OUT_RX0_CH3_B_CASE-: UNK8R1088.1 UNK8U409.A4
S8_OUT_RX0_CH3_C_CASE: UNK8C302.1 UNK8R1088.2 UNK8R1089.2
S8_OUT_RX0_CH4_ABC_CASE+: SITE8.D2(PAD_OUTP_RX0_CH[4]) UNK8U409.D2
S8_OUT_RX0_CH4_ABC_CASE-: SITE8.C1(PAD_OUTN_RX0_CH[4]) UNK8U409.D1
S8_OUT_RX0_CH4_B_CASE+: UNK8R180.1 UNK8U409.B5
S8_OUT_RX0_CH4_B_CASE-: UNK8R182.1 UNK8U409.A5
S8_OUT_RX0_CH4_C_CASE: UNK8C320.1 UNK8R180.2 UNK8R182.2
S8_OUT_RX0_CH5_ABC_CASE+: SITE8.D3(PAD_OUTP_RX0_CH[5]) UNK8U409.E2
S8_OUT_RX0_CH5_ABC_CASE-: SITE8.D1(PAD_OUTN_RX0_CH[5]) UNK8U409.E1
S8_OUT_RX0_CH5_B_CASE+: UNK8R666.1 UNK8U409.B6
S8_OUT_RX0_CH5_B_CASE-: UNK8R664.1 UNK8U409.A6
S8_OUT_RX0_CH5_C_CASE: UNK8C924.1 UNK8R664.2 UNK8R666.2
S8_PAD_SZQ: SITE8.T11(PAD_SZQ) UNK8K113.5
S8_PM_SAR0: S8_VREF_OUT.1(TP) SITE8.B12(PAD_PM_SAR0) UNK8K34.3 UNK8MK3.4
S8_SPI_CK_ABCD_CASE: SITE8.N15(PAD_SPI0_CK) UNK8K2.6
S8_SPI_CK_B_CASE: UNK8K2.5 UNK8K3.6
S8_SPI_CK_C_CASE: UNK8K3.7 UNK8U18.6
S8_SPI_CK_D_CASE: UNK8K3.5 UNK8U19.6
S8_SPI_CZ_ABCD_CASE: SITE8.N14(PAD_SPI0_CZ) UNK8K2.3
S8_SPI_CZ_B_CASE: UNK8K2.4 UNK8K3.3
S8_SPI_CZ_C_CASE: UNK8K3.2 UNK8R200.2 UNK8U18.1
S8_SPI_CZ_D_CASE: UNK8K3.4 UNK8R205.2 UNK8U19.1
S8_SPI_DI_ABCD_CASE: SITE8.P16(PAD_SPI0_DI) UNK8K4.6
S8_SPI_DI_B_CASE: UNK8K4.5 UNK8K5.6
S8_SPI_DI_C_CASE: UNK8K5.7 UNK8U18.5
S8_SPI_DI_D_CASE: UNK8K5.5 UNK8U19.5
S8_SPI_DO_ABCD_CASE: SITE8.P15(PAD_SPI0_DO) UNK8K4.3
S8_SPI_DO_B_CASE: UNK8K4.4 UNK8K5.3
S8_SPI_DO_C_CASE: UNK8K5.2 UNK8U18.2
S8_SPI_DO_D_CASE: UNK8K5.4 UNK8U19.2
S8_SPI_HLD_ABCD_CASE: SITE8.M15(PAD_SPI0_HLD) UNK8K6.3
S8_SPI_HLD_B_CASE: UNK8K6.4 UNK8K7.3
S8_SPI_HLD_C_CASE: UNK8K7.2 UNK8R202.1 UNK8U18.7
S8_SPI_HLD_D_CASE: UNK8K7.4 UNK8R206.1 UNK8U19.7
S8_SPI_WPZ_ABCD_CASE: SITE8.M16(PAD_SPI0_WPZ) UNK8K6.6
S8_SPI_WPZ_B_CASE: UNK8K6.5 UNK8K7.6
S8_SPI_WPZ_C_CASE: UNK8K7.7 UNK8R203.2 UNK8U18.3
S8_SPI_WPZ_D_CASE: UNK8K7.5 UNK8R207.2 UNK8U19.3
S8_USB2_SEL0: UNK8R164.2 UNK8U31.6
S8_USB2_SEL1: UNK8R163.2 UNK8U31.5
S8_USB2_SELS: UNK8R165.2 UNK8U31.16
S8_USB_D_AB_CASE+: SITE8.F1(PAD_USB_DP) UNK8U31.10
S8_USB_D_AB_CASE-: SITE8.F2(PAD_USB_DM) UNK8U31.9
S8_USB_D_B_CASE+: UNK8R160.2 UNK8U31.8
S8_USB_D_B_CASE-: UNK8R161.2 UNK8U31.7
S8_USER_3V3: S8_USER_3V3.1 UNK8C334.1 UNK8C335.1 UNK8C336.2 UNK8C337.2 UNK8C338.2 UNK8C339.2 UNK8R200.1 UNK8R201.2 UNK8R202.2 UNK8R203.1 UNK8R204.2 UNK8R205.1 UNK8R206.2 UNK8R207.1 UNK8U17.3
S8_XTAL_24M_IN_ABC_CASE: SITE8.K15(PAD_XTAL_24M_IN) UNK8K32.3
S8_XTAL_24M_IN_B_CASE: UNK8K32.4 UNK8R135.1
S8_XTAL_24M_IN_C_CASE: UNK8C267.1 UNK8R135.2 UNK8R136.2 UNK8Y1.3
S8_XTAL_24M_OUT_ABC_CASE: SITE8.K16(PAD_XTAL_24M_OUT) UNK8K32.6
S8_XTAL_24M_OUT_B_CASE: UNK8K32.5 UNK8R137.1
S8_XTAL_24M_OUT_C_CASE: UNK8C268.1 UNK8R136.1 UNK8R137.2 UNK8Y1.1
S8_XTAL_IN_32K_A_CASE: UNK8K29.7 UNK8U449.7
S8_XTAL_IN_32K_ABCD_CASE: SITE8.B6(PAD_XTAL_IN_32K) UNK8K29.6
S8_XTAL_IN_32K_B_CASE: UNK8C271.1 UNK8K29.5 UNK8Y2.1
S8_XTAL_IN_32K_D_CASE: UNK8R923.1 UNK8R973.2 UNK8U449.2
S8_XTAL_OUT_32K_A_CASE: UNK8K29.2 UNK8U449.8
S8_XTAL_OUT_32K_ABCD_CASE: SITE8.A6(PAD_XTAL_OUT_32K) UNK8K29.3
S8_XTAL_OUT_32K_B_CASE: UNK8C272.1 UNK8K29.4 UNK8Y2.2
S8_XTAL_OUT_32K_D_CASE: UNK8R652.1 UNK8R973.1 UNK8U449.1
SA_RCBIT_01: K107.8(V-) U74.16(1C) UNK2K107.8 UNK3K107.8 UNK4K107.8
SA_RCBIT_02: K34.8(V-) U74.15(2C) UNK2K34.8 UNK3K34.8 UNK4K34.8
SA_RCBIT_03: K96.12(V-) U74.14(3C) UNK2K96.12 UNK3K96.12 UNK4K96.12
SA_RCBIT_04: U72.16(1C) UNK5K34.8 UNK6K34.8 UNK7K34.8 UNK8K34.8
SA_RCBIT_05: K29.8(V-) U72.15(2C) UNK2K29.8 UNK3K29.8 UNK4K29.8
SA_RCBIT_06: U72.14(3C) UNK5K107.8 UNK6K107.8 UNK7K107.8 UNK8K107.8
SA_RCBIT_07: K5.8(V-) U77.16(1C) UNK2K5.8 UNK3K5.8 UNK4K5.8
SA_RCBIT_08: K6.8(V-) U77.15(2C) UNK2K6.8 UNK3K6.8 UNK4K6.8
SA_RCBIT_09: K7.8(V-) U77.14(3C) UNK2K7.8 UNK3K7.8 UNK4K7.8
SA_RCBIT_10: K4.8(V-) U75.16(1C) UNK2K4.8 UNK3K4.8 UNK4K4.8
SA_RCBIT_11: K3.8(V-) U75.15(2C) UNK2K3.8 UNK3K3.8 UNK4K3.8
SA_RCBIT_12: K2.8(V-) U75.14(3C) UNK2K2.8 UNK3K2.8 UNK4K2.8
SA_RCBIT_13: K32.8(V-) U80.16(1C) UNK2K32.8 UNK3K32.8 UNK4K32.8
SA_RCBIT_14: K39.8(V-) U80.15(2C) UNK2K39.8 UNK3K39.8 UNK4K39.8
SA_RCBIT_15: K113.4(V-) U80.14(3C) UNK2K113.4 UNK3K113.4 UNK4K113.4
SA_RCBIT_16: U405.16(1C) UNK5K96.12 UNK6K96.12 UNK7K96.12 UNK8K96.12
SA_RCBIT_17: U405.15(2C) UNK5K32.8 UNK6K32.8 UNK7K32.8 UNK8K32.8
SA_RCBIT_18: U405.14(3C) UNK5K29.8 UNK6K29.8 UNK7K29.8 UNK8K29.8
SA_RCBIT_19: U413.16(1C) UNK5K39.8 UNK6K39.8 UNK7K39.8 UNK8K39.8
SA_RCBIT_20: U413.15(2C) UNK5K113.4 UNK6K113.4 UNK7K113.4 UNK8K113.4
SA_RCBIT_21: U413.14(3C) UNK5K4.8 UNK6K4.8 UNK7K4.8 UNK8K4.8
SA_RCBIT_22: U415.16(1C) UNK5K5.8 UNK6K5.8 UNK7K5.8 UNK8K5.8
SA_RCBIT_23: U415.15(2C) UNK5K7.8 UNK6K7.8 UNK7K7.8 UNK8K7.8
SA_RCBIT_24: U415.14(3C) UNK5K6.8 UNK6K6.8 UNK7K6.8 UNK8K6.8
SA_RCBIT_25: U453.16(1C) UNK5K2.8 UNK6K2.8 UNK7K2.8 UNK8K2.8
SA_RCBIT_26: U453.15(2C) UNK5K3.8 UNK6K3.8 UNK7K3.8 UNK8K3.8
SA_SCBIT_01: R165.1 U70.18(1Y0) UNK2R165.1 UNK3R165.1 UNK4R165.1
SA_SCBIT_02: U70.16(1Y1) UNK5R991.1 UNK6R991.1 UNK7R991.1 UNK8R991.1
SA_SCBIT_03: U70.14(1Y2) UNK5R982.1 UNK6R982.1 UNK7R982.1 UNK8R982.1
SA_SCBIT_04: U70.12(1Y3) UNK5R985.1 UNK6R985.1 UNK7R985.1 UNK8R985.1
SA_SCBIT_05: R163.1 U70.3(2Y0) UNK2R163.1 UNK3R163.1 UNK4R163.1
SA_SCBIT_06: R164.1 U70.5(2Y1) UNK2R164.1 UNK3R164.1 UNK4R164.1
SA_SCBIT_07: R662.2 U70.7(2Y2) UNK2R662.2 UNK3R662.2 UNK4R662.2
SA_SCBIT_08: R172.2 U70.9(2Y3) UNK2R172.2 UNK3R172.2 UNK4R172.2
SA_SCBIT_09: U403.18(1Y0) UNK5R988.1 UNK6R988.1 UNK7R988.1 UNK8R988.1
SA_SCBIT_10: U403.16(1Y1) UNK5R172.2 UNK6R172.2 UNK7R172.2 UNK8R172.2
SA_SCBIT_11: U403.14(1Y2) UNK5R662.2 UNK6R662.2 UNK7R662.2 UNK8R662.2
SA_SCBIT_12: U403.12(1Y3) UNK5R164.1 UNK6R164.1 UNK7R164.1 UNK8R164.1
SA_SCBIT_13: R988.1 U403.3(2Y0) UNK2R988.1 UNK3R988.1 UNK4R988.1
SA_SCBIT_14: R985.1 U403.5(2Y1) UNK2R985.1 UNK3R985.1 UNK4R985.1
SA_SCBIT_15: R982.1 U403.7(2Y2) UNK2R982.1 UNK3R982.1 UNK4R982.1
SA_SCBIT_16: R991.1 U403.9(2Y3) UNK2R991.1 UNK3R991.1 UNK4R991.1
SA_SCBIT_17: U434.18(1Y0) UNK5R163.1 UNK6R163.1 UNK7R163.1 UNK8R163.1
SA_SCBIT_18: U434.16(1Y1) UNK5R165.1 UNK6R165.1 UNK7R165.1 UNK8R165.1
SA_SCBIT_19: U434.14(1Y2) UNK5MK3.2 UNK6MK3.2 UNK7MK3.2 UNK8MK3.2
SA_SCBIT_20: U434.12(1Y3) UNK5MK1.2 UNK5MR12.2 UNK6MK1.2 UNK6MR12.2 UNK7MK1.2 UNK7MR12.2 UNK8MK1.2 UNK8MR12.2
SA_SCBIT_21: MK3.2(V-) U434.3(2Y0) UNK2MK3.2 UNK3MK3.2 UNK4MK3.2
SA_SCBIT_22: MK1.2(V-) MR12.2 U434.5(2Y1) UNK2MK1.2 UNK2MR12.2 UNK3MK1.2 UNK3MR12.2 UNK4MK1.2 UNK4MR12.2
SA_SCBIT_23: MK4.2(V-) MR17.2 U434.7(2Y2) UNK2MK4.2 UNK2MR17.2 UNK3MK4.2 UNK3MR17.2 UNK4MK4.2 UNK4MR17.2
SA_SCBIT_24: MK2.2(V-) MR15.2 U434.9(2Y3) UNK2MK2.2 UNK2MR15.2 UNK3MK2.2 UNK3MR15.2 UNK4MK2.2 UNK4MR15.2
SA_SCBIT_25: U435.18(1Y0) UNK5MK4.2 UNK5MR17.2 UNK6MK4.2 UNK6MR17.2 UNK7MK4.2 UNK7MR17.2 UNK8MK4.2 UNK8MR17.2
SA_SCBIT_26: U435.16(1Y1) UNK5MK2.2 UNK5MR15.2 UNK6MK2.2 UNK6MR15.2 UNK7MK2.2 UNK7MR15.2 UNK8MK2.2 UNK8MR15.2
UBIT_3V3_UP: BD5.1 BD1721.1 BD1722.1 BD1723.1 R403.1
UDBGND: CB1.2 CB2.2 CB3.2 CB4.2 CB5.2 CB6.2 CB7.2 CB8.2 CB9.2 CB10.2 CB11.2 CB12.2 CB13.2 CB14.2 CB15.2 CB16.2 LDB1.2(B) RB501.1 RB502.1 RB507.1 RB508.1 RB509.1 RB510.1 RB511.1 RB512.1 RB513.1 RB514.1 RB515.1 RB516.1 UB1.1(A0) UB1.2(A1) UB1.3(A2) UB1.4(GND) UB1.7(WP) UTL1.A02 UTL1.A08 UTL1.A10 UTL1.A12 UTL1.A14 UTL1.B01 UTL1.B07 UTL1.B09 UTL1.B11 UTL1.B13 UTL2.A02 UTL2.A08 UTL2.A10 UTL2.A12 UTL2.A14 UTL2.B01 UTL2.B07 UTL2.B09 UTL2.B11 UTL2.B13 UTL3.A02 UTL3.A08 UTL3.A10 UTL3.A12 UTL3.A14 UTL3.B01 UTL3.B07 UTL3.B09 UTL3.B11 UTL3.B13 UTL4.A02 UTL4.A08 UTL4.A10 UTL4.A12 UTL4.A14 UTL4.B01 UTL4.B07 UTL4.B09 UTL4.B11 UTL4.B13 UTL5.A02 UTL5.A08 UTL5.A10 UTL5.A12 UTL5.A14 UTL5.B01 UTL5.B07 UTL5.B09 UTL5.B11 UTL5.B13 UTL6.A02 UTL6.A08 UTL6.A10 UTL6.A12 UTL6.A14 UTL6.B01 UTL6.B07 UTL6.B09 UTL6.B11 UTL6.B13 UTL7.A02 UTL7.A08 UTL7.A10 UTL7.A12 UTL7.A14 UTL7.B01 UTL7.B07 UTL7.B09 UTL7.B11 UTL7.B13 UTL8.A02 UTL8.A08 UTL8.A10 UTL8.A12 UTL8.A14 UTL8.B01 UTL8.B07 UTL8.B09 UTL8.B11 UTL8.B13 XC2.1
UT1_PDCF: UTL1.B15
UT1_PDCS: UTL1.A15
UT1_PGDS: UTL1.A16
UT1_PGRD: UTL1.B16
UT1_UP5V: C278.1 C279.1 C280.1 C281.1 C332.1 C333.1 C403.1 C404.1 C405.1 C406.1 C407.1 C408.1 C409.1 C410.1 C411.1 C412.1 C413.1 C415.1 C416.1 C417.1 C476.1 C477.1 C478.1 C910.1 C955.1 C956.1 C957.1 C958.1 C1082.1 C1083.1 C1085.1 CB1.1 CB2.1 CB3.1 CB4.1 CB5.1 CB6.1 CB7.1 CB8.1 CB9.1 CB10.1 CB11.1 CB12.1 CB13.1 CB14.1 CB15.1 CB16.1 CD1.2 CD2.2 J1.1 J2.1 K2.1(V+) K3.1(V+) K4.1(V+) K5.1(V+) K6.1(V+) K7.1(V+) K29.1(V+) K32.1(V+) K34.1(V+) K39.1(V+) K96.1(V+) K107.1(V+) K109.1(V+) K110.1(V+) K111.1(V+) K112.1(V+) K113.3(V+) LRB1.1 MBD1.1 MR11.1 MR12.1 MR13.1 MR14.2 MR15.1 MR16.1 MR17.1 MU1.1(VIN) MU1.3(EN) R331.1 R404.2 R405.1 R406.1 R407.1 R408.1 R409.1 R410.1 R411.1 R412.1 R413.1 R414.1 R415.1 R416.1 R420.1 R422.1 R509.2 R648.1 R649.1 R650.1 R658.1 R709.1 R710.1 R711.1 R712.1 R713.1 R714.1 R1093.1 R1097.1 RB1.1 RB2.1 RD1.1 RD2.1 RD4.2 RD6.2 RD7.1 RD8.1 RD9.1 RD10.1 RD12.2 RD14.2 RD15.1 RD16.1 SK1.1(V+) SK2.1(V+) SK3.1(V+) SK4.1(V+) SK5.1(V+) SK6.1(V+) SK7.1(V+) SK8.1(V+) U14.8(VDD) U15.8(VDD) U17.2(VIN) U71.4(VDD) U72.9(COM) U73.14(VCC) U74.9(COM) U75.9(COM) U76.14(VCC) U77.9(COM) U79.14(VCC) U80.9(COM) U108.4(VDD) U405.9(COM) U413.9(COM) U414.14(VCC) U415.9(COM) U453.9(COM) U454.14(VCC) UB1.8(VCC) UNK2C278.1 UNK2C279.1 UNK2C280.1 UNK2C281.1 UNK2C332.1 UNK2C333.1 UNK2C476.1 UNK2C477.1 UNK2C478.1 UNK2K2.1 UNK2K3.1 UNK2K4.1 UNK2K5.1 UNK2K6.1 UNK2K7.1 UNK2K29.1 UNK2K32.1 UNK2K34.1 UNK2K39.1 UNK2K96.1 UNK2K107.1 UNK2K113.3 UNK2MBD1.1 UNK2MR11.1 UNK2MR12.1 UNK2MR13.1 UNK2MR14.2 UNK2MR15.1 UNK2MR16.1 UNK2MR17.1 UNK2MU1.1 UNK2MU1.3 UNK2R331.1 UNK2R509.2 UNK2U17.2 UNK2U108.4 UNK3C278.1 UNK3C279.1 UNK3C280.1 UNK3C281.1 UNK3C332.1 UNK3C333.1 UNK3C476.1 UNK3C477.1 UNK3C478.1 UNK3K2.1 UNK3K3.1 UNK3K4.1 UNK3K5.1 UNK3K6.1 UNK3K7.1 UNK3K29.1 UNK3K32.1 UNK3K34.1 UNK3K39.1 UNK3K96.1 UNK3K107.1 UNK3K113.3 UNK3MBD1.1 UNK3MR11.1 UNK3MR12.1 UNK3MR13.1 UNK3MR14.2 UNK3MR15.1 UNK3MR16.1 UNK3MR17.1 UNK3MU1.1 UNK3MU1.3 UNK3R331.1 UNK3R509.2 UNK3U17.2 UNK3U108.4 UNK4C278.1 UNK4C279.1 UNK4C280.1 UNK4C281.1 UNK4C332.1 UNK4C333.1 UNK4C476.1 UNK4C477.1 UNK4C478.1 UNK4K2.1 UNK4K3.1 UNK4K4.1 UNK4K5.1 UNK4K6.1 UNK4K7.1 UNK4K29.1 UNK4K32.1 UNK4K34.1 UNK4K39.1 UNK4K96.1 UNK4K107.1 UNK4K113.3 UNK4MBD1.1 UNK4MR11.1 UNK4MR12.1 UNK4MR13.1 UNK4MR14.2 UNK4MR15.1 UNK4MR16.1 UNK4MR17.1 UNK4MU1.1 UNK4MU1.3 UNK4R331.1 UNK4R509.2 UNK4U17.2 UNK4U108.4 UNK5C278.1 UNK5C279.1 UNK5C280.1 UNK5C281.1 UNK5C332.1 UNK5C333.1 UNK5C476.1 UNK5C477.1 UNK5C478.1 UNK5K2.1 UNK5K3.1 UNK5K4.1 UNK5K5.1 UNK5K6.1 UNK5K7.1 UNK5K29.1 UNK5K32.1 UNK5K34.1 UNK5K39.1 UNK5K96.1 UNK5K107.1 UNK5K113.3 UNK5MBD1.1 UNK5MR11.1 UNK5MR12.1 UNK5MR13.1 UNK5MR14.2 UNK5MR15.1 UNK5MR16.1 UNK5MR17.1 UNK5MU1.1 UNK5MU1.3 UNK5R331.1 UNK5R509.2 UNK5U17.2 UNK5U108.4 UNK6C278.1 UNK6C279.1 UNK6C280.1 UNK6C281.1 UNK6C332.1 UNK6C333.1 UNK6C476.1 UNK6C477.1 UNK6C478.1 UNK6K2.1 UNK6K3.1 UNK6K4.1 UNK6K5.1 UNK6K6.1 UNK6K7.1 UNK6K29.1 UNK6K32.1 UNK6K34.1 UNK6K39.1 UNK6K96.1 UNK6K107.1 UNK6K113.3 UNK6MBD1.1 UNK6MR11.1 UNK6MR12.1 UNK6MR13.1 UNK6MR14.2 UNK6MR15.1 UNK6MR16.1 UNK6MR17.1 UNK6MU1.1 UNK6MU1.3 UNK6R331.1 UNK6R509.2 UNK6U17.2 UNK6U108.4 UNK7C278.1 UNK7C279.1 UNK7C280.1 UNK7C281.1 UNK7C332.1 UNK7C333.1 UNK7C476.1 UNK7C477.1 UNK7C478.1 UNK7K2.1 UNK7K3.1 UNK7K4.1 UNK7K5.1 UNK7K6.1 UNK7K7.1 UNK7K29.1 UNK7K32.1 UNK7K34.1 UNK7K39.1 UNK7K96.1 UNK7K107.1 UNK7K113.3 UNK7MBD1.1 UNK7MR11.1 UNK7MR12.1 UNK7MR13.1 UNK7MR14.2 UNK7MR15.1 UNK7MR16.1 UNK7MR17.1 UNK7MU1.1 UNK7MU1.3 UNK7R331.1 UNK7R509.2 UNK7U17.2 UNK7U108.4 UNK8C278.1 UNK8C279.1 UNK8C280.1 UNK8C281.1 UNK8C332.1 UNK8C333.1 UNK8C476.1 UNK8C477.1 UNK8C478.1 UNK8K2.1 UNK8K3.1 UNK8K4.1 UNK8K5.1 UNK8K6.1 UNK8K7.1 UNK8K29.1 UNK8K32.1 UNK8K34.1 UNK8K39.1 UNK8K96.1 UNK8K107.1 UNK8K113.3 UNK8MBD1.1 UNK8MR11.1 UNK8MR12.1 UNK8MR13.1 UNK8MR14.2 UNK8MR15.1 UNK8MR16.1 UNK8MR17.1 UNK8MU1.1 UNK8MU1.3 UNK8R331.1 UNK8R509.2 UNK8U17.2 UNK8U108.4 UT_UP5V.1(TP) UTL1.A05 UTL1.B04 UTL2.A05 UTL2.B04 UTL3.A05 UTL3.B04 UTL4.A05 UTL4.B04 UTL5.A05 UTL5.B04 UTL6.A05 UTL6.B04 UTL7.A05 UTL7.B04 UTL8.A05 UTL8.B04 XC2.2
UT1_URW00: UT1_SW1.8 UTL1.A01
UT1_URW01: UT1_SW1.7 UTL1.B02
UT1_URW02: UT1_SW1.6 UTL1.A03
UT1_URW03: UT1_SW1.5 UTL1.B03
UT1_URW04: UT1_SW1.4 UTL1.A04
UT1_URW05: UT1_SW1.3 UTL1.B05
UT1_URW06: UT1_SW1.2 UTL1.A06
UT1_UW07: UT1_SW1.1 UTL1.B06
UT1_UW08: UT1_SW2.8 UTL1.A07
UT1_UW09: UT1_SW2.7 UTL1.B08
UT1_UW10: UT1_SW2.6 UTL1.A09
UT1_UW11: UT1_SW2.5 UTL1.B10
UT1_UW12: UT1_SW2.4 UTL1.A11
UT1_UW13: UT1_SW2.3 UTL1.B12
UT1_UW14: RB1.2 UB1.6(SCL) UT1_SW2.2 UTL1.A13
UT1_UW15: RB2.2 UB1.5(SDA) UT1_SW2.1 UTL1.B14
UT2_PDCF: UTL2.B15
UT2_PDCS: UTL2.A15
UT2_PGDS: UTL2.A16
UT2_PGRD: UTL2.B16
UT2_URW00: UT2_SW1.8 UTL2.A01
UT2_URW01: R592.2 R932.2 UT2_SW1.7 UTL2.B02
UT2_URW02: UT2_SW1.6 UTL2.A03
UT2_URW03: R593.2 R930.2 UT2_SW1.5 UTL2.B03
UT2_URW04: R596.2 R934.2 UT2_SW1.4 UTL2.A04
UT2_URW05: R594.2 R929.2 UT2_SW1.3 UTL2.B05
UT2_URW06: R603.2 R936.2 UT2_SW1.2 UTL2.A06
UT2_UW07: R595.2 R931.2 UT2_SW1.1 UTL2.B06
UT2_UW08: R602.2 R939.2 UT2_SW2.8 UTL2.A07
UT2_UW09: R400.2 R926.2 UT2_SW2.7 UTL2.B08
UT2_UW10: R601.2 R937.2 UT2_SW2.6 UTL2.A09
UT2_UW11: R589.2 R927.2 UT2_SW2.5 UTL2.B10
UT2_UW12: R600.2 R938.2 UT2_SW2.4 UTL2.A11
UT2_UW13: R590.2 R925.2 UT2_SW2.3 UTL2.B12
UT2_UW14: R599.2 R940.2 UT2_SW2.2 UTL2.A13
UT2_UW15: R591.2 R928.2 UT2_SW2.1 UTL2.B14
UT3_PDCF: UTL3.B15
UT3_PDCS: UTL3.A15
UT3_PGDS: UTL3.A16
UT3_PGRD: UTL3.B16
UT3_URW00: UT3_SW1.8 UTL3.A01
UT3_URW01: UT3_SW1.7 UTL3.B02
UT3_URW02: UT3_SW1.6 UTL3.A03
UT3_URW03: UT3_SW1.5 UTL3.B03
UT3_URW04: UT3_SW1.4 UTL3.A04
UT3_URW05: UT3_SW1.3 UTL3.B05
UT3_URW06: UT3_SW1.2 UTL3.A06
UT3_UW07: UT3_SW1.1 UTL3.B06
UT3_UW08: UT3_SW2.8 UTL3.A07
UT3_UW09: UT3_SW2.7 UTL3.B08
UT3_UW10: UT3_SW2.6 UTL3.A09
UT3_UW11: UT3_SW2.5 UTL3.B10
UT3_UW12: UT3_SW2.4 UTL3.A11
UT3_UW13: UT3_SW2.3 UTL3.B12
UT3_UW14: UT3_SW2.2 UTL3.A13
UT3_UW15: UT3_SW2.1 UTL3.B14
UT4_PDCF: UTL4.B15
UT4_PDCS: UTL4.A15
UT4_PGDS: UTL4.A16
UT4_PGRD: UTL4.B16
UT4_URW00: UT4_SW1.8 UTL4.A01
UT4_URW01: UT4_SW1.7 UTL4.B02
UT4_URW02: UT4_SW1.6 UTL4.A03
UT4_URW03: UT4_SW1.5 UTL4.B03
UT4_URW04: UT4_SW1.4 UTL4.A04
UT4_URW05: UT4_SW1.3 UTL4.B05
UT4_URW06: R658.2 U79.13(6A) UT4_SW1.2 UTL4.A06
UT4_UW07: K112.8(V-) UT4_SW1.1 UTL4.B06
UT4_UW08: R650.2 U79.11(5A) UT4_SW2.8 UTL4.A07
UT4_UW09: K111.8(V-) UT4_SW2.7 UTL4.B08
UT4_UW10: R649.2 U79.9(4A) UT4_SW2.6 UTL4.A09
UT4_UW11: K110.8(V-) UT4_SW2.5 UTL4.B10
UT4_UW12: R714.2 U414.13(6A) UT4_SW2.4 UTL4.A11
UT4_UW13: K109.8(V-) UT4_SW2.3 UTL4.B12
UT4_UW14: R710.2 U414.11(5A) UT4_SW2.2 UTL4.A13
UT4_UW15: R709.2 U414.9(4A) UT4_SW2.1 UTL4.B14
UT5_PDCF: UTL5.B15
UT5_PDCS: UTL5.A15
UT5_PGDS: UTL5.A16
UT5_PGRD: UTL5.B16
UT5_UW00: UT5_SW1.8 UTL5.A01
UT5_UW01: UT5_SW1.7 UTL5.B02
UT5_UW02: UT5_SW1.6 UTL5.A03
UT5_UW03: UT5_SW1.5 UTL5.B03
UT5_UW04: UT5_SW1.4 UTL5.A04
UT5_UW05: UT5_SW1.3 UTL5.B05
UT5_UW06: UT5_SW1.2 UTL5.A06
UT5_UW07: UT5_SW1.1 UTL5.B06
UT5_UW08: UT5_SW2.8 UTL5.A07
UT5_UW09: UT5_SW2.7 UTL5.B08
UT5_UW10: UT5_SW2.6 UTL5.A09
UT5_UW11: UT5_SW2.5 UTL5.B10
UT5_UW12: UT5_SW2.4 UTL5.A11
UT5_UW13: UT5_SW2.3 UTL5.B12
UT5_UW14: UT5_SW2.2 UTL5.A13
UT5_UW15: UT5_SW2.1 UTL5.B14
UT6_PDCF: UTL6.B15
UT6_PDCS: UTL6.A15
UT6_PGDS: UTL6.A16
UT6_PGRD: UTL6.B16
UT6_UW00: R752.2 R946.2 UT6_SW1.8 UTL6.A01
UT6_UW01: R754.2 R945.2 UT6_SW1.7 UTL6.B02
UT6_UW02: R757.2 R948.2 UT6_SW1.6 UTL6.A03
UT6_UW03: R756.2 R947.2 UT6_SW1.5 UTL6.B03
UT6_UW04: R598.2 R935.2 UT6_SW1.4 UTL6.A04
UT6_UW05: R751.2 R944.2 UT6_SW1.3 UTL6.B05
UT6_UW06: R597.2 R933.2 UT6_SW1.2 UTL6.A06
UT6_UW07: R758.2 R942.2 UT6_SW1.1 UTL6.B06
UT6_UW08: SK8.8(V-) UT6_SW2.8 UTL6.A07
UT6_UW09: R753.2 R941.2 UT6_SW2.7 UTL6.B08
UT6_UW10: SK5.8(V-) UT6_SW2.6 UTL6.A09
UT6_UW11: R755.2 R943.2 UT6_SW2.5 UTL6.B10
UT6_UW12: SK7.8(V-) UT6_SW2.4 UTL6.A11
UT6_UW13: R759.2 R952.2 UT6_SW2.3 UTL6.B12
UT6_UW14: SK6.8(V-) UT6_SW2.2 UTL6.A13
UT6_UW15: R766.2 R950.2 UT6_SW2.1 UTL6.B14
UT7_PDCF: UTL7.B15
UT7_PDCS: UTL7.A15
UT7_PGDS: UTL7.A16
UT7_PGRD: UTL7.B16
UT7_UW00: UT7_SW1.8 UTL7.A01
UT7_UW01: UT7_SW1.7 UTL7.B02
UT7_UW02: UT7_SW1.6 UTL7.A03
UT7_UW03: UT7_SW1.5 UTL7.B03
UT7_UW04: UT7_SW1.4 UTL7.A04
UT7_UW05: UT7_SW1.3 UTL7.B05
UT7_UW06: UT7_SW1.2 UTL7.A06
UT7_UW07: UT7_SW1.1 UTL7.B06
UT7_UW08: R416.2 U76.5(3A) UT7_SW2.8 UTL7.A07
UT7_UW09: R1093.2 U454.1(1A) UT7_SW2.7 UTL7.B08
UT7_UW10: R415.2 U76.3(2A) UT7_SW2.6 UTL7.A09
UT7_UW11: R1097.2 U454.3(2A) UT7_SW2.5 UTL7.B10
UT7_UW12: R411.2 U76.1(1A) UT7_SW2.4 UTL7.A11
UT7_UW13: R412.2 U76.9(4A) UT7_SW2.3 UTL7.B12
UT7_UW14: R414.2 U76.13(6A) UT7_SW2.2 UTL7.A13
UT7_UW15: R413.2 U76.11(5A) UT7_SW2.1 UTL7.B14
UT8_PDCF: UTL8.B15
UT8_PDCS: UTL8.A15
UT8_PGDS: UTL8.A16
UT8_PGRD: UTL8.B16
UT8_UW00: SK4.8(V-) UT8_SW1.8 UTL8.A01
UT8_UW01: R408.2 U73.9(4A) UT8_SW1.7 UTL8.B02
UT8_UW02: SK1.8(V-) UT8_SW1.6 UTL8.A03
UT8_UW03: R409.2 U73.11(5A) UT8_SW1.5 UTL8.B03
UT8_UW04: SK2.8(V-) UT8_SW1.4 UTL8.A04
UT8_UW05: R410.2 U73.13(6A) UT8_SW1.3 UTL8.B05
UT8_UW06: SK3.8(V-) UT8_SW1.2 UTL8.A06
UT8_UW07: R405.2 U73.1(1A) UT8_SW1.1 UTL8.B06
UT8_UW08: R711.2 U414.5(3A) UT8_SW2.8 UTL8.A07
UT8_UW09: R406.2 U73.3(2A) UT8_SW2.7 UTL8.B08
UT8_UW10: R713.2 U414.3(2A) UT8_SW2.6 UTL8.A09
UT8_UW11: R407.2 U73.5(3A) UT8_SW2.5 UTL8.B10
UT8_UW12: R712.2 U414.1(1A) UT8_SW2.4 UTL8.A11
UT8_UW13: R422.2 U79.1(1A) UT8_SW2.3 UTL8.B12
UT8_UW14: R648.2 U79.5(3A) UT8_SW2.2 UTL8.A13
UT8_UW15: R420.2 U79.3(2A) UT8_SW2.1 UTL8.B14
N16771755: CA19.1 K96.5 K96.8
N16793879: BD9.1 SITE1.H3(PAD_AUD_VRM)
N16802127: R172.1 U408.A1(GPU_SEL)
N16802132: R661.1 U408.B7(/XSD)
N16802143: R662.1 U409.A1(GPU_SEL)
N16802148: R663.1 U409.B7(/XSD)
N16802203: R672.1 U409.C2(DDC_AUX_SEL)
N16802583: R659.1 U408.C2(DDC_AUX_SEL)
N17350989: R510.2 R511.1 U108.1(ADJ)
N17351004: C475.1 R510.1 R512.2 TP_MUX_3V3.1(TP) U108.5(VOUT)
N17351006: R509.1 U108.3(CE)
N17351151: R162.1 U31.15(OE#)
N17525467: CON1.2(5V-2) J2.2
N17525501: CON1.1(5V-1) J1.2
N17573836: R204.1 U19.8
N17574098: R201.1 U18.8
N17578091: SR3.2 STP3.1(TP)
N17578095: SR4.2 STP4.1(TP)
N17578103: SR5.2 STP5.1(TP)
N17578107: SC4.1 SK1.7 SR5.1
N17578109: SR6.2 STP6.1(TP)
N17578111: SC1.1 SK1.6 SR2.2
N17578117: SR2.1 STP2.1(TP)
N17578119: SC6.1 SK1.2 SR3.1
N17578121: SC2.1 SK1.3 SR1.2
N17578131: SC3.1 SK1.5 SR6.1
N17578138: SR9.2 STP9.1(TP)
N17578142: SR10.2 STP10.1(TP)
N17578153: SC10.1 SK2.7 SR11.1
N17578155: SR11.2 STP11.1(TP)
N17578165: SR12.2 STP12.1(TP)
N17578169: SC7.1 SK2.6 SR8.2
N17578175: SR8.1 STP8.1(TP)
N17578179: SC12.1 SK2.2 SR9.1
N17578181: SC9.1 SK2.5 SR12.1
N17578183: SC8.1 SK2.3 SR7.2
N17578209: SR7.1 STP7.1(TP)
N17578211: SC11.1 SK2.4 SR10.1
N17578235: SC5.1 SK1.4 SR4.1
N17578245: SR1.1 STP1.1(TP)
N17578251: SR18.2 STP16.1(TP)
N17578253: SR14.2 STP14.1(TP)
N17578257: SC17.1 SK3.7 SR14.1
N17578263: SR17.2 STP15.1(TP)
N17578267: SR13.1 STP18.1(TP)
N17578271: SC14.1 SK3.6 SR13.2
N17578275: SR15.2 STP13.1(TP)
N17578283: SC13.1 SK3.5 SR15.1
N17578291: SC15.1 SK3.3 SR16.2
N17578297: SC18.1 SK3.2 SR17.1
N17578299: SR16.1 STP17.1(TP)
N17578323: SC16.1 SK3.4 SR18.1
N17578329: SR23.2 STP21.1(TP)
N17578337: SR24.2 STP22.1(TP)
N17578341: SR20.2 STP20.1(TP)
N17578345: SC23.1 SK4.7 SR20.1
N17578351: SC19.1 SK4.5 SR21.1
N17578353: SC24.1 SK4.2 SR23.1
N17578355: SR19.1 STP24.1(TP)
N17578359: SC20.1 SK4.6 SR19.2
N17578363: SR21.2 STP19.1(TP)
N17578379: SC21.1 SK4.3 SR22.2
N17578383: SC22.1 SK4.4 SR24.1
N17578387: SR22.1 STP23.1(TP)
N17782373: R980.1 U449.6(OE#)
N17782417: R981.2 R982.2 U449.9(SEL)
N17785968: R983.1 U450.6(OE#)
N17786012: R984.2 R985.2 U450.9(SEL)
N17786363: R986.1 U451.6(OE#)
N17786399: R987.2 R988.2 U451.9(SEL)
N17929646: R1090.1 SITE1.N7(PAD_DRAM_SZQ)
N17930230: K113.1(NC) R1091.1
N17932221: RD1.2 RD9.2 RD20.2 U14.2(SDA) U15.2(SDA)
N17932243: RD2.2 RD10.2 RD19.2 U14.1(SCL) U15.1(SCL)
N17932245: RD4.1 U14.6(CT)
N17932247: RD6.1 U14.5(INT)
N17932257: RD5.2 RD8.2 U14.4(A1)
N17932289: RD3.2 RD7.2 U14.3(A0)
N17932337: RD11.2 RD15.2 U15.3(A0)
N17932339: RD13.2 RD16.2 U15.4(A1)
N17932349: RD12.1 U15.6(CT)
N17932351: RD14.1 U15.5(INT)
N17981963: U453.1(1B) U454.2(1Y)
N17981973: U453.2(2B) U454.4(2Y)
N18039645: MU4.3(EN) R331.2
N18039715: C299.2 MU4.1(FILTER)
N18039717: C300.1 C301.1 MR18.1 MU4.5(OUTS) MU4.6(OUTF)
N18039727: C298.2 MBD1.2 MU4.4(IN)
N18039793: MR1.2 MR7.2 MU1.4(FB)
N18039813: MR8.1 MR9.1 MU3.2(-IN)
N18039885: MK2.1(V+) MR13.2
N18039895: MK1.3 MK2.3 MK3.3 MK4.4
N18039909: MK3.1(V+) MR14.1
N18039916: MK4.1(V+) MR16.2
N18039964: MR9.2 MR10.1
N18039966: MK1.1(V+) MR11.2
N18097849: UNK2CA19.1 UNK2K96.5 UNK2K96.8
N18100710: UNK2R510.2 UNK2R511.1 UNK2U108.1
N18100716: UNK2C475.1 UNK2R510.1 UNK2R512.2 UNK2TP_MUX_3V3.1 UNK2U108.5
N18100717: UNK2R509.1 UNK2U108.3
N18100756: UNK2R162.1 UNK2U31.15
N18101409: SITE2.H3(PAD_AUD_VRM) UNK2BD9.1
N18101478: UNK2MU4.3 UNK2R331.2
N18101512: UNK2C299.2 UNK2MU4.1
N18101513: UNK2C300.1 UNK2C301.1 UNK2MR18.1 UNK2MU4.5 UNK2MU4.6
N18101518: UNK2C298.2 UNK2MBD1.2 UNK2MU4.4
N18101547: UNK2MR1.2 UNK2MR7.2 UNK2MU1.4
N18101557: UNK2MR8.1 UNK2MR9.1 UNK2MU3.2
N18101594: UNK2MK2.1 UNK2MR13.2
N18101599: UNK2MK1.3 UNK2MK2.3 UNK2MK3.3 UNK2MK4.4
N18101606: UNK2MK3.1 UNK2MR14.1
N18101610: UNK2MK4.1 UNK2MR16.2
N18101631: UNK2MR9.2 UNK2MR10.1
N18101632: UNK2MK1.1 UNK2MR11.2
N18101659: UNK2R980.1 UNK2U449.6
N18101670: UNK2R981.2 UNK2R982.2 UNK2U449.9
N18101811: SITE2.N7(PAD_DRAM_SZQ) UNK2R1090.1
N18101818: UNK2K113.1 UNK2R1091.1
N18103944: UNK2R172.1 UNK2U408.A1
N18103947: UNK2R661.1 UNK2U408.B7
N18103951: UNK2R662.1 UNK2U409.A1
N18103954: UNK2R663.1 UNK2U409.B7
N18103979: UNK2R672.1 UNK2U409.C2
N18104018: UNK2R659.1 UNK2U408.C2
N18104833: UNK2R204.1 UNK2U19.8
N18104928: UNK2R201.1 UNK2U18.8
N18104988: UNK2R983.1 UNK2U450.6
N18104999: UNK2R984.2 UNK2R985.2 UNK2U450.9
N18105006: UNK2R986.1 UNK2U451.6
N18105013: UNK2R987.2 UNK2R988.2 UNK2U451.9
N18105072: UNK2R989.1 UNK2U452.6
N18105079: UNK2R990.2 UNK2R991.2 UNK2U452.9
N18105089: UNK2C1066.2 UNK2U452.1
N18105091: UNK2C1067.2 UNK2U452.2
N18106166: UNK3CA19.1 UNK3K96.5 UNK3K96.8
N18109027: UNK3R510.2 UNK3R511.1 UNK3U108.1
N18109033: UNK3C475.1 UNK3R510.1 UNK3R512.2 UNK3TP_MUX_3V3.1 UNK3U108.5
N18109034: UNK3R509.1 UNK3U108.3
N18109073: UNK3R162.1 UNK3U31.15
N18109726: SITE3.H3(PAD_AUD_VRM) UNK3BD9.1
N18109795: UNK3MU4.3 UNK3R331.2
N18109829: UNK3C299.2 UNK3MU4.1
N18109830: UNK3C300.1 UNK3C301.1 UNK3MR18.1 UNK3MU4.5 UNK3MU4.6
N18109835: UNK3C298.2 UNK3MBD1.2 UNK3MU4.4
N18109864: UNK3MR1.2 UNK3MR7.2 UNK3MU1.4
N18109874: UNK3MR8.1 UNK3MR9.1 UNK3MU3.2
N18109911: UNK3MK2.1 UNK3MR13.2
N18109916: UNK3MK1.3 UNK3MK2.3 UNK3MK3.3 UNK3MK4.4
N18109923: UNK3MK3.1 UNK3MR14.1
N18109927: UNK3MK4.1 UNK3MR16.2
N18109948: UNK3MR9.2 UNK3MR10.1
N18109949: UNK3MK1.1 UNK3MR11.2
N18109976: UNK3R980.1 UNK3U449.6
N18109987: UNK3R981.2 UNK3R982.2 UNK3U449.9
N18110128: SITE3.N7(PAD_DRAM_SZQ) UNK3R1090.1
N18110135: UNK3K113.1 UNK3R1091.1
N18112261: UNK3R172.1 UNK3U408.A1
N18112264: UNK3R661.1 UNK3U408.B7
N18112268: UNK3R662.1 UNK3U409.A1
N18112271: UNK3R663.1 UNK3U409.B7
N18112296: UNK3R672.1 UNK3U409.C2
N18112335: UNK3R659.1 UNK3U408.C2
N18113150: UNK3R204.1 UNK3U19.8
N18113245: UNK3R201.1 UNK3U18.8
N18113305: UNK3R983.1 UNK3U450.6
N18113316: UNK3R984.2 UNK3R985.2 UNK3U450.9
N18113323: UNK3R986.1 UNK3U451.6
N18113330: UNK3R987.2 UNK3R988.2 UNK3U451.9
N18113389: UNK3R989.1 UNK3U452.6
N18113396: UNK3R990.2 UNK3R991.2 UNK3U452.9
N18113406: UNK3C1066.2 UNK3U452.1
N18113408: UNK3C1067.2 UNK3U452.2
N18114483: UNK4CA19.1 UNK4K96.5 UNK4K96.8
N18117344: UNK4R510.2 UNK4R511.1 UNK4U108.1
N18117350: UNK4C475.1 UNK4R510.1 UNK4R512.2 UNK4TP_MUX_3V3.1 UNK4U108.5
N18117351: UNK4R509.1 UNK4U108.3
N18117390: UNK4R162.1 UNK4U31.15
N18118043: SITE4.H3(PAD_AUD_VRM) UNK4BD9.1
N18118112: UNK4MU4.3 UNK4R331.2
N18118146: UNK4C299.2 UNK4MU4.1
N18118147: UNK4C300.1 UNK4C301.1 UNK4MR18.1 UNK4MU4.5 UNK4MU4.6
N18118152: UNK4C298.2 UNK4MBD1.2 UNK4MU4.4
N18118181: UNK4MR1.2 UNK4MR7.2 UNK4MU1.4
N18118191: UNK4MR8.1 UNK4MR9.1 UNK4MU3.2
N18118228: UNK4MK2.1 UNK4MR13.2
N18118233: UNK4MK1.3 UNK4MK2.3 UNK4MK3.3 UNK4MK4.4
N18118240: UNK4MK3.1 UNK4MR14.1
N18118244: UNK4MK4.1 UNK4MR16.2
N18118265: UNK4MR9.2 UNK4MR10.1
N18118266: UNK4MK1.1 UNK4MR11.2
N18118293: UNK4R980.1 UNK4U449.6
N18118304: UNK4R981.2 UNK4R982.2 UNK4U449.9
N18118445: SITE4.N7(PAD_DRAM_SZQ) UNK4R1090.1
N18118452: UNK4K113.1 UNK4R1091.1
N18120578: UNK4R172.1 UNK4U408.A1
N18120581: UNK4R661.1 UNK4U408.B7
N18120585: UNK4R662.1 UNK4U409.A1
N18120588: UNK4R663.1 UNK4U409.B7
N18120613: UNK4R672.1 UNK4U409.C2
N18120652: UNK4R659.1 UNK4U408.C2
N18121467: UNK4R204.1 UNK4U19.8
N18121562: UNK4R201.1 UNK4U18.8
N18121622: UNK4R983.1 UNK4U450.6
N18121633: UNK4R984.2 UNK4R985.2 UNK4U450.9
N18121640: UNK4R986.1 UNK4U451.6
N18121647: UNK4R987.2 UNK4R988.2 UNK4U451.9
N18121706: UNK4R989.1 UNK4U452.6
N18121713: UNK4R990.2 UNK4R991.2 UNK4U452.9
N18121723: UNK4C1066.2 UNK4U452.1
N18121725: UNK4C1067.2 UNK4U452.2
N18122800: UNK5CA19.1 UNK5K96.5 UNK5K96.8
N18125661: UNK5R510.2 UNK5R511.1 UNK5U108.1
N18125667: UNK5C475.1 UNK5R510.1 UNK5R512.2 UNK5TP_MUX_3V3.1 UNK5U108.5
N18125668: UNK5R509.1 UNK5U108.3
N18125707: UNK5R162.1 UNK5U31.15
N18126360: SITE5.H3(PAD_AUD_VRM) UNK5BD9.1
N18126429: UNK5MU4.3 UNK5R331.2
N18126463: UNK5C299.2 UNK5MU4.1
N18126464: UNK5C300.1 UNK5C301.1 UNK5MR18.1 UNK5MU4.5 UNK5MU4.6
N18126469: UNK5C298.2 UNK5MBD1.2 UNK5MU4.4
N18126498: UNK5MR1.2 UNK5MR7.2 UNK5MU1.4
N18126508: UNK5MR8.1 UNK5MR9.1 UNK5MU3.2
N18126545: UNK5MK2.1 UNK5MR13.2
N18126550: UNK5MK1.3 UNK5MK2.3 UNK5MK3.3 UNK5MK4.4
N18126557: UNK5MK3.1 UNK5MR14.1
N18126561: UNK5MK4.1 UNK5MR16.2
N18126582: UNK5MR9.2 UNK5MR10.1
N18126583: UNK5MK1.1 UNK5MR11.2
N18126610: UNK5R980.1 UNK5U449.6
N18126621: UNK5R981.2 UNK5R982.2 UNK5U449.9
N18126762: SITE5.N7(PAD_DRAM_SZQ) UNK5R1090.1
N18126769: UNK5K113.1 UNK5R1091.1
N18128895: UNK5R172.1 UNK5U408.A1
N18128898: UNK5R661.1 UNK5U408.B7
N18128902: UNK5R662.1 UNK5U409.A1
N18128905: UNK5R663.1 UNK5U409.B7
N18128930: UNK5R672.1 UNK5U409.C2
N18128969: UNK5R659.1 UNK5U408.C2
N18129784: UNK5R204.1 UNK5U19.8
N18129879: UNK5R201.1 UNK5U18.8
N18129939: UNK5R983.1 UNK5U450.6
N18129950: UNK5R984.2 UNK5R985.2 UNK5U450.9
N18129957: UNK5R986.1 UNK5U451.6
N18129964: UNK5R987.2 UNK5R988.2 UNK5U451.9
N18130023: UNK5R989.1 UNK5U452.6
N18130030: UNK5R990.2 UNK5R991.2 UNK5U452.9
N18130040: UNK5C1066.2 UNK5U452.1
N18130042: UNK5C1067.2 UNK5U452.2
N18131117: UNK6CA19.1 UNK6K96.5 UNK6K96.8
N18133978: UNK6R510.2 UNK6R511.1 UNK6U108.1
N18133984: UNK6C475.1 UNK6R510.1 UNK6R512.2 UNK6TP_MUX_3V3.1 UNK6U108.5
N18133985: UNK6R509.1 UNK6U108.3
N18134024: UNK6R162.1 UNK6U31.15
N18134677: SITE6.H3(PAD_AUD_VRM) UNK6BD9.1
N18134746: UNK6MU4.3 UNK6R331.2
N18134780: UNK6C299.2 UNK6MU4.1
N18134781: UNK6C300.1 UNK6C301.1 UNK6MR18.1 UNK6MU4.5 UNK6MU4.6
N18134786: UNK6C298.2 UNK6MBD1.2 UNK6MU4.4
N18134815: UNK6MR1.2 UNK6MR7.2 UNK6MU1.4
N18134825: UNK6MR8.1 UNK6MR9.1 UNK6MU3.2
N18134862: UNK6MK2.1 UNK6MR13.2
N18134867: UNK6MK1.3 UNK6MK2.3 UNK6MK3.3 UNK6MK4.4
N18134874: UNK6MK3.1 UNK6MR14.1
N18134878: UNK6MK4.1 UNK6MR16.2
N18134899: UNK6MR9.2 UNK6MR10.1
N18134900: UNK6MK1.1 UNK6MR11.2
N18134927: UNK6R980.1 UNK6U449.6
N18134938: UNK6R981.2 UNK6R982.2 UNK6U449.9
N18135079: SITE6.N7(PAD_DRAM_SZQ) UNK6R1090.1
N18135086: UNK6K113.1 UNK6R1091.1
N18137212: UNK6R172.1 UNK6U408.A1
N18137215: UNK6R661.1 UNK6U408.B7
N18137219: UNK6R662.1 UNK6U409.A1
N18137222: UNK6R663.1 UNK6U409.B7
N18137247: UNK6R672.1 UNK6U409.C2
N18137286: UNK6R659.1 UNK6U408.C2
N18138101: UNK6R204.1 UNK6U19.8
N18138196: UNK6R201.1 UNK6U18.8
N18138256: UNK6R983.1 UNK6U450.6
N18138267: UNK6R984.2 UNK6R985.2 UNK6U450.9
N18138274: UNK6R986.1 UNK6U451.6
N18138281: UNK6R987.2 UNK6R988.2 UNK6U451.9
N18138340: UNK6R989.1 UNK6U452.6
N18138347: UNK6R990.2 UNK6R991.2 UNK6U452.9
N18138357: UNK6C1066.2 UNK6U452.1
N18138359: UNK6C1067.2 UNK6U452.2
N18139434: UNK7CA19.1 UNK7K96.5 UNK7K96.8
N18142295: UNK7R510.2 UNK7R511.1 UNK7U108.1
N18142301: UNK7C475.1 UNK7R510.1 UNK7R512.2 UNK7TP_MUX_3V3.1 UNK7U108.5
N18142302: UNK7R509.1 UNK7U108.3
N18142341: UNK7R162.1 UNK7U31.15
N18142994: SITE7.H3(PAD_AUD_VRM) UNK7BD9.1
N18143063: UNK7MU4.3 UNK7R331.2
N18143097: UNK7C299.2 UNK7MU4.1
N18143098: UNK7C300.1 UNK7C301.1 UNK7MR18.1 UNK7MU4.5 UNK7MU4.6
N18143103: UNK7C298.2 UNK7MBD1.2 UNK7MU4.4
N18143132: UNK7MR1.2 UNK7MR7.2 UNK7MU1.4
N18143142: UNK7MR8.1 UNK7MR9.1 UNK7MU3.2
N18143179: UNK7MK2.1 UNK7MR13.2
N18143184: UNK7MK1.3 UNK7MK2.3 UNK7MK3.3 UNK7MK4.4
N18143191: UNK7MK3.1 UNK7MR14.1
N18143195: UNK7MK4.1 UNK7MR16.2
N18143216: UNK7MR9.2 UNK7MR10.1
N18143217: UNK7MK1.1 UNK7MR11.2
N18143244: UNK7R980.1 UNK7U449.6
N18143255: UNK7R981.2 UNK7R982.2 UNK7U449.9
N18143396: SITE7.N7(PAD_DRAM_SZQ) UNK7R1090.1
N18143403: UNK7K113.1 UNK7R1091.1
N18145529: UNK7R172.1 UNK7U408.A1
N18145532: UNK7R661.1 UNK7U408.B7
N18145536: UNK7R662.1 UNK7U409.A1
N18145539: UNK7R663.1 UNK7U409.B7
N18145564: UNK7R672.1 UNK7U409.C2
N18145603: UNK7R659.1 UNK7U408.C2
N18146418: UNK7R204.1 UNK7U19.8
N18146513: UNK7R201.1 UNK7U18.8
N18146573: UNK7R983.1 UNK7U450.6
N18146584: UNK7R984.2 UNK7R985.2 UNK7U450.9
N18146591: UNK7R986.1 UNK7U451.6
N18146598: UNK7R987.2 UNK7R988.2 UNK7U451.9
N18146657: UNK7R989.1 UNK7U452.6
N18146664: UNK7R990.2 UNK7R991.2 UNK7U452.9
N18146674: UNK7C1066.2 UNK7U452.1
N18146676: UNK7C1067.2 UNK7U452.2
N18147751: UNK8CA19.1 UNK8K96.5 UNK8K96.8
N18150612: UNK8R510.2 UNK8R511.1 UNK8U108.1
N18150618: UNK8C475.1 UNK8R510.1 UNK8R512.2 UNK8TP_MUX_3V3.1 UNK8U108.5
N18150619: UNK8R509.1 UNK8U108.3
N18150658: UNK8R162.1 UNK8U31.15
N18151311: SITE8.H3(PAD_AUD_VRM) UNK8BD9.1
N18151380: UNK8MU4.3 UNK8R331.2
N18151414: UNK8C299.2 UNK8MU4.1
N18151415: UNK8C300.1 UNK8C301.1 UNK8MR18.1 UNK8MU4.5 UNK8MU4.6
N18151420: UNK8C298.2 UNK8MBD1.2 UNK8MU4.4
N18151449: UNK8MR1.2 UNK8MR7.2 UNK8MU1.4
N18151459: UNK8MR8.1 UNK8MR9.1 UNK8MU3.2
N18151496: UNK8MK2.1 UNK8MR13.2
N18151501: UNK8MK1.3 UNK8MK2.3 UNK8MK3.3 UNK8MK4.4
N18151508: UNK8MK3.1 UNK8MR14.1
N18151512: UNK8MK4.1 UNK8MR16.2
N18151533: UNK8MR9.2 UNK8MR10.1
N18151534: UNK8MK1.1 UNK8MR11.2
N18151561: UNK8R980.1 UNK8U449.6
N18151572: UNK8R981.2 UNK8R982.2 UNK8U449.9
N18151713: SITE8.N7(PAD_DRAM_SZQ) UNK8R1090.1
N18151720: UNK8K113.1 UNK8R1091.1
N18153846: UNK8R172.1 UNK8U408.A1
N18153849: UNK8R661.1 UNK8U408.B7
N18153853: UNK8R662.1 UNK8U409.A1
N18153856: UNK8R663.1 UNK8U409.B7
N18153881: UNK8R672.1 UNK8U409.C2
N18153920: UNK8R659.1 UNK8U408.C2
N18154735: UNK8R204.1 UNK8U19.8
N18154830: UNK8R201.1 UNK8U18.8
N18154890: UNK8R983.1 UNK8U450.6
N18154901: UNK8R984.2 UNK8R985.2 UNK8U450.9
N18154908: UNK8R986.1 UNK8U451.6
N18154915: UNK8R987.2 UNK8R988.2 UNK8U451.9
N18154974: UNK8R989.1 UNK8U452.6
N18154981: UNK8R990.2 UNK8R991.2 UNK8U452.9
N18154991: UNK8C1066.2 UNK8U452.1
N18154993: UNK8C1067.2 UNK8U452.2
N18278718: R989.1 U452.6(OE#)
N18278732: R990.2 R991.2 U452.9(SEL)
N18278758: C1066.2 U452.1(USB+)
N18278790: C1067.2 U452.2(USB-)
N18477102: U79.6(3Y) U80.3(3B)
N18477108: U79.4(2Y) U80.2(2B)
N18477229: U79.10(5Y) U405.2(2B)
N18477291: U79.8(4Y) U405.1(1B)
N18477301: U79.12(6Y) U405.3(3B)
N18479086: U414.10(5Y) U415.2(2B)
N18479100: U413.3(3B) U414.6(3Y)
N18479120: U413.1(1B) U414.2(1Y)
N18479142: U413.2(2B) U414.4(2Y)
N18479202: U414.8(4Y) U415.1(1B)
N18479218: U414.12(6Y) U415.3(3B)
N18480061: R601.1 U403.13(2A2)
N18480064: R602.1 U403.11(2A3)
N18480115: BD1721.2 C894.1 C895.1 R933.1 R934.1 R935.1 R936.1 R937.1 R938.1 R939.1 R940.1 U403.20(VCC)
N18480820: BD1722.2 C983.1 C984.1 R941.1 R942.1 R943.1 R944.1 R945.1 R946.1 R947.1 R948.1 U434.20(VCC)
N18480908: R758.1 U434.4(1A1)
N18480914: R753.1 U434.6(1A2)
N18480920: R755.1 U434.8(1A3)
N18480930: R757.1 U434.17(2A0)
N18480954: R751.1 U434.2(1A0)
N18480970: R752.1 U434.15(2A1)
N18480990: R754.1 U434.13(2A2)
N18480996: R756.1 U434.11(2A3)
N18482064: BD1723.2 C985.1 C986.1 R950.1 R952.1 U435.20(VCC)
N18482160: R766.1 U435.4(1A1)
N18482210: R759.1 U435.2(1A0)
N19145542: SR30.2 STP28.1(TP)
N19145546: SR26.2 STP26.1(TP)
N19145550: SC29.1 SK5.7 SR26.1
N19145556: SR29.2 STP27.1(TP)
N19145558: SC30.1 SK5.2 SR29.1
N19145560: SR25.1 STP30.1(TP)
N19145564: SC26.1 SK5.6 SR25.2
N19145568: SR27.2 STP25.1(TP)
N19145576: SC25.1 SK5.5 SR27.1
N19145584: SC27.1 SK5.3 SR28.2
N19145590: SC28.1 SK5.4 SR30.1
N19145592: SR28.1 STP29.1(TP)
N19145780: SR36.2 STP34.1(TP)
N19145784: SR35.2 STP33.1(TP)
N19145790: SR33.2 STP31.1(TP)
N19145800: SR32.2 STP32.1(TP)
N19145804: SC35.1 SK6.7 SR32.1
N19145813: SC33.1 SK6.3 SR34.2
N19145817: SC31.1 SK6.5 SR33.1
N19145819: SC36.1 SK6.2 SR35.1
N19145821: SR31.1 STP36.1(TP)
N19145825: SC32.1 SK6.6 SR31.2
N19145869: SC34.1 SK6.4 SR36.1
N19145875: SR34.1 STP35.1(TP)
N19146153: SR41.2 STP39.1(TP)
N19146155: SR39.2 STP37.1(TP)
N19146167: SR42.2 STP41.1(TP)
N19146177: SC37.1 SK7.5 SR39.1
N19146179: SC39.1 SK7.3 SR40.2
N19146183: SC41.1 SK7.7 SR38.1
N19146185: SR38.2 STP38.1(TP)
N19146193: SC42.1 SK7.2 SR41.1
N19146199: SC38.1 SK7.6 SR37.2
N19146205: SR37.1 STP42.1(TP)
N19146217: SC40.1 SK7.4 SR42.1
N19146247: SR40.1 STP40.1(TP)
N19146496: SR47.2 STP45.1(TP)
N19146500: SR48.2 STP47.1(TP)
N19146502: SR44.2 STP44.1(TP)
N19146512: SR45.2 STP43.1(TP)
N19146518: SC44.1 SK8.6 SR43.2
N19146522: SR43.1 STP48.1(TP)
N19146524: SC48.1 SK8.2 SR47.1
N19146526: SC43.1 SK8.5 SR45.1
N19146528: SC45.1 SK8.3 SR46.2
N19146532: SC47.1 SK8.7 SR44.1
N19146554: SR46.1 STP46.1(TP)
N19146556: SC46.1 SK8.4 SR48.1
N19656281: BD5.2 C400.1 C401.1 R925.1 R926.1 R927.1 R928.1 R929.1 R930.1 R931.1 R932.1 U70.20(VCC)
N22558607: R400.1 U70.2(1A0)
N22558620: R404.1 U71.3(CE)
N22558621: C402.1 R402.1 R403.2 U71.5(VOUT) UBIT_3V3_UP.1(TP)
N22558623: R401.1 R402.2 U71.1(ADJ)
N23535319: LDB1.1(A) LRB1.2
N23799274: U73.2(1Y) U74.1(1B)
N23799277: U73.4(2Y) U74.2(2B)
N23799280: U73.6(3Y) U74.3(3B)
N23799283: U72.1(1B) U73.8(4Y)
N23799286: U72.2(2B) U73.10(5Y)
N23799289: U72.3(3B) U73.12(6Y)
N23799348: U76.2(1Y) U77.1(1B)
N23799351: U76.4(2Y) U77.2(2B)
N23799354: U76.6(3Y) U77.3(3B)
N23799357: U75.1(1B) U76.8(4Y)
N23799360: U75.2(2B) U76.10(5Y)
N23799363: U75.3(3B) U76.12(6Y)
N30783219: U79.2(1Y) U80.1(1B)
N31842551: R589.1 U70.4(1A1)
N31842593: R590.1 U70.6(1A2)
N31842638: R591.1 U70.8(1A3)
N31842671: R592.1 U70.17(2A0)
N31842704: R593.1 U70.15(2A1)
N31842737: R594.1 U70.13(2A2)
N31842770: R595.1 U70.11(2A3)
N31842787: R596.1 U403.4(1A1)
N31842830: R597.1 U403.6(1A2)
N31842855: R598.1 U403.8(1A3)
N31842884: R599.1 U403.17(2A0)
N31842923: R603.1 U403.2(1A0)
N31842948: R600.1 U403.15(2A1)
