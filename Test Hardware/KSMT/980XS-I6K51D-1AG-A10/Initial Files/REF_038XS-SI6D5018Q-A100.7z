# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
DGND on BOTTOM: 236.78,243.1 236.78,239.52 235.41,238.15 231.17,238.15 229.69,236.68 229.69,218.41 230.23,217.88 237.87,217.88 238.89,218.9 238.89,223.06 240.73,224.91 240.73,245.04 240.33,245.45 239.28,245.45 238.89,245.05 238.89,243.47 238.61,243.2 236.87,243.2 ; 1 cut-out
DGND on BOTTOM: 266.94,252.04 266.94,263.11 267.69,263.85 268.51,263.85 269.03,264.38 269.03,267.46 268.6,267.89 268.6,273.74 269.72,274.85 274.01,274.85 274.65,274.22 274.65,267.04 276.94,264.75 276.94,253.6 275.94,252.6 273.93,252.6 271.9,250.57 269.23,250.57 269.11,250.7 269.11,250.95 269.48,251.33 271.31,251.33 271.39,251.42 271.39,251.92 270.38,251.92 270.37,251.91 270.36,251.92 267.06,251.92 ; 2 cut-outs
DGND on BOTTOM: 306.94,252.04 306.94,263.11 307.68,263.85 308.51,263.85 309.03,264.38 309.03,267.46 308.6,267.89 308.6,273.74 309.72,274.85 314.01,274.85 314.65,274.22 314.65,267.04 316.94,264.75 316.94,253.6 315.94,252.6 313.93,252.6 311.9,250.57 309.23,250.57 309.11,250.7 309.11,250.95 309.48,251.33 311.31,251.33 311.39,251.42 311.39,251.92 310.38,251.92 310.37,251.91 310.36,251.92 307.06,251.92 ; 2 cut-outs
DGND on BOTTOM: 226.94,252.04 226.94,263.11 227.69,263.85 228.51,263.85 229.03,264.38 229.03,267.46 228.6,267.89 228.6,273.74 229.72,274.85 234.01,274.85 234.65,274.22 234.65,267.04 236.94,264.75 236.94,253.6 235.94,252.6 233.93,252.6 231.9,250.57 229.23,250.57 229.11,250.7 229.11,250.95 229.48,251.33 231.31,251.33 231.39,251.42 231.39,251.92 230.38,251.92 230.37,251.91 230.36,251.92 227.06,251.92 ; 2 cut-outs
DGND on BOTTOM: 356.78,183.1 356.78,179.52 355.41,178.15 351.17,178.15 349.69,176.68 349.69,158.41 350.23,157.88 357.87,157.88 358.89,158.9 358.89,163.06 360.73,164.91 360.73,185.04 360.33,185.45 359.28,185.45 358.89,185.05 358.89,183.47 358.61,183.2 356.87,183.2 ; 1 cut-out
DGND on BOTTOM: 226.94,192.04 226.94,203.11 227.69,203.85 228.51,203.85 229.03,204.38 229.03,207.46 228.6,207.89 228.6,213.74 229.72,214.85 234.01,214.85 234.65,214.22 234.65,207.04 236.94,204.75 236.94,193.6 235.94,192.6 233.93,192.6 231.9,190.57 229.23,190.57 229.11,190.7 229.11,190.95 229.48,191.33 231.31,191.33 231.39,191.42 231.39,191.92 230.38,191.92 230.37,191.91 230.36,191.92 227.06,191.92 ; 2 cut-outs
DGND on BOTTOM: 316.78,183.1 316.78,179.52 315.41,178.15 311.17,178.15 309.69,176.68 309.69,158.41 310.23,157.88 317.87,157.88 318.89,158.9 318.89,163.06 320.73,164.91 320.73,185.04 320.33,185.45 319.28,185.45 318.89,185.05 318.89,183.47 318.61,183.2 316.87,183.2 ; 1 cut-out
DGND on BOTTOM: 276.78,243.1 276.78,239.52 275.41,238.15 271.17,238.15 269.69,236.68 269.69,218.41 270.23,217.88 277.87,217.88 278.89,218.9 278.89,223.06 280.73,224.91 280.73,245.04 280.33,245.45 279.28,245.45 278.89,245.05 278.89,243.47 278.61,243.2 276.87,243.2 ; 1 cut-out
DGND on L02_GND, L04_GND, L06_GND, L08_GND, L10_GND, L12_GND, L14_GND, L16_GND, L18_GND, L20_GND, L22_GND, L24_GND, L26_GND, L28_GND, L30_GND: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02
DGND on L03_DPS: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 131 cut-outs
DGND on L07_DPS: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 92 cut-outs
DGND on L21_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 394 cut-outs
DGND on L23_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 197 cut-outs
(no net) on L05_DPS: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 191 cut-outs
(no net) on L09_DPS: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 142 cut-outs
(no net) on L11_DPS: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 148 cut-outs
(no net) on L13_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 308 cut-outs
(no net) on L15_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 86 cut-outs
(no net) on L17_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 60 cut-outs
(no net) on L19_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 399 cut-outs
(no net) on L25_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 134 cut-outs
(no net) on L27_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 108 cut-outs
(no net) on L29_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 142 cut-outs
(no net) on L31_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 108 cut-outs
(no net) on L32_GND, L34_GND, L35_DPS, L37_GND: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02
(no net) on L33_SIGNAL: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 229 cut-outs
(no net) on L36_UDB: 302.07,1.02 290.83,6.67 279.59,1.02 1.02,1.02 1.02,428.24 205.93,428.24 217.17,422.59 228.41,428.24 353.25,428.24 364.49,422.59 375.73,428.24 580.64,428.24 580.64,1.02 ; 40 cut-outs
CSDPS303P1 on L09_DPS: 293.98,36.37 291.21,39.15 291.21,179.45 292.55,180.79 309.26,180.79 309.44,180.97 309.44,181.96 309.59,182.11 312.61,182.11 312.87,181.86 312.87,177.05 312.86,177.02 312.86,176.53 312.65,176.33 312.65,171.19 307.72,166.25 307.72,102.99 305.75,101.03 305.75,49.84 306.28,49.3 310.63,49.3 311.48,48.45 311.48,37.64 310.22,36.37
CSDPS303P3 on L05_DPS: 312.08,36.37 310.82,37.64 310.82,48.45 311.67,49.3 316.02,49.3 316.55,49.84 316.55,102.09 301.37,117.28 301.37,172.38 295.29,178.46 295.29,191.47 298.29,194.46 300.07,194.46 302.2,196.6 317.64,196.6 318.61,195.63 318.61,192.83 316.47,190.7 316.47,188.29 316.09,187.9 316.09,187.02 315.61,186.53 309.01,186.53 308.8,186.74 308.8,190.65 308.24,191.21 304.54,191.21 302.91,189.59 302.91,177.55 305.4,175.06 315.41,175.06 317.87,172.59 317.87,144.65 317.36,144.14 317.36,127.26 328.88,115.75 328.88,36.93 328.35,36.4 327.67,36.4 327.64,36.37
CSDPS303P6 on L11_DPS: 307.36,46.53 307.33,46.56 306.65,46.56 306.12,47.09 306.12,92.74 291.23,107.62 291.23,171.7 301.62,182.09 312.62,182.09 312.87,181.84 312.87,173.2 306.67,167 306.67,121.77 318.45,109.99 318.45,60 318.98,59.46 323.33,59.46 324.18,58.61 324.18,47.8 322.92,46.53
CSDPS303P9 on L09_DPS: 314.98,36.37 314.95,36.4 314.27,36.4 313.74,36.93 313.74,47.96 311.02,50.67 311.02,100.58 311.91,101.47 311.91,143.64 310.89,144.66 310.89,166.75 315.08,170.94 315.08,178.73 314.67,179.15 314.67,182.47 314.52,182.62 309.67,182.62 309.62,182.57 309.62,182.21 309.36,181.96 307.74,181.96 307.72,181.99 307.1,181.99 306.87,182.21 306.87,190.09 308.55,191.77 328.42,191.77 328.79,191.4 328.79,104.57 326.07,101.85 326.07,49.84 326.6,49.3 330.95,49.3 331.8,48.45 331.8,37.64 330.54,36.37
CSDPS303P11 on L05_DPS: 332.4,36.37 331.14,37.64 331.14,48.45 331.99,49.3 336.34,49.3 336.87,49.84 336.87,112.84 319.98,129.73 319.98,143.12 319.47,143.62 319.47,174.8 316.37,177.9 306.36,177.9 304.99,179.27 304.99,190.09 305.3,190.39 307.94,190.39 308.3,190.04 308.3,185.44 308.4,185.34 328.62,185.34 330.06,183.9 330.06,173.86 330.57,173.35 330.57,142 349.2,123.37 349.2,36.93 348.67,36.4 347.99,36.4 347.96,36.37
CSDPS303P13 on L07_DPS: 325.14,36.37 325.11,36.4 307.29,36.4 305.97,37.72 305.97,109.45 293.36,122.05 293.36,188.09 295.67,190.39 317.73,190.39 320.86,187.26 320.86,168.49 327.28,162.07 327.28,127.13 336.23,118.17 336.23,49.84 336.76,49.3 341.11,49.3 341.96,48.45 341.96,37.64 340.7,36.37
CSDPS303P14 on L11_DPS: 330.22,46.53 330.19,46.56 329.51,46.56 328.98,47.09 328.98,111.86 312.76,128.08 312.76,168.44 316.2,171.88 316.2,186.59 315.62,187.17 311.68,187.17 311.42,187.43 311.42,192.43 312.01,193.01 327.2,193.01 328.77,191.44 328.77,133.3 341.31,120.76 341.31,60 341.84,59.46 346.19,59.46 347.04,58.61 347.04,47.8 345.78,46.53
CSDPS303P15 on L03_DPS: 304.26,31.64 303.54,32.36 303.54,112.76 289.17,127.13 289.17,185.12 290.18,186.13 302.91,186.13 305.02,188.23 305.02,189.94 305.62,190.54 317.15,190.54 319.01,188.67 319.01,153.65 341.31,131.36 341.31,51.82 341.21,51.82 341.31,51.71 341.31,49.84 341.84,49.3 346.19,49.3 347.04,48.45 347.04,37.64 346.75,37.34 347.04,37.04 347.04,32.45 346.23,31.64
CSDPS307P1 on L09_DPS: 367.64,36.37 367.08,36.93 367.08,90.75 331.21,126.63 331.21,179.45 332.55,180.79 349.26,180.79 349.44,180.97 349.44,181.96 349.59,182.11 352.61,182.11 352.87,181.86 352.87,177.05 352.86,177.02 352.86,176.53 352.65,176.33 352.65,171.19 347.72,166.25 347.72,138.49 379.41,106.79 379.41,49.84 379.94,49.3 384.29,49.3 385.14,48.45 385.14,37.64 383.88,36.37
CSDPS307P3 on L05_DPS: 385.74,36.37 384.48,37.64 384.48,48.45 385.33,49.3 389.68,49.3 390.21,49.84 390.21,85.28 341.37,134.12 341.37,172.38 335.29,178.46 335.29,191.47 338.29,194.46 340.07,194.46 342.2,196.6 357.64,196.6 358.61,195.63 358.61,192.83 356.47,190.7 356.47,188.29 356.09,187.9 356.09,187.02 355.61,186.53 349.01,186.53 348.8,186.74 348.8,190.65 348.24,191.21 344.54,191.21 342.91,189.59 342.91,177.55 345.4,175.06 355.41,175.06 357.87,172.59 357.87,144.65 357.36,144.14 357.36,135.27 389.38,103.25 391.03,103.25 402.54,91.74 402.54,36.93 402.01,36.4 401.33,36.4 401.3,36.37
CSDPS307P6 on L11_DPS: 381.02,46.53 380.99,46.56 380.31,46.56 379.78,47.09 379.78,90.27 331.23,138.82 331.23,171.7 341.62,182.09 352.62,182.09 352.87,181.84 352.87,173.2 346.67,167 346.67,145.17 392.11,99.73 392.11,60 392.64,59.46 396.99,59.46 397.84,58.61 397.84,47.8 396.58,46.53
CSDPS307P9 on L09_DPS: 388.64,36.37 388.61,36.4 387.93,36.4 387.4,36.93 387.4,104.6 352.6,139.4 352.6,140.64 350.89,142.36 350.89,166.75 355.08,170.94 355.08,178.73 354.67,179.15 354.67,182.47 354.52,182.62 349.67,182.62 349.62,182.57 349.62,182.21 349.36,181.96 347.74,181.96 347.72,181.99 347.1,181.99 346.87,182.21 346.87,190.09 348.55,191.77 368.43,191.77 368.79,191.4 368.79,147.72 399.73,116.78 399.73,49.84 400.26,49.3 404.61,49.3 405.46,48.45 405.46,37.64 404.2,36.37
CSDPS307P11 on L05_DPS: 406.06,36.37 404.8,37.64 404.8,48.45 405.65,49.3 410,49.3 410.53,49.84 410.53,90.99 396.65,104.88 392.68,104.88 392.68,104.77 360.22,137.24 360.22,142.44 359.47,143.2 359.47,174.8 356.37,177.9 346.36,177.9 344.99,179.27 344.99,190.09 345.3,190.39 347.94,190.39 348.29,190.04 348.29,185.44 348.4,185.34 368.62,185.34 370.06,183.9 370.06,173.86 370.57,173.35 370.57,153.54 422.86,101.25 422.86,36.93 422.33,36.4 421.65,36.4 421.62,36.37
CSDPS307P13 on L07_DPS: 398.8,36.37 398.77,36.4 380.95,36.4 379.63,37.72 379.63,82.02 333.36,128.28 333.36,188.09 335.67,190.39 357.73,190.39 360.86,187.26 360.86,168.49 367.28,162.07 367.28,130.38 409.89,87.76 409.89,49.84 410.42,49.3 414.77,49.3 415.62,48.45 415.62,37.64 414.36,36.37
CSDPS307P14 on L11_DPS: 403.88,46.53 403.85,46.56 403.17,46.56 402.64,47.09 402.64,101.12 374.01,129.74 367.49,129.74 352.76,144.47 352.76,168.44 356.2,171.88 356.2,186.59 355.62,187.17 351.68,187.17 351.42,187.43 351.42,192.43 352.01,193.01 367.2,193.01 368.77,191.44 368.77,151.44 414.97,105.25 414.97,60 415.5,59.46 419.85,59.46 420.7,58.61 420.7,47.8 419.44,46.53
CSDPS307P15 on L03_DPS: 377.92,31.64 377.2,32.36 377.2,101.87 329.17,149.9 329.17,185.12 330.18,186.13 342.91,186.13 345.02,188.23 345.02,189.94 345.62,190.54 357.15,190.54 359.01,188.67 359.01,157.01 388.91,127.11 399.88,127.11 414.97,112.03 414.97,49.84 415.5,49.3 419.85,49.3 420.7,48.45 420.7,37.64 420.41,37.34 420.7,37.04 420.7,32.45 419.89,31.64
CSDPS310P1 on L03_DPS: 331.21,221.11 330.19,222.12 330.19,231.65 329.17,232.66 329.17,245.12 330.18,246.13 342.91,246.13 345.02,248.23 345.02,249.94 345.62,250.54 371.37,250.54 384.26,263.44 384.26,297.98 379.74,302.5 379.74,376.19 380.56,377 422.53,377 423.24,376.28 423.24,360.49 422.39,359.64 418.04,359.64 417.51,359.1 417.51,233.36 405.26,221.11 357.25,221.11 357.25,222.03 356.32,221.11
CSDPS310P3 on L05_DPS: 346.42,237.85 344.99,239.27 344.99,250.09 345.3,250.39 347.94,250.39 348.29,250.04 348.29,245.44 348.4,245.34 356.02,245.34 358.51,247.83 358.51,265.68 361.3,268.48 361.3,288.02 400.1,326.82 400.1,372.01 400.63,372.54 401.31,372.54 401.34,372.57 416.9,372.57 418.16,371.3 418.16,360.49 417.31,359.64 412.96,359.64 412.43,359.1 412.43,319.75 375.27,282.59 375.27,239.52 373.59,237.85
CSDPS310P4 on L11_DPS: 345.78,247.17 345.13,247.82 345.13,266.55 341.11,270.57 341.11,284.31 405.18,348.39 405.18,361.85 405.71,362.38 406.39,362.38 406.42,362.41 421.98,362.41 423.24,361.14 423.24,350.33 422.39,349.48 418.04,349.48 417.51,348.94 417.51,327.19 385.47,295.15 371.18,295.15 358.76,282.73 358.76,249.17 357.41,247.83 352.18,247.83 352.1,247.75 352.1,247.45 351.83,247.17
CSDPS310P5 on L07_DPS: 343.93,239.52 340.8,242.65 340.8,260.99 334.38,267.4 334.38,302.58 377.95,346.15 377.95,370.94 379.55,372.54 396.23,372.54 396.26,372.57 411.82,372.57 413.08,371.3 413.08,360.49 412.23,359.64 407.88,359.64 407.35,359.1 407.35,344.97 366,303.62 366,247.65 360.94,242.6 360.94,240.97 359.5,239.52
CSDPS310P7 on L09_DPS: 347.1,241.99 346.87,242.21 346.87,253.54 355.18,261.84 355.18,294.57 386.23,325.63 387.73,325.63 407.99,345.89 407.99,359.1 407.46,359.64 403.11,359.64 402.26,360.49 402.26,371.3 403.52,372.57 419.08,372.57 419.11,372.54 419.79,372.54 420.32,372.01 420.32,332.05 369.55,281.29 369.55,245.03 368.41,243.89 357.88,243.89 356.61,242.62 349.06,242.62 348.93,242.49 348.93,242.16 348.75,241.99
CSDPS310P11 on L05_DPS: 349.01,246.53 348.8,246.74 348.8,250.88 348.24,251.43 346.57,251.43 344.28,253.72 344.28,258.78 339.08,263.98 339.08,266.45 338.32,267.21 338.32,294.22 379.78,335.69 379.78,372.01 380.31,372.54 380.99,372.54 381.02,372.57 396.58,372.57 397.84,371.3 397.84,360.49 396.99,359.64 392.64,359.64 392.11,359.1 392.11,325.41 356.47,289.77 356.47,248.28 356.09,247.9 356.09,247.01 355.61,246.53
CSDPS310P14 on L11_DPS: 333.49,239.37 331.33,241.53 331.33,296.08 382.32,347.07 382.32,361.85 382.85,362.38 383.53,362.38 383.56,362.41 399.12,362.41 400.38,361.14 400.38,350.33 399.53,349.48 395.18,349.48 394.65,348.94 394.65,339.1 340.34,284.79 340.34,284.61 340.37,284.58 340.37,270.38 344.33,266.42 344.33,246.63 345.63,245.34 352.64,245.34 352.87,245.12 352.87,239.62 352.61,239.37
CSDPS310P15 on L09_DPS: 334.88,235.97 331.76,239.09 331.76,247.22 331.05,247.93 331.05,264.31 330.95,264.41 330.95,302.76 373.89,345.69 384.05,345.69 387.67,349.31 387.67,359.1 387.14,359.64 382.79,359.64 381.94,360.49 381.94,371.3 383.2,372.57 398.76,372.57 398.79,372.54 399.47,372.54 400,372.01 400,345.11 352.54,297.65 352.54,290.83 352.54,262.38 343.46,253.3 343.46,241.38 344.05,240.79 349.26,240.79 349.44,240.97 349.44,241.96 349.59,242.11 352.61,242.11 352.87,241.86 352.87,237.05 352.79,236.85 351.9,235.97
CSDPS314P1 on L03_DPS: 291.21,221.11 290.19,222.12 290.19,231.65 289.17,232.66 289.17,245.12 290.18,246.13 302.91,246.13 305.02,248.23 305.02,249.94 305.62,250.54 310.31,250.54 313,253.24 313,263.62 320.55,271.16 320.55,307.93 306.08,322.4 306.08,376.19 306.9,377 348.87,377 349.58,376.28 349.58,360.49 348.73,359.64 344.38,359.64 343.85,359.1 343.85,325.69 380.52,289.03 380.52,270.14 374.28,263.91 352.31,263.91 341.49,253.09 329.21,253.09 327.49,251.37 327.49,223.2 325.4,221.11
CSDPS314P3 on L05_DPS: 306.42,237.85 304.99,239.27 304.99,250.09 305.3,250.39 307.94,250.39 308.3,250.04 308.3,245.44 308.4,245.34 316.02,245.34 318.51,247.83 318.51,265.68 321.3,268.48 321.3,300.23 320.17,301.36 320.17,321.13 326.44,327.41 326.44,372.01 326.97,372.54 327.65,372.54 327.68,372.57 343.24,372.57 344.5,371.3 344.5,360.49 343.65,359.64 339.3,359.64 338.77,359.1 338.77,300.06 335.27,296.56 335.27,239.52 333.59,237.85
CSDPS314P4 on L11_DPS: 305.78,247.17 305.13,247.82 305.13,266.55 301.11,270.57 301.11,312.66 331.52,343.08 331.52,361.85 332.05,362.38 332.73,362.38 332.76,362.41 348.32,362.41 349.58,361.14 349.58,350.33 348.73,349.48 344.38,349.48 343.85,348.94 343.85,326.87 318.71,301.73 318.71,283.26 318.76,283.21 318.76,249.17 317.41,247.83 312.18,247.83 312.11,247.75 312.11,247.45 311.83,247.17
CSDPS314P5 on L07_DPS: 303.93,239.52 300.8,242.65 300.8,260.99 294.38,267.4 294.38,332.89 304.29,342.8 304.29,370.94 305.89,372.54 322.57,372.54 322.6,372.57 338.16,372.57 339.42,371.3 339.42,360.49 338.57,359.64 334.22,359.64 333.69,359.1 333.69,325.11 326,317.41 326,247.65 320.94,242.6 320.94,240.97 319.5,239.52
CSDPS314P7 on L09_DPS: 307.1,241.99 306.87,242.21 306.87,253.54 315.18,261.84 315.18,314.29 334.33,333.44 334.33,359.1 333.8,359.64 329.45,359.64 328.6,360.49 328.6,371.3 329.86,372.57 345.42,372.57 345.45,372.54 346.13,372.54 346.66,372.01 346.66,324.56 329.55,307.46 329.55,245.03 328.41,243.89 317.88,243.89 316.61,242.62 309.06,242.62 308.93,242.49 308.93,242.16 308.75,241.99
CSDPS314P11 on L05_DPS: 309.01,246.53 308.8,246.74 308.8,250.88 308.24,251.43 306.57,251.43 304.28,253.72 304.28,258.78 299.08,263.98 299.08,266.45 298.32,267.21 298.32,312.03 306.12,319.84 306.12,372.01 306.65,372.54 307.33,372.54 307.36,372.57 322.92,372.57 324.18,371.3 324.18,360.49 323.33,359.64 318.98,359.64 318.45,359.1 318.45,300.93 315.98,298.45 315.98,280.67 316.48,280.16 316.48,277.38 316.47,277.37 316.47,248.28 316.09,247.9 316.09,247.01 315.61,246.53
CSDPS314P14 on L11_DPS: 293.49,239.37 291.33,241.53 291.33,331.33 308.66,348.67 308.66,361.85 309.19,362.38 309.87,362.38 309.9,362.41 325.46,362.41 326.72,361.14 326.72,350.33 325.87,349.48 321.52,349.48 320.99,348.94 320.99,334.42 300.37,313.79 300.37,270.38 304.33,266.42 304.33,246.63 305.63,245.34 312.64,245.34 312.87,245.12 312.87,239.62 312.61,239.37
CSDPS314P15 on L09_DPS: 294.88,235.97 291.76,239.09 291.76,247.22 291.05,247.93 291.05,264.31 290.95,264.41 290.95,326 314.01,349.06 314.01,359.1 313.48,359.64 309.13,359.64 308.28,360.49 308.28,371.3 309.54,372.57 325.1,372.57 325.13,372.54 325.81,372.54 326.34,372.01 326.34,337.39 312.31,323.36 312.31,291.06 312.54,290.83 312.54,262.38 303.46,253.3 303.46,241.38 304.05,240.79 309.26,240.79 309.44,240.97 309.44,241.96 309.59,242.11 312.61,242.11 312.87,241.86 312.87,237.05 312.79,236.85 311.9,235.97
CSDPS319P1 on L09_DPS: 146.66,36.37 146.1,36.93 146.1,83.62 211.21,148.72 211.21,179.45 212.55,180.79 229.26,180.79 229.44,180.97 229.44,181.96 229.59,182.11 232.61,182.11 232.87,181.86 232.87,177.05 232.86,177.02 232.86,176.53 232.65,176.33 232.65,171.19 227.72,166.25 227.72,137.42 158.43,68.13 158.43,49.84 158.96,49.3 163.31,49.3 164.16,48.45 164.16,37.64 162.9,36.37
CSDPS319P3 on L05_DPS: 164.76,36.37 163.5,37.64 163.5,48.45 164.35,49.3 168.7,49.3 169.23,49.84 169.23,96.97 221.37,149.1 221.37,172.38 215.29,178.46 215.29,191.47 218.29,194.46 220.07,194.46 222.2,196.6 237.64,196.6 238.61,195.63 238.61,192.83 236.47,190.7 236.47,188.29 236.09,187.9 236.09,187.02 235.61,186.53 229.01,186.53 228.8,186.74 228.8,190.65 228.24,191.21 224.54,191.21 222.91,189.59 222.91,177.55 225.4,175.06 235.41,175.06 237.87,172.59 237.87,144.65 237.36,144.14 237.36,141.96 181.56,86.16 181.56,36.93 181.03,36.4 180.35,36.4 180.32,36.37
CSDPS319P6 on L11_DPS: 160.04,46.53 160.01,46.56 159.33,46.56 158.8,47.09 158.8,96.9 211.23,149.33 211.23,171.7 221.62,182.09 232.62,182.09 232.87,181.84 232.87,173.2 226.67,167 226.67,135.11 171.13,79.56 171.13,60 171.66,59.46 176.01,59.46 176.86,58.61 176.86,47.8 175.6,46.53
CSDPS319P9 on L09_DPS: 167.66,36.37 167.63,36.4 166.95,36.4 166.42,36.93 166.42,66.34 185.79,85.71 226.82,125.98 232.41,131.57 232.41,143.76 230.89,145.29 230.89,166.75 235.08,170.94 235.08,178.73 234.67,179.15 234.67,182.47 234.52,182.62 229.67,182.62 229.62,182.57 229.62,182.21 229.36,181.96 227.74,181.96 227.72,181.99 227.1,181.99 226.87,182.21 226.87,190.09 228.55,191.77 248.41,191.77 248.79,191.39 248.79,120.4 194.94,66.55 185.67,66.55 178.75,59.63 178.75,49.84 179.28,49.3 183.63,49.3 184.48,48.45 184.48,37.64 183.22,36.37
CSDPS319P11 on L05_DPS: 185.08,36.37 183.82,37.64 183.82,48.45 184.67,49.3 189.02,49.3 189.55,49.84 189.55,82.79 202.62,95.86 202.62,103.15 240.39,140.92 240.39,143.1 239.47,144.02 239.47,174.8 236.37,177.9 226.36,177.9 224.99,179.27 224.99,190.09 225.3,190.39 227.94,190.39 228.3,190.04 228.3,185.44 228.4,185.34 248.62,185.34 250.06,183.9 250.06,173.86 250.57,173.35 250.57,127.13 201.88,78.44 201.88,36.93 201.35,36.4 200.67,36.4 200.64,36.37
CSDPS319P13 on L07_DPS: 177.82,36.37 177.79,36.4 159.97,36.4 158.65,37.72 158.65,84.12 213.37,138.84 213.37,188.09 215.67,190.39 237.73,190.39 240.86,187.26 240.86,168.49 247.28,162.07 247.28,133.41 204.6,90.73 204.6,78.61 188.91,62.92 188.91,49.84 189.44,49.3 193.79,49.3 194.64,48.45 194.64,37.64 193.38,36.37
CSDPS319P14 on L11_DPS: 182.9,46.53 182.87,46.56 182.19,46.56 181.66,47.09 181.66,76.35 232.76,127.45 232.76,168.44 236.2,171.88 236.2,186.59 235.62,187.17 231.68,187.17 231.42,187.43 231.42,192.43 232.01,193.01 247.2,193.01 248.77,191.44 248.77,130.28 248.73,130.24 248.73,121.33 193.99,66.59 193.99,60 194.52,59.46 198.87,59.46 199.72,58.61 199.72,47.8 198.46,46.53
CSDPS319P15 on L03_DPS: 156.94,31.64 156.22,32.36 156.22,52.62 156.36,52.76 156.3,52.82 156.3,98.89 209.17,151.77 209.17,185.12 210.19,186.13 222.91,186.13 225.02,188.23 225.02,189.94 225.62,190.54 237.15,190.54 239.01,188.67 239.01,148.79 193.99,103.77 193.99,51.82 193.89,51.82 193.99,51.71 193.99,49.84 194.52,49.3 198.87,49.3 199.72,48.45 199.72,37.64 199.43,37.34 199.72,37.04 199.72,32.45 198.91,31.64
CSDPS323P1 on L09_DPS: 220.32,36.37 219.76,36.93 219.76,81.46 250.04,111.74 250.04,138.41 251.21,139.57 251.21,179.45 252.55,180.79 269.26,180.79 269.44,180.97 269.44,181.96 269.59,182.11 272.61,182.11 272.87,181.86 272.87,177.05 272.86,177.02 272.86,176.53 272.65,176.33 272.65,171.19 267.72,166.25 267.72,105.92 232.09,70.29 232.09,49.84 232.62,49.3 236.97,49.3 237.82,48.45 237.82,37.64 236.56,36.37
CSDPS323P3 on L05_DPS: 238.42,36.37 237.16,37.64 237.16,48.45 238.01,49.3 242.36,49.3 242.89,49.84 242.89,114.11 261.37,132.59 261.37,172.38 255.29,178.46 255.29,191.47 258.29,194.46 260.07,194.46 262.2,196.6 277.64,196.6 278.61,195.63 278.61,192.83 276.47,190.7 276.47,188.29 276.09,187.9 276.09,187.02 275.61,186.53 269.01,186.53 268.8,186.74 268.8,190.65 268.24,191.21 264.54,191.21 262.91,189.59 262.91,177.55 265.4,175.06 275.41,175.06 277.87,172.59 277.87,144.65 277.36,144.14 277.36,124.71 255.22,102.57 255.22,36.93 254.69,36.4 254.01,36.4 253.98,36.37
CSDPS323P6 on L11_DPS: 233.7,46.53 233.67,46.56 232.99,46.56 232.46,47.09 232.46,100.25 251.23,119.02 251.23,171.7 261.62,182.09 272.62,182.09 272.87,181.84 272.87,173.2 266.67,167 266.67,105.11 244.79,83.22 244.79,60 245.32,59.46 249.67,59.46 250.52,58.61 250.52,47.8 249.26,46.53
CSDPS323P9 on L09_DPS: 241.32,36.37 241.29,36.4 240.61,36.4 240.08,36.93 240.08,71.68 272.41,104.01 272.41,143.76 270.89,145.29 270.89,166.75 275.08,170.94 275.08,178.73 274.67,179.15 274.67,182.47 274.52,182.62 269.67,182.62 269.62,182.57 269.62,182.21 269.36,181.96 267.74,181.96 267.72,181.99 267.1,181.99 266.87,182.21 266.87,190.09 268.55,191.77 288.42,191.77 288.79,191.39 288.79,96.77 252.41,60.39 252.41,49.84 252.94,49.3 257.29,49.3 258.14,48.45 258.14,37.64 256.88,36.37
CSDPS323P11 on L05_DPS: 258.74,36.37 257.48,37.64 257.48,48.45 258.33,49.3 262.68,49.3 263.21,49.84 263.21,105.63 279.93,122.35 279.93,142.88 279.47,143.34 279.47,174.8 276.37,177.9 266.36,177.9 264.99,179.27 264.99,190.09 265.3,190.39 267.94,190.39 268.3,190.04 268.3,185.44 268.4,185.34 288.62,185.34 290.06,183.9 290.06,173.86 290.57,173.35 290.57,110.15 275.54,95.12 275.54,36.93 275.01,36.4 274.33,36.4 274.3,36.37
CSDPS323P13 on L07_DPS: 251.48,36.37 251.45,36.4 233.63,36.4 232.31,37.72 232.31,105.82 253.36,126.87 253.36,188.09 255.67,190.39 277.73,190.39 280.86,187.26 280.86,168.49 287.28,162.07 287.28,126.14 262.57,101.43 262.57,49.84 263.1,49.3 267.45,49.3 268.3,48.45 268.3,37.64 267.04,36.37
CSDPS323P14 on L11_DPS: 256.56,46.53 256.53,46.56 255.85,46.56 255.32,47.09 255.32,82.6 272.76,100.04 272.76,168.44 276.2,171.88 276.2,186.59 275.62,187.17 271.68,187.17 271.42,187.43 271.42,192.43 272.01,193.01 287.2,193.01 288.77,191.44 288.77,91.67 267.65,70.55 267.65,60 268.18,59.46 272.53,59.46 273.38,58.61 273.38,47.8 272.12,46.53
CSDPS323P15 on L03_DPS: 230.6,31.64 229.88,32.36 229.88,132.48 249.17,151.77 249.17,185.12 250.18,186.13 262.91,186.13 265.02,188.23 265.02,189.94 265.62,190.54 277.15,190.54 279.01,188.67 279.01,117.27 267.65,105.9 267.65,51.82 267.55,51.82 267.65,51.71 267.65,49.84 268.18,49.3 272.53,49.3 273.38,48.45 273.38,37.64 273.09,37.34 273.38,37.04 273.38,32.45 272.57,31.64
CSDPS426P1 on L03_DPS: 240.61,221.11 239.06,222.66 239.06,248.95 223.27,264.74 204.09,264.74 200.89,267.94 200.89,298.22 232.42,329.76 232.42,376.19 233.24,377 275.21,377 275.92,376.28 275.92,360.49 275.07,359.64 270.72,359.64 270.19,359.1 270.19,357.31 270.27,357.31 270.27,327.09 259.08,315.9 259.08,265.94 262.67,262.34 262.67,250.36 263.02,250.01 264.49,250.01 265.02,250.54 276.4,250.54 277.72,249.22 277.72,222.5 276.32,221.11
CSDPS426P3 on L05_DPS: 266.42,237.85 264.99,239.27 264.99,250.09 265.3,250.39 267.94,250.39 268.3,250.04 268.3,245.44 268.4,245.34 276.02,245.34 278.51,247.83 278.51,265.68 281.3,268.48 281.3,302.01 252.78,330.53 252.78,372.01 253.31,372.54 253.99,372.54 254.02,372.57 269.58,372.57 270.84,371.3 270.84,360.49 269.99,359.64 265.64,359.64 265.11,359.1 265.11,338.01 294.26,308.86 294.26,293.88 295.27,292.87 295.27,239.52 293.59,237.85
CSDPS426P4 on L11_DPS: 265.78,247.17 265.13,247.82 265.13,266.55 261.11,270.57 261.11,316.64 257.86,319.89 257.86,361.85 258.39,362.38 259.07,362.38 259.1,362.41 274.66,362.41 275.92,361.14 275.92,350.33 275.07,349.48 270.72,349.48 270.19,348.94 270.19,341.44 278.76,332.87 278.76,249.17 277.41,247.83 272.18,247.83 272.11,247.75 272.11,247.45 271.83,247.17
CSDPS426P5 on L07_DPS: 263.93,239.52 260.8,242.65 260.8,260.99 254.38,267.4 254.38,289.53 230.63,313.28 230.63,370.94 232.23,372.54 248.91,372.54 248.94,372.57 264.5,372.57 265.76,371.3 265.76,360.49 264.91,359.64 260.56,359.64 260.03,359.1 260.03,346.19 286,320.22 286,247.65 280.94,242.6 280.94,240.97 279.5,239.52
CSDPS426P7 on L09_DPS: 267.1,241.99 266.87,242.21 266.87,253.54 275.18,261.84 275.18,321.47 260.67,335.98 260.67,359.1 260.14,359.64 255.79,359.64 254.94,360.49 254.94,371.3 256.2,372.57 271.76,372.57 271.79,372.54 272.47,372.54 273,372.01 273,344.22 289.55,327.67 289.55,245.03 288.41,243.89 277.88,243.89 276.61,242.62 269.06,242.62 268.93,242.49 268.93,242.16 268.75,241.99
CSDPS426P11 on L05_DPS: 269.01,246.53 268.8,246.74 268.8,250.88 268.24,251.43 266.57,251.43 264.28,253.72 264.28,258.78 259.08,263.98 259.08,266.45 258.32,267.21 258.32,294.76 232.46,320.62 232.46,372.01 232.99,372.54 233.67,372.54 233.7,372.57 249.26,372.57 250.52,371.3 250.52,360.49 249.67,359.64 245.32,359.64 244.79,359.1 244.79,333.44 276.47,301.76 276.47,248.28 276.09,247.9 276.09,247.01 275.61,246.53
CSDPS426P14 on L11_DPS: 253.49,239.37 251.33,241.53 251.33,296.6 235,312.93 235,361.85 235.53,362.38 236.21,362.38 236.24,362.41 251.8,362.41 253.06,361.14 253.06,350.33 252.21,349.48 247.86,349.48 247.33,348.94 247.33,327.88 260.37,314.84 260.37,270.38 264.33,266.42 264.33,246.63 265.63,245.34 272.64,245.34 272.87,245.12 272.87,239.62 272.61,239.37
CSDPS426P15 on L09_DPS: 254.88,235.97 251.76,239.09 251.76,247.22 251.05,247.93 251.05,264.31 250.95,264.41 250.95,320.55 240.35,331.15 240.35,359.1 239.82,359.64 235.47,359.64 234.62,360.49 234.62,371.3 235.88,372.57 251.44,372.57 251.47,372.54 252.15,372.54 252.68,372.01 252.68,340.92 272.31,321.29 272.31,291.06 272.54,290.83 272.54,262.38 263.46,253.3 263.46,241.38 264.05,240.79 269.26,240.79 269.44,240.97 269.44,241.96 269.59,242.11 272.61,242.11 272.87,241.86 272.87,237.05 272.79,236.85 271.9,235.97
CSDPS430P1 on BOTTOM: 49.78,168.4 50.55,169.16 50.55,187.71 50.04,188.21 45.08,188.21 44.45,187.58 44.45,169.42 45.47,168.4
CSDPS430P1 on L03_DPS: 165.38,221.11 158.76,227.72 158.76,376.19 159.58,377 201.55,377 202.26,376.28 202.26,360.49 201.41,359.64 197.06,359.64 196.53,359.1 196.53,357.31 196.53,251.9 202.31,246.13 222.91,246.13 225.02,248.23 225.02,249.94 225.62,250.54 236.4,250.54 237.72,249.22 237.72,222.5 236.32,221.11
CSDPS430P1 on L13_SIGNAL: 207.26,241.52 201.1,241.52 198.61,239.03 161.31,239.03 129.41,207.14 53.09,207.14 48.64,202.69 48.64,169.8 49.53,168.91 92.33,168.91 101.85,178.44 144.62,178.44 189.01,222.82 207.35,222.82 208.34,223.81 208.34,240.45
CSDPS430P3 on BOTTOM: 72.52,179.55 72.52,187.3 71.82,188 67.37,188 66.55,187.17 66.55,179.55 67.06,179.04 72.01,179.04
CSDPS430P3 on L05_DPS: 226.42,237.85 224.99,239.27 224.99,250.09 225.3,250.39 227.94,250.39 228.3,250.04 228.3,245.44 228.4,245.34 236.02,245.34 238.51,247.83 238.51,265.68 241.3,268.48 241.3,285.75 179.12,347.93 179.12,372.01 179.65,372.54 180.33,372.54 180.36,372.57 195.92,372.57 197.18,371.3 197.18,360.49 196.33,359.64 191.98,359.64 191.45,359.1 191.45,355.66 255.27,291.85 255.27,239.52 253.59,237.85
CSDPS430P3 on L15_SIGNAL: 243.71,300.99 246.63,298.07 246.63,277.24 244.02,274.62 202.79,274.62 193.93,265.76 91.77,265.76 79.4,253.39 79.4,177.37 77.67,175.64 68.25,175.64 66.5,177.39 66.5,190.17 48.06,208.61 48.06,270.38 65.38,287.71 200.08,287.71 213.36,300.99
CSDPS430P4 on BOTTOM: 72.52,169.39 72.52,177.14 71.82,177.84 67.37,177.84 66.55,177.01 66.55,169.39 67.06,168.88 72.01,168.88
CSDPS430P4 on L11_DPS: 225.78,247.17 225.13,247.82 225.13,266.55 221.11,270.57 221.11,295.43 184.2,332.33 184.2,361.85 184.73,362.38 185.41,362.38 185.44,362.41 201,362.41 202.26,361.14 202.26,350.33 201.41,349.48 197.06,349.48 196.53,348.94 196.53,341.52 238.76,299.29 238.76,249.17 237.41,247.83 232.18,247.83 232.11,247.75 232.11,247.45 231.83,247.17
CSDPS430P4 on L19_SIGNAL: 152.03,290.81 138.07,276.86 138.07,198.96 128.4,189.3 71.52,189.3 68.05,185.83 68.05,166.7 69.73,165.02 138.07,165.02 158.24,185.19 158.24,263.94 172.66,278.35 216.19,278.35 219.65,274.9 221.96,274.9 222.68,275.62 222.68,288.69 219.53,291.85 153.06,291.85
CSDPS430P5 on BOTTOM: 45.73,161.77 44.97,161.01 44.97,142.47 45.48,141.96 50.43,141.96 51.06,142.6 51.06,160.76 50.05,161.77
CSDPS430P5 on L07_DPS: 223.93,239.52 220.8,242.65 220.8,260.99 214.38,267.4 214.38,286.33 156.97,343.74 156.97,370.94 158.57,372.54 175.25,372.54 175.28,372.57 190.84,372.57 192.1,371.3 192.1,360.49 191.25,359.64 186.9,359.64 186.37,359.1 186.37,346.44 230,302.82 236.27,302.82 246,293.09 246,247.65 240.94,242.6 240.94,240.97 239.5,239.52
CSDPS430P5 on L13_SIGNAL: 223.57,276.31 223.57,295.36 216.54,302.39 59.44,302.39 20.7,263.65 20.7,144.78 25.07,140.42 48.53,140.42 50.58,142.47 50.58,159.99 49.66,160.91 46.31,160.91 44.02,163.2 43.41,163.81 43.41,213.21 86.55,256.35 137.6,256.35 155.83,274.57 221.83,274.57
CSDPS430P7 on BOTTOM: 72.52,196.06 72.52,203.81 71.82,204.51 67.37,204.51 66.55,203.68 66.55,196.06 67.06,195.55 72.01,195.55
CSDPS430P7 on BOTTOM: 72.52,206.22 72.52,213.97 71.82,214.67 67.37,214.67 66.55,213.84 66.55,206.22 67.06,205.71 72.01,205.71
CSDPS430P7 on L09_DPS: 227.1,241.99 226.87,242.21 226.87,253.54 235.18,261.84 235.18,289.28 235.84,289.94 235.84,297.81 187.01,346.65 187.01,359.1 186.48,359.64 182.13,359.64 181.28,360.49 181.28,371.3 182.54,372.57 198.1,372.57 198.13,372.54 198.81,372.54 199.34,372.01 199.34,357.94 249.55,307.72 249.55,245.03 248.41,243.89 237.88,243.89 236.61,242.62 229.06,242.62 228.93,242.49 228.93,242.16 228.75,241.99
CSDPS430P7 on L19_SIGNAL: 242.7,279.57 243.32,278.95 252.26,278.95 253.51,280.19 253.51,295.54 243.89,305.16 125.91,305.16 125.84,305.09 124.22,305.09 67.77,248.64 67.77,195.35 70.63,192.49 81.85,192.49 84.34,194.98 84.34,224.7 152.37,292.73 236.25,292.73 242.7,286.29
CSDPS430P11 on BOTTOM: 49.78,195.07 50.55,195.83 50.55,214.38 50.04,214.88 45.08,214.88 44.45,214.25 44.45,196.09 45.47,195.07
CSDPS430P11 on L05_DPS: 229.01,246.53 228.8,246.74 228.8,250.88 228.24,251.43 226.57,251.43 224.28,253.72 224.28,258.78 219.08,263.98 219.08,266.45 218.32,267.21 218.32,277.24 158.8,336.75 158.8,372.01 159.33,372.54 160.01,372.54 160.04,372.57 175.6,372.57 176.86,371.3 176.86,360.49 176.01,359.64 171.66,359.64 171.13,359.1 171.13,350.15 236.47,284.81 236.47,248.28 236.09,247.9 236.09,247.01 235.61,246.53
CSDPS430P11 on L19_SIGNAL: 266.13,264.33 274.52,272.72 274.52,304.6 257.3,321.82 100.11,321.82 42.86,264.57 42.86,195.59 45.69,192.76 62.39,192.76 66.29,196.67 66.29,248.92 123.23,305.85 246.33,305.85 256.24,295.95 256.24,279.48 253.98,277.23 240.08,277.23 239.01,278.3 233.59,278.3 233.31,278.02 233.31,266.03 235.01,264.33
CSDPS430P14 on BOTTOM: 66.18,160.78 66.18,153.03 66.88,152.34 71.32,152.34 72.15,153.16 72.15,160.78 71.64,161.29 66.69,161.29
CSDPS430P14 on L11_DPS: 213.49,239.37 211.33,241.53 211.33,282.65 195.4,298.58 189.31,298.58 161.34,326.54 161.34,361.85 161.87,362.38 162.55,362.38 162.58,362.41 178.14,362.41 179.4,361.14 179.4,350.33 178.55,349.48 174.2,349.48 173.67,348.94 173.67,340.55 220.37,293.85 220.37,270.38 224.33,266.42 224.33,246.63 225.63,245.34 232.64,245.34 232.87,245.12 232.87,239.62 232.61,239.37
CSDPS430P14 on L17_SIGNAL: 68.58,153.67 70.23,152.02 82.42,152.02 83.95,153.54 83.95,191.39 86.99,194.44 135.76,194.44 178.05,236.73 218.44,236.73 223.52,241.81 223.52,277.5 222.25,278.76 210.95,278.76 208.79,276.61 208.79,252.86 207.14,251.21 161.42,251.21 120.9,210.69 74.17,210.69 68.58,205.1
CSDPS430P15 on BOTTOM: 66.18,150.62 66.18,142.88 66.88,142.18 71.32,142.18 72.15,143 72.15,150.62 71.64,151.13 66.69,151.13
CSDPS430P15 on L09_DPS: 214.88,235.97 211.76,239.09 211.76,247.22 211.05,247.93 211.05,264.31 210.95,264.41 210.95,294.63 166.69,338.9 166.69,359.1 166.16,359.64 161.81,359.64 160.96,360.49 160.96,371.3 162.22,372.57 177.78,372.57 177.81,372.54 178.49,372.54 179.02,372.01 179.02,350.06 232.31,296.77 232.31,291.06 232.54,290.83 232.54,262.38 223.46,253.3 223.46,241.38 224.05,240.79 229.26,240.79 229.44,240.97 229.44,241.96 229.59,242.11 232.61,242.11 232.87,241.86 232.87,237.05 232.79,236.85 231.9,235.97
CSDPS430P15 on L19_SIGNAL: 172.42,276.59 159.69,263.86 159.69,181.93 139.96,162.19 69.26,162.19 65.49,158.42 65.49,140.65 68.31,137.82 152.34,137.82 178.6,164.08 178.6,253.22 187.63,262.25 212.34,262.25 213.99,263.91 230.59,263.91 232.53,265.84 232.53,277.89 232.02,278.4 225.52,278.4 225.12,278 225.12,274.72 224.55,274.14 218.55,274.14 216.1,276.59
S1_3V3_ETH_MUX on L23_SIGNAL: 236.71,270.58 236.39,270.26 236.39,268.88 237.4,267.88 245.51,267.88 247.56,269.93 247.56,274.32 247.14,274.74 239.89,274.74 239.4,274.25 239.4,271.04 238.94,270.58
S1_CON1_0V8 on BOTTOM: 35.18,177.29 35.18,169.54 35.88,168.85 40.32,168.85 41.15,169.67 41.15,177.29 40.64,177.8 35.69,177.8
S1_CON1_0V8 on BOTTOM: 35.18,203.96 35.18,196.22 35.88,195.52 40.32,195.52 41.15,196.34 41.15,203.96 40.64,204.47 35.69,204.47
S1_CON1_0V8 on L25_SIGNAL: 32.46,168.29 33.91,166.84 42.59,166.84 44.14,168.39 44.14,204.17 42.56,205.76 33.81,205.76 32.46,204.41
S1_CON1_1V5_1V2 on BOTTOM: 57.91,161.77 57.15,161.01 57.15,142.47 57.66,141.96 62.61,141.96 63.25,142.6 63.25,160.76 62.23,161.77
S1_CON1_1V5_1V2 on L15_SIGNAL: 21.72,184.98 41.28,184.98 45.49,180.78 45.49,143.27 47.17,141.59 61.58,141.59 63.74,143.74 63.74,188.38 54.18,197.95 23.88,197.95 20.78,194.85 20.78,185.93
S1_CON1_1V8 on BOTTOM: 36.32,161.77 35.56,161.01 35.56,142.47 36.07,141.96 41.02,141.96 41.66,142.6 41.66,160.76 40.64,161.77
S1_CON1_1V8 on BOTTOM: 63.11,206.22 63.11,213.97 62.41,214.67 57.97,214.67 57.14,213.84 57.14,206.22 57.65,205.71 62.6,205.71
S1_CON1_1V8 on L17_SIGNAL: 21.22,159.59 20.21,158.57 20.21,143.41 21.82,141.79 61.82,141.79 66.7,146.67 66.7,213.5 63.87,216.33 45.76,216.33 43.07,213.63 43.07,164.72 40.27,161.92 28.76,161.92 26.42,159.59
S1_CON1_A3V3 on BOTTOM: 57.91,188.44 57.15,187.68 57.15,169.14 57.66,168.63 62.61,168.63 63.25,169.27 63.25,187.43 62.23,188.44
S1_CON1_A3V3 on L23_SIGNAL: 22.35,191.9 58.67,191.9 62.1,188.47 62.1,153.42 57.02,148.34 21.34,148.34 18.03,151.64 18.03,187.58
S1_CON1_B3V3 on BOTTOM: 63.11,196.06 63.11,203.81 62.41,204.51 57.97,204.51 57.14,203.68 57.14,196.06 57.65,195.55 62.6,195.55
S1_CON1_B3V3 on L25_SIGNAL: 20.88,154.57 20.16,153.84 20.16,143.32 21.82,141.66 56.3,141.66 63.9,149.27 63.9,203.43 61.58,205.76 49.73,205.76 46.97,203 46.97,162.97 38.57,154.57
S1_CON1_CORE_0V9 on BOTTOM: 35.18,187.45 35.18,179.7 35.88,179.01 40.32,179.01 41.15,179.83 41.15,187.45 40.64,187.96 35.69,187.96
S1_CON1_CORE_0V9 on BOTTOM: 35.18,214.12 35.18,206.38 35.88,205.68 40.32,205.68 41.15,206.5 41.15,214.12 40.64,214.63 35.69,214.63
S1_CON1_CORE_0V9 on L17_SIGNAL: 37.27,215.65 22.13,215.65 20.17,213.7 20.17,165.09 21.28,163.98 37.51,163.98 38.92,165.39 38.92,214
S1_DVDD_DDR_RX on L17_SIGNAL: 231.7,238.34 232.17,238.82 232.17,244.54 232.04,244.68 227.02,244.68 226.87,244.53 226.87,238.46 226.98,238.34
S1_DVDD_DDR_TX on L23_SIGNAL: 230.24,238.09 230.24,240.59 230.04,240.79 225.78,240.79 225.49,240.5 225.49,238.12 225.88,237.73 229.88,237.73
S1_MUX_3V3 on L23_SIGNAL: 237.68,271.36 238.64,272.32 238.64,276.09 237.74,276.99 223.78,276.99 209.94,263.14 209.94,234.56 210.53,233.97 219.55,233.97 221.75,231.78 222.89,231.78 224.18,233.07 224.18,243.4 222.38,245.2 222.38,259.58 227.59,264.8 227.59,267.59 226.36,268.81 226.36,270.74 226.99,271.36
S1_PM_SAR0 on L23_SIGNAL: 222.78,283.1 222.78,278.91 223.46,278.23 246.42,278.23 248.63,276.02 248.63,269.74 245.98,267.08 239.72,267.08 232.05,259.41 232.05,250.88 232.09,250.84 232.09,247.96 232.22,247.84 235.28,247.84 235.42,247.98 235.42,257.41 242.2,264.19 249.34,264.19 251.24,266.09 251.24,281.93 248.34,284.83 224.51,284.83
S1_USER_3V3 on BOTTOM: 103.45,226.11 98.5,226.11 97.61,225.22 97.61,222.17 97.99,221.79 99.77,221.79 100.15,222.17 100.15,223.82 100.66,224.33 103.07,224.33 103.58,224.84 103.58,225.98
S1_USER_3V3 on L23_SIGNAL: 123.66,240.5 87.21,240.5 85.93,239.22 85.93,222.39 87.21,221.11 123.68,221.11 124.91,222.33 124.91,239.25
S2_3V3_ETH_MUX on L23_SIGNAL: 276.71,270.58 276.39,270.26 276.39,268.88 277.4,267.88 285.51,267.88 287.56,269.93 287.56,274.32 287.14,274.74 279.89,274.74 279.4,274.25 279.4,271.04 278.94,270.58
S2_DVDD_DDR_RX on L17_SIGNAL: 271.7,238.34 272.17,238.82 272.17,244.54 272.04,244.68 267.02,244.68 266.87,244.53 266.87,238.46 266.98,238.34
S2_DVDD_DDR_TX on L23_SIGNAL: 270.24,238.09 270.24,240.59 270.04,240.79 265.78,240.79 265.49,240.5 265.49,238.12 265.88,237.73 269.88,237.73
S2_MUX_3V3 on L23_SIGNAL: 277.68,271.36 278.64,272.32 278.64,276.09 277.74,276.99 263.78,276.99 249.94,263.14 249.94,234.56 250.53,233.97 259.55,233.97 261.75,231.78 262.89,231.78 264.18,233.07 264.18,243.4 262.38,245.2 262.38,259.58 267.59,264.8 267.59,267.59 266.36,268.81 266.36,270.74 266.99,271.36
S2_PM_SAR0 on L23_SIGNAL: 262.78,283.1 262.78,278.91 263.46,278.23 286.42,278.23 288.63,276.02 288.63,269.74 285.98,267.08 279.72,267.08 272.05,259.41 272.05,250.88 272.09,250.84 272.09,247.96 272.22,247.84 275.28,247.84 275.42,247.98 275.42,257.41 282.2,264.19 289.34,264.19 291.24,266.09 291.24,281.93 288.34,284.83 264.51,284.83
S2_USER_3V3 on BOTTOM: 103.45,194.36 98.5,194.36 97.61,193.47 97.61,190.42 97.99,190.04 99.77,190.04 100.15,190.42 100.15,192.07 100.66,192.58 103.07,192.58 103.58,193.09 103.58,194.23
S2_USER_3V3 on L23_SIGNAL: 123.66,208.75 87.21,208.75 85.93,207.47 85.93,190.64 87.21,189.36 123.68,189.36 124.91,190.58 124.91,207.5
S3_3V3_ETH_MUX on L23_SIGNAL: 316.71,270.58 316.39,270.26 316.39,268.88 317.4,267.88 325.51,267.88 327.56,269.93 327.56,274.32 327.14,274.74 319.89,274.74 319.4,274.25 319.4,271.04 318.94,270.58
S3_DVDD_DDR_RX on L17_SIGNAL: 311.7,238.34 312.17,238.82 312.17,244.54 312.04,244.68 307.02,244.68 306.87,244.53 306.87,238.46 306.98,238.34
S3_DVDD_DDR_TX on L23_SIGNAL: 310.24,238.09 310.24,240.59 310.03,240.79 305.78,240.79 305.49,240.5 305.49,238.12 305.88,237.73 309.88,237.73
S3_MUX_3V3 on L23_SIGNAL: 317.68,271.36 318.64,272.32 318.64,276.09 317.74,276.99 303.78,276.99 289.94,263.14 289.94,234.56 290.53,233.97 299.55,233.97 301.75,231.78 302.89,231.78 304.18,233.07 304.18,243.4 302.38,245.2 302.38,259.58 307.59,264.8 307.59,267.59 306.36,268.81 306.36,270.74 306.99,271.36
S3_PM_SAR0 on L23_SIGNAL: 302.78,283.1 302.78,278.91 303.46,278.23 326.42,278.23 328.63,276.02 328.63,269.74 325.97,267.08 319.72,267.08 312.05,259.41 312.05,250.88 312.09,250.84 312.09,247.96 312.22,247.84 315.28,247.84 315.42,247.98 315.42,257.41 322.2,264.19 329.34,264.19 331.24,266.09 331.24,281.93 328.34,284.83 304.51,284.83
S3_USER_3V3 on BOTTOM: 469.21,194.36 464.26,194.36 463.37,193.47 463.37,190.42 463.75,190.04 465.53,190.04 465.91,190.42 465.91,192.07 466.42,192.58 468.83,192.58 469.34,193.09 469.34,194.23
S3_USER_3V3 on L23_SIGNAL: 489.42,208.75 452.97,208.75 451.69,207.47 451.69,190.64 452.97,189.36 489.44,189.36 490.67,190.58 490.67,207.5
S4_3V3_ETH_MUX on L23_SIGNAL: 356.71,270.58 356.39,270.26 356.39,268.88 357.4,267.88 365.51,267.88 367.56,269.93 367.56,274.32 367.14,274.74 359.89,274.74 359.4,274.25 359.4,271.04 358.94,270.58
S4_DVDD_DDR_RX on L17_SIGNAL: 351.7,238.34 352.17,238.82 352.17,244.54 352.04,244.68 347.02,244.68 346.87,244.53 346.87,238.46 346.98,238.34
S4_DVDD_DDR_TX on L23_SIGNAL: 350.24,238.09 350.24,240.59 350.03,240.79 345.78,240.79 345.49,240.5 345.49,238.12 345.88,237.73 349.88,237.73
S4_MUX_3V3 on L23_SIGNAL: 357.68,271.36 358.64,272.32 358.64,276.09 357.74,276.99 343.78,276.99 329.94,263.14 329.94,234.56 330.53,233.97 339.55,233.97 341.75,231.78 342.89,231.78 344.18,233.07 344.18,243.4 342.38,245.2 342.38,259.58 347.59,264.8 347.59,267.59 346.36,268.81 346.36,270.74 346.99,271.36
S4_PM_SAR0 on L23_SIGNAL: 342.78,283.1 342.78,278.91 343.46,278.23 366.42,278.23 368.63,276.02 368.63,269.74 365.97,267.08 359.72,267.08 352.05,259.41 352.05,250.88 352.09,250.84 352.09,247.96 352.22,247.84 355.28,247.84 355.42,247.98 355.42,257.41 362.2,264.19 369.34,264.19 371.24,266.09 371.24,281.93 368.34,284.83 344.51,284.83
S4_USER_3V3 on BOTTOM: 469.21,226.11 464.26,226.11 463.37,225.22 463.37,222.17 463.75,221.79 465.53,221.79 465.91,222.17 465.91,223.82 466.42,224.33 468.83,224.33 469.34,224.84 469.34,225.98
S4_USER_3V3 on L23_SIGNAL: 489.42,240.5 452.97,240.5 451.69,239.22 451.69,222.39 452.97,221.11 489.44,221.11 490.67,222.33 490.67,239.25
S5_3V3_ETH_MUX on L23_SIGNAL: 236.71,210.58 236.39,210.26 236.39,208.88 237.4,207.88 245.51,207.88 247.56,209.93 247.56,214.32 247.14,214.74 239.89,214.74 239.4,214.25 239.4,211.04 238.94,210.58
S5_DVDD_DDR_RX on L17_SIGNAL: 231.7,178.35 232.17,178.82 232.17,184.54 232.04,184.68 227.02,184.68 226.87,184.53 226.87,178.46 226.98,178.35
S5_DVDD_DDR_TX on L23_SIGNAL: 230.24,178.09 230.24,180.59 230.04,180.79 225.78,180.79 225.49,180.5 225.49,178.13 225.88,177.73 229.88,177.73
S5_MUX_3V3 on L23_SIGNAL: 237.68,211.36 238.64,212.32 238.64,216.09 237.74,216.99 223.78,216.99 209.94,203.14 209.94,174.56 210.53,173.97 219.55,173.97 221.75,171.78 222.89,171.78 224.18,173.07 224.18,183.4 222.38,185.2 222.38,199.58 227.59,204.8 227.59,207.59 226.36,208.81 226.36,210.74 226.99,211.36
S5_PM_SAR0 on L23_SIGNAL: 234.12,189.72 233.97,189.87 231.58,189.87 231.44,189.73 231.44,162.77 233.4,160.81 233.4,147.34 235.14,145.61 238.32,145.61 239.27,146.56 239.27,163.03 234.12,168.18
S5_USER_3V3 on BOTTOM: 103.45,162.61 98.5,162.61 97.61,161.72 97.61,158.67 97.99,158.29 99.77,158.29 100.15,158.67 100.15,160.32 100.66,160.83 103.07,160.83 103.58,161.34 103.58,162.48
S5_USER_3V3 on L23_SIGNAL: 123.66,177 87.21,177 85.93,175.72 85.93,158.89 87.21,157.61 123.68,157.61 124.91,158.83 124.91,175.75
S6_3V3_ETH_MUX on L23_SIGNAL: 276.71,210.58 276.39,210.26 276.39,208.88 277.4,207.88 285.51,207.88 287.56,209.93 287.56,214.32 287.14,214.74 279.89,214.74 279.4,214.25 279.4,211.04 278.94,210.58
S6_DVDD_DDR_RX on L17_SIGNAL: 271.7,178.35 272.17,178.82 272.17,184.54 272.04,184.68 267.02,184.68 266.87,184.53 266.87,178.46 266.98,178.35
S6_DVDD_DDR_TX on L23_SIGNAL: 270.24,178.09 270.24,180.59 270.04,180.79 265.78,180.79 265.49,180.5 265.49,178.13 265.88,177.73 269.88,177.73
S6_MUX_3V3 on L23_SIGNAL: 277.68,211.36 278.64,212.32 278.64,216.09 277.74,216.99 263.78,216.99 249.94,203.14 249.94,174.56 250.53,173.97 259.55,173.97 261.75,171.78 262.89,171.78 264.18,173.07 264.18,183.4 262.38,185.2 262.38,199.58 267.59,204.8 267.59,207.59 266.36,208.81 266.36,210.74 266.99,211.36
S6_PM_SAR0 on L23_SIGNAL: 274.12,189.72 273.97,189.87 271.58,189.87 271.44,189.73 271.44,162.77 273.4,160.81 273.4,147.34 275.14,145.61 278.32,145.61 279.27,146.56 279.27,163.03 274.12,168.18
S6_USER_3V3 on BOTTOM: 103.45,130.86 98.5,130.86 97.61,129.97 97.61,126.92 97.99,126.54 99.77,126.54 100.15,126.92 100.15,128.57 100.66,129.08 103.07,129.08 103.58,129.59 103.58,130.73
S6_USER_3V3 on L23_SIGNAL: 123.66,145.25 87.21,145.25 85.93,143.97 85.93,127.14 87.21,125.86 123.68,125.86 124.91,127.08 124.91,144
S7_3V3_ETH_MUX on L23_SIGNAL: 316.71,210.58 316.39,210.26 316.39,208.88 317.4,207.88 325.51,207.88 327.56,209.93 327.56,214.32 327.14,214.74 319.89,214.74 319.4,214.25 319.4,211.04 318.94,210.58
S7_DVDD_DDR_RX on L17_SIGNAL: 311.7,178.35 312.17,178.82 312.17,184.54 312.04,184.68 307.02,184.68 306.87,184.53 306.87,178.46 306.98,178.35
S7_DVDD_DDR_TX on L23_SIGNAL: 310.24,178.09 310.24,180.59 310.03,180.79 305.78,180.79 305.49,180.5 305.49,178.13 305.88,177.73 309.88,177.73
S7_MUX_3V3 on L23_SIGNAL: 317.68,211.36 318.64,212.32 318.64,216.09 317.74,216.99 303.78,216.99 289.94,203.14 289.94,174.56 290.53,173.97 299.55,173.97 301.75,171.78 302.89,171.78 304.18,173.07 304.18,183.4 302.38,185.2 302.38,199.58 307.59,204.8 307.59,207.59 306.36,208.81 306.36,210.74 306.99,211.36
S7_PM_SAR0 on L23_SIGNAL: 314.12,189.72 313.97,189.87 311.58,189.87 311.44,189.73 311.44,162.77 313.4,160.81 313.4,147.34 315.14,145.61 318.32,145.61 319.27,146.56 319.27,163.03 314.12,168.18
S7_USER_3V3 on BOTTOM: 469.21,130.86 464.26,130.86 463.37,129.97 463.37,126.92 463.75,126.54 465.53,126.54 465.91,126.92 465.91,128.57 466.42,129.08 468.83,129.08 469.34,129.59 469.34,130.73
S7_USER_3V3 on L23_SIGNAL: 489.42,145.25 452.97,145.25 451.69,143.97 451.69,127.14 452.97,125.86 489.44,125.86 490.67,127.08 490.67,144
S8_3V3_ETH_MUX on L23_SIGNAL: 356.71,210.58 356.39,210.26 356.39,208.88 357.4,207.88 365.51,207.88 367.56,209.93 367.56,214.32 367.14,214.74 359.89,214.74 359.4,214.25 359.4,211.04 358.94,210.58
S8_DVDD_DDR_RX on L17_SIGNAL: 351.7,178.35 352.17,178.82 352.17,184.54 352.04,184.68 347.02,184.68 346.87,184.53 346.87,178.46 346.98,178.35
S8_DVDD_DDR_TX on L23_SIGNAL: 350.24,178.09 350.24,180.59 350.03,180.79 345.78,180.79 345.49,180.5 345.49,178.13 345.88,177.73 349.88,177.73
S8_MUX_3V3 on L23_SIGNAL: 357.68,211.36 358.64,212.32 358.64,216.09 357.74,216.99 343.78,216.99 329.94,203.14 329.94,174.56 330.53,173.97 339.55,173.97 341.75,171.78 342.89,171.78 344.18,173.07 344.18,183.4 342.38,185.2 342.38,199.58 347.59,204.8 347.59,207.59 346.36,208.81 346.36,210.74 346.99,211.36
S8_PM_SAR0 on L23_SIGNAL: 354.12,189.72 353.97,189.87 351.58,189.87 351.44,189.73 351.44,162.77 353.4,160.81 353.4,147.34 355.14,145.61 358.32,145.61 359.27,146.56 359.27,163.03 354.12,168.18
S8_USER_3V3 on BOTTOM: 469.21,162.61 464.26,162.61 463.37,161.72 463.37,158.67 463.75,158.29 465.53,158.29 465.91,158.67 465.91,160.32 466.42,160.83 468.83,160.83 469.34,161.34 469.34,162.48
S8_USER_3V3 on L23_SIGNAL: 489.42,177 452.97,177 451.69,175.72 451.69,158.89 452.97,157.61 489.44,157.61 490.67,158.83 490.67,175.75
UBIT_3V3_UP on L29_SIGNAL: 547.37,241.81 531.88,241.81 530.35,240.28 530.35,181.1 520.32,171.07 520.32,152.4 523.24,149.48 532.13,149.48 538.99,156.34 538.99,166.88 549.15,177.04 549.15,240.03
