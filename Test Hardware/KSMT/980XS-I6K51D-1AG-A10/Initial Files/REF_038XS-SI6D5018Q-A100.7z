# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#3061  -  []  269.33 210.27 0 top
NOREF#3062  -  []  233.99 208.8 90 top
NOREF#3063  -  []  270.5 181.72 90 top
NOREF#3064  -  []  348.27 185.29 90 top
NOREF#3065  -  []  247.65 160.09 90 top
NOREF#3066  -  []  474.45 249.7 0 top
NOREF#3067  -  []  84.1 289.86 0 top
NOREF#3068  -  []  362.74 209.49 0 top
NOREF#3069  -  []  347.93 187.56 0 top
NOREF#3070  -  []  223.92 295.57 0 top
NOREF#3071  -  []  356.94 192.76 90 top
NOREF#3072  -  []  534.31 221.15 0 top
NOREF#3073  -  []  469.35 214.75 90 top
NOREF#3074  -  []  313.63 138.2 0 top
NOREF#3075  -  []  467.84 201.86 90 top
NOREF#3076  -  []  303.92 295.57 0 top
NOREF#3077  -  []  221.29 292.89 90 top
NOREF#3078  -  []  273.43 189.88 90 top
NOREF#3079  -  []  219.41 226.69 0 top
NOREF#3080  -  []  231.16 245.61 0 top
NOREF#3081  -  []  264.96 135.33 90 top
NOREF#3082  -  []  254.38 243.29 0 top
NOREF#3083  -  []  234.66 243.33 90 top
NOREF#3084  -  []  293.29 253.86 90 top
NOREF#3085  -  []  282.91 207.92 90 top
NOREF#3086  -  []  449.05 186.2 0 top
NOREF#3087  -  []  37.49 249.91 90 top
NOREF#3088  -  []  283.24 208.22 90 top
NOREF#3089  -  []  233.46 243.33 0 top
NOREF#3090  -  []  120.64 156.45 0 top
NOREF#3091  -  []  307.58 178.18 90 top
NOREF#3092  -  []  468.1 249.7 0 top
NOREF#3093  -  []  97.24 183 90 top
NOREF#3094  -  []  81.36 275.66 0 top
NOREF#3095  -  []  570 164.1 90 top
NOREF#3096  -  []  252.78 250.69 90 top
NOREF#3097  -  []  311.19 183 0 top
NOREF#3098  -  []  243.37 273.06 90 top
NOREF#3099  -  []  266.61 250.18 90 top
NOREF#3100  -  []  334.66 192.79 0 top
NOREF#3101  -  []  230.54 184.96 0 top
NOREF#3102  -  []  262.96 225.63 90 top
NOREF#3103  -  []  312.45 183.7 90 top
NOREF#3104  -  []  223.34 286.27 90 top
NOREF#3105  -  []  356.23 134 90 top
NOREF#3106  -  []  358.71 141.78 90 top
NOREF#3107  -  []  323.98 207.75 90 top
NOREF#3108  -  []  307.58 238.18 0 top
NOREF#3109  -  []  267.41 133.69 0 top
NOREF#3110  -  []  355.12 295.18 90 top
NOREF#3111  -  []  250.56 175.55 90 top
NOREF#3112  -  []  331.64 195.18 0 top
NOREF#3113  -  []  317.71 207.75 0 top
NOREF#3114  -  []  350.54 244.96 0 top
NOREF#3115  -  []  304.52 282.62 0 top
NOREF#3116  -  []  274.66 243.33 90 top
NOREF#3117  -  []  278.22 268.86 0 top
NOREF#3118  -  []  309.59 185.94 90 top
NOREF#3119  -  []  456.55 241.07 0 top
NOREF#3120  -  []  552.28 147.98 0 top
NOREF#3121  -  []  242.91 207.92 0 top
NOREF#3122  -  []  265.98 185.61 0 top
NOREF#3123  -  []  481.8 253.35 0 top
NOREF#3124  -  []  356.47 269.49 0 top
NOREF#3125  -  []  80 277.9 90 top
NOREF#3126  -  []  480.05 244.1 0 top
NOREF#3127  -  []  274.91 223.58 90 top
NOREF#3128  -  []  243.55 213.3 0 top
NOREF#3129  -  []  499.83 224.19 90 top
NOREF#3130  -  []  468.1 154.45 0 top
NOREF#3131  -  []  351.15 243.67 90 top
NOREF#3132  -  []  352.23 172.39 90 top
NOREF#3133  -  []  455.4 154.45 0 top
NOREF#3134  -  []  310.5 250.18 90 top
NOREF#3135  -  []  323.72 271.73 0 top
NOREF#3136  -  []  331.16 236.15 90 top
NOREF#3137  -  []  357.71 267.75 0 top
NOREF#3138  -  []  343.27 174.06 0 top
NOREF#3139  -  []  211.34 183.29 0 top
NOREF#3140  -  []  250.56 235.55 90 top
NOREF#3141  -  []  252.01 194.76 0 top
NOREF#3142  -  []  311.16 245.61 0 top
NOREF#3143  -  []  89.64 249.7 0 top
NOREF#3144  -  []  235.12 294.17 90 top
NOREF#3145  -  []  351.15 179.12 90 top
NOREF#3146  -  []  501.65 226.53 0 top
NOREF#3147  -  []  350.83 238.82 90 top
NOREF#3148  -  []  309.23 268.44 0 top
NOREF#3149  -  []  351.15 186.26 90 top
NOREF#3150  -  []  459.07 162.36 0 top
NOREF#3151  -  []  331.16 247.72 90 top
NOREF#3152  -  []  318.32 141.41 90 top
NOREF#3153  -  []  457.6 249.7 0 top
NOREF#3154  -  []  475.18 228.97 90 top
NOREF#3155  -  []  324.05 272.03 90 top
NOREF#3156  -  []  354.1 283.17 90 top
NOREF#3157  -  []  534.31 222.55 0 top
NOREF#3158  -  []  265.33 135.72 0 top
NOREF#3159  -  []  243.37 213.54 0 top
NOREF#3160  -  []  84.1 263.88 0 top
NOREF#3161  -  []  212.45 178.82 0 top
NOREF#3162  -  []  354.61 295.18 90 top
NOREF#3163  -  []  242.33 233.13 90 top
NOREF#3164  -  []  233.63 146.07 0 top
NOREF#3165  -  []  322.24 135.78 90 top
NOREF#3166  -  []  350.82 181.42 90 top
NOREF#3167  -  []  252.45 238.82 0 top
NOREF#3168  -  []  211.33 222.13 0 top
NOREF#3169  -  []  122.64 214.75 90 top
NOREF#3170  -  []  282.74 269.49 0 top
NOREF#3171  -  []  277.95 146.07 90 top
NOREF#3172  -  []  240.04 135.47 90 top
NOREF#3173  -  []  311.84 246.26 0 top
NOREF#3174  -  []  223.27 173.14 0 top
NOREF#3175  -  []  291.33 207.13 0 top
NOREF#3176  -  []  323.72 211.73 0 top
NOREF#3177  -  []  235.44 194.76 90 top
NOREF#3178  -  []  553.49 164.1 90 top
NOREF#3179  -  []  83.29 217.95 0 top
NOREF#3180  -  []  309.85 184.32 90 top
NOREF#3181  -  []  83.8 276.47 0 top
NOREF#3182  -  []  315.6 281.03 90 top
NOREF#3183  -  []  270.18 182.62 0 top
NOREF#3184  -  []  352.2 284.47 0 top
NOREF#3185  -  []  232.45 243.7 90 top
NOREF#3186  -  []  115.04 217.95 0 top
NOREF#3187  -  []  333.29 253.86 90 top
NOREF#3188  -  []  355.44 194.76 90 top
NOREF#3189  -  []  309.46 145.44 90 top
NOREF#3190  -  []  106.69 417.57 90 top
NOREF#3191  -  []  259.42 292.84 90 top
NOREF#3192  -  []  271.84 244.96 0 top
NOREF#3193  -  []  228.56 238.48 90 top
NOREF#3194  -  []  267.77 234.98 0 top
NOREF#3195  -  []  227.59 184.06 90 top
NOREF#3196  -  []  231.16 246.26 90 top
NOREF#3197  -  []  348.93 180.73 0 top
NOREF#3198  -  []  534.31 219.75 0 top
NOREF#3199  -  []  231.54 245.93 90 top
NOREF#3200  -  []  541.61 147.98 0 top
NOREF#3201  -  []  566.06 154.21 0 top
NOREF#3202  -  []  487.94 204.72 0 top
NOREF#3203  -  []  230.55 134.62 0 top
NOREF#3204  -  []  222.96 165.63 90 top
NOREF#3205  -  []  480.8 186.2 0 top
NOREF#3206  -  []  326.75 269.12 0 top
NOREF#3207  -  []  334.66 252.79 0 top
NOREF#3208  -  []  255.58 194.86 90 top
NOREF#3209  -  []  269.53 238.82 0 top
NOREF#3210  -  []  269.53 244.02 90 top
NOREF#3211  -  []  307.05 133.3 0 top
NOREF#3212  -  []  232.46 242.37 90 top
NOREF#3213  -  []  477.18 128.72 0 top
NOREF#3214  -  []  231.16 239.12 90 top
NOREF#3215  -  []  112.92 207.37 0 top
NOREF#3216  -  []  461.75 154.45 0 top
NOREF#3217  -  []  456.65 246.5 90 top
NOREF#3218  -  []  272.46 240.42 90 top
NOREF#3219  -  []  268.27 244.64 90 top
NOREF#3220  -  []  348.93 180.74 90 top
NOREF#3221  -  []  345.98 185.61 0 top
NOREF#3222  -  []  282.74 209.49 0 top
NOREF#3223  -  []  268.57 184.96 0 top
NOREF#3224  -  []  111.42 223.97 0 top
NOREF#3225  -  []  344.52 285.16 0 top
NOREF#3226  -  []  315.23 223.88 90 top
NOREF#3227  -  []  333.66 243.2 0 top
NOREF#3228  -  []  309.53 244.02 0 top
NOREF#3229  -  []  281.13 267.92 90 top
NOREF#3230  -  []  93.31 225.86 0 top
NOREF#3231  -  []  317.14 138.77 90 top
NOREF#3232  -  []  534.61 234.43 0 top
NOREF#3233  -  []  273.17 291.16 0 top
NOREF#3234  -  []  263.95 174.38 90 top
NOREF#3235  -  []  313.43 249.88 90 top
NOREF#3236  -  []  319.72 136.37 0 top
NOREF#3237  -  []  283.37 273.54 0 top
NOREF#3238  -  []  364.68 274.19 0 top
NOREF#3239  -  []  228.24 178.18 0 top
NOREF#3240  -  []  108.69 217.95 0 top
NOREF#3241  -  []  358.71 140.12 90 top
NOREF#3242  -  []  210.56 240.75 0 top
NOREF#3243  -  []  219.33 256.13 0 top
NOREF#3244  -  []  305.68 245.93 0 top
NOREF#3245  -  []  335.71 253.56 90 top
NOREF#3246  -  []  213.39 243.61 0 top
NOREF#3247  -  []  102.08 201.86 90 top
NOREF#3248  -  []  539.45 207.04 0 top
NOREF#3249  -  []  316.7 293.15 90 top
NOREF#3250  -  []  352.13 182.07 90 top
NOREF#3251  -  []  284.49 208.86 0 top
NOREF#3252  -  []  231.8 190.18 90 top
NOREF#3253  -  []  533.93 207.81 0 top
NOREF#3254  -  []  265.05 145.8 0 top
NOREF#3255  -  []  347.05 134.31 0 top
NOREF#3256  -  []  83.29 154.45 0 top
NOREF#3257  -  []  351.44 240.08 90 top
NOREF#3258  -  []  345.33 133.69 0 top
NOREF#3259  -  []  235.91 163.58 90 top
NOREF#3260  -  []  253.66 243.2 0 top
NOREF#3261  -  []  350.18 183.37 90 top
NOREF#3262  -  []  346.97 246.58 0 top
NOREF#3263  -  []  266.06 146.65 90 top
NOREF#3264  -  []  309.59 246.58 90 top
NOREF#3265  -  []  230.18 183.37 90 top
NOREF#3266  -  []  308.44 202.36 0 top
NOREF#3267  -  []  98.19 186.2 0 top
NOREF#3268  -  []  230.83 189.88 90 top
NOREF#3269  -  []  293.22 191.59 0 top
NOREF#3270  -  []  356.23 223.88 90 top
NOREF#3271  -  []  322.34 267.24 0 top
NOREF#3272  -  []  235.48 295.57 0 top
NOREF#3273  -  []  355.12 294.17 90 top
NOREF#3274  -  []  487.94 202.18 0 top
NOREF#3275  -  []  257.83 211.13 0 top
NOREF#3276  -  []  354.91 163.58 90 top
NOREF#3277  -  []  350.82 249.88 90 top
NOREF#3278  -  []  292.45 178.82 0 top
NOREF#3279  -  []  116.75 133.82 90 top
NOREF#3280  -  []  277.71 267.75 90 top
NOREF#3281  -  []  467.84 139.01 0 top
NOREF#3282  -  []  269.59 246.58 0 top
NOREF#3283  -  []  271.08 209.73 0 top
NOREF#3284  -  []  320.81 158.16 0 top
NOREF#3285  -  []  269.85 179.12 90 top
NOREF#3286  -  []  331.83 230.23 315 top
NOREF#3287  -  []  306.94 204.26 0 top
NOREF#3288  -  []  266.06 148.23 0 top
NOREF#3289  -  []  320.81 218.16 0 top
NOREF#3290  -  []  325.1 208.22 0 top
NOREF#3291  -  []  478.68 207.37 0 top
NOREF#3292  -  []  224.52 281.35 90 top
NOREF#3293  -  []  362.91 207.92 0 top
NOREF#3294  -  []  266.91 144.24 0 top
NOREF#3295  -  []  351.19 183 0 top
NOREF#3296  -  []  295.01 193.56 90 top
NOREF#3297  -  []  541.61 166.69 0 top
NOREF#3298  -  []  350.55 134.62 90 top
NOREF#3299  -  []  212.01 183.2 0 top
NOREF#3300  -  []  352.12 189.88 90 top
NOREF#3301  -  []  347.25 173.9 90 top
NOREF#3302  -  []  455.2 221.6 0 top
NOREF#3303  -  []  341.29 292.89 0 top
NOREF#3304  -  []  303.56 295.96 0 top
NOREF#3305  -  []  287.4 207.92 90 top
NOREF#3306  -  []  568.42 149.79 0 top
NOREF#3307  -  []  264.52 286.56 90 top
NOREF#3308  -  []  275.12 293.93 0 top
NOREF#3309  -  []  483 217.95 0 top
NOREF#3310  -  []  271.49 182.62 0 top
NOREF#3311  -  []  310.82 249.88 90 top
NOREF#3312  -  []  235.83 281.88 90 top
NOREF#3313  -  []  306.45 147.01 90 top
NOREF#3314  -  []  252.66 182 90 top
NOREF#3315  -  []  364.79 211.56 90 top
NOREF#3316  -  []  295.56 252.47 90 top
NOREF#3317  -  []  307.9 244.36 90 top
NOREF#3318  -  []  55.27 249.91 90 top
NOREF#3319  -  []  335.06 183.2 0 top
NOREF#3320  -  []  356.47 209.49 0 top
NOREF#3321  -  []  487.64 233.61 90 top
NOREF#3322  -  []  272.74 244.64 90 top
NOREF#3323  -  []  107.94 180.6 0 top
NOREF#3324  -  []  347.9 238.48 90 top
NOREF#3325  -  []  546.66 212.46 0 top
NOREF#3326  -  []  237.71 267.75 90 top
NOREF#3327  -  []  487.94 236.47 0 top
NOREF#3328  -  []  40.23 254.72 0 top
NOREF#3329  -  []  274.44 146.64 0 top
NOREF#3330  -  []  352.13 238.82 90 top
NOREF#3331  -  []  270.82 181.42 90 top
NOREF#3332  -  []  272.2 284.47 0 top
NOREF#3333  -  []  230.57 208.63 90 top
NOREF#3334  -  []  292.78 239.12 90 top
NOREF#3335  -  []  354.65 183.33 90 top
NOREF#3336  -  []  345.83 145.8 90 top
NOREF#3337  -  []  230.13 208.11 90 top
NOREF#3338  -  []  276.89 133.69 0 top
NOREF#3339  -  []  228.57 184.96 0 top
NOREF#3340  -  []  350.89 243.32 0 top
NOREF#3341  -  []  102.34 154.45 0 top
NOREF#3342  -  []  540.94 220.27 0 top
NOREF#3343  -  []  252.78 190.69 90 top
NOREF#3344  -  []  349.83 209.1 90 top
NOREF#3345  -  []  308.27 185.28 0 top
NOREF#3346  -  []  245.73 213.87 90 top
NOREF#3347  -  []  324.6 268.22 90 top
NOREF#3348  -  []  271.8 190.18 90 top
NOREF#3349  -  []  339.87 207.91 0 top
NOREF#3350  -  []  303.27 233.14 0 top
NOREF#3351  -  []  90.64 158.1 0 top
NOREF#3352  -  []  297.83 271.13 0 top
NOREF#3353  -  []  333.22 238.82 90 top
NOREF#3354  -  []  305.88 175.27 0 top
NOREF#3355  -  []  475.7 246.5 90 top
NOREF#3356  -  []  214.66 252.79 0 top
NOREF#3357  -  []  226.61 249.5 0 top
NOREF#3358  -  []  333.09 183.29 90 top
NOREF#3359  -  []  281.44 190.47 0 top
NOREF#3360  -  []  355.37 189.88 90 top
NOREF#3361  -  []  568.79 164.49 0 top
NOREF#3362  -  []  343.56 295.96 0 top
NOREF#3363  -  []  347.75 175.77 0 top
NOREF#3364  -  []  276.7 293.15 90 top
NOREF#3365  -  []  351.54 186.58 0 top
NOREF#3366  -  []  243.55 273.3 0 top
NOREF#3367  -  []  229.59 185.94 90 top
NOREF#3368  -  []  362.56 209.25 90 top
NOREF#3369  -  []  270.83 251.08 0 top
NOREF#3370  -  []  314.91 163.58 0 top
NOREF#3371  -  []  334.36 254.76 0 top
NOREF#3372  -  []  534.31 235.5 0 top
NOREF#3373  -  []  219.41 221.54 90 top
NOREF#3374  -  []  80.94 264.88 0 top
NOREF#3375  -  []  83.29 217.95 0 top
NOREF#3376  -  []  235.12 295.18 0 top
NOREF#3377  -  []  263.71 283.19 0 top
NOREF#3378  -  []  292.33 182.3 90 top
NOREF#3379  -  []  456.64 137.41 90 top
NOREF#3380  -  []  231.54 246.58 0 top
NOREF#3381  -  []  350.86 245.29 0 top
NOREF#3382  -  []  488.4 151.25 90 top
NOREF#3383  -  []  253.22 180.02 0 top
NOREF#3384  -  []  228.44 202.36 0 top
NOREF#3385  -  []  487.64 170.11 90 top
NOREF#3386  -  []  339.41 161.54 90 top
NOREF#3387  -  []  309.15 210.03 90 top
NOREF#3388  -  []  303.09 174.94 0 top
NOREF#3389  -  []  312.14 242.07 0 top
NOREF#3390  -  []  269.33 270.27 0 top
NOREF#3391  -  []  225.96 188.86 0 top
NOREF#3392  -  []  539.45 192.94 0 top
NOREF#3393  -  []  255.01 253.56 90 top
NOREF#3394  -  []  242.91 267.92 0 top
NOREF#3395  -  []  83.8 277.28 90 top
NOREF#3396  -  []  293.29 193.86 90 top
NOREF#3397  -  []  244.49 268.86 0 top
NOREF#3398  -  []  469.1 253.35 0 top
NOREF#3399  -  []  227.59 244.06 90 top
NOREF#3400  -  []  89.44 158.1 0 top
NOREF#3401  -  []  226.61 239.75 90 top
NOREF#3402  -  []  236.94 192.76 90 top
NOREF#3403  -  []  466.15 154.45 0 top
NOREF#3404  -  []  222.95 288.54 90 top
NOREF#3405  -  []  305.06 226.14 0 top
NOREF#3406  -  []  284.79 271.56 0 top
NOREF#3407  -  []  253.1 250.39 90 top
NOREF#3408  -  []  230.24 244.64 90 top
NOREF#3409  -  []  344.52 287.83 0 top
NOREF#3410  -  []  272.46 182.37 90 top
NOREF#3411  -  []  333.61 193.56 90 top
NOREF#3412  -  []  220.33 249.91 0 top
NOREF#3413  -  []  557.76 148.37 0 top
NOREF#3414  -  []  215.06 183.2 0 top
NOREF#3415  -  []  303.27 234.62 0 top
NOREF#3416  -  []  275.12 295.18 0 top
NOREF#3417  -  []  343.71 285.73 0 top
NOREF#3418  -  []  333.1 190.39 90 top
NOREF#3419  -  []  347.58 178.18 0 top
NOREF#3420  -  []  533.93 209.21 0 top
NOREF#3421  -  []  213.22 251.59 0 top
NOREF#3422  -  []  316.22 282.25 90 top
NOREF#3423  -  []  230.24 245.28 0 top
NOREF#3424  -  []  292.66 193.56 90 top
NOREF#3425  -  []  215.06 254.76 0 top
NOREF#3426  -  []  449.05 217.95 0 top
NOREF#3427  -  []  270.83 191.08 0 top
NOREF#3428  -  []  97.24 246.5 90 top
NOREF#3429  -  []  334.38 194.86 0 top
NOREF#3430  -  []  346.6 190.18 90 top
NOREF#3431  -  []  106.74 217.95 0 top
NOREF#3432  -  []  122.64 151.25 90 top
NOREF#3433  -  []  83.8 290.19 0 top
NOREF#3434  -  []  366.75 269.12 0 top
NOREF#3435  -  []  346.28 191.08 0 top
NOREF#3436  -  []  535.51 235.5 90 top
NOREF#3437  -  []  312.46 250.18 90 top
NOREF#3438  -  []  312.46 242.37 90 top
NOREF#3439  -  []  363.37 273.54 0 top
NOREF#3440  -  []  363.15 271.05 0 top
NOREF#3441  -  []  228.26 162.94 90 top
NOREF#3442  -  []  234.44 141.43 0 top
NOREF#3443  -  []  255.01 242 90 top
NOREF#3444  -  []  223.95 174.38 90 top
NOREF#3445  -  []  455.4 186.2 0 top
NOREF#3446  -  []  546.66 196.96 0 top
NOREF#3447  -  []  102.08 205.05 0 top
NOREF#3448  -  []  320.48 209.12 0 top
NOREF#3449  -  []  332.66 182 90 top
NOREF#3450  -  []  213.99 193.86 90 top
NOREF#3451  -  []  467.35 212.35 0 top
NOREF#3452  -  []  230.19 238.82 90 top
NOREF#3453  -  []  349.53 244.02 90 top
NOREF#3454  -  []  348.55 178.48 90 top
NOREF#3455  -  []  282.64 207.56 0 top
NOREF#3456  -  []  94.04 154.45 0 top
NOREF#3457  -  []  352.78 251.08 0 top
NOREF#3458  -  []  365.9 272.03 0 top
NOREF#3459  -  []  252.96 243.2 0 top
NOREF#3460  -  []  350.57 268.63 90 top
NOREF#3461  -  []  212.43 13.4 0 top
NOREF#3462  -  []  293.09 243.93 0 top
NOREF#3463  -  []  231.16 186.26 90 top
NOREF#3464  -  []  503.64 226.27 90 top
NOREF#3465  -  []  235.98 182.68 90 top
NOREF#3466  -  []  308.93 240.09 90 top
NOREF#3467  -  []  89.64 217.95 0 top
NOREF#3468  -  []  347.27 186.26 0 top
NOREF#3469  -  []  268.93 180.73 0 top
NOREF#3470  -  []  360.81 268.22 90 top
NOREF#3471  -  []  349.59 187.23 0 top
NOREF#3472  -  []  449.05 249.7 0 top
NOREF#3473  -  []  311.8 250.18 90 top
NOREF#3474  -  []  229.15 270.51 0 top
NOREF#3475  -  []  456.55 164.57 0 top
NOREF#3476  -  []  344.52 289.22 90 top
NOREF#3477  -  []  265.83 145.8 90 top
NOREF#3478  -  []  540.03 220.67 0 top
NOREF#3479  -  []  290.56 240.75 0 top
NOREF#3480  -  []  267.77 174.98 0 top
NOREF#3481  -  []  292.45 238.82 0 top
NOREF#3482  -  []  334.36 243.2 0 top
NOREF#3483  -  []  461 148.85 0 top
NOREF#3484  -  []  231.11 293.99 90 top
NOREF#3485  -  []  84.29 253.35 0 top
NOREF#3486  -  []  333.1 178.82 90 top
NOREF#3487  -  []  456.55 228.07 0 top
NOREF#3488  -  []  251.64 255.18 0 top
NOREF#3489  -  []  323.37 213.54 0 top
NOREF#3490  -  []  227.59 244.06 0 top
NOREF#3491  -  []  255.38 193.86 90 top
NOREF#3492  -  []  474.41 195.75 0 top
NOREF#3493  -  []  332.96 194.76 0 top
NOREF#3494  -  []  233.43 189.88 90 top
NOREF#3495  -  []  305.95 248.85 90 top
NOREF#3496  -  []  547.04 223.75 90 top
NOREF#3497  -  []  286.89 295.03 90 top
NOREF#3498  -  []  280.37 135.17 90 top
NOREF#3499  -  []  290.61 175.6 90 top
NOREF#3500  -  []  456.64 170.43 90 top
NOREF#3501  -  []  358.39 139.82 90 top
NOREF#3502  -  []  244.49 208.86 0 top
NOREF#3503  -  []  502.15 223.76 90 top
NOREF#3504  -  []  534.61 231.63 0 top
NOREF#3505  -  []  274.66 183.33 90 top
NOREF#3506  -  []  503.03 224.14 90 top
NOREF#3507  -  []  251.96 182 90 top
NOREF#3508  -  []  308.93 241.38 0 top
NOREF#3509  -  []  65.76 268.08 0 top
NOREF#3510  -  []  271.48 251.08 0 top
NOREF#3511  -  []  243.83 158.13 90 top
NOREF#3512  -  []  350.83 187.16 0 top
NOREF#3513  -  []  330.61 192.27 0 top
NOREF#3514  -  []  546.96 210.74 0 top
NOREF#3515  -  []  333.66 183.2 0 top
NOREF#3516  -  []  232.23 232.39 90 top
NOREF#3517  -  []  501.65 208.37 0 top
NOREF#3518  -  []  272.78 249.88 90 top
NOREF#3519  -  []  254.66 192.79 0 top
NOREF#3520  -  []  352.23 170.19 90 top
NOREF#3521  -  []  231.48 241.42 90 top
NOREF#3522  -  []  359.44 140.92 0 top
NOREF#3523  -  []  362.33 173.13 90 top
NOREF#3524  -  []  353.35 241.38 90 top
NOREF#3525  -  []  276.65 267.92 0 top
NOREF#3526  -  []  229.83 269.1 90 top
NOREF#3527  -  []  108.69 154.45 0 top
NOREF#3528  -  []  244.79 211.56 90 top
NOREF#3529  -  []  323.55 273.3 0 top
NOREF#3530  -  []  306.74 294.64 0 top
NOREF#3531  -  []  259.41 166.69 0 top
NOREF#3532  -  []  272.23 232.39 90 top
NOREF#3533  -  []  269.15 270.03 90 top
NOREF#3534  -  []  332.54 194.86 90 top
NOREF#3535  -  []  276.65 267.92 90 top
NOREF#3536  -  []  210.61 187.17 90 top
NOREF#3537  -  []  308.93 181.38 0 top
NOREF#3538  -  []  270.24 244.64 90 top
NOREF#3539  -  []  311.16 246.26 90 top
NOREF#3540  -  []  83.8 265.66 0 top
NOREF#3541  -  []  310.83 251.08 0 top
NOREF#3542  -  []  312.13 243.4 0 top
NOREF#3543  -  []  354.78 182.68 0 top
NOREF#3544  -  []  349.23 180.41 0 top
NOREF#3545  -  []  316.23 163.88 90 top
NOREF#3546  -  []  343.71 280.78 90 top
NOREF#3547  -  []  462.75 158.1 0 top
NOREF#3548  -  []  230.84 243.37 0 top
NOREF#3549  -  []  455.4 249.7 0 top
NOREF#3550  -  []  335.38 253.86 90 top
NOREF#3551  -  []  292.33 193.86 90 top
NOREF#3552  -  []  286.56 293.46 90 top
NOREF#3553  -  []  254.68 183.61 0 top
NOREF#3554  -  []  55.27 250.69 0 top
NOREF#3555  -  []  213.09 183.29 90 top
NOREF#3556  -  []  259.12 288.34 0 top
NOREF#3557  -  []  309.83 269.1 90 top
NOREF#3558  -  []  455.4 217.95 0 top
NOREF#3559  -  []  63.39 272.5 0 top
NOREF#3560  -  []  299.12 288.34 0 top
NOREF#3561  -  []  246.03 214.19 0 top
NOREF#3562  -  []  272.14 251.08 0 top
NOREF#3563  -  []  269.23 208.44 0 top
NOREF#3564  -  []  213.22 190.39 90 top
NOREF#3565  -  []  314.78 242.68 0 top
NOREF#3566  -  []  287.88 212.03 90 top
NOREF#3567  -  []  278.39 139.82 0 top
NOREF#3568  -  []  323.83 158.13 90 top
NOREF#3569  -  []  462.75 253.35 0 top
NOREF#3570  -  []  352.13 181.42 90 top
NOREF#3571  -  []  467.35 156.45 0 top
NOREF#3572  -  []  229.59 187.23 0 top
NOREF#3573  -  []  280.04 135.47 90 top
NOREF#3574  -  []  311.49 240.02 0 top
NOREF#3575  -  []  541.25 147.59 90 top
NOREF#3576  -  []  291.64 182.3 90 top
NOREF#3577  -  []  109.42 165.47 0 top
NOREF#3578  -  []  272.23 227.99 90 top
NOREF#3579  -  []  282.56 269.73 0 top
NOREF#3580  -  []  321.34 136.1 0 top
NOREF#3581  -  []  500.77 207.98 0 top
NOREF#3582  -  []  295.16 251.22 90 top
NOREF#3583  -  []  272.46 180.42 90 top
NOREF#3584  -  []  90.79 177.57 0 top
NOREF#3585  -  []  308.17 137.2 90 top
NOREF#3586  -  []  227.64 241.37 0 top
NOREF#3587  -  []  315.44 194.76 90 top
NOREF#3588  -  []  498.63 225.44 0 top
NOREF#3589  -  []  285.29 272.67 0 top
NOREF#3590  -  []  247.56 212.93 0 top
NOREF#3591  -  []  232.74 244.64 90 top
NOREF#3592  -  []  293.61 193.56 90 top
NOREF#3593  -  []  368.21 211.73 90 top
NOREF#3594  -  []  330.33 162.13 90 top
NOREF#3595  -  []  348.17 137.2 90 top
NOREF#3596  -  []  267.05 134.31 0 top
NOREF#3597  -  []  254.38 194.86 0 top
NOREF#3598  -  []  453.45 249.7 0 top
NOREF#3599  -  []  211.96 182 90 top
NOREF#3600  -  []  350.83 247.15 0 top
NOREF#3601  -  []  66.13 268.47 0 top
NOREF#3602  -  []  346.91 144.24 90 top
NOREF#3603  -  []  213.66 183.2 0 top
NOREF#3604  -  []  309.85 239.12 90 top
NOREF#3605  -  []  243.37 213.06 90 top
NOREF#3606  -  []  267.9 238.48 90 top
NOREF#3607  -  []  303.09 232.9 0 top
NOREF#3608  -  []  270.13 208.11 90 top
NOREF#3609  -  []  332.45 250.39 0 top
NOREF#3610  -  []  557.76 164.88 0 top
NOREF#3611  -  []  283.83 158.13 90 top
NOREF#3612  -  []  347.58 238.18 0 top
NOREF#3613  -  []  232.79 183.41 90 top
NOREF#3614  -  []  55.27 247.71 90 top
NOREF#3615  -  []  331.33 207.13 0 top
NOREF#3616  -  []  102.14 253.35 0 top
NOREF#3617  -  []  102.38 236.47 0 top
NOREF#3618  -  []  243.24 268.22 90 top
NOREF#3619  -  []  456.55 145.82 0 top
NOREF#3620  -  []  331.83 203.63 0 top
NOREF#3621  -  []  267.64 240.73 90 top
NOREF#3622  -  []  294.68 183.61 0 top
NOREF#3623  -  []  362.34 267.24 0 top
NOREF#3624  -  []  245.9 212.03 0 top
NOREF#3625  -  []  227.77 174.98 0 top
NOREF#3626  -  []  334.68 182.3 90 top
NOREF#3627  -  []  311.55 285.02 0 top
NOREF#3628  -  []  304.91 233.9 0 top
NOREF#3629  -  []  88.89 148.85 0 top
NOREF#3630  -  []  108.65 195.75 0 top
NOREF#3631  -  []  501.52 222.3 90 top
NOREF#3632  -  []  222.76 12.57 90 top
NOREF#3633  -  []  229.53 238.82 90 top
NOREF#3634  -  []  215.83 199.63 0 top
NOREF#3635  -  []  268.27 185.28 0 top
NOREF#3636  -  []  263.71 288.4 0 top
NOREF#3637  -  []  345.06 226.14 0 top
NOREF#3638  -  []  321.13 267.92 90 top
NOREF#3639  -  []  96.99 221.6 0 top
NOREF#3640  -  []  83.2 276.6 90 top
NOREF#3641  -  []  313.11 183.7 90 top
NOREF#3642  -  []  315.44 254.76 90 top
NOREF#3643  -  []  341.62 293.19 90 top
NOREF#3644  -  []  251.16 247.72 90 top
NOREF#3645  -  []  480.8 217.95 0 top
NOREF#3646  -  []  334.68 255.18 0 top
NOREF#3647  -  []  355.23 223.88 90 top
NOREF#3648  -  []  463 246.5 90 top
NOREF#3649  -  []  459.07 225.86 0 top
NOREF#3650  -  []  235.38 249.88 90 top
NOREF#3651  -  []  223.27 175.18 0 top
NOREF#3652  -  []  313.4 294.56 0 top
NOREF#3653  -  []  284.6 268.22 90 top
NOREF#3654  -  []  352.45 240.42 90 top
NOREF#3655  -  []  251.34 194.86 0 top
NOREF#3656  -  []  240.81 158.16 90 top
NOREF#3657  -  []  333.22 240.02 0 top
NOREF#3658  -  []  534.61 222.87 0 top
NOREF#3659  -  []  312.14 240.12 90 top
NOREF#3660  -  []  487.64 236.8 0 top
NOREF#3661  -  []  323.54 267.24 90 top
NOREF#3662  -  []  251.16 240.15 0 top
NOREF#3663  -  []  211.16 191.72 0 top
NOREF#3664  -  []  252.96 194.76 0 top
NOREF#3665  -  []  461.75 249.7 0 top
NOREF#3666  -  []  350.24 240.08 0 top
NOREF#3667  -  []  250.61 180.7 0 top
NOREF#3668  -  []  230.84 242.62 0 top
NOREF#3669  -  []  560.13 170.72 90 top
NOREF#3670  -  []  271.48 185.96 90 top
NOREF#3671  -  []  254.31 182 90 top
NOREF#3672  -  []  244.38 213.87 0 top
NOREF#3673  -  []  271.44 180.08 90 top
NOREF#3674  -  []  264.52 287.83 0 top
NOREF#3675  -  []  95.99 186.2 0 top
NOREF#3676  -  []  335.58 243.29 90 top
NOREF#3677  -  []  226.61 179.76 90 top
NOREF#3678  -  []  254.36 194.76 0 top
NOREF#3679  -  []  312.13 243.4 90 top
NOREF#3680  -  []  211.83 225.63 90 top
NOREF#3681  -  []  310.84 187.16 0 top
NOREF#3682  -  []  332.96 254.76 0 top
NOREF#3683  -  []  362.74 269.49 0 top
NOREF#3684  -  []  96.99 189.85 0 top
NOREF#3685  -  []  305.68 185.29 90 top
NOREF#3686  -  []  242.34 267.24 0 top
NOREF#3687  -  []  272.46 181.7 0 top
NOREF#3688  -  []  224.52 283.89 90 top
NOREF#3689  -  []  311.84 186.26 0 top
NOREF#3690  -  []  290.56 192.32 0 top
NOREF#3691  -  []  331.16 187.72 90 top
NOREF#3692  -  []  232.13 243.4 90 top
NOREF#3693  -  []  478.18 200.32 0 top
NOREF#3694  -  []  81.82 278.99 0 top
NOREF#3695  -  []  234.91 223.58 90 top
NOREF#3696  -  []  102.08 204.4 90 top
NOREF#3697  -  []  308.25 173.12 90 top
NOREF#3698  -  []  478.68 239.12 0 top
NOREF#3699  -  []  307.93 187.56 0 top
NOREF#3700  -  []  311.48 241.42 90 top
NOREF#3701  -  []  325.73 214.51 0 top
NOREF#3702  -  []  272.23 172.39 90 top
NOREF#3703  -  []  311.19 269.1 90 top
NOREF#3704  -  []  335.71 182 90 top
NOREF#3705  -  []  456.65 183 90 top
NOREF#3706  -  []  87.69 217.95 0 top
NOREF#3707  -  []  47.98 268.08 0 top
NOREF#3708  -  []  270.84 242.62 0 top
NOREF#3709  -  []  309.89 245.61 0 top
NOREF#3710  -  []  480.6 189.85 0 top
NOREF#3711  -  []  534.31 231.31 0 top
NOREF#3712  -  []  253.29 242.3 90 top
NOREF#3713  -  []  276.11 234.13 90 top
NOREF#3714  -  []  309.59 185.93 0 top
NOREF#3715  -  []  83.29 249.7 0 top
NOREF#3716  -  []  37.31 265.88 90 top
NOREF#3717  -  []  215.71 253.56 90 top
NOREF#3718  -  []  342.95 286.63 90 top
NOREF#3719  -  []  123.19 280.67 90 top
NOREF#3720  -  []  238.39 139.82 0 top
NOREF#3721  -  []  214.36 193.12 0 top
NOREF#3722  -  []  120.02 132.32 90 top
NOREF#3723  -  []  310.84 183.37 90 top
NOREF#3724  -  []  210.61 252.27 0 top
NOREF#3725  -  []  307.63 247.88 0 top
NOREF#3726  -  []  307.25 234.3 90 top
NOREF#3727  -  []  546.66 196.31 90 top
NOREF#3728  -  []  110.89 217.95 0 top
NOREF#3729  -  []  253.61 193.56 90 top
NOREF#3730  -  []  117.24 186.2 0 top
NOREF#3731  -  []  349.5 268.8 0 top
NOREF#3732  -  []  223.09 234.38 0 top
NOREF#3733  -  []  236.94 252.76 90 top
NOREF#3734  -  []  232.78 189.88 90 top
NOREF#3735  -  []  295.58 183.29 90 top
NOREF#3736  -  []  212.33 193.86 90 top
NOREF#3737  -  []  365.73 213.87 90 top
NOREF#3738  -  []  330.56 175.55 90 top
NOREF#3739  -  []  269.46 145.44 90 top
NOREF#3740  -  []  305.14 295.18 90 top
NOREF#3741  -  []  285.73 213.87 90 top
NOREF#3742  -  []  333.09 195.5 0 top
NOREF#3743  -  []  47.37 254.33 90 top
NOREF#3744  -  []  251.33 207.13 0 top
NOREF#3745  -  []  480.8 249.7 0 top
NOREF#3746  -  []  500.77 226.14 0 top
NOREF#3747  -  []  302.56 286.27 0 top
NOREF#3748  -  []  230.91 187.24 90 top
NOREF#3749  -  []  232.2 283.17 90 top
NOREF#3750  -  []  487.64 170.76 0 top
NOREF#3751  -  []  117.42 128.72 90 top
NOREF#3752  -  []  228.93 240.74 90 top
NOREF#3753  -  []  250.61 252.27 0 top
NOREF#3754  -  []  309.15 270.03 90 top
NOREF#3755  -  []  356.7 293.15 90 top
NOREF#3756  -  []  320.04 140.12 0 top
NOREF#3757  -  []  345.44 146.16 90 top
NOREF#3758  -  []  546.66 211.06 0 top
NOREF#3759  -  []  312.78 183.41 0 top
NOREF#3760  -  []  324.6 208.22 90 top
NOREF#3761  -  []  284.79 211.56 90 top
NOREF#3762  -  []  259.41 161.54 90 top
NOREF#3763  -  []  334.68 193.86 90 top
NOREF#3764  -  []  352.45 250.18 90 top
NOREF#3765  -  []  334.36 253.12 0 top
NOREF#3766  -  []  349.53 244.02 0 top
NOREF#3767  -  []  214.31 182 90 top
NOREF#3768  -  []  217.83 271.13 0 top
NOREF#3769  -  []  351.48 182.62 0 top
NOREF#3770  -  []  102.34 249.7 0 top
NOREF#3771  -  []  315.12 294.17 0 top
NOREF#3772  -  []  345.43 292.08 90 top
NOREF#3773  -  []  454.65 219.95 0 top
NOREF#3774  -  []  299.87 267.91 0 top
NOREF#3775  -  []  274.78 182.68 0 top
NOREF#3776  -  []  310.24 180.08 0 top
NOREF#3777  -  []  213.39 255.18 0 top
NOREF#3778  -  []  81.36 289.37 0 top
NOREF#3779  -  []  348.01 234.3 90 top
NOREF#3780  -  []  534.31 234.1 0 top
NOREF#3781  -  []  307.58 244.06 0 top
NOREF#3782  -  []  253.39 255.18 0 top
NOREF#3783  -  []  474.41 164 0 top
NOREF#3784  -  []  270.89 182.68 90 top
NOREF#3785  -  []  277.14 144.1 90 top
NOREF#3786  -  []  306.6 190.18 90 top
NOREF#3787  -  []  485.2 217.95 0 top
NOREF#3788  -  []  122.18 138.68 0 top
NOREF#3789  -  []  213.1 178.82 90 top
NOREF#3790  -  []  333.29 242.3 90 top
NOREF#3791  -  []  245.1 268.22 0 top
NOREF#3792  -  []  272.14 242.07 0 top
NOREF#3793  -  []  303.27 235.18 0 top
NOREF#3794  -  []  230.55 134.62 90 top
NOREF#3795  -  []  234.82 281.03 0 top
NOREF#3796  -  []  347.58 238.18 90 top
NOREF#3797  -  []  316.29 209.25 90 top
NOREF#3798  -  []  351.15 181.72 90 top
NOREF#3799  -  []  228.26 222.94 90 top
NOREF#3800  -  []  309.23 180.41 0 top
NOREF#3801  -  []  253.22 178.82 90 top
NOREF#3802  -  []  234.44 146.64 0 top
NOREF#3803  -  []  344.91 173.9 0 top
NOREF#3804  -  []  78.8 291.62 0 top
NOREF#3805  -  []  318.71 140.12 90 top
NOREF#3806  -  []  461.07 133.97 90 top
NOREF#3807  -  []  459.8 186.2 0 top
NOREF#3808  -  []  83.8 264.21 0 top
NOREF#3809  -  []  231.16 243.67 90 top
NOREF#3810  -  []  331.31 243.2 0 top
NOREF#3811  -  []  264.52 290.49 0 top
NOREF#3812  -  []  122.18 170.43 0 top
NOREF#3813  -  []  211.83 263.63 0 top
NOREF#3814  -  []  215.38 242.3 90 top
NOREF#3815  -  []  363.24 268.22 90 top
NOREF#3816  -  []  347.93 247.56 0 top
NOREF#3817  -  []  327.56 212.93 0 top
NOREF#3818  -  []  483.18 160.47 90 top
NOREF#3819  -  []  310.57 208.63 0 top
NOREF#3820  -  []  270.57 268.63 0 top
NOREF#3821  -  []  311.21 247.56 0 top
NOREF#3822  -  []  78.8 262.93 0 top
NOREF#3823  -  []  334.31 242 90 top
NOREF#3824  -  []  347.64 181.38 0 top
NOREF#3825  -  []  102.14 189.85 0 top
NOREF#3826  -  []  269.15 210.51 0 top
NOREF#3827  -  []  331.96 193.56 90 top
NOREF#3828  -  []  231.48 185.96 90 top
NOREF#3829  -  []  315.83 281.88 90 top
NOREF#3830  -  []  455.4 186.2 0 top
NOREF#3831  -  []  360.81 218.16 0 top
NOREF#3832  -  []  90.79 228.07 90 top
NOREF#3833  -  []  309.59 187.23 0 top
NOREF#3834  -  []  253.29 253.86 90 top
NOREF#3835  -  []  46.16 254.72 0 top
NOREF#3836  -  []  348.25 234.12 90 top
NOREF#3837  -  []  310.84 178.82 90 top
NOREF#3838  -  []  290.56 175.55 90 top
NOREF#3839  -  []  230.86 185.29 0 top
NOREF#3840  -  []  264.09 231.46 90 top
NOREF#3841  -  []  226.61 248.85 90 top
NOREF#3842  -  []  473.7 212.35 0 top
NOREF#3843  -  []  360.37 135.17 90 top
NOREF#3844  -  []  222.86 226.14 0 top
NOREF#3845  -  []  347.63 187.88 0 top
NOREF#3846  -  []  255.01 193.56 90 top
NOREF#3847  -  []  292.96 194.76 0 top
NOREF#3848  -  []  546.96 209.34 0 top
NOREF#3849  -  []  316.52 133.3 0 top
NOREF#3850  -  []  547.04 223 0 top
NOREF#3851  -  []  335.06 194.76 0 top
NOREF#3852  -  []  539.65 193.24 90 top
NOREF#3853  -  []  232.23 167.99 0 top
NOREF#3854  -  []  349.23 181.06 0 top
NOREF#3855  -  []  122.18 236.47 0 top
NOREF#3856  -  []  363.72 211.73 90 top
NOREF#3857  -  []  322.57 220.09 0 top
NOREF#3858  -  []  275.6 281.03 90 top
NOREF#3859  -  []  303.71 285.73 0 top
NOREF#3860  -  []  567.63 154.21 90 top
NOREF#3861  -  []  487.94 141.22 0 top
NOREF#3862  -  []  55.09 266.66 0 top
NOREF#3863  -  []  212.96 254.76 0 top
NOREF#3864  -  []  293.29 242.3 90 top
NOREF#3865  -  []  232.79 243.4 0 top
NOREF#3866  -  []  546.66 197.71 90 top
NOREF#3867  -  []  210.56 187.12 90 top
NOREF#3868  -  []  266.97 245.93 90 top
NOREF#3869  -  []  362.91 267.92 90 top
NOREF#3870  -  []  307.56 144.79 90 top
NOREF#3871  -  []  267.25 233.9 90 top
NOREF#3872  -  []  264.52 289.22 90 top
NOREF#3873  -  []  217.83 263.63 90 top
NOREF#3874  -  []  253.22 190.39 90 top
NOREF#3875  -  []  551.91 166.3 0 top
NOREF#3876  -  []  84.29 189.85 0 top
NOREF#3877  -  []  362.91 207.92 90 top
NOREF#3878  -  []  95.31 133.97 90 top
NOREF#3879  -  []  261.29 292.89 90 top
NOREF#3880  -  []  356.29 209.73 0 top
NOREF#3881  -  []  333.39 255.18 0 top
NOREF#3882  -  []  55.27 248.49 0 top
NOREF#3883  -  []  243.45 271.37 0 top
NOREF#3884  -  []  325.9 212.03 0 top
NOREF#3885  -  []  251.64 242.3 90 top
NOREF#3886  -  []  309.59 246.58 0 top
NOREF#3887  -  []  309.89 185.61 0 top
NOREF#3888  -  []  308.93 180.73 0 top
NOREF#3889  -  []  347.63 247.88 0 top
NOREF#3890  -  []  293.39 183.61 0 top
NOREF#3891  -  []  323.98 267.75 0 top
NOREF#3892  -  []  251.64 193.86 90 top
NOREF#3893  -  []  250.61 235.6 90 top
NOREF#3894  -  []  486.95 221.6 0 top
NOREF#3895  -  []  344.09 171.46 0 top
NOREF#3896  -  []  560.13 171.5 0 top
NOREF#3897  -  []  310.84 182.62 0 top
NOREF#3898  -  []  333.09 255.5 0 top
NOREF#3899  -  []  288.21 211.73 90 top
NOREF#3900  -  []  287.4 267.92 90 top
NOREF#3901  -  []  234.1 283.17 90 top
NOREF#3902  -  []  260.66 166.14 0 top
NOREF#3903  -  []  115.81 253.42 0 top
NOREF#3904  -  []  263.92 295.57 0 top
NOREF#3905  -  []  244.68 274.19 0 top
NOREF#3906  -  []  119.44 249.7 0 top
NOREF#3907  -  []  353.49 291.46 90 top
NOREF#3908  -  []  317.95 143.53 90 top
NOREF#3909  -  []  100.39 217.95 0 top
NOREF#3910  -  []  268.93 268.11 0 top
NOREF#3911  -  []  461.75 154.45 0 top
NOREF#3912  -  []  347.25 234.3 90 top
NOREF#3913  -  []  231.84 246.26 0 top
NOREF#3914  -  []  271.49 180.02 0 top
NOREF#3915  -  []  216.33 17.59 0 top
NOREF#3916  -  []  227.25 234.3 90 top
NOREF#3917  -  []  280.81 218.66 90 top
NOREF#3918  -  []  294.66 181.23 0 top
NOREF#3919  -  []  291.16 191.72 0 top
NOREF#3920  -  []  225.33 135.72 0 top
NOREF#3921  -  []  308.93 240.74 90 top
NOREF#3922  -  []  303.27 174.06 0 top
NOREF#3923  -  []  222.56 286.27 0 top
NOREF#3924  -  []  482.51 165.57 90 top
NOREF#3925  -  []  310.84 243.37 0 top
NOREF#3926  -  []  558.12 166.69 0 top
NOREF#3927  -  []  274.61 294.17 90 top
NOREF#3928  -  []  268.44 262.36 0 top
NOREF#3929  -  []  355.21 281.4 90 top
NOREF#3930  -  []  324.35 211.05 90 top
NOREF#3931  -  []  293.66 243.2 0 top
NOREF#3932  -  []  350.55 134.62 90 top
NOREF#3933  -  []  352.45 181.7 0 top
NOREF#3934  -  []  461 188.2 0 top
NOREF#3935  -  []  365.9 212.03 0 top
NOREF#3936  -  []  355.05 250.18 90 top
NOREF#3937  -  []  293.61 253.56 90 top
NOREF#3938  -  []  91.84 217.95 0 top
NOREF#3939  -  []  267.64 241.37 0 top
NOREF#3940  -  []  546.96 212.13 0 top
NOREF#3941  -  []  270.54 244.96 0 top
NOREF#3942  -  []  290.33 162.13 90 top
NOREF#3943  -  []  461.75 249.7 0 top
NOREF#3944  -  []  461.55 189.85 0 top
NOREF#3945  -  []  271.19 183 0 top
NOREF#3946  -  []  475.18 165.47 0 top
NOREF#3947  -  []  309.15 270.51 0 top
NOREF#3948  -  []  331.16 191.72 0 top
NOREF#3949  -  []  286.89 291.24 90 top
NOREF#3950  -  []  83.8 262.76 0 top
NOREF#3951  -  []  467.9 189.85 0 top
NOREF#3952  -  []  275.91 163.58 0 top
NOREF#3953  -  []  334.38 254.86 0 top
NOREF#3954  -  []  210.61 235.6 90 top
NOREF#3955  -  []  457.6 217.95 0 top
NOREF#3956  -  []  271.15 190.18 90 top
NOREF#3957  -  []  352.23 167.99 0 top
NOREF#3958  -  []  330.56 192.32 0 top
NOREF#3959  -  []  305.43 295.26 0 top
NOREF#3960  -  []  243.83 218.13 90 top
NOREF#3961  -  []  272.06 245.29 90 top
NOREF#3962  -  []  302.96 225.63 90 top
NOREF#3963  -  []  310.89 182.68 90 top
NOREF#3964  -  []  570.88 417.57 90 top
NOREF#3965  -  []  90.79 164.57 90 top
NOREF#3966  -  []  253.09 194.86 90 top
NOREF#3967  -  []  293.22 238.82 90 top
NOREF#3968  -  []  349.5 208.8 0 top
NOREF#3969  -  []  539.84 220.07 90 top
NOREF#3970  -  []  344.52 281.35 90 top
NOREF#3971  -  []  325.83 229.63 90 top
NOREF#3972  -  []  277.14 146.64 90 top
NOREF#3973  -  []  351.21 187.56 0 top
NOREF#3974  -  []  278.22 208.86 0 top
NOREF#3975  -  []  274.74 191.08 0 top
NOREF#3976  -  []  81.82 265.27 0 top
NOREF#3977  -  []  292.54 183.29 90 top
NOREF#3978  -  []  454.65 180.6 0 top
NOREF#3979  -  []  310.84 178.82 0 top
NOREF#3980  -  []  335.16 179.65 90 top
NOREF#3981  -  []  349.59 186.58 0 top
NOREF#3982  -  []  236.07 267.24 0 top
NOREF#3983  -  []  466.15 217.95 0 top
NOREF#3984  -  []  307.63 187.88 0 top
NOREF#3985  -  []  541.61 150.18 0 top
NOREF#3986  -  []  282.56 269.25 90 top
NOREF#3987  -  []  228.93 240.09 90 top
NOREF#3988  -  []  254.66 241.23 0 top
NOREF#3989  -  []  312.2 283.17 90 top
NOREF#3990  -  []  265.96 248.85 0 top
NOREF#3991  -  []  112.42 168.57 90 top
NOREF#3992  -  []  91.84 154.45 0 top
NOREF#3993  -  []  232.13 243.4 0 top
NOREF#3994  -  []  230.54 244.96 0 top
NOREF#3995  -  []  243.72 271.73 0 top
NOREF#3996  -  []  503.64 223.36 90 top
NOREF#3997  -  []  237.95 146.07 90 top
NOREF#3998  -  []  109.69 221.6 0 top
NOREF#3999  -  []  252.66 193.56 90 top
NOREF#4000  -  []  269.83 209.1 90 top
NOREF#4001  -  []  228.56 178.48 90 top
NOREF#4002  -  []  265.68 245.29 90 top
NOREF#4003  -  []  366.03 214.19 0 top
NOREF#4004  -  []  342.96 165.63 90 top
NOREF#4005  -  []  283.15 271.05 0 top
NOREF#4006  -  []  81.69 261.04 90 top
NOREF#4007  -  []  350.5 183.67 90 top
NOREF#4008  -  []  260.66 226.14 0 top
NOREF#4009  -  []  557.76 166.3 90 top
NOREF#4010  -  []  318.33 268.22 90 top
NOREF#4011  -  []  270.55 134.62 0 top
NOREF#4012  -  []  211.33 267.13 0 top
NOREF#4013  -  []  271.16 186.26 90 top
NOREF#4014  -  []  79.1 263.26 0 top
NOREF#4015  -  []  268.93 181.38 0 top
NOREF#4016  -  []  365.73 273.87 90 top
NOREF#4017  -  []  268.49 136.9 90 top
NOREF#4018  -  []  467.35 251.7 0 top
NOREF#4019  -  []  264.96 134.08 0 top
NOREF#4020  -  []  347.05 134.31 90 top
NOREF#4021  -  []  356.89 133.69 0 top
NOREF#4022  -  []  211.31 183.2 0 top
NOREF#4023  -  []  332.33 242.3 90 top
NOREF#4024  -  []  213.99 253.86 90 top
NOREF#4025  -  []  348.27 245.93 0 top
NOREF#4026  -  []  84.1 262.43 0 top
NOREF#4027  -  []  334.36 183.2 0 top
NOREF#4028  -  []  282.57 160.09 0 top
NOREF#4029  -  []  352.05 185.29 90 top
NOREF#4030  -  []  292.78 179.12 90 top
NOREF#4031  -  []  253.22 191.59 0 top
NOREF#4032  -  []  277.27 207.24 90 top
NOREF#4033  -  []  213.29 193.86 90 top
NOREF#4034  -  []  221.62 293.19 90 top
NOREF#4035  -  []  351.48 251.08 0 top
NOREF#4036  -  []  114.29 251.7 0 top
NOREF#4037  -  []  456.64 233.93 90 top
NOREF#4038  -  []  473.7 180.6 0 top
NOREF#4039  -  []  476.65 249.7 0 top
NOREF#4040  -  []  254.68 243.61 0 top
NOREF#4041  -  []  267.9 182.38 90 top
NOREF#4042  -  []  295.83 199.63 0 top
NOREF#4043  -  []  255.71 242 90 top
NOREF#4044  -  []  243.98 267.75 90 top
NOREF#4045  -  []  115.04 154.45 0 top
NOREF#4046  -  []  230.18 251.08 0 top
NOREF#4047  -  []  295.58 194.86 90 top
NOREF#4048  -  []  272.14 180.12 90 top
NOREF#4049  -  []  294.36 183.2 0 top
NOREF#4050  -  []  67.34 268.08 90 top
NOREF#4051  -  []  356.94 252.76 90 top
NOREF#4052  -  []  348.66 166.14 0 top
NOREF#4053  -  []  349.59 185.94 90 top
NOREF#4054  -  []  293.66 194.76 0 top
NOREF#4055  -  []  311.16 241.72 90 top
NOREF#4056  -  []  231.8 250.18 90 top
NOREF#4057  -  []  226.97 245.93 90 top
NOREF#4058  -  []  310.13 208.11 90 top
NOREF#4059  -  []  251.64 182.3 90 top
NOREF#4060  -  []  114.29 148.85 0 top
NOREF#4061  -  []  103.59 151.25 90 top
NOREF#4062  -  []  213.32 13.07 90 top
NOREF#4063  -  []  353.03 295.96 0 top
NOREF#4064  -  []  219.87 267.91 0 top
NOREF#4065  -  []  230.24 184.64 90 top
NOREF#4066  -  []  268.01 234.3 90 top
NOREF#4067  -  []  275.44 194.76 90 top
NOREF#4068  -  []  352.13 191.08 0 top
NOREF#4069  -  []  333.09 254.86 90 top
NOREF#4070  -  []  276.47 269.49 0 top
NOREF#4071  -  []  230.18 243.37 0 top
NOREF#4072  -  []  294.31 242 90 top
NOREF#4073  -  []  230.24 180.08 0 top
NOREF#4074  -  []  350.73 226.09 0 top
NOREF#4075  -  []  108.49 221.6 0 top
NOREF#4076  -  []  113.09 154.45 0 top
NOREF#4077  -  []  534.61 220.08 0 top
NOREF#4078  -  []  211.96 242 90 top
NOREF#4079  -  []  350.83 251.08 0 top
NOREF#4080  -  []  90.88 232.66 90 top
NOREF#4081  -  []  231.16 183.67 90 top
NOREF#4082  -  []  275.83 283.46 0 top
NOREF#4083  -  []  244.38 273.87 0 top
NOREF#4084  -  []  349.15 210.03 90 top
NOREF#4085  -  []  95.31 165.72 90 top
NOREF#4086  -  []  362.56 269.25 90 top
NOREF#4087  -  []  231.48 249.88 90 top
NOREF#4088  -  []  305.68 185.93 0 top
NOREF#4089  -  []  116.04 158.1 0 top
NOREF#4090  -  []  266.28 191.08 0 top
NOREF#4091  -  []  294.68 242.3 90 top
NOREF#4092  -  []  345.05 145.8 0 top
NOREF#4093  -  []  119.44 217.95 0 top
NOREF#4094  -  []  310.5 181.72 90 top
NOREF#4095  -  []  266.93 178.18 0 top
NOREF#4096  -  []  83.67 289.47 90 top
NOREF#4097  -  []  215.06 194.76 0 top
NOREF#4098  -  []  330.61 252.27 0 top
NOREF#4099  -  []  272.14 180.12 0 top
NOREF#4100  -  []  307.27 186.26 0 top
NOREF#4101  -  []  20.74 132.9 90 top
NOREF#4102  -  []  63.94 254.72 0 top
NOREF#4103  -  []  330.61 187.17 90 top
NOREF#4104  -  []  253.09 183.93 0 top
NOREF#4105  -  []  224.96 134.08 0 top
NOREF#4106  -  []  290.61 187.17 90 top
NOREF#4107  -  []  350.55 134.62 0 top
NOREF#4108  -  []  213.32 14.79 90 top
NOREF#4109  -  []  560.49 171.11 0 top
NOREF#4110  -  []  457.19 272.83 0 top
NOREF#4111  -  []  286.56 291.54 90 top
NOREF#4112  -  []  317.27 267.24 90 top
NOREF#4113  -  []  331.64 193.86 90 top
NOREF#4114  -  []  480.18 139.32 0 top
NOREF#4115  -  []  295.06 254.76 0 top
NOREF#4116  -  []  304.52 281.35 90 top
NOREF#4117  -  []  335.71 242 90 top
NOREF#4118  -  []  282.57 220.09 0 top
NOREF#4119  -  []  117.24 217.95 0 top
NOREF#4120  -  []  454.65 148.85 0 top
NOREF#4121  -  []  283.37 213.54 0 top
NOREF#4122  -  []  357.95 138.2 90 top
NOREF#4123  -  []  346.91 144.24 0 top
NOREF#4124  -  []  233.4 294.56 0 top
NOREF#4125  -  []  270.84 238.82 90 top
NOREF#4126  -  []  365.83 169.63 90 top
NOREF#4127  -  []  295.38 182.3 90 top
NOREF#4128  -  []  317.71 267.75 90 top
NOREF#4129  -  []  473.7 244.1 0 top
NOREF#4130  -  []  541.25 150.57 0 top
NOREF#4131  -  []  269.15 210.03 90 top
NOREF#4132  -  []  101.59 156.45 0 top
NOREF#4133  -  []  360.48 269.12 0 top
NOREF#4134  -  []  333.29 182.3 90 top
NOREF#4135  -  []  343.27 235.18 0 top
NOREF#4136  -  []  350.18 238.82 90 top
NOREF#4137  -  []  122.18 202.18 0 top
NOREF#4138  -  []  292.66 242 90 top
NOREF#4139  -  []  236.47 269.49 0 top
NOREF#4140  -  []  344.42 235.77 0 top
NOREF#4141  -  []  345.48 235.27 0 top
NOREF#4142  -  []  475.18 133.72 90 top
NOREF#4143  -  []  255.06 243.2 0 top
NOREF#4144  -  []  108.49 253.35 0 top
NOREF#4145  -  []  55.09 265.88 90 top
NOREF#4146  -  []  542.34 236.63 90 top
NOREF#4147  -  []  227.91 242.38 90 top
NOREF#4148  -  []  332.01 254.76 0 top
NOREF#4149  -  []  39.68 272.5 90 top
NOREF#4150  -  []  314.82 281.03 0 top
NOREF#4151  -  []  213.39 195.18 0 top
NOREF#4152  -  []  300.66 226.14 0 top
NOREF#4153  -  []  304.09 171.46 90 top
NOREF#4154  -  []  342.63 289.44 0 top
NOREF#4155  -  []  286.24 293.16 90 top
NOREF#4156  -  []  275.44 194.76 90 top
NOREF#4157  -  []  293.22 178.82 90 top
NOREF#4158  -  []  362.64 207.56 0 top
NOREF#4159  -  []  227.27 186.26 0 top
NOREF#4160  -  []  107.94 244.1 0 top
NOREF#4161  -  []  243.24 208.22 90 top
NOREF#4162  -  []  95.24 148.85 0 top
NOREF#4163  -  []  247.65 220.09 90 top
NOREF#4164  -  []  269.23 180.41 0 top
NOREF#4165  -  []  227.26 238.48 90 top
NOREF#4166  -  []  274.75 282.62 90 top
NOREF#4167  -  []  330.61 247.17 90 top
NOREF#4168  -  []  229.86 239.12 90 top
NOREF#4169  -  []  548.65 417.57 90 top
NOREF#4170  -  []  367.07 208.22 90 top
NOREF#4171  -  []  348.22 182.08 90 top
NOREF#4172  -  []  463.95 217.95 0 top
NOREF#4173  -  []  231.48 181.42 90 top
NOREF#4174  -  []  284.35 271.05 90 top
NOREF#4175  -  []  121.88 236.15 90 top
NOREF#4176  -  []  270.84 183.37 90 top
NOREF#4177  -  []  270.91 247.23 90 top
NOREF#4178  -  []  295.41 296.9 0 top
NOREF#4179  -  []  277.71 207.75 90 top
NOREF#4180  -  []  501.52 204.14 90 top
NOREF#4181  -  []  306.28 251.08 0 top
NOREF#4182  -  []  229.23 268.44 0 top
NOREF#4183  -  []  270.18 191.08 0 top
NOREF#4184  -  []  225.98 185.61 0 top
NOREF#4185  -  []  270.19 178.82 90 top
NOREF#4186  -  []  452.74 2.28 90 top
NOREF#4187  -  []  351.84 184.96 0 top
NOREF#4188  -  []  213.54 179.12 90 top
NOREF#4189  -  []  269.59 247.23 0 top
NOREF#4190  -  []  211.16 240.15 0 top
NOREF#4191  -  []  223.27 234.62 0 top
NOREF#4192  -  []  333.54 190.69 90 top
NOREF#4193  -  []  240.81 218.16 90 top
NOREF#4194  -  []  306.28 191.08 0 top
NOREF#4195  -  []  235.6 281.03 90 top
NOREF#4196  -  []  293.09 194.86 90 top
NOREF#4197  -  []  468.1 249.7 0 top
NOREF#4198  -  []  335.16 191.22 90 top
NOREF#4199  -  []  243.98 267.75 0 top
NOREF#4200  -  []  292.01 183.2 0 top
NOREF#4201  -  []  264.91 173.9 0 top
NOREF#4202  -  []  268.26 162.94 90 top
NOREF#4203  -  []  229.89 186.26 0 top
NOREF#4204  -  []  233.43 249.88 90 top
NOREF#4205  -  []  266.61 190.18 90 top
NOREF#4206  -  []  313.11 243.7 90 top
NOREF#4207  -  []  461.75 217.95 0 top
NOREF#4208  -  []  474.25 253.35 0 top
NOREF#4209  -  []  212.66 182 90 top
NOREF#4210  -  []  311.49 180.02 0 top
NOREF#4211  -  []  227.94 181.7 0 top
NOREF#4212  -  []  365.73 214.51 0 top
NOREF#4213  -  []  349.5 268.8 90 top
NOREF#4214  -  []  365.1 208.22 0 top
NOREF#4215  -  []  356.65 267.92 0 top
NOREF#4216  -  []  357.27 207.24 90 top
NOREF#4217  -  []  310.18 182.62 0 top
NOREF#4218  -  []  83.29 186.2 0 top
NOREF#4219  -  []  310.5 183.67 90 top
NOREF#4220  -  []  534.31 232.71 0 top
NOREF#4221  -  []  318.39 139.82 0 top
NOREF#4222  -  []  351.44 180.08 90 top
NOREF#4223  -  []  122.81 278.82 90 top
NOREF#4224  -  []  232.23 227.99 0 top
NOREF#4225  -  []  79.1 291.94 0 top
NOREF#4226  -  []  270.18 183.37 90 top
NOREF#4227  -  []  276.07 207.24 0 top
NOREF#4228  -  []  109.42 133.72 0 top
NOREF#4229  -  []  345.14 295.18 90 top
NOREF#4230  -  []  311.16 181.72 90 top
NOREF#4231  -  []  540.55 192.84 0 top
NOREF#4232  -  []  291.64 243.61 0 top
NOREF#4233  -  []  327.65 2.28 90 top
NOREF#4234  -  []  286.24 291.24 0 top
NOREF#4235  -  []  312.23 232.39 90 top
NOREF#4236  -  []  312.46 241.7 0 top
NOREF#4237  -  []  227.05 133.3 0 top
NOREF#4238  -  []  276.29 209.73 0 top
NOREF#4239  -  []  303.95 233.82 90 top
NOREF#4240  -  []  356.37 207.56 0 top
NOREF#4241  -  []  251.16 187.72 90 top
NOREF#4242  -  []  102.34 217.95 0 top
NOREF#4243  -  []  353.42 189.88 90 top
NOREF#4244  -  []  272.14 242.07 90 top
NOREF#4245  -  []  313.49 291.46 90 top
NOREF#4246  -  []  343.27 234.06 0 top
NOREF#4247  -  []  312.74 184.64 90 top
NOREF#4248  -  []  293.22 180.02 0 top
NOREF#4249  -  []  330.56 235.55 90 top
NOREF#4250  -  []  244.6 268.22 90 top
NOREF#4251  -  []  253.66 254.76 0 top
NOREF#4252  -  []  230.19 178.82 90 top
NOREF#4253  -  []  263.95 173.82 90 top
NOREF#4254  -  []  285.4 212.03 90 top
NOREF#4255  -  []  335.16 251.22 90 top
NOREF#4256  -  []  90.88 137.41 0 top
NOREF#4257  -  []  335.58 194.86 90 top
NOREF#4258  -  []  315.44 194.76 90 top
NOREF#4259  -  []  231.49 182.62 0 top
NOREF#4260  -  []  294.36 181.55 0 top
NOREF#4261  -  []  311.54 244.64 0 top
NOREF#4262  -  []  347.63 187.24 90 top
NOREF#4263  -  []  461.75 186.2 0 top
NOREF#4264  -  []  347.58 243.28 0 top
NOREF#4265  -  []  483.18 128.72 90 top
NOREF#4266  -  []  312.78 183.41 90 top
NOREF#4267  -  []  102.34 154.45 0 top
NOREF#4268  -  []  249.83 263.63 90 top
NOREF#4269  -  []  230.84 178.82 90 top
NOREF#4270  -  []  304.96 135.33 90 top
NOREF#4271  -  []  335.38 182.3 90 top
NOREF#4272  -  []  235.23 163.88 90 top
NOREF#4273  -  []  67.52 249.91 90 top
NOREF#4274  -  []  547.04 233.91 90 top
NOREF#4275  -  []  289.83 203.63 90 top
NOREF#4276  -  []  313.76 243.65 0 top
NOREF#4277  -  []  293.09 183.29 90 top
NOREF#4278  -  []  108.69 217.95 0 top
NOREF#4279  -  []  310.19 178.82 0 top
NOREF#4280  -  []  351.55 285.02 0 top
NOREF#4281  -  []  331.16 251.72 0 top
NOREF#4282  -  []  93.31 130.61 0 top
NOREF#4283  -  []  333.99 253.86 90 top
NOREF#4284  -  []  346.93 178.18 0 top
NOREF#4285  -  []  309.89 186.91 0 top
NOREF#4286  -  []  229.53 184.02 0 top
NOREF#4287  -  []  547.34 238.42 0 top
NOREF#4288  -  []  310.82 181.42 90 top
NOREF#4289  -  []  90.79 209.32 0 top
NOREF#4290  -  []  309.33 270.27 0 top
NOREF#4291  -  []  276.94 252.76 90 top
NOREF#4292  -  []  306.91 144.24 0 top
NOREF#4293  -  []  235.23 223.88 90 top
NOREF#4294  -  []  227.64 181.38 90 top
NOREF#4295  -  []  349.5 208.8 90 top
NOREF#4296  -  []  477.18 192.22 0 top
NOREF#4297  -  []  283.45 211.37 0 top
NOREF#4298  -  []  551.91 147.59 0 top
NOREF#4299  -  []  468.14 170.43 0 top
NOREF#4300  -  []  229.59 186.58 0 top
NOREF#4301  -  []  299.72 293.16 0 top
NOREF#4302  -  []  265.48 235.27 0 top
NOREF#4303  -  []  475.18 197.22 0 top
NOREF#4304  -  []  313.03 295.96 0 top
NOREF#4305  -  []  464.85 277.48 90 top
NOREF#4306  -  []  237.27 267.24 90 top
NOREF#4307  -  []  228.93 268.11 0 top
NOREF#4308  -  []  355.91 163.58 0 top
NOREF#4309  -  []  299.41 166.69 0 top
NOREF#4310  -  []  322.56 269.25 90 top
NOREF#4311  -  []  343.71 291.06 0 top
NOREF#4312  -  []  271.21 247.56 0 top
NOREF#4313  -  []  316.52 133.3 90 top
NOREF#4314  -  []  324.79 211.56 90 top
NOREF#4315  -  []  370.33 222.13 90 top
NOREF#4316  -  []  363.83 158.13 90 top
NOREF#4317  -  []  282.34 267.24 0 top
NOREF#4318  -  []  333.61 253.56 90 top
NOREF#4319  -  []  347.25 178.48 90 top
NOREF#4320  -  []  236.22 282.25 90 top
NOREF#4321  -  []  322.74 209.49 0 top
NOREF#4322  -  []  254.38 183.29 0 top
NOREF#4323  -  []  348.49 136.9 90 top
NOREF#4324  -  []  95.99 217.95 0 top
NOREF#4325  -  []  347.41 133.69 0 top
NOREF#4326  -  []  308.27 244.64 90 top
NOREF#4327  -  []  312.23 167.99 0 top
NOREF#4328  -  []  259.42 293.48 0 top
NOREF#4329  -  []  292.01 194.76 0 top
NOREF#4330  -  []  230.19 178.82 0 top
NOREF#4331  -  []  310.89 242.68 90 top
NOREF#4332  -  []  227.93 247.56 0 top
NOREF#4333  -  []  472.5 249.7 0 top
NOREF#4334  -  []  59.94 169.53 0 top
