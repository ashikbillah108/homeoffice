# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D22116: length 392.6
  L13_SIGNAL w0.079: 17.59,327.85 17.59,326 20.96,322.63 208.24,322.63 227.85,303.01 302.72,303.01 306.96,307.25 307.68,307.25
  L13_SIGNAL w0.091: 307.68,307.25 308.43,306.5 v3(308.61,306.5) ; D221.16 17.59,327.85
  L27_SIGNAL w0.079: 331.31,251.37 331.31,252.45 332.4,253.54 337.39,253.54 338.04,254.19 341.4,254.19 342.24,255.03 342.24,258.31 341.8,258.75 341.8,260.39 339.57,262.62 339.57,269.84 338.77,270.63 338.77,281.71 331.62,288.86 326.08,288.86 317.88,297.05 315.72,297.05 309.93,302.84 309.93,306.92 309.68,307.18 309.5,307.18 308.83,306.5 v3(308.61,306.5)
  L27_SIGNAL w0.091: v1(331.16,251.22) 331.31,251.37
D22201: length 268.7
  L25_SIGNAL w0.076: 225.81,242.03 226.93,242.03 v2(227.26,242.35)
  L25_SIGNAL w0.091: 225.81,242.03 225.62,242.03 225.14,241.54 224.42,241.54 222.68,243.28 222.68,251.46 224.38,253.16 224.38,253.53 225.43,254.57 225.43,261.05 222.61,263.87 222.61,269.68 222.28,270.02 222.28,283.98 223.87,285.57 223.87,288.11 222.48,289.5 221.27,289.5 218.47,292.3 213.62,292.3 207.62,298.3 207.62,299.13 205.1,301.65 75.33,301.65 61.52,315.46 61.52,344.88 D222.01
D22202: length 316.9
  L31_SIGNAL w0.076: v2(267.25,242.35) 266.93,242.03 265.81,242.03
  L31_SIGNAL w0.091: D222.02 52.07,349.25 54.36,349.25 73.41,330.2 73.41,327.53 83.82,317.12 136.4,317.12 143.2,323.92 256.28,323.92 258.33,321.87 258.33,292.22 261.37,289.18 262.51,289.18 263.87,287.82 263.87,285.57 262.28,283.98 262.28,270.02 262.61,269.68 262.61,263.87 265.43,261.05 265.43,254.57 264.38,253.53 264.38,253.16 262.68,251.46 262.68,243.28 264.42,241.54 265.14,241.54 265.62,242.03 265.81,242.03
D22203: length 347.1
  L19_SIGNAL w0.102: D222.03 49.53,351.79 57.53,351.79 85.6,323.72 269.49,323.72 271.02,322.2 271.02,316.38 269.53,314.89 v3(269.5,314.89)
  L29_SIGNAL w0.076: v2(307.25,242.35) 306.93,242.03 305.81,242.03
  L29_SIGNAL w0.091: 305.81,242.03 305.62,242.03 305.14,241.54 304.42,241.54 302.68,243.28 302.68,251.46 304.38,253.16 304.38,253.53 305.43,254.57 305.43,261.05 302.61,263.87 302.61,269.68 302.28,270.02 302.28,283.98 303.87,285.57 303.87,287.49 297.89,293.47 290.73,293.47 286.97,297.23 279.35,297.23 275.97,300.61 275.34,300.61 271.53,304.42 271.53,312.86 v3(269.5,314.89)
D22204: length 378
  L23_SIGNAL w0.091: D222.04 46.99,349.25 56.13,349.25 82.55,322.83 279.16,322.83 296.64,305.35 311.78,305.35 v3(312.93,306.5)
  L27_SIGNAL w0.076: v2(347.25,242.35) 346.93,242.03 345.81,242.03
  L27_SIGNAL w0.091: v3(312.93,306.5) 312.93,303.78 317.5,299.21 319.4,299.21 326.26,292.35 337.37,292.35 342.97,286.76 342.97,284.67 342.28,283.98 342.28,270.02 342.61,269.68 342.61,263.87 345.43,261.05 345.43,254.57 344.38,253.53 344.38,253.16 342.68,251.46 342.68,243.28 344.42,241.54 345.14,241.54 345.62,242.03 345.81,242.03
D22205: length 279.9
  L25_SIGNAL w0.091: v2(225.96,242.36) 224.98,242.36 224.66,242.68 223.92,242.68 223.05,243.55 223.05,251.31 224.78,253.04 224.78,253.36 226.43,255.01 226.43,260.65 223,264.07 223,269.9 222.75,270.15 222.75,283.56 224.67,285.49 224.67,288.43 222.84,290.26 221.61,290.26 219.18,292.69 213.82,292.69 208.04,298.47 208.04,299.3 206.01,301.33 205.27,302.07 75.5,302.07 61.94,315.63 61.94,346.62 54.28,354.29 44.41,354.29 D222.05
D22206: length 327.3
  L31_SIGNAL w0.091: v2(265.96,242.36) 264.98,242.36 264.66,242.68 263.92,242.68 263.05,243.55 263.05,251.31 264.78,253.04 264.78,253.36 266.43,255.01 266.43,260.65 263,264.07 263,269.9 262.75,270.15 262.75,283.56 264.67,285.49 264.67,288.03 258.75,293.96 258.75,322.05 256.45,324.34 142.81,324.34 136.01,317.54 84.04,317.54 74.17,327.41 74.17,331.85 54.23,351.79 41.91,351.79 D222.06
D22207: length 356.7
  L19_SIGNAL w0.102: v3(269.5,316.41) 270.51,317.42 270.51,321.94 269.24,323.21 85.47,323.21 59.44,349.25 40.26,349.25 39.37,350.14 39.37,351.79 D222.07
  L29_SIGNAL w0.091: v3(269.5,316.41) 270.23,316.41 272.01,314.63 272.01,304.53 275.55,300.99 276.22,300.99 278.51,298.7 286.21,298.7 290.63,294.28 295.46,294.28 296.02,294.84 297.13,294.84 304.67,287.3 304.67,285.49 302.75,283.56 302.75,270.15 303,269.9 303,264.07 306.43,260.65 306.43,255.01 304.78,253.36 304.78,253.04 303.05,251.31 303.05,243.55 303.92,242.68 304.66,242.68 304.98,242.36 v2(305.95,242.36)
D22208: length 392.5
  L23_SIGNAL w0.091: v3(312.93,308.03) 312.95,308.03 313.49,307.5 313.49,305.1 313.35,304.97 296.48,304.97 279,322.45 82.25,322.45 57.74,346.96 39.12,346.96 D222.08
  L27_SIGNAL w0.091: v3(312.93,308.03) 313.41,308.03 314.41,307.03 314.41,304.21 317.76,300.86 318.27,300.86 326.4,292.74 339.47,292.74 344.11,288.1 344.11,284.92 342.75,283.56 342.75,270.15 343,269.9 343,264.07 346.43,260.65 346.43,255.01 344.78,253.36 344.78,253.04 343.05,251.31 343.05,243.55 343.92,242.68 344.66,242.68 344.98,242.36 v2(345.95,242.36)
D22209: length 292.9
  L25_SIGNAL w0.076: v2(225.96,243.66) 225.52,243.66 225.51,243.66 225.49,243.66
  L25_SIGNAL w0.091: 225.49,243.66 224.31,243.66 223.42,244.56 223.42,250.12 225.22,251.93 225.22,253.04 226.9,254.71 226.9,261.79 223.38,265.3 223.38,270.29 223.13,270.54 223.13,280.03 225.31,282.21 225.31,289.68 223.39,291.59 221.23,291.59 219.71,293.12 215.02,293.12 205.64,302.49 75.68,302.49 62.36,315.81 62.36,348.73 54.29,356.8 36.76,356.8 D222.09
D22210: length 339.1
  L31_SIGNAL w0.076: 265.49,243.66 265.51,243.66 265.52,243.66 v2(265.96,243.66)
  L31_SIGNAL w0.091: D222.10 31.75,351.79 31.75,353.44 32.64,354.33 53.98,354.33 76.07,332.23 76.07,329.06 87.12,318.01 135.55,318.01 142.35,324.81 256.64,324.81 259.21,322.24 259.21,295.56 265.31,289.47 265.31,282.21 263.13,280.03 263.13,270.54 263.38,270.29 263.38,265.3 266.9,261.79 266.9,254.71 265.22,253.04 265.22,251.93 263.42,250.12 263.42,244.56 264.31,243.66 265.49,243.66
D22211: length 365.2
  L19_SIGNAL w0.102: v3(269.5,319.08) 269.53,319.08 270.06,319.61 270.06,321.26 268.6,322.71 85.34,322.71 61.34,346.71 29.97,346.71 29.08,347.6 29.08,351.92 D222.11
  L29_SIGNAL w0.076: 305.49,243.66 305.51,243.66 305.52,243.66 v2(305.95,243.66)
  L29_SIGNAL w0.091: v3(269.5,319.08) 272.41,316.16 272.41,305.05 276.1,301.37 283.64,301.37 285.6,299.42 287.43,299.42 290.88,295.96 296.53,295.96 305.31,287.18 305.31,282.21 303.13,280.03 303.13,270.54 303.38,270.29 303.38,265.3 306.9,261.79 306.9,254.71 305.22,253.04 305.22,251.93 303.42,250.12 303.42,244.56 304.31,243.66 305.49,243.66
D22212: length 408.7
  L23_SIGNAL w0.091: v3(312.93,310.7) 314.26,309.37 314.26,304.74 314.11,304.59 296.33,304.59 278.85,322.07 81.91,322.07 57.53,346.46 29.46,346.46 D222.12
  L27_SIGNAL w0.076: v2(345.95,243.66) 345.52,243.66 345.51,243.66 345.49,243.66
  L27_SIGNAL w0.091: 345.49,243.66 344.31,243.66 343.42,244.56 343.42,250.12 345.22,251.93 345.22,253.04 346.9,254.71 346.9,261.79 343.38,265.3 343.38,270.29 343.13,270.54 343.13,280.03 345.31,282.21 345.31,287.54 338.33,294.51 326.14,294.51 319.42,301.23 318.06,301.23 315.02,304.27 315.02,308.61 313.74,309.89 v3(312.93,310.7)
D22213: length 305.4
  L25_SIGNAL w0.076: 224.73,245.37 225.79,244.31 v2(226.61,244.31)
  L25_SIGNAL w0.091: D222.13 29.16,359.36 52.74,359.36 62.78,349.32 62.78,315.98 75.85,302.91 205.81,302.91 214.34,294.39 220.34,294.39 221.87,292.86 224.41,292.86 225.87,291.4 225.87,281.93 224.63,280.69 224.63,270.59 223.98,269.94 223.98,265.24 227.51,261.71 227.51,254.48 225.88,252.85 225.88,251.75 224.26,250.14 224.26,245.83 224.73,245.37
D22214: length 353.1
  L31_SIGNAL w0.076: 264.73,245.37 265.79,244.31 v2(266.61,244.31)
  L31_SIGNAL w0.091: 264.73,245.37 264.26,245.83 264.26,250.14 265.88,251.75 265.88,252.85 267.51,254.48 267.51,261.71 263.98,265.24 263.98,269.94 264.63,270.59 264.63,280.69 265.87,281.93 265.87,291.28 263.4,293.75 262.89,293.75 261.12,295.52 261.12,299.61 259.64,301.1 259.64,322.41 256.82,325.23 141.84,325.23 135.13,318.52 87.38,318.52 76.62,329.27 76.62,334.22 53.97,356.87 22.61,356.87 21.21,355.47 21.21,351.41 D222.14
D22215: length 374.4
  L19_SIGNAL w0.102: D222.15 19.05,351.79 19.05,347.22 22.1,344.17 63.25,344.17 85.22,322.2 267.9,322.2 v3(269.5,320.6)
  L29_SIGNAL w0.076: v2(306.6,244.31) 305.79,244.31 304.73,245.37
  L29_SIGNAL w0.091: 304.73,245.37 304.26,245.83 304.26,250.14 305.88,251.75 305.88,252.85 307.51,254.48 307.51,261.71 303.98,265.24 303.98,269.94 304.63,270.59 304.63,280.69 305.87,281.93 305.87,288.9 297.59,297.18 291.64,297.18 287.06,301.76 276.34,301.76 272.92,305.18 272.92,317.88 270.2,320.6 v3(269.5,320.6)
D22216: length 423.5
  L23_SIGNAL w0.091: v3(312.93,312.22) 312.95,312.22 315.09,310.09 315.09,305.05 314.24,304.21 296.17,304.21 278.69,321.69 81.53,321.69 59.05,344.17 21.59,344.17 D222.16
  L27_SIGNAL w0.076: v2(346.6,244.31) 345.79,244.31 344.73,245.37
  L27_SIGNAL w0.091: v3(312.93,312.22) 314.78,312.22 315.57,311.43 315.57,305.15 319.13,301.59 319.57,301.59 326.29,294.88 340.09,294.88 345.87,289.1 345.87,281.93 344.63,280.69 344.63,270.59 343.98,269.94 343.98,265.24 347.51,261.71 347.51,254.48 345.88,252.85 345.88,251.75 344.26,250.14 344.26,245.83 344.73,245.37
D22301: length 284.9
  L25_SIGNAL w0.076: v2(227.26,246.91) 226.93,246.58 225.8,246.58
  L25_SIGNAL w0.091: 225.8,246.58 225.68,246.58 225.28,246.98 225.28,250.25 226.64,251.61 226.64,252.44 228.66,254.45 228.66,255.38 228.13,255.91 228.13,261.66 225.2,264.59 225.2,280.74 226.23,281.78 226.23,292.05 225.04,293.24 223.52,293.24 222,294.77 215.7,294.77 207.14,303.33 76.03,303.33 63.25,316.11 63.25,349.49 55.65,357.09 55.65,371.07 D223.01
D22302: length 326.4
  L31_SIGNAL w0.076: v2(267.25,246.91) 266.93,246.58 265.8,246.58
  L31_SIGNAL w0.091: D223.02 77.13,344.51 77.13,329.52 85.47,321.18 136.78,321.18 141.28,325.69 257.76,325.69 262.2,321.25 262.2,295.07 263.14,294.13 263.91,294.13 266.23,291.8 266.23,281.78 265.2,280.74 265.2,264.59 268.13,261.66 268.13,255.91 268.66,255.38 268.66,254.45 266.64,252.44 266.64,251.61 265.28,250.25 265.28,246.98 265.68,246.58 265.8,246.58
D22303: length 361.1
  L19_SIGNAL w0.102: D223.03 49.53,372.11 53.59,372.11 58.04,367.66 58.04,353.95 86.23,325.75 270.34,325.75 272.92,323.17 272.92,314.99 273.59,314.32 274.07,314.32 275.45,312.94 275.45,308.11 273.84,306.5 v3(273.82,306.5)
  L29_SIGNAL w0.076: 305.8,246.58 306.93,246.58 v2(307.25,246.91)
  L29_SIGNAL w0.091: v3(273.82,306.5) 273.82,305.18 276.81,302.18 287.71,302.18 291.45,298.44 298.04,298.44 301.79,294.69 302.16,294.69 306.23,290.62 306.23,281.78 305.2,280.74 305.2,264.59 308.13,261.66 308.13,255.91 308.66,255.38 308.66,254.45 306.64,252.44 306.64,251.61 305.28,250.25 305.28,246.98 305.68,246.58 305.8,246.58
D22304: length 403.1
  L23_SIGNAL w0.091: v3(317.25,306.5) 317.27,306.5 318.61,307.85 318.61,313.04 317.57,314.09 311.72,314.09 310.5,312.87 310.5,311.73 308.4,309.63 294.55,309.63 279.8,324.37 84.06,324.37 59.94,348.49 59.94,363.22 53.59,369.57 46.99,369.57 D223.04
  L27_SIGNAL w0.076: 345.8,246.58 346.93,246.58 v2(347.25,246.91)
  L27_SIGNAL w0.091: 345.8,246.58 345.68,246.58 345.28,246.98 345.28,250.25 346.64,251.61 346.64,252.44 348.66,254.45 348.66,255.38 348.13,255.91 348.13,261.66 345.2,264.59 345.2,280.74 346.23,281.78 346.23,289.94 344.4,291.77 344.4,292.45 341.61,295.24 327.44,295.24 320.67,302.01 319.35,302.01 317.25,304.11 v3(317.25,306.5)
D22305: length 300.7
  L23_SIGNAL w0.076: 225.48,245.28 226.28,245.28 v2(226.61,244.96)
  L23_SIGNAL w0.508: 225.48,245.28 225.04,245.72 225.04,251.32 228.86,255.14 228.86,267.82 227.86,268.82 v2(227.86,269)
  L25_SIGNAL w0.508: v2(227.1,269) 227.1,269.44 226.26,270.28 226.26,271.05 226.81,271.59 226.81,279.76 227.47,280.42 227.79,280.42 228.39,281.02 228.39,291.3 225.3,294.39 223.77,294.39 222.63,295.53 222.63,296.04 222,296.67 215.9,296.67 215.26,297.31 215.26,299.34 210.69,303.91 76.55,303.91 63.9,316.56 63.9,349.93 56.32,357.51 56.32,372.03 53.7,374.65 44.45,374.65 D223.05
D22306: length 342.1
  L23_SIGNAL w0.076: 265.48,245.28 266.28,245.28 v2(266.61,244.96)
  L23_SIGNAL w0.508: v2(267.86,269) 267.86,268.82 268.86,267.82 268.86,255.14 265.04,251.32 265.04,245.72 265.48,245.28
  L31_SIGNAL w0.508: v2(267.1,269) 267.1,269.44 266.26,270.28 266.26,271.05 266.81,271.59 266.81,279.76 267.47,280.42 267.79,280.42 268.39,281.02 268.39,290.67 264.29,294.77 263.52,294.77 262.84,295.45 262.84,321.88 258.33,326.39 140.97,326.39 136.65,322.07 85.85,322.07 78.23,329.69 78.23,348.11 54.23,372.11 41.91,372.11 D223.06
D22307: length 373.4
  L19_SIGNAL w0.102: D223.07 39.37,372.11 39.37,370.46 40.26,369.57 53.59,369.57 57.15,366.01 57.15,354.08 85.98,325.25 270.13,325.25 272.44,322.94 272.44,314.81 273.72,313.53 274.17,313.53 275.04,312.65 275.04,309.26 v3(273.82,308.03)
  L23_SIGNAL w0.076: v2(306.6,244.96) 306.28,245.28 305.48,245.28
  L23_SIGNAL w0.508: v2(307.86,269) 307.86,268.82 308.86,267.82 308.86,255.14 305.04,251.32 305.04,245.72 305.48,245.28
  L29_SIGNAL w0.508: v2(307.1,269) 307.1,269.44 306.26,270.28 306.26,271.05 306.81,271.59 306.81,279.76 307.47,280.42 307.79,280.42 308.39,281.02 308.39,290.22 303.8,294.81 303.16,294.81 301.65,296.32 301.65,296.98 299.61,299.02 293.56,299.02 289.74,302.84 277.16,302.84 274.83,305.18 274.83,307.52 274.32,308.03 v3(273.82,308.03)
D22308: length 414.2
  L23_SIGNAL w0.076: 345.48,245.28 346.28,245.28 v2(346.6,244.96)
  L23_SIGNAL w0.091: D223.08 39.12,367.28 54.57,367.28 59.44,362.41 59.44,348.32 83.75,324.01 279.65,324.01 294.41,309.25 308.54,309.25 310.87,311.57 310.87,312.72 311.87,313.72 317.42,313.72 318.25,312.89 318.25,309.03 v3(317.25,308.03)
  L23_SIGNAL w0.508: v2(347.86,269) 347.86,268.82 348.86,267.82 348.86,255.14 345.04,251.32 345.04,245.72 345.48,245.28
  L27_SIGNAL w0.508: v3(317.25,308.03) 317.73,308.03 318.32,307.43 318.32,304.44 320.19,302.58 321.12,302.58 323.05,300.64 324.45,300.64 328.17,296.93 341,296.93 348.39,289.54 348.39,281.02 347.79,280.42 347.47,280.42 346.81,279.76 346.81,271.59 346.26,271.05 346.26,270.28 347.1,269.44 v2(347.1,269)
D22309: length 308
  L25_SIGNAL w0.091: v2(227.91,248.85) 227.91,252.24 229.16,253.5 229.16,258.41 228.58,259 228.58,262.02 226.65,263.95 226.65,267.37 227.15,267.87 227.37,267.87 228.58,269.07 228.58,279.68 229.1,280.2 229.1,291.98 223.65,297.43 219.07,297.43 211.96,304.55 76.87,304.55 64.58,316.84 64.58,350.22 57,357.79 57,374.2 53.92,377.28 36.92,377.28 D223.09
D22310: length 350.6
  L31_SIGNAL w0.091: D223.10 31.75,372.11 31.75,373.76 32.64,374.65 53.98,374.65 79.25,349.38 79.25,329.69 85.85,323.09 136.14,323.09 140.21,327.15 258.64,327.15 263.68,322.12 263.68,301.49 264.67,300.5 264.67,295.65 269.1,291.23 269.1,280.2 268.58,279.68 268.58,269.07 267.37,267.87 267.15,267.87 266.65,267.37 266.65,263.95 268.58,262.02 268.58,259 269.16,258.41 269.16,253.5 267.9,252.24 v2(267.9,248.85)
D22311: length 378.6
  L19_SIGNAL w0.102: v3(273.82,310.7) 273.84,310.7 274.64,311.49 274.64,312.48 274,313.12 273.49,313.12 272.03,314.58 272.03,322.54 269.83,324.74 85.85,324.74 56.51,354.08 56.51,364.74 54.23,367.03 29.97,367.03 29.08,367.92 29.08,372.24 D223.11
  L29_SIGNAL w0.091: v2(307.9,248.85) 307.9,252.24 309.16,253.5 309.16,258.41 308.58,259 308.58,262.02 306.65,263.95 306.65,267.37 307.15,267.87 307.37,267.87 308.58,269.07 308.58,279.68 309.1,280.2 309.1,291.11 302.51,297.69 302.51,298.3 300.38,300.43 293.18,300.43 290.08,303.53 277.37,303.53 275.46,305.44 275.46,309.52 274.29,310.7 v3(273.82,310.7)
D22312: length 418.6
  L23_SIGNAL w0.091: D223.12 29.46,366.78 54.36,366.78 58.93,362.2 58.93,347.99 83.32,323.6 279.48,323.6 294.29,308.78 308.66,308.78 311.28,311.4 311.28,312.55 312.04,313.31 317.25,313.31 317.88,312.67 317.88,311.31 317.27,310.7 v3(317.25,310.7)
  L27_SIGNAL w0.091: v3(317.25,310.7) 319.32,308.62 319.32,305.79 323.87,301.24 325.5,301.24 328.17,298.58 342.39,298.58 349.1,291.87 349.1,280.2 348.58,279.68 348.58,269.07 347.37,267.87 347.15,267.87 346.65,267.37 346.65,263.95 348.58,262.02 348.58,259 349.16,258.41 349.16,253.5 347.9,252.24 v2(347.9,248.85)
D22313: length 321.5
  L25_SIGNAL w0.076: v2(230.5,248.85) 230.18,249.18 230.18,249.65
  L25_SIGNAL w0.091: 230.18,249.65 230.18,249.8 230.06,249.92 230.06,252.81 230.44,253.18 230.44,258.15 228.99,259.59 228.99,262.5 228.41,263.09 228.41,268.39 229.05,269.03 229.05,269.43 229.84,270.22 229.84,270.65 229.07,271.41 229.07,279.63 230.41,280.97 230.41,285.69 229.7,286.4 229.7,292.18 227.71,294.18 227.71,294.64 223.78,298.58 219.74,298.58 213.37,304.94 77.39,304.94 65.15,317.18 65.15,350.56 57.65,358.06 57.65,374.65 52.59,379.71 29.19,379.71 D223.13
D22314: length 366.2
  L31_SIGNAL w0.076: 270.18,249.65 270.18,249.18 v2(270.5,248.85)
  L31_SIGNAL w0.091: 270.18,249.65 270.18,249.8 270.06,249.92 270.06,252.81 270.44,253.18 270.44,258.15 268.99,259.59 268.99,262.5 268.41,263.09 268.41,268.39 269.05,269.03 269.05,269.43 269.84,270.22 269.84,270.65 269.07,271.41 269.07,279.63 270.41,280.97 270.41,285.69 269.7,286.4 269.7,291.26 265.14,295.82 265.14,301.01 264.24,301.91 264.24,322.29 258.78,327.75 139.28,327.75 135.13,323.6 86.36,323.6 79.76,330.2 79.76,351.41 53.97,377.19 22.61,377.19 21.21,375.79 21.21,371.73 D223.14
D22315: length 387.6
  L19_SIGNAL w0.102: v3(273.82,312.22) 271.53,314.51 271.53,322.33 269.62,324.23 85.72,324.23 54.99,354.97 54.99,363.73 54.23,364.49 22.1,364.49 19.05,367.54 19.05,372.11 D223.15
  L29_SIGNAL w0.076: v2(310.5,248.85) 310.18,249.18 310.18,249.65
  L29_SIGNAL w0.091: 310.18,249.65 310.18,249.8 310.06,249.92 310.06,252.81 310.44,253.18 310.44,258.15 308.99,259.59 308.99,262.5 308.41,263.09 308.41,268.39 309.05,269.03 309.05,269.43 309.84,270.22 309.84,270.65 309.07,271.41 309.07,279.63 310.41,280.97 310.41,285.69 309.7,286.4 309.7,291.37 303.32,297.75 303.32,299.03 301.52,300.84 293.83,300.84 290.63,304.04 277.5,304.04 275.97,305.56 275.97,310.95 274.7,312.22 v3(273.82,312.22)
D22316: length 431.7
  L23_SIGNAL w0.091: D223.16 21.59,364.49 54.36,364.49 58.42,360.43 58.42,347.73 82.93,323.21 279.32,323.21 296.8,305.73 309.16,305.73 311.78,308.36 311.78,312.04 312.67,312.93 316.54,312.93 v3(317.25,312.22)
  L27_SIGNAL w0.076: v2(350.5,248.85) 350.18,249.18 350.18,249.65
  L27_SIGNAL w0.091: v3(317.25,312.22) 318.08,312.22 320.26,310.05 320.26,306.24 324.87,301.62 325.63,301.62 325.64,301.61 325.65,301.61 328.32,298.94 342.54,298.94 342.66,298.83 344.04,298.83 349.42,293.45 349.42,292.46 349.7,292.18 349.7,286.4 350.41,285.69 350.41,280.97 349.07,279.63 349.07,271.41 349.84,270.65 349.84,270.22 349.05,269.43 349.05,269.03 348.41,268.39 348.41,263.09 348.99,262.5 348.99,259.59 350.44,258.15 350.44,253.18 350.06,252.81 350.06,249.92 350.18,249.8 350.18,249.65
D22401: length 304.9
  L25_SIGNAL w0.076: 231.48,251.08 231.48,249.83 v2(231.81,249.5)
  L25_SIGNAL w0.091: 231.48,251.08 231.48,251.31
  L25_SIGNAL w0.508: 231.48,251.31 231.48,253.19 231.23,253.44 231.23,258.76 229.61,260.38 229.61,262.86 229.05,263.41 229.05,266.98 229.94,267.86 229.94,269.38 230.51,269.96 230.51,271.63 232.97,274.09 232.97,284.6 230.34,287.23 230.34,291.17 230.89,291.72 230.89,293.5 229.74,294.64 229.36,294.64 226.47,297.54 226.47,298.22 225.53,299.15 221.62,299.15 215.21,305.56 77.72,305.56 65.9,317.39 65.9,351.04 58.45,358.49 58.45,388.59 D224.01
D22402: length 344.4
  L31_SIGNAL w0.076: 271.48,251.08 271.48,249.83 v2(271.81,249.5)
  L31_SIGNAL w0.091: 271.48,251.08 271.48,251.31
  L31_SIGNAL w0.508: D224.02 59.44,382.52 59.44,372.75 80.77,351.41 80.77,330.45 86.87,324.36 134.87,324.36 138.94,328.42 259.08,328.42 266.52,320.99 266.52,296.22 268.99,293.75 270.26,293.75 271.02,292.99 271.02,292.1 270.34,291.42 270.34,287.23 272.97,284.6 272.97,274.09 270.51,271.63 270.51,269.96 269.94,269.38 269.94,267.86 269.05,266.98 269.05,263.41 269.61,262.86 269.61,260.38 271.23,258.76 271.23,253.44 271.48,253.19 271.48,251.31
D22403: length 430.6
  L19_SIGNAL w0.102: v3(273.82,314.89) 273.84,314.89 276.17,317.22 276.17,323.21 272.64,326.74 88.17,326.74 60.2,354.71 60.2,376.4 54.09,382.51 25.16,382.51 24.38,383.29 24.38,391.41 25.22,392.25 46.81,392.25 D224.03
  L29_SIGNAL w0.076: 311.48,251.08 311.48,249.83 v2(311.81,249.5)
  L29_SIGNAL w0.091: 311.48,251.08 311.48,251.31
  L29_SIGNAL w0.508: v3(273.82,314.89) 275.28,314.89 276.61,313.56 276.61,306.07 277.67,305 290.78,305 294.28,301.5 303.28,301.5 311.25,293.52 311.25,292.35 310.34,291.44 310.34,287.23 312.97,284.6 312.97,274.09 310.51,271.63 310.51,269.96 309.94,269.38 309.94,267.86 309.05,266.98 309.05,263.41 309.61,262.86 309.61,260.38 311.23,258.76 311.23,253.44 311.48,253.19 311.48,251.31
D22404: length 407.8
  L19_SIGNAL w0.102: D224.04 46.99,389.89 54.36,389.89 62.15,382.09 62.15,369.24 74.22,357.18 127.73,357.18 148.07,336.83 294.08,336.83 316.82,314.1 321.92,314.1 323.09,312.93 323.09,307.59 322,306.5 v3(321.57,306.5)
  L27_SIGNAL w0.076: v2(351.8,249.5) 351.48,249.83 351.48,251.08
  L27_SIGNAL w0.091: 351.48,251.08 351.48,251.31
  L27_SIGNAL w0.508: 351.48,251.31 351.48,253.19 351.23,253.44 351.23,258.76 349.61,260.38 349.61,262.86 349.05,263.41 349.05,266.98 349.94,267.86 349.94,269.38 350.51,269.96 350.51,271.63 352.97,274.09 352.97,284.6 350.34,287.23 350.34,291.97 350.77,292.41 350.77,293.91 343.95,300.74 327.53,300.74 325.88,302.39 325.12,302.39 321.57,305.94 v3(321.57,306.5)
D22405: length 320.9
  L25_SIGNAL w0.076: v2(233.11,248.2) 233.43,248.53 233.43,249.67
  L25_SIGNAL w0.091: 233.43,249.67 233.43,249.87 233.63,250.07 233.63,250.99 232.58,252.05 232.58,260.86 229.63,263.81 229.63,266.36 230.76,267.49 230.76,269.2 231.53,269.98 231.53,271.84 234.65,274.96 234.65,291.51 233.93,292.23 233.43,292.23 230.89,294.77 230.89,295.53 225.94,300.48 222.23,300.48 213.88,308.83 75.6,308.83 66.57,317.86 66.57,351.38 59.13,358.82 59.13,390.81 55,394.94 44.42,394.94 D224.05
D22406: length 360.7
  L31_SIGNAL w0.076: v2(273.11,248.2) 273.43,248.53 273.43,249.67
  L31_SIGNAL w0.091: 273.43,249.67 273.43,249.87 273.63,250.07 273.63,250.99 272.58,252.05 272.58,260.86 269.63,263.81 269.63,266.36 270.76,267.49 270.76,269.2 271.53,269.98 271.53,271.84 274.65,274.96 274.65,291.26 271.27,294.64 270.13,294.64 267.27,297.49 267.27,321.35 259.57,329.06 138.05,329.06 134.11,325.12 87.43,325.12 81.79,330.76 81.79,351.47 60.2,373.06 60.2,386.46 54.23,392.43 41.91,392.43 D224.06
D22407: length 425.1
  L19_SIGNAL w0.102: v3(273.82,316.41) 274.72,316.41 275.77,317.46 275.77,323.04 272.55,326.26 87.93,326.26 59.69,354.5 59.69,376.19 53.88,382 24.91,382 23.88,383.03 23.88,391.92 24.71,392.76 37.16,392.76 D224.07
  L29_SIGNAL w0.076: v2(313.11,248.2) 313.43,248.53 313.43,249.67
  L29_SIGNAL w0.091: 313.43,249.67 313.43,249.87 313.63,250.07 313.63,250.99 312.58,252.05 312.58,260.86 309.63,263.81 309.63,266.36 310.76,267.49 310.76,269.2 311.53,269.98 311.53,271.84 314.65,274.96 314.65,291.26 310.73,295.18 310.73,296.38 304.95,302.16 295.22,302.16 291.56,305.82 277.88,305.82 277.24,306.45 277.24,314.83 275.66,316.41 v3(273.82,316.41)
D22408: length 419.3
  L19_SIGNAL w0.102: D224.08 39.12,387.6 54.61,387.6 61.23,380.98 61.23,369.47 74.02,356.69 127.53,356.69 147.87,336.34 293.98,336.34 316.74,313.58 321.42,313.58 322.58,312.42 322.58,309.04 v3(321.57,308.03)
  L27_SIGNAL w0.076: 353.43,249.67 353.43,248.53 v2(353.1,248.2)
  L27_SIGNAL w0.091: v3(321.57,308.03) 322.4,308.03 322.92,307.51 322.92,306.24 327.85,301.31 345.11,301.31 348.29,298.13 348.29,297.63 354.65,291.27 354.65,274.96 351.53,271.84 351.53,269.98 350.76,269.2 350.76,267.49 349.63,266.36 349.63,263.81 352.58,260.86 352.58,252.05 353.63,250.99 353.63,250.07 353.43,249.87 353.43,249.67
D22409: length 333
  L25_SIGNAL w0.508: v2(234.41,248.85) 234.41,248.86 234.41,251.08 233.27,252.22 233.27,259.48 234.2,260.4 234.2,269.33 234.39,269.52 234.39,272.59 235.31,273.51 235.31,280.34 235.97,281.01 235.97,285.73 235.39,286.3 235.39,294.71 233.76,296.33 232.41,296.33 227.69,301.06 223.69,301.06 214.88,309.87 75.83,309.87 67.61,318.09 67.61,351.8 60.16,359.25 60.16,391.73 54.38,397.52 36.84,397.52 D224.09
D22410: length 373.4
  L31_SIGNAL w0.508: v2(274.41,248.85) 274.41,248.86 274.41,251.08 273.27,252.22 273.27,259.48 274.2,260.4 274.2,269.33 274.39,269.52 274.39,272.59 275.31,273.51 275.31,280.34 275.97,281.01 275.97,285.73 275.39,286.3 275.39,295.35 274.33,296.41 272.49,296.41 267.96,300.94 267.96,321.75 259.77,329.95 137.67,329.95 133.6,325.88 87.63,325.88 82.8,330.71 82.8,351.89 61.21,373.48 61.21,387.73 53.98,394.97 32.64,394.97 31.75,394.08 31.75,392.43 D224.10
D22411: length 402.8
  L21_SIGNAL w0.102: D224.11 29.08,392.56 29.08,388.24 29.97,387.35 54.48,387.35 59.18,382.65 59.18,354.29 87.54,325.93 266.28,325.93 272.47,319.75 272.47,310.73 273.9,309.3 277.65,309.3 278.69,308.26 278.69,307.04 278.16,306.5 v3(278.13,306.5)
  L29_SIGNAL w0.508: v2(314.41,248.85) 314.41,248.86 314.41,251.08 313.27,252.22 313.27,259.48 314.2,260.4 314.2,269.33 314.38,269.52 314.38,272.59 315.31,273.51 315.31,280.34 315.97,281.01 315.97,285.73 315.39,286.3 315.39,294.71 313.43,296.67 311.51,296.67 311,297.18 311,297.89 306.12,302.77 295.98,302.77 292.24,306.5 v3(278.13,306.5)
D22412: length 428.5
  L19_SIGNAL w0.102: v3(321.57,310.7) 321.26,310.7 319.02,312.93 313.69,312.93 291.85,334.77 146.81,334.77 127.25,354.33 69.73,354.33 60.71,363.36 60.71,380.24 53.85,387.1 29.46,387.1 D224.12
  L27_SIGNAL w0.508: v3(321.57,310.7) 323.94,308.32 323.94,306.51 328.56,301.88 347.03,301.88 351.63,297.28 352.69,297.28 355.39,294.58 355.39,286.3 355.97,285.73 355.97,281.01 355.31,280.34 355.31,273.51 354.38,272.59 354.38,269.52 354.2,269.33 354.2,260.4 353.27,259.48 353.27,252.22 354.41,251.08 354.41,248.86 v2(354.4,248.85)
D22413: length 345.6
  L25_SIGNAL w0.091: v2(235.06,249.5) 235.51,249.96 235.51,251.17 234.65,252.02 234.65,259.77 235.03,260.15 235.03,271.98 236.42,273.37 236.42,273.96 237.23,274.77 237.23,281.69 236.98,281.94 236.98,294 229.23,301.75 224.67,301.75 213.46,312.96 73.86,312.96 68.38,318.44 68.38,351.95 60.82,359.51 60.82,392.29 53.22,399.89 29.05,399.89 D224.13
D22414: length 389
  L31_SIGNAL w0.091: D224.14 21.21,392.05 21.21,396.11 22.61,397.51 53.97,397.51 62.23,389.25 62.23,373.9 83.82,352.31 83.82,330.96 88.14,326.64 132.84,326.64 136.91,330.71 260.43,330.71 270.22,320.92 270.22,300.69 273.47,297.43 275.84,297.43 277.24,296.04 277.24,295.27 276.98,295.02 276.98,281.94 277.23,281.69 277.23,274.77 276.42,273.96 276.42,273.37 275.03,271.98 275.03,260.15 274.65,259.77 274.65,252.02 275.51,251.17 275.51,249.96 v2(275.06,249.5)
D22415: length 410.4
  L21_SIGNAL w0.102: D224.15 19.05,392.43 19.05,387.86 22.1,384.81 54.61,384.81 58.67,380.75 58.67,354.08 87.23,325.53 266.12,325.53 272.06,319.58 272.06,310.57 273.86,308.76 277.4,308.76 v3(278.13,308.03)
  L29_SIGNAL w0.091: v2(315.05,249.5) 315.51,249.96 315.51,251.17 314.65,252.02 314.65,259.77 315.03,260.15 315.03,271.98 316.42,273.37 316.42,273.96 317.23,274.77 317.23,281.69 316.98,281.94 316.98,294.19 313.76,297.41 313.2,297.41 307.19,303.43 296.24,303.43 291.64,308.03 v3(278.13,308.03)
D22416: length 441.4
  L13_SIGNAL w0.091: v3(321.57,312.22) 320.73,313.06 303.15,313.06 295.91,305.82 228.95,305.82 198.36,336.4 87.14,336.4 58.91,364.64 58.91,374.16 48.26,384.81 21.59,384.81 D224.16
  L27_SIGNAL w0.091: v2(355.05,249.5) 355.51,249.96 355.51,251.17 354.65,252.02 354.65,259.77 355.03,260.15 355.03,271.98 356.42,273.37 356.42,273.96 357.23,274.77 357.23,281.69 356.98,281.94 356.98,293.37 355.97,294.39 355.97,294.82 348.33,302.46 328.96,302.46 324.67,306.75 324.67,309.7 322.14,312.22 v3(321.57,312.22)
D40901: length 471.2
  L19_SIGNAL w0.076: 310.83,191.01 310.83,190.02 310.83,188.53 v2(310.5,188.21)
  L19_SIGNAL w0.102: 310.83,191.01 310.83,191.21 311.74,192.11 312.27,192.11 312.87,192.71 316.36,192.71 317.33,191.74 318.14,191.74 320.53,189.36 320.53,178.77 318.39,176.63 318.39,165.63 320.55,163.47 320.55,157.28 322.62,155.21 329.59,155.21 329.88,155.5 338.85,155.5 339.87,154.48 351.66,154.48 352.36,155.18 369,155.18 370.96,157.14 378.97,157.14 390.47,168.64 390.47,299.56 393.55,302.64 393.55,307.99 398.93,313.37 425.75,313.37 427.15,311.98 445.34,311.98 450.87,317.51 502.02,317.51 517.48,332.97 517.48,341.85 527.67,352.03 561.35,352.03 562.64,350.74 562.64,349.22 D409.01
D40902: length 547.2
  L19_SIGNAL w0.076: 234.08,189.79 234.08,188.53 v2(233.76,188.21)
  L19_SIGNAL w0.102: 234.08,189.79 234.08,190.65 234.7,191.26 235.46,191.26 237.73,188.99 237.73,179.81 236.24,178.31 236.24,165.48 238.57,163.14 238.57,154.25 239.73,153.09 249.82,153.09 250.48,152.43 258.01,152.43 259.15,153.57 268.77,153.57 271.92,150.42 272.73,150.42 275,148.16 275,147.95 277.49,145.47 307.56,145.47 309.49,143.54 314.75,143.54 315.96,142.32 319.43,142.32 320.81,140.94 332.97,140.94 333.91,141.89 343.46,141.89 345.94,139.4 387.28,139.4 404.55,156.67 404.55,291.08 412.75,299.29 447.83,299.29 450.21,301.67 501.96,301.67 528.94,328.65 564.29,328.65 565.33,329.69 565.33,339.27 D409.02
D40903: length 466.2
  L19_SIGNAL w0.076: 311.48,190.98 311.48,188.53 v2(311.16,188.21)
  L19_SIGNAL w0.102: D409.03 557.51,349.27 557.51,350.79 556.73,351.56 527.84,351.56 517.96,341.68 517.96,332.71 502.27,317.02 451.03,317.02 445.53,311.52 426.95,311.52 425.58,312.89 399.13,312.89 394.03,307.79 394.03,302.45 390.95,299.37 390.95,168.27 378.32,155.65 370.17,155.65 368.45,153.92 358.85,153.92 358.75,154.03 339.69,154.03 338.65,155.07 330.02,155.07 328.91,153.96 321.65,153.96 319.44,156.17 319.44,163.86 317.28,166.01 317.28,176.38 319.26,178.36 319.26,189.08 316.06,192.28 313.17,192.28 312.41,191.52 311.9,191.52 311.48,191.09 311.48,190.98
D40904: length 544.3
  L19_SIGNAL w0.076: v2(232.46,188.21) 232.78,188.53 232.78,191.01
  L19_SIGNAL w0.102: D409.04 560.04,339.06 560.04,329.62 559.49,329.06 528.78,329.06 501.79,302.07 449.96,302.07 447.7,299.82 412.62,299.82 404.13,291.33 404.13,156.91 388.77,141.55 373.48,141.55 371.88,139.95 363.9,139.95 363.26,140.6 345.46,140.6 343.76,142.29 333.74,142.29 332.8,141.35 320.97,141.35 319.6,142.73 316.13,142.73 314.92,143.94 309.66,143.94 307.56,146.04 278.52,146.04 275.95,148.62 275.23,148.62 273.22,150.64 273.22,151.34 270.53,154.03 259.03,154.03 257.84,152.83 250.96,152.83 250.28,153.52 239.95,153.52 239,154.46 239,163.45 236.77,165.68 236.77,176.68 238.8,178.71 238.8,188.61 235.71,191.69 233.35,191.69 232.78,191.12 232.78,191.01
D40905: length 455.4
  L19_SIGNAL w0.076: v2(312.46,188.21) 312.78,188.53 312.78,191.01
  L19_SIGNAL w0.102: D409.05 552.21,349.49 526.43,349.49 518.48,341.54 518.48,332.38 500.35,314.25 450.74,314.25 446.48,309.99 399.91,309.99 394.58,304.66 394.58,302.39 391.37,299.19 391.37,166.98 379.6,155.2 370.36,155.2 368.64,153.47 358.43,153.47 358.3,153.61 338.61,153.61 337.84,152.83 330.96,152.83 330.28,153.52 319.95,153.52 319,154.46 319,163.45 316.77,165.68 316.77,176.68 318.8,178.71 318.8,188.61 315.71,191.69 313.35,191.69 312.78,191.12 312.78,191.01
D40906: length 540.5
  L19_SIGNAL w0.076: 231.48,190.98 231.48,188.53 v2(231.16,188.21)
  L19_SIGNAL w0.102: D409.06 554.99,339.09 554.99,332.13 554.1,331.24 527.71,331.24 527,330.53 527,327.86 501.62,302.48 449.79,302.48 447.53,300.22 410.84,300.22 403.63,293.01 403.63,158.6 387.43,142.39 371.45,142.39 370.2,141.15 354.33,141.15 353.69,141.79 345.36,141.79 344.45,142.7 333.57,142.7 332.63,141.76 321.14,141.76 319.77,143.13 316.3,143.13 315.08,144.35 309.83,144.35 308.9,145.28 308.9,146 307.52,147.38 306.22,147.38 305.82,147.78 301.85,147.78 301.35,147.27 278.02,147.27 273.38,151.91 273.38,153.19 272.08,154.48 259.23,154.48 258.65,155.07 250.02,155.07 248.91,153.96 241.65,153.96 239.44,156.17 239.44,163.86 237.28,166.01 237.28,176.38 239.26,178.36 239.26,189.08 236.06,192.28 233.17,192.28 232.41,191.52 231.9,191.52 231.48,191.09 231.48,190.98
D40907: length 447.8
  L19_SIGNAL w0.076: 314.08,189.79 314.08,188.53 v2(313.76,188.21)
  L19_SIGNAL w0.102: D409.07 547.63,348.99 526.55,348.99 519.03,341.46 519.03,332.2 500.65,313.82 450.95,313.82 446.66,309.53 400.21,309.53 396.08,305.4 396.08,303.28 391.81,299.01 391.81,166.72 379.79,154.7 370.58,154.7 368.94,153.06 353.6,153.06 352.97,152.43 330.48,152.43 329.82,153.09 319.73,153.09 318.57,154.25 318.57,163.14 316.24,165.48 316.24,178.31 317.73,179.81 317.73,188.99 315.46,191.26 314.7,191.26 314.08,190.65 314.08,189.79
D40908: length 532.6
  L19_SIGNAL w0.076: v2(230.5,188.21) 230.83,188.53 230.83,190.02 230.83,191.01
  L19_SIGNAL w0.102: D409.08 544.89,334.07 544.89,332.54 544.13,331.78 527.33,331.78 526.47,330.92 526.47,327.9 501.46,302.89 449.62,302.89 447.36,300.63 408.58,300.63 403.17,295.22 403.17,161.02 386.51,144.36 371.89,144.36 369.45,141.91 360.78,141.91 360.11,142.58 355.42,142.58 354.93,142.09 353.96,142.09 353.14,142.91 347.67,142.91 347.18,143.4 345.39,143.4 345.1,143.1 323.28,143.1 322.85,143.54 316.47,143.54 315.25,144.75 310,144.75 309.31,145.44 309.31,146.17 306.43,149.05 283.72,149.05 283.13,148.46 277.4,148.46 274.44,151.42 274.44,153.48 273.33,154.59 273.33,154.99 273.11,155.21 269.04,155.21 268.57,155.69 260.33,155.69 260.15,155.5 249.88,155.5 249.59,155.21 242.62,155.21 240.55,157.28 240.55,163.47 238.39,165.63 238.39,176.63 240.53,178.77 240.53,189.36 238.14,191.74 237.33,191.74 236.36,192.71 232.87,192.71 232.27,192.11 231.74,192.11 230.83,191.21 230.83,191.01
D40909: length 496.3
  L19_SIGNAL w0.254: v2(268.55,188.86) 267.24,190.17
  L19_SIGNAL w0.508: D409.09 544.78,346.76 527.13,346.76 519.83,339.46 519.83,331.57 501.32,313.06 451.24,313.06 447.08,308.9 403.39,308.9 393.21,298.73 393.21,166.02 379.94,152.75 370.04,152.75 368.69,151.4 353.72,151.4 353.34,151.78 327.46,151.78 327.43,151.74 317.79,151.74 317.14,152.4 317.14,156.82 316.19,157.77 308.97,157.77 308.86,157.88 301.46,157.88 298.91,160.43 290.1,160.43 287.44,157.77 284.58,157.77 283.84,158.51 283.84,163.69 280.38,167.16 280.38,174.29 282.86,176.78 282.86,191.39 280.3,193.95 277.76,193.95 276.26,195.45 273.3,195.45 272.92,195.07 270.63,195.07 270.23,195.47 269.51,195.47 267.83,193.79 267.83,191.82 267.24,191.23 267.24,190.17
D40910: length 530.1
  L19_SIGNAL w0.254: v2(228.56,189.51) 229.11,190.06
  L19_SIGNAL w0.508: 229.11,190.06 229.11,190.91 229.54,191.34 229.54,192.46 230.53,193.44 231.25,193.44 231.6,193.08 232.37,193.08 233.26,193.98 236.21,193.98 237.76,192.43 239.87,192.43 241.26,191.03 241.26,177.22 239.31,175.26 239.31,165.86 241.19,163.98 241.19,158.51 241.76,157.94 242.31,157.94 242.86,157.39 242.86,156.38 243.37,155.87 249.01,155.87 250.99,157.85 258.06,157.85 259.61,156.3 268.96,156.3 269.38,155.87 273.73,155.87 275.16,154.43 275.16,152.36 278.45,149.07 282.78,149.07 283.48,149.77 307.56,149.77 309.51,147.82 310.24,147.82 311.92,146.13 315,146.13 316.94,144.2 323.39,144.2 323.82,143.76 344.74,143.76 345.87,144.89 348.22,144.89 349.48,143.63 369.86,143.63 371.47,145.24 385.39,145.24 401.71,161.56 401.71,296.3 406.84,301.43 447.21,301.43 449.32,303.55 500.72,303.55 525.38,328.2 525.38,332.09 527.31,334.02 539.76,334.02 D409.10
D40911: length 484.8
  L19_SIGNAL w0.254: 269.11,190.06 v2(268.55,189.51)
  L19_SIGNAL w0.508: D409.11 542.3,344.16 526.44,344.16 520.82,338.54 520.82,330.99 499.67,309.83 449.25,309.83 444.65,305.23 403.02,305.23 394.09,296.3 394.09,164.31 381.69,151.91 370.71,151.91 368.57,149.77 363.64,149.77 362.89,149.02 357.95,149.02 357.2,149.77 323.46,149.77 322.58,150.65 319.42,150.65 318.54,149.77 317.75,149.77 315.22,152.3 315.22,155.18 314.54,155.87 309,155.87 308.59,156.27 299.64,156.27 298.06,157.85 290.99,157.85 289.01,155.87 283.83,155.87 281.19,158.51 281.19,164.11 279.31,165.99 279.31,175.26 281.26,177.22 281.26,191.03 279.87,192.43 277.76,192.43 276.21,193.98 273.26,193.98 272.37,193.08 271.6,193.08 271.25,193.44 270.53,193.44 269.54,192.46 269.54,191.34 269.11,190.91 269.11,190.06
D40912: length 529.4
  L19_SIGNAL w0.254: v2(228.56,188.86) 227.24,190.17
  L19_SIGNAL w0.508: 227.24,190.17 227.24,191.23 227.83,191.82 227.83,193.79 229.51,195.47 230.23,195.47 230.63,195.07 232.92,195.07 233.3,195.45 236.26,195.45 237.76,193.95 240.3,193.95 242.86,191.39 242.86,176.78 240.38,174.29 240.38,167.16 243.84,163.69 243.84,158.51 244.58,157.77 247.44,157.77 250.1,160.43 258.91,160.43 261.46,157.88 268.86,157.88 268.91,157.83 273.76,157.83 277.14,154.46 277.14,152.4 277.84,151.69 298.56,151.69 299.08,152.21 308.06,152.21 309.03,151.25 309.03,150.73 311.24,148.51 311.24,148.18 312.37,147.04 315.47,147.04 317.24,145.28 344.94,145.28 345.67,146.01 348.4,146.01 349.93,144.49 363.03,144.49 363.78,145.24 369.75,145.24 371.57,147.06 384.49,147.06 400.9,163.47 400.9,298.03 405.18,302.31 446.84,302.31 448.96,304.42 499.87,304.42 524.23,328.77 524.23,333.31 527.51,336.6 537.26,336.6 D409.12
D40913: length 475.1
  L19_SIGNAL w0.076: v2(271.16,188.21) 271.48,188.53 271.48,190.98
  L19_SIGNAL w0.102: 271.48,190.98 271.48,191.09 271.9,191.52 272.41,191.52 273.17,192.28 276.06,192.28 279.26,189.08 279.26,178.36 277.28,176.38 277.28,166.14 279.44,163.98 279.44,156.17 281.65,153.96 288.91,153.96 290.02,155.07 298.65,155.07 299.25,154.46 312.04,154.46 313.28,153.21 313.28,152.6 314.06,151.82 314.06,151.16 316.64,148.59 322.89,148.59 323.4,148.07 345.35,148.07 345.85,148.57 346.95,148.57 347.47,148.05 353.2,148.05 353.7,148.54 355.47,148.54 356.59,147.42 358.85,147.42 359.11,147.17 362.86,147.17 363.12,147.42 368.53,147.42 371.16,150.06 382.8,150.06 396.08,163.34 396.08,201.52 398.57,204.01 398.57,299.14 403.44,304.01 446.11,304.01 450.79,308.69 500.81,308.69 522.22,330.11 522.22,336 527.61,341.39 536.97,341.39 D409.13
D40914: length 470
  L19_SIGNAL w0.076: 274.08,189.79 274.08,188.53 v2(273.76,188.21)
  L19_SIGNAL w0.102: D409.14 534.45,338.87 527.18,338.87 523.43,335.12 523.43,328.93 499.69,305.19 448.51,305.19 446.47,303.15 403.79,303.15 399.43,298.78 399.43,164.09 383.24,147.9 371.23,147.9 369.2,145.87 362.78,145.87 362.38,145.47 355.38,145.47 354.08,146.77 353.25,146.77 352.86,147.16 347.78,147.16 347.41,146.79 345.51,146.79 344.67,145.95 319.45,145.95 317.7,147.7 316.1,147.7 314.45,149.35 312.66,149.35 308.4,153.6 299.18,153.6 298.01,152.43 290.48,152.43 289.82,153.09 279.73,153.09 278.57,154.25 278.57,163.27 276.24,165.61 276.24,178.31 277.73,179.81 277.73,188.99 275.46,191.26 274.7,191.26 274.08,190.65 274.08,189.79
D40915: length 468.9
  L19_SIGNAL w0.076: v2(270.5,188.21) 270.83,188.53 270.83,190.02 270.83,191.01
  L19_SIGNAL w0.102: 270.83,191.01 270.83,191.21 271.74,192.11 272.27,192.11 272.87,192.71 276.36,192.71 277.33,191.74 278.14,191.74 280.53,189.36 280.53,178.77 278.39,176.63 278.39,165.76 280.55,163.6 280.55,157.28 282.62,155.21 289.59,155.21 289.88,155.5 300.15,155.5 300.31,155.66 308.34,155.66 308.93,155.08 312.38,155.08 314.54,152.92 314.54,151.33 316.82,149.05 356.06,149.05 356.69,148.41 362.81,148.41 363.3,147.93 368.2,147.93 370.75,150.48 382.48,150.48 395.58,163.57 395.58,201.72 398.09,204.23 398.09,299.34 403.24,304.48 445.91,304.48 450.6,309.17 500.25,309.17 521.67,330.58 521.67,336.32 527.24,341.9 532.4,341.9 D409.15
D40916: length 468
  L19_SIGNAL w0.076: 272.78,191.01 272.78,188.53 v2(272.46,188.21)
  L19_SIGNAL w0.102: 272.78,191.01 272.78,191.12 273.35,191.69 275.71,191.69 278.8,188.61 278.8,178.71 276.77,176.68 276.77,165.81 279,163.58 279,154.46 279.95,153.52 290.28,153.52 290.96,152.83 297.84,152.83 299.02,154.02 310.86,154.02 311.77,153.11 311.77,150.98 312.9,149.85 314.67,149.85 316.37,148.15 317.86,148.15 318.95,147.07 341.88,147.07 342.53,146.42 344.45,146.42 345.34,147.31 347.16,147.31 347.45,147.61 353.13,147.61 353.5,147.25 354.23,147.25 355.6,145.87 362.18,145.87 363.27,146.96 368.95,146.96 371.58,149.59 384.12,149.59 398.99,164.47 398.99,298.96 403.61,303.58 446.29,303.58 448.37,305.67 499.41,305.67 522.77,329.02 522.77,335.1 526.96,339.29 529.79,339.29 D409.16
D41001: length 363.9
  L19_SIGNAL w0.076: 354.08,189.79 354.08,188.53 v2(353.75,188.21)
  L19_SIGNAL w0.102: 354.08,189.79 354.08,190.65 354.7,191.26 355.46,191.26 356.9,189.82 374.23,189.82 386.73,202.33 386.73,299.37 390.27,302.91 390.27,316.66 395.79,322.17 503.02,322.17 514.99,334.14 514.99,342.54 523.92,351.47 523.92,358.21 527.46,361.75 567.49,361.75 D410.01
D41002: length 474.3
  L19_SIGNAL w0.254: v2(308.55,189.51) 309.11,190.06
  L19_SIGNAL w0.508: D410.02 562.59,356.85 527.4,356.85 525.49,354.95 525.49,350.82 516.75,342.08 516.75,333.37 501.61,318.23 450.55,318.23 445.04,312.72 427.52,312.72 426.16,314.08 395.61,314.08 392.81,311.27 392.81,303.06 389.01,299.27 389.01,169.31 377.57,157.87 370.48,157.87 368.48,155.87 340.04,155.87 338.06,157.85 330.99,157.85 329.01,155.87 323.37,155.87 322.86,156.38 322.86,157.39 322.31,157.94 321.76,157.94 321.19,158.51 321.19,163.98 319.31,165.86 319.31,175.26 321.26,177.22 321.26,191.03 319.87,192.43 317.76,192.43 316.21,193.98 313.26,193.98 312.37,193.08 311.6,193.08 311.24,193.44 310.53,193.44 309.54,192.46 309.54,191.34 309.11,190.91 309.11,190.06
D41003: length 360.5
  L19_SIGNAL w0.076: v2(352.45,188.21) 352.78,188.53 352.78,191.01
  L19_SIGNAL w0.102: 352.78,191.01 352.78,191.12 353.35,191.69 355.71,191.69 357.14,190.26 374.06,190.26 386.29,202.5 386.29,299.55 389.84,303.09 389.84,316.89 395.55,322.61 502.68,322.61 514.48,334.4 514.48,342.64 523.49,351.65 523.49,358.62 527.08,362.2 562.86,362.2 D410.03
D41004: length 473
  L19_SIGNAL w0.254: v2(308.55,188.86) 307.24,190.17
  L19_SIGNAL w0.508: 307.24,190.17 307.24,191.23 307.83,191.82 307.83,193.79 309.51,195.47 310.23,195.47 310.63,195.07 312.92,195.07 313.3,195.45 316.26,195.45 317.76,193.95 320.3,193.95 322.86,191.39 322.86,176.78 320.38,174.29 320.38,167.16 323.84,163.69 323.84,158.51 324.58,157.77 327.44,157.77 330.1,160.43 338.91,160.43 341.46,157.88 348.86,157.88 348.97,157.77 368.17,157.77 370.85,160.44 377.63,160.44 388.13,170.94 388.13,299.63 391.93,303.43 391.93,314.63 394.76,317.46 425.41,317.46 429.39,321.44 503.35,321.44 515.8,333.89 515.8,342.36 524.62,351.19 524.62,356.61 527.41,359.41 560.07,359.41 D410.04
D41005: length 359.2
  L33_SIGNAL w0.076: v2(353.75,189.51) 353.81,189.56 353.81,191.08
  L33_SIGNAL w0.091: D410.05 554.79,367.23 526.99,367.23 507.91,348.14 507.91,313.71 499.69,305.5 443.55,305.5 433.29,295.24 382.84,295.24 381.77,294.18 371.17,294.18 360.27,283.29 357.63,283.29 356.43,282.09 356.43,280.76 355.42,279.75 355.42,269.18 354.91,268.68 354.91,253.01 358.67,249.25 358.67,243.89 359.44,243.12 359.44,240.13 358.92,239.6 358.92,239.02 356.54,236.64 356.54,226.1 358.93,223.72 358.93,215.28 357.52,213.87 357.52,207.83 356.42,206.73 356.42,204.93 353.43,201.94 353.43,191.64 353.81,191.26 353.81,191.08
D41006: length 365.6
  L33_SIGNAL w0.091: UNK8K113.6 364.02,161.54 368.67,161.54 370.19,163.07 370.19,173.59 369.55,174.22 369.55,190.75 370.95,192.15 370.95,231.9 369.05,233.81 369.05,255.52 370.63,257.11 370.63,282.09 376.2,287.66 433.05,287.66 444.88,299.49 502.35,299.49 512.93,310.07 512.93,339.45 527.57,354.09 549.67,354.09 D410.06
D41007: length 352.9
  L33_SIGNAL w0.076: v2(353.75,188.86) 354.19,189.29 354.19,191.08
  L33_SIGNAL w0.091: D410.07 550.19,366.75 527.53,366.75 508.35,347.57 508.35,313.55 499.87,305.07 443.75,305.07 433.47,294.79 383.03,294.79 381.99,293.75 371.42,293.75 359.03,281.35 358.21,281.35 357.1,280.25 357.1,275.43 356.47,274.81 356.47,269.3 355.34,268.16 355.34,253.23 360.51,248.05 360.51,240.6 359.37,239.47 359.37,238.88 356.96,236.47 356.96,226.27 359.39,223.84 359.39,214.28 358.57,213.46 358.57,210.61 357.94,209.98 357.94,207.66 356.84,206.56 356.84,204.76 354.49,202.41 354.49,191.57 354.19,191.27 354.19,191.08
D41008: length 349
  L33_SIGNAL w0.091: v2(357.83,172.39) 361.21,175.77 361.21,185.46 370.59,194.83 370.59,231.75 368.68,233.66 368.68,255.79 370.21,257.32 370.21,282.43 376.72,288.94 433.74,288.94 444.71,299.9 502.18,299.9 512.52,310.24 512.52,340.05 527.05,354.58 545.08,354.58 D410.08
  BOTTOM w0.16: UNK8K32.2 v2(357.83,172.39)
D41009: length 347.5
  L33_SIGNAL w0.076: 354.57,191.08 354.57,190.45 354.73,190.29 354.73,188.07 354.54,187.88 354.08,187.88 v2(353.75,187.56)
  L33_SIGNAL w0.091: 354.57,191.08 354.57,191.13 354.91,191.47 354.91,202.24 357.26,204.59 357.26,205.37 359.09,207.21 359.09,209.01 359.84,209.76 359.84,212.72 360.55,213.43 360.55,223.28 357.38,226.45 357.38,236.26 359.62,238.5 360.25,238.5 361,239.24 361,248.91 358.15,251.76 357.46,251.76 356.51,252.71 356.51,253.4 355.76,254.15 355.76,264.52 356.48,265.24 356.48,266.37 357.49,267.38 357.49,278.44 372.36,293.32 382.23,293.32 383.28,294.37 433.64,294.37 443.92,304.65 500.04,304.65 508.77,313.37 508.77,346.46 527.04,364.74 547.12,364.74 D410.09
D41010: length 354.3
  L33_SIGNAL w0.091: D410.10 541.9,356.48 527.42,356.48 512.1,341.15 512.1,310.52 501.94,300.36 444.57,300.36 433.6,289.39 376.41,289.39 369.48,282.46 369.48,269.95 360.48,260.95 360.48,255.58 361.49,254.58 363.52,254.58 366.73,251.37 366.73,235.03 370.22,231.53 370.22,198.66 370.19,198.63 370.19,195.9 367.98,193.69 367.97,193.69 361.61,187.33 361.61,187.32 360.6,186.31 360.6,180.58 353.63,173.62 v2(353.63,172.39)
  BOTTOM w0.16: UNK8K32.7 v2(353.63,172.39)
D41011: length 338.8
  L33_SIGNAL w0.076: 355.7,191.04 v2(355.7,188.86)
  L33_SIGNAL w0.091: D410.11 542.54,364.24 527.56,364.24 509.19,345.86 509.19,313.2 500.22,304.23 444.1,304.23 433.82,293.95 383.53,293.95 382.47,292.89 372.54,292.89 358.61,278.95 358.61,270.74 358,270.13 358,267.26 356.92,266.18 356.92,265.08 356.19,264.35 356.19,254.31 356.73,253.77 356.95,253.56 356.95,252.89 357.64,252.2 358.31,252.2 361.45,249.05 361.45,239.06 360.4,238 359.75,238 358.29,236.54 358.29,226.23 360.97,223.54 360.97,209.96 360.09,209.08 360.09,207.17 358.45,205.53 358.45,205.14 355.33,202.02 355.33,192.68 355.7,192.3 355.7,191.04
D41012: length 349.1
  L33_SIGNAL w0.076: v2(351.8,183) 352.13,182.68 355.9,182.68
  L33_SIGNAL w0.091: 355.9,182.68 356.34,182.68
  L33_SIGNAL w0.508: D410.12 537.39,357.05 526.98,357.05 511.48,341.56 511.48,312.11 501.25,301.87 445.11,301.87 433.25,290.01 376.12,290.01 368.89,282.79 368.89,272.47 363.19,266.76 363.19,265.5 359.29,261.61 359.29,254.99 359.81,254.47 360.79,254.47 361.31,253.94 362.34,253.94 365.22,251.05 365.22,237.06 363.9,235.74 361.77,235.74 360.54,234.51 360.54,228.1 363.55,225.09 368.04,225.09 369.43,223.7 369.43,209.7 359.37,199.64 359.37,185.38 356.67,182.68 356.34,182.68
D41013: length 339.4
  L33_SIGNAL w0.076: 356.07,187.28 356.02,187.23 354.73,187.23 v2(354.4,187.56)
  L33_SIGNAL w0.091: 356.07,187.28 356.85,188.06 356.85,201.61 360.51,205.28 360.51,206.22 361.13,206.83 361.13,207.65 362.8,209.32 362.8,211.85 363.86,212.91 363.86,214.65 365.43,216.22 365.43,217.98 366.23,218.79 366.23,223.03 365.49,223.77 361.93,223.77 359.13,226.58 359.13,235.43 361.73,238.03 362.47,238.03 362.97,238.53 362.97,249.65 360.48,252.14 359.8,252.14 357.03,254.91 357.03,263.79 360.11,266.87 360.11,268.88 363.84,272.62 363.84,274.69 364.47,275.32 364.47,281.32 375.16,292 382.88,292 383.15,292.27 433.39,292.27 444.51,303.39 500.56,303.39 510.02,312.85 510.02,344.16 527.61,361.74 537,361.74 D410.13
D41014: length 341.2
  L33_SIGNAL w0.076: 356.07,183.33 354.73,183.33 v2(354.4,183)
  L33_SIGNAL w0.091: 356.07,183.33 356.16,183.33 358.8,185.96 358.8,201.58 360.16,202.95 360.22,202.95 364.33,207.06 364.33,207.6 368.67,211.93 368.67,223.51 367.65,224.52 363.13,224.52 359.96,227.69 359.96,235.09 361.38,236.5 362.82,236.5 364.58,238.27 364.58,250.08 361.64,253.02 361.16,253.02 360.42,253.75 359.52,253.75 358.63,254.64 358.63,263.03 361.22,265.62 361.22,266.88 362.85,268.5 363.92,268.5 366.18,270.76 366.18,271.93 367.14,272.9 367.14,282.05 376.2,291.11 383.39,291.11 383.71,291.43 433.74,291.43 444.86,302.55 500.91,302.55 510.86,312.5 510.86,342.46 527.61,359.21 534.47,359.21 D410.14
D41015: length 328.2
  L33_SIGNAL w0.076: 356.07,188.57 v2(355.7,188.21)
  L33_SIGNAL w0.091: D410.15 532.37,362.19 527.04,362.19 509.61,344.76 509.61,313.02 500.39,303.81 444.27,303.81 433.22,292.75 383.04,292.75 382.71,292.43 373.79,292.43 362.9,281.54 362.9,275.41 359.8,272.31 359.8,269.82 359.04,269.06 359.04,267.22 357.4,265.58 357.4,264.96 356.61,264.17 356.61,254.49 357.39,253.7 357.39,253.06 357.84,252.62 358.49,252.62 359.38,251.72 360.31,251.72 362.55,249.48 362.55,238.71 362.3,238.45 361.44,238.45 360.57,237.58 359.92,237.58 358.71,236.37 358.71,226.4 361.39,223.72 361.39,208.65 360.61,207.87 360.61,207.1 358.87,205.36 358.87,204.97 356.43,202.53 356.43,188.93 356.07,188.57
D41016: length 332
  L33_SIGNAL w0.076: v2(353.75,186.91) 354.08,186.58 356.07,186.58
  L33_SIGNAL w0.091: D410.16 529.82,359.64 527.03,359.64 510.44,343.06 510.44,312.68 500.74,302.97 444.69,302.97 433.57,291.85 383.43,291.85 383.15,291.57 375.36,291.57 365.29,281.49 365.29,272.54 363,270.26 363,269.44 360.61,267.06 360.61,266.73 357.46,263.58 357.46,255.08 359.98,252.57 361.5,252.57 363.43,250.64 363.43,238.39 362.66,237.61 361.9,237.61 359.54,235.26 359.54,227.51 362.92,224.14 365.64,224.14 366.6,223.18 366.6,216.19 366.76,216.03 366.76,215.54 366.17,214.95 366.17,210.89 364.26,208.98 363.19,208.98 361.57,207.36 361.57,205.74 357.27,201.44 357.27,187.49 356.36,186.58 356.07,186.58
D41101: length 387.2
  L19_SIGNAL w0.076: v2(351.15,188.21) 351.48,188.53 351.48,190.98
  L19_SIGNAL w0.102: 351.48,190.98 351.48,191.09 351.9,191.52 352.41,191.52 353.17,192.28 356.06,192.28 357.63,190.7 357.64,190.71 372.5,190.71 385.87,204.07 385.87,299.72 389.37,303.22 389.37,319.94 392.53,323.1 502.33,323.1 514,334.77 514,342.88 523,351.88 523,363.29 526.58,366.87 566.68,366.87 567.75,367.93 567.75,382.33 D411.01
D41102: length 382.2
  L19_SIGNAL w0.076: v2(350.5,188.21) 350.83,188.53 350.83,190.02 350.83,191.01
  L19_SIGNAL w0.102: 350.83,191.01 350.83,191.21 351.74,192.11 352.27,192.11 352.87,192.71 356.36,192.71 357.33,191.74 371.16,191.74 371.71,191.2 372.36,191.2 385.39,204.23 385.39,299.92 388.9,303.42 388.9,320.13 392.33,323.57 502.13,323.57 513.53,334.97 513.53,343.08 522.53,352.08 522.53,363.51 526.35,367.33 563.53,367.33 565.22,369.01 565.22,379.8 D411.02
D41103: length 382.2
  L19_SIGNAL w0.254: 349.11,190.06 v2(348.55,189.51)
  L19_SIGNAL w0.508: D411.03 562.69,382.35 562.69,370.55 561.8,369.67 527.14,369.67 521.85,364.38 521.85,352.36 512.85,343.36 512.85,335.25 501.85,324.25 392.05,324.25 388.27,320.47 388.27,303.88 383.93,299.55 383.93,205.02 371.34,192.43 357.76,192.43 356.21,193.98 353.26,193.98 352.37,193.08 351.6,193.08 351.24,193.44 350.53,193.44 349.54,192.46 349.54,191.34 349.11,190.91 349.11,190.06
