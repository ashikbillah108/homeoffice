# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSDPS426PS4: length 126.7
  L11_DPS w0.203: CSDPS426.A4 267.97,364.49 276.48,364.49 279.02,361.95 279.02,340.66 281.05,338.63 281.05,270 280.28,269.24 280.28,266.7 279.27,265.68 2SA21.2
CSDPS426PS5: length 147.5
  L07_DPS w0.203: CSDPS426.D5 263.14,359.16 261.29,359.16 260.65,358.52 260.65,347.77 290.34,318.08 290.34,256.34 287.5,253.49 287.5,247.57 281.35,241.43 281.35,239.47 280.11,238.23 277.19,238.23 276.88,238.53 2SA17.2
CSDPS426PS7: length 122.9
  L09_DPS w0.203: 2SA8.2 265.3,252.47 274.8,261.97 274.8,279.81 274.54,280.06 274.54,321.09 258.27,337.36 258.27,357.33 CSDPS426.D7
CSDPS426PS11: length 119.9
  L05_DPS w0.203: 2SA16.2 276.98,268.61 277.49,269.11 277.49,280.04 276.86,280.67 276.86,294.89 277.37,295.4 277.37,301.62 248.92,330.07 CSDPS426.D11
CSDPS426PS14: length 161.6
  L11_DPS w0.203: 2SA9.2 259.46,238 258.69,237.24 255.85,237.24 254.3,235.69 251.31,235.69 249.68,237.31 249.68,252.35 250.77,253.45 250.77,294.04 240.78,304.04 240.54,304.04 232.56,312.01 232.56,363.68 233.38,364.49 240.03,364.49 CSDPS426.A14
CSDPS426PS15: length 154.5
  L09_DPS w0.203: CSDPS426.D15 237.74,357.12 237.74,332.7 250.44,320 250.44,264.41 250.7,264.16 250.7,257.3 250.31,256.92 250.31,248.16 251.07,247.4 251.07,240.54 250.16,239.63 250.16,237.64 252.34,235.46 260.21,235.46 263.03,232.63 263.74,232.63 266.57,235.46 272.28,235.46 273.41,236.59 2SA23.2
CSDPS430GS1: length 149.1
  L03_DPS w0.203: CSDPS430.D2 198.12,304.93 199.9,303.15 199.9,253.35 204.71,248.54 218.53,248.54 218.94,248.95 218.94,251.73 219.35,252.15 SA2.2
  L13_SIGNAL w0.203: CSDPS430.A1 199.64,366.78 197.36,366.78 196.85,366.27 196.85,359.41 CSDPS430.D2
CSDPS430GS3: length 199.7
  L05_DPS w0.203: SA20.2 223.49,240.08 222.96,239.55 222.96,237.85 224.89,235.92 228.83,235.92 229.72,235.03 239.06,235.03 239.65,235.61 249.12,235.61 250.36,234.37 256.36,234.37 259.18,237.19 259.18,249.53 262.89,253.24 262.89,259.59 258.45,264.03 258.45,265.8 257.05,267.21 257.05,293.62 244.86,305.82 244.86,307.72 196.85,355.73 196.85,358.65 196.34,359.16 194.06,359.16 CSDPS430.D4
CSDPS430GS4: length 141.4
  L11_DPS w0.203: SA22.2 240.54,265.43 241.55,266.45 241.55,300.33 237.26,304.62 235.74,304.62 205.87,334.49 205.87,363.96 202.79,367.03 196.85,367.03 CSDPS430.A3
CSDPS430GS5: length 163.7
  L07_DPS w0.203: CSDPS430.D6 189.64,356.46 189.64,345.36 230.76,304.24 238.73,304.24 250.85,292.13 250.85,253.67 249.58,252.4 249.58,247.52 242.82,240.77 242.82,238.76 241.55,237.49 239.14,237.49 238.61,236.96 236.12,236.96 235.15,237.92 SA18.2
CSDPS430GS7: length 138.7
  L09_DPS w0.203: SA7.2 224.03,248.56 224.33,248.87 224.33,253.28 234.26,263.22 234.26,272.14 232.99,273.41 232.99,284.18 234.01,285.19 234.01,290.14 234.7,290.83 234.7,296.16 183.9,346.96 183.9,357.12 CSDPS430.D8
CSDPS430GS11: length 141.8
  L05_DPS w0.203: SA15.2 237.49,267.63 238.67,268.81 239.62,268.81 240.91,270.09 240.91,284.72 229.72,295.91 228.65,295.91 222.4,302.16 222.4,303.63 176.78,349.25 176.78,358.65 176.28,359.16 173.74,359.16 CSDPS430.D12
CSDPS430GS14: length 193.3
  L11_DPS w0.203: SA10.2 221.74,237.49 220.73,236.47 216.03,236.47 213.72,234.16 210.57,234.16 209.17,235.56 209.17,252.73 210.27,253.82 210.27,282.3 205.1,287.46 188.44,287.46 185.86,290.04 185.86,297.27 174.86,308.28 174.86,308.28 174.5,308.64 174.5,308.64 158.39,324.74 158.39,366.12 159.31,367.03 168.91,367.03 CSDPS430.A13
CSDPS430GS15: length 172.5
  L09_DPS w0.203: SA24.2 234.06,236.09 234.31,235.84 234.31,234.82 233.68,234.19 231.39,234.19 230.92,233.71 228.4,231.19 222.45,231.19 219.46,234.19 212.34,234.19 209.15,237.38 209.15,240.31 209.8,240.96 209.8,257.12 210.24,257.56 210.24,263.97 209.94,264.28 209.94,290.93 163.58,337.29 163.58,357.12 CSDPS430.D16
CSDPS430P1: length 5.7
  L03_DPS w0.203: v2(230.5,250.15) 230.04,250.15 228.86,251.33 226.83,251.33 226.52,251.64 SA1.1
  BOTTOM w0.508: CA1.1 v3(204.47,237.49)
  vias: v2(228.56,241.7) v2(228.56,241.06) v2(229.21,246.26) v2(229.21,245.61) v2(229.21,244.96) v2(229.86,244.96) v2(230.5,246.91) v2(230.5,246.26) v2(230.5,245.61) v2(230.5,244.3) v2(231.16,246.26) v2(231.16,245.61) v2(231.16,244.96) v2(231.16,244.3) v2(231.81,244.96) v3(49.4,187.31) v3(49.4,184.77) v3(49.4,182.23) v3(49.4,179.69) v3(49.4,177.15) v3(49.4,174.61) v3(49.4,172.07) v3(49.4,169.53) v3(204.47,240.03)
CSDPS430P3: length 8.9
  L05_DPS w0.203: SA19.1 224.08,249.47 224.76,250.15 v2(226.61,250.15)
  BOTTOM w0.508: CA35.1 v3(243.87,275.59)
  vias: v2(226.61,245.61) v2(227.91,245.61) v2(233.11,244.96) v3(70.99,187.31) v3(70.99,184.77) v3(70.99,182.23) v3(70.99,179.69) v3(114.29,273.05) v3(115.43,273.05) v3(116.57,273.05) v3(243.87,277.62)
CSDPS430P4: length 10
  L11_DPS w0.076: 236.07,247.23 232.13,247.23 v2(231.81,247.56)
  L11_DPS w0.203: 236.07,247.23 237.83,247.23 239.27,248.67 SA21.1
  BOTTOM w0.508: CA23.1 v3(221.51,275.59)
  vias: v3(70.99,177.15) v3(70.99,174.61) v3(70.99,172.07) v3(70.99,169.53) v3(221.51,277.62)
CSDPS430P5: length 5.2
  L07_DPS w0.203: SA17.1 229.62,238.53 229.21,238.94 v2(229.21,239.75)
  BOTTOM w0.508: CA21.1 v3(215.42,279.65)
  vias: v2(227.91,246.26) v2(227.91,244.96) v2(228.56,247.56) v2(228.56,239.75) v2(231.15,250.15) v2(231.8,250.15) v2(231.81,241.05) v2(232.46,250.15) v2(232.46,247.56) v2(232.46,246.26) v2(232.46,244.3) v2(233.11,250.15) v2(233.11,244.3) v2(233.76,243.65) v3(49.4,160.64) v3(49.4,158.1) v3(49.4,155.56) v3(49.4,153.02) v3(49.4,150.48) v3(49.4,147.94) v3(49.4,145.4) v3(49.4,142.86) v3(114.29,298.45) v3(115.43,298.45) v3(116.57,298.45) v3(215.42,281.69)
CSDPS430P7: length 5.9
  L09_DPS w0.076: 225.55,242.82 225.7,242.68 227.58,242.68 v2(227.91,242.35)
  L09_DPS w0.203: 225.55,242.82 225.3,243.08 SA8.1
  BOTTOM w0.508: CA8.1 v3(243.87,279.65)
  vias: v2(232.46,243) v2(233.76,246.26) v2(235.06,243) v3(70.99,213.98) v3(70.99,211.44) v3(70.99,208.9) v3(70.99,206.36) v3(70.99,203.82) v3(70.99,201.28) v3(70.99,198.74) v3(70.99,196.2) v3(243.87,281.69)
CSDPS430P11: length 8
  L05_DPS w0.076: v2(231.81,246.91) 232.13,247.23 235.97,247.23
  L05_DPS w0.203: 235.97,247.23 236.1,247.23 236.98,248.11 SA16.1
  BOTTOM w0.508: CA27.1 v3(233.93,275.59)
  vias: v2(235.06,250.15) v3(49.4,213.98) v3(49.4,211.44) v3(49.4,208.9) v3(49.4,206.36) v3(49.4,203.82) v3(49.4,201.28) v3(49.4,198.74) v3(49.4,196.2) v3(233.93,277.62)
CSDPS430P14: length 10.8
  L11_DPS w0.076: v2(232.46,241.06) 232.78,240.73 233.24,240.73 233.43,240.54 233.43,238.94 233.3,238.81
  L11_DPS w0.203: SA9.1 232.49,238 233.3,238.81
  BOTTOM w0.508: CA25.1 v3(215.42,275.59)
  vias: v2(229.86,239.75) v2(230.5,240.4) v2(230.5,239.76) v2(231.16,239.75) v2(231.81,241.7) v2(232.46,241.7) v3(70.99,160.64) v3(70.99,158.1) v3(70.99,155.56) v3(70.99,153.02) v3(215.42,277.62)
CSDPS430P15: length 7.1
  L09_DPS w0.076: v2(231.16,241.7) 231.48,242.03 233.24,242.03 233.43,241.84 233.43,239.4 233.41,239.38
  L09_DPS w0.203: 233.41,239.38 SA23.1
  BOTTOM w0.508: CA36.1 v3(227.6,275.59)
  vias: v2(228.56,239.1) v2(229.86,241.05) v2(229.86,240.41) v2(230.5,241.7) v2(230.5,241.05) v2(231.16,241.05) v2(231.81,239.1) v3(70.99,150.48) v3(70.99,147.94) v3(70.99,145.4) v3(70.99,142.86) v3(227.6,277.62)
CSDPS430PS1: length 152
  L03_DPS w0.203: SA1.2 225.03,251.64 224.03,250.63 221.67,250.63 220.81,249.78 220.81,248.98 219.53,247.7 215.26,247.7 214.57,247 204.03,247 202.27,248.76 200.76,248.76 197,252.51 197,358.48 197.8,359.28 199.52,359.28 CSDPS430.D1
  L13_SIGNAL w0.203: CSDPS430.D1 199.39,359.41 199.39,364.49 CSDPS430.A2
CSDPS430PS3: length 189.9
  L05_DPS w0.203: CSDPS430.D3 195.58,352.81 247.14,301.24 248.21,301.24 249.17,300.28 249.17,299.21 256.29,292.1 256.29,265.43 261.11,260.6 261.11,255.57 258.72,253.19 258.72,237.64 256.74,235.66 251.03,235.66 250.44,236.25 237.06,236.25 235.81,237.49 226.19,237.49 224.08,239.6 SA19.2
CSDPS430PS4: length 141.5
  L11_DPS w0.203: CSDPS430.A4 194.31,364.49 202.82,364.49 205.36,361.95 205.36,334.28 235.53,304.11 236.91,304.11 241.05,299.97 241.05,270 240.28,269.24 240.28,266.7 239.27,265.68 SA21.2
CSDPS430PS5: length 165.4
  L07_DPS w0.203: CSDPS430.D5 189.48,359.16 187.63,359.16 186.99,358.52 186.99,347.29 230.55,303.73 237.26,303.73 250.34,290.65 250.34,256.34 247.5,253.49 247.5,247.57 241.35,241.43 241.35,239.47 240.11,238.23 237.19,238.23 236.88,238.53 SA17.2
CSDPS430PS7: length 137.5
  L09_DPS w0.203: CSDPS430.D7 184.53,357.25 184.53,348.11 235.23,297.41 235.23,290.61 234.54,289.92 234.54,280.06 234.8,279.81 234.8,261.97 225.3,252.47 SA8.2
CSDPS430PS11: length 134.2
  L05_DPS w0.203: CSDPS430.D11 175.26,347.35 227.41,295.2 228.57,295.2 236.83,286.94 236.83,279.4 237.49,278.74 237.49,269.11 236.98,268.61 SA16.2
CSDPS430PS14: length 185.2
  L11_DPS w0.203: CSDPS430.A14 166.37,364.49 159.72,364.49 158.9,363.68 158.9,324.92 186.4,297.43 186.4,290.23 188.65,287.97 205.31,287.97 210.77,282.51 210.77,253.45 209.68,252.35 209.68,237.31 211.31,235.69 214.3,235.69 215.85,237.24 218.69,237.24 219.46,238 SA9.2
CSDPS430PS15: length 168.5
  L09_DPS w0.203: CSDPS430.D15 164.08,357.12 164.08,340.82 205.1,299.8 205.1,296.8 210.44,291.46 210.44,264.41 210.7,264.16 210.7,257.3 210.31,256.92 210.31,248.16 211.07,247.4 211.07,240.54 210.16,239.63 210.16,237.64 212.34,235.46 220.21,235.46 223.03,232.63 223.74,232.63 226.57,235.46 232.28,235.46 233.41,236.59 SA23.2
D431_MCB1_A+: length 108
  L15_SIGNAL w0.079: 166.97,291.9 166.97,321.62 153.96,334.63 153.96,376.93 156.36,379.32 156.74,379.32 156.82,379.24 156.82,379.12 156.9,379.04 157.05,379.04 157.13,379.12 157.13,379.24 157.21,379.32 157.37,379.32 157.45,379.24 157.45,379.12 157.53,379.04 157.68,379.04 157.76,379.12 157.76,379.24 157.84,379.32 158,379.32 158.08,379.24 158.08,379.12 158.16,379.04 158.31,379.04 158.39,379.12 158.39,379.24 158.47,379.32 158.63,379.32 158.71,379.24 158.71,379.12 158.79,379.04 158.94,379.04 159.02,379.12 159.02,379.24 159.1,379.32 159.26,379.32 159.34,379.24 159.34,379.12 159.42,379.04 159.57,379.04 159.65,379.12 159.65,379.24 159.73,379.32 159.89,379.32 159.97,379.24 159.97,379.12 160.05,379.04 160.2,379.04 160.28,379.12 160.28,379.24 160.36,379.32 160.76,379.32 161.39,379.96 161.39,381.66 161.87,382.14
  L15_SIGNAL w0.091: 161.87,382.14 162.38,382.14 162.56,381.97 D431.16 ; 166.97,291.9 167.05,291.82 K109.3
D431_MCB1_A-: length 108
  L15_SIGNAL w0.079: 161.79,382.34 161.2,381.74 161.2,380.04 160.68,379.52 156.28,379.52 153.77,377.01 153.77,334.55 166.78,321.54 166.78,291.9
  L15_SIGNAL w0.091: D431.15 163.9,382.34 161.79,382.34 ; 166.78,291.9 166.7,291.82 K109.6
D431_MCB1_B+: length 112.4
  L15_SIGNAL w0.079: 166.95,382.14 166.47,381.66 166.47,380.34 166.13,380 166.13,379.89 166.22,379.8 166.22,379.69 166.11,379.58 166,379.58 165.91,379.67 165.79,379.67 165.68,379.56 165.68,379.44 165.77,379.35 165.77,379.24 165.66,379.13 165.55,379.13 165.46,379.22 165.35,379.22 165.24,379.11 165.24,379 165.33,378.91 165.33,378.8 165.22,378.69 165.11,378.69 165.02,378.78 164.9,378.78 164.79,378.66 164.79,378.55 164.88,378.46 164.88,378.35 164.77,378.24 164.66,378.24 164.57,378.33 164.46,378.33 164.35,378.22 164.35,378.11 164.44,378.02 164.44,377.91 164.33,377.79 164.21,377.79 164.12,377.88 164.01,377.88 163.9,377.77 163.9,377.66 163.99,377.57 163.99,377.46 163.88,377.35 163.77,377.35 163.68,377.44 163.57,377.44 163.22,377.09 158.11,377.09 156.49,375.46 156.49,341.8 176.63,321.66 176.63,291.9
  L15_SIGNAL w0.091: 176.63,291.9 176.71,291.82 K110.3 ; 166.95,382.14 167.46,382.14 167.64,381.97 D431.14
D431_MCB1_B-: length 112.4
  L15_SIGNAL w0.079: 166.87,382.34 166.28,381.74 166.28,380.42 163.14,377.28 158.03,377.28 156.3,375.54 156.3,341.72 176.43,321.58 176.43,291.9
  L15_SIGNAL w0.091: K110.6 176.35,291.82 176.43,291.9 ; D431.13 168.98,382.34 166.87,382.34
D431_MCB1_C+: length 134.6
  L15_SIGNAL w0.079: 172.03,382.14 171.55,381.66 171.55,377.36 174.19,374.73 175.92,374.73 176,374.8 176,374.93 176.08,375.01 176.24,375.01 176.31,374.93 176.31,374.8 176.39,374.73 176.55,374.73 176.63,374.8 176.63,374.93 176.71,375.01 176.87,375.01 176.94,374.93 176.94,374.8 177.02,374.73 177.18,374.73 177.26,374.8 177.26,374.93 177.34,375.01 177.49,375.01 177.57,374.93 177.57,374.8 177.65,374.73 177.81,374.73 177.89,374.8 177.89,374.93 177.97,375.01 178.12,375.01 178.2,374.93 178.2,374.8 178.28,374.73 178.44,374.73 178.52,374.8 178.52,374.93 178.6,375.01 178.75,375.01 178.83,374.93 178.83,374.8 178.91,374.73 179.07,374.73 179.15,374.8 179.15,374.93 179.23,375.01 179.38,375.01 179.46,374.93 179.46,374.8 179.54,374.73 202.56,374.73 204.24,373.05 204.24,339.59 186.28,321.62 186.28,291.9
  L15_SIGNAL w0.091: 186.28,291.9 186.36,291.82 K111.3 ; 172.03,382.14 172.54,382.14 172.72,381.97 D431.12
D431_MCB1_C-: length 134.6
  L15_SIGNAL w0.079: 186.09,291.9 186.09,321.7 204.05,339.67 204.05,372.97 202.48,374.53 174.11,374.53 171.36,377.28 171.36,381.74 171.95,382.34
  L15_SIGNAL w0.091: 171.95,382.34 174.06,382.34 D431.11 ; 186.09,291.9 186.01,291.82 K111.6
D431_MCB1_D+: length 129.6
  L15_SIGNAL w0.079: 195.93,291.9 195.93,303.95 198.18,306.19 198.18,321.31 206.95,330.08 206.95,374.2 203.85,377.29 182.06,377.29 181.98,377.37 181.98,377.5 181.9,377.58 181.75,377.58 181.67,377.5 181.67,377.37 181.59,377.29 181.43,377.29 181.35,377.37 181.35,377.5 181.27,377.58 181.12,377.58 181.04,377.5 181.04,377.37 180.96,377.29 180.8,377.29 180.72,377.37 180.72,377.5 180.64,377.58 180.49,377.58 180.41,377.5 180.41,377.37 180.33,377.29 180.17,377.29 180.09,377.37 180.09,377.5 180.01,377.58 179.86,377.58 179.78,377.5 179.78,377.37 179.7,377.29 179.54,377.29 179.46,377.37 179.46,377.5 179.38,377.58 179.23,377.58 179.15,377.5 179.15,377.37 179.07,377.29 178.91,377.29 178.83,377.37 178.83,377.5 178.75,377.58 178.6,377.58 178.52,377.5 178.52,377.37 178.44,377.29 177.31,377.29 176.63,377.97 176.63,381.66 177.11,382.14
  L15_SIGNAL w0.091: 177.11,382.14 177.62,382.14 177.8,381.97 D431.10 ; K112.3 196.01,291.82 195.93,291.9
D431_MCB1_D-: length 129.6
  L15_SIGNAL w0.079: 195.74,291.9 195.74,304.03 197.99,306.27 197.99,321.39 206.76,330.16 206.76,374.12 203.77,377.1 177.23,377.1 176.44,377.89 176.44,381.74 177.03,382.34
  L15_SIGNAL w0.091: 177.03,382.34 179.14,382.34 D431.09 ; 195.74,291.9 195.66,291.82 K112.6
D10101: length 240.9
  L33_SIGNAL w0.091: D101.01 301.09,102.77 207.75,102.77 185.89,124.62 183.91,124.62 168.84,139.69 147.23,139.69 106.35,180.57 106.35,183.39 UNK5K4.7
D10102: length 269.2
  L17_SIGNAL w0.091: D101.02 308.46,97.64 304.85,97.64 286.92,79.71 156.57,79.71 143.81,92.47 143.81,133.26 131.57,145.49 109.65,145.49 106.55,148.59 106.55,151.43 UNK6K4.7
D10103: length 186.6
  L21_SIGNAL w0.102: D101.03 313.94,95 351.92,95 386.64,129.72 386.64,131.14 394.94,139.45 433.49,139.45 441.16,147.12 455.39,147.12 456.78,148.51 456.78,151.47 457.38,152.06 458.13,152.06 460.76,154.69 469.06,154.69 UNK7K4.7
D10104: length 194.1
  L21_SIGNAL w0.102: D101.04 316.61,100.71 346,100.71 347.03,101.74 349.67,101.74 390.82,142.89 433.38,142.89 468.92,178.43 468.92,183.42 UNK8K4.7
D10105: length 251.2
  L33_SIGNAL w0.091: UNK5K4.2 109.55,183.39 109.55,179 145.96,142.59 168.57,142.59 207.93,103.23 315.01,103.23 316.23,102.01 316.23,97.79 D101.05
D10106: length 279.9
  L17_SIGNAL w0.091: UNK6K4.2 109.47,151.71 109.47,148.49 111.15,146.81 132.12,146.81 145.13,133.8 145.13,92.16 157.02,80.26 286,80.26 309.06,103.32 315.78,103.32 D101.06
D10107: length 189.9
  L17_SIGNAL w0.091: D101.07 324.18,98.12 367.32,98.12 373,103.8 373,122.63 376.91,126.53 425.5,126.53 431.71,132.74 431.71,137.37 439.78,145.44 468.52,145.44 472.1,149.02 472.1,151.65 UNK7K4.2
D10108: length 186.5
  L21_SIGNAL w0.102: D101.08 326.21,100.15 346.35,100.15 347.34,101.14 350.88,101.14 392.09,142.36 433.44,142.36 469.44,178.36 471.07,178.36 472.1,179.39 472.1,183.4 UNK8K4.2
D10109: length 251.8
  L33_SIGNAL w0.091: UNK5K2.7 119.05,183.39 119.05,179.11 153.35,144.81 168.84,144.81 187.59,126.05 188.65,126.05 210.97,103.73 324.51,103.73 326.39,101.85 326.39,97.79 D101.09
D10110: length 280.8
  L17_SIGNAL w0.091: UNK6K2.7 119,151.69 119,147.83 119.46,147.37 132.35,147.37 145.69,134.04 145.69,93.24 156.58,82.35 286.46,82.35 308.83,104.71 326.02,104.71 328.47,102.26 328.47,100.79 D101.10
D10111: length 189.5
  L17_SIGNAL w0.091: UNK7K2.7 481.6,151.65 481.6,148.97 477.71,145.07 439.93,145.07 432.07,137.22 432.07,132.59 425.65,126.17 377.06,126.17 373.37,122.48 373.37,103.26 367.68,97.57 333.79,97.57 D101.11
D10112: length 186.7
  L21_SIGNAL w0.102: UNK8K2.7 481.62,183.42 481.62,179.49 478.77,176.63 470.51,176.63 451.49,157.61 450.28,157.61 433.04,140.36 392.68,140.36 350.27,97.94 336.4,97.94 D101.12
D10113: length 258.6
  L33_SIGNAL w0.091: UNK5K2.2 122.25,183.39 122.25,179.77 154.79,147.23 171.78,147.23 214.9,104.11 334.67,104.11 336.55,102.23 336.55,97.79 D101.13
D10114: length 287.5
  L17_SIGNAL w0.091: D101.14 338.63,100.79 338.63,102.97 336.44,105.17 307.66,105.17 285.29,82.8 156.99,82.8 146.29,93.5 146.29,134.29 132.6,147.98 123.16,147.98 122.43,148.72 122.43,151.46 UNK6K2.2
D10115: length 184.2
  L17_SIGNAL w0.091: UNK7K2.2 484.8,151.65 484.8,149.02 480.49,144.71 440.08,144.71 432.44,137.07 432.44,132.44 425.8,125.8 377.21,125.8 373.74,122.33 373.74,101.93 367.08,95.28 344.14,95.28 D101.15
D10116: length 180.6
  L21_SIGNAL w0.102: D101.16 346.56,99.06 347.75,100.25 350.75,100.25 392.33,141.83 433.55,141.83 449.73,158.01 451.32,158.01 470.39,177.09 478.65,177.09 481.22,179.66 481.22,185.05 482.18,186.01 485.38,186.01 UNK8K2.2
D10201: length 174.9
  L27_SIGNAL w0.076: 232.13,191.08 232.13,189.18 v2(231.81,188.86)
  L27_SIGNAL w0.091: D102.01 305.15,76.2 274.92,106.43 251.21,106.43 249.61,108.02 249.61,126.4 248.81,127.2 248.81,163.95 247.45,165.31 244.03,165.31 240.66,168.67 240.66,174.23 241.89,175.46 242.68,175.46 243.49,176.27 243.49,188.41 239.4,192.5 233.1,192.5 232.13,191.53 232.13,191.08
D10202: length 145.3
  L25_SIGNAL w0.076: 272.13,191.08 272.13,189.18 v2(271.81,188.86)
  L25_SIGNAL w0.091: 272.13,191.08 272.13,191.53 273.1,192.5 279.4,192.5 283.49,188.41 283.49,176.27 282.68,175.46 281.89,175.46 280.66,174.23 280.66,168.67 284.03,165.31 287.45,165.31 288.81,163.95 288.81,125.94 291.65,123.1 291.65,90.84 300.57,81.91 306.7,81.91 D102.02
D10203: length 179
  L31_SIGNAL w0.076: 312.13,191.08 312.13,189.18 v2(311.81,188.86)
  L31_SIGNAL w0.091: 312.13,191.08 312.13,191.53 313.1,192.5 319.4,192.5 323.49,188.41 323.49,176.27 322.68,175.46 321.89,175.46 320.66,174.23 320.66,168.67 324.03,165.31 327.45,165.31 328.81,163.95 328.81,128.48 335.46,121.83 335.46,108.28 338.4,105.34 344.24,105.34 349.25,100.33 349.25,88.9 344.93,84.58 316.99,84.58 313.69,81.28 313.69,77.47 D102.03
D10204: length 216.9
  L15_SIGNAL w0.091: v3(329.43,121.23) 327.53,119.33 327.53,107.7 331.09,104.14 346.4,104.14 349.5,101.03 349.5,85.69 346.62,82.8 319.02,82.8 D102.04
  L29_SIGNAL w0.076: 352.13,191.08 352.13,189.18 v2(351.8,188.86)
  L29_SIGNAL w0.091: 352.13,191.08 352.13,191.53 353.1,192.5 359.4,192.5 363.49,188.41 363.49,176.27 362.68,175.46 361.89,175.46 360.66,174.23 360.66,168.67 364.02,165.31 367.45,165.31 368.81,163.95 368.81,131.95 356.24,119.38 331.29,119.38 v3(329.43,121.23)
D10205: length 186
  L27_SIGNAL w0.076: v2(231.16,188.86) 230.83,189.18 230.83,191.08
  L27_SIGNAL w0.091: D102.05 316.4,77.3 316.4,82.27 315.62,83.05 298.92,83.05 275.04,106.93 251.46,106.93 250.06,108.34 250.06,126.58 249.25,127.39 249.25,166.92 250.17,167.84 250.17,172.24 244.64,177.77 244.64,187.85 238.8,193.7 233.17,193.7 230.83,191.36 230.83,191.08
D10206: length 153.6
  L25_SIGNAL w0.076: v2(271.16,188.86) 270.83,189.18 270.83,191.08
  L25_SIGNAL w0.091: 270.83,191.08 270.83,191.36 273.17,193.7 278.8,193.7 284.64,187.85 284.64,177.77 290.17,172.24 290.17,167.84 289.25,166.92 289.25,126.12 292.09,123.28 292.09,91.02 299.8,83.31 315.47,83.31 D102.06
D10207: length 168.3
  L31_SIGNAL w0.076: 310.83,191.08 310.83,189.18 v2(311.16,188.86)
  L31_SIGNAL w0.091: D102.07 323.85,77.47 323.85,81.79 325.88,83.82 344.8,83.82 349.69,88.72 349.69,100.51 344.43,105.78 338.72,105.78 335.91,108.59 335.91,122.01 329.25,128.67 329.25,166.92 330.17,167.84 330.17,172.24 324.64,177.77 324.64,187.85 318.8,193.7 313.16,193.7 310.83,191.36 310.83,191.08
D10208: length 206.1
  L15_SIGNAL w0.091: D102.08 328.68,82.3 346.83,82.3 349.88,85.35 349.88,101.19 346.56,104.52 331.34,104.52 327.91,107.95 327.91,117.35 329.13,118.56 v3(329.43,118.56)
  L29_SIGNAL w0.076: 350.83,191.08 350.83,189.18 v2(351.15,188.86)
  L29_SIGNAL w0.091: v3(329.43,118.56) 329.62,118.56 331.98,116.2 355.01,116.2 369.25,130.45 369.25,166.92 370.17,167.84 370.17,172.24 364.64,177.77 364.64,187.85 358.8,193.7 353.16,193.7 350.83,191.36 350.83,191.08
D10209: length 201.2
  L27_SIGNAL w0.076: v2(229.21,186.91) 229.53,187.23 229.53,189.9
  L27_SIGNAL w0.091: 229.53,189.9 229.53,192.68 231.2,194.35 233.8,194.35 234.09,194.06 240.02,194.06 245.01,189.07 245.01,179.12 250.58,173.55 250.58,167.68 249.64,166.74 249.64,127.55 250.44,126.75 250.44,108.71 251.71,107.44 275.08,107.44 299.08,83.44 325.29,83.44 326.53,82.2 326.53,77.33 D102.09
D10210: length 168.9
  L25_SIGNAL w0.076: v2(269.2,186.91) 269.53,187.23 269.53,189.9
  L25_SIGNAL w0.091: D102.10 324.61,84.33 299.34,84.33 292.48,91.18 292.48,123.44 289.64,126.28 289.64,166.74 290.58,167.68 290.58,173.55 285.01,179.12 285.01,189.07 280.02,194.06 274.09,194.06 273.8,194.35 271.2,194.35 269.53,192.68 269.53,189.9
D10211: length 164.3
  L31_SIGNAL w0.076: 309.53,189.9 309.53,187.23 v2(309.2,186.91)
  L31_SIGNAL w0.091: D102.11 333.76,77.22 333.76,81.79 335.03,83.06 344.59,83.06 350.08,88.55 350.08,100.68 344.59,106.17 339.09,106.17 336.3,108.97 336.3,122.17 329.64,128.83 329.64,166.74 330.58,167.68 330.58,173.55 325.01,179.12 325.01,189.07 320.02,194.06 314.09,194.06 313.8,194.35 311.2,194.35 309.53,192.68 309.53,189.9
D10212: length 201.6
  L15_SIGNAL w0.091: v3(329.43,117.04) 328.29,115.9 328.29,108.2 331.6,104.9 346.71,104.9 350.27,101.35 350.27,83.17 347.34,80.25 336.79,80.25 D102.12
  L29_SIGNAL w0.076: v2(349.2,186.91) 349.53,187.23 349.53,189.9
  L29_SIGNAL w0.091: 349.53,189.9 349.53,192.68 351.2,194.35 353.8,194.35 354.09,194.06 360.02,194.06 365.01,189.07 365.01,179.12 370.58,173.55 370.58,167.68 369.64,166.74 369.64,130.25 355.22,115.82 330.65,115.82 v3(329.43,117.04)
D10213: length 302.9
  L29_SIGNAL w0.091: D102.13 335.99,74.37 335.99,73.1 334.87,71.98 232.82,71.98 197.71,107.09 194.92,107.09 188.39,113.61 188.39,122.5 163.42,147.47 135.78,147.47 117.4,165.84 104.51,165.84 96.85,173.51 96.85,183.39 UNK5K6.2
D10214: length 293.8
  L29_SIGNAL w0.091: UNK6K6.2 96.77,151.71 96.77,147.83 99.44,145.16 163.2,145.16 184.66,123.7 184.66,112.78 192.15,105.28 197.28,105.28 231.57,70.99 337.19,70.99 339.22,73.03 339.22,77.6 D102.14
D10215: length 157
  L21_SIGNAL w0.102: D102.15 344.17,77.47 344.17,86.44 396.75,139.01 433.7,139.01 439.97,145.29 455.98,145.29 459.4,148.71 459.4,151.65 UNK7K6.2
D10216: length 228.5
  L21_SIGNAL w0.102: D102.16 347.98,81.28 351.03,81.28 385.69,115.94 386.6,115.94 408.18,137.52 456.41,137.52 466.44,147.55 474.09,147.55 475.62,149.07 475.62,168.02 487.55,179.96 487.55,185.55 486.41,186.69 462.69,186.69 UNK8K6.2
D10301: length 180
  L27_SIGNAL w0.091: D103.01 305.72,55.88 280.04,81.56 280.04,97.62 273.6,104.07 249.47,104.07 243.59,109.95 243.59,127.88 239.26,132.21 239.26,142.12 241.48,144.33 241.48,163.65 238.42,166.71 238.42,176.84 239.58,177.99 239.58,185.1 237.23,187.44 235.82,187.44 v2(235.71,187.56)
D10302: length 146.9
  L25_SIGNAL w0.091: D103.02 289.35,78.95 289.35,118.83 279.26,128.92 279.26,142.12 281.48,144.33 281.48,163.66 278.42,166.71 278.42,176.84 279.58,177.99 279.58,185.1 277.23,187.44 275.82,187.44 v2(275.71,187.56)
D10303: length 159.2
  L31_SIGNAL w0.091: v2(315.7,187.56) 315.82,187.44 317.23,187.44 319.58,185.1 319.58,177.99 318.42,176.84 318.42,166.46 321.48,163.41 321.48,144.33 319.26,142.12 319.26,140.22 324.61,134.87 324.61,124.46 323.34,123.19 323.34,108.2 319.71,104.57 308.03,104.57 302.41,98.96 302.41,70.54 311.25,61.7 311.25,57.05 D103.03
D10304: length 218
  L15_SIGNAL w0.091: D103.04 319.02,62.48 349.03,62.48 350.65,64.1 350.65,101.51 346.87,105.28 331.97,105.28 330.71,106.54 330.71,123.47 330.47,123.71 327.61,123.71 325.14,121.23 v3(325.12,121.23)
  L29_SIGNAL w0.091: v2(355.7,187.56) 355.82,187.44 357.23,187.44 359.58,185.1 359.58,177.99 358.42,176.84 358.42,167.23 361.48,164.17 361.48,144.33 359.26,142.12 359.26,140.97 357.06,138.77 357.06,134.56 346.96,124.46 327.91,124.46 326.77,123.32 326.77,122.55 325.45,121.23 v3(325.12,121.23)
D10305: length 193.1
  L27_SIGNAL w0.076: 235.9,187.88 235.38,187.88 v2(235.06,187.56)
  L27_SIGNAL w0.091: 235.9,187.88 238.13,187.88 240.54,185.47 240.54,178.23 238.83,176.52 238.83,168.27 243.64,163.45 243.64,159.47 243.05,158.88 243.05,129.31 244.83,127.54 244.83,109.43 249.74,104.52 273.91,104.52 280.63,97.8 280.63,81.7 300.18,62.15 315.38,62.15 316.19,61.33 316.19,57.19 D103.05
D10306: length 157.4
  L25_SIGNAL w0.076: v2(275.06,187.56) 275.38,187.88 275.9,187.88
  L25_SIGNAL w0.091: D103.06 316.36,62.1 307.09,62.1 289.77,79.42 289.77,119.17 283.05,125.89 283.05,158.88 283.64,159.47 283.64,163.45 278.83,168.27 278.83,176.52 280.54,178.23 280.54,185.47 278.13,187.88 275.9,187.88
D10307: length 168.7
  L31_SIGNAL w0.076: v2(315.05,187.56) 315.38,187.88 315.9,187.88
  L31_SIGNAL w0.091: D103.07 321.31,57.15 321.31,61.7 320.27,62.74 312.32,62.74 302.92,72.14 302.92,98.83 308.1,104.01 319.79,104.01 323.76,107.99 323.76,123.02 324.98,124.23 324.98,136.29 323.05,138.21 323.05,158.88 323.64,159.47 323.64,163.45 318.83,168.27 318.83,176.52 320.54,178.23 320.54,185.47 318.13,187.88 315.9,187.88
D10308: length 222.7
  L15_SIGNAL w0.091: v3(325.12,118.56) 324.36,119.32 324.36,123.44 325.01,124.09 330.62,124.09 331.09,123.63 331.09,106.68 332.1,105.66 347.03,105.66 351.03,101.67 351.03,63.76 349.25,61.98 328.68,61.98 D103.08
  L29_SIGNAL w0.076: v2(355.05,187.56) 355.38,187.88 355.9,187.88
  L29_SIGNAL w0.091: v3(325.12,118.56) 325.7,118.56 327.66,120.52 327.66,123.06 328.55,123.95 350.39,123.95 363.05,136.61 363.05,158.88 363.64,159.47 363.64,163.45 358.83,168.27 358.83,176.52 360.54,178.23 360.54,185.47 358.13,187.88 355.9,187.88
D10309: length 204.3
  L27_SIGNAL w0.076: v2(235.06,188.86) 235.38,188.53 236.07,188.53
  L27_SIGNAL w0.091: D103.09 326.4,57.14 326.4,61.44 325.25,62.59 300.44,62.59 281.18,81.84 281.18,97.86 274.05,104.99 249.93,104.99 245.37,109.55 245.37,127.76 243.42,129.7 243.42,158.55 244.04,159.17 244.04,163.61 239.24,168.41 239.24,175.55 240.98,177.29 240.98,187.01 239.46,188.53 236.07,188.53
D10310: length 168.3
  L25_SIGNAL w0.076: v2(275.06,188.86) 275.38,188.53 276.07,188.53
  L25_SIGNAL w0.091: 276.07,188.53 279.46,188.53 280.98,187.01 280.98,177.29 279.24,175.55 279.24,168.41 284.04,163.61 284.04,159.17 283.42,158.55 283.42,126.28 290.19,119.51 290.19,80.14 307.61,62.71 325.91,62.71 D103.10
D10311: length 179
  L31_SIGNAL w0.076: v2(315.05,188.86) 315.38,188.53 316.07,188.53
  L31_SIGNAL w0.091: D103.11 331.47,57.15 331.47,61.75 329.11,64.11 313.18,64.11 303.43,73.86 303.43,98.7 308.23,103.5 319.91,103.5 324.18,107.77 324.18,122.84 325.37,124.04 325.37,136.41 323.42,138.36 323.42,158.55 324.04,159.17 324.04,163.61 319.24,168.41 319.24,175.55 320.98,177.29 320.98,187.01 319.46,188.53 316.07,188.53
D10312: length 219.8
  L15_SIGNAL w0.091: v3(325.12,117.04) 325.1,117.04 323.99,118.14 323.99,123.62 324.85,124.48 330.78,124.48 331.47,123.78 331.47,106.88 332.29,106.06 347.19,106.06 351.42,101.83 351.42,62.13 349.23,59.93 336.79,59.93 D103.12
  L29_SIGNAL w0.076: v2(355.05,188.86) 355.38,188.53 356.07,188.53
  L29_SIGNAL w0.091: v3(325.12,117.04) 325.32,117.04 328.42,120.14 328.42,122.94 328.93,123.44 350.52,123.44 363.42,136.35 363.42,158.55 364.04,159.17 364.04,163.61 359.24,168.41 359.24,175.55 360.98,177.29 360.98,187.01 359.46,188.53 356.07,188.53
D10313: length 224.9
  L27_SIGNAL w0.076: v2(234.41,188.21) 234.08,188.53 234.08,190.08
  L27_SIGNAL w0.508: 234.08,190.08 234.08,190.94 235.01,191.87 238.34,191.87 242.72,187.49 242.72,176.71 242.34,176.32 241.34,176.32 239.89,174.88 239.89,168.6 243.83,164.66 245.65,164.66 246.34,163.97 246.34,158.55 245.12,157.33 245.12,155.37 245.69,154.81 245.69,151.69 245.18,151.18 245.18,129.47 248.67,125.98 248.67,107.95 250.95,105.66 274.32,105.66 282.45,97.54 282.45,82.3 300.03,64.72 336.09,64.72 336.6,64.21 336.6,57.1 D103.13
D10314: length 187.9
  L25_SIGNAL w0.076: v2(274.41,188.21) 274.08,188.53 274.08,190.08
  L25_SIGNAL w0.508: 274.08,190.08 274.08,190.94 275.01,191.87 278.34,191.87 282.72,187.49 282.72,176.71 282.34,176.32 281.34,176.32 279.89,174.88 279.89,168.6 283.83,164.66 285.65,164.66 286.34,163.97 286.34,158.55 285.12,157.33 285.12,155.37 285.69,154.81 285.69,151.69 285.17,151.18 285.17,126.05 290.96,120.27 290.96,80.77 308.1,63.63 335.15,63.63 D103.14
D10315: length 201.8
  L31_SIGNAL w0.076: v2(314.41,188.21) 314.08,188.53 314.08,190.08
  L31_SIGNAL w0.508: 314.08,190.08 314.08,190.94 315.01,191.87 318.34,191.87 322.72,187.49 322.72,176.71 322.34,176.32 321.34,176.32 319.89,174.88 319.89,168.6 323.83,164.66 325.65,164.66 326.34,163.97 326.34,158.55 325.12,157.33 325.12,155.37 325.69,154.81 325.69,151.69 325.17,151.18 325.17,138.38 327.41,136.14 327.41,108.2 322.13,102.93 308.92,102.93 304,98.01 304,74.46 312.67,65.79 339.34,65.79 341.63,63.5 341.63,57.15 D103.15
D10316: length 223.1
  L19_SIGNAL w0.102: D103.16 346.58,59.56 349.38,59.56 351.79,61.98 351.79,97.4 345.05,104.14 325.88,104.14 322.07,107.95 322.07,113.92 319.15,116.84 319.15,122.33 320.65,123.82 328.36,123.82 v3(329.43,122.76)
  L29_SIGNAL w0.076: 354.08,190.08 354.08,188.53 v2(354.4,188.21)
  L29_SIGNAL w0.508: v3(329.43,122.76) 330.38,122.76 332.87,120.27 356.11,120.27 365.17,129.34 365.17,151.18 365.69,151.69 365.69,154.81 365.12,155.37 365.12,157.33 366.34,158.55 366.34,163.97 365.65,164.66 363.83,164.66 359.89,168.6 359.89,174.88 361.34,176.32 362.34,176.32 362.72,176.71 362.72,187.49 358.34,191.87 355.01,191.87 354.08,190.94 354.08,190.08
D10401: length 202.1
  L27_SIGNAL w0.091: D104.01 277.45,65.45 277.45,80.45 268.36,89.54 236.64,89.54 228.63,97.56 228.63,123.73 235.48,130.58 235.48,147.46 237.04,149.02 237.04,153.72 238.83,155.51 238.83,163.62 235.21,167.24 235.21,178.94 235.5,179.24 235.5,179.96 v2(235.06,180.41)
D10402: length 160.2
  L25_SIGNAL w0.091: D104.02 309.07,38.1 287.53,59.64 287.53,117.22 275.48,129.27 275.48,147.46 277.04,149.02 277.04,153.72 278.83,155.51 278.83,163.62 275.21,167.24 275.21,178.94 275.5,179.24 275.5,179.96 v2(275.06,180.41)
D10403: length 166.6
  L31_SIGNAL w0.091: D104.03 311.15,36.83 306.53,36.83 300.38,42.98 300.38,99.47 307.47,106.55 313.18,106.55 315.34,108.71 315.34,122.94 317.06,124.66 317.06,137 315.48,138.59 315.48,147.46 317.04,149.02 317.04,153.72 318.83,155.51 318.83,163.62 315.21,167.24 315.21,178.94 315.5,179.24 315.5,179.96 v2(315.05,180.41)
D10404: length 229.2
  L19_SIGNAL w0.102: v3(320.8,121.23) 319.79,120.22 319.79,116.84 322.71,113.92 322.71,107.96 325.89,104.77 345.32,104.77 352.42,97.67 352.42,45.55 349.03,42.16 319.02,42.16 D104.04
  L29_SIGNAL w0.091: v3(320.8,121.23) 321.26,121.23 326.52,126.49 344.75,126.49 352.43,134.17 352.43,144.15 357.04,148.76 357.04,153.72 358.83,155.51 358.83,163.62 355.21,167.24 355.21,178.94 355.5,179.24 355.5,179.96 v2(355.05,180.41)
D10405: length 207.5
  L27_SIGNAL w0.076: 235.83,184.31 v2(235.06,184.31)
  L27_SIGNAL w0.091: 235.83,184.31 236.32,183.81 236.32,179.13 235.84,178.65 235.84,176.92 236.17,176.58 236.17,166.92 239.2,163.9 239.2,155.37 237.4,153.57 237.4,148.86 235.85,147.3 235.85,131.36 240.93,126.28 240.93,108.04 246.29,102.69 273,102.69 278.27,97.42 278.27,67.41 306.4,39.28 315.55,39.28 316.23,38.61 316.23,36.83 D104.05
D10406: length 174.4
  L25_SIGNAL w0.076: 275.83,184.31 v2(275.06,184.31)
  L25_SIGNAL w0.091: 275.83,184.31 276.32,183.81 276.32,179.13 275.84,178.65 275.84,176.92 276.17,176.58 276.17,166.92 279.2,163.9 279.2,155.37 277.4,153.57 277.4,148.86 275.85,147.3 275.85,132.71 276.54,132.02 276.54,128.97 287.91,117.6 287.91,60.1 308.64,39.37 318.77,39.37 D104.06
D10407: length 188.4
  L31_SIGNAL w0.076: v2(315.05,184.31) 315.83,184.31
  L31_SIGNAL w0.091: D104.07 321.31,36.83 321.31,38.35 320.29,39.37 306.73,39.37 300.89,45.21 300.89,99.34 307.59,106.05 319.28,106.05 321.82,108.58 321.82,129.85 319.28,132.39 319.28,136.65 318.01,137.92 316.66,137.92 315.85,138.74 315.85,147.3 317.4,148.86 317.4,153.57 319.2,155.37 319.2,163.9 316.17,166.92 316.17,176.58 315.84,176.92 315.84,178.65 316.32,179.13 316.32,183.81 315.83,184.31
D10408: length 224.1
  L19_SIGNAL w0.102: D104.08 328.68,41.66 349.25,41.66 352.93,45.34 352.93,97.88 345.53,105.28 326.23,105.28 323.21,108.3 323.21,116.18 320.83,118.56 v3(320.8,118.56)
  L29_SIGNAL w0.076: 355.83,184.31 v2(355.05,184.31)
  L29_SIGNAL w0.091: 355.83,184.31 356.32,183.81 356.32,179.13 355.84,178.65 355.84,176.92 356.17,176.58 356.17,166.92 359.2,163.9 359.2,155.37 357.4,153.57 357.4,147.85 355.85,146.3 355.85,145.8 352.86,142.81 352.86,134 344.93,126.07 326.85,126.07 323.34,122.55 323.34,120.02 321.89,118.56 v3(320.8,118.56)
D10409: length 220.2
  L27_SIGNAL w0.076: 235.48,185.28 234.08,185.28 v2(233.76,184.96)
  L27_SIGNAL w0.091: D104.09 326.46,36.76 326.46,40.79 325.42,41.84 306.36,41.84 278.88,69.32 278.88,97.41 273.14,103.15 246.55,103.15 241.42,108.29 241.42,127.52 236.31,132.63 236.31,141.68 238.79,144.17 238.79,154.36 239.58,155.14 239.58,164.15 236.58,167.16 236.58,176.77 236.32,177.03 236.32,178.18 237.49,179.35 237.49,183.27 235.48,185.28
D10410: length 186.7
  L25_SIGNAL w0.076: 275.48,185.28 274.08,185.28 v2(273.76,184.96)
  L25_SIGNAL w0.091: D104.10 326.39,41.91 307.01,41.91 288.42,60.5 288.42,117.86 277.3,128.97 277.3,132.1 276.31,133.1 276.31,141.68 278.79,144.17 278.79,154.36 279.58,155.14 279.58,164.16 276.58,167.16 276.58,176.77 276.32,177.03 276.32,178.18 277.49,179.35 277.49,183.27 275.48,185.28
D10411: length 199.9
  L31_SIGNAL w0.076: v2(313.76,184.96) 314.08,185.28 315.48,185.28
  L31_SIGNAL w0.091: 315.48,185.28 317.49,183.27 317.49,179.35 316.32,178.18 316.32,177.03 316.58,176.77 316.58,167.04 319.58,164.04 319.58,155.14 318.79,154.36 318.79,144.17 317.5,142.87 317.5,140.53 322.83,135.2 322.83,125.28 322.24,124.68 322.24,108.37 319.46,105.59 307.77,105.59 301.4,99.21 301.4,47.32 306.81,41.91 330.45,41.91 331.47,40.89 331.47,36.83 D104.11
D10412: length 224.6
  L19_SIGNAL w0.102: v3(320.8,117.04) 320.77,117.04 320.19,117.62 320.19,118.75 320.7,119.25 322.33,119.25 323.71,117.87 323.71,108.5 326.43,105.78 345.73,105.78 353.43,98.08 353.43,43.81 349.24,39.62 336.8,39.62 D104.12
  L29_SIGNAL w0.076: 355.48,185.28 354.08,185.28 v2(353.75,184.96)
  L29_SIGNAL w0.091: 355.48,185.28 357.49,183.27 357.49,179.35 356.32,178.18 356.32,177.03 356.58,176.77 356.58,167.42 359.58,164.42 359.58,155.14 358.79,154.36 358.79,144.17 355.14,140.52 355.14,134.8 345.82,125.48 326.9,125.48 324.49,123.06 324.49,120.27 321.26,117.04 v3(320.8,117.04)
D10413: length 232.5
  L27_SIGNAL w0.091: D104.13 336.56,36.82 336.56,43.62 335.79,44.4 306.3,44.4 279.49,71.21 279.49,97.48 273.35,103.62 246.83,103.62 241.9,108.55 241.9,127.67 237.14,132.43 237.14,141.34 241.01,145.21 241.01,163.36 237.32,167.04 237.32,176.46 239.17,178.31 239.17,184.63 236.9,186.91 v2(235.06,186.91)
D10414: length 201.2
  L25_SIGNAL w0.091: v2(275.06,186.91) 276.9,186.91 279.17,184.63 279.17,178.31 277.32,176.46 277.32,167.05 281.01,163.36 281.01,145.21 277.14,141.34 277.14,133.1 278.62,131.62 278.62,128.5 288.86,118.26 288.86,60.92 305.33,44.45 338.58,44.45 339.09,43.94 339.09,39.37 D104.14
D10415: length 212.5
  L31_SIGNAL w0.091: D104.15 341.63,36.83 341.63,43.18 340.36,44.45 306.83,44.45 301.9,49.38 301.9,99.09 307.9,105.08 319.58,105.08 322.83,108.33 322.83,123.7 323.6,124.46 323.6,135.02 317.9,140.72 317.9,142.1 321.01,145.21 321.01,163.24 317.32,166.93 317.32,176.46 319.17,178.31 319.17,184.63 316.9,186.91 v2(315.05,186.91)
D10416: length 209
  L19_SIGNAL w0.102: D104.16 346.46,39.12 349.5,39.12 353.95,43.56 353.95,98.3 345.95,106.3 326.65,106.3 324.23,108.72 324.23,121.9 325.09,122.76 v3(325.12,122.76)
  L29_SIGNAL w0.091: v2(355.05,186.91) 356.9,186.91 359.17,184.63 359.17,178.31 357.32,176.46 357.32,167.76 361.01,164.08 361.01,145.21 356.54,140.74 356.54,135.56 345.95,124.97 327.33,124.97 v3(325.12,122.76)
D10501: length 340.1
  L31_SIGNAL w0.079: v3(229.87,114.37) 230.18,114.37 230.89,113.66 231.17,113.66 231.5,113.34 231.5,112.66 230.7,111.86 229.16,111.86 216.47,124.55 216.47,150.43 219.01,152.97 219.01,161.26 219.62,161.88 219.62,166.96 220.9,168.23 220.9,181.15 220.17,181.88 212.43,181.88 211.51,180.96 211.51,179.8
  L31_SIGNAL w0.091: v1(211.66,179.65) 211.51,179.8
  L33_SIGNAL w0.079: 383.44,94.08 383.44,92.75 382.5,91.82 379.6,91.82 377.13,89.35 363.99,89.35 362.91,90.43 362.91,92.7 363.67,93.47 376.57,93.47 377.64,94.53 377.64,97.93 376.5,99.07 353.99,99.07 353.32,99.74 353.32,100.92 354.06,101.66 371.84,101.66 372.62,102.45 372.62,105.91 371.56,106.97 233.27,106.97 232.54,107.7 232.54,112.14 231,113.67 230.61,113.67 230.54,113.74
  L33_SIGNAL w0.091: 383.44,94.08 D105.01 ; v3(229.87,114.37) 229.91,114.37 230.54,113.74
D10502: length 285.6
  L29_SIGNAL w0.079: 251.51,179.8 251.51,180.96 252.43,181.88 260.17,181.88 260.9,181.15 260.9,168.23 259.62,166.96 259.62,161.88 259.01,161.26 259.01,152.97 256.47,150.43 256.47,144.93 249.17,137.62 249.17,136.39 237.3,124.52 237.3,108.03 230.5,101.24 230.5,94.07 233.58,90.99 369.49,90.99 370.59,92.09 370.59,95.15 371.4,95.96 374.72,95.96 375.67,95.02 375.67,93.95 376.09,93.53 378.26,93.53 378.71,93.99 378.71,99.95 379.27,100.51 379.38,100.51 379.39,100.5 379.5,100.5 379.61,100.61 379.61,100.72 379.61,100.73 379.61,100.84 379.72,100.95 379.83,100.95 379.84,100.95 379.95,100.95 380.06,101.06 380.06,101.17 380.05,101.18 380.05,101.29 380.16,101.4 380.28,101.4 380.28,101.39 380.39,101.39 380.51,101.5 380.51,101.61 380.5,101.62 380.5,101.73 380.61,101.84 380.72,101.84 380.73,101.84 380.84,101.84 380.95,101.95 380.95,102.06 380.94,102.07 380.94,102.18 381.38,102.62 385.55,102.62 386.02,102.15 386.02,101.54
  L29_SIGNAL w0.091: 386.02,101.54 D105.02 ; v1(251.66,179.65) 251.51,179.8
D10503: length 340.1
  L31_SIGNAL w0.079: v3(229.87,112.85) 230.26,112.85 230.89,113.47 231.09,113.47 231.3,113.26 231.3,112.74 230.62,112.05 229.24,112.05 216.66,124.63 216.66,150.35 219.2,152.89 219.2,161.18 219.82,161.8 219.82,166.88 221.09,168.15 221.09,181.23 220.25,182.07 212.35,182.07 211.31,181.04 211.31,179.8
  L31_SIGNAL w0.091: v1(211.16,179.65) 211.31,179.8
  L33_SIGNAL w0.079: 383.63,94.07 383.63,92.67 382.58,91.63 382.16,91.63 382.07,91.54 381.84,91.54 381.76,91.63 379.68,91.63 377.21,89.15 363.91,89.15 362.71,90.35 362.71,92.78 363.59,93.66 376.49,93.66 377.44,94.61 377.44,97.85 376.42,98.87 353.91,98.87 353.13,99.66 353.13,101 353.98,101.85 371.76,101.85 372.43,102.53 372.43,105.83 371.48,106.78 233.19,106.78 232.34,107.62 232.34,112.06 230.92,113.48 230.55,113.48
  L33_SIGNAL w0.091: 230.55,113.48 229.92,112.85 v3(229.87,112.85) ; 383.63,94.07 D105.03
D10504: length 285.6
  L29_SIGNAL w0.079: 386.22,101.46 386.22,102.23 385.63,102.81 381.3,102.81 378.52,100.03 378.52,94.07 378.18,93.73 376.17,93.73 375.86,94.03 375.86,95.1 374.8,96.16 371.32,96.16 370.39,95.23 370.39,92.17 369.41,91.19 233.66,91.19 230.7,94.15 230.7,101.16 237.49,107.95 237.49,124.44 249.36,136.31 249.36,137.54 255.73,143.91 256.66,144.85 256.66,150.35 259.2,152.89 259.2,161.18 259.82,161.8 259.82,166.88 261.09,168.15 261.09,181.23 260.25,182.07 252.35,182.07 251.31,181.04 251.31,179.8
  L29_SIGNAL w0.091: 386.22,101.46 D105.04 ; v1(251.16,179.65) 251.31,179.8
D10505: length 304.3
  L27_SIGNAL w0.079: 291.51,179.8 291.51,180.96 292.43,181.88 300.17,181.88 300.9,181.15 300.9,168.23 299.62,166.96 299.62,161.88 299.01,161.26 299.01,153.23 295.81,150.03 283.44,150.03 282.27,151.2 277.68,151.2 275.76,149.29 273.42,149.29 272.52,148.39 272.52,145.5 273.81,144.21 275.79,144.21 276.59,145.01 294.93,145.01 296.97,142.98 296.97,138.63 294.2,135.85 283.43,135.85 282.38,136.91 279.56,136.91 278.5,135.85 271.87,135.85 271.11,135.09 271.11,133.72 272.1,132.73 293.84,132.73 296.28,130.29 296.28,123.14 289.02,115.88 289.02,107.56 303.94,92.64 371.3,92.64 374.64,95.98 374.75,95.98 374.82,95.91 374.94,95.91 375.05,96.02 375.05,96.13 374.97,96.2 374.97,96.32 375.08,96.43 375.2,96.43 375.27,96.35 375.38,96.35 375.49,96.46 375.49,96.58 375.42,96.65 375.42,96.76 375.53,96.87 375.64,96.87 375.72,96.8 375.83,96.8 375.94,96.91 375.94,97.02 375.86,97.09 375.86,97.21 375.98,97.32 376.09,97.32 376.16,97.24 376.27,97.24 376.38,97.36 376.38,97.47 376.31,97.54 376.31,97.65 376.42,97.76 376.53,97.76 376.61,97.69 376.72,97.69 376.83,97.8 376.83,97.91 376.76,97.99 376.76,98.1 376.87,98.21 376.98,98.21 377.05,98.13 377.16,98.13 377.27,98.25 377.27,98.36 377.2,98.43 377.2,98.54 377.31,98.65 377.42,98.65 377.5,98.58 377.61,98.58 377.72,98.69 377.72,98.8 377.65,98.88 377.65,98.99 377.76,99.1 377.87,99.1 377.94,99.03 378.05,99.03 378.17,99.14 378.17,99.25 378.09,99.32 378.09,99.43 378.9,100.24 392.09,100.24 392.33,100.01 392.33,98.57 392.33,98.41 392.33,98.4 392.33,98.39
  L27_SIGNAL w0.091: D105.05 392.33,97.69 392.33,98.39 ; v1(291.66,179.65) 291.51,179.8
D10506: length 342.5
  L25_SIGNAL w0.079: 397.41,101.07 397.41,103.33 398.68,104.59 421.85,104.59 423.85,106.6 423.85,109.91 421.71,112.05 375.71,112.05 374.37,113.39 374.37,117.85 375.88,119.36 417.49,119.36 418.76,120.63 418.76,123.44 417.53,124.68 366.89,124.68 365.6,123.39 365.6,108.02 363.73,106.16 359.68,106.16 358.23,107.61 358.23,126.57 357.44,127.36 354.64,127.36 353.76,126.48 353.76,116.87 352.96,116.07 349.98,116.07 348.95,117.11 348.95,126.11 335.59,139.46 335.59,149.56 339.01,152.97 339.01,161.26 339.62,161.88 339.62,166.96 340.9,168.23 340.9,181.15 340.17,181.88 332.43,181.88 331.51,180.96 331.51,179.8
  L25_SIGNAL w0.091: D105.06 394.97,100.33 396.68,100.33 397.41,101.07 ; v1(331.66,179.65) 331.51,179.8
D10507: length 304.3
  L27_SIGNAL w0.079: 392.53,98.49 392.53,100.08 392.17,100.43 378.82,100.43 371.22,92.84 304.02,92.84 289.21,107.64 289.21,115.8 296.47,123.06 296.47,130.37 293.92,132.93 272.18,132.93 271.31,133.8 271.31,135.01 271.95,135.66 278.58,135.66 279.64,136.71 282.3,136.71 283.35,135.66 294.28,135.66 297.16,138.55 297.16,143.06 295.01,145.21 276.51,145.21 275.71,144.4 273.89,144.4 272.71,145.58 272.71,148.31 273.5,149.1 275.84,149.1 277.76,151.01 282.19,151.01 283.36,149.84 295.89,149.84 299.2,153.15 299.2,161.18 299.82,161.8 299.82,166.88 301.09,168.15 301.09,181.23 300.25,182.07 292.35,182.07 291.31,181.04 291.31,179.8
  L27_SIGNAL w0.091: D105.07 395.07,97.69 393.32,97.69 392.53,98.49 ; v1(291.16,179.65) 291.31,179.8
D10508: length 342.5
  L25_SIGNAL w0.079: 397.61,100.23 397.61,103.25 398.76,104.4 401.18,104.4 401.26,104.32 401.26,104.21 401.34,104.13 401.5,104.13 401.57,104.21 401.57,104.32 401.65,104.4 401.81,104.4 401.89,104.32 401.89,104.21 401.97,104.13 402.12,104.13 402.2,104.21 402.2,104.32 402.28,104.4 402.44,104.4 402.52,104.32 402.52,104.21 402.6,104.13 402.75,104.13 402.83,104.21 402.83,104.32 402.91,104.4 403.07,104.4 403.15,104.32 403.15,104.21 403.23,104.13 403.38,104.13 403.46,104.21 403.46,104.32 403.54,104.4 421.93,104.4 424.05,106.52 424.05,109.99 421.79,112.24 375.79,112.24 374.57,113.47 374.57,117.77 375.96,119.17 417.57,119.17 418.96,120.55 418.96,123.52 417.61,124.87 366.81,124.87 365.4,123.47 365.4,108.1 363.65,106.35 359.76,106.35 358.42,107.69 358.42,126.65 357.52,127.55 354.56,127.55 353.56,126.56 353.56,116.95 352.88,116.27 350.06,116.27 349.14,117.19 349.14,126.19 335.79,139.54 335.79,149.48 339.2,152.89 339.2,161.18 339.82,161.8 339.82,166.88 341.09,168.15 341.09,181.23 340.25,182.07 332.35,182.07 331.31,181.04 331.31,179.8
  L25_SIGNAL w0.091: v1(331.16,179.65) 331.31,179.8 ; 397.61,100.23 D105.08
D10509: length 340.1
  L31_SIGNAL w0.079: 211.51,178 211.51,177.59 209.9,175.98 209.9,174.17 211,173.07 211,167.42 214.43,164 214.43,141.72 213.1,140.4 213.1,123.29 226.87,109.52 228.99,109.52 229.65,110.18 v3(229.87,110.18)
  L31_SIGNAL w0.091: 211.51,178 UNK5U409.E8 v1(212.16,178.15)
  L33_SIGNAL w0.079: 230.76,109.47 231.46,109.47 231.71,109.22 231.71,107.36 232.92,106.15 370.51,106.15 371.38,105.27 371.38,103.36 370.59,102.56 353.79,102.56 352.49,101.27 352.49,99.39 353.65,98.24 372.44,98.24 373.37,97.31 373.37,95.22 372.44,94.29 362.32,94.29 361.53,93.51 361.53,90.33 363.47,88.39 400.02,88.39 402.31,90.67 402.31,90.78 402.28,90.81 402.28,90.92 402.39,91.03 402.5,91.03 402.53,91.01 402.64,91.01 402.75,91.12 402.75,91.23 402.72,91.26 402.72,91.37 402.84,91.48 402.95,91.48 402.97,91.45 403.08,91.45 403.2,91.56 403.2,91.67 403.17,91.7 403.17,91.81 403.28,91.92 403.39,91.92 403.42,91.9 403.53,91.9 403.76,92.13 403.76,94.08
  L33_SIGNAL w0.091: v3(229.87,110.18) 230.05,110.18 230.76,109.47 ; D105.09 403.76,94.08
  BOTTOM w0.16: UNK5U409.E8 v1(212.16,178.15)
D10510: length 285.6
  L29_SIGNAL w0.079: 405.03,97.03 405.03,94.66 403.74,93.37 403.63,93.37 403.52,93.48 403.41,93.48 403.3,93.37 403.3,93.26 403.41,93.15 403.41,93.04 403.3,92.93 403.19,92.93 403.08,93.04 402.96,93.04 402.85,92.93 402.85,92.82 402.96,92.71 402.96,92.59 402.85,92.48 402.74,92.48 402.63,92.59 402.52,92.59 402.41,92.48 402.41,92.37 402.52,92.26 402.52,92.15 402.41,92.04 402.3,92.04 402.18,92.15 402.07,92.15 401.96,92.04 401.96,91.92 402.07,91.81 402.07,91.7 401.96,91.59 401.85,91.59 401.74,91.7 401.63,91.7 401.52,91.59 401.52,91.48 401.63,91.37 401.63,91.26 401.52,91.15 401.4,91.15 401.29,91.26 401.18,91.26 401.07,91.14 401.07,91.03 401.18,90.92 401.18,90.81 400.28,89.92 232.62,89.92 229.28,93.25 229.28,102.02 235.71,108.46 235.71,124.59 246.88,135.76 246.88,137.92 254.43,145.46 254.43,164 251,167.42 251,173.07 249.9,174.17 249.9,175.98 251.51,177.59 251.51,178
  L29_SIGNAL w0.091: 405.03,97.03 405.03,97.89 D105.10 ; v1(252.16,178.15) UNK6U409.E8 251.51,178
  BOTTOM w0.16: UNK6U409.E8 v1(252.16,178.15)
D10511: length 340.1
  L31_SIGNAL w0.079: v3(229.87,108.66) 229.66,108.66 228.99,109.33 226.79,109.33 212.91,123.21 212.91,140.48 214.24,141.8 214.24,163.92 210.81,167.34 210.81,172.99 209.71,174.09 209.71,176.06 211.31,177.67 211.31,178
  L31_SIGNAL w0.091: v1(210.66,178.15) UNK5U409.E9 211.31,178
  L33_SIGNAL w0.079: 403.95,94.07 403.95,92.05 400.1,88.2 363.39,88.2 361.34,90.25 361.34,93.59 362.24,94.49 372.36,94.49 373.18,95.3 373.18,97.23 372.36,98.04 353.57,98.04 352.3,99.31 352.3,101.35 353.71,102.75 370.51,102.75 371.19,103.44 371.19,105.19 370.43,105.95 232.84,105.95 231.52,107.28 231.52,109.14 231.38,109.28 230.76,109.28
  L33_SIGNAL w0.091: D105.11 403.95,94.07 ; 230.76,109.28 230.14,108.66 v3(229.87,108.66)
  BOTTOM w0.16: UNK5U409.E9 v1(210.66,178.15)
D10512: length 285.6
  L29_SIGNAL w0.079: 251.31,178 251.31,177.67 249.71,176.06 249.71,174.09 250.81,172.99 250.81,167.34 254.24,163.92 254.24,145.54 246.69,138 246.69,135.84 235.52,124.67 235.52,108.54 229.09,102.1 229.09,93.17 232.54,89.72 400.36,89.72 405.23,94.58 405.23,97 405.26,97.03
  L29_SIGNAL w0.091: 251.31,178 UNK6U409.E9 v1(250.66,178.15) ; D105.12 407.8,97.92 406.15,97.92 405.26,97.03
  BOTTOM w0.16: UNK6U409.E9 v1(250.66,178.15)
D10513: length 304.3
  L27_SIGNAL w0.079: 291.51,178 291.51,177.59 289.9,175.98 289.9,174.17 291,173.07 291,167.42 294.43,164 294.43,153.16 293.48,152.21 289.88,152.21 288.67,153.42 276.06,153.42 274.2,151.56 272.23,151.56 271.21,150.55 271.21,143.7 272.91,142.01 275.61,142.01 277.52,143.92 291.16,143.92 292.13,142.94 292.13,139.82 291.25,138.94 272.57,138.94 270.14,136.51 270.14,133.47 271.97,131.64 293.38,131.64 294.53,130.5 294.53,122.93 288.03,116.44 288.03,107.28 305.78,89.53 410.27,89.53 412.6,91.87 412.6,91.98 412.54,92.05 412.54,92.16 412.65,92.27 412.76,92.27 412.83,92.2 412.94,92.2 413.05,92.32 413.05,92.43 412.98,92.49 412.98,92.6 413.09,92.72 413.2,92.72 413.27,92.65 413.38,92.65 413.92,93.19 413.92,94.08
  L27_SIGNAL w0.091: D105.13 413.92,94.08 ; v1(292.16,178.15) UNK7U409.E8 291.51,178
  BOTTOM w0.16: UNK7U409.E8 v1(292.16,178.15)
D10514: length 342.5
  L25_SIGNAL w0.079: 415.19,97.89 415.19,95.5 414.75,95.06 414.64,95.06 414.5,95.2 414.39,95.2 414.28,95.09 414.28,94.98 414.42,94.84 414.42,94.72 414.31,94.61 414.2,94.61 414.05,94.76 413.94,94.76 413.83,94.65 413.83,94.53 413.98,94.39 413.98,94.28 413.86,94.17 413.75,94.17 413.61,94.31 413.5,94.31 413.38,94.2 413.38,94.09 413.53,93.94 413.53,93.83 413.42,93.72 413.31,93.72 413.16,93.87 413.05,93.87 412.94,93.75 412.94,93.64 413.08,93.5 413.08,93.39 412.97,93.28 412.86,93.28 412.72,93.42 412.61,93.42 412.49,93.31 412.49,93.2 412.64,93.05 412.64,92.94 412.28,92.58 378.48,92.58 374.41,96.66 374.41,105.5 375.77,106.86 412.83,106.86 413.66,107.68 413.66,110.47 412.87,111.26 375.38,111.26 373.58,113.06 373.58,118.18 375.67,120.26 399.16,120.26 400.06,121.17 400.06,123.06 399.23,123.89 367.21,123.89 366.39,123.06 366.39,107.24 364.38,105.24 359.52,105.24 357.44,107.32 357.44,121.04 356.88,121.6 355.23,121.6 354.55,120.91 354.55,116.54 353.29,115.28 349.66,115.28 348.16,116.78 348.16,125.11 335.99,137.28 333.38,137.28 331.56,139.1 331.56,150.49 334.43,153.36 334.43,164 331,167.42 331,173.07 329.9,174.17 329.9,175.98 331.51,177.59 331.51,178
  L25_SIGNAL w0.091: 331.51,178 UNK8U409.E8 v1(332.16,178.15) ; D105.14 415.19,97.89
  BOTTOM w0.16: UNK8U409.E8 v1(332.16,178.15)
D10515: length 304.3
  L27_SIGNAL w0.079: 414.12,94.08 414.12,93.11 410.35,89.34 305.7,89.34 287.84,107.2 287.84,116.52 294.33,123.01 294.33,130.42 293.3,131.44 271.89,131.44 269.95,133.39 269.95,136.59 272.49,139.13 291.17,139.13 291.94,139.9 291.94,142.86 291.08,143.73 277.6,143.73 275.69,141.82 272.83,141.82 271.02,143.62 271.02,150.63 272.15,151.75 274.12,151.75 275.98,153.61 288.75,153.61 289.96,152.4 293.4,152.4 294.24,153.24 294.24,163.92 290.81,167.34 290.81,172.99 289.71,174.09 289.71,176.06 291.31,177.67 291.31,178
  L27_SIGNAL w0.091: D105.15 414.12,94.08 ; v1(290.66,178.15) UNK7U409.E9 291.31,178
  BOTTOM w0.16: UNK7U409.E9 v1(290.66,178.15)
