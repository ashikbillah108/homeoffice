# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D12508: length 341.7
  L13_SIGNAL w0.076: v2(233.11,246.91) 232.78,247.23 231.67,247.23 231.48,247.42 231.48,251.08
  L13_SIGNAL w0.091: 231.48,251.08 231.23,251.33 225.3,251.33 223.03,249.06 223.03,236.59 223.69,235.92 223.69,232.88 223.48,232.67 223.48,231.62 222.67,230.81 222.67,225.4 221.8,224.54 220.99,224.54 219.84,223.39 219.84,222.12 221.24,220.73 221.24,195.22 220.12,194.11 216.38,194.11 215.19,192.92 215.19,178 216.17,177.02 218.42,177.02 220.89,174.55 220.89,171.97 220.32,171.4 220.32,167.93 217.79,165.4 217.27,165.4 216.54,164.67 216.54,158.6 212.93,154.99 211.66,154.99 208.15,151.48 208.15,150.57 205.59,148.01 132.28,148.01 130.3,149.99 83.54,149.99 58.62,125.07 58.62,108.03 54.2,103.61 35.03,103.61 D125.08
D12509: length 319.7
  L13_SIGNAL w0.076: 224.73,190.69 225.12,191.08
  L13_SIGNAL w0.091: v2(233.63,232.39) 233.63,227.04 230.11,223.52 230.11,221.14 229.4,220.43 229.4,214.22 230.64,212.98 230.64,208.79 229.24,207.39 229.24,195.2 225.12,191.08 ; 224.73,190.69 222.23,188.19 222.23,178.44 227.57,173.09 227.57,162.24 227.08,161.75 227.08,155.71 223.14,151.76 222.38,151.76 220.73,150.11 217.4,150.11 210.02,142.74 127.83,142.74 125.91,144.65 93.73,144.65 89.61,140.54 84.89,140.54 62.53,118.19 62.53,100.95 54.3,92.71 36.83,92.71 D125.09
  BOTTOM w0.16: K32.7 v2(233.63,232.39)
D12510: length 346
  TOP w0.16: SW5.6 v3(126.48,260.35)
  L15_SIGNAL w0.076: 230.17,250.17 230.18,250.16 230.18,248.53 v2(230.5,248.2)
  L15_SIGNAL w0.091: 230.17,250.17 228.67,251.67 218.67,251.67 217.98,250.98 216.53,250.98 214.83,252.67 210.94,252.67 207.64,249.38 201.68,249.38 200.99,250.06 164.11,250.06 163.45,249.4 140.84,249.4 129.9,260.35 v3(126.48,260.35) 124.49,258.36 90.7,258.36 81.33,249 81.33,127.56 56.69,102.92 39.42,102.92 D125.10
D12511: length 322.7
  L13_SIGNAL w0.076: v2(227.26,245.61) 226.93,245.93 225.83,245.93
  L13_SIGNAL w0.091: D125.11 39.62,95 54.61,95 62.03,102.41 62.03,118.32 85.58,141.88 90.19,141.88 93.34,145.03 126.69,145.03 127.66,144.06 210.05,144.06 217.53,151.54 220.75,151.54 224.44,155.22 224.44,160.3 225.37,161.22 225.37,167.27 224.82,167.82 224.82,175.25 221.02,179.05 221.02,187.62 228.78,195.37 228.78,220.4 229.69,221.32 229.69,224.79 230.09,225.19 230.09,227.9 229.17,228.82 229.17,235.93 225.18,239.92 225.18,245.61 225.49,245.93 225.83,245.93
D12512: length 315.3
  L13_SIGNAL w0.076: v2(230.5,249.5) 230.18,249.83 226.32,249.83
  L13_SIGNAL w0.091: 226.32,249.83 224.82,249.83 223.4,248.41 223.4,240.03 224.29,239.14 224.29,238.51 223.91,238.12 223.91,236.23 224.06,236.08 224.06,231.68 223.04,230.65 223.04,224.55 222.48,224 222.48,210.65 222.76,210.38 222.76,195.6 220.85,193.69 219.52,193.69 218.16,192.33 218.16,177.87 221.31,174.73 221.31,171.79 220.83,171.32 220.83,167.92 218.66,165.75 218.66,158.76 217.31,157.4 216.74,157.4 215.41,156.08 215.41,155.09 207.41,147.09 129.84,147.09 129.11,147.83 86.87,147.83 59.08,120.04 59.08,107.27 54.55,102.74 44.32,102.74 D125.12
D12513: length 323.7
  L13_SIGNAL w0.076: 225.68,248.53 229.53,248.53 v2(229.86,248.2)
  L13_SIGNAL w0.091: D125.13 44.25,95.45 54.38,95.45 61.61,102.68 61.61,118.5 86.3,143.19 90.97,143.19 93.2,145.41 126.97,145.41 127.81,144.58 209.5,144.58 216.92,151.99 220.45,151.99 222.31,153.85 222.31,161.31 222.67,161.67 222.67,163.73 223.12,164.17 223.12,171.56 223.83,172.28 223.83,175.65 220.61,178.88 220.61,190.78 221.54,191.71 224.23,191.71 226.35,193.83 226.35,220.38 227.57,221.6 227.57,224.42 228.16,225 229.19,225 229.67,225.48 229.67,227.72 227.28,230.11 227.28,237.3 226.95,237.63 224.16,240.42 224.16,247.4 225.29,248.53 225.68,248.53
D12514: length 281.2
  L13_SIGNAL w0.091: K39.2 224.26,224.51 222.9,223.15 222.9,210.82 223.3,210.43 223.3,198.55 224.34,197.51 224.34,196.55 220.76,192.97 220.24,192.97 218.58,191.31 218.58,178.86 221.72,175.72 221.72,171.62 221.26,171.16 221.26,167.79 219.14,165.66 219.14,156.45 217.83,155.14 216.89,155.14 208.41,146.67 129.58,146.67 128.8,147.45 87.1,147.45 60.32,120.68 60.32,107.88 53.01,100.56 47.22,100.56 D125.14
D12515: length 316.9
  L13_SIGNAL w0.076: v2(229.86,248.85) 229.53,249.18 225.81,249.18
  L13_SIGNAL w0.091: 225.81,249.18 225.18,249.18 223.78,247.78 223.78,240.28 224.67,239.39 224.67,238.25 224.41,238 224.41,236.6 224.67,236.35 224.67,230.85 227.55,227.96 227.55,225.46 227.11,225.02 226.06,225.02 225.34,224.3 225.34,221.55 224.95,221.16 224.95,211.34 225.23,211.06 225.23,193.73 223.63,192.13 221.37,192.13 220.19,190.95 220.19,178.44 222.56,176.07 222.56,173.15 223.06,172.65 223.06,172.1 222.7,171.74 222.7,164.4 222.25,163.96 222.25,162.41 221.19,161.35 221.19,154.11 220.76,153.68 219.65,153.68 218.36,152.4 216.14,152.4 208.78,145.04 128.37,145.04 126.72,146.69 89.15,146.69 61.16,118.69 61.16,102.83 56.12,97.79 49.53,97.79 D125.15
D12516: length 276.2
  L13_SIGNAL w0.091: K39.7 224.26,209.34 224.11,209.2 224.11,206.84 224.82,206.14 224.82,194.97 222.4,192.55 220.41,192.55 219,191.14 219,179.04 222.14,175.89 222.14,171.94 222.27,171.81 222.27,165.27 221.25,164.25 220.51,164.25 220,163.74 220,161.52 220.48,161.04 220.48,158.12 219.84,157.48 219.84,154.81 217.86,152.83 215.22,152.83 207.88,145.49 130.05,145.49 128.47,147.07 87.35,147.07 60.74,120.46 60.74,107.7 53.14,100.1 51.84,100.1 D125.16
D12601: length 380.9
  L13_SIGNAL w0.091: UNK2K39.7 264.26,209.34 264.11,209.2 264.11,206.84 264.82,206.14 264.82,194.97 262.4,192.55 260.41,192.55 259,191.14 259,179.04 262.14,175.89 262.14,171.94 262.27,171.81 262.27,165.27 261.25,164.25 260.51,164.25 260,163.74 260,161.52 260.76,160.76 260.76,157.58 261.37,156.97 261.37,154.81 249.91,143.36 246.38,143.36 242.93,139.9 241.93,139.9 232.94,130.91 219.74,130.91 218.01,129.18 210.44,129.18 209.83,129.79 148.29,129.79 138.69,120.19 81.1,120.19 71.84,110.94 71.84,84.87 54.05,67.08 20.19,67.08 19.08,68.2 19.08,69.82 D126.01
D12602: length 342.5
  L13_SIGNAL w0.091: D126.02 21.92,85.42 54.14,85.42 65.56,96.83 65.56,115.93 84.2,134.57 142.44,134.57 147.35,139.47 210.98,139.47 217.17,145.67 225.12,145.67 227.18,147.73 227.18,148.87 227.69,149.38 232.05,149.38 240.54,157.86 240.54,163.28 236.96,166.86 236.96,176.1 239.13,178.27 240,178.27 242.78,181.05 242.78,187.25 236.04,193.98 236.04,202.2 236.68,202.84 236.68,204.13 237.3,204.75 237.3,205.53 239.13,207.36 239.13,207.79 239.84,208.5 239.84,211.53 239.54,211.82 239.54,215.79 240.38,216.62 240.78,216.62 242.57,218.42 K113.6
D12603: length 376.2
  L13_SIGNAL w0.091: UNK2K39.2 264.26,224.51 262.9,223.15 262.9,210.82 263.3,210.43 263.3,198.55 264.34,197.51 264.34,196.55 260.76,192.97 260.24,192.97 258.58,191.31 258.58,178.86 261.72,175.72 261.72,171.62 261.26,171.16 261.26,167.79 259.14,165.66 259.14,153.22 249.86,143.94 246.35,143.94 242.75,140.33 239.7,140.33 230.73,131.37 219.58,131.37 217.93,129.72 210.62,129.72 210.08,130.25 148.13,130.25 138.5,120.62 80.86,120.62 71.42,111.18 71.42,85.05 53.94,67.56 24.84,67.56 24.1,68.3 24.1,69.88 D126.03
D12604: length 354.5
  L13_SIGNAL w0.091: v2(237.83,232.39) 237.83,227.65 241.85,223.64 243.09,223.64 243.58,223.15 243.58,218.75 240.65,215.82 240.65,210.94 240.94,210.65 240.94,209.88 240.32,209.26 240.32,207.11 237.1,203.89 237.1,202.57 236.45,201.93 236.45,194.13 243.2,187.39 243.2,180.86 240.24,177.9 239.43,177.9 237.37,175.84 237.37,167.04 240.92,163.49 240.92,156.85 232.11,148.03 228.14,148.03 225.35,145.24 217.4,145.24 211.18,139.02 147.42,139.02 142.57,134.16 84.39,134.16 65.98,115.75 65.98,96.66 54.25,84.94 26.52,84.94 D126.04
  BOTTOM w0.16: K32.2 v2(237.83,232.39)
D12605: length 398.1
  L13_SIGNAL w0.076: v2(270.5,249.5) 270.18,249.83 266.32,249.83
  L13_SIGNAL w0.091: 266.32,249.83 264.82,249.83 263.4,248.41 263.4,240.03 264.29,239.14 264.29,238.51 263.91,238.12 263.91,236.23 264.06,236.08 264.06,231.68 263.04,230.65 263.04,224.55 262.48,224 262.48,210.65 262.76,210.38 262.76,195.6 260.85,193.69 259.52,193.69 258.16,192.33 258.16,177.87 261.31,174.73 261.31,171.79 260.83,171.32 260.83,167.92 258.66,165.75 258.66,153.43 250.27,145.03 245.47,145.03 241.22,140.79 239.47,140.79 230.5,131.83 219.2,131.83 218.26,130.89 210.82,130.89 210.31,131.4 148.5,131.4 140.42,123.32 82.04,123.32 71.01,112.28 71.01,86.44 54.16,69.6 29.46,69.6 D126.05
D12606: length 372.2
  L13_SIGNAL w0.091: v2(235.71,248.85) 239.21,248.85 241.42,246.65 241.42,239.24 238.31,236.13 238.31,229.19 244.1,223.39 244.1,218.67 241.07,215.64 241.07,211.11 241.36,210.82 241.36,208.35 240.74,207.73 240.74,206.94 237.52,203.72 237.52,202.46 236.96,201.9 236.96,194.92 243.62,188.26 243.62,179.18 242.75,178.31 241.31,178.31 240.47,177.47 239.83,177.47 238.34,175.98 238.34,166.8 241.43,163.7 241.43,155.35 239.94,153.86 238.57,153.86 232.37,147.67 228.54,147.67 225.68,144.81 217.73,144.81 210.77,137.85 146.94,137.85 141.55,132.46 109.73,132.46 109.35,132.84 99.44,132.84 98.93,132.33 83.16,132.33 66.4,115.57 66.4,95.32 53.96,82.88 29.54,82.88 D126.06
D12607: length 405.3
  L13_SIGNAL w0.076: 271.48,251.08 271.48,247.42 271.67,247.23 272.78,247.23 v2(273.11,246.91)
  L13_SIGNAL w0.091: 271.48,251.08 271.23,251.33 265.3,251.33 263.03,249.06 263.03,236.59 263.69,235.92 263.69,232.88 263.48,232.67 263.48,231.62 262.67,230.81 262.67,225.4 261.8,224.54 260.99,224.54 259.84,223.39 259.84,222.12 261.24,220.73 261.24,195.22 260.12,194.11 256.38,194.11 255.19,192.92 255.19,178 256.17,177.02 258.42,177.02 260.89,174.55 260.89,171.97 260.32,171.4 260.32,167.93 257.79,165.4 257.27,165.4 256.54,164.67 256.54,154.15 247.88,145.49 244.2,145.49 242.44,143.74 241.02,143.74 240,142.72 240,142.01 231.06,133.07 219.81,133.07 218.06,131.32 211.12,131.32 210.59,131.85 148.31,131.85 140.41,123.95 82.12,123.95 70.59,112.42 70.59,86.61 54.03,70.05 34.09,70.05 D126.07
D12608: length 381.6
  L13_SIGNAL w0.076: 234.57,250.45 234.73,250.29 234.73,248.07 234.54,247.88 234.08,247.88 v2(233.76,247.56)
  L13_SIGNAL w0.091: 234.57,250.45 234.57,251.13 234.91,251.47 236.34,251.47 238.19,249.63 240.22,249.63 242.58,247.27 242.58,238.89 238.73,235.04 238.73,229.36 243.55,224.54 244.99,224.54 246.24,223.29 246.24,218.97 241.49,214.22 241.49,211.28 241.78,210.99 241.78,208.15 241.16,207.53 241.16,205.92 238.37,203.13 238.37,202.38 237.44,201.45 237.44,195.12 244.84,187.73 244.84,179.12 243.62,177.9 241.71,177.9 240.21,176.4 239.83,176.4 238.76,175.33 238.76,166.9 241.41,164.24 242.45,164.24 243.69,163 243.69,159.18 242.93,158.42 242.93,156.24 239.98,153.29 239.65,153.29 236.25,149.89 235.11,149.89 232.47,147.24 228.63,147.24 225.82,144.42 222.35,144.42 215.32,137.39 147.25,137.39 141.22,131.36 109.01,131.36 107.69,130.05 101.51,130.05 100.67,130.88 100.13,130.88 99.31,131.7 84.45,131.7 66.81,114.06 66.81,95.14 54.04,82.37 34.11,82.37 D126.08
D12609: length 396.6
  L13_SIGNAL w0.076: 272.13,251.08 272.13,249.18 v2(272.46,248.85)
  L13_SIGNAL w0.091: D126.09 37.01,72.21 54.02,72.21 70.17,88.36 70.17,112.6 82,124.43 140.2,124.43 148.08,132.31 210.84,132.31 211.35,131.8 217.88,131.8 222.4,136.32 230.66,136.32 231.06,135.92 231.93,135.92 240.4,144.39 242.25,144.39 243.84,145.97 246.89,145.97 250.85,149.94 251.66,149.94 254.88,153.15 254.88,164.09 251.51,167.47 251.51,173.13 249.93,174.71 249.93,190.8 254.07,194.94 256.1,194.94 256.57,194.48 259.97,194.48 260.83,195.34 260.83,205.51 260.07,206.27 260.07,209 259.01,210.06 259.01,223.58 260.35,224.92 261.59,224.92 262.25,225.58 262.25,230.99 263.06,231.79 263.06,232.65 262.25,233.45 262.25,236.14 262.67,236.55 262.67,249.21 266.15,252.69 269.93,252.69 270.75,251.87 271.81,251.87 272.13,251.54 272.13,251.08
D12610: length 382.2
  L13_SIGNAL w0.091: v2(233.76,248.85) 234.19,249.29 234.19,251.27 234.76,251.84 240.54,251.84 242.94,249.44 242.94,238.74 239.14,234.94 239.14,229.53 243.76,224.92 247.26,224.92 249.08,223.09 249.08,218.53 247.39,216.84 244.7,216.84 243.52,215.67 243.52,212.45 242.77,211.69 242.77,208.34 241.58,207.14 241.58,205.74 238.84,203.01 238.84,202.13 238.46,201.75 238.46,194.67 239.25,193.88 240.09,193.88 245.25,188.71 245.25,178.94 243.75,177.43 241.83,177.43 239.18,174.78 239.18,168.11 244.1,163.19 244.1,158.65 243.57,158.12 243.57,154.82 238.61,149.86 237.19,149.86 234.47,147.14 233.78,147.14 231.52,144.89 229.33,144.89 228.71,145.5 227.5,145.5 225.93,143.94 222.48,143.94 215.47,136.93 147.48,136.93 140.21,129.67 82.95,129.67 67.23,113.95 67.23,93.45 54.15,80.37 37.19,80.37 D126.10
D12611: length 386.3
  L13_SIGNAL w0.076: 272.78,251.08 272.78,247.88 v2(273.11,247.56)
  L13_SIGNAL w0.091: 272.78,251.08 272.78,251.65 271.32,253.11 264.92,253.11 262.19,250.38 262.19,237.94 261.87,237.62 261.87,231.52 260.86,230.5 260.86,227.46 258.57,225.17 258.57,211.17 251.44,204.04 251.44,197.82 251.12,197.5 251.12,195.56 249.5,193.95 249.5,174.48 251.09,172.9 251.09,167.3 254.46,163.93 254.46,153.47 252.32,151.33 251.64,151.33 247.29,146.98 243.48,146.98 241.5,145 240.35,145 232.49,137.13 221.78,137.13 217.41,132.77 147.85,132.77 139.95,124.87 81.84,124.87 69.75,112.78 69.75,88.54 53.88,72.67 41.63,72.67 D126.11
D12612: length 384.3
  L13_SIGNAL w0.091: D126.12 41.76,79.86 54.25,79.86 67.65,93.26 67.65,113.78 82.91,129.03 103,129.03 104.39,127.63 107.06,127.63 108.46,129.03 140.23,129.03 147.68,136.48 210.56,136.48 211.23,135.81 215.85,135.81 223.6,143.56 226.07,143.56 227.37,144.86 228.54,144.86 228.89,144.52 232.48,144.52 237.13,149.17 239.9,149.17 244.02,153.29 244.02,155.85 245.06,156.9 245.06,158.52 246.61,160.07 246.61,163.53 246.2,163.93 243.99,163.93 239.6,168.33 239.6,174.67 241.4,176.47 244.29,176.47 245.67,177.86 245.67,188.93 240.26,194.34 239.55,194.34 238.87,195.02 238.87,201.6 243.19,205.92 243.19,210.29 244.01,211.12 244.01,214.61 245.82,216.42 247.56,216.42 249.5,218.36 249.5,223.27 247.47,225.3 243.97,225.3 239.56,229.71 239.56,234.12 241.98,236.53 242.38,236.53 243.46,237.62 243.46,250.44 241.69,252.22 234.57,252.22 233.81,251.45 233.81,249.56 v2(233.76,249.5)
D12613: length 390.5
  L13_SIGNAL w0.091: v2(264,259) 262.38,257.38 262.38,254.89 261.11,253.62 261.11,236.33 261.37,236.07 261.37,231.86 260.36,230.85 260.36,227.71 258.13,225.48 258.13,211.33 251.02,204.22 251.02,198.07 250.7,197.74 250.7,195.79 249.05,194.14 249.05,174.29 250.63,172.71 250.63,164.54 254.01,161.16 254.01,153.54 252.37,151.89 250.75,151.89 246.23,147.37 243.97,147.37 242.96,148.38 241.83,148.38 241.22,147.78 241.22,146.96 237.9,143.64 236.58,143.64 230.91,137.97 229.29,137.97 228.7,138.56 222.61,138.56 217.32,133.27 211.05,133.27 210.39,133.94 148.16,133.94 139.54,125.32 81.7,125.32 69.33,112.95 69.33,89.8 54.28,74.75 44.63,74.75 D126.13
  L23_SIGNAL w0.091: v2(264,259) 263.27,258.27 263.27,246 264.28,244.98 265.04,244.98 265.3,244.73 265.73,244.73 v2(265.96,244.96)
D12614: length 397.7
  L13_SIGNAL w0.091: v2(232.19,271.11) 232.19,269.6 234.19,267.59 234.19,259.71 240.22,253.69 242.77,253.69 246.89,249.56 246.89,236.85 250.85,232.9 250.85,225.61 250.37,225.14 250.37,218.05 249.42,217.09 249.42,209.84 240.48,200.9 240.48,195.36 241.34,194.5 243.6,194.5 247.67,190.44 247.67,177.85 245.46,175.64 241.69,175.64 240.59,174.55 240.59,168.6 244.2,165 248.95,165 250.37,163.58 250.37,154.15 247.6,151.38 244.27,151.38 243.64,150.75 243.64,150.43 242.44,149.23 241.1,149.23 240.31,148.44 239.43,148.44 238.05,147.07 238.05,146.66 235.14,143.75 231.36,143.75 230.53,142.93 230.53,142.9 226.65,142.9 225.68,141.94 224,141.94 216.92,134.85 147.52,134.85 138.96,126.29 81.48,126.29 68.49,113.3 68.49,91.64 54.19,77.34 47.12,77.34 D126.14
  BOTTOM w0.16: U449.3 v2(232.19,271.11)
D12615: length 379.1
  L13_SIGNAL w0.091: v2(233.18,271.1) 233.18,269.36 234.83,267.72 234.83,259.83 240.53,254.13 243.84,254.13 247.66,250.32 247.66,236.73 251.21,233.17 251.21,225.46 250.79,225.04 250.79,217.87 250.17,217.25 250.17,195.9 248.62,194.35 248.62,174.03 250.17,172.48 250.17,164.37 250.79,163.75 250.79,153.91 246.16,149.28 243.51,149.28 243.05,148.82 241.53,148.82 239.19,146.48 238.58,146.48 235.38,143.28 233.15,143.28 231.65,141.78 227.74,141.78 227.36,141.4 224.08,141.4 216.43,133.76 211.25,133.76 210.61,134.39 147.95,134.39 139.34,125.78 81.57,125.78 68.91,113.12 68.91,89.99 54.13,75.21 49.25,75.21 D126.15
  BOTTOM w0.16: U449.4 232.69,270.61 v2(233.18,271.1)
D12616: length 374.8
  L13_SIGNAL w0.076: v2(233.11,249.5) 233.43,249.83 233.43,251.08
  L13_SIGNAL w0.091: D126.16 51.71,77.83 54.08,77.83 68.07,91.81 68.07,113.61 81.19,126.72 138.68,126.72 147.27,135.31 216,135.31 223.89,143.2 226.23,143.2 227.53,144.5 228.39,144.5 228.77,144.12 233.97,144.12 236.04,146.19 236.04,147.09 237.76,148.81 240.07,148.81 245.57,154.31 245.57,154.94 248.8,158.17 248.8,163.92 248.37,164.35 244.2,164.35 239.98,168.57 239.98,174.47 241.56,176.05 244.46,176.05 246.73,178.32 246.73,189.27 241.86,194.13 241,194.13 240.42,194.72 239.81,194.72 239.32,195.2 239.32,201.46 243.61,205.74 243.61,208.38 246.17,210.94 246.17,214.44 249.95,218.22 249.95,225.53 250.48,226.06 250.48,231.99 244.73,237.73 244.73,251.21 243.35,252.59 234.18,252.59 233.43,251.84 233.43,251.08
D12701: length 488.5
  L13_SIGNAL w0.076: 273.43,251.08 273.43,249.83 v2(273.11,249.5)
  L13_SIGNAL w0.091: D127.01 19.08,49.5 19.08,47.88 20.19,46.76 65.19,46.76 79.15,60.72 79.15,99.92 84.2,104.98 134.62,104.98 149.33,119.68 242.21,119.68 251.36,128.83 275.26,128.83 281.61,135.18 281.61,139.24 285.57,143.21 285.57,154.94 288.8,158.17 288.8,163.92 288.37,164.35 284.08,164.35 279.98,168.45 279.98,174.47 281.56,176.05 284.46,176.05 286.73,178.32 286.73,189.27 281.86,194.13 281,194.13 280.42,194.72 279.81,194.72 279.32,195.2 279.32,201.46 283.61,205.74 283.61,208.38 286.17,210.94 286.17,214.44 289.95,218.22 289.95,225.53 290.48,226.06 290.48,231.99 284.73,237.73 284.73,251.21 283.35,252.59 274.18,252.59 273.43,251.84 273.43,251.08
D12702: length 412.8
  L13_SIGNAL w0.076: 265.81,249.18 269.53,249.18 v2(269.85,248.85)
  L13_SIGNAL w0.091: 265.81,249.18 265.18,249.18 263.78,247.78 263.78,240.28 264.67,239.39 264.67,238.25 264.41,238 264.41,236.6 264.67,236.35 264.67,230.85 267.55,227.96 267.55,225.46 267.11,225.02 266.06,225.02 265.34,224.3 265.34,221.55 264.95,221.16 264.95,211.34 265.23,211.06 265.23,193.73 263.63,192.13 261.37,192.13 260.19,190.95 260.19,178.44 262.56,176.07 262.56,173.15 263.06,172.65 263.06,172.1 262.7,171.74 262.7,164.4 262.25,163.96 262.25,162.41 261.19,161.35 261.19,158.17 261.77,157.58 261.77,153.44 251.23,142.9 247.29,142.9 243.84,139.45 242.19,139.45 232.49,129.74 219.28,129.74 218.24,128.7 210.13,128.7 209.5,129.34 148.48,129.34 138.88,119.74 81.29,119.74 72.26,110.71 72.26,83.35 53.93,65.02 21.84,65.02 D127.02
D12703: length 481.9
  L13_SIGNAL w0.091: v2(273.76,249.5) 273.81,249.56 273.81,251.45 274.57,252.22 281.69,252.22 283.46,250.44 283.46,237.62 282.38,236.53 281.98,236.53 279.56,234.12 279.56,229.58 283.84,225.3 287.47,225.3 289.5,223.27 289.5,218.36 287.56,216.42 285.82,216.42 284.01,214.61 284.01,211.12 283.19,210.29 283.19,205.92 278.87,201.6 278.87,195.02 279.55,194.34 280.26,194.34 285.67,188.93 285.67,177.86 284.29,176.47 281.4,176.47 279.6,174.67 279.6,168.28 283.94,163.93 286.2,163.93 286.61,163.53 286.61,160.07 285.06,158.52 285.06,156.9 284.02,155.85 284.02,151.95 285.06,150.9 285.06,144.09 280.21,139.24 280.21,137.19 272.31,129.29 249.94,129.29 244.02,123.37 242.49,123.37 239.27,120.14 149.14,120.14 134.43,105.44 83.95,105.44 78.73,100.22 78.73,60.89 65.08,47.24 24.84,47.24 24.1,47.98 24.1,49.56 D127.03
D12704: length 409
  L13_SIGNAL w0.076: 265.68,248.53 269.53,248.53 v2(269.85,248.2)
  L13_SIGNAL w0.091: 265.68,248.53 265.29,248.53 264.16,247.4 264.16,240.42 266.95,237.63 267.28,237.3 267.28,230.11 269.67,227.72 269.67,225.48 269.19,225 268.16,225 267.57,224.42 267.57,221.6 266.35,220.38 266.35,193.83 264.23,191.71 261.54,191.71 260.61,190.78 260.61,178.88 263.83,175.65 263.83,172.28 263.12,171.56 263.12,164.17 262.67,163.73 262.67,161.67 262.31,161.31 262.31,151.82 252.43,141.94 248.41,141.94 235.76,129.29 219.46,129.29 218.44,128.27 209.88,128.27 209.27,128.88 148.67,128.88 139.04,119.25 81.91,119.25 72.68,110.02 72.68,83.18 54.07,64.57 26.47,64.57 D127.04
D12705: length 461.3
  L13_SIGNAL w0.091: v2(273.76,248.85) 274.19,249.29 274.19,251.27 274.76,251.84 280.54,251.84 282.94,249.44 282.94,238.74 279.14,234.94 279.14,229.24 283.46,224.92 287.25,224.92 289.08,223.09 289.08,218.53 287.39,216.84 284.7,216.84 283.52,215.67 283.52,212.45 282.77,211.69 282.77,208.34 281.58,207.14 281.58,205.74 278.84,203.01 278.84,202.13 278.46,201.75 278.46,194.67 279.25,193.88 280.09,193.88 285.25,188.71 285.25,178.94 283.75,177.43 281.83,177.43 279.18,174.78 279.18,168.11 284.1,163.18 284.1,158.65 283.57,158.12 283.57,143.21 279.68,139.32 279.68,137.31 272.14,129.77 249.71,129.77 243.76,123.82 242.24,123.82 238.99,120.57 148.95,120.57 134.29,105.92 83.74,105.92 78.31,100.48 78.31,73.31 54.28,49.28 29.46,49.28 D127.05
D12706: length 397.9
  L13_SIGNAL w0.076: 265.83,245.93 266.93,245.93 v2(267.25,245.61)
  L13_SIGNAL w0.091: 265.83,245.93 265.49,245.93 265.18,245.61 265.18,239.92 269.17,235.93 269.17,228.82 270.09,227.9 270.09,225.19 269.69,224.79 269.69,221.32 268.78,220.4 268.78,195.37 261.02,187.62 261.02,179.05 264.82,175.25 264.82,167.82 265.37,167.27 265.37,161.22 264.44,160.3 264.44,152.55 263.42,151.53 262.78,151.53 252.65,141.4 248.49,141.4 235.92,128.83 219.61,128.83 218.62,127.84 209.63,127.84 209.04,128.42 148.86,128.42 136.72,116.28 80.4,116.28 73.1,108.99 73.1,81.68 53.98,62.56 29.54,62.56 D127.06
D12707: length 449.8
  L13_SIGNAL w0.076: v2(273.76,247.56) 274.08,247.88 274.54,247.88 274.73,248.07 274.73,250.29 274.57,250.45
  L13_SIGNAL w0.091: D127.07 34.09,49.73 54.14,49.73 77.89,73.48 77.89,100.62 83.74,106.48 134.2,106.48 151.07,123.34 206.71,123.34 207.29,122.76 220.45,122.76 221.54,123.85 241.63,123.85 242.14,124.36 243.59,124.36 250.11,130.89 269.57,130.89 279.91,141.22 279.91,143 282.93,146.02 282.93,158.42 283.69,159.18 283.69,163 282.45,164.24 281.41,164.24 278.76,166.9 278.76,175.33 279.83,176.4 280.21,176.4 281.71,177.9 283.62,177.9 284.84,179.12 284.84,187.73 277.44,195.12 277.44,201.45 278.37,202.38 278.37,203.13 281.16,205.92 281.16,207.53 281.78,208.15 281.78,210.99 281.49,211.28 281.49,214.22 286.24,218.97 286.24,223.29 284.99,224.54 283.21,224.54 278.73,229.02 278.73,235.04 282.57,238.89 282.57,247.27 280.22,249.63 278.19,249.63 276.34,251.47 274.91,251.47 274.57,251.13 274.57,250.45
D12708: length 382.3
  L13_SIGNAL w0.076: 264.73,190.69 265.12,191.08
  L13_SIGNAL w0.091: D127.08 34.11,62.05 54.1,62.05 73.53,81.48 73.53,108.77 80.58,115.82 136.91,115.82 149.05,127.97 208.84,127.97 209.4,127.41 218.82,127.41 219.79,128.37 237.03,128.37 248.82,140.16 256.11,140.16 256.72,140.77 256.72,142.37 264.57,150.22 264.57,151.03 267.08,153.54 267.08,161.75 267.57,162.24 267.57,173.09 262.23,178.44 262.23,188.19 264.73,190.69 ; v2(273.63,232.39) 273.63,227.04 270.11,223.52 270.11,221.14 269.4,220.43 269.4,214.22 270.64,212.98 270.64,208.79 269.24,207.39 269.24,195.2 265.12,191.08
  BOTTOM w0.16: UNK2K32.7 v2(273.63,232.39)
D12709: length 427.8
  L13_SIGNAL w0.091: D127.09 37.01,51.89 54.03,51.89 77.47,75.34 77.47,100.84 83.54,106.91 133.99,106.91 150.88,123.8 206.88,123.8 207.49,123.19 220.27,123.19 221.39,124.31 241.43,124.31 241.99,124.87 243.46,124.87 249.91,131.32 269.32,131.32 279.43,141.43 279.43,143.15 281.43,145.16 281.43,163.7 278.34,166.8 278.34,175.98 279.83,177.47 280.47,177.47 281.31,178.31 282.75,178.31 283.62,179.18 283.62,188.26 276.96,194.92 276.96,201.9 277.52,202.46 277.52,203.72 280.74,206.94 280.74,207.73 281.36,208.35 281.36,210.82 281.07,211.11 281.07,215.64 284.1,218.67 284.1,223.39 283.34,224.16 282.96,224.16 278.31,228.8 278.31,236.13 281.42,239.24 281.42,246.65 279.21,248.85 v2(275.71,248.85)
D12710: length 403.1
  L13_SIGNAL w0.076: 276.07,242.68 272.13,242.68 v2(271.81,243)
  L13_SIGNAL w0.091: 276.07,242.68 276.27,242.68
  L13_SIGNAL w0.508: D127.10 37.02,59.88 53.2,59.88 74.23,80.91 74.23,108.55 80.85,115.16 137.3,115.16 149.42,127.28 208.58,127.28 209.17,126.7 219.1,126.7 220.04,127.63 238.46,127.63 248.21,137.39 255.65,137.39 265.02,146.76 265.02,149.33 267.44,151.74 268.15,151.74 269.11,152.7 269.11,160.3 270,161.19 270,165.51 270.89,166.4 270.89,174.05 263.93,181.01 263.93,188.9 266.52,191.49 267.4,191.49 267.99,192.08 267.99,192.39 268.38,192.78 269.84,192.78 273.16,196.1 273.16,202.75 274.36,203.95 274.36,210.93 273.01,212.28 273.01,216.49 274.07,217.55 277.9,217.55 278.76,218.42 278.76,223.36 274.93,227.2 274.93,237.97 277.37,240.41 277.37,241.98 276.67,242.68 276.27,242.68
D12711: length 400.8
  L13_SIGNAL w0.091: v2(277.83,232.39) 277.83,227.65 281.85,223.64 283.09,223.64 283.58,223.15 283.58,218.75 280.65,215.82 280.65,210.94 280.94,210.65 280.94,209.88 280.32,209.26 280.32,207.11 277.1,203.89 277.1,202.57 276.45,201.93 276.45,194.13 283.2,187.39 283.2,180.86 280.24,177.9 279.43,177.9 277.37,175.84 277.37,167.04 280.92,163.49 280.92,146.08 275.44,140.59 275.44,138.99 268.22,131.78 248.97,131.78 242.6,125.4 241.83,125.4 241.2,124.76 221.21,124.76 220.07,123.62 207.72,123.62 207.09,124.26 150.69,124.26 133.82,107.39 83.26,107.39 77.05,101.18 77.05,75.55 53.85,52.35 41.63,52.35 D127.11
  BOTTOM w0.16: UNK2K32.2 v2(277.83,232.39)
D12712: length 398.7
  L13_SIGNAL w0.076: 276.07,243.33 274.73,243.33 v2(274.41,243)
  L13_SIGNAL w0.091: 276.07,243.33 276.86,243.33 278.75,241.44 278.75,240.86 276.11,238.22 276.11,226.95 279.4,223.67 279.4,218.14 277.87,216.61 276.22,216.61 275,215.39 275,203.5 274.55,203.05 274.55,196.68 273.41,195.54 273.41,192.71 274.65,191.47 275.34,191.47 278.92,187.88 278.92,182.35 274.14,177.57 274.14,167.31 278.45,163.01 278.45,158 274.77,154.32 274.77,150.37 274.13,149.73 268.2,149.73 267.16,148.69 267.16,147.19 256.77,136.8 249.33,136.8 239.52,127 220.34,127 219.28,125.93 208.76,125.93 208.15,126.54 149.78,126.54 135.51,112.27 81.53,112.27 74.96,105.69 74.96,80.3 53.96,59.3 41.52,59.3 D127.12
D12713: length 375.2
  L13_SIGNAL w0.091: UNK2K113.6 282.57,218.42 280.78,216.62 280.38,216.62 279.54,215.79 279.54,211.82 279.84,211.53 279.84,208.5 279.13,207.79 279.13,207.36 277.3,205.53 277.3,204.75 276.68,204.13 276.68,202.84 276.04,202.2 276.04,193.98 282.78,187.25 282.78,181.05 280,178.27 279.13,178.27 276.96,176.1 276.96,166.86 280.54,163.28 280.54,146.33 275.72,141.5 274.75,141.5 270.21,136.96 263.91,136.96 260.2,133.25 249.83,133.25 242.43,125.84 241.57,125.84 240.94,125.22 221.06,125.22 219.91,124.08 207.92,124.08 207.29,124.71 150.5,124.71 133.63,107.85 82.96,107.85 76.63,101.52 76.63,76.81 54.25,54.43 44.63,54.43 D127.13
D12714: length 401.8
  L13_SIGNAL w0.076: 275.84,247.23 274.73,247.23 v2(274.41,247.56)
  L13_SIGNAL w0.091: 275.84,247.23 276.9,247.23 280.67,243.46 280.67,240.92 278.89,239.14 278.89,238.5 276.96,236.57 276.96,227.29 280.94,223.31 280.94,218.12 280.5,217.68 280.14,217.68 278.66,216.2 278.66,212.87 277.55,211.75 277.55,207.73 276.46,206.64 276.46,205.1 275.84,204.48 275.84,203.23 275.31,202.7 275.31,195.94 274.89,195.51 274.89,192.98 281.13,186.74 281.13,181.46 279.78,180.11 278.58,180.11 276.17,177.7 276.17,166.47 279.2,163.44 279.2,156.49 277.03,154.32 277.03,149.2 272.64,144.81 267.52,144.81 266.09,143.38 265.4,143.38 257.35,135.33 249.83,135.33 240.59,126.09 220.7,126.09 219.63,125.02 208.31,125.02 207.7,125.63 150.12,125.63 135.85,111.35 81.91,111.35 75.79,105.24 75.79,78.6 54.21,57.02 47.12,57.02 D127.14
D12715: length 403.9
  L13_SIGNAL w0.091: v2(275.71,248.2) 278.08,248.2 281.05,245.24 281.05,239.4 280.22,238.56 279.58,238.56 277.38,236.36 277.38,227.46 281.36,223.48 281.36,217.83 280.57,217.04 280.11,217.04 279.09,216.02 279.09,211.95 278.58,211.44 278.58,208.14 276.88,206.45 276.88,204.93 276.26,204.31 276.26,203.01 275.68,202.42 275.68,195.55 275.25,195.13 275.25,193.17 281.55,186.88 281.55,181.32 276.56,176.33 276.56,166.68 279.58,163.66 279.58,156.11 278.84,155.37 278.84,146.28 270,137.44 263.73,137.44 261.16,134.87 250.82,134.87 248.91,132.96 248.07,132.96 240.77,125.65 220.88,125.65 219.76,124.54 208.13,124.54 207.49,125.17 150.31,125.17 136.03,110.9 82.09,110.9 76.21,105.01 76.21,76.98 54.12,54.89 49.25,54.89 D127.15
D12716: length 393.2
  L13_SIGNAL w0.076: v2(273.76,246.91) 274.08,246.58 275.8,246.58
  L13_SIGNAL w0.091: 275.8,246.58 276.79,246.58 279.27,244.09 279.27,240.67 277.8,239.2 277.8,237.92 276.54,236.67 276.54,227.12 280.49,223.16 280.49,218.52 280.22,218.24 280.11,218.24 278.03,216.16 277.48,216.16 275.42,214.1 275.42,203.33 274.93,202.84 274.93,196.22 274.52,195.81 274.52,192.81 279.4,187.93 279.4,181.46 274.57,176.63 274.57,167.47 278.83,163.22 278.83,156.73 275.24,153.14 275.24,150.2 274.35,149.3 269.34,149.3 267.61,147.57 267.61,146.94 256.54,135.86 249.73,135.86 248.7,134.84 248.04,134.84 239.75,126.54 220.55,126.54 219.48,125.48 208.51,125.48 207.9,126.09 149.96,126.09 135.71,111.84 81.79,111.84 75.37,105.42 75.37,78.78 54.1,57.51 51.71,57.51 D127.16
D12801: length 509.3
  L19_SIGNAL w0.076: 310.83,251.01 310.83,250.02 310.83,248.53 v2(310.5,248.2)
  L19_SIGNAL w0.102: 310.83,251.01 310.83,251.21 311.74,252.11 312.27,252.11 312.87,252.71 316.36,252.71 317.33,251.74 318.14,251.74 320.53,249.36 320.53,238.77 318.39,236.63 318.11,236.63 316.53,235.05 312.97,235.05 308.37,230.45 306.03,230.45 303.81,228.23 303.18,228.23 302.17,227.23 302.17,225.57 298.78,222.17 290.5,222.17 289.48,221.16 281.48,221.16 280.56,220.24 280.56,218.36 278.91,216.71 250.82,216.71 248.79,214.68 244.3,214.68 243.64,214.02 243.64,213.11 243.33,212.8 242.65,212.8 240.94,211.1 240.94,210.11 240.31,209.47 237.03,209.47 236.58,209.02 235.8,209.02 234.25,210.57 233.86,210.57 233.48,210.19 229.84,210.19 229.41,209.75 227.56,209.75 226.26,211.05 210.22,211.05 203.03,203.85 203.03,125.14 202,124.12 202,122.27 185.98,106.24 81.68,106.24 64.44,89 64.44,36.47 54.4,26.43 20.43,26.43 19.06,27.8 19.06,29.2 D128.01
D12802: length 500
  L13_SIGNAL w0.091: D128.02 21.92,44.78 63.8,44.78 79.57,60.54 79.57,99.56 84.56,104.55 134.84,104.55 149.52,119.23 242.49,119.23 251.66,128.4 275.46,128.4 282.07,135 282.07,139.06 286.61,143.61 286.61,150.39 290.37,154.15 290.37,163.58 288.95,165 284.07,165 280.59,168.48 280.59,174.55 281.69,175.64 285.46,175.64 287.67,177.85 287.67,190.44 283.6,194.5 281.34,194.5 280.48,195.36 280.48,200.9 289.42,209.84 289.42,217.09 290.37,218.05 290.37,225.14 290.85,225.61 290.85,232.9 286.89,236.85 286.89,249.56 282.77,253.69 280.22,253.69 274.19,259.71 274.19,267.59 272.19,269.6 v2(272.19,271.11)
  BOTTOM w0.16: UNK2U449.3 v2(272.19,271.11)
D12803: length 500.4
  L19_SIGNAL w0.076: v2(311.16,248.2) 311.48,248.53 311.48,250.98
  L19_SIGNAL w0.102: 311.48,250.98 311.48,251.09 311.9,251.52 312.41,251.52 313.17,252.28 316.06,252.28 319.26,249.08 319.26,238.36 316.79,235.89 315.55,235.89 315.29,236.14 313.3,236.14 308.12,230.96 305.22,230.96 301.79,227.53 300.99,227.53 299.99,226.53 299.99,224.61 298.8,223.42 290.75,223.42 288.9,221.56 280.16,221.56 279.52,220.93 279.52,217.98 278.71,217.17 250.57,217.17 248.51,215.11 243.81,215.11 242.57,213.87 242.57,213.39 239.88,210.69 239.01,210.69 238.3,209.98 236.14,209.98 234.9,211.23 233.95,211.23 233.31,210.59 230.63,210.59 230.45,210.77 228.98,210.77 227.61,212.14 210.7,212.14 202.6,204.03 202.6,125.32 201.57,124.3 201.57,122.44 185.8,106.67 81.5,106.67 64.01,89.18 64.01,36.7 54.21,26.9 25.05,26.9 24.21,27.73 24.21,29.13 D128.03
D12804: length 477.4
  L13_SIGNAL w0.091: D128.04 26.52,44.3 63.91,44.3 79.98,60.37 79.98,99.14 84.73,103.89 134.82,103.89 147.17,116.23 242.98,116.23 254.69,127.94 276.38,127.94 282.57,134.14 282.57,138.23 287.05,142.7 287.05,150.16 290.79,153.91 290.79,163.75 290.17,164.37 290.17,172.48 288.62,174.03 288.62,194.35 290.17,195.9 290.17,217.25 290.79,217.87 290.79,225.04 291.21,225.46 291.21,233.17 287.65,236.73 287.65,250.32 283.84,254.13 280.53,254.13 274.83,259.83 274.83,267.72 273.18,269.36 v2(273.18,271.1)
  BOTTOM w0.16: v2(273.18,271.1) 272.69,270.61 UNK2U449.4
D12805: length 487.5
  L19_SIGNAL w0.076: 312.78,251.01 312.78,248.53 v2(312.46,248.2)
  L19_SIGNAL w0.102: D128.05 29.43,28.99 54.2,28.99 63.57,38.35 63.57,89.37 81.32,107.12 182.49,107.12 201.33,125.95 201.33,204.68 209.22,212.57 227.86,212.57 229.21,211.23 230.4,211.23 230.96,211.79 234.98,211.79 235.81,210.95 237.16,210.95 237.87,211.66 239.45,211.66 244.09,216.31 248.95,216.31 250.24,217.6 278.46,217.6 279.06,218.21 279.06,222.58 280.33,223.85 298.62,223.85 299.53,224.76 299.53,226.66 300.89,228.02 301.67,228.02 305.12,231.47 307.99,231.47 313.41,236.89 316.98,236.89 318.8,238.71 318.8,248.61 315.71,251.69 313.35,251.69 312.78,251.12 312.78,251.01
D12806: length 444.9
  L15_SIGNAL w0.076: 233.45,251.08 234.08,250.45 234.08,247.88 v2(234.41,247.56)
  L15_SIGNAL w0.091: D128.06 24,39.5 13.39,39.5 10.59,42.29 10.59,99.24 14.86,103.5 56.21,103.5 80.67,127.97 80.67,249 90.55,258.88 107.21,258.88 109.85,261.52 131.34,261.52 141.77,251.09 208.35,251.09 210.5,253.25 216.58,253.25 217.47,252.35 225.6,252.35 226.11,252.86 229.13,252.86 230.45,251.54 232.99,251.54 233.45,251.08
D12807: length 476.8
  L19_SIGNAL w0.076: v2(313.76,248.2) 314.08,248.53 314.08,249.79
  L19_SIGNAL w0.102: 314.08,249.79 314.08,250.65 314.7,251.26 315.46,251.26 317.73,248.99 317.73,239.81 316.24,238.31 310.49,238.31 300.81,228.63 300.81,228.52 299.13,226.84 299.13,224.93 298.47,224.28 280.11,224.28 278.53,222.71 278.53,218.47 278.1,218.03 250.04,218.03 248.74,216.74 243.87,216.74 239.32,212.19 230.71,212.19 230.28,211.76 229.39,211.76 228.09,213.06 209.08,213.06 200.82,204.8 200.82,126.16 182.28,107.62 81.11,107.62 63.06,89.58 63.06,38.51 53.97,29.42 34.08,29.42 D128.07
D12808: length 390.1
  L19_SIGNAL w0.076: v2(231.16,248.2) 231.48,248.53 231.48,250.98
  L19_SIGNAL w0.102: D128.08 36.85,44.47 36.85,46.15 37.49,46.79 54.44,46.79 57.14,49.48 57.14,98.83 81.65,123.35 146.5,123.35 150.21,127.07 182.04,127.07 190.27,135.3 190.27,181.23 192.78,183.74 192.78,213.93 200.02,221.18 207.76,221.18 209.88,223.29 219.81,223.29 222.17,225.65 222.17,227.23 223.18,228.23 223.81,228.23 226.03,230.45 228.37,230.45 232.97,235.05 235.2,235.05 239.37,239.22 239.37,248.96 236.06,252.28 233.17,252.28 232.41,251.52 231.9,251.52 231.48,251.09 231.48,250.98
D12809: length 454.6
  L19_SIGNAL w0.254: 267.24,250.17 v2(268.55,248.85)
  L19_SIGNAL w0.508: D128.09 36.81,31.77 53.87,31.77 62.36,40.26 62.36,91.43 81.95,111.02 142.45,111.02 150.9,119.47 190.66,119.47 200.18,129 200.18,206.41 208.25,214.48 228.73,214.48 230.35,212.85 238.28,212.85 242.85,217.42 248.28,217.42 250.77,219.91 268.12,219.91 270,221.79 270,227.13 274.26,231.39 278.1,231.39 278.86,232.16 278.86,232.78 282.86,236.78 282.86,251.39 280.3,253.95 277.76,253.95 276.26,255.45 273.3,255.45 272.92,255.07 270.63,255.07 270.23,255.47 269.51,255.47 267.83,253.79 267.83,251.82 267.24,251.23 267.24,250.17
D12810: length 394.6
  L19_SIGNAL w0.254: v2(228.56,249.5) 229.11,250.06
  L19_SIGNAL w0.508: 229.11,250.06 229.11,250.91 229.54,251.34 229.54,252.46 230.53,253.44 231.25,253.44 231.6,253.08 232.37,253.08 233.26,253.98 236.21,253.98 237.76,252.43 239.87,252.43 241.26,251.03 241.26,237.22 237.6,233.55 233.55,233.55 227.48,227.48 223.57,227.48 222.86,226.77 222.86,222.5 221.82,221.46 209.4,221.46 208.44,220.5 201.6,220.5 193.5,212.41 193.5,182.06 190.92,179.48 190.92,133.73 183.59,126.4 150.5,126.4 144.44,120.34 81.69,120.34 57.89,96.53 57.89,48.19 54.11,44.41 41.87,44.41 D128.10
D12811: length 437.3
  L19_SIGNAL w0.254: v2(268.55,249.5) 269.11,250.06
  L19_SIGNAL w0.508: D128.11 39.4,34.26 53.79,34.26 61.45,41.92 61.45,91.8 81.57,111.93 142.07,111.93 150.52,120.38 187.26,120.38 190.99,124.12 192.05,124.12 198.62,130.68 198.62,164.4 198.6,164.42 198.6,207.54 206.56,215.5 209.47,215.5 210.58,216.61 227.91,216.61 229.67,214.86 238.28,214.86 241.78,218.36 247.85,218.36 250.93,221.44 262.29,221.44 262.86,222.01 262.86,226.77 263.57,227.48 267.48,227.48 273.55,233.55 277.6,233.55 281.26,237.22 281.26,251.03 279.87,252.43 277.76,252.43 276.21,253.98 273.26,253.98 272.37,253.08 271.6,253.08 271.25,253.44 270.53,253.44 269.54,252.46 269.54,251.34 269.11,250.91 269.11,250.06
D12812: length 399.8
  L19_SIGNAL w0.254: v2(228.56,248.85) 227.24,250.17
  L19_SIGNAL w0.508: 227.24,250.17 227.24,251.23 227.83,251.82 227.83,253.79 229.51,255.47 230.23,255.47 230.63,255.07 232.92,255.07 233.3,255.45 236.26,255.45 237.76,253.95 240.3,253.95 242.86,251.39 242.86,236.78 238.86,232.78 238.86,232.16 238.1,231.39 234.26,231.39 230,227.13 230,221.79 228.12,219.91 209.17,219.91 208.16,218.9 202.47,218.9 195.13,211.56 195.13,181.19 193.06,179.12 193.06,133.31 185.29,125.53 150.86,125.53 144.8,119.47 82.05,119.47 58.75,96.18 58.75,46.57 54.12,41.94 44.48,41.94 D128.12
D12813: length 420.5
  L19_SIGNAL w0.076: v2(271.16,248.2) 271.48,248.53 271.48,250.98
  L19_SIGNAL w0.102: D128.13 44.64,37.02 54.14,37.02 60.32,43.2 60.32,94.01 81.82,115.51 143.38,115.51 151.74,123.87 188.45,123.87 197.49,132.91 197.49,209.2 204.88,216.59 208.69,216.59 209.88,217.78 228.76,217.78 229.49,217.06 238.59,217.06 239.52,217.98 239.52,219.17 241.92,221.56 248.9,221.56 250.75,223.42 258.8,223.42 259.99,224.61 259.99,226.53 260.99,227.53 261.79,227.53 265.22,230.96 268.12,230.96 273.3,236.14 275.29,236.14 275.55,235.89 276.79,235.89 279.26,238.36 279.26,249.08 276.06,252.28 273.17,252.28 272.41,251.52 271.9,251.52 271.48,251.09 271.48,250.98
D12814: length 410.7
  L19_SIGNAL w0.076: v2(273.76,248.2) 274.08,248.53 274.08,249.79
  L19_SIGNAL w0.102: 274.08,249.79 274.08,250.65 274.7,251.26 275.46,251.26 277.73,248.99 277.73,239.81 276.24,238.31 270.49,238.31 260.81,228.63 260.81,228.52 259.13,226.84 259.13,224.93 258.47,224.28 240.11,224.28 238.53,222.71 238.53,218.47 238.05,217.98 229.84,217.98 228.55,219.28 209.85,219.28 208.86,218.29 204.04,218.29 195.83,210.08 195.83,180.13 195.24,179.54 195.24,133.25 186.77,124.78 151.36,124.78 143,116.42 81.44,116.42 59.4,94.39 59.4,44.59 54.38,39.57 47.19,39.57 D128.14
D12815: length 418.6
  L19_SIGNAL w0.076: 270.83,251.01 270.83,250.02 270.83,248.53 v2(270.5,248.2)
  L19_SIGNAL w0.102: D128.15 49.3,36.6 54.38,36.6 60.77,43 60.77,93.82 82.01,115.05 143.57,115.05 151.93,123.41 188.64,123.41 197.94,132.72 197.94,164.11 197.93,164.13 197.93,209 205.06,216.13 209.04,216.13 210.15,217.25 228.7,217.25 229.35,216.6 238.8,216.6 240.56,218.36 240.56,219.63 242.09,221.16 249.48,221.16 250.5,222.17 258.78,222.17 262.17,225.57 262.17,227.23 263.18,228.23 263.81,228.23 266.03,230.45 268.37,230.45 272.97,235.05 276.53,235.05 278.11,236.63 278.39,236.63 280.53,238.77 280.53,249.36 278.14,251.74 277.33,251.74 276.36,252.71 272.87,252.71 272.27,252.11 271.74,252.11 270.83,251.21 270.83,251.01
D12816: length 409.7
  L19_SIGNAL w0.076: 272.78,251.01 272.78,248.53 v2(272.46,248.2)
  L19_SIGNAL w0.102: D128.16 51.78,39.08 54.58,39.08 59.83,44.33 59.83,94.21 81.61,115.99 143.18,115.99 151.54,124.35 186.95,124.35 195.67,133.07 195.67,179.24 196.26,179.83 196.26,209.9 204.14,217.78 209.22,217.78 209.68,218.24 228.96,218.24 229.64,217.55 238.4,217.55 239.06,218.21 239.06,222.58 240.33,223.85 258.62,223.85 259.53,224.76 259.53,226.66 260.89,228.02 261.67,228.02 265.12,231.47 267.99,231.47 273.41,236.89 276.98,236.89 278.8,238.71 278.8,248.61 275.71,251.69 273.35,251.69 272.78,251.12 272.78,251.01
D12901: length 340.1
  L25_SIGNAL w0.079: 90.08,98.31 90.08,104.7 90.85,105.48 121.22,105.48 122.11,106.37 122.11,128.08 123.34,129.31 127.48,129.31 128.46,128.32 128.46,104.21 128.85,103.83 131.63,103.83 132.01,104.21 132.01,130.24 124.52,137.73 124.52,143.66 126.35,145.48 156.91,145.48 157.41,145.98 157.41,151.45 156.91,151.95 133.52,151.95 131.62,153.86 131.62,156.64 132.91,157.93 209.37,157.93 216.74,165.29 218.06,165.29 220.6,167.83 220.6,172.7 217.86,175.44 212,175.44 209.6,177.84 209.6,191.49 210.14,192.02 211.24,192.02 211.5,191.76 211.5,191.38 211.51,191.36
  L25_SIGNAL w0.091: 90.08,98.31 89.66,97.89 87.73,97.89 D129.01 ; 211.51,191.36 v1(211.66,191.22)
D12902: length 285.6
  L31_SIGNAL w0.079: 251.51,191.36 251.51,191.75 251.24,192.02 250.14,192.02 249.6,191.49 249.6,177.84 252,175.44 257.86,175.44 260.6,172.7 260.6,167.83 258.06,165.29 256.74,165.29 250.76,159.32 250.76,125.94 248.09,123.27 248.09,108.79 245.85,106.55 146.57,106.55 142.42,110.7 142.42,114.57 140.5,116.49 91,116.49 90.02,115.5 90.02,112.75 94.1,108.66 94.1,106.86 91.34,104.1 91.34,101.5
  L31_SIGNAL w0.091: 91.34,101.5 D129.02 ; v1(251.66,191.22) 251.51,191.36
D12903: length 340.1
  L25_SIGNAL w0.079: 211.31,191.36 211.31,191.68 211.16,191.83 210.22,191.83 209.8,191.41 209.8,177.92 212.08,175.63 217.94,175.63 220.8,172.78 220.8,167.75 218.14,165.1 216.82,165.1 209.45,157.73 132.99,157.73 131.81,156.56 131.81,153.94 133.6,152.15 156.99,152.15 157.61,151.53 157.61,145.9 156.99,145.29 126.43,145.29 124.71,143.58 124.71,137.81 132.21,130.32 132.21,104.13 131.71,103.63 128.77,103.63 128.27,104.13 128.27,128.24 127.4,129.12 123.42,129.12 122.3,128 122.3,106.29 121.3,105.28 90.93,105.28 90.27,104.62 90.27,103.92 90.35,103.84 90.52,103.84 90.6,103.77 90.6,103.61 90.52,103.53 90.35,103.53 90.27,103.45 90.27,103.29 90.35,103.21 90.52,103.21 90.6,103.14 90.6,102.98 90.52,102.9 90.35,102.9 90.27,102.82 90.27,102.66 90.35,102.58 90.52,102.58 90.6,102.51 90.6,102.35 90.52,102.27 90.35,102.27 90.27,102.19 90.27,102.03 90.35,101.95 90.52,101.95 90.6,101.88 90.6,101.72 90.52,101.64 90.35,101.64 90.27,101.56 90.27,101.4 90.35,101.32 90.52,101.32 90.6,101.25 90.6,101.09 90.52,101.01 90.35,101.01 90.27,100.93 90.27,100.77 90.35,100.69 90.52,100.69 90.6,100.62 90.6,100.46 90.52,100.38 90.35,100.38 90.27,100.3 90.27,97.69
  L25_SIGNAL w0.091: D129.03 90.27,97.69 ; 211.31,191.36 v1(211.16,191.22)
D12904: length 285.6
  L31_SIGNAL w0.079: 251.31,191.36 251.31,191.68 251.16,191.83 250.22,191.83 249.8,191.41 249.8,177.92 252.08,175.63 257.94,175.63 260.8,172.78 260.8,167.75 258.14,165.1 256.82,165.1 250.95,159.24 250.95,125.86 248.28,123.19 248.28,108.71 245.93,106.36 146.49,106.36 142.23,110.62 142.23,114.49 140.42,116.3 91.08,116.3 90.21,115.42 90.21,112.83 94.29,108.74 94.29,106.78 93.53,106.01 93.53,105.9 93.56,105.87 93.56,105.76 93.45,105.65 93.34,105.65 93.31,105.68 93.19,105.68 93.08,105.57 93.08,105.46 93.11,105.43 93.11,105.32 93,105.2 92.89,105.2 92.86,105.23 92.75,105.23 92.64,105.12 92.64,105.01 92.67,104.98 92.67,104.87 92.56,104.76 92.44,104.76 92.41,104.79 92.3,104.79 91.54,104.02 91.54,101.5
  L31_SIGNAL w0.091: v1(251.16,191.22) 251.31,191.36 ; 91.54,101.5 D129.04
D12905: length 304.3
  L15_SIGNAL w0.079: 254.38,117.98 254,117.98 253.36,117.35 253.36,113.79 247.59,108.02 147.15,108.02 146.01,109.16 146.01,115.12 144.93,116.2 137.74,116.2 136.49,114.95 136.49,109.18 135.33,108.02 103.4,108.02 100.75,105.37 100.64,105.37 100.54,105.47 100.43,105.47 100.32,105.36 100.32,105.25 100.42,105.15 100.42,105.04 100.31,104.93 100.19,104.93 100.09,105.03 99.98,105.03 99.87,104.91 99.87,104.8 99.97,104.7 99.97,104.59 99.86,104.48 99.75,104.48 99.65,104.58 99.54,104.58 99.43,104.47 99.43,104.36 99.53,104.26 99.53,104.15 99.41,104.03 99.3,104.03 99.2,104.13 99.09,104.13 98.98,104.02 98.98,103.91 99.08,103.81 99.08,103.7 97.54,102.16 97.54,98.51
  L15_SIGNAL w0.091: v3(255.77,118.56) 254.96,118.56 254.38,117.98 ; 97.54,98.51 97.54,97.54 D129.05
  L29_SIGNAL w0.079: v3(255.77,118.56) 255.98,118.56 256.64,117.9 257.16,117.9 257.24,117.98 257.24,122.89 260.65,126.3 262.42,126.3 265.86,129.74 268.2,129.74 273.4,134.94 278.59,134.94 278.96,134.57 281.36,134.57 281.81,135.01 285.78,135.01 290.13,139.36 290.13,154.86 289.12,155.87 289.12,157.68 296.74,165.29 298.06,165.29 300.6,167.83 300.6,172.7 297.86,175.44 292,175.44 289.28,178.17 289.28,191.16 290.14,192.02 291.24,192.02 291.51,191.75 291.51,191.36
  L29_SIGNAL w0.091: v1(291.66,191.22) 291.51,191.36
D12906: length 342.5
  L23_SIGNAL w0.079: 336.68,122.05 336.25,122.05 335.97,122.32 335.97,123.74 333.29,126.43 150.03,126.43 128.76,105.16 104.14,105.16 101.51,102.52 101.51,101.51
  L23_SIGNAL w0.091: 336.68,122.05 337.39,122.76 v3(338.07,122.76) ; 101.51,101.51 D129.06
  L27_SIGNAL w0.079: 338.84,122.17 339.45,122.17 339.53,122.25 339.53,124.89 334.83,129.59 334.83,136.99 335.72,137.88 335.72,149.91 333.82,151.81 333.82,162.59 336.49,165.27 338.04,165.27 340.6,167.83 340.6,172.7 337.86,175.44 332,175.44 329.6,177.84 329.6,191.49 330.14,192.02 331.24,192.02 331.51,191.75 331.51,191.36
  L27_SIGNAL w0.091: v3(338.07,122.76) 338.26,122.76 338.84,122.17 ; v1(331.66,191.22) 331.51,191.36
D12907: length 304.3
  L15_SIGNAL w0.079: 254.38,117.79 254.08,117.79 253.56,117.27 253.56,113.71 247.67,107.83 147.07,107.83 145.82,109.08 145.82,115.04 144.85,116.01 137.82,116.01 136.69,114.87 136.69,109.1 135.41,107.82 103.48,107.82 97.73,102.08 97.73,98.61
  L15_SIGNAL w0.091: 254.38,117.79 255.13,117.04 v3(255.77,117.04) ; D129.07 100.33,97.79 98.55,97.79 98.17,98.17 97.73,98.61
  L29_SIGNAL w0.079: 291.31,191.36 291.31,191.68 291.16,191.83 290.22,191.83 289.47,191.08 289.47,178.25 292.08,175.63 297.94,175.63 300.8,172.78 300.8,167.75 298.14,165.1 296.82,165.1 289.32,157.6 289.32,155.95 290.32,154.94 290.32,139.28 285.86,134.82 281.89,134.82 281.44,134.38 278.88,134.38 278.51,134.75 273.48,134.75 268.28,129.55 265.94,129.55 262.5,126.11 260.73,126.11 257.43,122.81 257.43,117.9 257.24,117.71 256.64,117.71 255.97,117.04 v3(255.77,117.04)
  L29_SIGNAL w0.091: v1(291.16,191.22) 291.31,191.36
D12908: length 342.5
  L23_SIGNAL w0.079: 101.7,101.5 101.7,102.44 102.49,103.23 102.6,103.23 102.63,103.21 102.74,103.21 102.85,103.32 102.85,103.43 102.83,103.46 102.83,103.57 102.94,103.68 103.05,103.68 103.07,103.65 103.19,103.65 103.3,103.77 103.3,103.88 103.27,103.9 103.27,104.01 103.38,104.13 103.49,104.13 103.52,104.1 103.63,104.1 103.74,104.21 103.74,104.32 103.72,104.35 103.72,104.46 104.22,104.96 128.84,104.96 150.11,126.23 333.21,126.23 335.78,123.66 335.78,122.24 336.17,121.85 336.68,121.85
  L23_SIGNAL w0.091: 336.68,121.85 337.3,121.23 v3(338.07,121.23) ; 101.7,101.5 D129.08
  L27_SIGNAL w0.079: 338.9,121.98 339.53,121.98 339.72,122.17 339.72,124.97 335.03,129.67 335.03,136.91 335.91,137.8 335.91,149.99 334.01,151.89 334.01,162.51 336.57,165.08 338.12,165.08 340.8,167.75 340.8,172.78 337.94,175.63 332.08,175.63 329.8,177.92 329.8,191.41 330.22,191.83 331.16,191.83 331.31,191.68 331.31,191.36
  L27_SIGNAL w0.091: v1(331.16,191.22) 331.31,191.36 ; v3(338.07,121.23) 338.15,121.23 338.9,121.98
D12909: length 340.1
  L25_SIGNAL w0.079: 211.51,180.82 211.51,181.65 211.76,181.9 217.68,181.9 218.65,180.92 218.65,178.82 221.59,175.88 221.59,171.96 222.19,171.35 222.19,165.71 221.5,165.02 220.17,165.02 215.2,160.05 215.2,156.29 214.04,155.13 210.39,155.13 208.36,157.17 134.03,157.17 132.65,155.78 132.65,154.37 134.18,152.84 159.56,152.84 160.41,151.99 160.41,145.32 159.69,144.59 127.94,144.59 126.57,143.23 126.57,140.49 127.81,139.25 142.86,139.25 144.38,137.74 144.38,133.06 142.83,131.51 135.3,131.51 132.9,129.11 132.9,102.06 132,101.16 128.48,101.16 127.57,102.06 127.57,124.92 126.95,125.55 123.88,125.55 123,124.67 123,106 121.59,104.59 111.68,104.59 110.4,103.31 110.4,98.31
  L25_SIGNAL w0.091: D129.09 108.05,97.89 109.98,97.89 110.4,98.31 ; 211.51,180.82 211.68,180.64 212.05,180.64 212.53,180.16 212.53,179.21 211.97,178.65 v1(211.66,178.65)
D12910: length 285.6
  L31_SIGNAL w0.079: 111.66,101.5 111.66,103.05 112.46,103.85 112.46,103.96 112.44,103.99 112.44,104.1 112.55,104.21 112.66,104.21 112.69,104.18 112.8,104.18 112.91,104.29 112.91,104.4 112.88,104.43 112.88,104.54 112.99,104.66 113.1,104.66 113.13,104.63 113.24,104.63 113.36,104.74 113.36,104.85 113.33,104.88 113.33,104.99 113.44,105.1 113.55,105.1 113.58,105.07 113.69,105.07 114.08,105.47 114.08,110.11 112.36,111.83 98.53,111.83 97.78,112.58 97.78,114.95 98.32,115.49 140.08,115.49 141.42,114.15 141.42,110.29 146.16,105.55 248.02,105.55 250,107.52 250,123.52 252.28,125.81 252.28,138.51 253.81,140.03 253.81,154.9 255.2,156.29 255.2,160.05 260.17,165.02 261.5,165.02 262.19,165.71 262.19,171.35 261.59,171.96 261.59,175.88 258.65,178.82 258.65,180.92 257.68,181.9 251.76,181.9 251.51,181.65 251.51,180.82
  L31_SIGNAL w0.091: 111.66,101.5 D129.10 ; 251.51,180.82 251.68,180.64 252.05,180.64 252.53,180.16 252.53,179.21 251.97,178.65 v1(251.66,178.65)
D12911: length 340.1
  L25_SIGNAL w0.079: 110.59,97.69 110.59,99.81 110.67,99.89 110.8,99.89 110.88,99.97 110.88,100.13 110.8,100.21 110.67,100.21 110.59,100.29 110.59,100.44 110.67,100.52 110.8,100.52 110.88,100.6 110.88,100.76 110.8,100.84 110.67,100.84 110.59,100.92 110.59,101.07 110.67,101.15 110.8,101.15 110.88,101.23 110.88,101.39 110.8,101.47 110.67,101.47 110.59,101.55 110.59,101.7 110.67,101.78 110.8,101.78 110.88,101.86 110.88,102.02 110.8,102.1 110.67,102.1 110.59,102.18 110.59,103.23 111.76,104.39 121.67,104.39 123.19,105.92 123.19,124.59 123.96,125.35 126.87,125.35 127.38,124.84 127.38,101.98 128.4,100.96 132.08,100.96 133.1,101.98 133.1,129.03 135.38,131.32 142.91,131.32 144.57,132.98 144.57,137.82 142.94,139.45 127.89,139.45 126.76,140.57 126.76,143.15 128.02,144.4 159.77,144.4 160.61,145.24 160.61,152.07 159.64,153.03 134.26,153.03 132.84,154.45 132.84,155.7 134.11,156.97 208.28,156.97 210.31,154.94 214.12,154.94 215.39,156.21 215.39,159.97 220.25,164.83 221.58,164.83 222.39,165.63 222.39,171.43 221.78,172.04 221.78,175.96 218.85,178.9 218.85,181 217.76,182.09 211.68,182.09 211.31,181.73 211.31,180.82
  L25_SIGNAL w0.091: 110.59,97.69 D129.11 ; 211.31,180.82 211.13,180.64 210.77,180.64 210.29,180.16 210.29,179.21 210.85,178.65 v1(211.16,178.65)
D12912: length 285.6
  L31_SIGNAL w0.079: 111.86,101.5 111.86,102.97 114.28,105.39 114.28,110.19 112.44,112.02 98.61,112.02 97.97,112.66 97.97,114.87 98.4,115.3 140,115.3 141.23,114.07 141.23,110.21 146.08,105.36 248.1,105.36 250.19,107.44 250.19,123.44 252.48,125.73 252.48,138.43 254,139.95 254,154.82 255.39,156.21 255.39,159.97 260.25,164.83 261.58,164.83 262.39,165.63 262.39,171.43 261.78,172.04 261.78,175.96 258.85,178.9 258.85,181 257.76,182.09 251.68,182.09 251.31,181.73 251.31,180.82
  L31_SIGNAL w0.091: 111.86,101.5 D129.12 ; 251.31,180.82 251.13,180.64 250.77,180.64 250.29,180.16 250.29,179.21 250.85,178.65 v1(251.16,178.65)
