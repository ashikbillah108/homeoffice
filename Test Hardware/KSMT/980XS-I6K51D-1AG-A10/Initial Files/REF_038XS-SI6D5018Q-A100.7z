# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D11310: length 223.7
  L17_SIGNAL w0.508: v2(280.33,270.23) 280.57,270.48
  L17_SIGNAL w0.762: 281.25,278.28 281.25,274.75 281.07,274.57
  L17_SIGNAL w1.016: 280.57,270.48 281.07,270.98 281.07,274.57 ; D113.10 319.69,324.77 314.9,324.77 312.52,322.4 304.23,322.4 298.65,327.98 298.65,332.44 289.92,341.16 282.25,341.16 280.8,339.72 280.8,322.44 279.26,320.9 279.26,305.99 277.14,303.87 257.92,303.87 256.6,302.55 256.6,286.31 257.86,285.05 259.79,285.05 260.81,284.03 260.81,281.24 261.46,280.59 262.23,280.59 263.23,281.59 265.27,281.59 266.11,282.43 266.11,295.64 264.89,296.86 264.89,301.35 265.83,302.3 270.19,302.3 270.98,301.52 270.98,297.66 270.99,297.64 270.99,297.56 271.84,296.71 274,296.71 274.85,297.56 274.85,300.43 275.86,301.45 279.95,301.45 281.07,300.33 281.07,278.46 281.25,278.28
  BOTTOM w0.305: v2(280.33,270.23) 279.83,269.74 UNK2U450.4
D11311: length 223.7
  L17_SIGNAL w0.508: v2(240.33,270.23) 240.57,270.48
  L17_SIGNAL w0.762: 241.07,274.57 241.25,274.75 241.25,278.28
  L17_SIGNAL w1.016: 240.57,270.48 241.07,270.98 241.07,274.57 ; 241.25,278.28 241.07,278.46 241.07,284.23 241.67,284.82 242.6,284.82 243.06,285.28 243.06,301.84 241.89,303.01 241.89,320.61 240.85,321.65 238.18,321.65 237.34,320.81 237.34,305.32 235.94,303.92 232.97,303.92 231.74,305.14 231.74,347.83 235.12,351.21 295.48,351.21 306.44,340.25 315.07,340.25 D113.11
  BOTTOM w0.305: U450.4 239.83,269.74 v2(240.33,270.23)
D11312: length 206.3
  L17_SIGNAL w0.508: 279.42,271.51 v2(279.08,271.17)
  L17_SIGNAL w1.016: D113.12 316.08,326.24 314.08,326.24 311.94,324.1 305,324.1 300.61,328.49 300.61,333.34 290.91,343.05 278.68,343.05 277.5,341.87 277.5,339.84 279.26,338.08 279.26,323.55 276.63,320.92 276.63,306.58 275.37,305.33 255.77,305.33 254.66,304.21 254.66,283.33 255.2,282.79 256.36,282.79 256.66,282.49 256.66,277.32 257.38,276.61 268.22,276.61 268.75,277.14 268.75,277.19 268.92,277.35 268.92,289.95 271.39,292.43 273.99,292.43 275,291.42 275,284.89 272.91,282.8 272.91,275.11 273.48,274.54 278.41,274.54 279.01,273.94 279.01,272.8 279.42,272.39 279.42,271.51
  BOTTOM w0.305: UNK2U450.2 278.83,270.56 279.08,270.81 v2(279.08,271.17)
D11313: length 264.1
  L17_SIGNAL w0.508: 245.6,271.9 v2(245.6,271.22)
  L17_SIGNAL w1.016: D113.13 311.72,338.52 305.93,338.52 294.83,349.62 238.12,349.62 233.57,345.08 233.57,324.98 235.03,323.53 241.87,323.53 243.34,325 243.34,335.12 244.37,336.14 247.67,336.14 248.71,335.11 248.71,329.42 250.6,327.52 262.56,327.52 264.88,329.83 264.88,334.13 265.89,335.15 270.58,335.15 271.71,334.01 271.71,328.31 267.08,323.68 247.29,323.68 245.16,321.55 245.16,275.18 245.6,274.75 245.6,271.9
  BOTTOM w0.305: U452.8 245.9,271.53 v2(245.6,271.22) U451.3
D11314: length 207
  L17_SIGNAL w0.508: 277.37,272.47 278.08,271.75 v2(278.08,271.17)
  L17_SIGNAL w1.016: D113.14 310.58,325.82 305.88,325.82 302.55,329.15 302.55,334.27 292.26,344.55 258.11,344.55 257.39,343.83 257.39,342.71 258.18,341.92 273.28,341.92 277.76,337.44 277.76,324.39 274.95,321.58 274.95,310.18 274.14,309.36 255.26,309.36 253.86,307.96 253.86,305.95 252.61,304.71 252.61,275.28 253.37,274.52 268.9,274.52 270.96,272.47 277.37,272.47
  BOTTOM w0.305: v2(278.08,271.17) 278.08,270.81 278.33,270.56 UNK2U450.1
D11315: length 263.6
  L17_SIGNAL w0.508: v2(246.71,271.22) 247.04,271.22
  L17_SIGNAL w1.016: D113.15 308.27,336.89 305.29,336.89 294.28,347.9 238.98,347.9 235.51,344.44 235.51,326.39 236.46,325.44 240.36,325.44 241.38,326.46 241.38,337.7 242.93,339.26 248.67,339.26 250.71,337.21 250.71,331.14 252.46,329.39 260.97,329.39 262.47,330.89 262.47,335.52 265.01,338.06 271.56,338.06 273.85,335.76 273.85,325.99 270.05,322.19 247.99,322.19 246.7,320.9 246.7,302.02 247.54,301.18 248.64,301.18 249.17,300.65 249.17,272.48 247.92,271.23 247.92,271.22 247.04,271.22
  BOTTOM w0.305: U452.7 246.4,271.53 v2(246.71,271.22) 246.1,270.6 U451.4
D11316: length 224.4
  L17_SIGNAL w0.508: 279.07,269.98 v2(279.33,270.23)
  L17_SIGNAL w1.016: 279.07,269.98 278.3,269.98 276.91,268.58 273.5,268.58 272.38,269.7 271.11,269.7 268.23,272.58 251.25,272.58 250.57,273.26 250.57,312.64 251.51,313.58 269.78,313.58 271.85,315.65 271.85,320.86 275.86,324.87 275.86,336.87 272.73,340 263.82,340 258.64,334.83 255.7,334.83 249.93,340.6 249.93,344.82 251.27,346.17 293.3,346.17 304.36,335.11 304.36,330.05 305.95,328.47 308.15,328.47 D113.16
  BOTTOM w0.305: UNK2U450.3 v2(279.33,270.23)
D11401: length 199.9
  L27_SIGNAL w0.091: v2(235.71,247.56) 236.28,247.56 237.06,248.34 237.06,250.85 236.63,251.28 236.63,253.56 234.99,255.2 234.99,280.04 234.5,280.53 234.5,284.75 235.23,285.48 235.23,296.52 242.29,303.58 242.29,320.27 268.56,346.54 346.05,346.54 346.71,347.2 346.71,351.79 D114.01
D11402: length 154
  L25_SIGNAL w0.091: v2(275.71,247.56) 276.28,247.56 277.06,248.34 277.06,250.85 276.63,251.28 276.63,253.56 274.99,255.2 274.99,280.04 274.5,280.53 274.5,284.75 275.23,285.48 275.23,287.82 284.56,297.15 286.43,297.15 287.12,297.84 287.12,323.94 307.93,344.74 339.66,344.74 D114.02
D11403: length 154.5
  L31_SIGNAL w0.091: v2(315.7,247.56) 316.28,247.56 317.06,248.34 317.06,250.85 316.63,251.28 316.63,253.56 314.99,255.2 314.99,280.04 314.5,280.53 314.5,284.75 315.23,285.48 315.23,295.93 319.77,300.46 319.77,320.44 316.51,323.7 311.81,323.7 304.16,331.34 304.16,342.77 305.56,344.17 339.09,344.17 341.63,346.71 341.63,351.79 D114.03
D11404: length 121.7
  L23_SIGNAL w0.091: v3(351.79,310.7) 350.72,309.63 347.22,309.63 346.46,310.39 346.46,323.34 350.65,327.53 350.65,344.3 345.69,349.25 341.63,349.25 D114.04
  L29_SIGNAL w0.091: v3(351.79,310.7) 352.24,310.7 355.23,307.71 355.23,285.48 354.5,284.75 354.5,280.53 354.99,280.04 354.99,255.2 356.63,253.56 356.63,251.28 357.06,250.85 357.06,248.34 356.28,247.56 v2(355.7,247.56)
D11405: length 190.6
  L27_SIGNAL w0.076: 235.9,247.88 235.38,247.88 v2(235.06,247.56)
  L27_SIGNAL w0.091: 235.9,247.88 236.2,248.18 236.2,251.45 235.26,252.39 235.26,254.33 234.52,255.06 234.52,271.84 233.17,273.2 233.17,284.21 234.86,285.9 234.86,297.59 241.55,304.28 241.55,320.29 268.22,346.96 336.07,346.96 336.55,347.44 336.55,351.79 D114.05
D11406: length 143.7
  L25_SIGNAL w0.076: v2(275.06,247.56) 275.38,247.88 275.9,247.88
  L25_SIGNAL w0.091: D114.06 329.96,345.2 307.79,345.2 284.78,322.2 284.78,299.14 284.11,298.46 284.11,297.27 274.47,287.63 274.47,285.51 273.17,284.21 273.17,273.2 274.52,271.84 274.52,255.06 275.26,254.33 275.26,252.39 276.2,251.45 276.2,248.18 275.9,247.88
D11407: length 145
  L31_SIGNAL w0.076: v2(315.05,247.56) 315.38,247.88 315.9,247.88
  L31_SIGNAL w0.091: D114.07 331.47,351.79 331.47,347.73 330.45,346.71 307.42,346.71 303.66,342.95 303.66,330.83 311.28,323.21 316.31,323.21 319.28,320.24 319.28,300.61 314.86,296.2 314.86,285.9 313.17,284.21 313.17,273.2 314.52,271.84 314.52,255.06 315.26,254.33 315.26,252.39 316.2,251.45 316.2,248.18 315.9,247.88
D11408: length 130
  L23_SIGNAL w0.091: v3(351.79,308.03) 350.63,309.19 347.09,309.19 346.06,310.22 346.06,323.57 350.2,327.71 350.2,343.73 346.84,347.09 333.63,347.09 D114.08
  L29_SIGNAL w0.076: 355.9,247.88 355.38,247.88 v2(355.05,247.56)
  L29_SIGNAL w0.091: v3(351.79,308.03) 353.26,308.03 354.86,306.43 354.86,285.9 353.17,284.21 353.17,273.2 354.52,271.84 354.52,255.06 355.26,254.33 355.26,252.39 356.2,251.45 356.2,248.18 355.9,247.88
D11409: length 178.4
  L27_SIGNAL w0.091: D114.09 326.39,351.79 326.39,349.8 325.84,349.25 269.75,349.25 240.72,320.22 240.72,303.96 234.5,297.74 234.5,286.06 232.8,284.36 232.8,273.04 234.16,271.69 234.16,262.4 233.31,261.55 233.31,254.56 234.89,252.98 234.89,251.85 235.53,251.21 235.53,249.33 v2(235.06,248.85)
D11410: length 132.9
  L25_SIGNAL w0.091: v2(275.06,248.85) 275.53,249.33 275.53,251.21 274.89,251.85 274.89,252.98 273.31,254.56 273.31,261.55 274.16,262.4 274.16,271.69 272.8,273.04 272.8,284.36 274.1,285.66 274.1,289.05 283.4,298.35 283.4,321.58 307.56,345.74 320.34,345.74 D114.10
D11411: length 132.8
  L31_SIGNAL w0.091: v2(315.05,248.85) 315.53,249.33 315.53,251.21 314.89,251.85 314.89,252.98 313.31,254.56 313.31,261.55 314.16,262.4 314.16,271.69 312.8,273.04 312.8,284.36 314.5,286.06 314.5,296.46 315.17,297.13 315.17,297.9 318.77,301.5 318.77,320.03 316.1,322.7 310.89,322.7 303.15,330.44 303.15,343.16 309.24,349.25 320.29,349.25 321.31,350.27 321.31,351.79 D114.11
D11412: length 135.9
  L23_SIGNAL w0.091: v3(347.48,308.03) 347.04,308.03 345.69,309.37 345.69,323.72 349.76,327.78 349.76,343.41 346.71,346.46 324.1,346.46 D114.12
  L29_SIGNAL w0.091: v2(355.05,248.85) 355.53,249.33 355.53,251.21 354.89,251.85 354.89,252.98 353.31,254.56 353.31,261.55 354.16,262.4 354.16,271.69 352.8,273.04 352.8,284.36 354.5,286.06 354.5,301.58 348.05,308.03 v3(347.48,308.03)
D11413: length 171.1
  L27_SIGNAL w0.076: v2(234.41,248.2) 234.08,248.53 234.08,250.08
  L27_SIGNAL w0.508: 234.08,250.08 234.08,251.57 232.89,252.75 232.89,253.95 231.02,255.82 231.02,261.87 229.46,263.43 229.46,266.48 230.49,267.5 230.49,272.56 229.38,273.67 229.38,278.23 230.79,279.64 230.79,283.48 230.17,284.09 230.17,290.54 230.83,291.2 230.83,295.88 240.13,305.18 240.13,320.65 271.27,351.79 316.23,351.79 D114.13
D11414: length 128.5
  L25_SIGNAL w0.076: 274.08,250.08 274.08,248.53 v2(274.41,248.2)
  L25_SIGNAL w0.508: 274.08,250.08 274.08,251.57 272.89,252.75 272.89,253.95 271.02,255.82 271.02,261.87 269.46,263.43 269.46,266.48 270.49,267.5 270.49,272.56 269.38,273.67 269.38,278.23 270.79,279.64 270.79,283.48 270.17,284.09 270.17,291.04 270.83,291.69 272.63,291.69 275.75,294.81 276.72,294.81 277.17,295.26 277.17,296.12 282.77,301.71 282.77,322.21 307.19,346.63 311.07,346.63 D114.14
D11415: length 125.5
  L31_SIGNAL w0.076: 314.08,250.08 314.08,248.53 v2(314.41,248.2)
  L31_SIGNAL w0.508: 314.08,250.08 314.08,251.57 312.89,252.75 312.89,253.95 311.02,255.82 311.02,261.87 309.46,263.43 309.46,266.48 310.49,267.5 310.49,272.56 309.38,273.67 309.38,278.23 310.79,279.64 310.79,283.48 310.17,284.09 310.17,290.74 310.9,291.46 310.9,294.39 313.79,297.28 314.21,297.28 314.59,297.67 314.59,299.61 316.17,301.18 316.17,319.34 313.56,321.94 310.51,321.94 302.51,329.95 302.51,347.6 306.7,351.79 311.15,351.79 D114.15
D11416: length 145.5
  L23_SIGNAL w0.091: v3(347.48,306.5) 347.45,306.5 345.33,308.63 345.33,323.87 349.39,327.94 349.39,343.01 346.58,345.82 314.58,345.82 D114.16
  L29_SIGNAL w0.076: v2(354.4,248.2) 354.08,248.53 354.08,250.08
  L29_SIGNAL w0.508: 354.08,250.08 354.08,251.57 352.89,252.75 352.89,253.95 351.02,255.82 351.02,261.87 349.46,263.43 349.46,266.48 350.49,267.5 350.49,272.56 349.38,273.67 349.38,278.23 350.79,279.64 350.79,283.48 350.17,284.09 350.17,291.75 350.9,292.48 350.9,303.08 v3(347.48,306.5)
D11501: length 215
  L27_SIGNAL w0.076: 232.13,251.08 232.13,249.18 v2(231.81,248.85)
  L27_SIGNAL w0.091: 232.13,251.08 232.13,252.11 230.66,253.58 230.66,255.08 228.77,256.97 228.77,266.74 229.75,267.73 229.75,271.72 228.81,272.67 228.81,295.61 237.06,303.86 237.06,319.23 270.26,352.42 281.02,352.42 290.54,361.95 346.01,361.95 346.71,362.65 346.71,372.11 D115.01
D11502: length 179.8
  L25_SIGNAL w0.076: v2(271.81,248.85) 272.13,249.18 272.13,251.08
  L25_SIGNAL w0.091: 272.13,251.08 272.13,252.11 270.66,253.58 270.66,255.08 268.77,256.97 268.77,266.74 269.75,267.73 269.75,271.72 268.81,272.67 268.81,294.21 270.89,296.29 275.02,296.29 282.11,303.38 282.11,337.12 306.93,361.95 343.33,361.95 344.17,362.79 344.17,369.57 D115.02
D11503: length 172.5
  L31_SIGNAL w0.076: v2(311.81,248.85) 312.13,249.18 312.13,251.08
  L31_SIGNAL w0.091: D115.03 341.63,372.11 341.63,365 341.12,364.49 305.56,364.49 301.75,360.68 301.75,329.18 314.71,316.23 314.71,302.13 313.06,300.48 313.06,297.81 308.81,293.57 308.81,272.67 309.75,271.72 309.75,267.73 308.77,266.74 308.77,256.97 310.66,255.08 310.66,253.58 312.13,252.11 312.13,251.08
D11504: length 137
  L23_SIGNAL w0.091: v3(347.48,310.7) 347.5,310.7 348.87,312.07 348.87,323.21 352.42,326.77 352.42,365 347.85,369.57 341.63,369.57 D115.04
  L29_SIGNAL w0.076: 352.13,251.08 352.13,249.18 v2(351.8,248.85)
  L29_SIGNAL w0.091: v3(347.48,310.7) 346.76,310.7 346.2,310.13 346.2,306.07 348.81,303.46 348.81,272.67 349.75,271.72 349.75,267.73 348.77,266.74 348.77,256.97 350.66,255.08 350.66,253.58 352.13,252.11 352.13,251.08
D11505: length 202.8
  L27_SIGNAL w0.076: 230.83,251.08 230.83,249.18 v2(231.16,248.85)
  L27_SIGNAL w0.091: 230.83,251.08 230.83,251.36 230.18,252.01 230.18,253.75 228.41,255.52 228.41,297.24 236.45,305.28 236.45,319.51 269.88,352.93 280.89,352.93 292.44,364.49 335.81,364.49 336.55,365.23 336.55,372.11 D115.05
D11506: length 168.6
  L25_SIGNAL w0.076: 270.83,251.08 270.83,249.18 v2(271.16,248.85)
  L25_SIGNAL w0.091: D115.06 334,369.56 334.04,369.52 334.04,365.1 333.43,364.49 306.83,364.49 281.69,339.35 281.69,304.36 274.13,296.8 270.34,296.8 268.41,294.86 268.41,255.52 270.18,253.75 270.18,252.01 270.83,251.36 270.83,251.08
D11507: length 160.2
  L31_SIGNAL w0.076: v2(311.16,248.85) 310.83,249.18 310.83,251.08
  L31_SIGNAL w0.091: 310.83,251.08 310.83,251.36 310.18,252.01 310.18,253.75 308.41,255.52 308.41,293.73 312.65,297.98 312.65,300.65 314.29,302.28 314.29,315.89 301.24,328.93 301.24,361.19 307.09,367.03 330.45,367.03 331.47,368.05 331.47,372.11 D115.07
D11508: length 145.9
  L23_SIGNAL w0.091: D115.08 333.63,367.41 349.38,367.41 352.04,364.74 352.04,326.93 348.49,323.37 348.49,312.58 348.13,312.22 v3(347.48,312.22)
  L29_SIGNAL w0.076: 350.83,251.08 350.83,249.18 v2(351.15,248.85)
  L29_SIGNAL w0.091: v3(347.48,312.22) 346.64,312.22 345.82,311.4 345.82,305.44 348.41,302.85 348.41,255.52 350.18,253.75 350.18,252.01 350.83,251.36 350.83,251.08
D11509: length 196.2
  L27_SIGNAL w0.076: 229.53,249.9 229.53,247.23 v2(229.21,246.91)
  L27_SIGNAL w0.091: D115.09 326.39,372.11 326.39,367.77 325.65,367.03 294.26,367.03 280.67,353.44 269.62,353.44 235.87,319.69 235.87,305.84 231.14,301.12 230.25,301.12 225.78,296.65 225.78,285.75 226.25,285.28 226.25,280.84 226.99,280.1 226.99,272.88 226.46,272.34 226.46,264.02 227.04,263.43 227.04,255.86 229.53,253.37 229.53,249.9
D11510: length 162.1
  L25_SIGNAL w0.076: v2(269.2,246.91) 269.53,247.23 269.53,249.9
  L25_SIGNAL w0.091: D115.10 321.31,367.03 306.87,367.03 281.17,341.33 281.17,304.43 274.17,297.43 269.06,297.43 265.78,294.16 265.78,285.75 266.25,285.28 266.25,280.84 266.99,280.1 266.99,272.88 266.46,272.34 266.46,264.02 267.04,263.43 267.04,255.86 269.53,253.37 269.53,249.9
D11511: length 151
  L31_SIGNAL w0.076: v2(309.2,246.91) 309.53,247.23 309.53,249.9
  L31_SIGNAL w0.091: D115.11 321.31,372.11 321.31,370.59 320.29,369.57 308.61,369.57 300.74,361.7 300.74,327.02 307.59,320.17 307.59,319.28 311.15,315.72 311.15,298.32 305.78,292.96 305.78,285.75 306.25,285.28 306.25,280.84 306.99,280.1 306.99,272.88 306.46,272.34 306.46,264.02 307.04,263.43 307.04,255.86 309.53,253.37 309.53,249.9
D11512: length 157.9
  L23_SIGNAL w0.091: v3(347.48,314.89) 347.5,314.89 348.11,315.5 348.11,323.6 351.54,327.02 351.54,364.49 349.25,366.78 324.1,366.78 D115.12
  L29_SIGNAL w0.076: 349.53,249.9 349.53,247.23 v2(349.2,246.91)
  L29_SIGNAL w0.091: v3(347.48,314.89) 346.51,314.89 345.44,313.82 345.44,304.8 346.76,303.48 346.76,296.64 345.78,295.66 345.78,284.65 346.25,284.18 346.25,280.84 346.99,280.1 346.99,272.88 346.46,272.34 346.46,264.02 347.04,263.43 347.04,255.86 349.53,253.37 349.53,249.9
D11513: length 185.1
  L27_SIGNAL w0.076: 228.88,250.35 228.88,248.53 v2(228.56,248.2)
  L27_SIGNAL w0.091: 228.88,250.35 228.88,251.07 226.57,253.38 226.57,260.22 225.22,261.57 225.22,271.62 226.44,272.84 226.44,279.99 225.88,280.54 225.88,284.72 225.2,285.41 225.2,298.6 234.31,307.72 234.31,320.8 267.46,353.95 280.52,353.95 296.14,369.57 315.54,369.57 316.23,370.26 316.23,372.11 D115.13
D11514: length 152.4
  L25_SIGNAL w0.076: 268.88,250.35 268.88,248.53 v2(268.55,248.2)
  L25_SIGNAL w0.091: 268.88,250.35 268.88,251.07 266.57,253.38 266.57,260.22 265.22,261.57 265.22,271.62 266.44,272.84 266.44,279.99 265.88,280.54 265.88,284.72 265.2,285.41 265.2,295.94 267.72,298.46 273.79,298.46 280.63,305.31 280.63,341.55 308.66,369.57 313.69,369.57 D115.14
D11515: length 140.7
  L31_SIGNAL w0.076: v2(308.55,248.2) 308.88,248.53 308.88,250.35
  L31_SIGNAL w0.091: 308.88,250.35 308.88,251.07 306.57,253.38 306.57,260.22 305.22,261.57 305.22,271.62 306.44,272.84 306.44,279.99 305.88,280.54 305.88,284.72 305.2,285.41 305.2,294.15 309.25,298.19 309.25,316.61 307.09,318.77 307.09,320.04 300.23,326.9 300.23,365.25 307.09,372.11 311.15,372.11 D115.15
D11516: length 166.8
  L23_SIGNAL w0.091: v3(347.48,316.41) 346.82,317.06 346.82,322.95 351.15,327.28 351.15,363.22 349.88,364.49 314.58,364.49 313.63,365.44 313.63,367.09 D115.16
  L29_SIGNAL w0.076: 348.88,250.35 348.88,248.53 v2(348.55,248.2)
  L29_SIGNAL w0.091: v3(347.48,316.41) 346.38,316.41 345.06,315.09 345.06,284.35 345.69,283.72 345.69,280.73 346.44,279.99 346.44,272.84 345.22,271.62 345.22,261.57 346.57,260.22 346.57,253.38 348.88,251.07 348.88,250.35
D11601: length 234.9
  L27_SIGNAL w0.076: v2(227.91,246.91) 227.58,246.58 227.58,246.12 227.39,245.93 225.74,245.93
  L27_SIGNAL w0.091: 225.74,245.93 225.49,245.93 224.65,246.77 224.65,259.09 224.12,259.62 224.12,266.08 222.85,267.35 222.85,270.12 222.24,270.73 222.24,285.19 221.51,285.92 221.51,293.34 221,293.86 221,299.99 229.11,308.1 229.11,321.06 263.52,355.47 279.78,355.47 310.5,386.2 344.84,386.2 346.73,388.09 346.73,392.45 D116.01
D11602: length 205.5
  L25_SIGNAL w0.076: v2(267.9,246.91) 267.58,246.58 267.58,246.12 267.39,245.93 265.74,245.93
  L25_SIGNAL w0.091: D116.02 340.83,386.55 315.1,386.55 279.24,350.69 279.24,306.58 273.19,300.53 263.42,300.53 262.48,299.59 262.48,293.99 261.51,293.02 261.51,285.92 262.24,285.19 262.24,270.73 262.85,270.12 262.85,267.35 264.12,266.08 264.12,259.62 264.65,259.09 264.65,246.77 265.49,245.93 265.74,245.93
D11603: length 196
  L31_SIGNAL w0.076: 305.74,245.93 307.39,245.93 307.58,246.12 307.58,246.58 v2(307.9,246.91)
  L31_SIGNAL w0.091: D116.03 341.63,392.43 341.63,387.86 339.6,385.83 305.56,385.83 298.75,379.01 298.75,323.38 305.56,316.57 305.56,306.2 306.45,305.31 306.45,297.31 301.51,292.37 301.51,285.92 302.24,285.19 302.24,270.73 302.85,270.12 302.85,267.35 304.12,266.08 304.12,259.62 304.65,259.09 304.65,246.77 305.49,245.93 305.74,245.93
D11604: length 178.1
  L23_SIGNAL w0.091: v3(343.16,308.03) 343.14,308.03 342.52,307.41 342.52,306.07 344.04,304.55 352.04,304.55 354.58,307.09 354.58,311.66 352.55,313.69 351.28,313.69 349.63,315.34 349.63,322.83 353.19,326.39 353.19,378.33 D116.04
  L29_SIGNAL w0.076: v2(347.9,246.91) 347.58,246.58 347.58,246.12 347.39,245.93 345.74,245.93
  L29_SIGNAL w0.091: 345.74,245.93 345.49,245.93 344.65,246.77 344.65,259.09 344.12,259.62 344.12,266.08 342.85,267.35 342.85,270.12 342.24,270.73 342.24,285.19 341.51,285.92 341.51,292.24 342.52,293.24 342.52,304.04 343.92,305.44 343.92,307.85 343.74,308.03 v3(343.16,308.03)
D11605: length 226.2
  L27_SIGNAL w0.076: v2(226.61,243.65) 226.28,243.98
  L27_SIGNAL w0.091: D116.05 336.58,392.46 336.58,388.11 335.14,386.68 310.22,386.68 279.53,355.98 263.02,355.98 228.66,321.62 228.66,308.29 220.55,300.18 220.55,295.23 219.71,294.39 219.71,292.35 220.12,291.94 220.12,286.15 220.48,285.79 220.48,270.34 221.43,269.4 221.43,267.94 223.52,265.84 223.52,258.83 224.28,258.06 224.28,245.76 226.06,243.98 226.28,243.98
D11606: length 198.2
  L25_SIGNAL w0.076: v2(266.61,243.65) 266.28,243.98
  L25_SIGNAL w0.091: 266.28,243.98 266.06,243.98 264.28,245.76 264.28,258.06 263.52,258.83 263.52,265.84 261.43,267.94 261.43,269.4 260.48,270.34 260.48,285.79 260.12,286.15 260.12,292.32 259.51,292.93 259.51,294.41 260.54,295.44 260.54,300.13 261.34,300.93 272.75,300.93 277.06,305.24 277.06,349.2 315.09,387.22 331.34,387.22 D116.06
D11607: length 186.3
  L31_SIGNAL w0.076: 306.28,243.98 v2(306.6,243.65)
  L31_SIGNAL w0.091: D116.07 331.47,392.43 331.47,388.37 329.95,386.84 305.56,386.84 298.2,379.48 298.2,323.34 305.05,316.48 305.05,298.45 300.11,293.51 300.11,286.16 300.48,285.79 300.48,270.34 301.43,269.4 301.43,267.94 303.52,265.84 303.52,258.83 304.28,258.06 304.28,245.76 306.06,243.98 306.28,243.98
D11608: length 182.4
  L23_SIGNAL w0.091: D116.08 336.68,384.68 345.76,384.68 352.81,377.64 352.81,326.55 349.25,322.99 349.25,315.18 351.12,313.31 352.39,313.31 354.08,311.63 354.08,307.34 351.66,304.93 344.74,304.93 v3(343.16,306.5)
  L29_SIGNAL w0.076: 346.28,243.98 v2(346.6,243.65)
  L29_SIGNAL w0.091: v3(343.16,306.5) 343.16,305.31 340.49,302.64 340.49,295.27 339.85,294.64 339.85,292.49 340.12,292.23 340.12,286.15 340.48,285.79 340.48,270.34 341.43,269.4 341.43,267.94 343.52,265.84 343.52,258.83 344.28,258.06 344.28,245.76 346.06,243.98 346.28,243.98
D11609: length 429.6
  TOP w0.16: JP1.3 v3(108.41,261.08)
  L15_SIGNAL w0.076: v2(235.06,246.26) 234.73,246.58 234.73,250.24
  L15_SIGNAL w0.091: 234.73,250.24 234.73,250.33 233.02,252.04 230.48,252.04 228.73,253.8 210.33,253.8 208,251.46 142.21,251.46 131.75,261.92 109.26,261.92 v3(108.41,261.08)
  L29_SIGNAL w0.091: D116.09 326.46,392.5 326.46,387.99 324.93,386.45 305.3,386.45 274.83,355.98 183.02,355.98 119.99,292.95 119.99,272.66 v3(108.41,261.08)
D11610: length 176.8
  L15_SIGNAL w0.076: v2(275.06,246.26) 274.73,246.58 274.73,251.08
  L15_SIGNAL w0.091: D116.10 323.59,389.63 317.28,389.63 316.23,390.68 316.23,391.58 315.6,392.21 314.28,392.21 313.49,391.41 313.49,387.84 280.52,354.87 280.52,289.74 276.07,285.3 276.07,280.96 274.66,279.55 274.66,264.4 273.2,262.94 273.2,253.17 274.73,251.63 274.73,251.08
D11611: length 193.5
  L15_SIGNAL w0.076: v2(315.05,246.26) 314.73,246.58 314.73,251.08
  L15_SIGNAL w0.091: 314.73,251.08 314.73,251.63 313.2,253.17 313.2,262.94 314.66,264.4 314.66,279.55 316.07,280.96 316.07,285.16 328.78,297.87 328.78,303.69 351.89,326.79 351.89,392.05 349.14,394.8 323.68,394.8 D116.11
D11612: length 192.8
  L15_SIGNAL w0.076: 354.73,251.08 354.73,246.58 v2(355.05,246.26)
  L15_SIGNAL w0.091: 354.73,251.08 354.73,251.63 353.2,253.17 353.2,262.94 354.66,264.4 354.66,279.55 356.07,280.96 356.07,283.39 354.59,284.87 354.59,392.8 349.56,397.84 321.25,397.84 318.77,395.36 318.77,392.43 D116.12
D11613: length 421
  TOP w0.16: JP1.4 v3(108.41,263.08)
  L15_SIGNAL w0.076: v2(235.71,246.26) 235.38,246.58 235.38,250.24
  L15_SIGNAL w0.091: 235.38,250.24 235.41,250.27 235.41,251.16 233.76,252.81 231.5,252.81 230.12,254.18 218.26,254.18 217.56,254.88 215.28,254.88 214.58,254.18 210.04,254.18 207.72,251.85 142.56,251.85 130.54,263.88 109.21,263.88 v3(108.41,263.08)
  L29_SIGNAL w0.091: D116.13 316.3,392.5 316.3,388.28 315.43,387.41 305.08,387.41 274.48,356.81 182.52,356.81 119.05,293.34 119.05,273.05 109.07,263.08 v3(108.41,263.08)
D11614: length 162.1
  L15_SIGNAL w0.076: 275.38,250.24 275.38,246.58 v2(275.71,246.26)
  L15_SIGNAL w0.091: D116.14 313.91,390.11 313.91,387.63 280.97,354.69 280.97,289.57 276.56,285.16 276.56,279.32 275.26,278.03 275.26,264.13 274.53,263.39 274.53,252.63 275.39,251.76 275.39,250.25 275.38,250.24
D11615: length 209.4
  L15_SIGNAL w0.076: 315.38,250.24 315.38,246.58 v2(315.7,246.26)
  L15_SIGNAL w0.091: 315.38,250.24 315.39,250.25 315.39,251.76 314.53,252.63 314.53,263.39 315.26,264.13 315.26,278.03 316.56,279.32 316.56,285.05 329.21,297.71 329.21,303.51 352.32,326.62 352.32,392.23 349.32,395.23 322.39,395.23 321.31,394.15 321.31,390.63 320.81,390.13 319.38,390.13 318.77,390.75 318.77,391.59 317.71,392.65 313.47,392.65 D116.15
D11616: length 201.8
  L15_SIGNAL w0.076: v2(355.7,246.26) 355.38,246.58 355.38,250.24
  L15_SIGNAL w0.091: D116.16 311.15,392.43 311.15,397.07 312.41,398.32 349.76,398.32 355.08,393 355.08,285.07 356.56,283.59 356.56,279.32 355.26,278.03 355.26,264.13 354.53,263.39 354.53,252.63 355.39,251.76 355.39,250.25 355.38,250.24
D11701: length 308.8
  L19_SIGNAL w0.254: v2(308.55,249.5) 309.11,250.06
  L19_SIGNAL w0.508: D117.01 161.27,97.77 161.27,102.81 163.92,105.47 188.91,105.47 202.84,119.4 202.84,123.85 203.7,124.71 203.7,202.36 210.92,209.58 210.92,209.78 211.43,210.29 225.95,210.29 226.47,209.77 226.47,209.22 226.44,209.19 226.44,208.73 226.83,208.34 228.14,208.34 228.94,209.14 233.32,209.14 233.39,209.08 234.6,209.08 234.62,209.09 235.36,208.36 236.75,208.36 236.96,208.15 241.07,208.15 241.5,208.58 241.5,209.78 242.75,211.02 242.75,211.66 243.26,212.17 245.57,212.17 245.76,211.97 248.68,211.97 251.56,214.86 278.28,214.86 281.78,218.36 287.85,218.36 290.93,221.44 302.29,221.44 302.86,222.01 302.86,226.77 303.57,227.48 307.48,227.48 313.55,233.55 317.6,233.55 321.26,237.22 321.26,251.03 319.87,252.43 317.76,252.43 316.21,253.98 313.26,253.98 312.37,253.08 311.6,253.08 311.24,253.44 310.53,253.44 309.54,252.46 309.54,251.34 309.11,250.91 309.11,250.06
D11702: length 315.2
  L19_SIGNAL w0.254: v2(308.55,248.85) 307.24,250.17
  L19_SIGNAL w0.508: 307.24,250.17 307.24,251.23 307.83,251.82 307.83,253.79 309.51,255.47 310.23,255.47 310.63,255.07 312.92,255.07 313.3,255.45 316.26,255.45 317.76,253.95 320.3,253.95 322.86,251.39 322.86,236.78 318.86,232.78 318.86,232.16 318.1,231.39 314.26,231.39 310,227.13 310,221.79 308.12,219.91 290.77,219.91 288.28,217.42 282.85,217.42 278.25,212.83 270.63,212.83 270.13,213.33 269.41,213.33 268.83,212.75 251.59,212.75 249.28,210.44 247.57,210.44 245.74,208.61 242.69,208.61 240.83,206.75 235.86,206.75 234.7,205.59 234.7,204.55 234.11,203.96 227.44,203.96 224.06,207.34 219.08,207.34 217.68,208.74 211.56,208.74 210.37,207.55 210.37,206.5 205.3,201.43 205.3,117.54 192.31,104.56 165.47,104.56 163.87,102.96 163.87,100.37 D117.02
D11703: length 330.1
  L19_SIGNAL w0.076: 354.08,249.79 354.08,248.53 v2(353.75,248.2)
  L19_SIGNAL w0.102: 354.08,249.79 354.08,250.65 354.7,251.26 355.46,251.26 357.73,248.99 357.73,239.81 356.24,238.31 350.49,238.31 340.81,228.63 340.81,228.52 339.13,226.84 339.13,224.93 338.47,224.28 320.11,224.28 318.53,222.71 318.53,218.47 318.1,218.03 290.04,218.03 288.74,216.74 283.87,216.74 279.22,212.09 270.61,212.09 270.28,211.76 268.96,211.76 268.63,212.09 252.88,212.09 248.72,207.93 243.66,207.93 242.65,206.91 241.93,206.91 241.1,206.08 237.65,206.08 234.92,203.35 226.03,203.35 223.66,205.73 221.65,205.73 220.65,206.73 218.83,206.73 217.5,208.05 212.9,208.05 207.72,202.87 207.72,200.91 205.94,199.12 205.94,113.98 195.88,103.92 168,103.92 166.32,102.23 166.32,97.74 D117.03
D11704: length 327.9
  L19_SIGNAL w0.076: 352.78,251.01 352.78,248.53 v2(352.45,248.2)
  L19_SIGNAL w0.102: D117.04 172.04,103.46 196.07,103.46 206.39,113.79 206.39,197.74 208.25,199.6 208.25,202.82 211.88,206.45 218.53,206.45 218.66,206.32 220.23,206.32 221.32,205.23 222.94,205.23 225.3,202.87 235.79,202.87 237.26,204.34 240.03,204.34 242.13,206.45 242.88,206.45 243.27,206.83 248.25,206.83 252.47,211.05 266.24,211.05 266.64,211.45 268.55,211.45 268.78,211.23 270.5,211.23 270.89,211.61 275.15,211.61 275.81,210.95 277.16,210.95 277.87,211.66 279.45,211.66 284.09,216.31 288.95,216.31 290.24,217.6 318.46,217.6 319.06,218.21 319.06,222.58 320.33,223.85 338.62,223.85 339.53,224.76 339.53,226.66 340.89,228.02 341.67,228.02 345.12,231.47 347.99,231.47 353.41,236.89 356.98,236.89 358.8,238.71 358.8,248.61 355.71,251.69 353.35,251.69 352.78,251.12 352.78,251.01
D11705: length 263.6
  L17_SIGNAL w0.508: 287.11,211.22 v2(286.71,211.22)
  L17_SIGNAL w0.762: 283.08,193.62 282.54,194.16 279.65,194.16
  L17_SIGNAL w1.016: 283.08,193.62 283.08,176.56 282.49,175.97 281.78,175.97 280.08,174.27 280.08,168.17 283.41,164.85 288.18,164.85 289.2,163.83 289.2,154.69 288.03,153.52 284.15,153.52 283.56,152.92 283.56,152.33 282.36,151.13 278.73,151.13 278.38,151.48 273.59,151.48 273.08,151.99 267.18,151.99 266.7,151.51 266.7,149.99 265.44,148.72 265.44,147.39 267.04,145.79 267.04,132.1 266.16,131.23 241.71,131.23 241.14,130.66 241.14,129.73 240.37,128.96 233.46,128.96 216.93,112.43 216.93,88.55 212.2,83.82 182.88,83.82 D117.05 ; 279.65,194.16 278.96,194.84 278.96,197.64 279.73,198.4 280.49,198.4 281.02,198.93 281.02,203.66 281.84,204.47 288.59,204.47 289.31,205.19 289.31,209.77 287.86,211.22 287.11,211.22
  BOTTOM w0.305: UNK6U451.4 286.1,210.6 v2(286.71,211.22) 286.4,211.53 UNK6U452.7
D11706: length 223.7
  L17_SIGNAL w0.508: 240.57,210.48 v2(240.33,210.23)
  L17_SIGNAL w1.016: D117.06 175.14,101.48 175.14,194.92 174.45,195.6 159.96,195.6 157.05,198.51 157.05,213.05 159.81,215.81 208.49,215.81 209.33,216.64 240.35,216.64 241.07,215.93 241.07,210.98 240.57,210.48
  BOTTOM w0.305: UNK5U450.4 239.83,209.74 v2(240.33,210.23)
D11707: length 264.1
  L17_SIGNAL w0.508: 285.6,210.21 v2(285.6,211.22)
  L17_SIGNAL w0.762: 281.07,191.32 280.16,192.23 277.64,192.23 ; 279.01,175.89 279.01,175.31 278.42,174.71
  L17_SIGNAL w1.016: 285.6,210.21 285.6,209.68 283.61,207.7 283.61,207.11 282.93,206.43 279.73,206.43 278.94,205.64 278.94,203 278.35,202.41 277.62,202.41 276.9,201.69 276.9,192.97 277.64,192.23 ; D117.07 186.2,85.58 207.34,85.58 214.86,93.11 214.86,112.8 230.9,128.84 230.9,130.55 231.92,131.56 238.38,131.56 242.11,135.29 260.17,135.29 261.21,136.33 261.21,139.99 259.33,141.87 254.14,141.87 251.63,139.35 245.78,139.35 245.08,140.05 245.08,142.72 245.85,143.5 255.03,143.5 261.5,149.96 261.5,152.92 262.6,154.03 273.25,154.03 273.75,153.52 280.17,153.52 281,154.34 281,164.01 276.83,168.18 276.83,173.13 278.42,174.71 ; 281.07,191.32 281.07,178.61 280.54,178.08 279.8,178.08 279.01,177.29 279.01,175.89
  BOTTOM w0.305: UNK6U451.3 v2(285.6,211.22) 285.9,211.53 UNK6U452.8
D11708: length 206.3
  L17_SIGNAL w0.508: 239.4,211.49 v2(239.08,211.17)
  L17_SIGNAL w1.016: 239.4,211.49 239.4,212.61 239.01,213 239.01,213.91 238.44,214.48 233.57,214.48 232.91,213.83 232.91,213.79 232.38,213.26 230.15,213.26 228.75,214.66 209.75,214.66 208.53,213.45 168.57,213.45 167.51,212.39 167.51,203.87 166.69,203.05 166.05,203.05 165.06,202.05 165.06,199.05 165.78,198.33 176.66,198.33 177.59,197.41 177.59,124.51 179.43,122.67 179.43,100.69 D117.08
  BOTTOM w0.305: v2(239.08,211.17) 239.08,210.81 238.83,210.56 UNK5U450.2
D11709: length 224.4
  L17_SIGNAL w0.508: 279.07,209.98 v2(279.33,210.23)
  L17_SIGNAL w0.762: 275.79,177.7 276.56,178.47
  L17_SIGNAL w1.016: 279.07,209.98 278.63,209.98 277.31,208.66 277.31,206.45 277.08,206.22 277.08,204.37 275.08,202.36 275.08,193.83 274.92,193.68 274.92,192.51 278.12,189.31 278.12,184.91 277.31,184.1 277.31,179.22 276.56,178.47 ; D117.09 189.58,87.28 206.43,87.28 213.12,93.97 213.12,114.21 226.8,127.89 226.8,133.96 226.64,134.13 226.64,143.59 227.65,144.61 229.09,144.61 232.63,141.07 232.63,139.67 233.71,138.6 235.39,138.6 236.23,139.44 236.23,141.65 240.14,145.56 254.54,145.56 258.8,149.82 258.8,152.98 258.98,153.16 258.98,154.97 260.06,156.06 269.18,156.06 269.49,155.75 278.62,155.75 279.12,156.25 279.12,163.37 274.65,167.84 274.65,177.01 275.33,177.7 275.79,177.7
  BOTTOM w0.305: UNK6U450.3 v2(279.33,210.23)
D11710: length 207.1
  L17_SIGNAL w0.508: 237.21,212.63 238.08,211.75 v2(238.08,211.17)
  L17_SIGNAL w1.016: D117.10 185.22,101.4 185.22,122.75 183.1,124.88 183.1,199.69 182.09,200.7 173.57,200.7 172.55,201.72 172.55,209.64 173.55,210.64 208.17,210.64 209.98,212.44 222.32,212.44 222.86,211.91 222.86,210.03 223.32,209.56 223.32,204.65 224.5,203.48 233.86,203.48 234.65,204.27 234.65,211.73 235.54,212.63 237.21,212.63
  BOTTOM w0.305: v2(238.08,211.17) 238.08,210.81 238.33,210.56 UNK5U450.1
D11711: length 207.1
  L17_SIGNAL w0.508: v2(278.08,211.17) 278.08,211.75 277.21,212.63
  L17_SIGNAL w0.762: 267.7,193.12 266.62,193.12 266.29,192.79
  L17_SIGNAL w1.016: 266.29,192.79 265.96,192.46 265.96,191.92 264.19,190.16 264.19,185.94 262.76,184.51 262.76,177.37 264.41,175.72 264.41,172.35 262.71,170.65 262.71,160.4 262.08,159.77 258.8,159.77 258.15,160.41 256.98,160.41 256.01,159.44 256.01,151.18 254.28,149.45 243.72,149.45 243.11,148.84 237.25,148.84 234.79,146.39 232.23,146.39 231.03,147.59 228.14,147.59 225.29,144.73 221.69,144.73 220.68,143.72 220.68,129.83 218.07,127.23 213.22,127.23 211.22,125.23 211.22,94.88 205.35,89.01 192.93,89.01 D117.11 ; 277.21,212.63 275.54,212.63 274.65,211.73 274.65,204.27 268.7,198.32 268.7,194.11 267.7,193.12
  BOTTOM w0.305: v2(278.08,211.17) 278.08,210.81 278.33,210.56 UNK6U450.1
D11712: length 224.4
  L17_SIGNAL w0.508: 239.07,209.98 v2(239.33,210.23)
  L17_SIGNAL w1.016: D117.12 189.55,100.65 189.55,123.79 185.53,127.81 185.53,197.15 186.46,198.09 204.94,198.09 205.54,198.69 205.54,202.33 204.53,203.35 180.51,203.35 180.25,203.61 180.25,207.66 180.69,208.1 209.25,208.1 210.86,206.49 218,206.49 220.49,204 220.49,202.24 221.51,201.22 233.68,201.22 237.08,204.63 237.08,206.22 237.31,206.45 237.31,208.66 238.63,209.98 239.07,209.98
  BOTTOM w0.305: UNK5U450.3 v2(239.33,210.23)
D11713: length 206.3
  L17_SIGNAL w0.508: v2(279.08,211.17) 279.42,211.51
  L17_SIGNAL w1.016: D117.13 196.28,90.74 203.93,90.74 209.02,95.83 209.02,131.01 211.38,133.37 215.89,133.37 216.67,132.58 216.67,131.93 217.35,131.24 218.38,131.24 218.77,131.63 218.77,146.9 221.35,149.49 225.95,149.49 226.44,149.99 226.44,151.02 227.42,151.99 233.08,151.99 233.59,151.48 252.12,151.48 254.15,153.52 254.15,160 256.66,162.51 258.22,162.51 259.59,163.88 259.59,166.66 259.78,166.94 260.69,167.86 260.69,189.79 261.15,190.25 262.15,190.25 262.71,190.8 262.71,191.59 263.44,192.32 264.15,192.32 264.69,192.86 264.69,193.73 267.05,196.09 267.05,199.11 269.16,201.22 269.16,207.04 270.23,208.1 270.23,210.72 272.97,213.46 272.97,213.97 273.58,214.58 278.38,214.58 279.01,213.94 279.01,212.8 279.42,212.39 279.42,211.51
  BOTTOM w0.305: UNK6U450.2 278.83,210.56 279.08,210.81 v2(279.08,211.17)
D11714: length 264.1
  L17_SIGNAL w0.508: v2(245.6,211.22) 245.6,210.21
  L17_SIGNAL w0.762: 238.42,174.71 239.01,175.31 239.01,175.89
  L17_SIGNAL w1.016: D117.14 198.15,104.17 198.15,123.37 197.12,124.39 191.37,124.39 187.93,127.84 187.93,194.64 188.95,195.66 207.26,195.66 208.31,194.61 208.31,188.4 207.75,187.85 203.79,187.85 203.12,187.18 203.12,161.14 204.14,160.12 207.49,160.12 209.81,162.44 218.01,162.44 220.07,164.49 229.72,164.49 231.8,162.41 236.17,162.41 237.19,163.42 237.19,164.86 236.83,165.22 236.83,173.13 238.42,174.71 ; 239.01,175.89 239.01,177.29 239.8,178.08 240.54,178.08 241.13,178.67 241.13,187.39 240.32,188.2 237.91,188.2 236.9,189.22 236.9,201.69 237.62,202.41 238.35,202.41 238.94,203 238.94,205.64 239.73,206.43 243.13,206.43 243.69,206.98 243.69,207.77 245.6,209.68 245.6,210.21
  BOTTOM w0.305: UNK5U452.8 245.9,211.53 v2(245.6,211.22) UNK5U451.3
D11715: length 223.7
  L17_SIGNAL w0.508: 280.57,210.48 v2(280.33,210.23)
  L17_SIGNAL w1.016: 280.57,210.48 281.07,210.98 281.07,215.93 280.35,216.64 265.41,216.64 264.76,216 264.76,210.87 263.02,209.12 263.02,197.84 262.66,197.48 262.66,194.89 261.92,194.16 259.28,194.16 258.62,193.5 258.62,177.52 257.35,176.25 255.44,176.25 250.84,171.65 250.84,157.82 248.56,155.55 228.77,155.55 228.26,156.06 220.06,156.06 218.98,154.97 218.98,153.32 213.69,148.03 211.58,148.03 207.22,152.39 199.15,152.39 198.13,151.37 198.13,130.41 207.09,121.45 207.09,97.53 201.92,92.37 199.73,92.37 D117.15
  BOTTOM w0.305: UNK6U450.4 279.83,209.74 v2(280.33,210.23)
D11716: length 263.7
  L17_SIGNAL w0.508: 247.11,211.22 v2(246.71,211.22)
  L17_SIGNAL w1.016: 247.11,211.22 247.86,211.22 249.31,209.77 249.31,205.19 248.59,204.47 241.84,204.47 241.02,203.66 241.02,198.93 240.49,198.4 239.73,198.4 238.96,197.64 238.96,193.01 239.85,192.12 242.58,192.12 243.18,191.52 243.18,176.66 242.49,175.97 241.78,175.97 240,174.19 240,164.51 240.94,163.56 240.94,158.24 240.28,157.58 229.52,157.58 228.98,158.12 228.98,158.84 228.06,159.77 218.8,159.77 217.99,160.58 212.02,160.58 208.95,157.51 208.95,155.88 207.94,154.87 201.38,154.87 200.66,155.59 200.66,189.46 199.65,190.47 191.55,190.47 190.42,189.35 190.42,128.15 191.94,126.62 199.43,126.62 201.91,124.15 201.91,102.85 D117.16
  BOTTOM w0.305: UNK5U451.4 246.1,210.6 v2(246.71,211.22) 246.4,211.53 UNK5U452.7
D11801: length 173
  L25_SIGNAL w0.076: v2(234.41,182.35) 234.73,182.68 236.07,182.68
  L25_SIGNAL w0.091: 236.07,182.68 236.91,181.84 236.91,179.74 236.15,178.98 236.15,167.32 239.58,163.88 239.58,155.14 237.27,152.84 237.27,152.53 232.07,147.32 229.47,147.32 226.3,144.14 209.17,144.14 206.31,141.29 206.31,95.97 200.35,90.01 169.35,90.01 161.29,81.96 161.29,77.47 D118.01
D11802: length 215.7
  L31_SIGNAL w0.076: 276.07,182.68 274.73,182.68 v2(274.41,182.35)
  L31_SIGNAL w0.091: D118.02 172.72,88.9 271.4,88.9 279.07,96.57 279.07,136.98 277.88,138.18 277.88,147.57 277.11,148.34 277.11,152.68 279.58,155.14 279.58,163.88 276.15,167.32 276.15,178.98 276.91,179.74 276.91,181.84 276.07,182.68
D11803: length 234.7
  L23_SIGNAL w0.091: v3(273.05,121.23) 272.81,121.23 271.02,119.44 271.02,108.77 266.51,104.27 227.33,104.27 205.61,82.55 167.39,82.55 166.37,81.53 166.37,77.47 D118.03
  L29_SIGNAL w0.076: v2(314.41,182.35) 314.73,182.68 316.07,182.68 316.07,182.68
  L29_SIGNAL w0.091: 316.07,182.68 316.91,181.84 316.91,179.74 316.15,178.98 316.15,166.96 319.58,163.53 319.58,155.14 317.27,152.84 317.27,152.53 311.28,146.53 311.28,138.37 310.9,137.99 310.9,134.89 308.5,132.49 306.87,132.49 299.97,125.6 276.86,125.6 274.07,122.81 274.07,121.54 273.76,121.23 v3(273.05,121.23)
D11804: length 274.7
  L21_SIGNAL w0.102: v3(346.71,114.37) 346.68,114.37 345.06,112.75 345.06,108.18 342.42,105.54 306.46,105.54 287.66,86.74 175.64,86.74 D118.04
  L27_SIGNAL w0.076: v2(354.4,182.35) 354.73,182.68 356.07,182.68 356.07,182.68
  L27_SIGNAL w0.091: v3(346.71,114.37) 347.8,114.37 349.96,116.53 349.96,123.72 352.9,126.66 352.9,133.12 355.76,135.98 355.76,146.46 357.27,147.98 357.27,152.84 359.58,155.14 359.58,163.88 356.15,167.32 356.15,178.98 356.91,179.74 356.91,181.84 356.07,182.68
D11805: length 167.9
  L25_SIGNAL w0.076: 235.88,184.63 234.73,184.63 v2(234.41,184.31)
  L25_SIGNAL w0.091: 235.88,184.63 236.1,184.4 237.77,184.4 238.81,183.36 238.81,180.52 237.27,178.98 237.27,177.24 236.82,176.79 236.82,167.19 240.56,163.45 240.56,154.52 236.15,150.11 235.84,150.11 230.38,144.65 227.84,144.65 226.96,143.78 210.58,143.78 207.69,140.89 207.69,96.34 200.55,89.21 178.6,89.21 171.45,82.05 171.45,77.47 D118.05
D11806: length 209.4
  L31_SIGNAL w0.076: v2(274.41,184.31) 274.73,184.63 275.88,184.63
  L31_SIGNAL w0.091: D118.06 182.46,88.48 271.57,88.48 279.49,96.4 279.49,145.71 278.89,146.3 278.89,152.85 280.56,154.52 280.56,163.45 276.82,167.19 276.82,176.79 277.27,177.24 277.27,178.98 278.81,180.52 278.81,183.36 277.77,184.4 276.1,184.4 275.88,184.63
D11807: length 227.6
  L15_SIGNAL w0.091: D118.07 176.58,77.52 176.58,79.22 177.37,80.01 199.39,80.01 223.77,104.39 267.43,104.39 270.51,107.47 270.51,116.05 273.03,118.56 v3(273.05,118.56)
  L29_SIGNAL w0.076: v2(314.41,184.31) 314.73,184.63 315.88,184.63
  L29_SIGNAL w0.091: v3(273.05,118.56) 275.34,120.85 275.34,122.81 277.59,125.06 299.95,125.06 307,132.11 308.71,132.11 312.6,136 312.6,146.87 315.84,150.11 316.15,150.11 320.56,154.52 320.56,163.18 316.82,166.92 316.82,176.79 317.27,177.24 317.27,178.98 318.81,180.52 318.81,183.36 317.77,184.4 316.1,184.4 315.88,184.63
D11808: length 269.1
  L21_SIGNAL w0.102: D118.08 185.29,86.23 287.91,86.23 306.76,105.08 342.57,105.08 345.47,107.98 345.47,111.61 v3(346.71,112.85)
  L27_SIGNAL w0.076: v2(354.4,184.31) 354.73,184.63 355.88,184.63
  L27_SIGNAL w0.091: 355.88,184.63 356.1,184.4 357.77,184.4 358.81,183.36 358.81,180.52 357.27,178.98 357.27,177.24 356.82,176.79 356.82,167.19 360.56,163.45 360.56,154.52 358.99,152.95 358.99,143.85 356.18,141.04 356.18,135.81 353.31,132.95 353.31,126.49 350.38,123.55 350.38,116.04 347.18,112.85 v3(346.71,112.85)
D11809: length 161.4
  L25_SIGNAL w0.076: 235.2,185.28 234.08,185.28 v2(233.76,185.61)
  L25_SIGNAL w0.091: D118.09 181.61,77.47 181.61,82.08 188.1,88.57 200.57,88.57 208.11,96.11 208.11,139.02 212.5,143.41 226.4,143.41 226.82,142.99 230.87,142.99 233.81,145.92 234.46,145.92 240.94,152.4 240.94,163.64 237.32,167.26 237.32,176.68 238.94,178.31 238.94,179.6 239.55,180.21 239.55,183.73 237.1,186.18 236.22,186.18 235.32,185.28 235.2,185.28
D11810: length 203.4
  L31_SIGNAL w0.076: v2(273.76,185.61) 274.08,185.28 275.2,185.28
  L31_SIGNAL w0.091: D118.10 192.2,88.06 271.75,88.06 279.91,96.22 279.91,127.76 281.18,129.03 281.18,135.5 281.69,136.01 281.69,138.94 279.91,140.72 279.91,143.26 280.94,144.28 280.94,163.64 277.32,167.26 277.32,176.68 278.94,178.31 278.94,179.6 279.55,180.21 279.55,183.73 277.1,186.18 276.22,186.18 275.32,185.28 275.2,185.28
D11811: length 220.4
  L15_SIGNAL w0.091: D118.11 186.69,77.47 201.68,77.47 228.22,104.01 267.59,104.01 270.89,107.31 270.89,114.88 v3(273.05,117.04)
  L29_SIGNAL w0.076: 315.2,185.28 314.08,185.28 v2(313.76,185.61)
  L29_SIGNAL w0.091: 315.2,185.28 315.32,185.28 316.22,186.18 317.1,186.18 319.55,183.73 319.55,180.21 318.94,179.6 318.94,178.31 317.32,176.68 317.32,167.06 320.94,163.44 320.94,152.4 314.46,145.92 314.21,145.92 313.25,144.96 313.25,135.95 308.74,131.44 307.85,131.44 301.02,124.62 277.91,124.62 276.22,122.94 276.22,118.62 274.65,117.04 v3(273.05,117.04)
D11812: length 263
  L21_SIGNAL w0.102: v3(351.02,122.76) 351,122.76 347.7,119.46 347.7,108.31 344.07,104.67 307.02,104.67 288.17,85.83 195.05,85.83 D118.12
  L27_SIGNAL w0.076: v2(353.75,185.61) 354.08,185.28 355.2,185.28
  L27_SIGNAL w0.091: v3(351.02,122.76) 351.7,122.76 358.56,129.62 358.56,136.37 360.16,137.97 360.16,144.14 360.94,144.91 360.94,163.64 357.32,167.26 357.32,176.68 358.94,178.31 358.94,179.6 359.55,180.21 359.55,183.73 357.1,186.18 356.22,186.18 355.32,185.28 355.2,185.28
D11813: length 159.5
  L25_SIGNAL w0.076: v2(235.06,188.21) 235.38,188.53 235.8,188.53
  L25_SIGNAL w0.091: D118.13 191.77,77.47 191.77,79.25 192.61,80.08 201.39,80.08 208.66,87.35 208.66,137.03 213.36,141.73 231.65,141.73 233.43,143.51 235.71,143.51 238.76,146.56 238.76,147.7 243.46,152.4 243.46,156.82 243.7,157.06 243.7,162.93 242.99,163.64 242.98,163.64 242.92,163.7 241.45,163.7 238.7,166.46 238.7,176.95 240.95,179.21 240.95,185.23 237.66,188.53 235.8,188.53
D11814: length 196.4
  L31_SIGNAL w0.076: v2(275.06,188.21) 275.38,188.53 275.8,188.53
  L31_SIGNAL w0.091: 275.8,188.53 277.66,188.53 280.95,185.23 280.95,179.21 278.7,176.95 278.7,166.46 281.45,163.7 282.92,163.7 282.98,163.64 282.99,163.64 283.7,162.93 283.7,157.06 283.46,156.82 283.46,152.4 283.21,152.15 283.21,130.15 280.34,127.28 280.34,95.94 272.03,87.63 201.93,87.63 D118.14
D11815: length 213.4
  L15_SIGNAL w0.091: D118.15 196.48,77.1 202.45,77.1 228.98,103.63 267.97,103.63 271.65,107.31 271.65,114.86 274.45,117.66 274.45,119.86 277.34,122.76 v3(277.36,122.76)
  L29_SIGNAL w0.076: 315.8,188.53 315.38,188.53 v2(315.05,188.21)
  L29_SIGNAL w0.091: v3(277.36,122.76) 299.68,122.76 307.84,130.92 308.8,130.92 313.71,135.82 313.71,140.99 318.76,146.04 318.76,147.7 323.46,152.4 323.46,156.82 323.7,157.06 323.7,162.93 322.99,163.64 322.98,163.64 322.92,163.7 321.31,163.7 318.7,166.32 318.7,176.95 320.95,179.21 320.95,185.23 317.66,188.53 315.8,188.53
D11816: length 257.5
  L21_SIGNAL w0.102: D118.16 204.8,85.42 288.34,85.42 307.16,104.24 344.27,104.24 348.11,108.08 348.11,118.31 v3(351.02,121.23)
  L27_SIGNAL w0.076: 355.8,188.53 355.38,188.53 v2(355.05,188.21)
  L27_SIGNAL w0.091: v3(351.02,121.23) 351.86,121.23 358.98,128.35 358.98,136.19 363.46,140.67 363.46,156.82 363.7,157.06 363.7,162.93 362.99,163.64 362.98,163.64 362.92,163.7 361.45,163.7 358.69,166.46 358.69,176.95 360.95,179.21 360.95,185.23 357.66,188.53 355.8,188.53
D11901: length 209.2
  L25_SIGNAL w0.091: v2(235.06,189.51) 238.7,189.51 241.52,186.68 241.52,179.18 239.11,176.76 239.11,166.59 241.63,164.07 243.13,164.07 244.06,163.14 244.06,158.4 244.78,157.69 244.78,155.38 245.5,154.65 245.5,149.3 238.35,142.15 234.35,142.15 232.72,140.51 215.33,140.51 215.11,140.3 214.47,140.3 209.17,135 209.17,79.88 201.09,71.8 170.49,71.8 161.29,62.6 161.29,57.15 D119.01
D11902: length 244.6
  L31_SIGNAL w0.091: v2(275.06,189.51) 278.7,189.51 281.52,186.68 281.52,179.18 279.11,176.76 279.11,166.59 281.63,164.07 283.13,164.07 284.06,163.14 284.06,158.4 284.78,157.69 284.78,155.38 285.5,154.65 285.5,149.3 285.12,148.92 285.12,130.27 280.85,126 280.85,95.81 272.03,86.99 207.83,86.99 203.2,82.36 203.2,72.28 196.83,65.91 170.05,65.91 D119.02
D11903: length 267.4
  L23_SIGNAL w0.091: D119.03 166.37,57.15 166.37,59.18 166.88,59.69 201.42,59.69 203.83,62.1 203.83,77.34 230.38,103.89 266.67,103.89 271.53,108.74 271.53,119.41 272.64,120.52 276.66,120.52 v3(277.36,121.23)
  L29_SIGNAL w0.091: v3(277.36,121.23) 298.83,121.23 307.12,129.52 308,129.52 314.38,135.9 314.38,139.12 315.47,140.21 315.47,140.97 320.29,145.8 322,145.8 325.5,149.3 325.5,154.65 324.78,155.38 324.78,157.69 324.06,158.4 324.06,163.14 323.13,164.07 321.58,164.07 319.11,166.54 319.11,176.76 321.52,179.18 321.52,186.68 318.7,189.51 v2(315.05,189.51)
D11904: length 300.9
  L21_SIGNAL w0.102: D119.04 176.53,67.31 214.38,67.31 231.98,84.91 288.55,84.91 307.47,103.84 344.63,103.84 348.62,107.82 348.62,116.18 351,118.56 v3(351.02,118.56)
  L27_SIGNAL w0.091: v2(355.05,189.51) 358.7,189.51 361.52,186.68 361.52,179.18 359.11,176.76 359.11,166.59 361.63,164.07 363.13,164.07 364.06,163.14 364.06,158.4 364.78,157.69 364.78,155.38 365.5,154.65 365.5,130.55 363.86,128.91 361.37,128.91 v3(351.02,118.56)
D11905: length 211.3
  L25_SIGNAL w0.508: D119.05 171.45,57.15 171.45,62.26 179.58,70.39 201.36,70.39 209.93,78.96 209.93,133.73 211.33,135.13 213.36,135.13 217.17,138.94 229.36,138.94 229.95,139.52 230.77,139.52 231.1,139.19 237.27,139.19 239.47,141.39 239.47,142.27 240.67,143.47 242.02,143.47 247.46,148.91 247.46,150.81 249.13,152.47 249.13,153.59 247.3,155.43 247.3,156.84 246.41,157.73 246.41,163.39 245.92,163.88 244.64,163.88 243.74,164.77 242.63,164.77 239.92,167.48 239.92,175.83 242.8,178.7 242.8,189.43 240.31,191.91 235.24,191.91 234.41,191.08 234.41,188.86 v2(234.41,188.86)
D11906: length 245.6
  L31_SIGNAL w0.508: D119.06 178.94,64.64 197.36,64.64 204.47,71.75 204.47,81.84 208.99,86.36 272.41,86.36 281.61,95.55 281.61,124.63 287.46,130.48 287.46,150.81 289.13,152.47 289.13,153.59 287.3,155.43 287.3,156.84 286.41,157.73 286.41,163.39 285.92,163.88 284.64,163.88 283.74,164.77 282.63,164.77 279.92,167.48 279.92,175.83 282.8,178.7 282.8,189.43 280.31,191.91 275.24,191.91 274.41,191.08 274.41,188.86 v2(274.41,188.86)
D11907: length 266.4
  L15_SIGNAL w0.091: D119.07 176.58,57.2 176.58,58.9 177.37,59.69 199.97,59.69 205.49,65.21 205.49,77.6 231.14,103.25 270.17,103.25 274.7,107.78 274.7,115.92 277.34,118.56 v3(277.36,118.56)
  L29_SIGNAL w0.508: v3(277.36,118.56) 286.23,118.56 287.17,119.51 298.2,119.51 307.59,128.91 309.63,128.91 310.62,129.9 310.62,131.09 315.21,135.69 315.21,138.68 316.8,140.27 316.8,141.29 320.24,144.72 323.27,144.72 327.46,148.91 327.46,150.81 329.13,152.47 329.13,153.59 327.3,155.43 327.3,156.84 326.41,157.73 326.41,163.39 325.92,163.88 324.64,163.88 323.74,164.77 322.63,164.77 319.92,167.48 319.92,175.83 322.8,178.7 322.8,189.43 320.31,191.91 315.24,191.91 314.41,191.08 314.41,188.86 v2(314.41,188.86)
D11908: length 302.3
  L21_SIGNAL w0.102: v3(351.02,117.04) 349.1,115.11 349.1,107.54 344.96,103.4 307.72,103.4 288.75,84.43 232.51,84.43 212.85,64.77 184.15,64.77 D119.08
  L27_SIGNAL w0.508: v3(351.02,117.04) 354.53,117.04 367.46,129.97 367.46,150.81 369.13,152.47 369.13,153.59 367.29,155.43 367.29,156.84 366.41,157.73 366.41,163.39 365.92,163.88 364.64,163.88 363.74,164.77 362.63,164.77 359.92,167.48 359.92,175.83 362.8,178.7 362.8,189.43 360.31,191.91 355.24,191.91 354.41,191.08 354.41,188.86 v2(354.4,188.86)
D11909: length 205
  L25_SIGNAL w0.076: 233.43,189.67 233.43,188.53 v2(233.11,188.21)
  L25_SIGNAL w0.091: D119.09 181.61,57.15 181.61,61.76 188.94,69.09 201.68,69.09 210.69,78.1 210.69,130.68 217.42,137.41 231.14,137.41 231.77,138.05 237.62,138.05 239.65,140.08 240.47,140.08 250.18,149.79 250.18,161.89 247.62,164.45 244.88,164.45 243.77,165.56 242.65,165.56 240.57,167.64 240.57,174.78 243.39,177.59 243.39,191.15 242.05,192.49 235,192.49 233.63,191.12 233.63,190.07 233.43,189.87 233.43,189.67
D11910: length 241.3
  L31_SIGNAL w0.076: v2(273.11,188.21) 273.43,188.53 273.43,189.67
  L31_SIGNAL w0.091: D119.10 188.21,63.75 198.12,63.75 205.48,71.11 205.48,81.53 209.3,85.34 272.29,85.34 282.37,95.43 282.37,121.59 290.18,129.4 290.18,161.89 287.62,164.45 284.88,164.45 283.77,165.56 282.65,165.56 280.57,167.64 280.57,174.78 283.39,177.59 283.39,191.15 282.05,192.49 275,192.49 273.63,191.12 273.63,190.07 273.43,189.87 273.43,189.67
D11911: length 261.7
  L15_SIGNAL w0.091: D119.11 186.69,57.15 200.91,57.15 206.25,62.48 206.25,77.47 231.65,102.87 270.51,102.87 275.21,107.57 275.21,114.88 v3(277.36,117.04)
  L29_SIGNAL w0.076: 313.43,189.67 313.43,188.53 v2(313.11,188.21)
  L29_SIGNAL w0.091: v3(277.36,117.04) 286,117.04 287.76,118.8 298.63,118.8 308.1,128.27 310.13,128.27 311.28,129.41 311.28,130.4 315.98,135.1 315.98,137.92 319.51,141.45 321.84,141.45 330.18,149.79 330.18,161.89 327.62,164.45 324.88,164.45 323.77,165.56 322.65,165.56 320.57,167.64 320.57,174.78 323.39,177.59 323.39,191.15 322.05,192.49 315,192.49 313.63,191.12 313.63,190.07 313.43,189.87 313.43,189.67
D11912: length 297.7
  L21_SIGNAL w0.102: v3(351.02,114.37) 351,114.37 349.5,112.88 349.5,107.19 345.26,102.95 307.84,102.95 288.92,84.02 233.12,84.02 211.33,62.23 191.77,62.23 D119.12
  L27_SIGNAL w0.076: v2(353.1,188.21) 353.43,188.53 353.43,189.67
  L27_SIGNAL w0.091: 353.43,189.67 353.43,189.87 353.63,190.07 353.63,191.12 355,192.49 362.05,192.49 363.39,191.15 363.39,177.59 360.57,174.78 360.57,167.64 362.65,165.56 363.77,165.56 364.88,164.45 367.62,164.45 370.18,161.89 370.18,130.17 354.39,114.37 v3(351.02,114.37)
D11913: length 196.1
  L25_SIGNAL w0.076: v2(231.81,189.51) 231.48,189.83 231.48,191.08
  L25_SIGNAL w0.091: 231.48,191.31 231.48,191.08
  L25_SIGNAL w0.508: 231.48,191.31 231.48,192.25 233.13,193.9 242.42,193.9 244.88,191.44 244.88,179.27 250.35,173.8 250.35,162.57 250.76,162.16 250.76,148.01 238.39,135.64 229.5,135.64 228.65,136.48 220.78,136.48 219.68,135.38 217.68,135.38 211.58,129.29 211.58,77.18 200.1,65.7 195.89,65.7 191.82,61.62 191.82,57.2 D119.13
