# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D21606: length 392.6
  L31_SIGNAL w0.079: 331.51,252.11 331.51,254.62 330.83,255.29 330.83,261.71 334.35,265.22 334.35,300.69 336.07,302.42 356.48,302.42 358.97,304.91 358.97,332.13 360.43,333.59 365.74,333.59 367.31,332.02 367.31,295.81 368.2,294.92 374.14,294.92 375.17,295.95 375.17,311.73 376.87,313.43 411.36,313.43 411.86,313.93 411.86,317.26 411.31,317.8 390.16,317.8 389.28,318.68 389.28,321.25 390.36,322.33 424.43,322.33 431.8,329.7 431.8,357.16 444.16,369.51 462.99,369.51 463.68,370.2 463.68,386.59 464.37,387.28 479.44,387.28 480.16,388 480.16,388.72
  L31_SIGNAL w0.091: 331.51,252.11 331.8,251.82 332.25,251.82 332.63,251.44 332.63,250.53 332.31,250.22 v1(331.66,250.22) ; 480.16,388.72 D216.06
D21607: length 358.4
  L25_SIGNAL w0.079: 481.2,391.39 481.2,389.7 480.93,389.43 480.82,389.43 480.64,389.6 480.53,389.6 480.42,389.49 480.42,389.38 480.6,389.21 480.6,389.1 480.48,388.99 480.37,388.99 480.2,389.16 480.09,389.16 479.98,389.05 479.98,388.94 480.15,388.76 480.15,388.65 480.04,388.54 479.93,388.54 479.75,388.71 479.64,388.71 479.53,388.6 479.53,388.49 479.7,388.32 479.7,388.21 479.24,387.74 469.26,387.74 466.15,384.64 466.15,370.03 463.34,367.22 447.59,367.22 424.73,344.36 350.19,344.36 346.85,341.02 311.04,341.02 292.41,322.4 292.41,295.23 287.24,290.05 287.24,270.68 287.91,270.01 289.93,270.01 290.77,270.85 290.77,291.06 291.54,291.83 293.78,291.83 294.45,291.17 294.45,265.6 290.64,261.79 290.64,255.21 291.31,254.54 291.31,252.11
  L25_SIGNAL w0.091: D216.07 481.2,392.56 481.2,391.39 ; v1(291.16,250.22) 290.51,250.22 290.19,250.53 290.19,251.44 290.57,251.82 291.02,251.82 291.31,252.11
D21608: length 392.6
  L31_SIGNAL w0.079: 479.96,388.72 479.96,388.08 479.36,387.48 464.29,387.48 463.48,386.67 463.48,370.28 462.91,369.71 444.08,369.71 431.61,357.24 431.61,329.78 424.35,322.52 390.28,322.52 389.09,321.33 389.09,318.6 390.08,317.61 411.23,317.61 411.67,317.18 411.67,314.01 411.28,313.62 376.79,313.62 374.98,311.81 374.98,296.03 374.06,295.11 368.28,295.11 367.51,295.89 367.51,332.1 365.82,333.78 360.35,333.78 358.77,332.21 358.77,304.99 356.4,302.61 335.99,302.61 334.15,300.77 334.15,265.3 330.64,261.79 330.64,255.21 331.31,254.54 331.31,252.11
  L31_SIGNAL w0.091: 479.96,388.72 D216.08 ; 331.31,252.11 331.02,251.82 330.57,251.82 330.19,251.44 330.19,250.53 330.51,250.22 v1(331.16,250.22)
D21609: length 354
  L27_SIGNAL w0.076: v2(235.06,240.4) 235.38,240.73 235.95,240.73
  L27_SIGNAL w0.091: 235.95,240.73 236.88,240.73 241.39,245.24 241.39,253.14 239.47,255.07 239.47,266.54 240.31,267.38 240.31,269.57 240.96,270.22 240.96,297.54 246.61,303.19 246.61,320.8 269.99,344.18 419.37,344.18 449.43,374.25 449.43,383.05 451.19,384.81 470.6,384.81 473.72,387.92 473.72,392.44 D216.09
D21610: length 307.4
  L25_SIGNAL w0.076: v2(275.06,240.4) 275.38,240.73 275.95,240.73
  L25_SIGNAL w0.091: 275.95,240.73 276.88,240.73 281.39,245.24 281.39,253.14 279.47,255.07 279.47,266.54 280.31,267.38 280.31,269.57 280.96,270.22 280.96,285.95 290.52,295.51 290.52,322.95 309.89,342.33 346.13,342.33 349.48,345.68 419.37,345.68 423.6,349.91 423.6,359.85 453.64,389.89 471.17,389.89 D216.10
D21611: length 271
  L31_SIGNAL w0.076: v2(315.05,240.4) 315.38,240.73 315.95,240.73
  L31_SIGNAL w0.091: D216.11 468.63,392.43 464.69,392.43 463.55,391.29 463.55,388.49 462.41,387.35 451.87,387.35 428.89,364.38 428.89,353.97 416.79,341.87 366.2,341.87 356.49,332.15 356.49,309.64 351.02,304.16 328.93,304.16 320.96,296.19 320.96,270.22 320.31,269.57 320.31,267.38 319.47,266.54 319.47,255.07 321.39,253.14 321.39,245.24 316.88,240.73 315.95,240.73
D21612: length 251.7
  L23_SIGNAL w0.091: v3(351.79,319.08) 351.61,319.08 351.03,319.66 351.03,322.1 373.76,344.84 373.76,370.97 387.1,384.3 448.56,384.3 454.15,389.89 466.09,389.89 D216.12
  L29_SIGNAL w0.076: 355.95,240.73 355.38,240.73 v2(355.05,240.4)
  L29_SIGNAL w0.091: v3(351.79,319.08) 352.88,319.08 360.96,311 360.96,270.22 360.31,269.57 360.31,267.38 359.47,266.54 359.47,255.07 361.39,253.14 361.39,245.24 356.88,240.73 355.95,240.73
D21613: length 344.6
  L27_SIGNAL w0.076: v2(233.76,241.05) 234.08,241.38 235.22,241.38
  L27_SIGNAL w0.091: D216.13 463.55,392.43 463.55,387.99 462.91,387.35 452.37,387.35 448.82,383.79 448.82,374.65 418.79,344.62 269.69,344.62 246.05,320.98 246.05,303.2 240.53,297.68 240.53,287.49 239.27,286.23 239.27,272.89 239.78,272.38 239.78,269.6 239.04,268.86 239.04,254.89 240.87,253.07 240.87,246.77 235.48,241.38 235.22,241.38
D21614: length 300.5
  L25_SIGNAL w0.076: 275.22,241.38 274.08,241.38 v2(273.76,241.05)
  L25_SIGNAL w0.091: 275.22,241.38 275.48,241.38 280.87,246.77 280.87,253.07 279.04,254.89 279.04,268.86 279.78,269.6 279.78,272.38 279.27,272.89 279.27,286.23 283.72,290.68 283.72,291.37 285.7,293.35 287.39,293.35 289.81,295.78 289.81,323.24 309.35,342.78 345.83,342.78 349.12,346.07 419.04,346.07 423.1,350.14 423.1,360.87 454.66,392.43 461.01,392.43 D216.14
D21615: length 256.9
  L31_SIGNAL w0.076: 315.22,241.38 314.08,241.38 v2(313.76,241.05)
  L31_SIGNAL w0.091: 315.22,241.38 315.48,241.38 320.87,246.77 320.87,253.07 319.04,254.89 319.04,268.86 319.78,269.6 319.78,272.38 319.27,272.89 319.27,282.69 320.59,284.02 320.59,297.11 321.61,298.13 321.61,298.13 323.91,300.43 323.91,300.43 328.04,304.56 343.17,304.56 355.73,317.12 355.73,332.84 365.78,342.9 416.43,342.9 428.12,354.58 428.12,366.27 454.28,392.43 458.47,392.43 D216.15
D21616: length 259.5
  L29_SIGNAL w0.076: 355.22,241.38 354.08,241.38 v2(353.75,241.05)
  L29_SIGNAL w0.091: 355.22,241.38 355.48,241.38 360.87,246.77 360.87,253.07 359.04,254.89 359.04,268.86 359.78,269.6 359.78,272.38 359.26,272.89 359.26,286.23 360.53,287.49 360.53,310.29 353.57,317.25 350.9,317.25 350.01,316.36 350.01,307.21 350.72,306.5 v3(351.79,306.5)
  L31_SIGNAL w0.091: v3(351.79,306.5) 351.97,306.5 356.11,310.64 356.11,332.49 366.14,342.52 416.81,342.52 428.48,354.19 428.48,365.11 452.25,388.87 454.91,388.87 D216.16
D21701: length 179.8
  L25_SIGNAL w0.076: v2(235.06,248.2) 235.38,248.53 235.8,248.53
  L25_SIGNAL w0.091: 235.8,248.53 236.1,248.53 236.5,248.93 236.5,251.04 235.01,252.52 235.01,259.62 235.5,260.1 235.5,270.36 236.52,271.39 236.52,272.36 237.17,273.01 237.17,273.53 241.01,277.36 241.01,293.66 237.24,297.43 235.58,297.43 230.89,302.13 224.9,302.13 213.66,313.38 161.2,313.38 141.84,332.74 D217.01
D21702: length 233.8
  L31_SIGNAL w0.076: 275.8,248.53 275.38,248.53 v2(275.06,248.2)
  L31_SIGNAL w0.091: D217.02 125.6,331.34 260.81,331.34 270.81,321.34 270.81,301.73 273.96,298.58 276.22,298.58 281.01,293.79 281.01,277.36 277.17,273.53 277.17,273.01 276.52,272.36 276.52,271.39 275.5,270.36 275.5,260.1 275.01,259.62 275.01,252.52 276.5,251.04 276.5,248.93 276.09,248.53 275.8,248.53
D21703: length 279
  L19_SIGNAL w0.102: v3(278.13,310.7) 278.16,310.7 281.18,313.71 281.18,327.43 276.99,331.62 123.04,331.62 D217.03
  L29_SIGNAL w0.076: 315.8,248.53 315.38,248.53 v2(315.05,248.2)
  L29_SIGNAL w0.091: 315.8,248.53 316.09,248.53 316.5,248.93 316.5,251.04 315.01,252.52 315.01,259.62 315.5,260.1 315.5,270.36 316.52,271.39 316.52,272.36 317.17,273.01 317.17,273.53 321.01,277.36 321.01,293.67 310.74,303.94 296.45,303.94 289.69,310.7 v3(278.13,310.7)
D21704: length 320.4
  L23_SIGNAL w0.091: D217.04 123.32,326.26 280.49,326.26 294.22,312.53 299.58,312.53 305.52,318.47 326.65,318.47 327.79,317.33 327.79,308.38 325.91,306.5 v3(325.89,306.5)
  L27_SIGNAL w0.076: v2(355.05,248.2) 355.38,248.53 355.8,248.53
  L27_SIGNAL w0.091: 355.8,248.53 356.09,248.53 356.5,248.93 356.5,251.04 355.01,252.52 355.01,259.62 355.5,260.1 355.5,270.36 356.52,271.39 356.52,272.36 357.17,273.01 357.17,273.53 361.01,277.36 361.01,293.8 351.99,302.82 329.57,302.82 v3(325.89,306.5)
D21705: length 197.5
  L25_SIGNAL w0.076: 235.45,245.28 234.08,245.28 v2(233.76,245.61)
  L25_SIGNAL w0.091: 235.45,245.28 237.36,247.19 237.36,251.42 236.48,252.3 236.48,259.78 236.86,260.16 236.86,266.69 237.36,267.18 237.36,269.2 238.84,270.69 239.51,270.69 241.41,272.59 241.41,274.11 242.59,275.28 242.59,294.12 234.2,302.5 225.31,302.5 214.02,313.8 161.37,313.8 141.2,333.97 118.07,333.97 D217.05
D21706: length 253.8
  L31_SIGNAL w0.076: v2(273.76,245.61) 274.08,245.28 275.45,245.28
  L31_SIGNAL w0.091: D217.06 115.57,331.47 115.57,332.87 116.71,334.01 259.16,334.01 271.43,321.74 271.43,301.72 274.19,298.96 278,298.96 282.59,294.37 282.59,275.28 281.41,274.11 281.41,272.59 279.51,270.69 278.84,270.69 277.36,269.2 277.36,267.18 276.86,266.69 276.86,260.16 276.48,259.78 276.48,252.3 277.36,251.42 277.36,247.19 275.45,245.28
D21707: length 294.4
  L19_SIGNAL w0.102: v3(278.13,312.22) 280.77,314.86 280.77,327.27 276.82,331.22 113.28,331.22 D217.07
  L29_SIGNAL w0.076: v2(313.76,245.61) 314.08,245.28 315.45,245.28
  L29_SIGNAL w0.091: 315.45,245.28 317.36,247.19 317.36,251.42 316.48,252.3 316.48,259.78 316.86,260.16 316.86,266.69 317.36,267.18 317.36,269.2 318.84,270.69 319.51,270.69 321.41,272.59 321.41,274.11 322.59,275.28 322.59,294.63 312.78,304.44 296.66,304.44 288.88,312.22 v3(278.13,312.22)
D21708: length 336.4
  L23_SIGNAL w0.091: v3(325.89,308.03) 327.28,309.42 327.28,317.12 326.44,317.96 307.63,317.96 306.37,316.71 306.37,315.77 302.77,312.17 293.87,312.17 280.28,325.75 113.66,325.75 D217.08
  L27_SIGNAL w0.076: v2(353.75,245.61) 354.08,245.28 355.45,245.28
  L27_SIGNAL w0.091: 355.45,245.28 357.36,247.19 357.36,251.42 356.48,252.3 356.48,259.78 356.86,260.16 356.86,266.69 357.36,267.18 357.36,269.2 358.84,270.69 359.51,270.69 361.41,272.59 361.41,274.11 362.59,275.28 362.59,293.99 353.39,303.19 330.11,303.19 326.94,306.36 326.94,307.61 326.52,308.03 v3(325.89,308.03)
D21709: length 215.4
  L25_SIGNAL w0.076: 235.88,244.63 234.73,244.63 v2(234.41,244.31)
  L25_SIGNAL w0.091: D217.09 110.44,336.5 142.31,336.5 164.59,314.21 214.32,314.21 225.5,303.04 235.69,303.04 245.1,293.62 245.1,275.3 244.08,274.28 244.08,273.71 243.23,272.85 242.65,272.85 241.35,271.55 241.35,270.3 240.77,269.72 239.54,269.72 238,268.18 238,267.14 237.25,266.39 237.25,259.96 236.84,259.56 236.84,253.07 238.64,251.27 238.64,246.52 236.49,244.36 236.14,244.36 235.88,244.63
D21710: length 270.5
  L31_SIGNAL w0.076: 275.88,244.63 274.73,244.63 v2(274.41,244.31)
  L31_SIGNAL w0.091: 275.88,244.63 276.14,244.36 276.49,244.36 278.64,246.52 278.64,251.27 276.84,253.07 276.84,259.56 277.25,259.96 277.25,266.39 278,267.14 278,268.18 279.54,269.72 280.77,269.72 281.35,270.3 281.35,271.55 282.65,272.85 283.23,272.85 284.08,273.71 284.08,274.28 285.1,275.3 285.1,290.07 283.84,291.33 283.84,294.83 271.87,306.8 271.87,322.19 257.51,336.55 106.3,336.55 105.41,335.66 105.41,331.47 D217.10
D21711: length 306.6
  L19_SIGNAL w0.102: v3(278.13,314.89) 278.16,314.89 279.53,316.25 279.53,325.31 275.89,328.96 104.13,328.96 103,330.09 103,331.34 D217.11
  L29_SIGNAL w0.076: 315.88,244.63 314.73,244.63 v2(314.41,244.31)
  L29_SIGNAL w0.091: 315.88,244.63 316.14,244.36 316.49,244.36 318.64,246.52 318.64,251.27 316.84,253.07 316.84,259.56 317.25,259.96 317.25,266.39 318,267.14 318,268.18 319.54,269.72 320.77,269.72 321.35,270.3 321.35,271.55 322.65,272.85 323.23,272.85 324.08,273.71 324.08,274.28 325.1,275.3 325.1,294.15 314.3,304.95 296.87,304.95 286.94,314.89 v3(278.13,314.89)
D21712: length 347.4
  L23_SIGNAL w0.091: v3(325.89,310.7) 326.06,310.7 326.44,311.07 326.44,313.21 322.07,317.58 307.78,317.58 306.75,316.55 306.75,315.46 303.08,311.78 293.71,311.78 280.12,325.37 103.89,325.37 D217.12
  L27_SIGNAL w0.076: v2(354.4,244.31) 354.73,244.63 355.88,244.63
  L27_SIGNAL w0.091: v3(325.89,310.7) 327.61,308.97 327.61,306.38 330.44,303.56 353.54,303.56 353.57,303.53 353.8,303.53 365.1,292.23 365.1,275.3 364.08,274.28 364.08,273.71 363.23,272.85 362.65,272.85 361.35,271.55 361.35,270.3 360.77,269.72 359.54,269.72 358,268.18 358,267.14 357.25,266.39 357.25,259.96 356.84,259.56 356.84,253.07 358.64,251.27 358.64,246.52 356.49,244.36 356.14,244.36 355.88,244.63
D21713: length 229.1
  L25_SIGNAL w0.076: v2(234.41,242.35) 234.73,242.68 236.07,242.68
  L25_SIGNAL w0.091: D217.13 102.8,339.02 140.43,339.02 162.31,317.15 212.19,317.15 225.93,303.4 235.84,303.4 245.47,293.77 245.47,273.58 244.74,272.85 244.23,272.85 241.72,270.34 241.72,268.69 238.61,265.58 238.61,260.8 237.21,259.4 237.21,253.39 239.11,251.48 239.11,245.45 236.34,242.68 236.07,242.68
D21714: length 286.7
  L31_SIGNAL w0.076: v2(274.41,242.35) 274.73,242.68 276.07,242.68
  L31_SIGNAL w0.091: 276.07,242.68 276.34,242.68 279.11,245.45 279.11,251.48 277.21,253.39 277.21,259.4 278.61,260.8 278.61,265.58 281.72,268.69 281.72,270.34 284.23,272.85 284.74,272.85 285.47,273.58 285.47,293.77 286.22,294.52 286.22,295.56 284.98,296.8 284.48,296.8 280.67,300.61 278.7,300.61 272.35,306.96 272.35,322.61 255.86,339.09 98.3,339.09 95.63,336.42 95.63,331.85 D217.14
D21715: length 317.9
  L19_SIGNAL w0.102: v3(278.13,316.41) 279.12,317.4 279.12,325.15 275.72,328.55 93.6,328.55 92.71,329.44 92.71,331.47 D217.15
  L29_SIGNAL w0.076: v2(314.41,242.35) 314.73,242.68 316.07,242.68 316.07,242.68
  L29_SIGNAL w0.091: 316.07,242.68 316.34,242.68 319.11,245.45 319.11,251.48 317.21,253.39 317.21,259.4 318.61,260.8 318.61,265.58 321.72,268.69 321.72,270.34 324.23,272.85 324.74,272.85 325.47,273.58 325.47,295.82 315.82,305.46 297.08,305.46 286.13,316.41 v3(278.13,316.41)
D21716: length 362
  L23_SIGNAL w0.091: v3(325.89,312.22) 325.89,313.05 321.82,317.12 307.97,317.12 307.21,316.36 307.21,311.15 306.12,310.05 294.72,310.05 279.91,324.87 94.23,324.87 D217.16
  L27_SIGNAL w0.076: v2(354.4,242.35) 354.73,242.68 356.07,242.68 356.07,242.68
  L27_SIGNAL w0.091: v3(325.89,312.22) 326.59,312.22 328.25,310.56 328.25,306.34 330.67,303.92 353.69,303.92 353.7,303.91 354.7,303.91 365.47,293.14 365.47,273.58 364.74,272.85 364.23,272.85 361.72,270.34 361.72,268.69 358.61,265.58 358.61,260.8 357.21,259.4 357.21,253.39 359.11,251.48 359.11,245.45 356.34,242.68 356.07,242.68
D21801: length 209.2
  L25_SIGNAL w0.076: 235.78,241.38 234.73,241.38 v2(234.41,241.05)
  L25_SIGNAL w0.091: D218.01 131.93,353.06 162.05,322.94 162.05,319.68 164.16,317.57 212.29,317.57 226.07,303.78 236.86,303.78 249.31,291.34 249.31,275.53 245.47,271.7 244.41,271.7 243.29,270.57 243.29,269.74 238.99,265.44 238.99,260.66 238.63,260.31 238.63,252.74 239.49,251.88 239.49,243.36 237.52,241.38 235.78,241.38
D21802: length 259.9
  L31_SIGNAL w0.076: 275.78,241.38 274.73,241.38 v2(274.41,241.05)
  L31_SIGNAL w0.091: 275.78,241.38 277.52,241.38 279.49,243.36 279.49,251.88 278.63,252.74 278.63,260.31 278.98,260.66 278.98,265.44 283.29,269.74 283.29,270.57 284.41,271.7 285.47,271.7 289.31,275.53 289.31,295.53 279.37,305.47 277.47,305.47 275.27,307.67 275.27,320.6 256.28,339.6 139.83,339.6 127.63,351.79 125.73,351.79 D218.02
D21803: length 300.1
  L21_SIGNAL w0.102: v3(273.82,319.08) 273.84,319.08 274.37,319.61 274.37,321.2 268.73,326.85 148.45,326.85 125.9,349.4 124.32,349.4 123.06,350.66 123.06,351.92 D218.03
  L29_SIGNAL w0.076: 315.78,241.38 314.73,241.38 v2(314.41,241.05)
  L29_SIGNAL w0.091: 315.78,241.38 317.52,241.38 319.49,243.36 319.49,251.88 318.63,252.74 318.63,260.31 318.98,260.66 318.98,265.44 323.29,269.74 323.29,270.57 324.41,271.7 325.47,271.7 329.31,275.53 329.31,299.72 326.01,303.02 319.4,303.02 313.82,308.61 294.77,308.61 286,317.37 276.86,317.37 275.16,319.08 v3(273.82,319.08)
D21804: length 345
  L23_SIGNAL w0.091: v3(330.2,306.5) 330.22,306.5 331.54,307.82 331.54,321.11 330.33,322.33 304.55,322.33 298.2,328.68 146.68,328.68 126.11,349.25 120.65,349.25 D218.04
  L27_SIGNAL w0.076: 355.78,241.38 354.73,241.38 v2(354.4,241.05)
  L27_SIGNAL w0.091: v3(330.2,306.5) 330.2,305.69 331.55,304.34 356.57,304.34 369.31,291.6 369.31,275.53 365.47,271.7 364.41,271.7 363.29,270.57 363.29,269.74 358.98,265.44 358.98,260.66 358.63,260.31 358.63,252.74 359.49,251.88 359.49,243.36 357.52,241.38 355.78,241.38
D21805: length 223.5
  L25_SIGNAL w0.076: v2(233.76,240.4) 234.08,240.73 235.91,240.73
  L25_SIGNAL w0.091: 235.91,240.73 237.76,240.73 237.93,240.56 238.46,240.56 238.5,240.6 238.51,240.6 240.6,242.7 240.6,251.85 239,253.45 239,260.16 239.36,260.52 239.36,263.45 245.86,269.95 246.28,269.95 249.75,273.42 249.75,291.52 236.98,304.29 226.52,304.29 212.83,317.99 164.34,317.99 162.47,319.85 162.47,323.11 131.29,354.29 118.07,354.29 D218.05
D21806: length 277.2
  L31_SIGNAL w0.076: v2(273.76,240.4) 274.08,240.73 275.91,240.73
  L31_SIGNAL w0.091: D218.06 115.57,351.79 115.57,353.19 116.71,354.33 127.89,354.33 130.56,351.66 130.56,349.5 140.01,340.04 256.46,340.04 275.72,320.79 275.72,307.94 277.76,305.9 279.57,305.9 285.67,299.8 285.67,299.79 287.97,297.49 287.98,297.49 289.75,295.72 289.75,273.42 286.28,269.95 285.86,269.95 279.36,263.45 279.36,260.52 279,260.16 279,253.45 280.6,251.85 280.6,242.7 278.51,240.6 278.5,240.6 278.46,240.56 277.93,240.56 277.76,240.73 275.91,240.73
D21807: length 311.8
  L21_SIGNAL w0.102: v3(273.82,320.6) 267.98,326.44 148.29,326.44 125.73,349 113.66,349 112.9,349.76 112.9,351.92 D218.07
  L29_SIGNAL w0.076: 315.91,240.73 314.08,240.73 v2(313.76,240.4)
  L29_SIGNAL w0.091: v3(273.82,320.6) 274.58,320.6 277.37,317.82 286.19,317.82 294.95,309.05 317.31,309.05 322.9,303.47 326.19,303.47 329.75,299.91 329.75,273.42 326.28,269.95 325.86,269.95 319.36,263.45 319.36,260.52 319,260.16 319,253.45 320.6,251.85 320.6,242.7 318.51,240.6 318.5,240.6 318.46,240.56 317.93,240.56 317.76,240.73 315.91,240.73
D21808: length 360.3
  L23_SIGNAL w0.091: v3(330.2,308.03) 331.12,308.95 331.12,320.64 329.82,321.94 304.16,321.94 298.07,328.04 146.26,328.04 127.34,346.96 112.78,346.96 D218.08
  L27_SIGNAL w0.076: 355.91,240.73 354.08,240.73 v2(353.75,240.4)
  L27_SIGNAL w0.091: v3(330.2,308.03) 331.16,308.03 331.47,307.72 331.47,305.56 332.25,304.78 362.1,304.78 369.75,297.13 369.75,273.42 366.28,269.95 365.86,269.95 359.36,263.45 359.36,260.52 359,260.16 359,253.45 360.6,251.85 360.6,242.7 358.5,240.6 358.5,240.6 358.46,240.56 357.93,240.56 357.76,240.73 355.91,240.73
D21809: length 236.5
  L25_SIGNAL w0.076: 236.04,240.08 234.08,240.08 v2(233.76,239.75)
  L25_SIGNAL w0.091: 236.04,240.08 240.04,240.08 241.49,241.53 241.49,252.87 239.56,254.8 239.56,259.93 240.49,260.86 240.49,263 243.13,265.65 243.13,266.44 245.92,269.23 246.15,269.23 250.17,273.25 250.17,292.63 238,304.8 226.74,304.8 210.08,321.45 167.77,321.45 132.41,356.82 110.44,356.82 D218.09
D21810: length 293.3
  L31_SIGNAL w0.076: v2(273.76,239.75) 274.08,240.08 276.04,240.08
  L31_SIGNAL w0.091: D218.10 105.41,351.79 105.41,355.98 106.3,356.87 127.76,356.87 131.19,353.44 131.19,349.58 140.22,340.55 256.67,340.55 276.22,321 276.22,311.12 279.13,308.21 279.13,307.61 290.17,296.57 290.17,273.25 286.15,269.23 285.92,269.23 283.13,266.44 283.13,265.65 280.49,263 280.49,260.86 279.56,259.93 279.56,254.8 281.49,252.87 281.49,241.53 280.04,240.08 276.04,240.08
D21811: length 358.6
  L19_SIGNAL w0.102: v3(278.13,319.08) 276.61,317.55 276.61,310.64 277.62,309.63 279.91,309.63 282.7,312.42 282.7,328.36 277.92,333.15 142.54,333.15 128.82,346.86 104,346.86 102.74,348.12 102.74,351.92 D218.11
  L29_SIGNAL w0.076: 316.04,240.08 314.08,240.08 v2(313.76,239.75)
  L29_SIGNAL w0.091: 316.04,240.08 320.04,240.08 321.49,241.53 321.49,252.87 319.56,254.8 319.56,259.93 320.49,260.86 320.49,263 323.13,265.65 323.13,266.44 325.92,269.23 326.15,269.23 330.17,273.25 330.17,300.26 320.96,309.47 295.12,309.47 285.52,319.08 v3(278.13,319.08)
D21812: length 370.5
  L23_SIGNAL w0.091: v3(330.2,310.7) 330.23,310.7 330.76,311.23 330.76,312.45 328.8,314.4 328.8,319.9 327.13,321.56 303.78,321.56 297.81,327.53 146.16,327.53 127.37,346.32 103.26,346.32 D218.12
  L27_SIGNAL w0.076: v2(353.75,239.75) 354.08,240.08 356.04,240.08
  L27_SIGNAL w0.091: v3(330.2,310.7) 330.78,310.7 332.1,309.37 332.1,306.06 332.97,305.2 363.71,305.2 370.17,298.74 370.17,273.25 366.15,269.23 365.92,269.23 363.13,266.44 363.13,265.65 360.49,263 360.49,260.86 359.56,259.93 359.56,254.8 361.49,252.87 361.49,241.53 360.04,240.08 356.04,240.08
D21813: length 253.8
  L25_SIGNAL w0.091: v2(233.11,240.4) 233.11,238.95 233.49,238.56 240.51,238.56 242.98,241.04 242.98,252.96 240.54,255.4 240.54,260.4 240.85,260.71 240.85,261.45 250.75,271.34 250.75,292.68 238.09,305.34 226.96,305.34 210.48,321.82 168.05,321.82 130.53,359.34 102.8,359.34 D218.13
D21814: length 311.4
  L31_SIGNAL w0.091: v2(273.11,240.4) 273.11,238.95 273.49,238.56 280.51,238.56 282.98,241.04 282.98,252.96 280.54,255.4 280.54,260.4 280.85,260.71 280.85,261.45 290.75,271.34 290.75,296.63 279.54,307.83 279.54,308.39 276.67,311.26 276.67,321.18 256.86,341 140.41,341 131.95,349.45 131.95,354.2 126.75,359.41 98.3,359.41 95.63,356.74 95.63,352.17 D218.14
D21815: length 374.9
  L19_SIGNAL w0.102: D218.15 92.84,351.66 92.84,347.09 93.47,346.46 128.65,346.46 142.37,332.74 277.75,332.74 282.3,328.19 282.3,312.59 279.74,310.03 277.79,310.03 277.01,310.81 277.01,316.36 278.69,318.04 278.69,320.07 278.16,320.6 v3(278.13,320.6)
  L29_SIGNAL w0.091: v3(278.13,320.6) 284.81,320.6 295.36,310.05 321.02,310.05 330.75,300.32 330.75,271.34 320.85,261.45 320.85,260.71 320.54,260.4 320.54,255.4 322.98,252.96 322.98,241.04 320.51,238.56 313.49,238.56 313.11,238.95 v2(313.11,240.4)
D21816: length 384.7
  L23_SIGNAL w0.091: v3(330.2,312.22) 328.42,314 328.42,319.4 326.64,321.18 303.4,321.18 297.67,326.92 145.02,326.92 127.76,344.17 95.25,344.17 D218.16
  L27_SIGNAL w0.091: v3(330.2,312.22) 331.16,312.22 332.47,310.91 332.47,306.21 333.12,305.56 363.98,305.56 370.75,298.8 370.75,271.34 360.85,261.45 360.85,260.71 360.54,260.4 360.54,255.4 362.98,252.96 362.98,241.04 360.51,238.56 353.49,238.56 353.1,238.95 v2(353.1,240.4)
D21901: length 393
  L27_SIGNAL w0.079: 125.84,371.8 125.84,369.63 126.23,369.25 126.34,369.25 126.45,369.36 126.56,369.36 126.68,369.25 126.68,369.14 126.56,369.03 126.56,368.91 126.67,368.8 126.78,368.8 126.9,368.92 127.01,368.92 127.12,368.81 127.12,368.69 127.01,368.58 127.01,368.47 127.12,368.36 127.23,368.36 127.34,368.47 127.46,368.47 127.57,368.36 127.57,368.25 127.45,368.13 127.45,368.02 127.56,367.91 127.68,367.91 127.79,368.03 127.9,368.03 128.01,367.91 128.01,367.8 127.9,367.69 127.9,367.58 128.01,367.47 128.12,367.47 128.24,367.58 128.35,367.58 128.46,367.47 128.46,367.36 128.34,367.24 128.34,367.13 128.45,367.02 136.88,358.59 136.88,330.43 130.81,324.36 87.65,324.36 86.11,322.81 86.11,319.28 87.12,318.26 134.29,318.26 135.43,317.12 135.43,314.35 134.51,313.44 86.61,313.44 85.79,312.61 85.79,306.13 86.87,305.05 151.13,305.05 155.9,300.28 200.43,300.28 213.04,287.67 213.04,264.63 210.94,262.53 210.94,254.37 211.51,253.8 211.51,251.84
  L27_SIGNAL w0.091: 125.84,371.8 125.84,372.22 D219.01 ; 211.51,251.84 211.74,251.62 212.33,251.62 212.58,251.36 212.58,250.14 v1(212.16,249.72)
  BOTTOM w0.16: U408.E8 v1(212.16,249.72)
D21902: length 350.6
  L25_SIGNAL w0.079: 123.29,369.5 123.29,367.63 123.68,367.24 126.39,367.24 126.47,367.31 126.47,367.45 126.55,367.53 126.71,367.53 126.79,367.45 126.79,367.31 126.87,367.24 127.02,367.24 127.1,367.31 127.1,367.45 127.18,367.53 127.34,367.53 127.42,367.45 127.42,367.31 127.5,367.24 127.65,367.24 127.73,367.31 127.73,367.45 127.81,367.53 127.97,367.53 128.05,367.45 128.05,367.31 128.13,367.24 128.28,367.24 128.36,367.31 128.36,367.45 128.44,367.53 128.6,367.53 128.68,367.45 128.68,367.31 128.76,367.24 128.91,367.24 128.99,367.31 128.99,367.45 129.07,367.53 129.23,367.53 129.31,367.45 129.31,367.31 129.39,367.24 129.54,367.24 129.62,367.31 129.62,367.45 129.7,367.53 129.86,367.53 129.94,367.45 129.94,367.31 130.02,367.24 131.13,367.24 158.02,340.35 225.68,340.35 228.97,337.06 228.97,334.1 226.38,331.52 167.64,331.52 166.2,330.08 166.2,326.36 167.48,325.08 233.86,325.08 238,320.94 238,306.99 250.12,294.87 251.85,294.87 253.04,293.68 253.04,264.63 250.94,262.53 250.94,254.37 251.51,253.8 251.51,251.84
  L25_SIGNAL w0.091: 251.51,251.84 251.74,251.62 252.33,251.62 252.58,251.36 252.58,250.14 v1(252.16,249.72) ; 123.29,369.5 123.29,369.67 D219.02
  BOTTOM w0.16: UNK2U408.E8 v1(252.16,249.72)
D21903: length 393
  L27_SIGNAL w0.079: 125.65,371.7 125.65,369.55 128.37,366.83 136.69,358.51 136.69,330.51 130.73,324.55 87.57,324.55 85.91,322.89 85.91,319.2 87.04,318.07 134.21,318.07 135.23,317.04 135.23,314.43 134.43,313.63 86.53,313.63 85.6,312.69 85.6,306.05 86.79,304.86 151.05,304.86 155.82,300.09 200.35,300.09 212.85,287.59 212.85,264.71 210.75,262.61 210.75,254.29 211.32,253.72 211.32,251.85
  L27_SIGNAL w0.091: 125.65,371.7 125.29,372.07 123.23,372.07 D219.03 ; 211.32,251.85 211.08,251.62 210.49,251.62 210.24,251.36 210.24,250.14 v1(210.66,249.72)
  BOTTOM w0.16: U408.E9 v1(210.66,249.72)
D21904: length 350.6
  L25_SIGNAL w0.079: 251.32,251.85 251.32,253.72 250.75,254.29 250.75,262.61 252.85,264.71 252.85,293.6 251.77,294.68 250.04,294.68 237.8,306.91 237.8,320.86 233.78,324.89 167.4,324.89 166.01,326.28 166.01,330.16 167.56,331.71 226.3,331.71 228.77,334.18 228.77,336.98 225.6,340.16 157.94,340.16 131.05,367.04 123.6,367.04 123.09,367.55 123.09,369.4
  L25_SIGNAL w0.091: v1(250.66,249.72) 250.24,250.14 250.24,251.36 250.49,251.62 251.08,251.62 251.32,251.85 ; D219.04 120.65,369.57 122.92,369.57 123.09,369.4
  BOTTOM w0.16: UNK2U408.E9 v1(250.66,249.72)
D21905: length 358.4
  L31_SIGNAL w0.079: 115.64,371.45 115.64,370.41 116.41,369.64 125.16,369.64 126.36,368.44 126.47,368.44 126.56,368.53 126.67,368.53 126.79,368.42 126.79,368.31 126.69,368.21 126.69,368.1 126.8,367.99 126.91,367.99 127.01,368.09 127.12,368.09 127.23,367.97 127.23,367.86 127.14,367.77 127.14,367.66 127.25,367.54 127.36,367.54 127.45,367.64 127.57,367.64 127.68,367.53 127.68,367.42 127.58,367.32 127.58,367.21 127.69,367.1 127.8,367.1 127.9,367.19 128.01,367.19 128.12,367.08 128.12,366.97 128.03,366.88 128.03,366.77 128.14,366.65 128.25,366.65 128.35,366.75 128.46,366.75 128.57,366.64 128.57,366.53 128.47,366.43 128.47,366.32 142.05,352.74 246.9,352.74 247.69,351.95 247.69,348.5 246.97,347.79 206.28,347.79 205.32,346.83 205.32,343 206.18,342.14 258.56,342.14 293.04,307.66 293.04,264.63 290.94,262.53 290.94,254.37 291.51,253.8 291.51,251.84
  L31_SIGNAL w0.091: 115.64,371.45 115.64,372.18 D219.05 ; v1(292.16,249.72) 292.58,250.14 292.58,251.36 292.33,251.62 291.74,251.62 291.51,251.84
  BOTTOM w0.16: UNK3U408.E8 v1(292.16,249.72)
D21906: length 392.6
  L23_SIGNAL w0.079: 111.84,368.38 111.84,367.47 112.17,367.14 128.53,367.14 145.92,349.75 148.58,349.75 149.35,350.52 149.35,355.75 149.91,356.3 152.58,356.3 153.2,355.68 153.2,342.88 153.48,342.6 155.81,342.6 155.89,342.68 155.89,349.88 156.52,350.51 158.51,350.51 159.12,349.9 159.12,338.5 160.11,337.52 161.98,337.52 162.38,337.92 162.38,344.28 162.98,344.88 165.44,344.88 166.07,344.25 166.07,332.55 166.56,332.06 168.45,332.06 169.04,332.66 169.04,337.7 169.61,338.27 171.69,338.27 172.21,337.75 172.21,333.02 174.53,330.7 299.15,330.7 305.55,324.29 336.89,324.29 340.67,320.51 340.67,307.37 340.48,307.18 339.64,307.18
  L23_SIGNAL w0.091: D219.06 111.84,368.38 ; v3(338.84,306.5) 338.97,306.5 339.64,307.18
  L29_SIGNAL w0.079: 331.51,251.84 331.51,253.8 330.94,254.37 330.94,262.53 333.04,264.63 333.04,302.92 337.27,307.15 338.07,307.15 338.72,306.5 v3(338.84,306.5)
  L29_SIGNAL w0.091: 331.51,251.84 331.74,251.62 332.33,251.62 332.58,251.36 332.58,250.14 v1(332.16,249.72)
  BOTTOM w0.16: UNK4U408.E8 v1(332.16,249.72)
D21907: length 358.4
  L31_SIGNAL w0.079: 115.44,371.35 115.44,370.33 116.33,369.44 125.08,369.44 141.97,352.55 246.82,352.55 247.5,351.87 247.5,348.58 246.89,347.98 206.2,347.98 205.13,346.91 205.13,342.92 206.1,341.94 258.48,341.94 292.85,307.58 292.85,264.71 290.75,262.61 290.75,254.29 291.32,253.72 291.32,251.85
  L31_SIGNAL w0.091: 115.44,371.35 114.68,372.11 113.03,372.11 D219.07 ; v1(290.66,249.72) 290.24,250.14 290.24,251.36 290.49,251.62 291.08,251.62 291.32,251.85
  BOTTOM w0.16: UNK3U408.E9 v1(290.66,249.72)
D21908: length 392.6
  L23_SIGNAL w0.079: 111.65,368.41 111.65,367.39 112.09,366.95 128.45,366.95 145.84,349.56 148.66,349.56 149.55,350.44 149.55,355.67 149.99,356.11 152.49,356.11 153,355.6 153,342.8 153.4,342.4 155.89,342.4 156.08,342.6 156.08,349.8 156.6,350.32 158.43,350.32 158.93,349.82 158.93,338.42 160.03,337.32 162.06,337.32 162.58,337.84 162.58,344.2 163.06,344.69 165.36,344.69 165.88,344.17 165.88,332.47 166.48,331.87 168.53,331.87 169.24,332.58 169.24,337.62 169.69,338.07 171.61,338.07 172.01,337.67 172.01,332.94 174.45,330.5 299.07,330.5 305.47,324.1 336.81,324.1 340.47,320.43 340.47,307.45 340.4,307.37 339.73,307.37 339.72,307.38 339.56,307.38 339.55,307.38
  L23_SIGNAL w0.091: v3(338.84,308.03) 338.91,308.03 339.55,307.38 ; D219.08 111.65,368.41
  L29_SIGNAL w0.079: 331.32,251.85 331.32,253.72 330.75,254.29 330.75,262.61 332.85,264.71 332.85,303 337.19,307.34 338.07,307.34 338.76,308.03 v3(338.84,308.03)
  L29_SIGNAL w0.091: 331.32,251.85 331.08,251.62 330.49,251.62 330.24,251.36 330.24,250.14 v1(330.66,249.72)
  BOTTOM w0.16: UNK4U408.E9 v1(330.66,249.72)
D21909: length 205.6
  L27_SIGNAL w0.076: 226.95,238.78 227.39,238.78 227.58,238.97 227.58,239.43 v2(227.91,239.75)
  L27_SIGNAL w0.091: D219.09 108,374.7 128.47,374.7 138.68,364.49 138.68,361.7 197.48,302.9 203.83,302.9 214.62,292.11 214.62,267.74 220.16,262.2 220.16,257.56 220.92,256.79 220.92,242.72 224.86,238.78 226.95,238.78
D21910: length 259
  L25_SIGNAL w0.076: 266.95,238.78 267.39,238.78 267.58,238.97 267.58,239.43 v2(267.9,239.75)
  L25_SIGNAL w0.091: 266.95,238.78 264.86,238.78 260.92,242.72 260.92,256.79 260.16,257.56 260.16,262.2 254.62,267.74 254.62,295.73 253.69,296.66 252.14,296.66 240.5,308.3 240.5,327.73 217.06,351.16 151.61,351.16 130.59,372.18 105.48,372.18 D219.10
D21911: length 298
  L31_SIGNAL w0.076: 306.95,238.78 307.39,238.78 307.58,238.97 307.58,239.43 v2(307.9,239.75)
  L31_SIGNAL w0.091: D219.11 102.87,374.65 138.18,374.65 158.75,354.08 247.99,354.08 294.62,307.44 294.62,267.74 300.16,262.2 300.16,257.56 300.92,256.79 300.92,242.72 304.86,238.78 306.95,238.78
D21912: length 387.2
  L23_SIGNAL w0.091: v3(343.16,320.6) 343.14,320.6 341.63,319.1 341.63,306.66 340.53,305.56 338.16,305.56 337.31,306.41 337.31,320.5 334.6,323.21 305.18,323.21 298.7,329.69 163.7,329.69 128.52,364.87 105.03,364.87 D219.12
  L29_SIGNAL w0.076: v2(347.9,239.75) 347.58,239.43 347.58,238.97 347.39,238.78 346.95,238.78
  L29_SIGNAL w0.091: 346.95,238.78 344.86,238.78 340.92,242.72 340.92,256.79 340.16,257.56 340.16,262.2 334.62,267.74 334.62,301.47 339.85,306.7 339.85,318.9 341.56,320.6 v3(343.16,320.6)
D21913: length 218.1
  L27_SIGNAL w0.076: v2(227.26,240.4) 226.93,240.08 226.93,239.54
  L27_SIGNAL w0.091: D219.13 100.28,377.14 127.76,377.14 139.95,364.95 139.95,361.19 197.36,303.78 204.47,303.78 216.15,292.1 216.15,267.82 220.57,263.4 220.57,257.72 221.29,257 221.29,242.94 224.89,239.35 226.74,239.35 226.93,239.54
D21914: length 271.8
  L25_SIGNAL w0.076: 266.93,239.54 266.93,240.08 v2(267.25,240.4)
  L25_SIGNAL w0.091: D219.14 95.36,372.22 95.36,374.08 95.82,374.54 130.66,374.54 153.39,351.8 217.2,351.8 244.25,324.75 244.25,305.98 252.99,297.23 254.99,297.23 256.15,296.07 256.15,267.82 260.57,263.4 260.57,257.72 261.29,257 261.29,242.94 264.89,239.35 266.74,239.35 266.93,239.54
D21915: length 309.5
  L31_SIGNAL w0.076: 306.93,239.54 306.93,240.08 v2(307.25,240.4)
  L31_SIGNAL w0.091: 306.93,239.54 306.74,239.35 304.89,239.35 301.29,242.94 301.29,257 300.57,257.72 300.57,263.4 296.15,267.82 296.15,292.87 295.15,293.88 295.15,297.69 295.07,297.77 295.07,307.63 248.17,354.52 159.06,354.52 136.4,377.19 95.25,377.19 D219.15
D21916: length 392.5
  L23_SIGNAL w0.091: D219.16 95.38,364.36 128.31,364.36 163.49,329.18 298.45,329.18 304.93,322.71 334.39,322.71 336.8,320.29 336.8,306.2 337.95,305.05 340.74,305.05 342.14,306.45 342.14,318.06 v3(343.16,319.08)
  L29_SIGNAL w0.076: v2(347.25,240.4) 346.93,240.08 346.93,239.54
  L29_SIGNAL w0.091: 346.93,239.54 346.74,239.35 344.89,239.35 341.29,242.94 341.29,257 340.57,257.72 340.57,263.4 336.15,267.82 336.15,302.12 340.36,306.32 340.36,317.63 341.81,319.08 v3(343.16,319.08)
D22001: length 195.4
  L27_SIGNAL w0.091: D220.01 132.09,388.61 132.09,383.53 158.75,356.87 161.58,356.87 218.95,299.5 218.95,285.84 219.13,285.66 219.13,269.7 223.01,265.82 223.01,258.57 223.32,258.26 223.32,244.13 225.74,241.7 v2(226.61,241.7)
D22002: length 251.3
  L25_SIGNAL w0.091: D220.02 126,389.62 131.7,389.62 134.48,386.84 134.48,379.73 159.88,354.33 223.89,354.33 250.46,327.76 250.46,306.14 253.88,302.72 256.68,302.72 258.95,300.45 258.95,285.84 259.13,285.66 259.13,269.7 263.01,265.82 263.01,258.57 263.32,258.26 263.32,244.13 265.74,241.7 v2(266.61,241.7)
D22003: length 284.2
  L31_SIGNAL w0.091: v2(306.6,241.7) 305.74,241.7 303.32,244.13 303.32,258.26 303.01,258.57 303.01,265.82 299.13,269.7 299.13,285.66 298.95,285.84 298.95,306.54 249.01,356.48 159.81,356.48 129.79,386.5 129.79,390.79 128.14,392.43 123.19,392.43 D220.03
D22004: length 342.9
  L23_SIGNAL w0.091: v3(343.16,310.7) 343.18,310.7 344.93,312.45 344.93,321.82 340.12,326.63 306.6,326.63 299.97,333.25 181.36,333.25 129.85,384.75 129.85,388.05 128.02,389.89 120.65,389.89 D220.04
  L29_SIGNAL w0.091: v3(343.16,310.7) 342.45,310.7 342.26,310.51 342.26,305.37 338.95,302.06 338.95,285.84 339.13,285.66 339.13,269.7 343.01,265.82 343.01,258.57 343.32,258.26 343.32,244.13 345.74,241.7 v2(346.6,241.7)
D22005: length 205.1
  L27_SIGNAL w0.091: v2(225.96,241.06) 224.93,241.06 222.96,243.03 222.96,257.99 222.59,258.36 222.59,264.5 218.55,268.54 218.55,298.46 205.21,311.79 205.21,312.38 161.23,356.36 157.99,356.36 126.98,387.37 118.82,387.37 118.12,388.07 118.12,392.42 D220.05
D22006: length 260.5
  L25_SIGNAL w0.091: v2(265.96,241.06) 264.93,241.06 262.96,243.03 262.96,257.99 262.59,258.36 262.59,264.5 258.55,268.54 258.55,300.28 256.51,302.31 253.71,302.31 250.05,305.97 250.05,327.6 223.72,353.92 159.72,353.92 134.08,379.56 134.08,384.85 131.57,387.35 118.11,387.35 D220.06
D22007: length 292.9
  L31_SIGNAL w0.091: v2(305.95,241.06) 304.93,241.06 302.96,243.03 302.96,257.99 302.59,258.36 302.59,264.5 298.55,268.54 298.55,306.28 248.81,356.01 159.61,356.01 125.73,389.89 113.92,389.89 113.09,390.72 113.09,392.37 D220.07
D22008: length 352.2
  L23_SIGNAL w0.091: v3(343.16,312.22) 344.55,313.61 344.55,321.56 340,326.12 306.34,326.12 299.72,332.74 181.18,332.74 129.01,384.91 129.01,386.61 128.02,387.6 112.78,387.6 D220.08
  L29_SIGNAL w0.091: v3(343.16,312.22) 342.45,312.22 341.76,311.53 341.76,305.44 338.55,302.22 338.55,268.54 342.59,264.5 342.59,258.36 342.96,257.99 342.96,243.03 344.93,241.06 v2(345.95,241.06)
D22009: length 215.2
  L27_SIGNAL w0.091: D220.09 107.96,392.42 107.96,388.07 111.2,384.83 127.87,384.83 156.84,355.85 158.03,355.85 204.56,309.33 207.02,309.33 217.12,299.22 217.12,268.13 221.38,263.87 221.38,258.89 222.59,257.68 222.59,242.81 225,240.4 v2(225.96,240.4)
D22010: length 268
  L25_SIGNAL w0.091: v2(265.96,240.4) 265,240.4 262.59,242.81 262.59,257.68 261.38,258.89 261.38,263.87 257.12,268.13 257.12,299.47 255.74,300.85 252.28,300.85 245.24,307.88 245.24,327.85 220.1,352.99 157.6,352.99 131.74,378.86 131.74,382.35 129.27,384.81 110.49,384.81 D220.10
D22011: length 305.7
  L31_SIGNAL w0.091: D220.11 102.87,392.43 102.87,387.99 103.5,387.35 127.63,387.35 159.42,355.56 248.54,355.56 298.18,305.91 298.18,291.13 297.12,290.07 297.12,268.13 301.38,263.87 301.38,258.89 302.59,257.68 302.59,242.81 305,240.4 v2(305.95,240.4)
D22012: length 362.5
  L23_SIGNAL w0.091: D220.12 105.41,384.81 128.23,384.81 180.81,332.23 299.47,332.23 306.07,325.63 339.97,325.63 344.17,321.43 344.17,315.87 343.18,314.89 v3(343.16,314.89)
  L29_SIGNAL w0.091: v2(345.95,240.4) 345,240.4 342.59,242.81 342.59,257.68 341.38,258.89 341.38,263.87 337.12,268.13 337.12,301.56 341.38,305.82 341.38,313.69 342.57,314.89 v3(343.16,314.89)
D22013: length 226.6
  L27_SIGNAL w0.091: D220.13 97.8,392.42 97.8,386.06 101.58,382.29 127.86,382.29 154.8,355.35 157.85,355.35 204.29,308.91 205.44,308.91 215.24,299.11 215.24,295.76 216.61,294.39 216.61,268.01 221.02,263.6 221.02,258.67 222.19,257.49 222.19,257.48 222.22,257.45 222.22,242.61 225.08,239.75 v2(226.61,239.75)
D22014: length 279.2
  L25_SIGNAL w0.091: v2(266.61,239.75) 265.08,239.75 262.22,242.61 262.22,257.45 262.19,257.48 262.19,257.49 261.02,258.67 261.02,263.6 256.61,268.01 256.61,297.94 255.83,298.73 253.71,298.73 244.74,307.7 244.74,327.75 220.11,352.37 155.55,352.37 130.66,377.26 130.66,380.42 128.8,382.27 100.89,382.27 100.33,382.83 100.33,384.81 D220.14
D22015: length 316.7
  L31_SIGNAL w0.091: v2(306.6,239.75) 305.08,239.75 302.22,242.61 302.22,257.45 302.19,257.48 302.19,257.49 301.02,258.67 301.02,263.6 296.61,268.01 296.61,290.32 297.69,291.4 297.69,294.89 296.29,296.29 296.29,307.14 248.34,355.08 159.23,355.08 129.5,384.81 96.01,384.81 92.71,388.11 92.71,392.43 D220.15
D22016: length 375.2
  L23_SIGNAL w0.091: v3(343.16,316.41) 343.79,317.04 343.79,321.29 339.96,325.12 305.94,325.12 299.42,331.64 180.5,331.64 129.88,382.27 96.01,382.27 95.25,383.03 95.25,384.81 D220.16
  L29_SIGNAL w0.091: v2(346.6,239.75) 345.08,239.75 342.22,242.61 342.22,257.45 342.19,257.48 342.19,257.49 341.02,258.67 341.02,263.6 336.61,268.01 336.61,301.93 340.87,306.18 340.87,315.47 341.81,316.41 v3(343.16,316.41)
D22101: length 393
  L25_SIGNAL w0.079: 52.17,331.4 52.17,327.48 53.36,326.28 53.47,326.28 53.6,326.4 53.71,326.4 53.82,326.29 53.82,326.18 53.7,326.06 53.7,325.95 53.81,325.83 53.92,325.83 54.04,325.96 54.15,325.96 54.26,325.84 54.26,325.73 54.14,325.61 54.14,325.5 54.25,325.39 54.37,325.39 54.49,325.51 54.6,325.51 54.71,325.4 54.71,325.29 54.59,325.17 54.59,325.05 54.7,324.94 54.81,324.94 54.93,325.06 55.04,325.06 55.16,324.95 55.16,324.84 55.03,324.72 55.03,324.61 55.14,324.5 55.26,324.5 55.38,324.62 55.49,324.62 55.6,324.51 55.6,324.4 55.48,324.27 55.48,324.16 60.4,319.24 60.4,310.54 58.92,309.05 26.8,309.05 25.28,307.54 25.28,283.61 26.55,282.34 33.76,282.34 35.07,283.64 35.07,301.11 37.69,303.74 51.34,303.74 53.77,301.31 53.77,288.71 54.78,287.69 67.51,287.69 68.69,288.87 68.69,297.9 71.16,300.36 200.03,300.36 209.6,290.79 217.84,290.79 221.76,286.86 221.76,285.31 220.88,284.42 220.88,271.1 221.17,270.81 221.17,263.95 222.84,262.28 222.84,259.52 224.52,257.83 224.52,254.96 217.58,248.02 215.38,248.02 211.51,244.14 211.51,240.82
  L25_SIGNAL w0.091: D221.01 52.17,331.57 52.17,331.4 ; v1(211.66,238.65) 211.97,238.65 212.53,239.21 212.53,240.16 212.05,240.64 211.68,240.64 211.51,240.82
D22102: length 350.6
  L31_SIGNAL w0.079: 48.36,327.76 48.36,326.31 49.55,325.12 56.14,325.12 65.73,315.54 65.73,295.61 66.44,294.89 68.31,294.89 68.89,295.48 68.89,307.68 70.65,309.44 209.17,309.44 222.63,322.9 253.06,322.9 255.16,320.81 255.16,293.47 261.76,286.86 261.76,285.31 260.88,284.42 260.88,271.1 261.17,270.81 261.17,263.95 262.84,262.28 262.84,259.52 264.52,257.83 264.52,254.96 257.58,248.02 255.38,248.02 251.51,244.14 251.51,240.82
  L31_SIGNAL w0.091: 48.36,327.76 D221.02 ; 251.51,240.82 251.68,240.64 252.05,240.64 252.53,240.16 252.53,239.21 251.97,238.65 v1(251.66,238.65)
D22103: length 393
  L25_SIGNAL w0.079: 51.97,331.3 51.97,327.4 60.21,319.16 60.21,310.62 58.84,309.25 26.72,309.25 25.09,307.62 25.09,283.53 26.47,282.14 33.84,282.14 35.26,283.56 35.26,301.03 37.77,303.54 51.26,303.54 53.57,301.23 53.57,288.63 54.7,287.5 67.59,287.5 68.88,288.79 68.88,297.81 71.24,300.17 199.95,300.17 209.52,290.59 217.76,290.59 221.57,286.78 221.57,285.39 220.68,284.5 220.68,271.02 220.97,270.73 220.97,263.87 222.65,262.2 222.65,259.44 224.33,257.75 224.33,255.04 217.5,248.21 215.3,248.21 211.31,244.22 211.31,240.82
  L25_SIGNAL w0.091: D221.03 49.53,331.47 51.8,331.47 51.97,331.3 ; v1(211.16,238.65) 210.85,238.65 210.29,239.21 210.29,240.16 210.77,240.64 211.13,240.64 211.31,240.82
D22104: length 350.6
  L31_SIGNAL w0.079: 251.31,240.82 251.31,244.22 255.3,248.21 257.5,248.21 264.33,255.04 264.33,257.75 262.65,259.44 262.65,262.2 260.97,263.87 260.97,270.73 260.68,271.02 260.68,284.5 261.57,285.39 261.57,286.78 254.96,293.39 254.96,320.73 252.98,322.71 222.71,322.71 209.25,309.25 70.73,309.25 69.09,307.6 69.09,295.4 68.39,294.7 66.36,294.7 65.53,295.53 65.53,315.46 56.06,324.93 49.47,324.93 48.16,326.23 48.16,327.76
  L31_SIGNAL w0.091: 251.31,240.82 251.13,240.64 250.77,240.64 250.29,240.16 250.29,239.21 250.85,238.65 v1(251.16,238.65) ; 48.16,327.76 D221.04
D22105: length 358.4
  L23_SIGNAL w0.079: 268.4,311.58 267.57,311.58 264.82,314.33 156.7,314.33 154.35,311.99 145.98,311.99 139.64,318.32 76.61,318.32 73.41,321.52 73.41,324.22 72.53,325.1 69.57,325.1 68.83,324.37 68.83,321.47 65.53,318.17 56.99,318.17 50.17,324.99 48.95,324.99 48.87,325.07 48.87,325.18 48.79,325.25 48.63,325.25 48.56,325.18 48.56,325.07 48.48,324.99 48.32,324.99 48.24,325.07 48.24,325.18 48.16,325.25 48,325.25 47.93,325.18 47.93,325.07 47.85,324.99 47.69,324.99 47.61,325.07 47.61,325.18 47.53,325.25 47.37,325.25 47.3,325.18 47.3,325.07 47.22,324.99 47.06,324.99 46.98,325.07 46.98,325.18 46.9,325.25 46.74,325.25 46.67,325.18 46.67,325.07 46.59,324.99 46.43,324.99 46.35,325.07 46.35,325.18 46.27,325.25 46.11,325.25 46.04,325.18 46.04,325.07 45.96,324.99 45.8,324.99 45.72,325.07 45.72,325.18 45.64,325.25 45.49,325.25 45.41,325.18 45.41,325.07 45.33,324.99 43.96,324.99 41.99,326.96 41.99,330.81
  L23_SIGNAL w0.091: 41.99,330.81 41.99,331.55 D221.05 ; 268.4,311.58 269.04,312.22 v3(269.5,312.22)
  L29_SIGNAL w0.079: 291.51,240.82 291.51,244.14 295.38,248.02 297.58,248.02 304.52,254.96 304.52,257.83 302.84,259.52 302.84,262.28 301.17,263.95 301.17,270.81 300.88,271.1 300.88,284.42 301.76,285.31 301.76,286.86 296.03,292.6 289.64,292.6 285.68,296.56 278.46,296.56 271.08,303.94 271.08,311.21 270.76,311.53 270.38,311.53 269.69,312.22 v3(269.5,312.22)
  L29_SIGNAL w0.091: 291.51,240.82 291.68,240.64 292.05,240.64 292.53,240.16 292.53,239.21 291.97,238.65 v1(291.66,238.65)
D22106: length 392.6
  L13_SIGNAL w0.079: 38.16,327.72 38.15,327.71 38.15,327.16 39.16,326.14 206.81,326.14 227.89,305.06 299.81,305.06 306.26,311.51 307.49,311.51
  L13_SIGNAL w0.091: v3(308.61,312.22) 308.2,312.22 307.49,311.51 ; D221.06 38.16,327.72
  L27_SIGNAL w0.079: v3(308.61,312.22) 309.32,312.22 309.88,311.66 310.64,311.66 311.22,311.08 311.22,303.74 316.31,298.64 318.22,298.64 325.96,290.9 337.73,290.9 341.76,286.86 341.76,285.61 340.88,284.72 340.88,271.1 341.17,270.81 341.17,263.95 342.84,262.28 342.84,259.52 344.52,257.83 344.52,254.96 337.58,248.02 335.38,248.02 331.51,244.14 331.51,240.82
  L27_SIGNAL w0.091: v1(331.66,238.65) 331.97,238.65 332.53,239.21 332.53,240.16 332.05,240.64 331.68,240.64 331.51,240.82
D22107: length 358.4
  L23_SIGNAL w0.079: 41.78,330.73 41.8,330.72 41.8,326.88 43.88,324.8 50.09,324.8 56.91,317.98 65.61,317.98 69.02,321.39 69.02,324.29 69.65,324.91 72.45,324.91 73.22,324.14 73.22,321.44 76.53,318.13 139.56,318.13 145.9,311.79 154.43,311.79 156.78,314.14 264.74,314.14 267.49,311.39 268.29,311.39
  L23_SIGNAL w0.091: 41.78,330.73 41.05,331.47 39.37,331.47 D221.07 ; v3(269.5,310.7) 268.98,310.7 268.29,311.39
  L29_SIGNAL w0.079: v3(269.5,310.7) 269.74,310.7 270.38,311.34 270.68,311.34 270.89,311.13 270.89,303.86 278.38,296.37 285.6,296.37 289.56,292.4 295.95,292.4 301.57,286.78 301.57,285.39 300.68,284.5 300.68,271.02 300.97,270.73 300.97,263.87 302.65,262.2 302.65,259.44 304.33,257.75 304.33,255.04 297.5,248.21 295.3,248.21 291.31,244.22 291.31,240.82
  L29_SIGNAL w0.091: v1(291.16,238.65) 290.85,238.65 290.29,239.21 290.29,240.16 290.77,240.64 291.13,240.64 291.31,240.82
D22108: length 392.6
  L13_SIGNAL w0.079: 307.44,311.3 307.44,311.31 307.41,311.31 307.4,311.32 306.34,311.32 299.89,304.87 227.81,304.87 206.73,325.95 39.08,325.95 37.95,327.08 37.95,327.81
  L13_SIGNAL w0.091: 307.44,311.3 308.05,310.7 v3(308.61,310.7) ; D221.08 37.95,327.81
  L27_SIGNAL w0.079: v3(308.61,310.7) 309.11,310.7 309.88,311.46 310.56,311.46 311.02,311 311.02,303.66 316.23,298.45 318.13,298.45 325.88,290.7 337.65,290.7 341.57,286.78 341.57,285.69 340.68,284.8 340.68,271.02 340.97,270.73 340.97,263.87 342.65,262.2 342.65,259.44 344.33,257.75 344.33,255.04 337.5,248.21 335.3,248.21 331.31,244.22 331.31,240.82
  L27_SIGNAL w0.091: 331.31,240.82 331.13,240.64 330.77,240.64 330.29,240.16 330.29,239.21 330.85,238.65 v1(331.16,238.65)
D22109: length 393
  L25_SIGNAL w0.079: 29.31,330.83 29.31,328 24.18,322.87 23.53,322.87 20.5,319.84 20.5,306.21 18,303.71 18,278.98 23.18,273.8 34.65,273.8 37.5,276.65 37.5,300.84 39.25,302.59 50.54,302.59 51.34,301.79 51.34,277 54.19,274.15 69.62,274.15 71.12,275.65 71.12,298.27 72.05,299.2 199.31,299.2 209.42,289.08 217.49,289.08 218.58,287.99 218.58,284.51 218.97,284.13 218.97,270.71 219.76,269.92 219.76,262.7 222,260.47 222,258.83 222.8,258.02 222.8,255.32 221.48,254 218.12,254 217.47,253.35 212.48,253.35 211.51,252.37 211.51,251.37
  L25_SIGNAL w0.091: 29.31,330.83 29.95,331.47 31.75,331.47 D221.09 ; v1(211.66,251.22) 211.51,251.37
D22110: length 350.6
  L31_SIGNAL w0.079: 251.52,251.36 251.52,251.46 251.51,251.47 251.51,252.37 252.48,253.35 257.47,253.35 258.12,254 261.48,254 262.8,255.32 262.8,258.02 262,258.83 262,260.47 259.76,262.7 259.76,269.92 258.97,270.71 258.97,284.13 258.58,284.51 258.58,288.15 253.12,293.62 253.12,321.09 252.23,321.98 225.97,321.98 208.23,304.23 73.58,304.23 71.18,301.83 71.18,293.92 70,292.74 64.52,292.74 63.25,294 63.25,303.4 48.76,317.88 35.43,317.88 28.04,325.28 28.04,327.76
  L31_SIGNAL w0.091: 28.04,327.76 D221.10 ; v1(251.66,251.22) 251.52,251.36
D22111: length 393
  L25_SIGNAL w0.079: 211.31,251.37 211.31,252.45 212.4,253.54 217.39,253.54 218.04,254.19 221.4,254.19 222.61,255.4 222.61,257.94 221.8,258.75 221.8,260.39 219.57,262.62 219.57,269.84 218.77,270.63 218.77,284.05 218.39,284.43 218.39,287.91 217.41,288.89 209.34,288.89 199.23,299.01 72.13,299.01 71.32,298.19 71.32,275.57 69.7,273.95 54.11,273.95 51.14,276.92 51.14,301.71 50.46,302.4 39.33,302.4 37.69,300.76 37.69,276.57 34.73,273.61 23.1,273.61 17.81,278.9 17.81,303.79 20.3,306.29 20.3,319.92 23.45,323.07 24.1,323.07 25.05,324.01 25.05,324.12 24.97,324.2 24.97,324.31 25.08,324.42 25.19,324.42 25.27,324.35 25.38,324.35 25.49,324.46 25.49,324.57 25.41,324.65 25.41,324.76 25.52,324.87 25.63,324.87 25.71,324.79 25.83,324.79 25.94,324.9 25.94,325.01 25.86,325.09 25.86,325.2 25.97,325.32 26.08,325.32 26.16,325.24 26.27,325.24 26.38,325.35 26.38,325.46 26.3,325.54 26.3,325.65 26.41,325.76 26.53,325.76 26.6,325.68 26.72,325.68 26.83,325.79 26.83,325.9 26.75,325.98 26.75,326.09 26.86,326.21 26.97,326.21 27.05,326.13 27.16,326.13 27.27,326.24 27.27,326.35 27.19,326.43 27.19,326.54 27.31,326.65 27.42,326.65 27.5,326.57 27.61,326.57 29.11,328.08 29.11,330.93
  L25_SIGNAL w0.091: 211.31,251.37 v1(211.16,251.22) ; 29.11,330.93 29.11,331.57 D221.11
D22112: length 350.6
  L31_SIGNAL w0.079: 27.84,327.76 27.84,325.2 35.35,317.69 48.68,317.69 63.05,303.32 63.05,293.92 64.44,292.54 70.08,292.54 71.37,293.84 71.37,301.75 73.66,304.04 208.31,304.04 226.05,321.78 252.15,321.78 252.92,321.01 252.92,293.54 258.39,288.07 258.39,284.43 258.77,284.05 258.77,270.63 259.57,269.84 259.57,262.62 261.8,260.39 261.8,258.75 262.61,257.94 262.61,255.4 261.4,254.19 258.04,254.19 257.39,253.54 252.4,253.54 251.31,252.45 251.31,251.37
  L31_SIGNAL w0.091: v1(251.16,251.22) 251.31,251.37 ; 27.84,327.76 D221.12
D22113: length 358.4
  L23_SIGNAL w0.079: 270.51,307.13 270.77,307.13 271.14,307.51 271.14,308.5 269.95,309.69 75.52,309.69 73.97,311.25 69.6,311.25 68.07,309.71 52.5,309.71 37.54,324.67 31.02,324.67 30.94,324.75 30.94,324.89 30.86,324.97 30.7,324.97 30.62,324.89 30.62,324.75 30.55,324.67 30.39,324.67 30.31,324.75 30.31,324.89 30.23,324.97 30.07,324.97 29.99,324.89 29.99,324.75 29.92,324.67 29.76,324.67 29.68,324.75 29.68,324.89 29.6,324.97 29.44,324.97 29.36,324.89 29.36,324.75 29.29,324.67 29.13,324.67 29.05,324.75 29.05,324.89 28.97,324.97 28.81,324.97 28.73,324.89 28.73,324.75 28.66,324.67 28.5,324.67 28.42,324.75 28.42,324.89 28.34,324.97 28.18,324.97 28.1,324.89 28.1,324.75 28.03,324.67 25.08,324.67 21.66,328.09 21.66,330.83
  L23_SIGNAL w0.091: v3(269.5,306.5) 269.88,306.5 270.51,307.13 ; 21.66,330.83 21.66,331.54 D221.13
  L29_SIGNAL w0.079: v3(269.5,306.5) 269.26,306.5 268.62,307.15 268.32,307.15 268.17,307 268.17,305 277.78,295.39 281.9,295.39 284.26,293.03 285.11,293.03 287.32,290.83 295.77,290.83 298.58,288.02 298.58,284.51 298.97,284.13 298.97,270.71 299.76,269.92 299.76,262.7 301.49,260.97 301.49,258.57 302.8,257.26 302.8,255.32 301.48,254 298.12,254 297.47,253.35 292.48,253.35 291.51,252.37 291.51,251.37
  L29_SIGNAL w0.091: v1(291.66,251.22) 291.51,251.37
D22114: length 392.6
  L13_SIGNAL w0.079: 17.8,327.68 17.8,326.09 17.78,326.08 21.04,322.82 208.32,322.82 227.93,303.21 302.64,303.21 306.88,307.44 307.59,307.44 307.6,307.45 307.75,307.45 307.76,307.46
  L13_SIGNAL w0.091: 307.76,307.46 308.33,308.03 v3(308.61,308.03) ; D221.14 17.8,327.68
  L27_SIGNAL w0.079: v3(308.61,308.03) 308.85,308.03 309.5,307.38 309.76,307.38 310.13,307 310.13,302.92 315.8,297.25 317.96,297.25 326.16,289.05 331.7,289.05 338.97,281.79 338.97,270.71 339.76,269.92 339.76,262.7 342,260.47 342,258.83 342.43,258.39 342.43,254.95 341.48,254 338.12,254 337.47,253.35 332.48,253.35 331.51,252.37 331.51,251.37
  L27_SIGNAL w0.091: v1(331.66,251.22) 331.51,251.37
D22115: length 358.4
  L23_SIGNAL w0.079: 21.46,330.73 21.46,328.01 25,324.48 37.46,324.48 52.42,309.51 68.15,309.51 69.68,311.05 73.89,311.05 75.44,309.5 269.87,309.5 270.94,308.43 270.94,307.59 270.69,307.34 270.51,307.34
  L23_SIGNAL w0.091: D221.15 19.05,331.47 20.73,331.47 21.46,330.73 ; 270.51,307.34 269.82,308.03 v3(269.5,308.03)
  L29_SIGNAL w0.079: 291.31,251.37 291.31,252.45 292.4,253.54 297.39,253.54 298.04,254.19 301.4,254.19 302.61,255.4 302.61,257.18 301.29,258.49 301.29,260.89 299.57,262.62 299.57,269.84 298.77,270.63 298.77,284.05 298.39,284.43 298.39,287.94 295.69,290.64 287.24,290.64 285.03,292.84 284.18,292.84 281.82,295.2 277.7,295.2 267.98,304.92 267.98,307.08 268.24,307.34 268.58,307.34 269.27,308.03 v3(269.5,308.03)
  L29_SIGNAL w0.091: v1(291.16,251.22) 291.31,251.37
