# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D12913: length 304.3
  L15_SIGNAL w0.079: 261.1,117.65 261.8,117.65 262.06,117.39 262.06,116.27 261.56,115.76 255.57,115.76 254.31,114.51 254.31,110.57 250.66,106.92 220.91,106.92 220.9,106.92 151.63,106.92 150.88,106.17 150.88,98.6 149.7,97.43 145.86,97.43 144.8,98.49 144.8,114.39 144.16,115.02 138.7,115.02 138.18,114.5 138.18,108.48 136.62,106.92 122.54,106.92 122.03,106.4 121.91,106.4 121.8,106.52 121.69,106.52 121.58,106.4 121.58,106.29 121.69,106.18 121.69,106.07 121.58,105.96 121.47,105.96 121.36,106.07 121.25,106.07 121.13,105.96 121.13,105.85 121.25,105.74 121.25,105.62 121.13,105.51 121.02,105.51 120.91,105.62 120.8,105.62 120.69,105.51 120.69,105.4 120.8,105.29 120.8,105.18 120.69,105.07 120.58,105.07 120.47,105.18 120.36,105.18 120.24,105.07 120.24,104.96 120.35,104.85 120.35,104.73 120.24,104.62 120.13,104.62 120.02,104.73 119.91,104.73 119.8,104.62 119.8,104.51 119.91,104.4 119.91,104.29 119.8,104.18 119.69,104.18 119.58,104.29 119.46,104.29 119.35,104.18 119.35,104.07 119.46,103.95 119.46,103.84 118.07,102.45 118.07,98.43
  L15_SIGNAL w0.091: 261.1,117.65 260.49,117.04 v3(260.09,117.04) ; 118.07,98.43 118.07,97.75 D129.13
  L29_SIGNAL w0.079: 291.51,180.82 291.51,181.65 291.76,181.9 297.68,181.9 298.65,180.92 298.65,178.82 301.59,175.88 301.59,171.96 302.19,171.35 302.19,165.71 301.5,165.02 300.17,165.02 295.2,160.05 295.2,144.58 292.73,142.11 292.73,139.83 285.94,133.04 273.35,133.04 269.03,128.72 266.11,128.72 262.68,125.29 260.9,125.29 258,122.38 258,118.03 258.32,117.71 259.22,117.71 259.89,117.04 v3(260.09,117.04)
  L29_SIGNAL w0.091: 291.51,180.82 291.68,180.64 292.05,180.64 292.53,180.16 292.53,179.21 291.97,178.65 v1(291.66,178.65)
D12914: length 342.5
  L23_SIGNAL w0.079: 336.68,117.86 335.75,117.86 328.01,125.59 151.74,125.59 145.04,118.89 145.04,96.04 144.23,95.22 140.09,95.22 139.06,96.26 139.06,101.2 136.37,103.89 126.74,103.89 126.66,103.96 126.66,103.99 126.58,104.07 126.42,104.07 126.34,103.99 126.34,103.96 126.26,103.89 126.11,103.89 126.03,103.96 126.03,103.99 125.95,104.07 125.79,104.07 125.71,103.99 125.71,103.96 125.63,103.89 125.48,103.89 125.4,103.96 125.4,103.99 125.32,104.07 125.16,104.07 125.08,103.99 125.08,103.96 125,103.89 123.19,103.89 121.83,102.53 121.83,101.51
  L23_SIGNAL w0.091: 336.68,117.86 337.39,118.56 v3(338.07,118.56) ; 121.83,101.51 D129.14
  L27_SIGNAL w0.079: 331.51,180.82 331.51,181.65 331.76,181.9 337.68,181.9 338.65,180.92 338.65,178.82 341.59,175.88 341.59,171.96 342.19,171.35 342.19,165.71 341.5,165.02 340.17,165.02 335.2,160.05 335.2,152.99 336.68,151.51 336.68,129.52 340.64,125.56 340.64,118.65 339.85,117.86 339.34,117.86
  L27_SIGNAL w0.091: v1(331.66,178.65) 331.97,178.65 332.53,179.21 332.53,180.16 332.05,180.64 331.68,180.64 331.51,180.82 ; v3(338.07,118.56) 338.64,118.56 339.34,117.86
D12915: length 304.3
  L15_SIGNAL w0.079: 118.26,98.53 118.26,102.37 122.62,106.73 136.7,106.73 138.37,108.4 138.37,114.42 138.78,114.83 144.08,114.83 144.6,114.31 144.6,98.41 145.78,97.23 149.78,97.23 151.07,98.52 151.07,106.09 151.71,106.73 220.82,106.73 220.83,106.73 250.74,106.73 254.51,110.49 254.51,114.43 255.65,115.57 261.64,115.57 262.25,116.19 262.25,117.47 261.88,117.85 261.12,117.85
  L15_SIGNAL w0.091: 261.12,117.85 260.4,118.56 v3(260.09,118.56) ; 118.26,98.53 119,97.79 120.65,97.79 D129.15
  L29_SIGNAL w0.079: 291.31,180.82 291.31,181.73 291.68,182.09 297.76,182.09 298.84,181 298.84,178.9 301.78,175.96 301.78,172.04 302.39,171.43 302.39,165.63 301.58,164.83 300.25,164.83 295.39,159.97 295.39,144.5 292.93,142.03 292.93,139.75 286.02,132.84 273.43,132.84 269.11,128.52 266.19,128.52 262.76,125.09 260.99,125.09 258.19,122.3 258.19,118.11 258.4,117.9 259.22,117.9 259.89,118.56 v3(260.09,118.56)
  L29_SIGNAL w0.091: v1(291.16,178.65) 290.85,178.65 290.29,179.21 290.29,180.16 290.77,180.64 291.13,180.64 291.31,180.82
D12916: length 342.5
  L23_SIGNAL w0.079: 122.02,101.5 122.02,102.45 123.27,103.69 136.29,103.69 138.86,101.12 138.86,96.18 140.01,95.03 144.31,95.03 145.23,95.96 145.23,118.81 151.82,125.4 327.93,125.4 335.67,117.66 336.68,117.66
  L23_SIGNAL w0.091: v3(338.07,117.04) 337.3,117.04 336.68,117.66 ; 122.02,101.5 D129.16
  L27_SIGNAL w0.079: 331.31,180.82 331.31,181.73 331.68,182.09 337.76,182.09 338.84,181 338.84,178.9 341.78,175.96 341.78,172.04 342.39,171.43 342.39,165.63 341.58,164.83 340.25,164.83 335.39,159.97 335.39,153.07 336.87,151.59 336.87,129.6 340.84,125.64 340.84,118.57 339.93,117.66 339.34,117.66
  L27_SIGNAL w0.091: v1(331.16,178.65) 330.85,178.65 330.29,179.21 330.29,180.16 330.77,180.64 331.13,180.64 331.31,180.82 ; v3(338.07,117.04) 338.72,117.04 339.34,117.66
D13001: length 231
  L25_SIGNAL w0.076: 225.69,189.18 230.18,189.18 v2(230.5,188.86)
  L25_SIGNAL w0.091: D130.01 87.65,77.49 87.65,81.29 93.98,87.62 128.04,87.62 134.7,94.29 134.7,118.36 171.31,154.96 208.51,154.96 210.82,152.65 217.71,152.65 218.73,153.67 218.73,162.11 220.72,164.1 221.97,164.1 223.16,165.29 223.16,168.97 224.14,169.94 224.14,175.05 221.24,177.95 221.24,187.78 222.64,189.18 225.69,189.18
D13002: length 273.5
  L31_SIGNAL w0.076: v2(270.5,188.86) 270.18,189.18 265.69,189.18
  L31_SIGNAL w0.091: D130.02 95.5,85.34 95.5,86.87 96.27,87.63 133.1,87.63 150.03,104.56 249.74,104.56 252.71,107.53 252.71,123.92 258.73,129.93 258.73,162.11 260.72,164.1 261.97,164.1 263.16,165.29 263.16,168.97 264.14,169.94 264.14,175.05 261.24,177.95 261.24,187.78 262.64,189.18 265.69,189.18
D13003: length 308.4
  L23_SIGNAL w0.091: v3(260.09,122.76) 260.07,122.76 258.67,121.35 258.67,108.85 257.13,107.31 162.42,107.31 152.15,97.04 152.15,89.41 145.29,82.55 94,82.55 92.71,81.26 92.71,77.47 D130.03
  L29_SIGNAL w0.076: 305.69,189.18 310.18,189.18 v2(310.5,188.86)
  L29_SIGNAL w0.091: v3(260.09,122.76) 261.57,122.76 266.45,127.64 270.01,127.64 274.07,131.7 288.29,131.7 294.13,137.54 294.13,141.73 298.73,146.33 298.73,162.11 300.72,164.1 301.97,164.1 303.16,165.29 303.16,168.97 304.14,169.94 304.14,175.05 301.24,177.95 301.24,187.78 302.64,189.18 305.69,189.18
D13004: length 354
  L21_SIGNAL w0.102: D130.04 100.33,85.09 100.33,86.35 101.61,87.63 159.57,87.63 163.3,91.36 281.91,91.36 301.75,111.21 301.75,114.68 303.4,116.33 336.11,116.33 v3(338.07,114.37)
  L27_SIGNAL w0.076: v2(350.5,188.86) 350.18,189.18 345.69,189.18
  L27_SIGNAL w0.091: 345.69,189.18 342.64,189.18 341.24,187.78 341.24,177.95 344.14,175.05 344.14,169.94 343.16,168.97 343.16,165.29 341.97,164.1 340.72,164.1 338.73,162.11 338.73,150.13 338.21,149.61 338.21,129.45 341.76,125.9 341.76,118.07 v3(338.07,114.37)
D13005: length 219.1
  L25_SIGNAL w0.076: 225.68,188.53 227.58,188.53 v2(227.91,188.86)
  L25_SIGNAL w0.091: D130.05 97.84,77.52 97.84,82.27 100.57,85 127.97,85 135.21,92.24 135.21,118.26 171.44,154.49 208.22,154.49 210.62,152.09 218.4,152.09 221.19,154.88 221.19,161.1 222.25,162.16 222.25,163.79 223.51,165.05 225,165.05 225.45,165.5 225.45,167.39 224.88,167.96 224.88,174.89 222.59,177.19 222.59,186.67 224.45,188.53 225.68,188.53
D13006: length 258.7
  L31_SIGNAL w0.076: 265.68,188.53 267.58,188.53 v2(267.9,188.86)
  L31_SIGNAL w0.091: 265.68,188.53 264.45,188.53 262.59,186.67 262.59,177.19 264.88,174.89 264.88,167.96 265.45,167.39 265.45,165.5 265,165.05 263.51,165.05 262.25,163.79 262.25,162.16 261.19,161.1 261.19,150.79 259.21,148.8 259.21,129.67 253.24,123.7 253.24,107.31 250.03,104.1 150.29,104.1 131.28,85.09 105.41,85.09 D130.06
D13007: length 294.6
  L23_SIGNAL w0.091: D130.07 102.87,77.47 102.87,79.5 103.38,80.01 143.51,80.01 152.65,89.15 152.65,97.03 162.53,106.9 257.3,106.9 259.08,108.68 259.08,120.22 v3(260.09,121.23)
  L29_SIGNAL w0.076: 305.68,188.53 307.58,188.53 v2(307.9,188.86)
  L29_SIGNAL w0.091: v3(260.09,121.23) 260.68,121.23 266.46,127.02 270.02,127.02 274.32,131.32 291.33,131.32 296.16,136.15 296.16,140.46 299.59,143.89 299.59,148.56 301.19,150.16 301.19,161.1 302.25,162.16 302.25,163.79 303.51,165.05 305,165.05 305.45,165.5 305.45,167.39 304.88,167.96 304.88,174.89 302.59,177.19 302.59,186.67 304.45,188.53 305.68,188.53
D13008: length 343.1
  L21_SIGNAL w0.102: v3(342.39,122.76) 342.36,122.76 339.22,119.61 339.22,112.52 338.96,112.27 337.46,112.27 336.55,113.18 336.55,114.81 335.53,115.82 303.53,115.82 302.26,114.55 302.26,111.14 282.08,90.96 163.47,90.96 157.6,85.09 110.49,85.09 D130.08
  L27_SIGNAL w0.076: v2(347.9,188.86) 347.58,188.53 345.68,188.53
  L27_SIGNAL w0.091: 345.68,188.53 344.45,188.53 342.59,186.67 342.59,177.19 344.88,174.89 344.88,167.96 345.45,167.39 345.45,165.5 344.99,165.05 343.51,165.05 342.25,163.79 342.25,162.16 341.19,161.1 341.19,150.55 338.65,148 338.65,129.63 342.39,125.89 v3(342.39,122.76)
D13009: length 208.6
  L25_SIGNAL w0.076: 225.8,186.58 226.93,186.58 v2(227.26,186.91)
  L25_SIGNAL w0.091: D130.09 107.92,77.44 107.92,81.78 108.71,82.57 127.73,82.57 135.65,90.49 135.65,116.8 171.96,153.11 208.84,153.11 210.25,151.7 219.9,151.7 220.1,151.9 220.21,151.9 221.75,153.44 221.75,157.77 222.69,158.71 222.69,163.6 223.72,164.63 225.19,164.63 225.65,165.09 226.88,165.09 227.6,165.82 227.6,168.45 227.26,168.79 227.26,173.07 223.27,177.06 223.27,185.42 224.44,186.58 225.8,186.58
D13010: length 248.3
  L31_SIGNAL w0.076: v2(267.25,186.91) 266.93,186.58 265.8,186.58
  L31_SIGNAL w0.091: D130.10 113.03,82.55 129.46,82.55 150.62,103.72 250.4,103.72 253.87,107.19 253.87,123.44 260.35,129.92 260.35,149.35 261.75,150.75 261.75,157.66 262.69,158.59 262.69,163.6 263.72,164.63 265.19,164.63 265.65,165.09 266.88,165.09 267.6,165.82 267.6,168.45 267.26,168.79 267.26,173.07 263.27,177.06 263.27,185.42 264.44,186.58 265.8,186.58
D13011: length 282.9
  L23_SIGNAL w0.091: D130.11 113.28,77.72 141.98,77.72 153.16,88.91 153.16,96.9 162.8,106.54 259.44,106.54 260.98,108.08 260.98,119.35 264.39,122.76 v3(264.41,122.76)
  L29_SIGNAL w0.076: 305.8,186.58 306.93,186.58 v2(307.25,186.91)
  L29_SIGNAL w0.091: v3(264.41,122.76) 268.15,126.49 270.89,126.49 275.34,130.94 291.62,130.94 296.88,136.19 296.88,140.28 300.35,143.76 300.35,148.21 301.75,149.61 301.75,157.84 302.69,158.77 302.69,163.6 303.72,164.63 305.19,164.63 305.65,165.09 306.88,165.09 307.6,165.82 307.6,168.45 307.26,168.79 307.26,173.07 303.27,177.06 303.27,185.42 304.44,186.58 305.8,186.58
D13012: length 333.4
  L21_SIGNAL w0.102: v3(342.39,121.23) 339.72,118.57 339.72,112.39 339.09,111.76 337.4,111.76 336.14,113.01 336.14,114.58 335.53,115.19 303.55,115.19 302.97,114.6 302.97,111.27 282.24,90.55 163.64,90.55 155.64,82.55 118.11,82.55 D130.12
  L27_SIGNAL w0.076: 345.8,186.58 346.93,186.58 v2(347.25,186.91)
  L27_SIGNAL w0.091: v3(342.39,121.23) 342.72,121.23 343.79,122.3 343.79,125.16 339.12,129.83 339.12,147.84 341.75,150.47 341.75,157.61 342.69,158.54 342.69,163.6 343.72,164.63 345.19,164.63 345.65,165.09 346.88,165.09 347.6,165.82 347.6,168.45 347.26,168.79 347.26,173.07 343.27,177.06 343.27,185.42 344.44,186.58 345.8,186.58
D13013: length 200
  L25_SIGNAL w0.076: v2(226.61,184.31) 225.79,184.31 225.63,184.46
  L25_SIGNAL w0.091: 225.63,184.46 225.24,184.86 224.46,184.86 223.7,184.1 223.7,179.81 224.36,179.15 224.36,176.51 225.56,175.31 226.58,175.31 228.1,173.79 228.73,173.79 230.37,172.15 230.37,165.99 229.47,165.09 227.42,165.09 226.66,164.33 225.4,164.33 225.06,163.98 223.87,163.98 223.25,163.36 223.25,158.6 222.42,157.77 222.42,153.39 220.56,151.53 220.25,151.53 220.05,151.33 209.02,151.33 207.75,152.61 172.06,152.61 136.08,116.62 136.08,88.42 127.73,80.08 118.95,80.08 118.16,79.29 118.16,77.52 D130.13
D13014: length 240.3
  L31_SIGNAL w0.076: v2(266.61,184.31) 265.79,184.31 265.63,184.46
  L31_SIGNAL w0.091: D130.14 120.65,80.01 127.63,80.01 150.91,103.28 250.73,103.28 254.51,107.06 254.51,123.44 260.99,129.92 260.99,148.72 262.42,150.15 262.42,157.66 263.25,158.48 263.25,163.36 263.87,163.98 265.06,163.98 265.4,164.33 266.66,164.33 267.42,165.09 269.47,165.09 270.36,165.99 270.36,172.15 268.73,173.79 268.1,173.79 266.58,175.31 265.56,175.31 264.36,176.51 264.36,179.15 263.7,179.81 263.7,184.1 264.46,184.86 265.24,184.86 265.63,184.46
D13015: length 275.7
  L23_SIGNAL w0.091: v3(264.41,121.23) 261.56,118.38 261.56,108.14 259.59,106.17 163.19,106.17 153.67,96.65 153.67,88.65 142.38,77.36 123.08,77.36 D130.15
  L29_SIGNAL w0.076: v2(306.6,184.31) 305.79,184.31 305.63,184.46
  L29_SIGNAL w0.091: 305.63,184.46 305.24,184.86 304.46,184.86 303.7,184.1 303.7,179.81 304.36,179.15 304.36,176.51 305.56,175.31 306.58,175.31 308.1,173.79 308.73,173.79 310.36,172.15 310.36,165.99 309.47,165.09 307.42,165.09 306.66,164.33 305.4,164.33 305.06,163.98 303.87,163.98 303.25,163.36 303.25,158.66 302.42,157.83 302.42,149.76 302.77,149.41 302.77,148.59 300.86,146.69 300.86,143.64 298.13,140.91 298.13,135.67 292.05,129.59 274.62,129.59 271.02,125.98 268.86,125.98 266.32,123.44 266.32,122.43 265.12,121.23 v3(264.41,121.23)
D13016: length 318.4
  L21_SIGNAL w0.102: v3(342.39,118.56) 342.36,118.56 340.23,116.44 340.23,112.27 339.22,111.25 303.59,111.25 282.43,90.09 163.75,90.09 153.67,80.01 125.73,80.01 D130.16
  L27_SIGNAL w0.076: v2(346.6,184.31) 345.79,184.31 345.63,184.46
  L27_SIGNAL w0.091: v3(342.39,118.56) 344.39,120.57 344.39,126.08 340.85,129.62 340.85,146.92 342.42,148.49 342.42,157.6 343.25,158.43 343.25,163.36 343.87,163.98 345.06,163.98 345.4,164.33 346.66,164.33 347.42,165.09 349.47,165.09 350.36,165.99 350.36,172.15 348.73,173.79 348.1,173.79 346.58,175.31 345.56,175.31 344.36,176.51 344.36,179.15 343.7,179.81 343.7,184.1 344.46,184.86 345.24,184.86 345.63,184.46
D13101: length 244.4
  L25_SIGNAL w0.091: v2(225.96,183.66) 225.95,183.66 225.05,183.66 224.16,182.78 224.16,179.88 231.34,172.7 231.34,166.39 229.66,164.72 227.63,164.72 226.86,163.96 225.83,163.96 225.27,163.39 225.27,159.96 224.27,158.97 224.27,153.37 221.02,150.11 209.55,150.11 207.54,152.12 173.49,152.12 136.51,115.15 136.51,75.93 127.9,67.32 93.98,67.32 87.65,60.99 87.65,57.17 D131.01
D13102: length 283.7
  L31_SIGNAL w0.091: D131.02 95.5,65.02 95.5,66.55 96.27,67.31 127.63,67.31 130.3,69.98 130.3,81.03 152.18,102.9 251.11,102.9 256.54,108.33 256.54,124.21 262.25,129.92 262.25,143.89 264.92,146.56 264.92,147.83 264.27,148.48 264.27,158.97 265.27,159.96 265.27,163.39 265.83,163.96 266.86,163.96 267.63,164.72 269.66,164.72 271.34,166.39 271.34,172.7 264.16,179.88 264.16,182.78 265.05,183.66 265.95,183.66 v2(265.96,183.66)
D13103: length 315.2
  L15_SIGNAL w0.091: v3(264.41,118.56) 264.39,118.56 262.99,117.16 262.99,109.76 259.15,105.92 161.29,105.92 142.62,87.25 142.62,72.9 129.41,59.69 94,59.69 92.71,58.4 92.71,57.15 D131.03
  L29_SIGNAL w0.091: v3(264.41,118.56) 267.08,121.23 267.08,123.06 269.54,125.52 271.1,125.52 274.61,129.03 293.29,129.03 300.33,136.07 300.33,141.83 304.68,146.18 304.68,147.32 304.27,147.72 304.27,158.97 305.27,159.96 305.27,163.39 305.83,163.96 306.86,163.96 307.63,164.72 309.66,164.72 311.34,166.39 311.34,172.7 304.16,179.88 304.16,182.78 305.05,183.66 305.95,183.66 v2(305.95,183.66)
D13104: length 355.4
  L21_SIGNAL w0.102: v3(342.39,117.04) 340.64,115.29 340.64,112.04 339.34,110.74 306.96,110.74 285.9,89.69 164.28,89.69 141.9,67.31 101.61,67.31 100.33,66.03 100.33,64.77 D131.04
  L27_SIGNAL w0.091: v3(342.39,117.04) 342.85,117.04 344.95,119.15 344.95,126.11 341.27,129.79 341.27,142.39 344.68,145.8 344.68,150.88 344.27,151.28 344.27,158.97 345.27,159.96 345.27,163.39 345.83,163.96 346.86,163.96 347.63,164.72 349.66,164.72 351.34,166.39 351.34,172.7 344.16,179.88 344.16,182.78 345.05,183.66 345.95,183.66 v2(345.95,183.66)
D13105: length 234.7
  L25_SIGNAL w0.091: D131.05 97.77,57.13 97.77,61.43 101.07,64.73 127.94,64.73 136.97,73.76 136.97,114.95 172.54,150.52 207.36,150.52 208.28,149.61 224.75,149.61 226.4,151.26 226.4,160.27 227.54,161.41 227.54,163.64 228.23,164.33 229.95,164.33 232.02,166.4 232.02,172.56 225.04,179.54 225.04,181.78 225.62,182.36 v2(225.96,182.36)
D13106: length 271
  L31_SIGNAL w0.091: v2(265.96,182.36) 265.62,182.36 265.04,181.78 265.04,179.54 272.02,172.56 272.02,166.4 269.95,164.33 268.23,164.33 267.54,163.64 267.54,161.41 266.4,160.27 266.4,150.07 265.68,149.35 265.68,144.27 264.67,143.26 264.67,134.37 262.76,132.46 262.76,129.67 257.05,123.95 257.05,107.7 251.88,102.52 152.81,102.52 131.19,80.9 131.19,68.58 127.38,64.77 105.41,64.77 D131.06
D13107: length 302.8
  L15_SIGNAL w0.091: v3(264.41,117.04) 263.47,116.1 263.47,109.52 259.49,105.54 161.67,105.54 143.26,87.12 143.26,72.39 128.02,57.15 102.87,57.15 D131.07
  L29_SIGNAL w0.091: v3(264.41,117.04) 264.74,117.04 267.72,120.02 267.72,122.94 269.81,125.03 271.23,125.03 274.79,128.6 294.69,128.6 300.76,134.67 300.76,141.5 305.56,146.3 305.56,148.46 306.4,149.3 306.4,160.27 307.54,161.41 307.54,163.64 308.23,164.33 309.95,164.33 312.02,166.4 312.02,172.56 305.04,179.54 305.04,181.78 305.62,182.36 v2(305.95,182.36)
D13108: length 342.5
  L21_SIGNAL w0.102: v3(342.39,114.37) 342.36,114.37 341.05,113.06 341.05,109.65 339.45,108.05 304.84,108.05 286.07,89.28 164.45,89.28 139.93,64.77 110.49,64.77 D131.08
  L27_SIGNAL w0.091: v2(345.95,182.36) 345.62,182.36 345.04,181.78 345.04,179.54 352.02,172.56 352.02,166.4 349.95,164.33 348.23,164.33 347.54,163.64 347.54,161.41 346.4,160.27 346.4,149.04 345.44,148.08 345.44,145.54 342.3,142.4 342.3,130.59 345.42,127.46 345.42,117.41 v3(342.39,114.37)
D13109: length 225.2
  L25_SIGNAL w0.076: v2(227.26,182.35) 226.93,182.03 225.85,182.03
  L25_SIGNAL w0.091: D131.09 107.92,57.12 107.92,61.46 108.69,62.23 128.83,62.23 138.48,71.88 138.48,114.41 173.51,149.44 207.68,149.44 207.9,149.22 225.2,149.22 228.79,152.82 228.79,160.42 229.84,161.47 229.84,163.49 232.39,166.03 232.39,172.76 225.42,179.72 225.42,181.61 225.85,182.03
D13110: length 269.6
  L31_SIGNAL w0.076: 265.85,182.03 266.93,182.03 v2(267.25,182.35)
  L31_SIGNAL w0.091: D131.10 113.03,62.23 127.76,62.23 132.22,66.69 132.22,80.42 143.1,91.3 254.36,91.3 257.7,94.64 257.7,101.24 262.02,105.56 262.02,125.37 266.95,130.31 266.95,145.03 268.79,146.87 268.79,160.42 269.84,161.47 269.84,163.49 272.39,166.03 272.39,172.76 265.42,179.72 265.42,181.61 265.85,182.03
D13111: length 300.7
  L23_SIGNAL w0.091: D131.11 113.03,57.15 113.03,59.18 113.54,59.69 141.6,59.69 154.18,72.26 154.18,96.42 163.55,105.79 262.99,105.79 265.03,107.84 265.03,119.08 268.71,122.76 v3(268.73,122.76)
  L29_SIGNAL w0.076: 305.85,182.03 306.93,182.03 v2(307.25,182.35)
  L29_SIGNAL w0.091: v3(268.73,122.76) 269.59,122.76 274.98,128.14 294.92,128.14 301.24,134.47 301.24,141.1 308.79,148.65 308.79,160.42 309.84,161.47 309.84,163.49 312.39,166.03 312.39,172.76 305.42,179.72 305.42,181.61 305.85,182.03
D13112: length 331.7
  L21_SIGNAL w0.102: v3(342.39,112.85) 341.5,111.96 341.5,109.35 339.78,107.62 305.06,107.62 286.26,88.82 164.56,88.82 137.97,62.23 118.11,62.23 D131.12
  L27_SIGNAL w0.076: 345.85,182.03 346.93,182.03 v2(347.25,182.35)
  L27_SIGNAL w0.091: 345.85,182.03 345.42,181.61 345.42,179.72 352.39,172.76 352.39,166.03 349.84,163.49 349.84,161.47 348.79,160.42 348.79,147.88 344.94,144.03 344.94,134.37 344.6,134.04 344.6,129.81 345.91,128.51 345.91,115.53 343.23,112.85 v3(342.39,112.85)
D13113: length 208.9
  L25_SIGNAL w0.091: v2(233.11,180.41) 233.11,166.21 230.25,163.35 230.25,161.3 229.16,160.21 229.16,150.88 227.13,148.84 226.19,148.84 225.38,148.04 174.68,148.04 140.06,113.41 140.06,70.61 129.13,59.69 118.87,59.69 118.16,58.97 118.16,57.2 D131.13
D13114: length 255.1
  L31_SIGNAL w0.091: D131.14 120.65,59.69 128.02,59.69 132.59,64.26 132.59,80.26 143.26,90.93 254.51,90.93 258.06,94.49 258.06,101.09 262.38,105.41 262.38,125.22 267.32,130.16 267.32,144.88 269.16,146.72 269.16,160.21 270.25,161.3 270.25,163.35 273.11,166.21 v2(273.11,180.41)
D13115: length 283.9
  L23_SIGNAL w0.091: D131.15 123.19,57.15 139.7,57.15 154.69,72.14 154.69,96.41 163.68,105.41 263.14,105.41 265.62,107.89 265.62,118.13 v3(268.73,121.23)
  L29_SIGNAL w0.091: v3(268.73,121.23) 269.19,121.23 275.56,127.61 295.96,127.61 302.29,133.93 302.29,141.5 309.16,148.38 309.16,160.21 310.25,161.3 310.25,163.35 313.11,166.21 v2(313.11,180.41)
D13116: length 315.4
  L21_SIGNAL w0.102: v3(346.71,122.76) 346.68,122.76 343.03,119.1 343.03,108.51 341.73,107.21 305.23,107.21 286.43,88.42 164.73,88.42 136,59.69 125.73,59.69 D131.16
  L27_SIGNAL w0.091: v3(346.71,122.76) 347.13,123.18 347.13,145.33 349.16,147.36 349.16,160.21 350.25,161.3 350.25,163.35 353.1,166.21 v2(353.1,180.41)
D13201: length 323.6
  L23_SIGNAL w0.076: v2(226.61,184.96) 226.28,185.28 225.48,185.28
  L23_SIGNAL w0.508: v2(227.86,209) 227.86,208.82 228.86,207.82 228.86,195.14 225.04,191.32 225.04,185.72 225.48,185.28
  L25_SIGNAL w0.508: D132.01 81.11,40.81 81.11,101.26 109.25,129.4 114.26,129.4 122.03,137.18 122.03,152.73 129.41,160.11 208.11,160.11 210.68,162.67 210.68,171.49 206,176.18 206,192.01 210.54,196.55 210.54,201.19 213.91,204.56 217.75,204.56 220.2,207.02 220.2,208.52 222.12,210.44 226.09,210.44 227.1,209.43 v2(227.1,209)
D13202: length 405.8
  L23_SIGNAL w0.076: v2(266.61,184.96) 266.28,185.28 265.48,185.28
  L23_SIGNAL w0.508: 265.48,185.28 265.04,185.72 265.04,191.32 268.86,195.14 268.86,207.82 267.86,208.82 v2(267.86,209)
  L31_SIGNAL w0.508: D132.02 86.23,40.77 82.93,40.77 79.5,44.2 79.5,118.11 81.53,120.14 149.61,120.14 153.67,116.08 214.63,116.08 223.14,107.57 243.33,107.57 245.11,109.35 245.11,122.17 248.92,125.98 248.92,153.92 247.4,155.45 247.4,157.99 249.49,160.08 249.49,161.48 250.68,162.67 250.68,171.49 247.15,175.02 247.15,193.17 250.54,196.55 250.54,201.19 253.91,204.56 257.75,204.56 260.2,207.02 260.2,208.52 262.12,210.44 266.09,210.44 267.1,209.43 v2(267.1,209)
D13203: length 412.1
  L23_SIGNAL w0.076: 305.48,185.28 306.28,185.28 v2(306.6,184.96)
  L23_SIGNAL w0.091: v3(255.77,122.76) 256.84,123.82 268.44,123.82 270.26,122.01 270.26,109.25 266.03,105.03 163.82,105.03 155.19,96.4 155.19,66.17 128.4,39.37 93.34,39.37 92.58,38.61 92.58,36.7 D132.03
  L23_SIGNAL w0.508: v2(307.86,209) 307.86,208.82 308.86,207.82 308.86,195.14 305.04,191.32 305.04,185.72 305.48,185.28
  L29_SIGNAL w0.508: v3(255.77,122.76) 260.15,127.13 261.75,127.13 265.56,130.94 268.1,130.94 273.43,136.27 279.83,136.27 282.63,139.06 287.78,139.06 288.93,140.21 288.93,154.81 287.4,156.34 287.4,157.35 289.17,159.13 289.17,161.17 290.68,162.67 290.68,171.49 287.15,175.02 287.15,193.17 290.54,196.55 290.54,201.19 293.91,204.56 297.75,204.56 300.2,207.02 300.2,208.52 302.12,210.44 306.09,210.44 307.1,209.43 v2(307.1,209)
D13204: length 436.2
  L19_SIGNAL w0.102: v3(338.07,112.85) 338.04,112.85 336.93,113.96 336.93,116.71 329.41,124.23 304.05,124.23 280.93,101.11 280.93,96.09 272.79,87.95 164.84,87.95 130.12,53.23 130.12,49.27 127.85,46.99 101.61,46.99 100.33,45.71 100.33,44.45 D132.04
  L23_SIGNAL w0.076: v2(346.6,184.96) 346.28,185.28 345.48,185.28
  L23_SIGNAL w0.508: 345.48,185.28 345.04,185.72 345.04,191.32 348.86,195.14 348.86,207.82 347.86,208.82 v2(347.86,209)
  L27_SIGNAL w0.508: v3(338.07,112.85) 337.11,112.85 336.04,113.92 336.04,124.3 330.68,129.67 330.68,171.49 327.15,175.02 327.15,193.17 330.54,196.55 330.54,201.19 333.91,204.56 337.75,204.56 340.2,207.02 340.2,208.52 342.12,210.44 346.09,210.44 347.1,209.43 v2(347.1,209)
D13205: length 255.2
  L25_SIGNAL w0.091: v2(233.76,180.41) 233.37,180.02 233.37,179.11 234.28,178.2 234.28,165.8 235.8,164.28 237.19,164.28 238.45,163.01 238.45,156.35 234.07,151.96 231.97,151.96 227.33,147.32 226.48,147.32 225,145.84 220.39,145.84 218.61,147.62 176.37,147.62 140.54,111.78 140.54,57.01 127.94,44.41 101.07,44.41 97.77,41.11 97.77,36.81 D132.05
D13206: length 300.3
  L31_SIGNAL w0.091: D132.06 105.41,44.45 130.35,44.45 133.48,47.57 133.48,79.54 144.36,90.42 257.05,90.42 262.64,96.01 262.64,102.74 265.3,105.41 265.3,126.62 268.35,129.67 268.35,130.94 269.75,132.33 269.75,139.19 270.76,140.21 270.76,145.99 274.75,149.98 274.75,152.65 278.45,156.35 278.45,163.01 277.19,164.28 275.8,164.28 274.28,165.8 274.28,178.2 273.37,179.11 273.37,180.02 v2(273.76,180.41)
D13207: length 329.5
  L15_SIGNAL w0.091: v3(268.73,118.56) 268.71,118.56 265.46,115.31 265.46,107.55 263.06,105.16 162.3,105.16 143.89,86.75 143.89,48.27 134.99,39.37 103.38,39.37 102.87,38.86 102.87,36.83 D132.07
  L29_SIGNAL w0.091: v3(268.73,118.56) 269.69,118.56 271.53,120.4 271.53,122.81 275.85,127.13 297.44,127.13 303.49,133.18 303.49,135.13 307.05,138.69 307.05,144.94 311.81,149.71 311.81,151.39 312.39,151.97 314.07,151.97 318.45,156.35 318.45,163.01 317.19,164.28 315.8,164.28 314.28,165.8 314.28,178.2 313.37,179.11 313.37,180.02 v2(313.76,180.41)
D13208: length 357
  L21_SIGNAL w0.102: D132.08 110.49,44.45 133.1,44.45 154.15,65.51 154.15,76.69 165.42,87.96 287.16,87.96 306.01,106.81 341.96,106.81 343.84,108.69 343.84,118.36 v3(346.71,121.23)
  L27_SIGNAL w0.091: v3(346.71,121.23) 347.8,121.23 348.62,122.05 348.62,124.46 350.65,126.49 350.65,133.48 352.93,135.76 352.93,148.29 354.59,149.95 354.59,152.48 358.45,156.35 358.45,163.01 357.19,164.28 355.8,164.28 354.28,165.8 354.28,178.2 353.37,179.11 353.37,180.02 v2(353.75,180.41)
D13209: length 246.2
  L25_SIGNAL w0.091: D132.09 107.92,36.8 107.92,41.14 108.69,41.91 128.83,41.91 141,54.08 141,111.61 176.58,147.2 218.44,147.2 220.22,145.41 225.17,145.41 226.69,146.94 227.58,146.94 232.23,151.58 234.21,151.58 238.83,156.2 238.83,163.18 237.34,164.67 236.09,164.67 234.7,166.05 234.7,178.81 v2(233.76,179.76)
D13210: length 290.2
  L31_SIGNAL w0.091: D132.10 113.03,41.91 128.99,41.91 134.07,46.99 134.07,79.55 144.44,89.92 257.3,89.92 263.14,95.76 263.14,102.49 265.94,105.28 265.94,126.49 268.99,129.54 268.99,130.81 275.34,137.16 275.34,152.71 278.83,156.2 278.83,163.18 277.34,164.67 276.09,164.67 274.7,166.05 274.7,178.81 v2(273.76,179.76)
D13211: length 317.1
  L15_SIGNAL w0.091: v3(268.73,117.04) 266.09,114.4 266.09,107.29 263.58,104.77 162.81,104.77 144.53,86.49 144.53,48.39 132.97,36.83 113.03,36.83 D132.11
  L29_SIGNAL w0.091: v3(268.73,117.04) 270.46,117.04 272.29,118.87 272.29,122.94 276.1,126.75 297.6,126.75 304.7,133.84 304.7,134.27 307.59,137.16 307.59,144.96 318.83,156.2 318.83,163.18 317.34,164.67 316.09,164.67 314.7,166.05 314.7,178.81 v2(313.76,179.76)
D13212: length 346.8
  L21_SIGNAL w0.102: D132.12 118.11,41.91 132.08,41.91 154.56,64.39 154.56,76.52 165.59,87.55 287.33,87.55 306.17,106.4 342.13,106.4 344.25,108.52 344.25,116.13 346.68,118.56 v3(346.71,118.56)
  L27_SIGNAL w0.091: v2(353.75,179.76) 354.7,178.81 354.7,166.05 356.09,164.67 357.34,164.67 358.83,163.18 358.83,156.2 355.12,152.49 355.12,149.96 353.31,148.15 353.31,135.61 351.02,133.32 351.02,126.34 349.07,124.39 349.07,120.09 347.55,118.56 v3(346.71,118.56)
D13213: length 236.5
  L25_SIGNAL w0.076: v2(234.41,181.06) 234.73,180.73 236.01,180.73 236.07,180.68
  L25_SIGNAL w0.091: D132.13 118.16,36.88 118.16,38.65 118.87,39.37 129.13,39.37 141.73,51.97 141.73,110.24 176.02,144.53 226.06,144.53 229.36,147.83 231.9,147.83 236.42,152.35 236.42,153.27 239.2,156.05 239.2,163.37 235.21,167.36 235.21,178.79 236.18,179.75 236.18,180.57 236.07,180.68
D13214: length 285.2
  L31_SIGNAL w0.076: v2(274.41,181.06) 274.73,180.73 276.01,180.73 276.07,180.68
  L31_SIGNAL w0.091: 276.07,180.68 276.18,180.57 276.18,179.75 275.21,178.79 275.21,167.36 279.2,163.37 279.2,156.05 276.42,153.27 276.42,137.49 270.38,131.44 270.38,129.92 266.57,126.11 266.57,105.16 265.18,103.76 265.18,93.47 261.11,89.41 144.53,89.41 134.75,79.63 134.75,46.35 127.76,39.37 120.65,39.37 D132.14
D13215: length 307.9
  L23_SIGNAL w0.091: D132.15 123.19,36.83 130.05,36.83 155.7,62.48 155.7,96.39 163.96,104.65 266.19,104.65 270.64,109.09 270.64,120.37 273.03,122.76 v3(273.05,122.76)
  L29_SIGNAL w0.076: 316.07,180.68 316.01,180.73 314.73,180.73 v2(314.41,181.06)
  L29_SIGNAL w0.091: 316.07,180.68 316.18,180.57 316.18,179.75 315.21,178.79 315.21,167.36 319.2,163.37 319.2,156.05 316.42,153.27 316.42,152.35 310.77,146.7 310.77,140.21 309.37,138.81 309.37,137.69 306.43,134.75 306.43,133.63 299.03,126.24 276.53,126.24 v3(273.05,122.76)
D13216: length 339.5
  L21_SIGNAL w0.102: v3(346.71,117.04) 344.65,114.99 344.65,108.35 342.3,105.99 306.34,105.99 287.5,87.15 165.76,87.15 155.07,76.45 155.07,63.37 131.06,39.37 125.73,39.37 D132.16
  L27_SIGNAL w0.076: v2(354.4,181.06) 354.73,180.73 356.01,180.73 356.07,180.68
  L27_SIGNAL w0.091: 356.07,180.68 356.18,180.57 356.18,179.75 355.21,178.79 355.21,167.36 359.2,163.37 359.2,156.05 356.42,153.27 356.42,148.91 355.34,147.82 355.34,136.16 352.48,133.3 352.48,126.83 349.54,123.9 349.54,119.4 347.18,117.04 v3(346.71,117.04)
D20101: length 298.4
  L19_SIGNAL w0.102: v2(235.71,186.26) 236.3,186.26 236.85,185.7 236.85,180.85 229.41,173.41 229.41,168.66 229.84,168.23 229.84,162.64 228.98,161.77 228.98,153.14 232.51,149.61 232.51,129.64 233.5,128.65 422.53,128.65 D201.01
D20102: length 244.5
  L23_SIGNAL w0.091: D201.02 455.93,97.79 425.2,97.79 417.32,105.66 353.06,105.66 350.46,108.27 350.46,116.65 338.33,128.78 298.51,128.78 280.54,146.74 280.54,163.37 278.89,165.02 278.89,176.32 277.11,178.1 277.11,185.93 276.79,186.26 v2(275.71,186.26)
D20103: length 208.8
  L23_SIGNAL w0.091: D201.03 458.47,97.79 458.47,99.82 457.71,100.58 423.15,100.58 417.45,106.28 382.16,106.28 358.71,129.73 357.7,129.73 355.6,131.83 327.28,131.83 319.79,139.32 319.79,144.1 320.54,144.86 320.54,163.37 318.89,165.02 318.89,176.32 317.11,178.1 317.11,185.93 316.79,186.26 v2(315.7,186.26)
D20104: length 176.7
  L23_SIGNAL w0.091: D201.04 463.3,100.08 463.3,103.12 462.79,103.63 421.39,103.63 417.83,107.19 385.49,107.19 362.71,129.96 362.71,135.81 359.66,138.85 359.66,143.59 360.54,144.47 360.54,163.37 358.89,165.02 358.89,176.32 357.11,178.1 357.11,185.93 356.79,186.26 v2(355.7,186.26)
D20105: length 311.6
  L19_SIGNAL w0.102: D201.05 463.68,97.66 463.68,101.73 462.53,102.87 449.71,102.87 423.42,129.16 233.71,129.16 233.3,129.57 233.3,151.31 230.86,153.75 230.86,156.9 229.49,158.27 229.49,161.56 230.34,162.41 230.34,163.38 230.35,163.39 230.35,173.63 237.26,180.54 237.26,186.03 236.5,186.79 235.59,186.79 v2(235.06,186.26)
D20106: length 258.7
  L23_SIGNAL w0.091: v2(275.06,186.26) 275.49,186.69 276.99,186.69 277.62,186.06 277.62,178.31 279.4,176.53 279.4,165.23 281.05,163.58 281.05,146.87 291.13,136.79 291.77,136.79 299.28,129.29 341.88,129.29 352.17,119 352.17,110.49 351.86,110.18 v3(351.02,110.18)
  L29_SIGNAL w0.091: D201.06 465.84,100.58 435.23,100.58 424.94,110.87 424.69,110.87 423.29,112.27 353.11,112.27 v3(351.02,110.18)
D20107: length 219.5
  L23_SIGNAL w0.091: v2(315.05,186.26) 315.49,186.69 316.99,186.69 317.62,186.06 317.62,178.31 319.4,176.53 319.4,165.23 321.05,163.58 321.05,144.65 320.29,143.89 320.29,139.45 326.9,132.84 356.24,132.84 382.4,106.68 417.62,106.68 421.68,102.62 458.09,102.62 461.01,99.69 461.01,98.42 461.64,97.79 468.63,97.79 D201.07
D20108: length 184
  L23_SIGNAL w0.091: v2(355.05,186.26) 355.49,186.69 356.99,186.69 357.62,186.06 357.62,178.31 359.4,176.53 359.4,165.23 361.05,163.58 361.05,144.26 360.17,143.38 360.17,139.06 363.22,136.02 363.22,130.18 385.7,107.7 418.04,107.7 421.34,104.39 467.11,104.39 D201.08
D20109: length 347.8
  L19_SIGNAL w0.102: v3(238.5,112.85) 238.47,112.85 237.94,113.38 237.94,114.6 239.51,116.17 277.81,116.17 289.15,127.51 347.6,127.51 367.28,107.82 427.23,107.82 439.93,95.12 473.58,95.12 D201.09
  L31_SIGNAL w0.076: v2(232.46,186.91) 232.78,187.23 232.78,187.69 232.97,187.88 235.93,187.88
  L31_SIGNAL w0.091: v3(238.5,112.85) 237.42,112.85 236.73,113.54 236.73,122.94 243.33,129.54 243.33,134.63 243.56,134.86 243.56,157.54 244.08,158.06 244.08,163.62 239.45,168.25 239.45,174.81 240.95,176.31 240.95,184.83 237.91,187.88 235.93,187.88
D20110: length 333.1
  L29_SIGNAL w0.076: 275.93,187.88 272.97,187.88 272.78,187.69 272.78,187.23 v2(272.46,186.91)
  L29_SIGNAL w0.091: D201.10 473.46,103.12 433.45,103.12 425.2,111.38 424.81,111.38 421.26,114.94 301.12,114.94 299.47,116.59 289.31,116.59 287.76,115.04 254.58,115.04 253.62,116 253.62,122.71 259.18,128.27 260.48,128.27 265.3,133.1 265.81,133.1 267.21,134.49 267.21,135.37 269,137.16 270,137.16 271.84,139 274.64,139 275.72,140.08 281.18,140.08 283.56,142.47 283.56,157.54 284.08,158.06 284.08,163.62 279.45,168.25 279.45,174.81 280.95,176.31 280.95,184.83 277.91,187.88 275.93,187.88
D20111: length 265.5
  L27_SIGNAL w0.076: v2(312.46,186.91) 312.78,187.23 312.78,187.69 312.97,187.88 315.93,187.88
  L27_SIGNAL w0.091: 315.93,187.88 317.91,187.88 320.95,184.83 320.95,176.31 319.45,174.81 319.45,168.25 324.08,163.62 324.08,158.06 323.56,157.54 323.56,134.46 313.28,124.18 313.28,112.96 314.48,111.76 424.31,111.76 431.82,104.25 476.74,104.25 478.82,102.16 478.82,97.76 D201.11
D20112: length 196.8
  L25_SIGNAL w0.076: v2(352.45,186.91) 352.78,187.23 352.78,187.69 352.97,187.88 355.93,187.88
  L25_SIGNAL w0.091: D201.12 478,103.66 453.31,103.66 448.94,108.03 448.94,123.19 427.55,144.58 369.38,144.58 363.56,150.41 363.56,157.54 364.08,158.06 364.08,163.62 359.45,168.25 359.45,174.81 360.95,176.31 360.95,184.83 357.91,187.88 355.93,187.88
D20113: length 359
  L19_SIGNAL w0.102: D201.13 481.58,92.96 440.93,92.96 426.71,107.19 364.24,107.19 344.42,127 289.31,127 278,115.7 239.83,115.7 v3(238.5,114.37)
  L31_SIGNAL w0.076: v2(231.81,188.21) 232.13,188.53 235.91,188.53
  L31_SIGNAL w0.091: 235.91,188.53 239.31,188.53 241.52,186.33 241.52,176.17 239.86,174.51 239.86,168.39 243.79,164.45 245.49,164.45 246.15,163.8 246.15,157.64 245.39,156.88 245.39,130.58 237.24,122.43 237.24,115.06 237.92,114.37 v3(238.5,114.37)
D20114: length 347.7
  L29_SIGNAL w0.076: v2(271.81,188.21) 272.13,188.53 275.91,188.53
  L29_SIGNAL w0.091: D201.14 482.73,104.01 433.32,104.01 425.58,111.76 424.95,111.76 421.4,115.32 301.4,115.32 299.62,117.09 288.8,117.09 287.27,115.57 254.76,115.57 254.13,116.2 254.13,122.28 259.61,127.76 260.6,127.76 264.54,131.7 267.46,131.7 269.11,133.35 269.11,135.38 271.91,138.18 276.48,138.18 277.5,139.19 281.56,139.19 285.39,143.02 285.39,156.88 286.15,157.64 286.15,163.8 285.49,164.45 283.79,164.45 279.86,168.39 279.86,174.51 281.52,176.17 281.52,186.33 279.31,188.53 275.91,188.53
D20115: length 277.3
  L27_SIGNAL w0.076: v2(311.81,188.21) 312.13,188.53 315.91,188.53
  L27_SIGNAL w0.091: D201.15 489,97.74 489,102.14 486.21,104.93 431.9,104.93 424.69,112.14 315.9,112.14 315.39,112.65 315.39,124.25 325.39,134.26 325.39,156.88 326.15,157.64 326.15,163.8 325.49,164.45 323.79,164.45 319.86,168.39 319.86,174.51 321.52,176.17 321.52,186.33 319.31,188.53 315.91,188.53
D20116: length 209.2
  L25_SIGNAL w0.076: v2(351.8,188.21) 352.13,188.53 355.91,188.53
  L25_SIGNAL w0.091: D201.16 486.97,104.85 453.06,104.85 449.83,108.08 449.83,123.83 428.42,145.24 370.51,145.24 365.39,150.36 365.39,156.88 366.15,157.64 366.15,163.8 365.49,164.45 363.79,164.45 359.86,168.39 359.86,174.51 361.52,176.17 361.52,186.33 359.31,188.53 355.91,188.53
D20201: length 316.1
  L31_SIGNAL w0.076: 235.49,185.28 233.43,185.28 v2(233.11,185.61)
  L31_SIGNAL w0.091: v3(234.18,122.76) 234.18,124.46 236.98,127.25 236.98,134.5 239.34,136.87 239.34,143.8 240.61,145.07 240.61,163.63 237.35,166.89 237.35,175.87 238.82,177.34 238.82,183.4 238.1,184.11 236.65,184.11 235.49,185.28
  L33_SIGNAL w0.091: D202.01 453.64,75.18 449.71,75.18 431.55,93.34 431.55,99.42 423.02,107.95 376.83,107.95 364.52,120.26 238.53,120.26 236.03,122.76 v3(234.18,122.76)
D20202: length 323.7
  L29_SIGNAL w0.076: v2(273.11,185.61) 273.43,185.28 275.49,185.28
  L29_SIGNAL w0.091: 275.49,185.28 276.65,184.11 278.1,184.11 278.82,183.4 278.82,177.34 277.35,175.87 277.35,167.03 280.61,163.76 280.61,147.9 278.8,146.09 273.47,146.09 272.16,144.78 268.1,144.78 266.85,143.54 266.85,140.18 250.82,124.16 250.82,108.2 252.37,106.66 352.53,106.66 353.95,108.08 420.94,108.08 443.12,85.9 454,85.9 455.47,84.43 455.47,80.47 D202.02
D20203: length 253.9
  L27_SIGNAL w0.076: v2(313.11,185.61) 313.43,185.28 315.49,185.28
  L27_SIGNAL w0.091: D202.03 458.45,77.49 458.45,81.74 457.23,82.96 446.61,82.96 422.01,107.56 311.5,107.56 309.14,109.93 309.14,126.47 312.6,129.94 312.6,130.96 319.36,137.71 319.34,137.73 319.34,143.8 320.61,145.07 320.61,163.77 317.35,167.03 317.35,175.87 318.82,177.34 318.82,183.4 318.1,184.11 316.65,184.11 315.49,185.28
D20204: length 195.3
  L25_SIGNAL w0.076: 355.49,185.28 353.43,185.28 v2(353.1,185.61)
  L25_SIGNAL w0.091: D202.04 460.89,80.13 456.17,80.13 446.4,89.9 446.4,122.17 426.93,141.65 371.39,141.65 370.9,141.16 364.74,141.16 360.61,145.28 360.61,163.77 357.35,167.04 357.35,175.87 358.82,177.34 358.82,183.4 358.1,184.11 356.65,184.11 355.49,185.28
D20205: length 330.9
  L31_SIGNAL w0.076: v2(233.11,186.26) 233.43,185.93 236.11,185.93
  L31_SIGNAL w0.091: 236.11,185.93 236.36,186.18 236.99,186.18 239.18,184 239.18,176.4 238.29,175.5 238.29,166.59 241.04,163.83 241.04,144.89 239.78,143.62 239.78,136.69 238.51,135.42 238.51,127.25 235.2,123.95 235.2,121.67 234.77,121.23 v3(234.18,121.23)
  L33_SIGNAL w0.091: D202.05 461.26,72.64 450.6,72.64 430.91,92.33 430.91,99.16 422.52,107.55 376.71,107.55 364.4,119.86 238.4,119.86 237.04,121.23 v3(234.18,121.23)
D20206: length 335.2
  L29_SIGNAL w0.076: v2(273.11,186.26) 273.43,185.93 276.11,185.93
  L29_SIGNAL w0.091: 276.11,185.93 276.36,186.18 276.99,186.18 279.18,184 279.18,176.4 278.28,175.5 278.28,166.72 281.04,163.97 281.04,146.42 279.53,144.91 277.57,144.91 276.71,144.04 269.58,144.04 268.52,142.99 267.83,142.99 267.33,142.49 267.33,139.5 263.45,135.61 263.45,134.21 262.84,133.6 261.92,133.6 258.04,129.72 257.61,129.72 252.35,124.46 252.35,109.73 255.03,107.04 352.15,107.04 355.85,110.74 420.59,110.74 420.59,110.74 420.6,110.74 444.92,86.41 464.59,86.41 466.04,84.96 466.04,80.06 D202.06
D20207: length 264.1
  L27_SIGNAL w0.076: v2(313.11,186.26) 313.43,185.93 316.11,185.93
  L27_SIGNAL w0.091: D202.07 468.68,77.42 468.68,81.69 466.93,83.44 446.73,83.44 422.16,108.01 311.74,108.01 309.69,110.07 309.69,126.3 313.15,129.77 313.15,130.87 319.78,137.5 319.78,143.62 321.04,144.89 321.04,163.97 318.28,166.73 318.28,175.5 319.18,176.4 319.18,184 316.99,186.18 316.36,186.18 316.11,185.93
D20208: length 205.2
  L25_SIGNAL w0.076: v2(353.1,186.26) 353.43,185.93 356.11,185.93
  L25_SIGNAL w0.091: 356.11,185.93 356.36,186.18 356.99,186.18 359.18,184 359.18,176.4 358.28,175.5 358.28,166.73 361.04,163.98 361.04,146.13 365.58,141.59 370.74,141.59 371.17,142.02 427.08,142.02 446.91,122.18 446.91,89.91 454.27,82.55 468.63,82.55 D202.08
D20209: length 355
  L19_SIGNAL w0.102: D202.09 473.71,77.47 473.71,82.55 470.6,85.66 444.69,85.66 424.43,105.92 360.93,105.92 341.12,125.73 292.35,125.73 278,111.38 241.68,111.38 238.96,108.66 v3(238.5,108.66)
  L31_SIGNAL w0.076: 235.91,186.58 234.73,186.58 v2(234.41,186.26)
  L31_SIGNAL w0.091: 235.91,186.58 237.32,186.58 239.55,184.35 239.55,176.25 238.66,175.36 238.66,166.85 241.44,164.07 241.44,144.73 240.17,143.46 240.17,136.52 239.27,135.62 239.27,127 235.71,123.44 235.71,109.73 236.78,108.66 v3(238.5,108.66)
D20210: length 343.3
  L29_SIGNAL w0.076: v2(274.41,186.26) 274.73,186.58 275.91,186.58
  L29_SIGNAL w0.091: D202.10 476.34,79.92 476.34,84.36 473.75,86.95 445.09,86.95 420.77,111.27 355.44,111.27 351.65,107.48 255.36,107.48 252.86,109.98 252.86,123.82 258.23,129.2 259.31,129.2 265.27,135.16 265.27,136.91 267.74,139.38 267.74,140.19 268.06,140.51 270.44,140.51 271.53,141.6 277.44,141.6 278.21,142.37 279.08,142.37 281.44,144.73 281.44,164.2 278.66,166.98 278.66,175.36 279.55,176.25 279.55,184.35 277.32,186.58 275.91,186.58
D20211: length 271.5
  L27_SIGNAL w0.076: 315.91,186.58 314.73,186.58 v2(314.41,186.26)
  L27_SIGNAL w0.091: D202.11 478.85,77.41 478.85,81.77 476.72,83.91 447.46,83.91 420.6,110.77 312.22,110.77 310.19,112.8 310.19,125.7 314.55,130.07 314.55,131.62 320.17,137.24 320.17,143.46 321.44,144.73 321.44,164.21 318.66,166.99 318.66,175.36 319.55,176.25 319.55,184.35 317.32,186.58 315.91,186.58
D20212: length 214.1
  L25_SIGNAL w0.076: v2(354.4,186.26) 354.73,186.58 355.91,186.58
  L25_SIGNAL w0.091: D202.12 477.9,83.44 453.9,83.44 447.52,89.82 447.52,122.1 427.23,142.38 370.95,142.38 370.56,141.99 365.89,141.99 361.44,146.43 361.44,164.21 358.66,166.99 358.66,175.36 359.55,176.25 359.55,184.35 357.32,186.58 355.91,186.58
D20213: length 366.6
  L19_SIGNAL w0.102: D202.13 483.87,77.47 483.87,83.82 480.38,87.31 445.07,87.31 425.69,106.68 363.98,106.68 344.17,126.49 292.1,126.49 277.75,112.14 240.46,112.14 v3(238.5,110.18)
  L31_SIGNAL w0.076: v2(234.41,186.91) 234.73,187.23 235.83,187.23
  L31_SIGNAL w0.091: 235.83,187.23 237.21,187.23 240.53,183.91 240.53,176.53 239.04,175.04 239.04,168.13 243.65,163.53 243.65,158.24 243.13,157.72 243.13,135.13 242.83,134.83 242.83,129.87 236.22,123.25 236.22,111.25 237.29,110.18 v3(238.5,110.18)
D20214: length 356.6
  L29_SIGNAL w0.076: v2(274.41,186.91) 274.73,187.23 275.83,187.23
  L29_SIGNAL w0.091: D202.14 486.41,80.01 486.41,84.33 483.11,87.62 444.94,87.62 420.93,111.63 355.09,111.63 351.39,107.93 255.67,107.93 253.24,110.36 253.24,123.19 258.81,128.77 259.55,128.77 265.64,134.85 265.64,136.73 268.17,139.27 270.05,139.27 271.75,140.97 281.35,140.97 283.13,142.75 283.13,157.72 283.65,158.24 283.65,163.53 279.04,168.13 279.04,175.04 280.53,176.53 280.53,183.91 277.21,187.23 275.83,187.23
D20215: length 283.8
  L27_SIGNAL w0.076: 315.83,187.23 314.73,187.23 v2(314.41,186.91)
  L27_SIGNAL w0.091: 315.83,187.23 317.21,187.23 320.53,183.91 320.53,176.53 319.04,175.04 319.04,168.13 323.65,163.53 323.65,158.24 323.13,157.72 323.13,136.63 310.72,124.22 310.72,113.09 312.59,111.22 421.17,111.22 447.98,84.4 486.68,84.4 488.97,82.11 488.97,77.45 D202.15
D20216: length 225.3
  L25_SIGNAL w0.076: v2(354.4,186.91) 354.73,187.23 355.83,187.23
  L25_SIGNAL w0.091: 355.83,187.23 357.21,187.23 360.53,183.91 360.53,176.53 359.04,175.04 359.04,168.13 363.65,163.53 363.65,158.24 363.13,157.72 363.13,148.84 369.23,142.75 428.24,142.75 447.93,123.06 447.93,90.91 454.38,84.45 491.08,84.45 491.64,83.9 491.64,79.86 D202.16
D20301: length 351.4
  L31_SIGNAL w0.091: v3(234.18,112.85) 233.96,112.85 232.41,114.4 232.41,123.19 228.5,127.1 228.5,130.65 226.78,132.36 226.78,144.4 228.79,146.4 228.79,156.9 229.48,157.6 229.48,161.09 230.13,161.74 230.13,163.54 234.7,168.1 234.7,177.35 235.06,177.71 v2(235.06,179.76)
  L33_SIGNAL w0.091: v3(234.18,112.85) 234.16,112.85 232.17,114.84 232.17,118.9 233.27,120 234.46,120 238.17,116.29 286.18,116.29 288.7,118.8 300.71,118.8 303.26,116.25 367.41,116.25 376.59,107.06 422,107.06 430.28,98.79 430.28,67.18 442.59,54.86 453.64,54.86 D203.01
D20302: length 321.1
  L29_SIGNAL w0.091: D203.02 455.47,60.15 455.47,64.6 454.36,65.71 451.26,65.71 437.36,79.6 437.36,89.21 420.33,106.25 354.73,106.25 353.62,105.14 251.22,105.14 248.67,107.7 248.67,126.03 263.27,140.64 263.27,142.62 268.79,148.14 268.79,156.9 269.48,157.6 269.48,161.09 270.13,161.74 270.13,163.54 274.7,168.1 274.7,177.35 275.06,177.71 v2(275.06,179.76)
D20303: length 257.4
  L27_SIGNAL w0.091: D203.03 458.5,57.12 458.5,62.03 451.47,69.06 451.47,75.37 421.18,105.66 308.36,105.66 305.96,108.06 305.96,129.11 306.78,129.94 306.78,144.4 308.79,146.4 308.79,156.9 309.48,157.6 309.48,161.09 310.13,161.74 310.13,163.54 314.7,168.1 314.7,177.35 315.05,177.71 v2(315.05,179.76)
D20304: length 209.3
  L25_SIGNAL w0.091: v2(355.05,179.76) 355.05,177.71 354.7,177.35 354.7,168.1 350.13,163.54 350.13,161.74 349.48,161.09 349.48,157.6 348.79,156.9 348.79,144.86 360.43,133.22 370.84,133.22 371.39,132.67 421.3,132.67 444.12,109.85 444.12,71.37 455.68,59.82 460.88,59.82 D203.04
D20305: length 361.9
  L31_SIGNAL w0.091: v3(234.18,114.37) 232.82,115.74 232.82,123.8 229.25,127.36 229.25,132.71 235.23,138.68 235.23,146.94 236.49,148.2 236.49,153.5 238.81,155.82 238.81,163.61 235.11,167.31 235.11,176.85 235.7,177.43 235.7,180.4 v2(235.71,180.41)
  L33_SIGNAL w0.091: v3(234.18,114.37) 233.35,114.37 232.54,115.19 232.54,118.74 233.43,119.63 234.06,119.63 237.77,115.92 286.34,115.92 288.85,118.44 300.56,118.44 303.11,115.88 367.23,115.88 376.44,106.68 421.49,106.68 429.64,98.52 429.64,66.95 444.26,52.32 461.26,52.32 D203.05
D20306: length 338
  L29_SIGNAL w0.091: D203.06 466.04,59.74 466.04,64.64 464.54,66.14 451.56,66.14 437.8,79.91 437.8,89.39 420.41,106.78 354.72,106.78 353.46,105.52 251.48,105.52 249.25,107.75 249.25,125.15 264.03,139.93 264.03,142.62 269.24,147.83 269.24,148.59 270,149.35 275.6,149.35 276.49,150.24 276.49,153.5 278.81,155.82 278.81,163.87 275.11,167.57 275.11,176.85 275.7,177.43 275.7,180.4 v2(275.71,180.41)
D20307: length 270.2
  L27_SIGNAL w0.091: D203.07 468.73,57.05 468.73,61.25 467.38,62.6 458.9,62.6 451.91,69.58 451.91,75.61 421.4,106.12 308.56,106.12 306.45,108.23 306.45,128.19 315.23,136.96 315.23,146.94 316.49,148.2 316.49,153.5 318.81,155.82 318.81,163.87 315.11,167.57 315.11,176.85 315.7,177.43 315.7,180.4 v2(315.7,180.41)
D20308: length 218.8
  L25_SIGNAL w0.091: v2(355.7,180.41) 355.7,180.4 355.7,177.43 355.11,176.85 355.11,167.57 358.81,163.87 358.81,155.82 357.5,154.51 357.5,149.35 358.09,148.77 358.09,143.27 362.34,139.01 425.88,139.01 444.88,120.02 444.88,71.63 454.28,62.23 470.79,62.23 471.5,61.52 471.5,59.36 D203.08
D20309: length 361.9
  L31_SIGNAL w0.076: v2(234.41,180.41) 234.73,180.73 235.91,180.73
  L31_SIGNAL w0.091: v3(234.18,117.04) 233.71,117.04 233.22,117.52 233.22,124.92 230.84,127.3 230.84,133.41 235.6,138.18 235.6,146.79 236.86,148.05 236.86,153.35 239.18,155.67 239.18,163.76 236.3,166.65 236.3,180.34 235.91,180.73
  L33_SIGNAL w0.091: v3(234.18,117.04) 235.67,115.55 286.49,115.55 289,118.07 300.41,118.07 302.96,115.52 367.06,115.52 376.28,106.3 420.88,106.3 429.01,98.17 429.01,66.68 444,51.69 470.79,51.69 D203.09
D20310: length 348.4
  L29_SIGNAL w0.076: 275.91,180.73 274.73,180.73 v2(274.41,180.41)
  L29_SIGNAL w0.091: D203.10 476.34,59.6 476.34,64.04 473.75,66.63 451.68,66.63 438.23,80.08 438.23,89.57 420.58,107.22 354.61,107.22 353.3,105.9 251.73,105.9 249.76,107.87 249.76,125.02 266.06,141.33 266.06,144.02 269.75,147.7 272.92,147.7 274.07,148.84 275.72,148.84 276.86,149.99 276.86,153.35 279.18,155.67 279.18,164.01 276.3,166.9 276.3,180.34 275.91,180.73
D20311: length 281.1
  L27_SIGNAL w0.076: 315.91,180.73 314.73,180.73 v2(314.41,180.41)
  L27_SIGNAL w0.091: D203.11 478.84,57.1 478.84,61.33 477.03,63.14 459.2,63.14 452.43,69.91 452.43,75.73 421.59,106.57 308.85,106.57 306.92,108.5 306.92,128.03 315.6,136.71 315.6,146.79 316.86,148.05 316.86,153.35 319.18,155.67 319.18,164.01 316.3,166.9 316.3,180.34 315.91,180.73
D20312: length 230.6
  L25_SIGNAL w0.076: v2(354.4,180.41) 354.73,180.73 355.91,180.73
  L25_SIGNAL w0.091: 355.91,180.73 356.3,180.34 356.3,166.9 359.18,164.01 359.18,155.67 358.51,154.99 358.51,143.44 362.51,139.43 426.48,139.43 445.39,120.52 445.39,72.24 452.35,65.28 479.98,65.28 481.43,63.83 481.43,59.59 D203.12
D20313: length 379.5
  L31_SIGNAL w0.076: v2(232.46,185.61) 232.78,185.28 232.78,184.82 232.97,184.63 235.37,184.63
  L31_SIGNAL w0.091: 235.37,184.63 237.73,182.27 237.73,176.86 236.97,176.09 236.97,166.64 239.55,164.05 239.55,155.52 237.23,153.19 237.23,147.9 235.97,146.63 235.97,132.08 235.46,131.57 235.46,127.63 233.63,125.8 233.63,119.12 v3(234.18,118.56)
  L33_SIGNAL w0.091: v3(234.18,118.56) 233.64,118.56 233.17,118.09 233.17,115.66 233.64,115.19 286.64,115.19 289.15,117.7 300.25,117.7 302.81,115.15 366.89,115.15 376.12,105.92 420.17,105.92 428.37,97.72 428.37,66.42 443.74,51.05 480.31,51.05 D203.13
D20314: length 364.8
  L29_SIGNAL w0.076: 275.37,184.63 272.97,184.63 272.78,184.82 272.78,185.28 v2(272.46,185.61)
  L29_SIGNAL w0.091: D203.14 486.41,59.69 486.41,64.01 483.2,67.21 451.72,67.21 438.66,80.26 438.66,89.75 420.76,107.65 354.28,107.65 352.93,106.3 252.1,106.3 250.24,108.15 250.24,124.18 266.45,140.39 266.45,143.76 269.88,147.19 274.96,147.19 277.23,149.47 277.23,153.19 279.55,155.52 279.55,164.19 276.97,166.77 276.97,176.09 277.73,176.86 277.73,182.27 275.37,184.63
D20315: length 295.2
  L27_SIGNAL w0.076: v2(312.46,185.61) 312.78,185.28 312.78,184.82 312.97,184.63 315.37,184.63
  L27_SIGNAL w0.091: D203.15 489.04,57.06 489.04,61.5 486.87,63.67 459.55,63.67 452.89,70.33 452.89,76.02 421.82,107.09 311.38,107.09 308.62,109.85 308.62,127.85 310.52,129.75 310.52,130.9 315.97,136.35 315.97,146.63 317.23,147.9 317.23,153.19 319.55,155.52 319.55,164.19 316.97,166.77 316.97,176.09 317.73,176.86 317.73,182.27 315.37,184.63
D20316: length 247.1
  L25_SIGNAL w0.076: 355.37,184.63 352.97,184.63 352.78,184.82 352.78,185.28 v2(352.45,185.61)
  L25_SIGNAL w0.091: D203.16 491.64,59.54 491.64,63.58 489.18,66.04 452.48,66.04 445.9,72.62 445.9,121.03 427.08,139.85 362.69,139.85 358.93,143.61 358.93,154.89 359.55,155.52 359.55,164.2 356.97,166.78 356.97,176.09 357.73,176.86 357.73,182.27 355.37,184.63
D20401: length 371.7
  L31_SIGNAL w0.076: 225.7,182.7 226.26,182.7 v2(226.61,182.35)
  L31_SIGNAL w0.091: 225.7,182.7 225.53,182.7 225.21,182.38 225.21,181.78 224.29,180.86 224.29,171.46 227.56,168.19 227.56,165.81 226.49,164.74 223.98,164.74 223.1,163.86 223.1,158.4 222.31,157.61 222.31,150.77 219.07,147.54 219.07,127.89 225.73,121.23 v3(229.87,121.23)
  L33_SIGNAL w0.091: D204.01 453.64,34.54 444.25,34.54 427.74,51.05 427.74,97.45 419.65,105.54 375.95,105.54 369.34,112.15 303.38,112.15 302.21,113.32 302.21,114 299.52,116.69 290.85,116.69 286.31,112.15 234.06,112.15 231.14,115.07 231.14,119.26 229.87,120.54 v3(229.87,121.23)
D20402: length 349.2
  L29_SIGNAL w0.076: v2(266.61,182.35) 266.26,182.7 265.7,182.7
  L29_SIGNAL w0.091: D204.02 435.64,59.66 435.64,88.49 419.39,104.74 355.38,104.74 354.25,103.61 247.64,103.61 244.25,107.01 244.25,125.63 259.07,140.45 259.07,147 262.31,150.24 262.31,157.7 263.1,158.49 263.1,163.86 263.98,164.74 266.49,164.74 267.56,165.81 267.56,168.19 264.29,171.46 264.29,180.86 265.21,181.78 265.21,182.38 265.53,182.7 265.7,182.7
D20403: length 287.8
  L27_SIGNAL w0.076: v2(306.6,182.35) 306.26,182.7 305.7,182.7
  L27_SIGNAL w0.091: D204.03 458.51,36.79 458.51,42.65 449.45,51.7 449.45,74.67 420.23,103.89 307.45,103.89 304.12,107.22 304.12,115 302.73,116.38 302.73,124.46 299.07,128.12 299.07,147.15 302.31,150.39 302.31,157.43 303.1,158.22 303.1,163.86 303.98,164.74 306.49,164.74 307.56,165.81 307.56,168.19 304.29,171.46 304.29,180.86 305.21,181.78 305.21,182.38 305.53,182.7 305.7,182.7
