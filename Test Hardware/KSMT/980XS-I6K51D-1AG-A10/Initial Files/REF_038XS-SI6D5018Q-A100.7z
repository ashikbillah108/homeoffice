# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D11914: length 231.8
  L31_SIGNAL w0.076: 271.48,191.08 271.48,189.83 v2(271.81,189.51)
  L31_SIGNAL w0.091: 271.48,191.31 271.48,191.08
  L31_SIGNAL w0.508: D119.14 196.95,62.33 198.48,62.33 206.05,69.91 206.05,81.29 209.35,84.58 272.54,84.58 283.13,95.17 283.13,121.53 290.76,129.16 290.76,162.16 290.35,162.57 290.35,173.8 284.88,179.27 284.88,191.44 282.42,193.9 273.13,193.9 271.48,192.25 271.48,191.31
D11915: length 317
  L23_SIGNAL w0.091: v3(255.77,121.23) 255.75,121.23 255.02,121.97 255.02,123.7 255.9,124.59 276.99,124.59 277.92,123.66 277.92,120.95 276.99,120.02 272.67,120.02 271.91,119.25 271.91,108.58 266.83,103.5 231.52,103.5 205.61,77.6 205.61,60.2 202.56,57.15 196.85,57.15 D119.15
  L29_SIGNAL w0.076: v2(311.81,189.51) 311.48,189.83 311.48,191.08
  L29_SIGNAL w0.091: 311.48,191.08 311.48,191.31
  L29_SIGNAL w0.508: 311.48,191.31 311.48,192.25 313.13,193.9 322.42,193.9 324.88,191.44 324.88,179.27 330.35,173.8 330.35,162.57 330.76,162.16 330.76,148.01 323.28,140.53 319.47,140.53 316.61,137.67 316.61,133.86 310.13,127.38 308.36,127.38 304.93,123.95 304.93,121.03 303.91,120.02 301.12,120.02 298.93,117.83 288.14,117.83 286.46,116.15 255.32,116.15 254.76,116.71 254.76,120.22 v3(255.77,121.23)
D11916: length 288.4
  L21_SIGNAL w0.102: D119.16 199.39,59.69 209.68,59.69 233.5,83.52 289.13,83.52 308.15,102.54 345.62,102.54 350.01,106.93 350.01,112.14 350.72,112.85 v3(351.02,112.85)
  L27_SIGNAL w0.076: 351.48,191.08 351.48,189.83 v2(351.8,189.51)
  L27_SIGNAL w0.091: 351.48,191.31 351.48,191.08
  L27_SIGNAL w0.508: v3(351.02,112.85) 355.59,112.85 370.76,128.02 370.76,162.16 370.35,162.57 370.35,173.8 364.88,179.27 364.88,191.44 362.42,193.9 353.13,193.9 351.48,192.25 351.48,191.31
D12001: length 195.5
  L27_SIGNAL w0.076: v2(228.56,188.21) 228.23,188.53 225.67,188.53
  L27_SIGNAL w0.091: 225.67,188.53 224,188.53 220.17,184.7 220.17,167.8 217.67,165.3 217.13,165.3 216.5,164.66 216.5,151.64 212.56,147.7 196.98,147.7 162.34,113.06 162.34,106.87 157.73,102.27 157.73,37.85 D120.01
D12002: length 248.7
  L25_SIGNAL w0.076: 265.67,188.53 268.23,188.53 v2(268.55,188.21)
  L25_SIGNAL w0.091: 265.67,188.53 264,188.53 260.17,184.7 260.17,167.8 257.67,165.3 257.13,165.3 256.5,164.66 256.5,137.94 248.02,129.46 227.38,129.46 224.66,126.75 224.66,46.1 210.44,31.88 164.85,31.88 163.83,32.89 163.83,36.83 D120.02
D12003: length 282.8
  L31_SIGNAL w0.076: 305.67,188.53 308.23,188.53 v2(308.55,188.21)
  L31_SIGNAL w0.091: 305.67,188.53 304,188.53 300.17,184.7 300.17,167.8 297.67,165.3 297.13,165.3 296.49,164.66 296.49,127.33 286.26,117.09 286.26,94.74 273.81,82.3 227.33,82.3 225.55,80.52 225.55,36.58 218.19,29.21 171.45,29.21 D120.03
D12004: length 281.3
  L15_SIGNAL w0.091: v3(307.84,122.76) 306.14,122.76 301.75,118.36 294.91,118.36 287.91,111.37 287.91,105.4 272.94,90.42 235.09,90.42 224.28,79.62 224.28,55.5 213.11,44.32 171.7,44.32 171.45,44.07 171.45,41.91 D120.04
  L29_SIGNAL w0.076: v2(348.55,188.21) 348.23,188.53 345.67,188.53
  L29_SIGNAL w0.091: 345.67,188.53 344,188.53 340.17,184.7 340.17,167.8 337.67,165.3 337.13,165.3 336.49,164.66 336.49,149.8 316.23,129.54 315.47,129.54 311.28,125.35 309.63,125.35 307.84,123.57 v3(307.84,122.76)
D12005: length 204.8
  L17_SIGNAL w0.091: D120.05 168.91,36.83 168.91,38.81 168.35,39.37 155.24,39.37 141.96,52.65 141.96,130.05 129.6,142.41 124.6,142.41 123.95,143.05 102.75,143.05 96.67,149.14 96.67,160.73 93.65,163.75 93.65,183.39 UNK5K6.7
D12006: length 172.2
  L29_SIGNAL w0.091: UNK6K6.7 93.85,151.43 93.85,147.95 97.15,144.65 135.76,144.65 173.99,106.43 173.99,39.37 D120.06
D12007: length 340.6
  L21_SIGNAL w0.102: UNK7K6.7 456.2,151.65 456.2,148.5 455.22,147.52 440.78,147.52 433.21,139.95 393.11,139.95 350.7,97.54 303.72,97.54 289.25,83.06 234.19,83.06 206.63,55.5 206.63,47.37 201.17,41.91 177.04,41.91 176.4,41.28 176.4,36.7 D120.07
D12008: length 427.9
  L21_SIGNAL w0.102: UNK8K6.7 459.9,187.1 486.64,187.1 487.96,185.78 487.96,176.17 478.23,166.45 478.23,161.06 478.28,161.01 478.28,148.08 477.14,146.94 467.23,146.94 457.23,136.93 410.34,136.93 396.32,122.91 396.32,117.22 350.09,70.99 223.14,70.99 207.39,55.25 207.39,46.35 200.41,39.37 179.07,39.37 D120.08
D12009: length 340.1
  L27_SIGNAL w0.079: 182.79,33.11 182.79,32.02 182.56,31.79 182.44,31.79 182.38,31.86 182.27,31.86 182.15,31.75 182.15,31.64 182.22,31.57 182.22,31.46 182.11,31.35 182,31.35 181.93,31.42 181.82,31.42 181.71,31.3 181.71,31.19 181.78,31.13 181.78,31.01 181.02,30.26 152.77,30.26 132.5,50.54 132.5,115.45 135.35,118.3 141.03,118.3 144.03,115.3 144.03,82.56 146.69,79.9 150.8,79.9 153.25,82.34 153.25,100.98 158.86,106.59 158.86,124.01 163.52,128.66 173.22,128.66 194.48,149.92 212.17,149.92 214.29,152.05 214.29,159.97 211.37,162.9 211.37,175.1 209.6,176.87 209.6,183.72 211.51,185.63 211.51,189.62 211.51,189.63
  L27_SIGNAL w0.091: v1(212.16,189.72) 211.6,189.72 211.51,189.63 ; 182.79,33.11 D120.09
  BOTTOM w0.16: UNK5U408.E8 v1(212.16,189.72)
D12010: length 285.6
  L25_SIGNAL w0.079: 186.69,36.04 186.69,34.92 187.45,34.16 202.06,34.16 206.22,38.33 206.22,67.88 213.6,75.26 215.7,75.26 219.08,71.87 219.08,69.84 212.02,62.78 212.02,48.19 215.01,45.19 220.63,45.19 223.02,47.58 223.02,128.1 225.92,131 245.92,131 248.47,133.55 249.93,133.55 254.29,137.91 254.29,159.97 251.37,162.9 251.37,175.1 249.6,176.87 249.6,183.72 251.51,185.64 251.51,189.63
  L25_SIGNAL w0.091: 251.51,189.63 251.6,189.72 v1(252.16,189.72) ; 186.69,36.04 186.16,36.58 184.4,36.58 D120.10
  BOTTOM w0.16: UNK6U408.E8 v1(252.16,189.72)
D12011: length 340.1
  L27_SIGNAL w0.079: 211.31,189.63 211.32,189.62 211.32,185.71 209.4,183.8 209.4,176.79 211.17,175.02 211.17,162.82 214.1,159.89 214.1,152.13 212.09,150.11 194.4,150.11 173.14,128.86 163.44,128.86 158.67,124.09 158.67,106.67 153.06,101.06 153.06,82.42 150.72,80.09 146.77,80.09 144.23,82.64 144.23,115.38 141.11,118.49 135.27,118.49 132.3,115.53 132.3,50.46 152.69,30.07 181.1,30.07 182.98,31.94 182.98,33.12
  L27_SIGNAL w0.091: v1(210.66,189.72) 211.22,189.72 211.31,189.63 ; 182.98,33.12 D120.11
  BOTTOM w0.16: UNK5U408.E9 v1(210.66,189.72)
D12012: length 285.6
  L25_SIGNAL w0.079: 186.88,37.02 186.88,35.01 187.53,34.36 201.98,34.36 202.76,35.14 202.76,35.25 202.66,35.34 202.66,35.46 202.78,35.57 202.89,35.57 202.98,35.47 203.09,35.47 203.2,35.58 203.2,35.7 203.11,35.79 203.11,35.9 203.22,36.01 203.33,36.01 203.43,35.92 203.54,35.92 203.65,36.03 203.65,36.14 203.56,36.24 203.56,36.35 203.67,36.46 203.78,36.46 203.87,36.36 203.98,36.36 204.1,36.47 204.1,36.59 204,36.68 204,36.79 204.11,36.9 204.22,36.9 204.32,36.81 204.43,36.81 204.54,36.92 204.54,37.03 204.45,37.13 204.45,37.24 204.56,37.35 204.67,37.35 204.76,37.25 204.88,37.25 204.99,37.37 204.99,37.48 204.89,37.57 204.89,37.68 205,37.79 205.11,37.79 205.21,37.7 205.32,37.7 205.43,37.81 205.43,37.92 205.34,38.02 205.34,38.13 205.45,38.24 205.56,38.24 205.66,38.15 205.77,38.15 206.03,38.41 206.03,67.96 213.52,75.45 215.78,75.45 219.28,71.95 219.28,69.76 212.21,62.7 212.21,48.27 215.09,45.38 220.55,45.38 222.82,47.66 222.82,128.18 225.84,131.19 245.84,131.19 248.39,133.74 249.85,133.74 254.1,137.99 254.1,159.89 251.17,162.82 251.17,175.02 249.4,176.79 249.4,183.8 251.32,185.71 251.32,189.62 251.31,189.63
  L25_SIGNAL w0.091: 251.31,189.63 251.22,189.72 v1(250.66,189.72) ; 186.88,37.02 D120.12
  BOTTOM w0.16: UNK6U408.E9 v1(250.66,189.72)
D12013: length 304.3
  L31_SIGNAL w0.079: 291.51,189.63 291.51,185.64 289.6,183.72 289.6,176.87 291.37,175.1 291.37,162.9 294.29,159.97 294.29,129.24 285.18,120.12 285.18,95.04 273.2,83.06 225.4,83.06 222.34,80 222.34,67.6 221.57,66.83 220.18,66.83 219.41,67.6 219.41,80.25 218.59,81.06 217.5,81.06 216.53,80.09 216.53,67.58 215.76,66.81 214.46,66.81 213.69,67.58 213.69,79.64 212.58,80.74 208.81,80.74 207.64,79.58 207.64,35.55 203.02,30.92 193.98,30.92 192.95,31.95 192.95,33.11
  L31_SIGNAL w0.091: 291.51,189.63 291.6,189.72 v1(292.16,189.72) ; 192.95,33.11 D120.13
  BOTTOM w0.16: UNK7U408.E8 v1(292.16,189.72)
D12014: length 342.5
  L15_SIGNAL w0.079: 304.8,117.66 305.48,117.66 305.75,117.39 305.75,116.54 305.23,116.02 302.85,116.02 302.21,116.65 294.18,116.65 293.18,115.66 293.18,100.88 277.4,85.1 232.8,85.1 229.26,81.55 229.26,75.23 232.71,71.77 268.38,71.77 269.87,70.28 269.87,66.11 268.6,64.85 234.08,64.85 228.51,59.28 228.51,52.26 218.26,42.01 196.18,42.01 195.54,41.36 195.54,40.6
  L15_SIGNAL w0.091: v3(303.53,117.04) 304.18,117.04 304.8,117.66 ; 195.54,40.6 D120.14
  L29_SIGNAL w0.079: 331.51,189.63 331.51,185.64 331.42,185.54 329.6,183.72 329.6,176.87 331.37,175.1 331.37,162.9 334.29,159.97 334.29,149.51 322.83,138.05 320.93,138.05 318.77,135.89 318.77,133.22 317.12,131.57 316.36,131.57 311.02,126.24 309.25,126.24 306.32,123.32 306.32,118.36 305.66,117.7 304.41,117.7 303.75,117.04 v3(303.53,117.04)
  L29_SIGNAL w0.091: v1(332.16,189.72) 331.6,189.72 331.51,189.63
  BOTTOM w0.16: UNK8U408.E8 v1(332.16,189.72)
D12015: length 304.3
  L31_SIGNAL w0.079: 291.31,189.63 291.32,189.62 291.32,185.71 289.4,183.8 289.4,176.79 291.17,175.02 291.17,162.82 294.1,159.89 294.1,129.32 284.99,120.2 284.99,95.12 273.12,83.25 225.32,83.25 222.15,80.08 222.15,67.68 221.49,67.02 220.26,67.02 219.6,67.68 219.6,80.33 218.67,81.26 217.42,81.26 216.34,80.17 216.34,67.66 215.68,67.01 214.54,67.01 213.88,67.66 213.88,79.72 212.66,80.94 208.73,80.94 207.45,79.66 207.45,35.63 202.94,31.12 195.66,31.12 195.58,31.19 195.58,31.29 195.5,31.37 195.34,31.37 195.26,31.29 195.26,31.19 195.19,31.12 195.03,31.12 194.95,31.19 194.95,31.29 194.87,31.37 194.71,31.37 194.63,31.29 194.63,31.19 194.56,31.12 194.06,31.12 193.14,32.03 193.14,33.12
  L31_SIGNAL w0.091: 193.14,33.12 D120.15 ; v1(290.66,189.72) 291.22,189.72 291.31,189.63
  BOTTOM w0.16: UNK7U408.E9 v1(290.66,189.72)
D12016: length 342.5
  L15_SIGNAL w0.079: 195.73,40.49 195.73,41.28 196.26,41.81 218.34,41.81 228.71,52.18 228.71,59.2 234.16,64.65 268.68,64.65 270.07,66.03 270.07,70.36 268.46,71.96 232.79,71.96 229.45,75.31 229.45,81.47 232.88,84.91 277.48,84.91 293.38,100.8 293.38,115.58 294.26,116.46 302.13,116.46 302.77,115.82 305.31,115.82 305.94,116.46 305.94,117.47 305.56,117.86 304.8,117.86
  L15_SIGNAL w0.091: 195.73,40.49 D120.16 ; 304.8,117.86 304.09,118.56 v3(303.53,118.56)
  L29_SIGNAL w0.079: 331.31,189.63 331.32,189.62 331.32,185.71 329.4,183.8 329.4,176.79 331.17,175.02 331.17,162.82 334.1,159.89 334.1,149.59 322.75,138.24 320.85,138.24 318.58,135.97 318.58,133.3 317.04,131.77 316.28,131.77 310.94,126.43 309.16,126.43 306.13,123.4 306.13,118.44 305.58,117.89 304.41,117.89 303.74,118.56 v3(303.53,118.56)
  L29_SIGNAL w0.091: v1(330.66,189.72) 331.22,189.72 331.31,189.63
  BOTTOM w0.16: UNK8U408.E9 v1(330.66,189.72)
D12101: length 315.3
  L19_SIGNAL w0.076: 350.83,251.01 350.83,250.02 350.83,248.53 v2(350.5,248.2)
  L19_SIGNAL w0.102: 350.83,251.01 350.83,251.21 351.74,252.11 352.27,252.11 352.87,252.71 356.36,252.71 357.33,251.74 358.14,251.74 360.53,249.36 360.53,238.77 358.39,236.63 358.11,236.63 356.53,235.05 352.97,235.05 348.37,230.45 346.03,230.45 343.81,228.23 343.18,228.23 342.17,227.23 342.17,225.57 338.78,222.17 330.5,222.17 329.48,221.16 321.28,221.16 320.56,220.44 320.56,218.36 318.91,216.71 290.82,216.71 288.82,214.71 284.32,214.71 283.64,214.02 283.64,213.16 283.03,212.55 282.39,212.55 280.94,211.1 280.94,210.11 280.31,209.47 277.03,209.47 276.58,209.02 273.63,209.02 272.89,209.75 266.57,209.75 266.11,210.21 253.64,210.21 249.37,205.93 243.93,205.93 239.85,201.85 226.9,201.85 226.47,201.42 223.39,201.42 219.86,204.95 212.62,204.95 209.13,201.46 209.13,199.23 208.22,198.32 208.22,121.98 D121.01
D12102: length 319.7
  L19_SIGNAL w0.254: 349.11,250.06 v2(348.55,249.5)
  L19_SIGNAL w0.508: 349.11,250.06 349.11,250.91 349.54,251.34 349.54,252.46 350.53,253.44 351.24,253.44 351.6,253.08 352.37,253.08 353.26,253.98 356.21,253.98 357.76,252.43 359.87,252.43 361.26,251.03 361.26,237.22 357.6,233.55 353.55,233.55 347.48,227.48 343.57,227.48 342.86,226.77 342.86,222.5 341.82,221.46 330.95,221.46 327.85,218.36 321.78,218.36 318.28,214.86 291.26,214.86 287.37,210.97 287.37,210.95 285.01,208.58 281.5,208.58 281.07,208.15 276.96,208.15 276.75,208.36 273.4,208.36 272.64,209.12 270.94,209.12 268.35,206.53 262.6,206.53 261.64,207.49 261.44,207.49 259.51,209.42 258.69,209.42 258.08,208.81 253.92,208.81 249.83,204.72 244.43,204.72 240.37,200.66 221.59,200.66 217.91,204.34 213.51,204.34 210.54,201.37 210.54,199.52 208.87,197.85 208.87,126.41 D121.02
D12103: length 320.9
  L19_SIGNAL w0.076: 351.48,250.98 351.48,248.53 v2(351.15,248.2)
  L19_SIGNAL w0.102: D121.03 237.47,95.23 232,95.23 207.78,119.45 207.78,198.47 208.71,199.4 208.71,201.9 212.69,205.89 219.51,205.89 223.52,201.88 226.31,201.88 226.8,202.36 236.07,202.36 237.62,203.91 241.33,203.91 243.8,206.39 249.16,206.39 253.42,210.64 266.42,210.64 266.72,210.34 268.37,210.34 268.8,210.77 270.45,210.77 270.63,210.59 275.53,210.59 276.14,209.98 277.19,209.98 277.9,210.69 279.86,210.69 282.6,213.43 282.6,213.89 283.81,215.11 288.51,215.11 290.57,217.17 318.71,217.17 319.52,217.98 319.52,220.86 320.22,221.56 328.9,221.56 330.75,223.42 338.8,223.42 339.99,224.61 339.99,226.53 340.99,227.53 341.79,227.53 345.22,230.96 348.12,230.96 353.3,236.14 355.29,236.14 355.55,235.89 356.79,235.89 359.26,238.36 359.26,249.08 356.06,252.28 353.17,252.28 352.41,251.52 351.9,251.52 351.48,251.09 351.48,250.98
D12104: length 329.6
  L19_SIGNAL w0.254: 347.24,250.17 v2(348.55,248.85)
  L19_SIGNAL w0.508: 347.24,250.17 347.24,251.23 347.83,251.82 347.83,253.79 349.51,255.47 350.23,255.47 350.63,255.07 352.92,255.07 353.3,255.45 356.26,255.45 357.76,253.95 360.3,253.95 362.86,251.39 362.86,236.78 358.86,232.78 358.86,232.16 358.1,231.39 354.26,231.39 350,227.13 350,221.79 348.12,219.91 330.77,219.91 328.28,217.42 322.85,217.42 318.25,212.83 310.63,212.83 310.13,213.33 309.41,213.33 308.83,212.75 290.96,212.75 289.74,211.53 289.74,208.05 288.37,206.68 278.28,206.68 275.49,203.89 262.43,203.89 262.12,203.58 260.84,203.58 259.99,204.42 253.55,204.42 250.65,201.51 250.65,196.46 248.34,194.16 241.4,194.16 240.69,194.87 240.69,195.51 240.64,195.63 239.7,196.57 227.88,196.57 225.72,194.42 219.31,194.42 218.64,193.75 211.79,193.75 209.78,191.73 209.78,127.11 230.35,106.54 233.82,106.54 D121.04
D12105: length 263.7
  L17_SIGNAL w0.508: 367.11,211.22 v2(366.71,211.22)
  L17_SIGNAL w0.762: 363.08,193.62 362.54,194.16 359.65,194.16
  L17_SIGNAL w1.016: D121.05 256.54,83.82 281.17,83.82 304.26,106.91 359.43,106.91 369.26,116.74 369.26,163.49 368.21,164.54 363.71,164.54 360.08,168.17 360.08,174.27 361.78,175.97 362.49,175.97 363.08,176.56 363.08,193.62 ; 359.65,194.16 358.96,194.84 358.96,197.64 359.72,198.4 360.49,198.4 361.02,198.93 361.02,203.66 361.84,204.47 368.59,204.47 369.31,205.19 369.31,209.77 367.86,211.22 367.11,211.22
  BOTTOM w0.305: UNK8U451.4 366.1,210.6 v2(366.71,211.22) 366.4,211.53 UNK8U452.7
D12106: length 223.7
  L17_SIGNAL w0.508: v2(320.33,210.23) 320.57,210.48
  L17_SIGNAL w1.016: D121.06 242.4,103.04 231.82,103.04 226.53,108.33 226.53,114.23 228.32,116.02 231.81,116.02 232.82,117.04 232.82,125.22 234.95,127.35 241.62,127.35 242.64,128.36 271.85,128.36 272.99,129.51 272.99,137.25 272.11,138.13 272.11,146.06 272.99,146.94 272.99,148.39 274.18,149.59 278.03,149.59 278.78,148.84 282.71,148.84 283.32,149.45 289.49,149.45 290.75,150.71 290.75,171.56 295.44,176.25 297.35,176.25 298.62,177.52 298.62,193.5 299.28,194.16 301.96,194.16 302.66,194.86 302.66,197.48 303.02,197.84 303.02,209.13 304.76,210.87 304.76,216 305.41,216.64 320.35,216.64 321.07,215.93 321.07,210.98 320.57,210.48
  BOTTOM w0.305: UNK7U450.4 319.83,209.74 v2(320.33,210.23)
D12107: length 264.1
  L17_SIGNAL w0.508: v2(365.6,211.22) 365.6,210.21
  L17_SIGNAL w0.762: 359.01,175.89 359.01,175.31 358.42,174.71 ; 360.99,164.02 360.99,158.65
  L17_SIGNAL w1.016: 359.01,175.89 359.01,177.29 359.8,178.08 360.54,178.08 361.07,178.61 361.07,191.64 360.49,192.23 357.62,192.23 356.9,192.95 356.9,201.69 357.62,202.41 358.35,202.41 358.94,203 358.94,205.64 359.72,206.43 363.13,206.43 363.69,206.98 363.69,207.77 365.6,209.68 365.6,210.21 ; D121.07 259.86,85.58 279.62,85.58 300.74,106.7 300.74,108.83 303.31,111.4 354.53,111.4 361.15,118.03 361.15,132.66 362.06,133.57 362.06,139.17 359.95,141.27 359.95,143.27 362.26,145.57 366.54,145.57 367.24,146.28 367.24,148.85 366.45,149.65 363.52,149.65 362.71,148.84 361.45,148.84 360.77,149.53 360.77,152.41 361.87,153.52 365.38,153.52 365.89,154.03 365.89,155.13 367.14,156.38 367.14,157.05 366.34,157.86 361.79,157.86 360.99,158.65 ; 358.42,174.71 356.83,173.13 356.83,168.19 360.99,164.02
  BOTTOM w0.305: UNK8U452.8 365.9,211.53 v2(365.6,211.22) UNK8U451.3
D12108: length 206.3
  L17_SIGNAL w0.508: v2(319.08,211.17) 319.42,211.51
  L17_SIGNAL w1.016: 319.42,211.51 319.42,212.39 319.01,212.8 319.01,213.94 318.38,214.58 313.58,214.58 312.97,213.97 312.97,213.46 310.23,210.72 310.23,208.1 309.16,207.04 309.16,201.22 307.05,199.11 307.05,195.79 304.69,193.42 304.69,192.86 303.95,192.12 303.24,192.12 302.71,191.59 302.71,190.8 302.15,190.25 301.15,190.25 300.69,189.79 300.69,175.8 301.39,175.11 301.39,170.48 300.76,169.86 300.76,167.93 299.78,166.94 299.59,166.66 299.59,163.32 294.31,158.03 294.31,151.95 289.79,147.44 283.73,147.44 282.98,146.68 282.98,145.05 281.96,144.04 279.31,144.04 278.74,144.6 278.74,147.06 278,147.8 276.58,147.8 275.84,147.06 275.84,145.47 276.34,144.97 276.34,134.15 274.9,132.72 274.9,128.82 273.04,126.95 243.59,126.95 242.37,125.74 236.41,125.74 235.39,124.71 235.39,106.54 237.46,104.47 246.05,104.47 D121.08
  BOTTOM w0.305: UNK7U450.2 318.83,210.56 319.08,210.81 v2(319.08,211.17)
D12109: length 224.4
  L17_SIGNAL w0.508: 359.07,209.98 v2(359.33,210.23)
  L17_SIGNAL w0.762: 355.79,177.7 356.56,178.47
  L17_SIGNAL w1.016: 355.79,177.7 355.33,177.7 354.64,177.01 354.64,167.84 358.94,163.55 358.94,155.16 357.08,153.3 357.08,148.78 355.85,147.55 355.85,131.43 355.05,130.63 355.05,122.84 351.99,119.77 296.94,119.77 283.76,106.59 283.76,92.63 278.41,87.28 263.24,87.28 D121.09 ; 359.07,209.98 358.63,209.98 357.31,208.66 357.31,206.45 357.08,206.22 357.08,204.37 355.08,202.36 355.08,193.83 354.92,193.68 354.92,192.51 358.12,189.31 358.12,184.91 357.31,184.1 357.31,179.22 356.56,178.47
  BOTTOM w0.305: UNK8U450.3 v2(359.33,210.23)
D12110: length 207.1
  L17_SIGNAL w0.508: v2(318.08,211.17) 318.08,211.75 317.21,212.63
  L17_SIGNAL w0.762: 306.29,192.79 306.62,193.12 307.76,193.12
  L17_SIGNAL w1.016: 307.76,193.12 308.7,194.06 308.7,198.32 314.65,204.27 314.65,211.73 315.54,212.63 317.21,212.63 ; 306.29,192.79 305.96,192.46 305.96,191.92 304.19,190.16 304.19,185.94 302.76,184.51 302.76,177.37 304.41,175.72 304.41,170.84 302.66,169.09 302.66,158.26 301.62,157.23 301.62,149.78 300.64,148.8 300.64,146.55 299.62,145.53 287.94,145.53 287.79,145.38 287.78,145.38 287.24,144.85 287.24,144.83 287.14,144.73 287.14,138.09 286.3,137.26 283.7,137.26 282.96,138 282.96,140.85 282.19,141.62 280.84,141.62 279.74,140.51 279.74,136.78 278.99,136.04 278.99,127.9 276.63,125.54 244.65,125.54 243.08,123.97 237.86,123.97 237.14,123.26 237.14,108.22 239.39,105.97 249.63,105.97 D121.10
  BOTTOM w0.305: v2(318.08,211.17) 318.08,210.81 318.33,210.56 UNK7U450.1
D12111: length 207.1
  L17_SIGNAL w0.508: 357.21,212.63 358.08,211.75 v2(358.08,211.17)
  L17_SIGNAL w0.762: 347.76,193.12 346.62,193.12 346.29,192.79
  L17_SIGNAL w1.016: 347.76,193.12 348.7,194.06 348.7,198.32 354.64,204.27 354.64,211.73 355.54,212.63 357.21,212.63 ; D121.11 266.59,89.01 277.26,89.01 281.46,93.21 281.46,107.14 298.29,123.97 336.7,123.97 338.65,125.93 338.65,137.03 340.83,139.2 340.83,149.57 341.94,150.68 341.94,157.53 342.66,158.25 342.66,170.39 344.25,171.98 344.25,175.88 342.69,177.43 342.69,184.44 344.19,185.94 344.19,190.16 345.96,191.92 345.96,192.46 346.29,192.79
  BOTTOM w0.305: UNK8U450.1 358.33,210.56 358.08,210.81 v2(358.08,211.17)
D12112: length 224.4
  L17_SIGNAL w0.508: v2(319.33,210.23) 319.07,209.98
  L17_SIGNAL w0.762: 316.56,178.47 315.79,177.7
  L17_SIGNAL w1.016: 319.07,209.98 318.63,209.98 317.31,208.66 317.31,206.45 317.08,206.22 317.08,204.37 315.08,202.36 315.08,193.83 314.92,193.68 314.92,192.51 318.12,189.31 318.12,184.91 317.31,184.1 317.31,179.22 316.56,178.47 ; 315.79,177.7 315.33,177.7 314.65,177.01 314.65,167.84 318.94,163.55 318.94,156.12 318.36,155.55 308.77,155.55 308.26,156.06 307.31,156.06 306.72,155.46 306.72,150.05 305.29,148.61 305.29,145.23 303.5,143.45 290.33,143.45 289.16,142.28 289.16,140.16 289.93,139.39 291.78,139.39 294.26,141.87 299.14,141.87 301.39,139.62 301.39,136.23 300.49,135.33 282.48,135.33 281.06,133.92 281.06,127.09 278.12,124.15 246.55,124.15 244.29,121.9 244.29,108.62 245.47,107.44 253.24,107.44 D121.12
  BOTTOM w0.305: UNK7U450.3 v2(319.33,210.23)
D12113: length 206.3
  L17_SIGNAL w0.508: 359.42,211.51 v2(359.08,211.17)
  L17_SIGNAL w1.016: 359.42,211.51 359.42,212.39 359.01,212.8 359.01,213.94 358.38,214.58 353.58,214.58 352.97,213.97 352.97,213.46 350.23,210.72 350.23,208.1 349.16,207.04 349.16,201.22 347.05,199.11 347.05,195.37 344.67,192.99 344.67,192.69 344.1,192.12 343.24,192.12 342.71,191.59 342.71,190.8 342.15,190.25 341.34,190.25 340.75,189.66 340.75,167.92 339.78,166.94 339.59,166.66 339.59,163.32 335.24,158.98 335.24,145.38 336.63,143.99 336.63,138.47 335.45,137.3 334.46,137.3 334.33,137.43 330.31,137.43 329.3,136.41 329.3,128.42 326.83,125.96 292.6,125.96 290.18,123.54 290.18,118.44 279.57,107.82 279.57,93.95 276.35,90.74 269.94,90.74 D121.13
  BOTTOM w0.305: v2(359.08,211.17) 359.08,210.81 358.83,210.56 UNK8U450.2
D12114: length 264.1
  L17_SIGNAL w0.508: v2(325.6,211.22) 325.6,210.21
  L17_SIGNAL w0.762: 319.01,175.89 319.01,175.31 318.42,174.71
  L17_SIGNAL w1.016: 318.42,174.71 316.83,173.13 316.83,168.18 321,164.02 321,154.11 320.41,153.52 313.59,153.52 313.08,154.03 309.7,154.03 308.96,153.29 308.96,150.19 309.63,149.51 316.56,149.51 316.95,149.9 316.95,150.86 317.73,151.64 319.18,151.64 319.94,150.88 320.17,150.88 320.97,150.08 320.97,144.39 319.95,143.37 317,143.37 315.98,144.39 315.98,146.03 315.27,146.75 313.7,146.75 312.96,146.01 312.96,143.33 311.92,142.28 310.25,142.28 309.72,142.82 309.72,144.17 308.96,144.93 307.94,144.93 307.06,144.05 307.06,142.16 306.06,141.16 305.07,141.16 303.94,140.03 303.94,138.16 305.24,136.86 309.79,136.86 311.92,134.72 311.92,133.02 310.2,131.3 283.73,131.3 283.05,130.61 283.05,128.37 284.81,126.61 284.81,121.48 283.28,119.96 246.63,119.96 245.91,119.24 245.91,112.32 246.7,111.53 253,111.53 254.37,110.16 254.37,108.49 259.53,103.33 262.43,103.33 D121.14 ; 319.01,175.89 319.01,177.29 319.8,178.08 320.54,178.08 321.07,178.61 321.07,191.64 320.49,192.23 317.62,192.23 316.9,192.95 316.9,201.69 317.62,202.41 318.35,202.41 318.94,203 318.94,205.64 319.73,206.43 323.13,206.43 323.69,206.98 323.69,207.77 325.6,209.68 325.6,210.21
  BOTTOM w0.305: UNK7U451.3 v2(325.6,211.22) 325.9,211.53 UNK7U452.8
D12115: length 223.7
  L17_SIGNAL w0.508: v2(360.33,210.23) 360.57,210.48
  L17_SIGNAL w1.016: 360.57,210.48 361.07,210.98 361.07,215.93 360.35,216.64 345.41,216.64 344.76,216 344.76,210.87 343.03,209.13 343.03,197.85 342.66,197.48 342.66,194.89 341.92,194.15 340.17,194.15 340.17,194.16 339.28,194.16 338.62,193.5 338.62,177.52 337.35,176.25 335.44,176.25 330.92,171.73 330.92,151.33 332.55,149.71 332.55,140.01 331.96,139.43 327.82,139.43 327.11,138.72 327.11,131.88 326.49,131.25 321.63,131.25 321.1,130.73 321.1,129.8 318.83,127.52 289.65,127.52 288.28,126.15 288.28,119.25 280.63,111.6 270.88,111.6 270.1,110.82 270.1,104.04 270.58,103.55 273.01,103.55 277.55,99 277.55,94.56 275.37,92.37 273.39,92.37 D121.15
  BOTTOM w0.305: v2(360.33,210.23) 359.83,209.74 UNK8U450.4
D12116: length 263.6
  L17_SIGNAL w0.508: v2(326.71,211.22) 327.11,211.22
  L17_SIGNAL w0.762: 323.08,193.62 322.54,194.16 319.85,194.16
  L17_SIGNAL w1.016: 319.85,194.16 319.12,194.89 319.12,197.79 319.73,198.4 320.49,198.4 321.02,198.93 321.02,203.66 321.84,204.47 328.59,204.47 329.31,205.19 329.31,209.77 327.86,211.22 327.11,211.22 ; D121.16 266.13,104.71 260.24,104.71 257.31,107.65 257.31,110.63 256.47,111.47 255.43,111.47 253.29,113.61 253.29,115.04 254.04,115.79 282.26,115.79 286.58,120.11 286.58,127.97 287.69,129.08 312.29,129.08 313.01,129.8 313.01,130.62 314.92,132.53 318.97,132.53 319.7,133.26 324.39,133.26 325.19,134.06 325.19,136.59 324.47,137.31 319.98,137.31 318.58,135.91 314.16,135.91 311.67,138.4 311.67,140.18 312.7,141.21 315.98,141.21 316.77,140.43 321.55,140.43 322.58,141.45 329.27,141.45 329.83,142.02 329.83,144.77 329.11,145.49 325.66,145.49 325.06,146.09 325.06,148.92 325.66,149.52 328.65,149.52 329.32,150.19 329.32,152.9 328.71,153.52 324.15,153.52 323.31,154.36 323.31,154.95 323.12,155.14 323.12,157.16 323.84,157.88 328.52,157.88 329.2,158.56 329.2,163.55 328.21,164.54 323.71,164.54 320.08,168.17 320.08,174.27 321.78,175.97 322.49,175.97 323.08,176.56 323.08,193.62
  BOTTOM w0.305: UNK7U451.4 326.1,210.6 v2(326.71,211.22) 326.4,211.53 UNK7U452.7
D12201: length 110.6
  L27_SIGNAL w0.076: v2(227.26,180.41) 227.58,180.08 227.58,178.18
  L27_SIGNAL w0.091: 227.58,178.18 227.58,177.81 230.38,175.01 230.38,165.71 229.07,164.4 228.3,164.4 227.59,163.69 227.59,161.47 227.03,160.91 227.03,146.84 226.45,146.26 226.45,126.36 226.94,125.86 226.94,82.94 D122.01
D12202: length 146.3
  L25_SIGNAL w0.076: 267.58,178.18 267.58,180.08 v2(267.25,180.41)
  L25_SIGNAL w0.091: 267.58,178.18 267.58,177.81 270.38,175.01 270.38,165.71 269.07,164.4 268.3,164.4 267.59,163.69 267.59,161.47 267.03,160.91 267.03,146.84 266.45,146.26 266.45,129.96 268.9,127.51 274.45,127.51 278.9,123.06 278.9,95.54 267.56,84.19 241.67,84.19 D122.02
D12203: length 268.4
  L31_SIGNAL w0.076: v2(307.25,180.41) 307.58,180.08 307.58,178.18
  L31_SIGNAL w0.091: 307.58,178.18 307.58,177.81 310.38,175.01 310.38,165.71 309.07,164.4 308.3,164.4 307.59,163.69 307.59,161.47 307.03,160.91 307.03,146.84 306.45,146.26 306.45,140.34 308.24,138.55 308.49,138.55 312.43,134.61 312.43,125.62 310.9,124.08 310.9,113.54 308.61,111.25 307.59,111.25 306.32,109.98 306.32,108.08 298.35,100.1 298.35,51.77 276.01,29.43 232.01,29.43 229.36,32.09 229.36,66.8 D122.03
D12204: length 180
  L15_SIGNAL w0.091: D122.04 246.25,83.69 278.78,83.69 298.45,103.37 298.45,107.81 302.91,112.27 312.91,112.27 314.32,113.68 314.32,119.08 v3(316.48,121.23)
  L29_SIGNAL w0.076: 347.58,178.18 347.58,180.08 v2(347.25,180.41)
  L29_SIGNAL w0.091: v3(316.48,121.23) 316.81,121.23 320.42,124.84 322.1,124.84 325.73,128.47 334.85,128.47 339.22,132.84 339.22,139.02 347.03,146.84 347.03,160.91 347.59,161.47 347.59,163.69 348.3,164.4 349.07,164.4 350.38,165.71 350.38,175.01 347.58,177.81 347.58,178.18
D12205: length 114.1
  L27_SIGNAL w0.076: v2(227.91,179.76) 228.23,179.43 228.23,178.18
  L27_SIGNAL w0.091: D122.05 242.74,77.3 242.74,82.27 236.98,88.03 236.98,88.04 236.89,88.13 235.75,88.13 227.37,96.51 227.37,126.2 226.81,126.75 226.81,144.57 228.52,146.27 228.52,157.43 229.12,158.03 229.12,161.31 229.67,161.86 229.67,163.92 230.75,164.99 230.75,175.2 228.23,177.72 228.23,178.18
D12206: length 135.5
  L25_SIGNAL w0.076: v2(267.9,179.76) 268.23,179.43 268.23,178.18
  L25_SIGNAL w0.091: 268.23,178.18 268.23,177.72 270.75,175.2 270.75,164.99 269.67,163.92 269.67,161.86 269.12,161.31 269.12,158.03 268.52,157.43 268.52,146.27 266.81,144.57 266.81,130.11 268.99,127.93 274.62,127.93 279.32,123.23 279.32,95.36 267.73,83.77 251.41,83.77 D122.06
D12207: length 285.6
  L31_SIGNAL w0.076: 308.23,178.18 308.23,179.43 v2(307.9,179.76)
  L31_SIGNAL w0.091: D122.07 247.9,77.22 233.04,77.22 228.93,73.1 228.93,31.8 231.72,29.01 276.19,29.01 298.86,51.68 298.86,99.97 306.96,108.08 309.5,108.08 311.4,109.98 311.4,123.95 312.86,125.41 312.86,136.4 311.34,137.92 309.88,137.92 308.89,138.92 308.55,138.92 306.81,140.66 306.81,144.57 308.52,146.27 308.52,157.43 309.12,158.03 309.12,161.31 309.67,161.86 309.67,163.92 310.75,164.99 310.75,175.2 308.23,177.72 308.23,178.18
D12208: length 169.6
  L15_SIGNAL w0.091: v3(316.48,118.56) 316.46,118.56 314.71,116.81 314.71,113.53 313.07,111.89 303.07,111.89 298.83,107.65 298.83,103.21 278.94,83.31 256.03,83.31 D122.08
  L29_SIGNAL w0.076: 348.23,178.18 348.23,179.43 v2(347.9,179.76)
  L29_SIGNAL w0.091: 348.23,178.18 348.23,177.72 350.75,175.2 350.75,164.99 349.67,163.92 349.67,161.86 349.12,161.31 349.12,158.03 348.52,157.43 348.52,147.35 340.49,139.32 340.49,132.33 336.17,128.02 325.92,128.02 322.35,124.44 320.78,124.44 319.15,122.81 319.15,121.03 316.68,118.56 v3(316.48,118.56)
D12209: length 124.8
  L27_SIGNAL w0.076: 233.43,178.81 233.43,180.73 v2(233.76,181.06)
  L27_SIGNAL w0.091: D122.09 252.87,77.33 252.87,82.2 246.45,88.62 235.98,88.62 227.79,96.82 227.79,126.8 227.18,127.4 227.18,144.42 228.88,146.12 228.88,157.28 229.48,157.88 229.48,161.09 230.13,161.74 230.13,163.54 232.86,166.26 232.86,178.24 233.43,178.81
D12210: length 127.4
  L25_SIGNAL w0.076: v2(273.76,181.06) 273.43,180.73 273.43,178.81
  L25_SIGNAL w0.091: D122.10 261.06,83.26 267.94,83.26 279.83,95.15 279.83,123.44 274.83,128.44 269,128.44 267.18,130.26 267.18,144.42 268.88,146.12 268.88,157.28 269.48,157.88 269.48,161.09 270.13,161.74 270.13,163.54 272.86,166.26 272.86,178.24 273.43,178.81
D12211: length 300.7
  L31_SIGNAL w0.076: 313.43,178.81 313.43,180.73 v2(313.76,181.06)
  L31_SIGNAL w0.091: 313.43,178.81 312.86,178.24 312.86,166.26 310.13,163.54 310.13,161.74 309.48,161.09 309.48,157.88 308.88,157.28 308.88,142.98 315.14,136.72 315.14,124.52 314.2,123.57 314.2,108.84 312.93,107.57 307.09,107.57 299.36,99.85 299.36,51.47 276.4,28.5 231.5,28.5 228.42,31.58 228.42,73.23 232.89,77.7 257.58,77.7 D122.11
D12212: length 164.7
  L15_SIGNAL w0.091: D122.12 265.68,82.8 279.15,82.8 299.34,103 299.34,107.57 303.28,111.51 313.23,111.51 315.09,113.37 315.09,115.65 v3(316.48,117.04)
  L29_SIGNAL w0.076: 353.43,178.81 353.43,180.73 v2(353.75,181.06)
  L29_SIGNAL w0.091: v3(316.48,117.04) 317.19,117.04 319.91,119.76 319.91,122.81 321.06,123.95 322.58,123.95 326.13,127.51 341.88,127.51 347.18,132.8 347.18,145.25 348.88,146.95 348.88,157.28 349.48,157.88 349.48,161.09 350.13,161.74 350.13,163.54 352.86,166.26 352.86,178.24 353.43,178.81
D12213: length 135.9
  L27_SIGNAL w0.091: D122.13 262.97,77.39 262.97,82.07 256,89.04 236.37,89.04 228.21,97.2 228.21,125.34 235.11,132.24 235.11,147.61 236.67,149.17 236.67,153.88 238.45,155.66 238.45,163.48 234.7,167.23 234.7,179.46 v2(234.41,179.76)
D12214: length 111.9
  L25_SIGNAL w0.091: v2(274.41,179.76) 274.7,179.46 274.7,167.23 278.45,163.48 278.45,155.66 276.66,153.88 276.66,149.17 275.11,147.61 275.11,129.01 280.31,123.8 280.31,92.35 D122.14
D12215: length 314.5
  L31_SIGNAL w0.091: v2(314.41,179.76) 314.7,179.46 314.7,167.23 318.45,163.48 318.45,155.66 316.66,153.88 316.66,149.17 315.11,147.61 315.11,138.28 316.54,136.85 316.54,124.9 314.83,123.19 314.83,108.84 313.06,107.06 307.34,107.06 299.87,99.59 299.87,51.26 276.61,27.99 231.29,27.99 227.91,31.37 227.91,74.6 233.1,79.78 267.23,79.78 267.97,79.04 267.97,77.47 D122.15
D12216: length 157.7
  L15_SIGNAL w0.091: v3(320.8,122.76) 320.78,122.76 317.25,119.22 317.25,116.2 315.59,114.55 315.59,113.16 313.44,111 303.4,111 299.7,107.3 299.7,102.47 277.24,80.01 273.05,80.01 D122.16
  L29_SIGNAL w0.091: v2(354.4,179.76) 354.7,179.46 354.7,167.23 358.45,163.48 358.45,155.66 356.66,153.88 356.66,149.15 351.03,143.51 351.03,134.62 343.41,127 326.26,127 322.02,122.76 v3(320.8,122.76)
D12301: length 135
  L27_SIGNAL w0.091: D123.01 225.26,64.3 225.26,124.24 220.98,128.52 220.98,148.77 221.95,149.74 221.95,158.12 222.22,158.39 222.22,164.69 223.07,165.53 223.07,170.17 222.02,171.22 222.02,176.82 223.21,178.02 223.21,179.51 225.41,181.7 v2(226.61,181.7)
D12302: length 159.7
  L25_SIGNAL w0.091: v2(266.61,181.7) 265.41,181.7 263.21,179.51 263.21,178.02 262.02,176.82 262.02,171.22 263.07,170.17 263.07,165.53 262.22,164.69 262.22,158.07 261.95,157.8 261.95,150.46 260.98,149.49 260.98,132.71 255.55,127.28 230.28,127.28 227.2,124.21 227.2,67.44 D123.02
D12303: length 242
  L31_SIGNAL w0.091: v2(306.6,181.7) 305.41,181.7 303.21,179.51 303.21,178.02 302.02,176.82 302.02,171.22 303.07,170.17 303.07,165.53 302.22,164.69 302.22,157.93 301.95,157.65 301.95,149.94 300.98,148.97 300.98,138.74 302.56,137.16 304.29,137.16 306.49,134.96 306.49,113.33 304.16,111 304.16,108.46 296.32,100.61 296.32,52.73 274.93,31.34 233.1,31.34 231.47,32.97 231.47,50.9 232.64,52.07 234.95,52.07 D123.03
D12304: length 211.3
  L15_SIGNAL w0.091: v3(312.16,121.23) 312.18,121.23 314.26,123.31 321.06,123.31 321.53,122.84 321.53,120.86 321.23,120.55 319.58,120.55 317.72,118.7 317.72,113.25 312.32,107.85 307.26,107.85 300.71,101.3 300.71,87.71 276.36,63.37 246.25,63.37 D123.04
  L29_SIGNAL w0.091: v2(346.6,181.7) 345.41,181.7 343.21,179.51 343.21,178.02 342.02,176.82 342.02,171.22 343.07,170.17 343.07,165.53 342.22,164.69 342.22,157.97 341.95,157.7 341.95,150.29 340.98,149.32 340.98,144.89 336.55,140.46 336.55,136.53 331.6,131.57 326.14,131.57 321.31,126.75 317.88,126.75 312.37,121.23 v3(312.16,121.23)
D12305: length 138.7
  L27_SIGNAL w0.091: D123.05 242.7,57.02 242.7,62.21 237.99,66.92 236.29,66.92 225.68,77.53 225.68,124.58 222.2,128.07 222.2,147.64 222.32,147.76 222.32,157.87 222.67,158.22 222.67,164.46 223.34,165.13 224.8,165.13 225.27,165.6 225.27,169.53 223.83,170.97 223.83,177.48 225.12,178.77 225.12,180.22 v2(225.96,181.06)
D12306: length 168.3
  L25_SIGNAL w0.091: D123.06 241.81,62.99 232.32,62.99 227.71,67.6 227.71,123.7 230.86,126.85 255.63,126.85 262.2,133.41 262.2,147.64 262.32,147.76 262.32,157.55 262.67,157.9 262.67,164.46 263.34,165.13 264.8,165.13 265.27,165.6 265.27,169.53 263.83,170.97 263.83,177.48 265.12,178.77 265.12,180.22 v2(265.96,181.06)
D12307: length 256.5
  L31_SIGNAL w0.091: v2(305.95,181.06) 305.12,180.22 305.12,178.77 303.83,177.48 303.83,170.97 305.27,169.53 305.27,165.6 304.8,165.13 303.34,165.13 302.67,164.46 302.67,157.76 302.32,157.41 302.32,147.76 302.2,147.64 302.2,138.49 303.02,137.67 304.8,137.67 306.95,135.52 306.95,113.02 304.67,110.74 304.67,108.33 296.82,100.48 296.82,52.6 275.12,30.89 232.84,30.89 231.02,32.71 231.02,55.1 233.07,57.15 247.65,57.15 D123.07
D12308: length 209.2
  L15_SIGNAL w0.091: D123.08 256.03,62.99 276.52,62.99 301.09,87.56 301.09,101.14 307.41,107.47 312.58,107.47 318.1,113 318.1,118.54 319.73,120.17 321.38,120.17 321.91,120.7 321.91,123.09 321.33,123.67 312.02,123.67 311.53,123.19 311.53,119.2 v3(312.16,118.56)
  L29_SIGNAL w0.091: v2(345.95,181.06) 345.12,180.22 345.12,178.77 343.83,177.48 343.83,170.97 345.27,169.53 345.27,165.6 344.8,165.13 343.34,165.13 342.67,164.46 342.67,157.81 342.32,157.46 342.32,147.76 342.2,147.64 342.2,145.09 337.1,140 337.1,136.48 331.77,131.15 326.37,131.15 321.45,126.23 318.12,126.23 314.83,122.94 314.83,121.23 v3(312.16,118.56)
D12309: length 150.7
  L27_SIGNAL w0.091: D123.09 252.73,57.15 252.73,61.94 246.93,67.74 236.32,67.74 226.1,77.96 226.1,124.92 222.67,128.36 222.67,133.32 223.44,134.09 223.44,145.37 224.89,146.82 224.89,148.28 224.23,148.95 224.23,157.46 223.1,158.58 223.1,163.86 223.98,164.74 226.49,164.74 227.56,165.81 227.56,168.19 224.29,171.46 224.29,177.2 225.96,178.86 v2(225.96,180.41)
D12310: length 180.9
  L25_SIGNAL w0.091: D123.10 251.54,63.42 232.5,63.42 228.22,67.7 228.22,123.19 231.42,126.39 256.6,126.39 262.67,132.46 262.67,133.32 263.44,134.09 263.44,145.37 264.89,146.82 264.89,148.28 264.23,148.95 264.23,157.38 263.1,158.51 263.1,163.86 263.98,164.74 266.49,164.74 267.56,165.81 267.56,168.19 264.29,171.46 264.29,177.2 265.96,178.86 v2(265.96,180.41)
D12311: length 276.8
  L31_SIGNAL w0.091: D123.11 257.81,57.15 257.81,58.85 257.2,59.46 232.94,59.46 230.45,56.97 230.45,32.56 232.61,30.4 275.43,30.4 297.33,52.31 297.33,100.36 305.18,108.2 305.18,110.11 307.28,112.2 308.17,112.2 309.37,113.41 309.37,131.06 307.34,133.1 307.34,135.89 304.86,138.37 303.8,138.37 303.44,138.74 303.44,145.37 304.89,146.82 304.89,148.28 304.23,148.95 304.23,157.46 303.1,158.58 303.1,163.86 303.98,164.74 306.49,164.74 307.56,165.81 307.56,168.19 304.29,171.46 304.29,177.2 305.95,178.86 v2(305.95,180.41)
D12312: length 210
  L15_SIGNAL w0.091: D123.12 265.68,62.48 276.73,62.48 301.59,87.35 301.59,100.93 307.75,107.09 315.88,107.09 318.61,109.82 318.61,118.33 319.94,119.66 321.59,119.66 322.33,120.4 322.33,123.32 321.47,124.18 312,124.18 311.02,123.2 311.02,118.16 312.14,117.04 v3(312.16,117.04)
  L29_SIGNAL w0.091: v3(312.16,117.04) 312.62,117.04 315.72,120.14 315.72,123.19 318.39,125.86 321.82,125.86 325.5,129.54 331.98,129.54 338.14,135.7 338.14,140.07 344.89,146.82 344.89,148.28 344.23,148.95 344.23,157.46 343.1,158.58 343.1,163.86 343.98,164.74 346.49,164.74 347.56,165.81 347.56,168.19 344.29,171.46 344.29,177.2 345.95,178.86 v2(345.95,180.41)
D12313: length 157.2
  L27_SIGNAL w0.091: D123.13 262.97,57.07 262.97,61.47 256.07,68.37 236.51,68.37 226.52,78.35 226.52,125.52 224.43,127.61 224.43,133.93 224.82,134.32 224.82,145.77 225.36,146.31 225.36,148.92 224.72,149.56 224.72,159.86 225.35,160.49 225.35,163.75 225.87,164.27 227.17,164.27 227.76,164.85 228.84,164.85 229.69,165.7 229.69,167.64 227.3,170.03 227.3,176.79 226.61,177.48 v2(226.61,179.76)
D12314: length 189.5
  L25_SIGNAL w0.091: D123.14 261.24,63.88 232.68,63.88 228.73,67.84 228.73,122.81 231.94,126.02 258.5,126.02 264.43,131.95 264.43,133.93 264.82,134.32 264.82,145.77 265.36,146.31 265.36,148.92 264.72,149.56 264.72,159.86 265.35,160.49 265.35,163.75 265.87,164.27 267.17,164.27 267.76,164.85 268.84,164.85 269.69,165.7 269.69,167.64 267.3,170.03 267.3,176.79 266.61,177.48 v2(266.61,179.76)
D12315: length 288.7
  L31_SIGNAL w0.091: v2(306.6,179.76) 306.6,177.48 307.3,176.79 307.3,170.03 309.69,167.64 309.69,165.7 308.84,164.85 307.76,164.85 307.17,164.27 305.87,164.27 305.35,163.75 305.35,160.49 304.72,159.86 304.72,149.56 305.36,148.92 305.36,146.31 304.82,145.77 304.82,139.17 306.83,137.16 308.1,137.16 311.1,134.16 311.1,125.18 310.13,124.21 310.13,113.54 308.36,111.76 307.35,111.76 305.69,110.1 305.69,108.08 297.84,100.23 297.84,51.92 275.82,29.9 232.33,29.9 229.82,32.41 229.82,57.12 232.64,59.94 266.9,59.94 267.97,58.88 267.97,57.15 D123.15
D12316: length 202.9
  L15_SIGNAL w0.091: v3(316.48,122.76) 316.46,122.76 313.06,119.35 313.06,116.71 312.55,116.2 312.04,116.2 310.51,117.73 310.51,123.44 311.78,124.71 321.56,124.71 322.71,123.57 322.71,120.02 321.94,119.25 320.29,119.25 319.15,118.11 319.15,109.6 316.23,106.68 308.1,106.68 302.13,100.71 302.13,87.12 274.7,59.69 273.05,59.69 D123.16
  L29_SIGNAL w0.091: v2(346.6,179.76) 346.6,177.48 347.3,176.79 347.3,170.03 349.69,167.64 349.69,165.7 348.84,164.85 347.76,164.85 347.17,164.27 345.87,164.27 345.35,163.75 345.35,160.49 344.72,159.86 344.72,149.56 345.36,148.92 345.36,146.31 338.58,139.53 338.58,134.19 333.43,129.03 325.68,129.03 322,125.35 319.07,125.35 v3(316.48,122.76)
D12401: length 166.1
  L27_SIGNAL w0.076: v2(228.56,186.91) 228.23,187.23 228.23,187.69 228.04,187.88 225.75,187.88
  L27_SIGNAL w0.091: D124.01 223.58,45.66 223.58,122.62 218.64,127.56 218.64,165.75 220.54,167.65 220.54,184.55 223.87,187.88 225.75,187.88
D12402: length 188.7
  L25_SIGNAL w0.076: v2(268.55,186.91) 268.23,187.23 268.23,187.69 268.04,187.88 265.75,187.88
  L25_SIGNAL w0.091: D124.02 235.41,38.1 225.17,48.34 225.17,126.24 227.97,129.04 249.25,129.04 258.64,138.43 258.64,165.75 260.54,167.65 260.54,184.55 263.87,187.88 265.75,187.88
D12403: length 207.3
  L31_SIGNAL w0.076: v2(308.55,186.91) 308.23,187.23 308.23,187.69 308.04,187.88 305.75,187.88
  L31_SIGNAL w0.091: 305.75,187.88 303.87,187.88 300.54,184.55 300.54,167.65 298.64,165.75 298.64,138.24 300.28,136.6 300.28,135.07 301.24,134.11 301.24,129.79 301.75,129.29 301.75,111.12 294.26,103.63 294.26,63.88 274.83,44.45 240.54,44.45 240.03,43.94 240.03,36.83 D124.03
D12404: length 251.5
  L15_SIGNAL w0.091: D124.04 245.24,42.04 277.37,42.04 302.69,67.36 302.69,100.51 308.5,106.31 319.42,106.31 323.14,110.03 323.14,123.77 321.77,125.15 311.33,125.15 309.88,123.7 309.88,123.25 307.87,121.23 v3(307.84,121.23)
  L29_SIGNAL w0.076: 345.75,187.88 348.04,187.88 348.23,187.69 348.23,187.23 v2(348.55,186.91)
  L29_SIGNAL w0.091: v3(307.84,121.23) 308.18,121.23 309.25,122.3 309.25,123.44 310.64,124.84 311.91,124.84 316,128.93 317.9,128.93 338.64,149.66 338.64,165.75 340.54,167.65 340.54,184.55 343.87,187.88 345.75,187.88
D12405: length 170.9
  L27_SIGNAL w0.091: v2(226.61,186.91) 225.05,186.91 220.9,182.76 220.9,167.41 220.64,167.15 220.64,167.15 219.12,165.64 219.12,128.59 224,123.72 224,50.61 232.77,41.84 241.79,41.84 242.53,41.1 242.53,36.87 D124.05
D12406: length 194.4
  L25_SIGNAL w0.091: v2(266.61,186.91) 265.05,186.91 260.9,182.76 260.9,167.41 260.64,167.15 260.64,167.15 259.12,165.64 259.12,136.65 251.09,128.62 228.57,128.62 225.68,125.73 225.68,48.67 234.98,39.37 245.11,39.37 D124.06
D12407: length 192.6
  L31_SIGNAL w0.091: v2(306.6,186.91) 305.05,186.91 300.9,182.76 300.9,167.41 300.64,167.15 300.64,167.15 299.12,165.64 299.12,138.52 300.7,136.94 300.7,135.29 302.26,133.73 302.26,111 294.77,103.5 294.77,61.85 274.83,41.91 251.21,41.91 250.19,40.89 250.19,36.83 D124.07
D12408: length 204.4
  L19_SIGNAL w0.102: D124.08 255.02,41.66 277.58,41.66 303.11,67.19 303.11,104.19 306.15,107.23 306.15,116.9 307.82,118.56 v3(307.84,118.56)
  L29_SIGNAL w0.091: v3(307.84,118.56) 310.39,121.11 310.39,123.19 311.47,124.27 312.29,124.27 316.36,128.33 319.09,128.33 339.12,148.37 339.12,165.64 340.64,167.15 340.64,167.15 340.9,167.41 340.9,182.76 345.05,186.91 v2(346.6,186.91)
D12409: length 183.8
  L27_SIGNAL w0.076: v2(227.91,186.91) 227.58,186.58 227.58,186.12 227.39,185.93 225.74,185.93
  L27_SIGNAL w0.091: 225.74,185.93 224.94,185.93 221.27,182.26 221.27,170.44 222.28,169.43 222.28,165.93 221.43,165.08 220.42,165.08 219.56,164.22 219.56,161.57 220.67,160.45 220.67,158.36 221.2,157.83 221.2,150.14 220.24,149.18 220.24,128.21 224.42,124.03 224.42,52.81 232.77,44.46 251.76,44.46 252.73,43.49 252.73,36.83 D124.09
D12410: length 208
  L25_SIGNAL w0.076: 265.74,185.93 267.39,185.93 267.58,186.12 267.58,186.58 v2(267.9,186.91)
  L25_SIGNAL w0.091: D124.10 252.73,41.91 233.17,41.91 226.19,48.89 226.19,125.22 229.16,128.19 252.54,128.19 260.24,135.89 260.24,149.89 261.2,150.85 261.2,157.7 260.67,158.24 260.67,160.46 259.56,161.57 259.56,164.22 260.42,165.08 261.43,165.08 262.28,165.93 262.28,169.43 261.27,170.44 261.27,182.26 264.94,185.93 265.74,185.93
D12411: length 186.1
  L31_SIGNAL w0.076: v2(307.9,186.91) 307.58,186.58 307.58,186.12 307.39,185.93 305.74,185.93
  L31_SIGNAL w0.091: 305.74,185.93 304.94,185.93 301.27,182.26 301.27,170.44 302.28,169.43 302.28,165.93 301.43,165.08 300.42,165.08 299.56,164.22 299.56,161.57 300.52,160.6 300.52,158.38 301.2,157.7 301.2,150.34 300.24,149.38 300.24,138.17 301.12,137.28 301.12,135.5 302.77,133.86 302.77,110.87 295.27,103.38 295.27,59.82 274.83,39.37 260.86,39.37 260.35,38.86 260.35,36.83 D124.11
D12412: length 199.3
  L19_SIGNAL w0.102: v3(307.84,117.04) 306.87,116.06 306.87,107.18 303.66,103.97 303.66,66.96 276.45,39.75 263.27,39.75 D124.12
  L29_SIGNAL w0.076: v2(347.9,186.91) 347.58,186.58 347.58,186.12 347.39,185.93 345.74,185.93
  L29_SIGNAL w0.091: v3(307.84,117.04) 308.05,117.04 311.28,120.27 311.28,122.94 311.91,123.57 312.55,123.57 316.74,127.76 320.32,127.76 325.91,133.35 326.26,133.35 340.24,147.32 340.24,149.72 341.2,150.68 341.2,157.79 340.53,158.46 340.53,160.59 339.56,161.57 339.56,164.22 340.42,165.08 341.43,165.08 342.28,165.93 342.28,169.43 341.27,170.44 341.27,182.26 344.94,185.93 345.74,185.93
D12413: length 189
  L27_SIGNAL w0.091: D124.13 262.94,36.78 262.94,46.18 262.13,46.99 232.87,46.99 224.84,55.02 224.84,124.15 220.62,128.37 220.62,149.02 221.58,149.98 221.58,157.97 221.04,158.51 221.04,160.72 219.92,161.84 219.92,163.81 220.68,164.57 221.45,164.57 222.64,165.77 222.64,169.79 221.64,170.8 221.64,176.96 222.51,177.83 222.51,180.51 225.1,183.11 226.06,183.11 v2(226.61,183.65)
D12414: length 214.9
  L25_SIGNAL w0.091: D124.14 265.48,39.32 265.48,43.56 264.59,44.45 232.79,44.45 226.69,50.55 226.69,124.71 229.71,127.73 254.37,127.73 260.62,133.99 260.62,149.74 261.58,150.7 261.58,157.85 261.08,158.34 261.08,160.68 259.92,161.84 259.92,163.81 260.68,164.57 261.45,164.57 262.64,165.77 262.64,169.79 261.64,170.8 261.64,176.96 262.51,177.83 262.51,180.51 265.1,183.11 266.06,183.11 v2(266.61,183.65)
D12415: length 173.2
  L31_SIGNAL w0.091: v2(306.6,183.65) 306.06,183.11 305.1,183.11 302.51,180.51 302.51,177.83 301.64,176.96 301.64,170.8 302.64,169.79 302.64,165.77 301.45,164.57 300.68,164.57 299.92,163.81 299.92,161.84 300.99,160.77 300.99,158.44 301.58,157.86 301.58,150.19 300.62,149.23 300.62,138.55 302.77,136.4 303.53,136.4 304.65,135.28 304.65,112.12 295.78,103.25 295.78,57.53 275.08,36.83 270.51,36.83 D124.15
D12416: length 187.2
  L19_SIGNAL w0.102: v3(312.16,122.76) 312.13,122.76 308.74,119.36 308.74,108.33 304.16,103.76 304.16,66.42 276.99,39.24 272.92,39.24 D124.16
  L29_SIGNAL w0.091: v3(312.16,122.76) 313,122.76 317.5,127.25 320.45,127.25 326.05,132.86 330.8,132.86 335.83,137.88 335.83,140.75 340.62,145.54 340.62,149.57 341.58,150.53 341.58,157.93 340.93,158.58 340.93,160.83 339.92,161.84 339.92,163.81 340.68,164.57 341.45,164.57 342.64,165.77 342.64,169.79 341.64,170.8 341.64,176.96 342.51,177.83 342.51,180.51 345.1,183.11 346.06,183.11 v2(346.6,183.65)
D12501: length 378.3
  L13_SIGNAL w0.091: D125.01 19.08,90.14 19.08,88.52 20.19,87.4 54.28,87.4 65.14,98.26 65.14,116.11 84.03,135 142.24,135 147.17,139.93 210.8,139.93 216.92,146.05 224.41,146.05 225.55,147.19 225.55,148.34 227.2,149.99 230.69,149.99 232.43,151.73 233.72,151.73 239.58,157.59 239.58,163.66 236.56,166.68 236.56,176.33 241.55,181.32 241.55,186.88 235.25,193.17 235.25,195.13 235.68,195.55 235.68,202.42 236.26,203.01 236.26,204.31 236.88,204.93 236.88,206.45 238.58,208.14 238.58,211.44 239.09,211.95 239.09,216.02 240.11,217.04 240.57,217.04 241.36,217.83 241.36,223.48 237.38,227.46 237.38,236.36 239.58,238.56 240.22,238.56 241.05,239.4 241.05,245.24 238.08,248.2 v2(235.71,248.2)
D12502: length 360.5
  L13_SIGNAL w0.091: v2(224,259) 222.38,257.38 222.38,254.89 221.11,253.62 221.11,236.33 221.37,236.07 221.37,231.86 220.36,230.85 220.36,227.71 218.13,225.48 218.13,211.33 211.02,204.22 211.02,198.07 210.7,197.74 210.7,195.79 209.05,194.14 209.05,174.29 210.63,172.71 210.63,156.5 204.26,150.13 132.17,150.13 127.48,154.81 84.33,154.81 55.73,126.21 55.73,106.91 53.77,104.95 21.13,104.95 D125.02
  L23_SIGNAL w0.091: v2(224,259) 223.27,258.27 223.27,246 224.28,244.98 225.04,244.98 225.3,244.73 225.73,244.73 v2(225.96,244.96)
D12503: length 369.5
  L13_SIGNAL w0.076: 235.8,246.58 234.08,246.58 v2(233.76,246.91)
  L13_SIGNAL w0.091: D125.03 24.1,90.2 24.1,88.62 24.84,87.88 54.17,87.88 64.72,98.43 64.72,116.28 85.73,137.29 90.73,137.29 92.84,139.4 146,139.4 146.99,140.39 210.62,140.39 217.93,147.7 224.4,147.7 225.3,148.6 225.3,149.22 227.69,151.61 231.01,151.61 231.8,152.4 233.04,152.4 238.83,158.18 238.83,163.22 234.57,167.47 234.57,176.63 239.4,181.46 239.4,187.93 234.52,192.81 234.52,195.81 234.93,196.22 234.93,202.84 235.42,203.33 235.42,214.1 237.48,216.16 238.03,216.16 240.11,218.24 240.22,218.24 240.49,218.52 240.49,223.67 236.54,227.62 236.54,236.67 237.8,237.92 237.8,239.2 239.27,240.67 239.27,244.09 236.79,246.58 235.8,246.58
D12504: length 346.1
  L13_SIGNAL w0.076: v2(233.11,247.56) 232.78,247.88 232.78,251.08
  L13_SIGNAL w0.091: 232.78,251.08 232.78,251.65 231.32,253.11 224.92,253.11 222.19,250.38 222.19,237.94 221.87,237.62 221.87,231.52 220.86,230.5 220.86,227.46 218.57,225.17 218.57,211.17 211.44,204.04 211.44,197.82 211.12,197.5 211.12,195.56 209.5,193.95 209.5,174.48 211.09,172.9 211.09,156.35 204.41,149.67 131.96,149.67 127.2,154.43 84.84,154.43 57.78,127.38 57.78,108.38 53.9,104.5 25.76,104.5 D125.04
D12505: length 357.3
  L13_SIGNAL w0.076: 236.07,243.33 234.73,243.33 v2(234.41,243)
  L13_SIGNAL w0.091: D125.05 29.6,89.78 53.9,89.78 64.3,100.18 64.3,116.45 85.77,137.92 90.68,137.92 93.34,140.59 126.36,140.59 127.33,141.56 211.18,141.56 217.7,148.08 223.96,148.08 224.41,148.53 224.41,149.1 227.46,152.15 230.89,152.15 232.66,153.92 233.88,153.92 238.45,158.49 238.45,163.01 234.14,167.31 234.14,177.57 238.92,182.35 238.92,187.88 235.34,191.47 234.65,191.47 233.41,192.71 233.41,195.54 234.55,196.68 234.55,203.05 235,203.5 235,215.39 236.22,216.61 237.87,216.61 239.4,218.14 239.4,224.17 236.11,227.46 236.11,238.22 238.75,240.86 238.75,241.44 236.86,243.33 236.07,243.33
D12506: length 343.3
  L13_SIGNAL w0.076: v2(232.46,248.85) 232.13,249.18 232.13,251.08
  L13_SIGNAL w0.091: D125.06 30.4,104.06 54.07,104.06 58.2,108.2 58.2,125.31 85.04,152.15 128.83,152.15 131.73,149.25 206.11,149.25 207.79,150.92 207.79,152.31 211.51,156.03 211.51,173.13 209.93,174.71 209.93,190.8 214.07,194.94 216.1,194.94 216.57,194.48 219.97,194.48 220.83,195.34 220.83,205.51 220.07,206.27 220.07,209 219.01,210.06 219.01,223.58 220.35,224.92 221.59,224.92 222.25,225.58 222.25,230.99 223.06,231.79 223.06,232.65 222.26,233.45 222.26,236.14 222.67,236.55 222.67,249.21 226.15,252.69 229.93,252.69 230.75,251.87 231.81,251.87 232.13,251.54 232.13,251.08
D12507: length 352.5
  L13_SIGNAL w0.076: 236.07,242.68 232.13,242.68 v2(231.81,243)
  L13_SIGNAL w0.091: 236.07,242.68 236.27,242.68
  L13_SIGNAL w0.508: D125.07 34.09,90.37 53.31,90.37 63.5,100.56 63.5,118.24 84.45,139.19 85.41,139.19 85.41,139.19 90.04,139.19 94.11,143.26 124.71,143.26 125.83,142.14 210.72,142.14 218.06,149.48 223.62,149.48 224.54,150.39 224.54,151.29 224.98,151.74 225.15,151.74 227.46,154.05 228.43,154.05 229.11,154.73 229.11,160.3 230,161.19 230,165.51 230.89,166.4 230.89,174.05 223.93,181.01 223.93,188.9 226.52,191.49 227.4,191.49 227.99,192.08 227.99,192.39 228.38,192.78 229.84,192.78 233.16,196.1 233.16,202.75 234.36,203.95 234.36,210.93 233.01,212.28 233.01,216.49 234.07,217.55 237.9,217.55 238.77,218.42 238.77,223.87 234.93,227.71 234.93,237.97 237.37,240.41 237.37,241.98 236.67,242.68 236.27,242.68
