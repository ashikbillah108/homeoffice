# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SA_RCBIT_19: length 347.6
  L36_UDB w0.203: v3(78.49,268.38) 85.18,268.38 96.72,256.84 120.4,256.84 124.33,252.91 124.33,209.02 137.39,195.96 137.39,180.29 155.45,162.23 220.35,162.23 UNK5K39.8 222.72,164.61 241.03,164.61 241.55,164.08 249.13,164.08 250.27,162.94 UNK6K39.8 262.72,164.61 281.03,164.61 281.55,164.08 289.13,164.08 290.27,162.94 UNK7K39.8 302.72,164.61 321.03,164.61 321.55,164.08 329.13,164.08 330.27,162.94 UNK8K39.8
  BOTTOM w0.203: U413.16 77.97,267.87 v3(78.49,268.38)
SA_RCBIT_20: length 386.5
  L36_UDB w0.203: UNK8K113.4 365.49,157.93 329.81,157.93 UNK7K113.4 326.36,161.38 319.62,161.38 318.99,160.75 318.99,158.75 318.2,157.96 289.78,157.96 UNK6K113.4 286.35,161.39 279.64,161.39 278.99,160.75 278.99,158.75 278.12,157.88 249.86,157.88 UNK5K113.4 246.36,161.38 239.62,161.38 238.99,160.75 238.99,158.75 238.08,157.83 155.6,157.83 136.45,176.99 136.45,195.78 122.2,210.03 122.2,252.22 118.28,256.15 96.25,256.15 85.09,267.31 78.29,267.31 v3(77.22,268.38)
  BOTTOM w0.203: U413.15 v3(77.22,268.38)
SA_RCBIT_21: length 619
  L31_SIGNAL w0.203: UNK6K4.8 104.74,168.07 107.68,171.01 107.68,178.2 106.3,179.58 106.3,186.64 UNK5K4.8 ; UNK7K4.8 470.5,168.07 473.33,170.9 473.33,178.31 472.06,179.58 472.06,186.64 UNK8K4.8
  L36_UDB w0.203: v3(75.95,268.38) 75.95,194.77 84.45,186.26 102.8,186.26 UNK5K4.8 ; UNK6K4.8 106.3,154.89 106.3,148.95 131.83,123.42 427.28,123.42 445.64,141.78 445.64,188.52 449.96,192.84 467.96,192.84 470.5,190.3 UNK8K4.8
  BOTTOM w0.203: U413.14 76.57,267.76 v3(75.95,268.38)
SA_RCBIT_22: length 610.9
  L31_SIGNAL w0.203: UNK6K5.8 97.31,157.52 97.31,176.95 99.99,179.63 99.99,186.6 UNK5K5.8 ; UNK7K5.8 462.79,157.81 462.79,173.61 465.75,176.57 465.75,186.6 UNK8K5.8
  L36_UDB w0.203: UNK6K5.8 99.97,154.87 99.97,136.96 116.54,120.4 425.12,120.4 446.28,141.55 446.28,187.41 449.72,190.85 461.49,190.85 UNK8K5.8 ; UNK5K5.8 97.09,186.89 84.71,186.89 79.17,192.43 79.17,252.12 85.65,258.6 v3(85.65,260.4)
  BOTTOM w0.203: v3(85.65,260.4) 86.17,260.92 U415.16
SA_RCBIT_23: length 594.8
  L31_SIGNAL w0.203: UNK8K7.8 453.03,186.62 453.03,179.26 452.19,178.42 452.19,157.18 UNK7K7.8 ; UNK5K7.8 87.27,186.62 87.27,179.26 86.43,178.42 86.43,157.18 UNK6K7.8
  L36_UDB w0.203: UNK5K7.8 85.69,191.75 81.15,196.29 81.15,252.55 86.92,258.32 v3(86.92,260.4) ; UNK6K7.8 87.29,154.84 87.29,147.88 91.69,143.49 91.69,123.5 95.94,119.25 425.63,119.25 447.55,141.17 447.55,184.3 UNK8K7.8
  BOTTOM w0.203: v3(86.92,260.4) U415.15
SA_RCBIT_24: length 600.8
  L31_SIGNAL w0.203: UNK6K6.8 93.63,158.04 93.63,186.61 UNK5K6.8 ; UNK7K6.8 459.39,158.04 459.39,186.61 UNK8K6.8
  L36_UDB w0.203: UNK8K6.8 456.17,189.83 450.26,189.83 446.91,186.48 446.91,141.35 425.4,119.84 99.87,119.84 93.57,126.14 93.57,154.91 UNK6K6.8 ; UNK5K6.8 92.04,190.18 81.86,200.36 81.86,250.67 88.19,257 v3(88.19,260.4)
  BOTTOM w0.203: v3(88.19,260.4) 87.57,261.02 U415.14
SA_RCBIT_25: length 577.6
  L31_SIGNAL w0.203: UNK7K2.8 484.87,158.12 484.87,186.53 UNK8K2.8 ; UNK5K2.8 119.11,186.53 119.11,158.12 UNK6K2.8
  L36_UDB w0.203: UNK6K2.8 119.02,154.87 119.02,147.83 142.37,124.49 426.72,124.49 444.37,142.14 444.37,191.33 451.64,198.59 474.83,198.59 483.2,190.23 UNK8K2.8 ; v3(498.32,211.48) 497.61,210.78 497.61,172.39 483.2,157.98 UNK7K2.8
  BOTTOM w0.203: v3(498.32,211.48) 497.8,210.97 497.8,209.79 U453.16
SA_RCBIT_26: length 580.5
  L31_SIGNAL w0.203: UNK7K3.8 477.7,157.3 477.7,164.66 476.35,166.01 476.35,176.51 478.51,178.66 478.51,186.54 UNK8K3.8 ; UNK5K3.8 112.75,186.54 112.75,172.19 110.59,170.03 110.59,160.78 111.94,159.43 111.94,157.3 UNK6K3.8
  L36_UDB w0.203: v3(497.05,211.48) 495.2,209.63 495.2,174.8 UNK7K3.8 ; UNK8K3.8 476.85,190.22 469.35,197.72 452.38,197.72 445.01,190.35 445.01,141.96 427,123.95 139.19,123.95 122.18,140.97 120.39,140.97 112.69,148.67 112.69,154.85 UNK6K3.8
  BOTTOM w0.203: v3(497.05,211.48) 497.05,209.79 U453.15
SA_SCBIT_01: length 359
  L36_UDB w0.203: v2(228.01,233.28) 228.32,233.58 237.87,233.58 240.04,235.75 248.88,235.75 250.81,233.82 253.76,233.82 255.65,235.71 260.31,235.71 261.08,234.94 261.08,232.67 261.95,231.8 263.97,231.8 265.45,233.28 v2(268.01,233.28) 268.32,233.58 277.87,233.58 280.04,235.75 288.88,235.75 290.81,233.82 294.26,233.82 294.86,234.42 296.19,234.42 297.31,235.53 300.49,235.53 301.08,234.94 301.08,232.67 301.95,231.8 303.97,231.8 305.45,233.28 v2(308.01,233.28) 308.32,233.58 317.87,233.58 320.04,235.75 328.88,235.75 330.81,233.82 334.14,233.82 334.74,234.42 336.19,234.42 337.31,235.53 340.49,235.53 341.08,234.94 341.08,232.67 341.95,231.8 343.97,231.8 345.45,233.28 v2(348.01,233.28) 348.32,233.58 357.87,233.58 360.04,235.75 369.71,235.75 371.42,237.46 397.64,237.46 399.24,235.86 412.29,235.86 443.72,267.29 503.48,267.29 534.25,236.52 v3(535.97,236.52)
  BOTTOM w0.203: U70.18 539.39,236.63 538.8,237.22 536.95,237.22 536.25,236.52 v3(535.97,236.52)
SA_SCBIT_02: length 348.1
  L36_UDB w0.203: v3(535.97,235.13) 534.77,235.13 503.23,266.67 450.32,266.67 433.35,249.7 433.35,230.41 415.77,212.83 371.42,212.83 370.56,211.96 364.04,211.96 v2(363.45,211.37) 361.88,212.94 329.41,212.94 328.43,211.96 324.04,211.96 v2(323.45,211.37) 321.88,212.94 289.41,212.94 288.43,211.96 284.04,211.96 v2(283.45,211.37) 281.88,212.94 249.41,212.94 248.43,211.96 244.04,211.96 v2(243.45,211.37)
  BOTTOM w0.203: v3(535.97,235.13) 536.25,235.13 536.95,235.83 538.7,235.83 538.9,235.63 U70.16
SA_SCBIT_03: length 371
  L36_UDB w0.203: v3(535.97,233.73) 535.05,233.73 502.67,266.12 450.55,266.12 433.91,249.47 433.91,228.9 415.67,210.67 365.97,210.67 364.21,208.9 361.87,208.9 361.11,209.66 356.8,209.66 356.08,210.38 351.17,210.38 v2(349.23,208.44) 347.64,210.03 346.74,210.03 346.1,210.67 325.97,210.67 324.21,208.9 321.87,208.9 321.11,209.66 316.8,209.66 316.08,210.38 311.17,210.38 v2(309.23,208.44) 307.64,210.03 306.74,210.03 306.1,210.67 285.97,210.67 284.21,208.9 281.87,208.9 281.11,209.66 276.8,209.66 276.08,210.38 271.17,210.38 v2(269.23,208.44) 267.64,210.03 266.74,210.03 266.1,210.67 245.97,210.67 244.21,208.9 241.87,208.9 241.11,209.66 236.8,209.66 236.08,210.38 231.17,210.38 v2(229.23,208.44)
  BOTTOM w0.203: U70.14 538.9,234.63 538.7,234.43 536.95,234.43 536.25,233.73 v3(535.97,233.73)
SA_SCBIT_04: length 361.5
  L36_UDB w0.203: v2(236.37,207.56) 236.97,208.16 261.04,208.16 262.67,206.53 268.31,206.53 270.71,208.93 275.01,208.93 v2(276.37,207.56) 276.97,208.16 301.04,208.16 302.67,206.53 308.31,206.53 310.71,208.93 315.01,208.93 v2(316.37,207.56) 316.97,208.16 341.04,208.16 342.67,206.53 348.31,206.53 350.71,208.93 355.01,208.93 v2(356.37,207.56) 356.97,208.16 369.7,208.16 370,208.46 415.57,208.46 434.48,227.36 434.48,249.23 449.93,264.68 501.18,264.68 533.53,232.33 v3(535.97,232.33)
  BOTTOM w0.203: v3(535.97,232.33) 536.25,232.33 536.95,233.03 538.8,233.03 539.39,233.63 U70.12
SA_SCBIT_05: length 374.3
  L36_UDB w0.203: v2(223.24,233.14) 224.3,233.14 225.34,234.18 234.33,234.18 235.14,234.99 238.27,234.99 239.65,236.37 250.09,236.37 252.08,234.38 253.43,234.38 255.48,236.43 260.6,236.43 261.73,235.29 261.73,234.22 262.81,233.14 v2(263.24,233.14) 264.3,233.14 265.34,234.18 274.33,234.18 275.14,234.99 278.27,234.99 279.65,236.37 290.09,236.37 292.08,234.38 293.88,234.38 295.93,236.43 300.6,236.43 301.73,235.29 301.73,234.22 302.81,233.14 v2(303.24,233.14) 304.3,233.14 305.34,234.18 314.33,234.18 315.14,234.99 318.27,234.99 319.65,236.37 330.09,236.37 332.08,234.38 333.88,234.38 335.93,236.43 340.6,236.43 341.73,235.29 341.73,234.22 342.81,233.14 v2(343.24,233.14) 344.3,233.14 345.34,234.18 354.33,234.18 355.14,234.99 358.27,234.99 359.65,236.37 369.45,236.37 371.17,238.09 397.9,238.09 399.5,236.49 410.48,236.49 442.65,268.66 519.81,268.66 546.58,241.88 v3(546.58,237.72)
  BOTTOM w0.203: U70.3 543.48,236.63 543.88,237.02 545.61,237.02 546.31,237.72 v3(546.58,237.72)
SA_SCBIT_06: length 379.8
  L36_UDB w0.203: v3(546.58,236.33) 548.03,237.77 548.03,241.26 520.05,269.24 440.86,269.24 410.39,238.76 370.84,238.76 369.82,237.74 358.9,237.74 356.82,235.66 354.97,235.66 354.18,234.87 348.98,234.87 348.07,235.78 345.63,235.78 343.91,234.06 v2(343.24,234.06) 342.78,234.06 342.31,234.52 342.31,235.49 340.2,237.6 339.21,237.6 338.72,237.12 335.76,237.12 334.25,235.61 331.85,235.61 329.72,237.74 318.9,237.74 316.82,235.66 314.97,235.66 314.18,234.87 308.98,234.87 308.07,235.78 305.63,235.78 303.91,234.06 v2(303.24,234.06) 302.78,234.06 302.31,234.52 302.31,235.49 300.2,237.6 299.21,237.6 298.72,237.12 295.76,237.12 294.25,235.61 291.85,235.61 289.72,237.74 278.9,237.74 276.82,235.66 274.97,235.66 274.18,234.87 268.98,234.87 268.07,235.78 265.63,235.78 263.91,234.06 v2(263.24,234.06) 262.78,234.06 262.31,234.52 262.31,235.49 260.2,237.6 259.21,237.6 258.72,237.12 255.4,237.12 253.9,235.61 251.85,235.61 249.72,237.74 238.9,237.74 236.82,235.66 234.97,235.66 234.18,234.87 228.98,234.87 228.07,235.78 225.63,235.78 223.91,234.06 v2(223.24,234.06)
  BOTTOM w0.203: U70.5 545.61,235.63 546.31,236.33 v3(546.58,236.33)
SA_SCBIT_07: length 382.8
  TOP w0.203: UNK4R662.2 v2(335.82,241.23) ; R662.2 v2(215.82,241.23) ; UNK2R662.2 v2(255.82,241.23) ; UNK3R662.2 v2(295.82,241.23)
  L36_UDB w0.203: v3(546.58,234.93) 548.61,236.96 548.61,241.59 520.32,269.88 438.77,269.88 410.62,241.74 359.78,241.74 356.04,238 346.01,238 344.4,239.61 340.25,239.61 338.63,241.23 v2(335.82,241.23) 335.31,241.74 319.78,241.74 316.04,238 306.01,238 304.4,239.61 300.25,239.61 298.63,241.23 v2(295.82,241.23) 295.31,241.74 279.78,241.74 276.04,238 266.01,238 264.4,239.61 260.25,239.61 258.63,241.23 v2(255.82,241.23) 255.31,241.74 239.78,241.74 236.04,238 226.01,238 224.4,239.61 220.25,239.61 218.63,241.23 v2(215.82,241.23)
  BOTTOM w0.203: U70.7 543.48,234.63 543.88,234.23 545.61,234.23 546.31,234.93 v3(546.58,234.93)
SA_SCBIT_08: length 374.1
  TOP w0.203: UNK3R172.2 v2(295.82,252.79) ; UNK4R172.2 v2(335.82,252.79) ; R172.2 v2(215.82,252.79) ; UNK2R172.2 v2(255.82,252.79)
  L36_UDB w0.203: v2(215.82,252.79) 218.96,252.79 219.3,252.46 224.52,252.46 225.46,253.4 231.5,253.4 232.21,252.69 248.92,252.69 249.39,253.16 255.45,253.16 v2(255.82,252.79) 258.96,252.79 259.3,252.46 264.14,252.46 265.08,253.4 271.5,253.4 272.21,252.69 288.92,252.69 289.39,253.16 295.45,253.16 v2(295.82,252.79) 298.96,252.79 299.3,252.46 304.53,252.46 305.47,253.4 311.5,253.4 312.21,252.69 328.92,252.69 329.39,253.16 335.45,253.16 v2(335.82,252.79) 338.96,252.79 339.3,252.46 344.15,252.46 345.09,253.4 351.5,253.4 352.21,252.69 370.17,252.69 371.2,253.72 419.91,253.72 437.39,271.2 519.86,271.2 549.2,241.86 549.2,236.15 v3(546.58,233.53)
  BOTTOM w0.203: U70.9 542.9,233.63 543.7,232.83 545.61,232.83 546.31,233.53 v3(546.58,233.53)
SA_SCBIT_09: length 363.8
  L36_UDB w0.203: v3(535.97,223.57) 535.97,227.92 499.79,264.11 450.16,264.11 435.05,249 435.05,227.13 415.67,207.75 370.74,207.75 369.47,206.48 363.72,206.48 v2(362.64,207.56) 361.48,206.41 357.92,206.41 355.29,203.78 345.19,203.78 343.48,205.5 340.89,205.5 339.91,206.48 323.72,206.48 v2(322.64,207.56) 321.48,206.41 317.92,206.41 315.29,203.78 305.19,203.78 303.48,205.5 300.89,205.5 299.91,206.48 283.72,206.48 v2(282.64,207.56) 281.48,206.41 277.92,206.41 275.29,203.78 265.19,203.78 263.48,205.5 260.89,205.5 259.91,206.48 243.72,206.48 v2(242.64,207.56)
  BOTTOM w0.203: v3(535.97,223.57) 536.25,223.57 536.95,224.27 538.8,224.27 539.39,223.67 U403.18
SA_SCBIT_10: length 402.6
  TOP w0.203: UNK7R172.2 v2(295.82,192.79) ; UNK6R172.2 v2(255.82,192.79) ; UNK5R172.2 v2(215.82,192.79) ; UNK8R172.2 v2(335.82,192.79)
  L36_UDB w0.203: v2(215.82,192.79) 218.96,192.79 219.3,192.46 224.55,192.46 225.5,193.4 231.5,193.4 232.21,192.69 248.92,192.69 249.39,193.16 255.45,193.16 v2(255.82,192.79) 258.96,192.79 259.3,192.46 264.48,192.46 265.42,193.4 271.5,193.4 272.21,192.69 288.92,192.69 289.39,193.16 295.45,193.16 v2(295.82,192.79) 298.96,192.79 299.3,192.46 303.99,192.46 304.93,193.4 311.5,193.4 312.21,192.69 328.92,192.69 329.39,193.16 335.45,193.16 v2(335.82,192.79) 338.96,192.79 339.3,192.46 345.03,192.46 345.97,193.4 351.5,193.4 352.21,192.69 369.22,192.69 371.83,195.3 419.79,195.3 435.69,211.2 435.69,248.79 450.47,263.58 499.57,263.58 533.93,229.21 533.93,224.21 v3(535.97,222.17)
  BOTTOM w0.203: v3(535.97,222.17) 536.25,222.17 536.95,222.87 538.7,222.87 538.9,222.67 U403.16
SA_SCBIT_11: length 424.6
  TOP w0.203: UNK8R662.2 v2(335.82,181.23) ; UNK6R662.2 v2(255.82,181.23) ; UNK5R662.2 v2(215.82,181.23) ; UNK7R662.2 v2(295.82,181.23)
  L36_UDB w0.203: v2(215.82,181.23) 218.63,181.23 220.25,179.61 224.4,179.61 226.01,178 236.04,178 239.78,181.74 255.31,181.74 v2(255.82,181.23) 258.63,181.23 260.25,179.61 264.4,179.61 266.01,178 276.04,178 279.78,181.74 295.31,181.74 v2(295.82,181.23) 298.63,181.23 300.25,179.61 304.4,179.61 306.01,178 316.04,178 319.78,181.74 335.31,181.74 v2(335.82,181.23) 338.63,181.23 340.25,179.61 344.4,179.61 346.01,178 356.04,178 358.55,180.51 372.65,180.51 375.07,182.93 426.57,182.93 436.27,192.63 436.27,248.41 450.08,262.22 498.67,262.22 533.12,227.76 533.12,223.63 v3(535.97,220.78)
  BOTTOM w0.203: v3(535.97,220.78) 536.25,220.78 536.95,221.47 538.7,221.47 538.9,221.67 U403.14
SA_SCBIT_12: length 425.3
  L36_UDB w0.203: v2(223.24,174.06) 223.91,174.06 225.63,175.78 228.07,175.78 228.98,174.87 234.18,174.87 234.97,175.66 236.82,175.66 238.9,177.74 249.72,177.74 251.85,175.61 254.26,175.61 255.76,177.12 258.72,177.12 259.21,177.6 260.2,177.6 262.31,175.49 262.31,174.52 262.78,174.06 v2(263.24,174.06) 263.91,174.06 265.63,175.78 268.07,175.78 268.98,174.87 274.18,174.87 274.97,175.66 276.82,175.66 278.9,177.74 289.72,177.74 291.85,175.61 294.25,175.61 295.76,177.12 298.72,177.12 299.21,177.6 300.2,177.6 302.31,175.49 302.31,174.52 302.78,174.06 v2(303.24,174.06) 303.91,174.06 305.63,175.78 308.07,175.78 308.98,174.87 314.18,174.87 314.97,175.66 316.82,175.66 318.9,177.74 329.72,177.74 331.85,175.61 334.25,175.61 335.76,177.12 338.72,177.12 339.21,177.6 340.2,177.6 342.31,175.49 342.31,174.52 342.78,174.06 v2(343.24,174.06) 343.91,174.06 345.63,175.78 348.07,175.78 348.98,174.87 354.18,174.87 354.97,175.66 356.82,175.66 359.35,178.19 372.4,178.19 376.5,182.3 426.82,182.3 436.88,192.35 436.88,248.16 450.33,261.61 498.41,261.61 531.39,228.63 531.39,223.96 v3(535.97,219.38)
  BOTTOM w0.203: U403.12 539.39,220.67 538.8,220.08 536.95,220.08 536.25,219.38 v3(535.97,219.38)
SA_SCBIT_13: length 356.4
  L36_UDB w0.203: v2(242.64,267.56) 243.72,266.48 259.91,266.48 260.89,265.5 263.48,265.5 265.19,263.78 275.29,263.78 277.92,266.41 281.48,266.41 v2(282.64,267.56) 283.72,266.48 299.91,266.48 300.89,265.5 303.48,265.5 305.19,263.78 315.29,263.78 317.92,266.41 321.48,266.41 v2(322.64,267.56) 323.72,266.48 339.91,266.48 340.89,265.5 343.48,265.5 345.19,263.78 355.29,263.78 357.92,266.41 361.48,266.41 v2(362.64,267.56) 363.6,266.6 426.42,266.6 431.64,271.82 521.75,271.82 550.52,243.05 550.52,229.57 546.58,225.63 v3(546.58,224.77)
  BOTTOM w0.203: v3(546.58,224.77) 546.31,224.77 545.61,224.07 543.88,224.07 543.48,223.67 U403.3
SA_SCBIT_14: length 363.9
  L36_UDB w0.203: v3(546.58,223.37) 547.53,223.37 551.08,226.92 551.08,243.31 521.99,272.4 431.4,272.4 426.19,267.18 369.52,267.18 368.54,268.16 356.97,268.16 v2(356.37,267.56) 355.01,268.93 350.71,268.93 348.31,266.53 342.67,266.53 341.04,268.16 316.97,268.16 v2(316.37,267.56) 315.01,268.93 310.71,268.93 308.31,266.53 302.67,266.53 301.04,268.16 276.97,268.16 v2(276.37,267.56) 275.01,268.93 270.71,268.93 268.31,266.53 262.67,266.53 261.04,268.16 236.97,268.16 v2(236.37,267.56)
  BOTTOM w0.203: U403.5 545.61,222.67 546.31,223.37 v3(546.58,223.37)
SA_SCBIT_15: length 379.1
  L36_UDB w0.203: v2(229.23,268.44) 231.17,270.38 236.08,270.38 236.8,269.66 241.11,269.66 241.87,268.9 244.21,268.9 245.97,270.67 266.1,270.67 266.74,270.03 267.64,270.03 v2(269.23,268.44) 271.17,270.38 276.08,270.38 276.8,269.66 281.11,269.66 281.87,268.9 284.21,268.9 285.97,270.67 306.1,270.67 306.74,270.03 307.64,270.03 v2(309.23,268.44) 311.17,270.38 316.08,270.38 316.8,269.66 321.11,269.66 321.87,268.9 324.21,268.9 325.97,270.67 346.1,270.67 346.74,270.03 347.64,270.03 v2(349.23,268.44) 351.17,270.38 356.08,270.38 356.8,269.66 361.11,269.66 361.87,268.9 364.21,268.9 365.97,270.67 367.99,270.67 370,268.66 426.01,268.66 431.34,273.99 464.08,273.99 465,273.08 467.16,273.08 468,273.91 521.41,273.91 551.61,243.71 551.61,226.16 547.43,221.97 v3(546.58,221.97)
  BOTTOM w0.203: U403.7 543.48,221.67 543.88,221.28 545.61,221.28 546.31,221.97 v3(546.58,221.97)
SA_SCBIT_16: length 361.3
  L36_UDB w0.203: v2(243.45,271.37) 244.04,271.96 248.43,271.96 249.41,272.94 281.88,272.94 v2(283.45,271.37) 284.04,271.96 288.43,271.96 289.41,272.94 321.88,272.94 v2(323.45,271.37) 324.04,271.96 328.43,271.96 329.41,272.94 361.88,272.94 v2(363.45,271.37) 364.04,271.96 367.81,271.96 370.48,269.29 425.83,269.29 431.1,274.56 464.32,274.56 465.24,273.65 466.92,273.65 467.76,274.49 521.65,274.49 553.11,243.03 553.11,226.42 547.27,220.58 v3(546.58,220.58)
  BOTTOM w0.203: v3(546.58,220.58) 546.31,220.58 545.61,219.88 543.7,219.88 542.9,220.67 U403.9
SA_SCBIT_17: length 429.8
  L36_UDB w0.203: v2(223.24,173.14) 224.3,173.14 225.34,174.18 234.33,174.18 235.14,174.99 238.27,174.99 239.65,176.37 250.09,176.37 252.08,174.38 253.88,174.38 255.93,176.43 260.6,176.43 261.73,175.29 261.73,174.22 262.81,173.14 v2(263.24,173.14) 264.3,173.14 265.34,174.18 274.33,174.18 275.14,174.99 278.27,174.99 279.65,176.37 290.09,176.37 292.08,174.38 293.88,174.38 295.93,176.43 300.6,176.43 301.73,175.29 301.73,174.22 302.81,173.14 v2(303.24,173.14) 304.3,173.14 305.34,174.18 314.33,174.18 315.14,174.99 318.27,174.99 319.65,176.37 330.09,176.37 332.08,174.38 333.88,174.38 335.93,176.43 340.6,176.43 341.73,175.29 341.73,174.22 342.81,173.14 v2(343.24,173.14) 344.3,173.14 345.34,174.18 354.33,174.18 355.14,174.99 358.27,174.99 359.65,176.37 369.14,176.37 370.04,177.27 374.4,177.27 377.82,180.68 426.16,180.68 437.53,192.05 437.53,247.89 450.6,260.96 498.14,260.96 530.66,228.45 530.66,217.47 535.59,212.54 v3(535.59,210.24)
  BOTTOM w0.203: U434.18 539.01,210.34 538.42,210.93 536.57,210.93 535.87,210.24 v3(535.59,210.24)
SA_SCBIT_18: length 426
  L36_UDB w0.203: v3(535.59,208.84) 528.95,215.48 528.95,226.27 495.51,259.71 450.23,259.71 438.15,247.63 438.15,191.8 426.42,180.06 379.06,180.06 374.65,175.65 359.94,175.65 357.87,173.58 348.32,173.58 v2(348.01,173.28) 345.45,173.28 343.97,171.8 341.95,171.8 341.08,172.67 341.08,174.94 340.49,175.53 337.31,175.53 336.2,174.42 334.84,174.42 334.24,173.82 330.81,173.82 328.88,175.75 320.04,175.75 317.87,173.58 308.32,173.58 v2(308.01,173.28) 305.45,173.28 303.97,171.8 301.95,171.8 301.08,172.67 301.08,174.94 300.49,175.53 297.31,175.53 296.2,174.42 294.84,174.42 294.24,173.82 290.81,173.82 288.88,175.75 280.04,175.75 277.87,173.58 268.32,173.58 v2(268.01,173.28) 265.45,173.28 263.97,171.8 261.95,171.8 261.08,172.67 261.08,174.94 260.49,175.53 257.31,175.53 256.2,174.42 254.84,174.42 254.24,173.82 250.81,173.82 248.88,175.75 240.04,175.75 237.87,173.58 228.32,173.58 v2(228.01,173.28)
  BOTTOM w0.203: U434.16 538.51,209.34 538.32,209.54 536.57,209.54 535.87,208.84 v3(535.59,208.84)
SA_SCBIT_19: length 429
  L36_UDB w0.203: v3(535.59,207.44) 528.32,214.71 528.32,226.01 495.25,259.08 450.5,259.08 438.78,247.37 438.78,173.41 413.29,147.91 363.46,147.91 362.58,148.78 358.67,148.78 357.8,147.91 v3(354.44,147.91) 353.05,149.29 346.09,149.29 344.7,147.91 323.71,147.91 322.93,148.69 319.18,148.69 318.4,147.91 v3(314.44,147.91) 313.05,149.29 306.09,149.29 304.7,147.91 283.54,147.91 282.8,148.65 279.22,148.65 278.49,147.91 v3(274.44,147.91) 273.05,149.29 266.09,149.29 264.7,147.91 243.93,147.91 243.24,148.6 235.12,148.6 v3(234.44,147.91)
  BOTTOM w0.203: U434.14 538.51,208.34 538.32,208.14 536.57,208.14 535.87,207.44 v3(535.59,207.44)
SA_SCBIT_20: length 437.9
  L36_UDB w0.203: v3(535.59,206.04) 534.59,206.04 527.71,212.93 527.71,225.76 495,258.47 450.75,258.47 439.39,247.12 439.39,171.45 413.32,145.37 v3(354.44,145.37) 352.32,147.49 347.79,147.49 345.66,145.37 v3(314.44,145.37) 312.32,147.49 307.79,147.49 305.66,145.37 v3(274.44,145.37) 272.32,147.49 267.79,147.49 265.66,145.37 v3(234.44,145.37)
  BOTTOM w0.203: U434.12 539.01,207.34 538.42,206.74 536.57,206.74 535.87,206.04 v3(535.59,206.04)
  BOTTOM w0.508: UNK8MR12.2 v3(354.44,145.37) ; UNK7MR12.2 v3(314.44,145.37) ; UNK6MR12.2 v3(274.44,145.37) ; UNK5MR12.2 v3(234.44,145.37)
SA_SCBIT_21: length 391.7
  L36_UDB w0.203: v3(227.22,281.35) 227.93,280.65 232.01,280.65 234.36,283 262.57,283 264.22,281.35 v3(267.22,281.35) 267.93,280.65 270.96,280.65 273.32,283 302.57,283 304.22,281.35 v3(307.22,281.35) 307.92,280.65 310.96,280.65 313.32,283 342.57,283 344.22,281.35 v3(347.22,281.35) 347.92,280.65 350.96,280.65 353.32,283 370.81,283 371.96,284.15 514.6,284.15 553.72,245.03 553.72,218.95 v3(546.2,211.43)
  BOTTOM w0.203: v3(546.2,211.43) 545.93,211.43 545.23,210.74 543.5,210.74 543.1,210.34 U434.3
SA_SCBIT_22: length 395.9
  L36_UDB w0.203: v3(546.2,210.04) 554.33,218.16 554.33,245.24 514.71,284.85 350.76,284.85 349.8,283.89 v3(347.22,283.89) 346.26,284.85 310.76,284.85 309.8,283.89 v3(307.22,283.89) 306.26,284.85 270.76,284.85 269.8,283.89 v3(267.22,283.89) 266.26,284.85 230.76,284.85 229.8,283.89 v3(227.22,283.89)
  BOTTOM w0.203: U434.5 545.23,209.34 545.93,210.04 v3(546.2,210.04)
  BOTTOM w0.508: MR12.2 v3(227.22,283.89) ; UNK4MR12.2 v3(347.22,283.89) ; UNK3MR12.2 v3(307.22,283.89) ; UNK2MR12.2 v3(267.22,283.89)
SA_SCBIT_23: length 410.2
  L36_UDB w0.203: v3(546.2,208.64) 547.68,208.64 555.65,216.61 555.65,244.73 513.84,286.54 359.9,286.54 356.13,290.31 352.21,290.31 348.46,286.56 v3(347.22,286.56) 342.53,286.56 340.11,288.98 318.17,288.98 316.84,290.31 312.21,290.31 308.46,286.56 v3(307.22,286.56) 302.53,286.56 300.11,288.98 278.17,288.98 276.84,290.31 272.21,290.31 268.46,286.56 v3(267.22,286.56) 262.53,286.56 260.11,288.98 238.17,288.98 236.84,290.31 232.21,290.31 228.46,286.56 v3(227.22,286.56)
  BOTTOM w0.203: U434.7 543.1,208.34 543.5,207.94 545.23,207.94 545.93,208.64 v3(546.2,208.64)
  BOTTOM w0.508: MR17.2 v3(227.22,286.56) ; UNK4MR17.2 v3(347.22,286.56) ; UNK2MR17.2 v3(267.22,286.56) ; UNK3MR17.2 v3(307.22,286.56)
SA_SCBIT_24: length 411.7
  L36_UDB w0.203: v3(227.22,289.22) 229.69,291.69 231.91,291.69 232.58,292.36 236.45,292.36 237.93,290.88 261.73,290.88 263.38,289.22 v3(267.22,289.22) 269.69,291.69 271.91,291.69 272.58,292.36 276.45,292.36 277.93,290.88 301.73,290.88 303.38,289.22 v3(307.22,289.22) 309.69,291.69 311.91,291.69 312.58,292.36 316.45,292.36 317.93,290.88 341.73,290.88 343.38,289.22 v3(347.22,289.22) 349.69,291.69 351.91,291.69 352.58,292.36 356.45,292.36 361.71,287.1 514.07,287.1 556.21,244.96 556.21,215.82 547.63,207.24 v3(546.2,207.24)
  BOTTOM w0.203: v3(546.2,207.24) 545.93,207.24 545.23,206.54 543.31,206.54 542.52,207.34 U434.9
  BOTTOM w0.508: UNK2MR15.2 v3(267.22,289.22) ; UNK3MR15.2 v3(307.22,289.22) ; MR15.2 v3(227.22,289.22) ; UNK4MR15.2 v3(347.22,289.22)
SA_SCBIT_25: length 442.8
  L36_UDB w0.203: v3(234.44,142.7) 235.46,143.72 266.49,143.72 267.36,144.6 272.54,144.6 v3(274.44,142.7) 275.46,143.72 306.49,143.72 307.36,144.6 312.54,144.6 v3(314.44,142.7) 315.46,143.72 346.49,143.72 347.36,144.6 352.54,144.6 v3(354.44,142.7) 355.34,143.61 370.31,143.61 371.27,144.58 415.21,144.58 439.98,169.34 439.98,246.88 450.1,257 492.45,257 526.08,223.36 526.08,212.62 538.13,200.58 v3(538.13,196.84)
  BOTTOM w0.203: U435.18 538.73,196.24 v3(538.13,196.84)
  BOTTOM w0.508: UNK5MR17.2 v3(234.44,142.7) ; UNK7MR17.2 v3(314.44,142.7) ; UNK8MR17.2 v3(354.44,142.7) ; UNK6MR17.2 v3(274.44,142.7)
SA_SCBIT_26: length 448
  L36_UDB w0.203: v3(538.13,195.44) 525.55,208.02 525.55,223.14 492.23,256.46 450.32,256.46 440.51,246.65 440.51,167.36 414.93,141.78 362.97,141.78 361.22,140.04 v3(354.44,140.04) 353.14,140.04 350.13,137.02 346.67,137.02 344.75,138.95 315.53,138.95 v3(314.44,140.04) 313.14,140.04 310.13,137.02 306.68,137.02 304.77,138.93 275.54,138.93 v3(274.44,140.04) 273.14,140.04 270.13,137.02 266.68,137.02 264.75,138.95 235.52,138.95 v3(234.44,140.04)
  BOTTOM w0.203: U435.16 538.33,195.24 v3(538.13,195.44)
  BOTTOM w0.508: UNK8MR15.2 v3(354.44,140.04) ; UNK6MR15.2 v3(274.44,140.04) ; UNK5MR15.2 v3(234.44,140.04) ; UNK7MR15.2 v3(314.44,140.04)
UBIT_3V3_UP:
  vias: v3(523.99,153.29) v3(543.09,213.97) v3(543.09,199.88) v3(543.47,240.26) v3(543.47,227.31)
UDBGND: length 11.2
  BOTTOM w0.508: UB1.1 v3(219.96,17.59) ; CB13.2 v3(22.84,133.35) ; CB9.2 v3(166.1,133.35) ; CB7.2 v3(422.91,290.83) ; UB1.3 v3(219.96,14.86) ; CB11.2 v3(156.21,290.83) ; CB1.2 v3(418.06,133.35) ; UB1.7 v3(214.73,16.13) ; UB1.4 v3(219.96,13.4) ; UB1.2 v3(219.96,16.13) ; CB15.2 v3(20.34,295.91) ; CB3.2 v3(561.32,133.35) ; CB5.2 v3(558.82,295.91)
  vias: v3(20.34,298.45) v3(22.84,130.81) v3(27.67,298.45) v3(27.67,130.81) v3(40.01,298.45) v3(110.49,300.99) v3(128.27,130.81) v3(156.21,293.37) v3(156.98,288.29) v3(166.1,130.81) v3(170.68,130.81) v3(212.48,17.59) v3(411.98,130.81) v3(418.06,130.81) v3(422.91,293.37) v3(424.68,288.29) v3(453.39,298.45) v3(453.39,130.81) v3(554.99,298.45) v3(554.99,130.81) v3(558.82,298.45) v3(561.32,130.81)
UT1_UP5V: length 234.7
  TOP w0.305: U15.8 CD2.2 v3(466.36,278.38) ; RD9.1 v3(456,278.37) RD10.1 ; v3(296.92,296.6) CD1.2 U14.8 ; RD15.1 455.63,274.87 v3(455.63,273.15) ; RD1.1 v3(286.56,296.6) RD2.1
  TOP w0.508: v2(222.07,209.01) v2(222.07,208) ; v2(302.07,209.01) v2(302.07,208) ; v2(262.07,209.01) v2(262.07,208) ; v2(302.07,269.01) v2(302.07,268) ; v2(342.07,209.01) v2(342.07,208) ; v2(222.07,269.01) v2(222.07,268) ; v3(519.61,148.33) v3(520.62,148.33) ; v2(342.07,269.01) v2(342.07,268) ; v2(262.07,269.01) v2(262.07,268)
  BOTTOM w0.16: K113.3 C1083.1
  BOTTOM w0.254: MU1.3 232.37,284.63 C281.1 ; UNK4MU1.3 352.37,284.63 UNK4C281.1 ; UNK7MU1.3 309.29,144.63 UNK7C281.1 ; UNK8C281.1 349.29,144.63 UNK8MU1.3 ; UNK6C281.1 269.29,144.63 UNK6MU1.3 ; UNK3C281.1 312.37,284.63 UNK3MU1.3 ; UNK2C281.1 272.37,284.63 UNK2MU1.3 ; UNK5MU1.3 229.29,144.63 UNK5C281.1
  BOTTOM w0.305: UNK6R331.1 v3(280.04,135.12) ; C416.1 82.32,275.16 U79.14 ; U76.14 502.15,222.7 C412.1 ; UNK2R331.1 v3(261.62,294.14) ; UNK3R331.1 v3(301.62,294.14) ; U454.14 502.15,204.55 502.28,204.42 ; U73.14 82.32,288.88 C407.1 ; R331.1 v3(221.62,294.14) ; UNK4R331.1 v3(341.62,294.14) ; UNK8R331.1 v3(360.04,135.12) ; U414.14 82.32,261.44 C956.1 ; UNK5R331.1 v3(240.04,135.12) ; UNK7R331.1 v3(320.04,135.12)
  BOTTOM w0.381: RB2.1 v3(211.66,13.4) ; RB1.1 v3(211.66,15.11)
  BOTTOM w0.457: v3(351.59,282.75) 352.01,283.17 UNK4MU1.1 ; UNK8MU1.1 349.65,146.09 v3(350.07,146.51) ; UNK5MU1.1 229.65,146.09 v3(230.07,146.51) ; MU1.1 232.01,283.17 v3(231.59,282.75) ; v3(271.59,282.75) 272.01,283.17 UNK2MU1.1 ; v3(310.07,146.51) 309.65,146.09 UNK7MU1.1 ; UNK6MU1.1 269.65,146.09 v3(270.07,146.51) ; v3(311.59,282.75) 312.01,283.17 UNK3MU1.1
  BOTTOM w0.508: 271.13,141.42 271.14,141.43 UNK6MR16.1 ; 271.13,141.42 UNK6MR15.1 ; 271.13,141.42 UNK6MR17.1 271.13,144.08 ; UNK6K32.1 v2(277.83,175.59) ; MR15.1 230.53,289.76 MR13.1 ; MR15.1 230.53,287.84 ; MR15.1 230.61,289.3 v3(232.37,289.3) v3(232.37,288.11) C280.1 C281.1 ; UNK8MR16.1 351.14,141.43 351.13,141.42 ; 231.13,144.08 UNK5MR17.1 231.13,141.42 ; 231.13,144.08 231.15,144.1 UNK5MR11.1 ; 231.13,144.08 UNK5MR12.1 231.13,146.13 231.64,146.64 UNK5MR14.2 ; UNK3MR13.1 310.53,289.76 UNK3MR15.1 ; 350.53,285.18 UNK4MR17.1 350.53,287.84 ; 350.53,285.18 UNK4MR12.1 350.53,283.13 350.02,282.62 UNK4MR14.2 ; 350.53,285.18 350.51,285.16 UNK4MR11.1 ; 230.53,287.84 MR17.1 230.53,285.18 ; 230.53,287.84 230.52,287.83 MR16.1 ; UNK2U17.2 104.66,195.18 104.98,195.5 ; 310.53,287.84 UNK3MR15.1 ; 310.53,287.84 UNK3MR17.1 310.53,285.18 ; 310.53,287.84 310.51,287.83 UNK3MR16.1 ; UNK3MR15.1 310.61,289.3 v3(312.37,289.3) v3(312.37,288.11) UNK3C280.1 UNK3C281.1 ; UNK7MR16.1 311.14,141.43 311.13,141.42 ; UNK5MR15.1 231.05,139.96 v3(229.29,139.96) v3(229.29,141.15) UNK5C280.1 UNK5C281.1 ; UNK5MR15.1 231.13,139.5 UNK5MR13.1 ; UNK5MR15.1 231.13,141.42 ; UNK3U17.2 470.42,195.18 470.74,195.5 ; 351.13,141.42 UNK8MR15.1 ; 351.13,141.42 UNK8MR17.1 351.13,144.08 ; UNK8MR15.1 351.13,139.5 UNK8MR13.1 ; UNK8MR15.1 351.05,139.96 v3(349.29,139.96) v3(349.29,141.15) UNK8C280.1 UNK8C281.1 ; UNK2K29.1 v2(269.84,254.76) ; UB1.8 v3(213.48,17.59) ; 311.13,141.42 UNK7MR15.1 ; 311.13,141.42 UNK7MR17.1 311.13,144.08 ; UNK7MR15.1 311.05,139.96 v3(309.29,139.96) v3(309.29,141.15) UNK7C280.1 UNK7C281.1 ; UNK7MR15.1 311.13,139.5 UNK7MR13.1 ; 231.13,141.42 231.15,141.43 UNK5MR16.1 ; 311.13,144.08 311.14,144.1 UNK7MR11.1 ; 311.13,144.08 UNK7MR12.1 311.13,146.13 311.64,146.64 UNK7MR14.2 ; 271.13,144.08 271.14,144.1 UNK6MR11.1 ; 271.13,144.08 UNK6MR12.1 271.13,146.13 271.64,146.64 UNK6MR14.2 ; 350.53,287.84 UNK4MR15.1 ; 350.53,287.84 350.51,287.83 UNK4MR16.1 ; UNK4MR15.1 350.53,289.76 UNK4MR13.1 ; UNK4MR15.1 350.61,289.3 v3(352.37,289.3) v3(352.37,288.11) UNK4C280.1 UNK4C281.1 ; CB13.1 v3(20.34,133.35) ; UNK8K32.1 v2(357.83,175.59) ; UNK7U17.2 470.42,131.68 470.74,132 ; 270.53,285.18 UNK2MR17.1 270.53,287.84 ; 270.53,285.18 UNK2MR12.1 270.53,283.13 270.02,282.62 UNK2MR14.2 ; 270.53,285.18 270.52,285.16 UNK2MR11.1 ; UNK3K32.1 v2(317.83,235.59) ; UNK6MR15.1 271.05,139.96 v3(269.29,139.96) v3(269.29,141.15) UNK6C280.1 UNK6C281.1 ; UNK6MR15.1 271.13,139.5 UNK6MR13.1 ; CB5.1 v3(561.32,295.91) ; 270.53,287.84 UNK2MR15.1 ; 270.53,287.84 270.52,287.83 UNK2MR16.1 ; UNK2MR15.1 270.53,289.76 UNK2MR13.1 ; UNK2MR15.1 270.61,289.3 v3(272.37,289.3) v3(272.37,288.11) UNK2C280.1 UNK2C281.1 ; 310.53,285.18 UNK3MR12.1 310.53,283.13 310.02,282.62 UNK3MR14.2 ; 310.53,285.18 310.51,285.16 UNK3MR11.1 ; UNK4U17.2 470.42,226.93 470.74,227.25 ; UNK7K29.1 v2(309.84,194.76) ; UNK5K32.1 v2(237.83,175.59) ; UNK5K29.1 v2(229.84,194.76) ; UNK4K32.1 v2(357.83,235.59) ; 230.53,285.18 230.52,285.16 MR11.1 ; 230.53,285.18 MR12.1 230.53,283.13 230.02,282.62 MR14.2 ; K32.1 v2(237.83,235.59) ; U17.2 104.66,226.93 104.98,227.25 ; 351.13,144.08 UNK8MR12.1 351.13,146.13 351.64,146.64 UNK8MR14.2 ; 351.13,144.08 351.14,144.1 UNK8MR11.1 ; CB7.1 v3(425.41,290.83) ; CB1.1 v3(415.56,133.35) ; UNK2K32.1 v2(277.83,235.59) ; 470.74,163.75 470.42,163.43 UNK8U17.2 ; CB15.1 v3(22.84,295.91) ; UNK6K29.1 v2(269.84,194.76) ; UNK7K32.1 v2(317.83,175.59) ; CB3.1 v3(558.82,133.35) ; CB11.1 v3(158.71,290.83) ; UNK8K29.1 v2(349.84,194.76) ; UNK3K29.1 v2(309.84,254.76) ; UNK5U17.2 104.66,163.43 104.98,163.75 ; 104.98,132 104.66,131.68 UNK6U17.2 ; CB9.1 v3(163.6,133.35) ; K29.1 v2(229.84,254.76) ; UNK4K29.1 v2(349.84,254.76)
  BOTTOM w0.584: U453.9 C1085.1 ; v3(510.75,221.35) U75.9 ; v3(73.21,282.43) U80.9 ; v3(73.21,268.71) U413.9 ; v3(90.92,260.1) U415.9 ; U77.9 v3(493.05,229.97) ; v3(90.92,273.81) U405.9 ; v3(73.21,296.14) U74.9 ; U72.9 v3(90.92,287.53)
  vias: v2(79.1,291.94) v2(79.1,290.69) v2(79.1,278.23) v2(79.1,276.97) v2(79.1,264.51) v2(79.1,263.26) v2(84.7,292.77) v2(84.7,291.32) v2(84.7,289.86) v2(84.7,279.05) v2(84.7,277.6) v2(84.7,276.15) v2(84.7,265.34) v2(84.7,263.88) v2(84.7,262.43) v2(498.93,225.77) v2(498.93,224.51) v2(498.93,206.36) v2(504.54,226.59) v2(504.54,225.14) v2(504.54,223.69) v3(20.34,130.81) v3(22.84,298.45) v3(43.74,298.45) v3(83.74,288.59) v3(83.74,274.88) v3(83.74,261.16) v3(107.7,227.33) v3(107.7,195.58) v3(107.7,163.83) v3(107.7,132.08) v3(109.1,227.5) v3(109.1,195.75) v3(109.1,164) v3(109.1,132.25) v3(158.71,293.37) v3(163.6,130.81) v3(222.95,290.96) v3(238.71,138.3) v3(262.95,290.96) v3(278.71,138.3) v3(284.67,294.06) v3(284.67,291.54) v3(296.92,294.06) v3(296.92,292.79) v3(302.95,290.96) v3(318.71,138.3) v3(342.95,290.96) v3(358.71,138.3) v3(415.56,130.81) v3(425.41,293.37) v3(466.36,275.84) v3(466.36,274.57) v3(473.46,227.33) v3(473.46,195.58) v3(473.46,163.83) v3(473.46,132.08) v3(474.86,227.5) v3(474.86,195.75) v3(474.86,164) v3(474.86,132.25) v3(493.05,211.81) v3(503.58,222.42) v3(503.58,204.26) v3(558.82,130.81) v3(561.32,298.45)
UT1_URW00: length 4.3
  TOP w0.254: UT1_SW1.8 158.1,13.32 UTL1.A01
UT1_URW01: length 6.9
  TOP w0.254: UTL1.B02 161.29,16.51 161.29,13.97 160.64,13.32 UT1_SW1.7
UT1_URW02: length 4.3
  TOP w0.254: UTL1.A03 163.18,13.32 UT1_SW1.6
UT1_URW03: length 6.9
  TOP w0.254: UTL1.B03 166.37,16.51 166.37,13.84 165.72,13.2 UT1_SW1.5
UT1_URW04: length 3.8
  TOP w0.254: UT1_SW1.4 168.26,14.62 UTL1.A04
UT1_URW05: length 6.9
  TOP w0.254: UT1_SW1.3 170.8,13.32 171.45,13.97 171.45,16.51 UTL1.B05
UT1_URW06: length 3.8
  TOP w0.254: UTL1.A06 172.72,13.84 173.34,13.22 UT1_SW1.2
UT1_UW07: length 7.4
  TOP w0.254: UTL1.B06 173.99,16.51 173.99,14.22 175.88,12.33 UT1_SW1.1
UT1_UW08: length 7.2
  TOP w0.254: UT1_SW2.8 180.33,12.84 179.7,13.46 177.04,13.46 UTL1.A07
UT1_UW09: length 11.5
  TOP w0.254: UT1_SW2.7 v3(182.87,10.05)
  L15_SIGNAL w0.203: UTL1.B08 179.07,16.51 179.07,13.84 v3(182.87,10.05)
UT1_UW10: length 7.3
  TOP w0.254: UTL1.A09 181.86,13.72 184.66,13.72 185.41,12.97 UT1_SW2.6
UT1_UW11: length 11.5
  TOP w0.254: UT1_SW2.5 v3(187.95,10.05)
  L15_SIGNAL w0.203: UTL1.B10 184.15,16.51 184.15,13.84 v3(187.95,10.05)
UT1_UW12: length 7.3
  TOP w0.254: UT1_SW2.4 190.49,12.97 189.99,13.46 187.2,13.46 UTL1.A11
UT1_UW13: length 11.5
  TOP w0.254: UT1_SW2.3 v3(193.03,10.05)
  L15_SIGNAL w0.203: v3(193.03,10.05) 189.23,13.84 189.23,16.51 UTL1.B12
UT1_UW14: length 34.2
  TOP w0.254: UTL1.A13 192.15,13.59 195.07,13.59 195.57,13.09 UT1_SW2.2
  L15_SIGNAL w0.203: UTL1.A13 191.63,14.11 212.15,14.11 v3(213.15,15.11)
  BOTTOM w0.203: v3(213.15,15.11) 213.41,14.86 UB1.6
UT1_UW15: length 37
  TOP w0.254: UTL1.B14 194.31,16.51 196.21,16.51 196.85,15.88 196.85,13.97 198.11,12.71 UT1_SW2.1
  L15_SIGNAL w0.203: v3(213.15,13.4) 214.07,14.32 214.07,15.59 213.18,16.49 194.33,16.49 UTL1.B14
  BOTTOM w0.203: UB1.5 v3(213.15,13.4)
UT2_URW00: length 4.3
  TOP w0.254: UTL2.A01 305.42,13.32 UT2_SW1.8
UT2_URW01: length 411.1
  TOP w0.254: UTL2.B02 308.61,16.51 308.61,13.97 307.96,13.32 UT2_SW1.7
  L31_SIGNAL w0.203: v3(537.24,236.52) 536.56,235.84 530.86,235.84 504.32,209.3 498.22,209.3 487.3,198.37 448.82,198.37 435.86,185.42 435.86,42.16 425.07,31.36 323.46,31.36 UTL2.B02
  BOTTOM w0.203: R932.2 536.24,235.83 536.93,236.52 v3(537.24,236.52)
UT2_URW02: length 4.3
  TOP w0.254: UT2_SW1.6 310.5,13.32 UTL2.A03
UT2_URW03: length 408.3
  TOP w0.254: UTL2.B03 313.69,16.51 313.69,13.84 313.04,13.2 UT2_SW1.5
  L31_SIGNAL w0.203: v3(537.24,235.13) 536.56,234.44 535.18,234.44 534.54,233.81 529.84,233.81 504.57,208.53 500.25,208.53 496.13,204.41 496.13,202.25 494.92,201.04 491.87,201.04 488.57,197.74 450.72,197.74 436.5,183.51 436.5,41.89 425.09,30.48 325.12,30.48 UTL2.B03
  BOTTOM w0.203: R930.2 536.24,234.43 536.93,235.13 v3(537.24,235.13)
UT2_URW04: length 401.9
  TOP w0.254: UT2_SW1.4 315.58,14.62 UTL2.A04
  L31_SIGNAL w0.203: UTL2.A04 320.8,9.4 362.12,9.4 373.46,20.74 426.43,20.74 444.12,38.44 444.12,117.6 451.2,124.69 491.88,124.69 513.54,146.34 513.54,148.11 523.7,158.27 523.7,182 526.29,184.59 526.29,206.81 532.2,212.71 532.93,212.71 540.31,220.09 542.03,220.09 v3(545.31,223.37)
  BOTTOM w0.203: R934.2 546.32,224.07 545.62,223.37 v3(545.31,223.37)
UT2_URW05: length 401.6
  TOP w0.254: UTL2.B05 318.77,16.51 318.77,13.97 318.12,13.32 UT2_SW1.3
  L31_SIGNAL w0.203: v3(537.24,233.73) 536.56,233.04 531.24,233.04 493.39,195.2 476.76,195.2 475.6,196.36 474.61,196.36 474.47,196.22 466.22,196.22 466.1,196.34 464.94,196.34 463.8,195.2 450.47,195.2 437.13,181.86 437.13,41.63 425.1,29.59 329.31,29.59 UTL2.B05
  BOTTOM w0.203: v3(537.24,233.73) 536.93,233.73 536.24,233.03 R929.2
UT2_URW06: length 397.6
  TOP w0.254: UTL2.A06 320.04,13.84 320.66,13.22 UT2_SW1.2
  L31_SIGNAL w0.203: v3(545.31,224.77) 541.2,224.77 540.21,223.77 540.21,221.03 532.63,213.45 531.89,213.45 525.55,207.11 525.55,184.9 522.96,182.31 522.96,158.4 512.8,148.24 512.8,146.65 491.4,125.25 450.75,125.25 443.48,117.98 443.48,38.7 426.42,21.64 373.68,21.64 363.22,11.18 324.1,11.18 UTL2.A06
  BOTTOM w0.203: v3(545.31,224.77) 545.62,224.77 546.32,225.47 R936.2
UT2_UW07: length 397.1
  TOP w0.254: UT2_SW1.1 323.2,12.33 321.31,14.22 321.31,16.51 UTL2.B06
  L31_SIGNAL w0.203: v3(537.24,232.33) 536.43,231.52 534.8,231.52 496.44,193.17 450.85,193.17 437.77,180.09 437.77,41.37 425.23,28.83 331.09,28.83 UTL2.B06
  BOTTOM w0.203: v3(537.24,232.33) 536.93,232.33 536.24,231.63 R931.2
UT2_UW08: length 387.7
  TOP w0.254: UT2_SW2.8 327.65,12.84 327.02,13.46 324.36,13.46 UTL2.A07
  L31_SIGNAL w0.203: UTL2.A07 326.01,11.81 362.97,11.81 373.56,22.4 426.29,22.4 442.85,38.96 442.85,118.24 450.44,125.83 491.06,125.83 510.87,145.64 510.87,148.77 521.03,158.93 521.03,185.17 523.65,187.78 523.65,208.99 533.37,218.72 536.58,218.72 v3(537.24,219.38)
  BOTTOM w0.203: v3(537.24,219.38) 536.93,219.38 536.24,218.68 R939.2
UT2_UW09: length 407.5
  TOP w0.254: UT2_SW2.7 v3(330.19,10.05)
  L15_SIGNAL w0.203: v3(330.19,10.05) 326.39,13.84 326.39,16.51 UTL2.B08
  L31_SIGNAL w0.203: v3(545.31,237.72) 541.13,237.72 540.26,236.85 540.26,233.04 537.85,230.63 534.92,230.63 494.28,189.99 450.47,189.99 438.4,177.93 438.4,41.1 425.37,28.07 335.41,28.07 UTL2.B08
  BOTTOM w0.203: R926.2 546.32,238.42 545.62,237.72 v3(545.31,237.72)
UT2_UW10: length 383
  TOP w0.254: UTL2.A09 329.18,13.72 331.98,13.72 332.73,12.97 UT2_SW2.6
  L31_SIGNAL w0.203: v3(537.24,220.78) 536.56,220.09 533.86,220.09 523.02,209.25 523.02,188.04 520.4,185.43 520.4,159.16 510.24,149 510.24,145.9 490.8,126.46 449.67,126.46 442.21,119 442.21,39.22 426.35,23.36 373.62,23.36 362.71,12.45 330.45,12.45 UTL2.A09
  BOTTOM w0.203: v3(537.24,220.78) 536.93,220.78 536.24,220.08 R937.2
UT2_UW11: length 397.6
  TOP w0.254: UT2_SW2.5 v3(335.27,10.05)
  L15_SIGNAL w0.203: UTL2.B10 331.47,16.51 331.47,13.84 v3(335.27,10.05)
  L31_SIGNAL w0.203: UTL2.B10 339.72,27.31 425.5,27.31 439.04,40.84 439.04,124.84 461.64,147.45 502.16,147.45 513.46,158.75 513.46,208.15 534.16,228.85 537.84,228.85 v3(545.31,236.33)
  BOTTOM w0.203: R927.2 546.32,237.02 545.62,236.33 v3(545.31,236.33)
UT2_UW12: length 378.3
  TOP w0.254: UT2_SW2.4 337.81,12.97 337.31,13.46 334.52,13.46 UTL2.A11
  L31_SIGNAL w0.203: UTL2.A11 334.9,13.08 362.33,13.08 373.38,24.13 426.22,24.13 441.58,39.49 441.58,121.31 454.51,134.24 494.56,134.24 518.57,158.24 518.57,187.86 521.06,190.35 521.06,209.78 532.76,221.49 536.56,221.49 v3(537.24,222.17)
  BOTTOM w0.203: v3(537.24,222.17) 536.93,222.17 536.24,221.48 R938.2
UT2_UW13: length 391.9
  TOP w0.254: UT2_SW2.3 v3(340.35,10.05)
  L15_SIGNAL w0.203: UTL2.B12 336.55,16.51 336.55,13.84 v3(340.35,10.05)
  L31_SIGNAL w0.203: v3(545.31,234.93) 538.58,228.19 534.47,228.19 515.34,209.07 515.34,159.41 502.64,146.71 462.03,146.71 439.67,124.36 439.67,40.58 425.51,26.42 343.92,26.42 UTL2.B12
  BOTTOM w0.203: v3(545.31,234.93) 545.62,234.93 546.32,235.63 R925.2
UT2_UW14: length 373.3
  TOP w0.254: UT2_SW2.2 342.89,13.09 342.39,13.59 339.47,13.59 UTL2.A13
  L31_SIGNAL w0.203: UTL2.A13 339.34,13.72 361.7,13.72 372.74,24.76 425.96,24.76 440.94,39.75 440.94,121.56 454.25,134.87 494.3,134.87 517.94,158.5 517.94,188.12 520.43,190.61 520.43,210.04 533.3,222.91 536.58,222.91 v3(537.24,223.57)
  BOTTOM w0.203: v3(537.24,223.57) 536.93,223.57 536.24,222.87 R940.2
UT2_UW15: length 386.4
  TOP w0.254: UT2_SW2.1 345.43,12.71 344.17,13.97 344.17,15.88 343.53,16.51 341.63,16.51 UTL2.B14
  L31_SIGNAL w0.203: UTL2.B14 341.59,19.01 341.59,19.01 348.23,25.65 425.65,25.65 440.31,40.31 440.31,124.03 461.37,145.08 502.01,145.08 516,159.08 516,207.01 535.15,226.16 543.59,226.16 545.31,227.89 v3(545.31,233.53)
  BOTTOM w0.203: R928.2 546.32,234.23 545.62,233.53 v3(545.31,233.53)
UT3_URW00: length 4.3
  TOP w0.254: UT3_SW1.8 423.56,415.94 UTL3.A01
UT3_URW01: length 6.9
  TOP w0.254: UTL3.B02 420.37,412.75 420.37,415.29 421.02,415.94 UT3_SW1.7
UT3_URW02: length 4.3
  TOP w0.254: UTL3.A03 418.48,415.94 UT3_SW1.6
UT3_URW03: length 6.9
  TOP w0.254: UT3_SW1.5 415.94,416.06 415.29,415.42 415.29,412.75 UTL3.B03
UT3_URW04: length 3.8
  TOP w0.254: UTL3.A04 413.4,414.64 UT3_SW1.4
UT3_URW05: length 6.9
  TOP w0.254: UTL3.B05 410.21,412.75 410.21,415.29 410.86,415.94 UT3_SW1.3
UT3_URW06: length 3.8
  TOP w0.254: UT3_SW1.2 408.32,416.04 408.94,415.42 UTL3.A06
UT3_UW07: length 7.4
  TOP w0.254: UT3_SW1.1 405.78,416.93 407.67,415.04 407.67,412.75 UTL3.B06
UT3_UW08: length 7.2
  TOP w0.254: UT3_SW2.8 401.33,416.42 401.95,415.8 404.62,415.8 UTL3.A07
UT3_UW09: length 11.5
  TOP w0.254: UT3_SW2.7 v3(398.79,419.21)
  L15_SIGNAL w0.203: v3(398.79,419.21) 402.59,415.42 402.59,412.75 UTL3.B08
UT3_UW10: length 7.3
  TOP w0.254: UT3_SW2.6 396.25,416.29 397,415.54 399.8,415.54 UTL3.A09
UT3_UW11: length 11.5
  TOP w0.254: UT3_SW2.5 v3(393.71,419.21)
  L15_SIGNAL w0.203: v3(393.71,419.21) 397.51,415.42 397.51,412.75 UTL3.B10
UT3_UW12: length 7.3
  TOP w0.254: UT3_SW2.4 391.17,416.29 391.67,415.8 394.46,415.8 UTL3.A11
UT3_UW13: length 11.5
  TOP w0.254: UT3_SW2.3 v3(388.63,419.21)
  L15_SIGNAL w0.203: v3(388.63,419.21) 392.43,415.42 392.43,412.75 UTL3.B12
UT3_UW14: length 7.4
  TOP w0.254: UT3_SW2.2 386.09,416.17 386.59,415.67 389.51,415.67 UTL3.A13
UT3_UW15: length 9.3
  TOP w0.254: UT3_SW2.1 383.55,416.55 384.81,415.29 384.81,413.38 385.44,412.75 387.35,412.75 UTL3.B14
UT4_URW00: length 4.3
  TOP w0.254: UTL4.A01 276.24,415.94 UT4_SW1.8
UT4_URW01: length 6.9
  TOP w0.254: UTL4.B02 273.05,412.75 273.05,415.29 273.7,415.94 UT4_SW1.7
UT4_URW02: length 4.3
  TOP w0.254: UT4_SW1.6 271.16,415.94 UTL4.A03
UT4_URW03: length 6.9
  TOP w0.254: UTL4.B03 267.97,412.75 267.97,415.42 268.62,416.06 UT4_SW1.5
UT4_URW04: length 3.8
  TOP w0.254: UTL4.A04 266.08,414.64 UT4_SW1.4
UT4_URW05: length 6.9
  TOP w0.254: UT4_SW1.3 263.54,415.94 262.89,415.29 262.89,412.75 UTL4.B05
UT4_URW06: length 270.4
  TOP w0.254: UT4_SW1.2 261,416.04 261.62,415.42 UTL4.A06
  L33_SIGNAL w0.203: v2(84.1,276.15) 82.8,277.45 82.8,281.77 87.27,286.24 92.55,286.24 110,303.69 114.55,303.69 116.3,305.44 157.61,305.44 222.02,369.85 222.02,408.32 231.57,417.87 257.77,417.87 UTL4.A06
  BOTTOM w0.203: U79.13 83.65,276.6 v2(84.1,276.15)
UT4_UW07: length 165.5
  TOP w0.254: UT4_SW1.1 258.46,416.93 260.35,415.04 260.35,412.75 UTL4.B06
  L33_SIGNAL w0.203: K112.8 193.29,302.13 227.46,336.3 227.46,403.81 231.29,407.64 257.78,407.64 UTL4.B06
UT4_UW08: length 270.1
  TOP w0.254: UT4_SW2.8 254.01,416.42 254.63,415.8 257.3,415.8 UTL4.A07
  L33_SIGNAL w0.203: UTL4.A07 255.79,417.31 231.8,417.31 222.58,408.09 222.58,366.34 160.91,304.67 116.73,304.67 115.19,303.13 110.23,303.13 92.78,285.68 87.5,285.68 83.36,281.54 83.36,278.34 v2(84.1,277.6)
  BOTTOM w0.203: U79.11 v2(84.1,277.6)
UT4_UW09: length 169
  TOP w0.254: UT4_SW2.7 v3(251.47,419.21)
  L15_SIGNAL w0.203: v3(251.47,419.21) 255.27,415.42 255.27,412.75 UTL4.B08
  L33_SIGNAL w0.203: UTL4.B08 253.34,408.28 231.03,408.28 226.82,404.08 226.82,340.4 K111.8
UT4_UW10: length 264.5
  TOP w0.254: UT4_SW2.6 248.93,416.29 249.68,415.54 252.48,415.54 UTL4.A09
  L33_SIGNAL w0.203: v2(84.1,279.05) 84.1,281.46 87.71,285.06 95.96,285.06 113.49,302.59 115.95,302.59 117.27,303.91 164.59,303.91 223.12,362.44 223.12,407.86 232.03,416.77 251.25,416.77 UTL4.A09
  BOTTOM w0.203: U79.9 83.65,278.6 v2(84.1,279.05)
UT4_UW11: length 171.6
  TOP w0.254: UT4_SW2.5 v3(246.39,419.21)
  L15_SIGNAL w0.203: UTL4.B10 250.19,412.75 250.19,415.42 v3(246.39,419.21)
  L33_SIGNAL w0.203: K110.8 176.74,299.97 182.12,299.97 226.19,344.04 226.19,404.34 230.76,408.91 248.89,408.91 UTL4.B10
UT4_UW12: length 270.5
  TOP w0.254: UTL4.A11 247.14,415.8 244.35,415.8 243.85,416.29 UT4_SW2.4
  L33_SIGNAL w0.203: v2(84.1,262.43) 82.8,263.73 82.8,266.53 87.83,271.55 93.22,271.55 124.82,303.15 168.15,303.15 223.78,358.78 223.78,407.59 232.3,416.11 246.83,416.11 UTL4.A11
  BOTTOM w0.203: v2(84.1,262.43) 83.65,262.88 U414.13
UT4_UW13: length 174.2
  TOP w0.254: UT4_SW2.3 v3(241.31,419.21)
  L15_SIGNAL w0.203: v3(241.31,419.21) 245.11,415.42 245.11,412.75 UTL4.B12
  L33_SIGNAL w0.203: UTL4.B12 244.45,409.55 230.5,409.55 225.55,404.6 225.55,347.6 178.82,300.86 167.98,300.86 K109.8
UT4_UW14: length 264.5
  TOP w0.254: UTL4.A13 242.19,415.67 239.27,415.67 238.77,416.17 UT4_SW2.2
  L33_SIGNAL w0.203: v2(84.1,263.88) 83.36,264.63 83.36,266.14 85.37,268.15 91.37,268.15 125.6,302.39 171.83,302.39 224.35,354.9 224.35,407.35 232.54,415.54 242.32,415.54 UTL4.A13
  BOTTOM w0.203: U414.11 v2(84.1,263.88)
UT4_UW15: length 260
  TOP w0.254: UT4_SW2.1 236.23,416.55 237.49,415.29 237.49,413.38 238.12,412.75 240.03,412.75 UTL4.B14
  L33_SIGNAL w0.203: v2(84.1,265.34) 84.1,265.99 85.2,267.08 93.14,267.08 127.69,301.62 175.39,301.62 224.89,351.13 224.89,404.88 230.23,410.21 240.03,410.21 UTL4.B14
  BOTTOM w0.203: U414.9 83.65,264.88 v2(84.1,265.34)
UT5_UW00: length 4.3
  TOP w0.254: UT5_SW1.8 10.78,13.32 UTL5.A01
UT5_UW01: length 6.9
  TOP w0.254: UTL5.B02 13.97,16.51 13.97,13.97 13.32,13.32 UT5_SW1.7
UT5_UW02: length 4.3
  TOP w0.254: UTL5.A03 15.86,13.32 UT5_SW1.6
UT5_UW03: length 6.9
  TOP w0.254: UTL5.B03 19.05,16.51 19.05,13.84 18.4,13.2 UT5_SW1.5
UT5_UW04: length 3.8
  TOP w0.254: UTL5.A04 20.94,14.62 UT5_SW1.4
UT5_UW05: length 6.9
  TOP w0.254: UTL5.B05 24.13,16.51 24.13,13.97 23.48,13.32 UT5_SW1.3
UT5_UW06: length 3.8
  TOP w0.254: UTL5.A06 25.4,13.84 26.02,13.22 UT5_SW1.2
UT5_UW07: length 7.4
  TOP w0.254: UTL5.B06 26.67,16.51 26.67,14.22 28.56,12.33 UT5_SW1.1
UT5_UW08: length 7.2
  TOP w0.254: UTL5.A07 29.72,13.46 32.38,13.46 33.01,12.84 UT5_SW2.8
UT5_UW09: length 11.5
  TOP w0.254: UT5_SW2.7 v3(35.55,10.05)
  L15_SIGNAL w0.203: v3(35.55,10.05) 31.75,13.84 31.75,16.51 UTL5.B08
UT5_UW10: length 7.3
  TOP w0.254: UT5_SW2.6 38.09,12.97 37.34,13.72 34.54,13.72 UTL5.A09
UT5_UW11: length 11.5
  TOP w0.254: UT5_SW2.5 v3(40.63,10.05)
  L15_SIGNAL w0.203: UTL5.B10 36.83,16.51 36.83,13.84 v3(40.63,10.05)
UT5_UW12: length 7.3
  TOP w0.254: UTL5.A11 39.88,13.46 42.67,13.46 43.17,12.97 UT5_SW2.4
UT5_UW13: length 11.5
  TOP w0.254: UT5_SW2.3 v3(45.71,10.05)
  L15_SIGNAL w0.203: v3(45.71,10.05) 41.91,13.84 41.91,16.51 UTL5.B12
UT5_UW14: length 7.4
  TOP w0.254: UT5_SW2.2 48.25,13.09 47.75,13.59 44.83,13.59 UTL5.A13
UT5_UW15: length 9.3
  TOP w0.254: UT5_SW2.1 50.79,12.71 49.53,13.97 49.53,15.88 48.89,16.51 46.99,16.51 UTL5.B14
UT6_UW00: length 262.4
  TOP w0.254: UT6_SW1.8 452.74,13.32 UTL6.A01
  L31_SIGNAL w0.203: UTL6.A01 449.3,20.6 449.3,105.21 463.98,119.89 502.44,119.89 528.68,146.13 528.68,177.42 531.42,180.16 531.42,205.31 534.26,208.15 536.18,208.15 v3(536.86,208.84)
  BOTTOM w0.203: v3(536.86,208.84) 536.55,208.84 535.86,208.14 R946.2
UT6_UW01: length 260
  TOP w0.254: UT6_SW1.7 455.28,13.32 455.93,13.97 455.93,16.51 UTL6.B02
  L31_SIGNAL w0.203: UTL6.B02 450.01,24.97 450.01,102.39 466.9,119.28 503.97,119.28 530.68,145.99 530.68,174.84 533.25,177.41 533.25,204.7 535.3,206.76 536.18,206.76 v3(536.86,207.44)
  BOTTOM w0.203: R945.2 535.86,206.74 536.55,207.44 v3(536.86,207.44)
UT6_UW02: length 272.4
  TOP w0.254: UT6_SW1.6 457.82,13.32 UTL6.A03
  L31_SIGNAL w0.203: UTL6.A03 457.77,13.27 453.96,13.27 448.61,18.62 448.61,105.31 463.78,120.47 502.11,120.47 527.91,146.28 527.91,177.73 530.66,180.48 530.66,205.69 534.54,209.58 536.2,209.58 v3(536.86,210.24)
  BOTTOM w0.203: v3(536.86,210.24) 536.55,210.24 535.86,209.54 R948.2
UT6_UW03: length 258.8
  TOP w0.254: UT6_SW1.5 460.36,13.2 461.01,13.84 461.01,16.51 UTL6.B03
  L31_SIGNAL w0.203: UTL6.B03 450.67,26.85 450.67,102.23 464.79,116.36 502.06,116.36 531.39,145.69 531.39,174.55 533.96,177.11 533.96,202.23 536.86,205.14 v3(536.86,206.04)
  BOTTOM w0.203: R947.2 535.86,205.35 536.55,206.04 v3(536.86,206.04)
UT6_UW04: length 286.4
  TOP w0.254: UTL6.A04 462.9,14.62 UT6_SW1.4
  L31_SIGNAL w0.203: UTL6.A04 459.57,12.53 453.66,12.53 447.88,18.31 447.88,108.15 463.25,123.52 493.55,123.52 515.9,145.87 515.9,148.77 526.06,158.93 526.06,181.03 528.65,183.62 528.65,207.34 532.38,211.07 535.81,211.07 v3(545.31,220.58)
  BOTTOM w0.203: R935.2 546.32,221.28 545.62,220.58 v3(545.31,220.58)
UT6_UW05: length 269.9
  TOP w0.254: UTL6.B05 466.09,16.51 466.09,13.97 465.44,13.32 UT6_SW1.3
  L31_SIGNAL w0.203: v3(544.93,211.43) 540.82,211.43 539.83,210.44 539.83,205.94 535.71,201.83 535.71,175.58 532.79,172.66 532.79,146.2 502.32,115.72 467.56,115.72 451.43,99.59 451.43,31.17 UTL6.B05
  BOTTOM w0.203: v3(544.93,211.43) 545.24,211.43 545.94,212.13 R944.2
UT6_UW06: length 296.5
  TOP w0.254: UT6_SW1.2 467.98,13.22 467.36,13.84 UTL6.A06
  L31_SIGNAL w0.203: v3(545.31,221.97) 542.12,218.78 539.99,218.78 533.22,212.01 532.49,212.01 528.06,207.59 528.06,183.86 525.47,181.27 525.47,159.17 515.31,149.01 515.31,146.12 493.3,124.11 459.65,124.11 447.09,111.56 447.09,17.99 453.33,11.75 463.87,11.75 UTL6.A06
  BOTTOM w0.203: v3(545.31,221.97) 545.62,221.97 546.32,222.67 R933.2
UT6_UW07: length 267.1
  TOP w0.254: UTL6.B06 468.63,16.51 468.63,14.22 470.52,12.33 UT6_SW1.1
  L31_SIGNAL w0.203: UTL6.B06 452.2,32.94 452.2,99.59 467.66,115.06 502.59,115.06 533.45,145.92 533.45,172.39 536.37,175.31 536.37,201.48 v3(544.93,210.04)
  BOTTOM w0.203: v3(544.93,210.04) 545.24,210.04 545.94,210.74 R942.2
UT6_UW08: length 211.1
  TOP w0.254: UT6_SW2.8 474.97,12.84 474.34,13.46 471.68,13.46 UTL6.A07
  L31_SIGNAL w0.203: SK8.8 545.57,123.93 523.57,123.93 505.46,105.82 505.46,19.69 497.13,11.35 473.79,11.35 UTL6.A07
UT6_UW09: length 241
  TOP w0.254: UT6_SW2.7 v3(477.51,10.05)
  L15_SIGNAL w0.203: v3(477.51,10.05) 473.71,13.84 473.71,16.51 UTL6.B08
  L31_SIGNAL w0.203: UTL6.B08 477.04,22.38 487.78,22.38 500.2,34.8 500.2,109.68 534.03,143.51 534.03,171.98 538.96,176.91 538.96,202.67 v3(544.93,208.64)
  BOTTOM w0.203: R941.2 545.94,209.34 545.24,208.64 v3(544.93,208.64)
UT6_UW10: length 221.1
  TOP w0.254: UTL6.A09 476.5,13.72 479.3,13.72 480.05,12.97 UT6_SW2.6
  L31_SIGNAL w0.203: SK5.8 563.7,158.57 563.7,143.33 544.93,124.56 523.01,124.56 504.62,106.17 504.62,20.03 496.78,12.19 478.03,12.19 UTL6.A09
UT6_UW11: length 235.3
  TOP w0.254: UT6_SW2.5 v3(482.59,10.05)
  L15_SIGNAL w0.203: UTL6.B10 478.79,16.51 478.79,13.84 v3(482.59,10.05)
  L31_SIGNAL w0.203: UTL6.B10 480.87,21.13 487.83,21.13 500.89,34.19 500.89,109.37 535.81,144.3 535.81,171.27 541.6,177.06 541.6,195.22 543.99,197.61 543.99,206.3 v3(544.93,207.24)
  BOTTOM w0.203: R943.2 545.94,207.94 545.24,207.24 v3(544.93,207.24)
