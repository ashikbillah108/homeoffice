# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CSDPS303GS1: length 127.4
  L09_DPS w0.203: CSDPS303.D2 308.91,51.77 308.91,102.29 310.76,104.13 310.76,138.04 311.15,138.43 311.15,139.19 310.58,139.77 310.58,143.7 309.24,145.03 309.24,161.04 310.26,162.05 310.26,167.13 314.32,171.2 7SA24.2
CSDPS303GS3: length 205
  L05_DPS w0.203: CSDPS303.D4 313.92,49.76 311.91,49.76 311.15,50.52 311.15,103.62 301.42,113.35 301.42,115.14 296.16,120.4 296.16,162.28 291.08,167.36 291.08,174.47 292.68,176.07 292.68,179.83 291.49,181.03 291.49,183.59 289.68,185.39 289.68,190.14 290.41,190.87 290.41,202.08 293.21,204.88 298.47,204.88 299.99,203.35 316.83,203.35 319.49,200.69 7SA15.2
CSDPS303GS6: length 151.9
  L11_DPS w0.203: 7SA10.2 315.03,171.42 309.87,166.27 309.87,162.38 309.19,161.7 309.19,142.79 311.37,140.61 311.37,137.24 310.4,136.27 310.4,126.07 319.71,116.76 319.71,106.68 321.56,104.83 321.56,69.8 326.69,64.67 326.69,42.65 325.96,41.91 318.77,41.91 CSDPS303.A5
CSDPS303GS9: length 178.2
  L09_DPS w0.203: 7SA7.2 303.4,189.23 302.89,189.74 302.89,191.26 305.43,193.8 310.51,193.8 311.27,194.56 312.54,194.56 313.3,193.8 328.54,193.8 329.81,192.53 329.81,174.24 330.83,173.23 330.83,104.26 329.16,102.59 329.16,51.84 CSDPS303.D10
CSDPS303GS11: length 156
  L05_DPS w0.203: CSDPS303.D12 334.19,49.71 332.28,49.71 331.47,50.52 331.47,113.92 318.57,126.82 318.57,137.39 318,137.95 318,143.28 318.51,143.78 318.51,172.64 314.9,176.25 312.99,176.25 312.26,175.51 305.58,175.51 303.24,177.85 303.24,179.5 303.49,179.76 7SA20.2
CSDPS303GS13: length 154.7
  L07_DPS w0.203: CSDPS303.D14 339.34,51.82 339.34,118.97 332.3,126.02 332.3,137.98 331.16,139.12 331.16,173.13 329.86,174.42 329.86,184.4 321.81,192.46 7SA18.2
CSDPS303GS14: length 189.2
  L11_DPS w0.203: CSDPS303.A13 339.09,41.91 348.92,41.91 350.32,43.31 350.32,116.61 341.17,125.76 339.04,125.76 330.55,134.24 330.55,167.59 330.8,167.84 330.8,172.85 329.99,173.66 329.99,193.17 328.7,194.46 317.49,194.46 316.53,195.43 7SA22.2
CSDPS303GS15: length 168.9
  L03_DPS w0.203: 7SA2.2 318.52,191.87 320.61,189.78 320.61,164.85 321.44,164.02 321.44,154.39 328.41,147.42 330.89,147.42 341.15,137.16 341.15,135.39 342.73,133.81 343.08,133.81 344.5,132.38 344.5,51.74 CSDPS303.D16
  L13_SIGNAL w0.203: CSDPS303.A15 341.63,44.45 341.63,51.31 342.14,51.82 344.42,51.82 CSDPS303.D16
CSDPS303P1: length 10.2
  L09_DPS w0.076: 313.43,178.81 313.43,181.85 313.25,182.03 311.48,182.03 v2(311.16,181.7)
  L09_DPS w0.203: 7SA23.1 313.04,176 313.43,176.39 313.43,178.81
  BOTTOM w0.508: UNK7CA36.1 v3(305.3,150.98)
  vias: v2(308.55,179.11) v2(309.85,181.06) v2(309.85,180.41) v2(310.5,181.7) v2(310.5,181.06) v2(311.16,181.06) v2(311.81,179.11) v3(305.3,153.01)
CSDPS303P3: length 12.5
  L05_DPS w0.076: 316.07,187.23 312.13,187.23 v2(311.81,186.91)
  L05_DPS w0.203: 316.07,187.23 316.1,187.23 316.98,188.11 316.98,189.46 318.98,191.46 7SA16.1
  BOTTOM w0.508: UNK7CA27.1 v3(305.3,155.04)
  vias: v2(315.05,190.16) v3(305.3,157.07)
CSDPS303P6: length 7.8
  L11_DPS w0.076: v2(312.46,181.06) 312.78,180.73 313.24,180.73 313.43,180.54 313.43,179.45
  L11_DPS w0.203: 7SA9.1 314.24,176.96 313.43,177.77 313.43,179.45
  BOTTOM w0.508: UNK7CA25.1 v3(300.48,150.98)
  vias: v2(309.85,179.76) v2(310.5,180.41) v2(310.5,179.76) v2(311.16,179.76) v2(311.81,181.7) v2(312.46,181.7) v3(300.48,153.01)
CSDPS303P9: length 6.4
  L09_DPS w0.076: v2(307.9,182.35) 307.58,182.68 305.55,182.68
  L09_DPS w0.203: 7SA8.1 303.91,183.44 304.67,182.68 305.55,182.68
  BOTTOM w0.508: UNK7CA8.1 v3(319.75,152.5)
  vias: v2(312.46,183) v2(313.76,186.26) v2(315.05,183) v3(319.75,154.53)
CSDPS303P11: length 8.9
  L05_DPS w0.203: v2(306.6,190.16) 304.76,190.16 304.08,189.47 7SA19.1
  BOTTOM w0.508: UNK7CA35.1 v3(324.57,152.5)
  vias: v2(306.6,185.61) v2(307.9,185.61) v2(313.11,184.96) v3(324.57,154.53)
CSDPS303P13: length 3.8
  L07_DPS w0.203: v2(313.11,190.16) 314.72,191.77 7SA17.1
  BOTTOM w0.508: UNK7CA21.1 v3(310.12,150.98)
  vias: v2(307.9,186.26) v2(307.9,184.96) v2(308.55,187.56) v2(308.55,179.76) v2(309.2,179.76) v2(311.15,190.16) v2(311.8,190.16) v2(311.81,181.06) v2(312.46,190.16) v2(312.46,187.56) v2(312.46,186.26) v2(312.46,184.3) v2(313.11,184.3) v2(313.76,183.65) v3(310.12,153.01)
CSDPS303P14: length 11.2
  L11_DPS w0.076: 310.83,191.08 310.83,188.07 311.02,187.88 311.48,187.88 v2(311.81,187.56)
  L11_DPS w0.203: 310.83,191.08 310.83,191.53 310.21,192.15 310.21,192.74 310.76,193.29 312.31,193.29 312.97,193.95 7SA21.1
  BOTTOM w0.508: UNK7CA23.1 v3(319.75,147.83)
  vias: v3(319.75,149.86)
CSDPS303P15: length 7.6
  L03_DPS w0.203: 7SA1.1 310.23,191.36 310,191.13 310,190.66 v2(310.5,190.16)
  BOTTOM w0.508: UNK7CA1.1 v3(300.48,155.04)
  vias: v2(308.55,181.7) v2(308.55,181.06) v2(309.2,186.26) v2(309.2,185.61) v2(309.2,184.96) v2(309.85,184.96) v2(310.5,186.91) v2(310.5,186.26) v2(310.5,185.61) v2(310.5,184.3) v2(311.16,186.26) v2(311.16,185.61) v2(311.16,184.96) v2(311.16,184.3) v2(311.81,184.96) v3(300.48,157.07)
CSDPS303PS1: length 126.6
  L09_DPS w0.203: 7SA23.2 313.04,170.68 309.75,167.39 309.75,162.31 308.73,161.29 308.73,144.82 310.01,143.55 310.01,139.7 308.99,138.68 308.99,103.5 308.38,102.9 308.38,51.84 CSDPS303.D1
CSDPS303PS3: length 199.6
  L05_DPS w0.203: CSDPS303.D3 313.69,52.07 313.69,101.73 301.88,113.54 301.88,115.57 299.16,118.29 299.16,165.99 300.55,167.39 300.55,171.15 297.05,174.65 297.05,175.54 295.8,176.78 294.12,176.78 293.36,177.54 293.36,180.62 294,181.25 294,186.31 292.81,187.5 292.81,192.43 291.02,194.21 291.02,201.83 293.39,204.19 297.91,204.19 299.23,202.87 315.53,202.87 318.98,199.42 7SA16.2
CSDPS303PS6: length 148.3
  L11_DPS w0.203: CSDPS303.A6 321.28,44.42 325.35,44.42 326.14,45.21 326.14,64.44 321.01,69.57 321.01,104.42 319.02,106.4 319.02,113.18 307.3,124.9 307.3,145.56 308.6,146.86 308.6,160.88 307.56,161.93 307.56,166.83 308.76,168.02 310.48,168.02 314.24,171.78 7SA9.2
CSDPS303PS9: length 174.2
  L09_DPS w0.203: 7SA8.2 303.91,190.5 306.45,193.04 312.29,193.04 312.67,192.66 328.16,192.66 329.31,191.51 329.31,173.74 330.32,172.72 330.32,104.77 328.65,103.1 328.65,51.79 CSDPS303.D9
CSDPS303PS11: length 150.9
  L05_DPS w0.203: CSDPS303.D11 334.01,52.07 334.01,103.23 332.84,104.39 332.84,116.23 319.2,129.87 319.2,136.56 319.45,136.8 319.45,142.42 318.99,142.88 318.99,173.51 316.92,175.58 316.92,175.96 315.36,177.52 306.14,177.52 304.08,179.58 7SA19.2
CSDPS303PS13: length 152.9
  L07_DPS w0.203: 7SA17.2 320.39,191.77 329.26,182.91 329.26,174.37 330.5,173.13 330.5,127.06 338.81,118.75 338.81,51.79 CSDPS303.D13
CSDPS303PS14: length 183.3
  L11_DPS w0.203: 7SA21.2 328.39,193.95 329.51,192.84 329.51,172.95 330.27,172.19 330.27,168.02 329.74,167.49 329.74,133.18 338.2,124.71 341.48,124.71 349.55,116.64 349.55,45.14 349.05,44.63 341.81,44.63 CSDPS303.A14
CSDPS303PS15: length 163.3
  L03_DPS w0.203: 7SA1.2 317.02,191.36 319.51,188.87 319.51,156.26 320.55,155.22 320.55,152.99 327.76,145.78 331.41,145.78 338.52,138.67 338.52,136.74 342.92,132.34 342.92,126.13 343.84,125.21 343.84,51.74 CSDPS303.D15
  L13_SIGNAL w0.203: CSDPS303.D15 344.17,49.53 344.17,44.45 CSDPS303.A16
CSDPS307GS1: length 139.5
  L09_DPS w0.203: 8SA24.2 354.32,171.2 350.26,167.13 350.26,162.05 349.24,161.04 349.24,144.49 350.14,143.59 350.14,142.49 351.71,140.92 351.71,138.51 359.51,130.71 359.51,129.57 382.55,106.53 382.55,51.79 CSDPS307.D2
CSDPS307GS3: length 218.9
  L05_DPS w0.203: CSDPS307.D4 387.58,49.76 385.57,49.76 384.81,50.52 384.81,86.21 349.97,121.04 349.97,123.28 336.16,137.09 336.16,162.28 331.08,167.36 331.08,174.47 332.68,176.07 332.68,179.83 331.49,181.03 331.49,183.59 329.68,185.39 329.68,190.14 330.41,190.87 330.41,202.08 333.21,204.88 338.47,204.88 339.99,203.35 356.83,203.35 359.49,200.69 8SA15.2
CSDPS307GS6: length 172.9
  L11_DPS w0.203: 8SA10.2 355.03,171.42 349.87,166.27 349.87,162.38 349.19,161.7 349.19,144.97 353.36,140.79 353.36,140.08 359.49,133.96 361.39,133.96 367.33,128.02 369.44,128.02 379.81,117.65 379.81,113.59 389.08,104.32 398.45,104.32 400.38,102.39 400.38,42.67 399.62,41.91 392.43,41.91 CSDPS307.A5
CSDPS307GS9: length 190.8
  L09_DPS w0.203: CSDPS307.D10 402.89,51.77 402.89,100.96 401.8,102.06 401.8,117.27 370.83,148.24 370.83,173.23 369.81,174.24 369.81,192.53 368.54,193.8 353.3,193.8 352.54,194.56 351.27,194.56 350.51,193.8 345.43,193.8 342.89,191.26 342.89,189.74 343.4,189.23 8SA7.2
CSDPS307GS11: length 173.1
  L05_DPS w0.203: CSDPS307.D12 407.9,49.76 405.89,49.76 405.13,50.52 405.13,92.2 401.75,95.58 400.93,95.58 400.38,96.13 400.38,96.95 399.21,98.12 398.39,98.12 397.84,98.67 397.84,99.24 393.19,103.89 389.38,103.89 362.57,130.7 362.57,130.95 358.62,134.9 358.62,137.29 358,137.91 358,143.28 358.51,143.78 358.51,172.64 354.9,176.25 352.99,176.25 352.26,175.51 345.58,175.51 343.24,177.85 343.24,179.5 343.49,179.76 8SA20.2
CSDPS307GS13: length 175.7
  L07_DPS w0.203: 8SA18.2 361.81,192.46 369.86,184.4 369.86,174.42 371.16,173.13 371.16,130.31 376.35,125.12 380.83,125.12 398.23,107.72 405.79,107.72 413,100.51 413,51.82 CSDPS307.D14
CSDPS307GS14: length 211.7
  L11_DPS w0.203: CSDPS307.A13 412.75,41.91 424.84,41.91 428.45,45.52 428.45,98.45 420.34,106.55 417.12,106.55 408.94,114.73 408.94,118.24 397.69,129.49 392.86,129.49 370.55,151.8 370.55,167.59 370.8,167.84 370.8,172.85 369.99,173.66 369.99,193.17 368.7,194.46 357.49,194.46 356.53,195.43 8SA22.2
CSDPS307GS15: length 193.2
  L03_DPS w0.203: 8SA2.2 358.52,191.87 360.61,189.78 360.61,159.16 364.02,155.75 367.84,155.75 370.48,153.11 370.48,148.91 390.25,129.15 406.93,129.15 418.16,117.92 418.16,51.74 CSDPS307.D16
  L13_SIGNAL w0.203: CSDPS307.A15 415.29,44.45 415.29,51.31 415.8,51.82 418.08,51.82 CSDPS307.D16
CSDPS307P1: length 10.2
  L09_DPS w0.076: 353.43,178.81 353.43,181.85 353.25,182.03 351.48,182.03 v2(351.15,181.7)
  L09_DPS w0.203: 8SA23.1 353.04,176 353.43,176.39 353.43,178.81
  BOTTOM w0.508: UNK8CA36.1 v3(345.3,150.98)
  vias: v2(348.55,179.11) v2(349.85,181.06) v2(349.85,180.41) v2(350.5,181.7) v2(350.5,181.06) v2(351.15,181.06) v2(351.8,179.11) v3(345.3,153.01)
CSDPS307P3: length 12.5
  L05_DPS w0.076: v2(351.8,186.91) 352.13,187.23 356.07,187.23
  L05_DPS w0.203: 8SA16.1 358.98,191.46 356.98,189.46 356.98,188.11 356.1,187.23 356.07,187.23
  BOTTOM w0.508: UNK8CA27.1 v3(345.3,155.04)
  vias: v2(355.05,190.16) v3(345.3,157.07)
CSDPS307P6: length 7.8
  L11_DPS w0.076: v2(352.45,181.06) 352.78,180.73 353.24,180.73 353.43,180.54 353.43,179.45
  L11_DPS w0.203: 353.43,179.45 353.43,177.77 354.24,176.96 8SA9.1
  BOTTOM w0.508: UNK8CA25.1 v3(340.48,150.98)
  vias: v2(349.85,179.76) v2(350.5,180.41) v2(350.5,179.76) v2(351.15,179.76) v2(351.8,181.7) v2(352.45,181.7) v3(340.48,153.01)
CSDPS307P9: length 6.4
  L09_DPS w0.076: 345.55,182.68 347.58,182.68 v2(347.9,182.35)
  L09_DPS w0.203: 345.55,182.68 344.67,182.68 343.91,183.44 8SA8.1
  BOTTOM w0.508: UNK8CA8.1 v3(359.75,152.5)
  vias: v2(352.45,183) v2(353.75,186.26) v2(355.05,183) v3(359.75,154.53)
CSDPS307P11: length 8.9
  L05_DPS w0.203: v2(346.6,190.16) 344.76,190.16 344.08,189.47 8SA19.1
  BOTTOM w0.508: UNK8CA35.1 v3(364.57,152.5)
  vias: v2(346.6,185.61) v2(347.9,185.61) v2(353.1,184.96) v3(364.57,154.53)
CSDPS307P13: length 4.5
  L07_DPS w0.203: 8SA17.1 354.72,191.77 v2(353.1,190.16) ; 411.48,46.99 411.48,46.28
  BOTTOM w0.508: UNK8CA21.1 v3(350.12,150.98)
  vias: v2(347.9,186.26) v2(347.9,184.96) v2(348.55,187.56) v2(348.55,179.76) v2(349.2,179.76) v2(351.15,190.16) v2(351.8,190.16) v2(351.8,181.06) v2(352.45,190.16) v2(352.45,187.56) v2(352.45,186.26) v2(352.45,184.3) v2(353.1,184.3) v2(353.75,183.65) v3(350.12,153.01)
CSDPS307P14: length 11.2
  L11_DPS w0.076: 350.83,191.08 350.83,188.07 351.02,187.88 351.48,187.88 v2(351.8,187.56)
  L11_DPS w0.203: 350.83,191.08 350.83,191.53 350.21,192.15 350.21,192.74 350.76,193.29 352.31,193.29 352.97,193.95 8SA21.1
  BOTTOM w0.508: UNK8CA23.1 v3(359.75,147.83)
  vias: v3(359.75,149.86)
CSDPS307P15: length 7.6
  L03_DPS w0.203: 8SA1.1 350.23,191.36 350,191.13 350,190.66 v2(350.5,190.16)
  BOTTOM w0.508: UNK8CA1.1 v3(340.48,155.04)
  vias: v2(348.55,181.7) v2(348.55,181.06) v2(349.2,186.26) v2(349.2,185.61) v2(349.2,184.96) v2(349.85,184.96) v2(350.5,186.91) v2(350.5,186.26) v2(350.5,185.61) v2(350.5,184.3) v2(351.15,186.26) v2(351.15,185.61) v2(351.15,184.96) v2(351.15,184.3) v2(351.8,184.96) v3(340.48,157.07)
CSDPS307PS1: length 139.2
  L09_DPS w0.203: CSDPS307.D1 382.04,51.84 382.04,106.32 359,129.36 359,130.5 351.21,138.3 351.21,140.54 349.39,142.36 349.39,143.62 348.73,144.27 348.73,161.29 349.75,162.31 349.75,167.39 353.04,170.68 8SA23.2
CSDPS307PS3: length 213.6
  L05_DPS w0.203: 8SA16.2 358.98,199.42 355.53,202.87 339.23,202.87 337.91,204.19 333.39,204.19 331.02,201.83 331.02,194.21 332.81,192.43 332.81,187.5 334,186.31 334,181.25 333.36,180.62 333.36,177.54 334.12,176.78 335.8,176.78 337.05,175.54 337.05,174.65 340.55,171.15 340.55,167.39 339.16,165.99 339.16,135.7 379.17,95.68 379.17,94.08 387.35,85.9 387.35,52.07 CSDPS307.D3
CSDPS307PS6: length 167.1
  L11_DPS w0.203: 8SA9.2 354.24,171.78 350.48,168.02 348.76,168.02 347.56,166.83 347.56,161.93 348.6,160.88 348.6,144.73 352.78,140.55 352.78,139.83 360.62,131.99 361.43,131.99 365.02,128.4 365.02,127.58 388.87,103.73 398.21,103.73 399.8,102.15 399.8,45.21 399.01,44.42 394.94,44.42 CSDPS307.A6
CSDPS307PS9: length 187.4
  L09_DPS w0.203: CSDPS307.D9 402.39,51.87 402.39,100.75 401.29,101.85 401.29,117.06 393.87,124.49 392.79,124.49 370.32,146.95 370.32,172.72 369.31,173.74 369.31,191.51 368.16,192.66 352.67,192.66 352.29,193.04 346.45,193.04 343.91,190.5 8SA8.2
CSDPS307PS11: length 167.1
  L05_DPS w0.203: 8SA19.2 344.08,179.58 346.14,177.52 355.36,177.52 356.92,175.96 356.92,175.58 358.99,173.51 358.99,142.88 359.45,142.42 359.45,136.69 362.97,133.17 362.97,132.46 376.05,119.38 377.49,119.38 392.47,104.39 393.45,104.39 397.84,100 399.17,100 400.05,99.12 400.05,98.68 401.27,97.46 401.71,97.46 402.26,96.91 402.26,96.09 407.67,90.68 407.67,52.07 CSDPS307.D11
CSDPS307PS13: length 174.4
  L07_DPS w0.203: CSDPS307.D13 412.47,51.79 412.47,100.29 405.57,107.19 394.1,107.19 377.4,123.88 376.04,123.88 370.5,129.43 370.5,173.13 369.26,174.37 369.26,182.91 360.39,191.77 8SA17.2
CSDPS307PS14: length 203.1
  L11_DPS w0.203: 8SA21.2 368.39,193.95 369.51,192.84 369.51,172.95 370.27,172.19 370.27,168.02 369.74,167.49 369.74,151.83 392.63,128.93 393.98,128.93 417.17,105.74 420.01,105.74 427.63,98.11 427.63,46.63 425.63,44.63 415.47,44.63 CSDPS307.A14
CSDPS307PS15: length 183.6
  L03_DPS w0.203: 8SA1.2 357.02,191.36 359.51,188.87 359.51,158.46 370.54,147.43 370.54,146.43 389.03,127.94 403.52,127.94 417.5,113.96 417.5,51.74 CSDPS307.D15
  L13_SIGNAL w0.203: CSDPS307.D15 417.83,49.53 417.83,44.45 CSDPS307.A16
CSDPS310GS1: length 249.7
  L03_DPS w0.203: CSDPS310.D2 420.12,359.16 423.16,359.16 425.44,361.43 425.44,376.95 424.81,377.57 379.09,377.57 377.6,376.07 377.6,322.43 378.97,321.06 378.97,300.66 383.29,296.34 383.29,267.33 369.98,254.03 357.66,254.03 356.67,255.02 356.67,256.88 354.93,258.62 349.34,258.62 344.91,254.19 344,254.19 343.25,253.44 343.25,252.72 343.83,252.15 4SA2.2
  L13_SIGNAL w0.203: CSDPS310.A1 420.62,366.78 418.34,366.78 417.83,366.27 417.83,359.41 CSDPS310.D2
CSDPS310GS3: length 185.1
  L05_DPS w0.203: CSDPS310.D4 415.62,356.54 415.62,316.87 403.4,304.65 402.03,304.65 380.52,283.13 380.52,234.7 379.6,233.78 370.95,233.78 369.12,235.61 359.65,235.61 359.06,235.03 349.72,235.03 348.83,235.92 344.89,235.92 342.96,237.85 342.96,239.55 343.49,240.08 4SA20.2
CSDPS310GS4: length 164.2
  L11_DPS w0.203: 4SA22.2 360.54,265.43 361.55,266.45 361.55,282.15 373.46,294.06 391.69,294.06 397.94,300.3 399.08,300.3 426.85,328.07 426.85,363.96 423.77,367.03 417.83,367.03 CSDPS310.A3
CSDPS310GS5: length 159
  L07_DPS w0.203: 4SA18.2 355.15,237.92 356.12,236.96 358.61,236.96 359.14,237.49 361.55,237.49 362.82,238.76 362.82,240.77 369.58,247.52 369.58,252.4 370.85,253.67 370.85,297.52 389.28,315.95 389.28,320.34 391.29,322.35 406.5,322.35 410.54,326.39 410.54,356.54 CSDPS310.D6
CSDPS310GS7: length 140.7
  L09_DPS w0.203: 4SA7.2 344.03,248.56 344.33,248.87 344.33,253.28 354.26,263.22 354.26,272.14 352.99,273.41 352.99,281.87 354.2,283.08 354.2,297.31 357.63,300.74 357.63,301.7 380.8,324.87 382.27,324.87 387.02,329.62 387.02,330.12 388.7,331.8 389.2,331.8 389.89,332.49 389.89,332.99 390.91,334.01 392.68,334.01 404.88,346.2 404.88,357.12 CSDPS310.D8
CSDPS310GS11: length 126.3
  L05_DPS w0.203: 4SA15.2 357.49,267.63 358.67,268.81 359.62,268.81 360.91,270.09 360.91,291.54 366.04,296.67 369.37,296.67 395.3,322.61 395.3,356.54 CSDPS310.D12
CSDPS310GS14: length 185
  L11_DPS w0.203: CSDPS310.A13 389.89,367.03 380.29,367.03 379.37,366.12 379.37,345.72 351.64,317.99 347.14,317.99 330.27,301.11 330.27,253.82 329.17,252.73 329.17,235.56 330.57,234.16 333.72,234.16 336.03,236.47 340.73,236.47 341.74,237.49 4SA10.2
CSDPS310GS15: length 183.7
  L09_DPS w0.203: 4SA24.2 354.06,236.09 354.31,235.84 354.31,234.82 353.68,234.19 351.39,234.19 350.78,233.58 348.4,231.19 342.45,231.19 339.46,234.19 332.34,234.19 329.15,237.38 329.15,240.31 329.8,240.96 329.8,257.12 330.24,257.56 330.24,263.97 329.94,264.28 329.94,305.04 342.65,317.75 343.66,317.75 345.69,319.79 345.69,320.8 371.86,346.96 384.05,346.96 384.56,347.47 384.56,357.12 CSDPS310.D16
CSDPS310P1: length 5.7
  L03_DPS w0.203: v2(350.5,250.15) 350.04,250.15 348.86,251.33 346.83,251.33 346.52,251.64 4SA1.1
  BOTTOM w0.508: UNK4CA1.1 v3(377.19,245.11)
  vias: v2(348.55,241.7) v2(348.55,241.06) v2(349.2,246.26) v2(349.2,245.61) v2(349.2,244.96) v2(349.85,244.96) v2(350.5,246.91) v2(350.5,246.26) v2(350.5,245.61) v2(350.5,244.3) v2(351.15,246.26) v2(351.15,245.61) v2(351.15,244.96) v2(351.15,244.3) v2(351.8,244.96) v3(377.19,247.65)
CSDPS310P3: length 8.9
  L05_DPS w0.203: v2(346.6,250.15) 344.76,250.15 344.08,249.47 4SA19.1
  BOTTOM w0.508: UNK4CA35.1 v3(363.87,275.59)
  vias: v2(346.6,245.61) v2(347.9,245.61) v2(353.1,244.96) v3(363.87,277.62)
CSDPS310P4: length 10
  L11_DPS w0.076: 356.07,247.23 352.13,247.23 v2(351.8,247.56)
  L11_DPS w0.203: 356.07,247.23 357.83,247.23 359.27,248.67 4SA21.1
  BOTTOM w0.508: UNK4CA23.1 v3(341.51,275.59)
  vias: v3(341.51,277.62)
CSDPS310P5: length 5.2
  L07_DPS w0.203: 4SA17.1 349.62,238.53 349.2,238.94 v2(349.2,239.75)
  BOTTOM w0.508: UNK4CA21.1 v3(335.42,279.65)
  vias: v2(347.9,246.26) v2(347.9,244.96) v2(348.55,247.56) v2(348.55,239.75) v2(351.15,250.15) v2(351.8,250.15) v2(351.8,241.05) v2(352.45,250.15) v2(352.45,247.56) v2(352.45,246.26) v2(352.45,244.3) v2(353.1,250.15) v2(353.1,244.3) v2(353.75,243.65) v3(335.42,281.69)
CSDPS310P7: length 5.9
  L09_DPS w0.076: v2(347.9,242.35) 347.58,242.68 345.7,242.68 345.55,242.82
  L09_DPS w0.203: 345.55,242.82 345.3,243.08 4SA8.1
  BOTTOM w0.508: UNK4CA8.1 v3(363.87,279.65)
  vias: v2(352.45,243) v2(353.75,246.26) v2(355.05,243) v3(363.87,281.69)
CSDPS310P11: length 8
  L05_DPS w0.076: v2(351.8,246.91) 352.13,247.23 355.97,247.23
  L05_DPS w0.203: 4SA16.1 356.98,248.11 356.1,247.23 355.97,247.23
  BOTTOM w0.508: UNK4CA27.1 v3(353.93,275.59)
  vias: v2(355.05,250.15) v3(353.93,277.62)
CSDPS310P14: length 10.8
  L11_DPS w0.076: 353.3,238.81 353.43,238.94 353.43,240.54 353.24,240.73 352.78,240.73 v2(352.45,241.06)
  L11_DPS w0.203: 4SA9.1 352.49,238 353.3,238.81
  BOTTOM w0.508: UNK4CA25.1 v3(335.42,275.59)
  vias: v2(349.85,239.75) v2(350.5,240.4) v2(350.5,239.76) v2(351.15,239.75) v2(351.8,241.7) v2(352.45,241.7) v3(335.42,277.62)
CSDPS310P15: length 7.1
  L09_DPS w0.076: 353.41,239.38 353.43,239.4 353.43,241.84 353.24,242.03 351.48,242.03 v2(351.15,241.7)
  L09_DPS w0.203: 353.41,239.38 4SA23.1
  BOTTOM w0.508: UNK4CA36.1 v3(347.6,275.59)
  vias: v2(348.55,239.1) v2(349.85,241.05) v2(349.85,240.41) v2(350.5,241.7) v2(350.5,241.05) v2(351.15,241.05) v2(351.8,239.1) v3(347.6,277.62)
CSDPS310PS1: length 246.1
  L03_DPS w0.203: CSDPS310.D1 423.04,358.14 426.08,361.19 426.08,377.23 425.09,378.23 378.82,378.23 376.94,376.35 376.94,301.73 381.51,297.15 381.51,266.2 369.79,254.48 359.71,254.48 355.12,259.08 349.15,259.08 344.72,254.65 343.78,254.65 342.69,253.56 342.69,251.46 343.51,250.63 344.03,250.63 345.03,251.64 4SA1.2
  L13_SIGNAL w0.203: CSDPS310.D1 420.37,359.41 420.37,364.49 CSDPS310.A2
CSDPS310PS3: length 179.5
  L05_DPS w0.203: CSDPS310.D3 415.52,359.18 413.66,359.18 412.98,358.5 412.98,357.17 414.96,355.19 414.96,320.17 394.74,299.95 394.74,299.34 379.63,284.23 379.63,271.78 377.88,270.03 377.88,239.62 374.5,236.25 357.06,236.25 355.81,237.49 346.19,237.49 344.08,239.6 4SA19.2
CSDPS310PS4: length 163.2
  L11_DPS w0.203: CSDPS310.A4 415.29,364.49 423.8,364.49 426.34,361.95 426.34,331.44 389.45,294.55 371.94,294.55 361.05,283.65 361.05,270 360.28,269.24 360.28,266.7 359.27,265.68 4SA21.2
CSDPS310PS5: length 161.1
  L07_DPS w0.203: CSDPS310.D5 410.46,359.16 408.61,359.16 407.97,358.52 407.97,356.84 409.88,354.94 409.88,326.9 405.84,322.86 391.08,322.86 388.77,320.56 388.77,316.16 370.34,297.73 370.34,256.34 367.5,253.49 367.5,247.57 361.35,241.43 361.35,239.47 360.11,238.23 357.18,238.23 356.88,238.53 4SA17.2
CSDPS310PS7: length 138.8
  L09_DPS w0.203: 4SA8.2 345.3,252.47 354.8,261.97 354.8,279.81 354.58,280.02 354.58,282.32 354.84,282.57 354.84,295.91 376.17,317.25 377.16,317.25 386.28,326.36 386.28,327.48 387.73,328.93 388.68,328.93 389.76,330.01 389.76,330.71 390.78,331.72 391.54,331.72 392.3,332.49 392.3,332.98 405.38,346.06 405.38,357.12 CSDPS310.D7
CSDPS310PS11: length 129.7
  L05_DPS w0.203: CSDPS310.D11 395.2,359.18 393.34,359.18 392.66,358.5 392.66,357.17 394.64,355.19 394.64,326.24 370.41,302.01 369.27,302.01 356.86,289.6 356.86,280.67 357.49,280.04 357.49,269.11 356.98,268.61 4SA16.2
CSDPS310PS14: length 176.9
  L11_DPS w0.203: CSDPS310.A14 387.35,364.49 380.7,364.49 379.88,363.68 379.88,345.47 351.74,317.32 347.19,317.32 330.77,300.9 330.77,253.45 329.68,252.35 329.68,237.31 331.31,235.69 334.3,235.69 335.85,237.24 338.69,237.24 339.46,238 4SA9.2
CSDPS310PS15: length 180
  L09_DPS w0.203: 4SA23.2 353.41,236.59 352.28,235.46 346.57,235.46 343.74,232.63 343.03,232.63 340.21,235.46 332.34,235.46 330.16,237.64 330.16,239.63 331.07,240.54 331.07,247.4 330.31,248.16 330.31,256.92 330.7,257.3 330.7,264.16 330.44,264.41 330.44,304.83 342.75,317.14 344.32,317.14 346.46,319.28 346.46,320.85 372.07,346.46 384.26,346.46 385.06,347.26 385.06,357.12 CSDPS310.D15
CSDPS314GS1: length 222.9
  L03_DPS w0.203: 3SA2.2 303.75,252.15 303.14,252.75 303.14,263.27 306.44,266.56 308.65,266.56 309.59,267.5 ; CSDPS314.D2 346.46,359.16 349.5,359.16 351.78,361.43 351.78,376.95 351.15,377.57 305.44,377.57 303.94,376.07 303.94,322.43 308.11,318.25 308.6,318.25 315.39,311.45
  L03_DPS w0.254: 315.39,311.45 315.43,311.41 315.43,284.7 314.57,283.84 314.57,281.06 314.83,280.8 314.83,271.78 313.56,270.51 312.6,270.51 309.59,267.5
  L13_SIGNAL w0.203: CSDPS314.D2 344.17,359.41 344.17,366.27 344.68,366.78 346.96,366.78 CSDPS314.A1
CSDPS314GS3: length 172.6
  L05_DPS w0.203: 3SA20.2 303.49,240.08 302.96,239.55 302.96,237.85 304.89,235.92 308.83,235.92 309.72,235.03 319.06,235.03 319.65,235.61 329.12,235.61 330.36,234.37 336.36,234.37 339.18,237.19 339.18,249.53 342.66,253.01 342.66,259.82 338.45,264.03 338.45,265.8 337.05,267.21 337.05,294.34 342.34,299.63 342.34,300.36 341.96,300.74 341.96,356.54 CSDPS314.D4
CSDPS314GS4: length 139.1
  L11_DPS w0.203: 3SA22.2 320.54,265.43 321.55,266.45 321.55,300.26 338.89,317.59 339.28,317.59 353.19,331.5 353.19,363.96 350.11,367.03 344.17,367.03 CSDPS314.A3
CSDPS314GS5: length 136.1
  L07_DPS w0.203: 3SA18.2 315.15,237.92 316.12,236.96 318.61,236.96 319.14,237.49 321.55,237.49 322.82,238.76 322.82,240.77 329.58,247.52 329.58,252.4 330.85,253.67 330.85,303.75 332.89,305.79 332.89,321.31 336.88,325.3 336.88,356.54 CSDPS314.D6
CSDPS314GS7: length 125.6
  L09_DPS w0.203: CSDPS314.D8 331.22,357.12 331.22,340.36 324.1,333.25 324.1,328.8 313.69,318.39 313.69,304.29 313.43,304.03 313.43,296.92 312.67,296.16 312.67,291.15 314.01,289.81 314.01,285.19 312.99,284.18 312.99,273.41 314.26,272.14 314.26,263.22 304.33,253.28 304.33,248.87 304.03,248.56 3SA7.2
CSDPS314GS11: length 111.4
  L05_DPS w0.203: 3SA15.2 317.49,267.63 318.67,268.81 319.62,268.81 320.91,270.09 320.91,300.1 319.79,301.22 319.79,324.23 321.64,326.09 321.64,356.54 CSDPS314.D12
CSDPS314GS14: length 168.5
  L11_DPS w0.203: CSDPS314.A13 316.23,367.03 306.63,367.03 305.71,366.12 305.71,347.75 290.27,332.3 290.27,253.82 289.17,252.73 289.17,235.56 290.57,234.16 293.72,234.16 296.03,236.47 300.73,236.47 301.74,237.49 3SA10.2
CSDPS314GS15: length 162
  L09_DPS w0.203: 3SA24.2 314.06,236.09 314.31,235.84 314.31,234.82 313.68,234.19 311.39,234.19 310.92,233.71 310.92,233.71 308.4,231.19 302.45,231.19 299.46,234.19 292.34,234.19 289.15,237.38 289.15,240.31 289.8,240.96 289.8,257.12 290.24,257.56 290.24,263.97 289.94,264.28 289.94,326.51 310.9,347.47 310.9,357.12 CSDPS314.D16
CSDPS314P1: length 5.7
  L03_DPS w0.203: 3SA1.1 306.52,251.64 306.83,251.33 308.86,251.33 310.04,250.15 v2(310.5,250.15)
  BOTTOM w0.508: UNK3CA1.1 v3(364.09,295.91)
  vias: v2(308.55,241.7) v2(308.55,241.06) v2(309.2,246.26) v2(309.2,245.61) v2(309.2,244.96) v2(309.85,244.96) v2(310.5,246.91) v2(310.5,246.26) v2(310.5,245.61) v2(310.5,244.3) v2(311.16,246.26) v2(311.16,245.61) v2(311.16,244.96) v2(311.16,244.3) v2(311.81,244.96) v3(364.09,297.94)
CSDPS314P3: length 8.9
  L05_DPS w0.203: v2(306.6,250.15) 304.76,250.15 304.08,249.47 3SA19.1
  BOTTOM w0.508: UNK3CA35.1 v3(323.87,275.59)
  vias: v2(306.6,245.61) v2(307.9,245.61) v2(313.11,244.96) v3(323.87,277.62)
CSDPS314P4: length 10
  L11_DPS w0.076: v2(311.81,247.56) 312.13,247.23 316.07,247.23
  L11_DPS w0.203: 316.07,247.23 317.83,247.23 319.27,248.67 3SA21.1
  BOTTOM w0.508: UNK3CA23.1 v3(301.51,275.59)
  vias: v3(301.51,277.62)
CSDPS314P5: length 5.2
  L07_DPS w0.203: 3SA17.1 309.62,238.53 309.2,238.94 v2(309.2,239.75)
  BOTTOM w0.508: UNK3CA21.1 v3(295.42,279.65)
  vias: v2(307.9,246.26) v2(307.9,244.96) v2(308.55,247.56) v2(308.55,239.75) v2(311.15,250.15) v2(311.8,250.15) v2(311.81,241.05) v2(312.46,250.15) v2(312.46,247.56) v2(312.46,246.26) v2(312.46,244.3) v2(313.11,250.15) v2(313.11,244.3) v2(313.76,243.65) v3(295.42,281.69)
CSDPS314P7: length 5.9
  L09_DPS w0.076: v2(307.9,242.35) 307.58,242.68 305.7,242.68 305.55,242.82
  L09_DPS w0.203: 3SA8.1 305.3,243.08 305.55,242.82
  BOTTOM w0.508: UNK3CA8.1 v3(323.87,279.65)
  vias: v2(312.46,243) v2(313.76,246.26) v2(315.05,243) v3(323.87,281.69)
CSDPS314P11: length 8
  L05_DPS w0.076: v2(311.81,246.91) 312.13,247.23 315.97,247.23
  L05_DPS w0.203: 315.97,247.23 316.1,247.23 316.98,248.11 3SA16.1
  BOTTOM w0.508: UNK3CA27.1 v3(313.93,275.59)
  vias: v2(315.05,250.15) v3(313.93,277.62)
CSDPS314P14: length 10.8
  L11_DPS w0.076: v2(312.46,241.06) 312.78,240.73 313.24,240.73 313.43,240.54 313.43,238.94 313.3,238.81
  L11_DPS w0.203: 313.3,238.81 312.49,238 3SA9.1
  BOTTOM w0.508: UNK3CA25.1 v3(295.42,275.59)
  vias: v2(309.85,239.75) v2(310.5,240.4) v2(310.5,239.76) v2(311.16,239.75) v2(311.81,241.7) v2(312.46,241.7) v3(295.42,277.62)
CSDPS314P15: length 7.1
  L09_DPS w0.076: v2(311.16,241.7) 311.48,242.03 313.24,242.03 313.43,241.84 313.43,239.4 313.41,239.38
  L09_DPS w0.203: 313.41,239.38 3SA23.1
  BOTTOM w0.508: UNK3CA36.1 v3(307.6,275.59)
  vias: v2(308.55,239.1) v2(309.85,241.05) v2(309.85,240.41) v2(310.5,241.7) v2(310.5,241.05) v2(311.16,241.05) v2(311.81,239.1) v3(307.6,277.62)
CSDPS314PS1: length 221.4
  L03_DPS w0.203: 308.88,268.97 307.95,268.05 307.16,268.05 302.69,263.57 302.69,251.46 303.51,250.63 304.03,250.63 305.03,251.64 3SA1.2 ; 314.58,285.5 314.58,311.54 308.49,317.63 304.41,317.63 303.28,318.77 303.28,376.35 305.16,378.23 351.43,378.23 352.42,377.23 352.42,361.19 349.38,358.14 CSDPS314.D1
  L03_DPS w0.254: 314.58,285.5 312.67,283.59 312.67,272.77 308.88,268.97
  L13_SIGNAL w0.203: CSDPS314.D1 346.71,359.41 346.71,364.49 CSDPS314.A2
CSDPS314PS3: length 171.7
  L05_DPS w0.203: CSDPS314.D3 341.86,359.18 340,359.18 339.32,358.5 339.32,357.17 341.3,355.19 341.3,300.41 336.29,295.39 336.29,265.43 341.12,260.59 341.12,255.58 338.72,253.19 338.72,237.64 336.74,235.66 331.03,235.66 330.44,236.25 317.06,236.25 315.81,237.49 306.19,237.49 304.08,239.6 3SA19.2
CSDPS314PS4: length 139.2
  L11_DPS w0.203: CSDPS314.A4 341.63,364.49 350.14,364.49 352.68,361.95 352.68,331.71 339.07,318.1 338.68,318.1 321.05,300.47 321.05,270 320.28,269.24 320.28,266.7 319.27,265.68 3SA21.2
CSDPS314PS5: length 138.5
  L07_DPS w0.203: 3SA17.2 316.88,238.53 317.19,238.23 320.11,238.23 321.35,239.47 321.35,241.43 327.5,247.57 327.5,253.49 330.34,256.34 330.34,303.96 332.38,306 332.38,321.52 336.22,325.36 336.22,354.94 334.31,356.84 334.31,358.52 334.95,359.16 336.8,359.16 CSDPS314.D5
CSDPS314PS7: length 123.4
  L09_DPS w0.203: 3SA8.2 305.3,252.47 314.8,261.97 314.8,279.81 314.54,280.06 314.54,314.67 328.93,329.06 328.93,336.68 331.72,339.47 331.72,357.12 CSDPS314.D7
CSDPS314PS11: length 115.1
  L05_DPS w0.203: 3SA16.2 316.98,268.61 317.49,269.11 317.49,280.04 316.86,280.67 316.86,294.97 317.35,295.45 317.35,298.3 319.02,299.97 319.02,324.99 320.98,326.95 320.98,355.19 319,357.18 319,358.5 319.68,359.18 321.54,359.18 CSDPS314.D11
CSDPS314PS14: length 160.3
  L11_DPS w0.203: CSDPS314.A14 313.69,364.49 307.04,364.49 306.22,363.68 306.22,347.54 290.77,332.09 290.77,253.45 289.68,252.35 289.68,237.31 291.31,235.69 294.3,235.69 295.85,237.24 298.69,237.24 299.46,238 3SA9.2
CSDPS314PS15: length 158
  L09_DPS w0.203: 3SA23.2 313.41,236.59 312.28,235.46 306.57,235.46 303.74,232.63 303.03,232.63 300.21,235.46 292.34,235.46 290.16,237.64 290.16,239.63 291.07,240.54 291.07,247.4 290.31,248.16 290.31,256.92 290.7,257.3 290.7,264.16 290.44,264.41 290.44,326.3 311.4,347.26 311.4,357.12 CSDPS314.D15
CSDPS319GS1: length 160
  L09_DPS w0.203: CSDPS319.D2 161.54,51.82 161.54,62.74 174.24,75.44 174.24,79.38 183.51,88.65 186.69,88.65 193.99,95.95 193.99,99.25 197.61,102.87 201.68,102.87 230.76,131.95 230.76,136.78 231.65,137.67 231.65,142.24 229.24,144.65 229.24,161.04 230.26,162.05 230.26,167.13 234.32,171.2 5SA24.2
CSDPS319GS3: length 226.3
  L05_DPS w0.203: CSDPS319.D4 166.6,49.76 164.59,49.76 163.83,50.52 163.83,70.74 163.88,70.79 163.88,106.4 185.55,128.07 195.5,128.07 216.16,148.72 216.16,162.28 211.08,167.36 211.08,174.47 212.68,176.07 212.68,179.83 211.49,181.03 211.49,183.59 209.68,185.39 209.68,190.14 210.41,190.87 210.41,202.08 213.21,204.88 218.47,204.88 219.99,203.35 236.83,203.35 239.49,200.69 5SA15.2
CSDPS319GS6: length 169.9
  L11_DPS w0.203: 5SA10.2 235.03,171.42 229.88,166.27 229.88,162.38 229.19,161.7 229.19,142.79 231.37,140.61 231.37,137.24 230.4,136.27 230.4,132 198.73,100.33 197.43,100.33 196.9,99.8 196.9,93.8 194.31,91.21 189.38,91.21 179.4,81.23 179.4,42.67 178.64,41.91 171.45,41.91 CSDPS319.A5
CSDPS319GS9: length 214.9
  L09_DPS w0.203: CSDPS319.D10 181.86,51.82 181.86,61.47 185.93,65.53 195.96,65.53 236.85,106.43 241.81,106.43 249.68,114.3 249.68,138.94 250.83,140.09 250.83,173.23 249.81,174.24 249.81,192.53 248.54,193.8 233.3,193.8 232.54,194.56 231.27,194.56 230.51,193.8 225.43,193.8 222.89,191.26 222.89,189.74 223.4,189.23 5SA7.2
CSDPS319GS11: length 172.7
  L05_DPS w0.203: 5SA20.2 223.49,179.76 223.24,179.5 223.24,177.85 225.58,175.51 232.26,175.51 232.99,176.25 234.9,176.25 238.51,172.64 238.51,144.25 237.79,143.54 237.79,140.94 199.24,102.39 199.24,95.99 184.15,80.9 184.15,50.52 184.91,49.76 186.92,49.76 CSDPS319.D12
CSDPS319GS13: length 176.2
  L07_DPS w0.203: 5SA18.2 241.81,192.46 249.86,184.4 249.86,174.42 251.16,173.13 251.16,141 250.14,139.97 250.14,131.01 248.64,129.51 247.95,129.51 206.32,87.88 206.32,76.53 192.02,62.24 192.02,51.82 CSDPS319.D14
CSDPS319GS14: length 200.8
  L11_DPS w0.203: 5SA22.2 236.53,195.43 237.5,194.46 248.7,194.46 249.99,193.17 249.99,173.66 250.8,172.85 250.8,167.84 250.55,167.59 250.55,118.8 207.47,75.72 207.47,45.52 203.86,41.91 191.77,41.91 CSDPS319.A13
CSDPS319GS15: length 178.8
  L03_DPS w0.203: CSDPS319.D16 197.18,51.74 197.18,102.63 199.65,105.1 201.44,105.1 206.97,110.63 206.97,112.33 227.37,132.73 228.47,132.73 230.06,134.32 230.06,136.08 231.46,137.48 233.17,137.48 241.44,145.75 241.44,164.02 240.61,164.85 240.61,189.78 238.52,191.87 5SA2.2
  L13_SIGNAL w0.203: CSDPS319.D16 197.1,51.82 194.82,51.82 194.31,51.31 194.31,44.45 CSDPS319.A15
CSDPS319P1: length 10.2
  L09_DPS w0.076: 233.43,178.81 233.43,181.85 233.25,182.03 231.48,182.03 v2(231.16,181.7)
  L09_DPS w0.203: 233.43,178.81 233.43,176.39 233.04,176 5SA23.1
  BOTTOM w0.508: UNK5CA36.1 v3(225.3,150.98)
  vias: v2(228.56,179.11) v2(229.86,181.06) v2(229.86,180.41) v2(230.5,181.7) v2(230.5,181.06) v2(231.16,181.06) v2(231.81,179.11) v3(225.3,153.01)
CSDPS319P3: length 12.5
  L05_DPS w0.076: v2(231.81,186.91) 232.13,187.23 236.07,187.23
  L05_DPS w0.203: 236.07,187.23 236.1,187.23 236.98,188.11 236.98,189.46 238.98,191.46 5SA16.1
  BOTTOM w0.508: UNK5CA27.1 v3(225.3,155.04)
  vias: v2(235.06,190.16) v3(225.3,157.07)
CSDPS319P6: length 7.8
  L11_DPS w0.076: 233.43,179.45 233.43,180.54 233.24,180.73 232.78,180.73 v2(232.46,181.06)
  L11_DPS w0.203: 233.43,179.45 233.43,177.77 234.24,176.96 5SA9.1
  BOTTOM w0.508: UNK5CA25.1 v3(220.48,150.98)
  vias: v2(229.86,179.76) v2(230.5,180.41) v2(230.5,179.76) v2(231.16,179.76) v2(231.81,181.7) v2(232.46,181.7) v3(220.48,153.01)
CSDPS319P9: length 6.4
  L09_DPS w0.076: v2(227.91,182.35) 227.58,182.68 225.55,182.68
  L09_DPS w0.203: 225.55,182.68 224.67,182.68 223.91,183.44 5SA8.1
  BOTTOM w0.508: UNK5CA8.1 v3(239.75,152.5)
  vias: v2(232.46,183) v2(233.76,186.26) v2(235.06,183) v3(239.75,154.53)
CSDPS319P11: length 8.9
  L05_DPS w0.203: 5SA19.1 224.08,189.47 224.76,190.16 v2(226.61,190.16)
  BOTTOM w0.508: UNK5CA35.1 v3(244.57,152.5)
  vias: v2(226.61,185.61) v2(227.91,185.61) v2(233.11,184.96) v3(244.57,154.53)
CSDPS319P13: length 3.8
  L07_DPS w0.203: 5SA17.1 234.72,191.77 v2(233.11,190.16)
  BOTTOM w0.508: UNK5CA21.1 v3(230.12,150.98)
  vias: v2(227.91,186.26) v2(227.91,184.96) v2(228.56,187.56) v2(228.56,179.76) v2(229.21,179.76) v2(231.15,190.16) v2(231.8,190.16) v2(231.81,181.06) v2(232.46,190.16) v2(232.46,187.56) v2(232.46,186.26) v2(232.46,184.3) v2(233.11,184.3) v2(233.76,183.65) v3(230.12,153.01)
CSDPS319P14: length 11.2
  L11_DPS w0.076: v2(231.81,187.56) 231.48,187.88 231.02,187.88 230.83,188.07 230.83,191.08
  L11_DPS w0.203: 5SA21.1 232.97,193.95 232.31,193.29 230.76,193.29 230.21,192.74 230.21,192.15 230.83,191.53 230.83,191.08
  BOTTOM w0.508: UNK5CA23.1 v3(239.75,147.83)
  vias: v3(239.75,149.86)
CSDPS319P15: length 7.6
  L03_DPS w0.203: v2(230.5,190.16) 230,190.66 230,191.13 230.23,191.36 5SA1.1
  BOTTOM w0.508: UNK5CA1.1 v3(220.48,155.04)
  vias: v2(228.56,181.7) v2(228.56,181.06) v2(229.21,186.26) v2(229.21,185.61) v2(229.21,184.96) v2(229.86,184.96) v2(230.5,186.91) v2(230.5,186.26) v2(230.5,185.61) v2(230.5,184.3) v2(231.16,186.26) v2(231.16,185.61) v2(231.16,184.96) v2(231.16,184.3) v2(231.81,184.96) v3(220.48,157.07)
CSDPS319PS1: length 159.6
  L09_DPS w0.203: CSDPS319.D1 161.04,51.82 161.04,62.95 173.74,75.65 173.74,79.59 189.07,94.92 190.68,94.92 191.9,96.14 191.9,99.57 192.66,100.33 193.29,100.33 196.47,103.5 201.29,103.5 220.73,122.94 220.73,123.85 227.63,130.75 227.66,130.75 230.17,133.27 230.17,136.91 231.14,137.88 231.14,142.03 228.73,144.44 228.73,161.29 229.75,162.31 229.75,167.39 233.04,170.68 5SA23.2
CSDPS319PS3: length 220.1
  L05_DPS w0.203: CSDPS319.D3 166.37,52.07 166.37,104.37 188.8,126.8 196.75,126.8 219.16,149.2 219.16,165.99 220.55,167.39 220.55,171.15 217.05,174.65 217.05,175.54 215.8,176.78 214.12,176.78 213.37,177.54 213.37,180.62 214,181.25 214,186.31 212.81,187.5 212.81,192.43 211.02,194.21 211.02,201.83 213.39,204.19 217.91,204.19 219.23,202.87 235.53,202.87 238.98,199.42 5SA16.2
CSDPS319PS6: length 163.5
  L11_DPS w0.203: 5SA9.2 234.24,171.78 230.48,168.02 228.76,168.02 227.56,166.83 227.56,161.93 228.61,160.88 228.61,146.86 227.3,145.56 227.3,129.93 201.23,103.86 197.87,103.86 194.49,100.48 194.49,95.76 190.55,91.82 188.85,91.82 178.82,81.79 178.82,45.21 178.03,44.42 173.96,44.42 CSDPS319.A6
CSDPS319PS9: length 208.8
  L09_DPS w0.203: 5SA8.2 223.91,190.5 226.45,193.04 232.29,193.04 232.67,192.66 248.16,192.66 249.31,191.51 249.31,173.74 250.32,172.72 250.32,140.3 249.17,139.15 249.17,117.98 238.12,106.93 236.64,106.93 195.75,66.04 185.72,66.04 181.36,61.68 181.36,51.82 CSDPS319.D9
CSDPS319PS11: length 167.3
  L05_DPS w0.203: 5SA19.2 224.08,179.58 226.14,177.52 235.36,177.52 236.92,175.96 236.92,175.58 238.99,173.51 238.99,143.48 239.8,142.67 239.8,141.35 201.9,103.45 201.9,96.09 200.84,95.02 199.95,95.02 186.69,81.76 186.69,52.07 CSDPS319.D11
CSDPS319PS13: length 175.3
  L07_DPS w0.203: 5SA17.2 240.39,191.77 249.26,182.91 249.26,174.37 250.5,173.13 250.5,141.43 249.17,140.1 249.17,132.28 244.25,127.36 241.93,127.36 205.49,90.91 205.49,76.71 191.49,62.71 191.49,51.79 CSDPS319.D13
CSDPS319PS14: length 194.6
  L11_DPS w0.203: 5SA21.2 248.39,193.95 249.51,192.84 249.51,172.95 250.27,172.19 250.27,168.02 249.74,167.49 249.74,118.71 206.65,75.62 206.65,46.63 204.65,44.63 194.49,44.63 CSDPS319.A14
CSDPS319PS15: length 171.5
  L03_DPS w0.203: 5SA1.2 237.02,191.36 239.51,188.87 239.51,156.26 240.55,155.22 240.55,146.25 235.48,141.19 233.85,141.19 230.62,137.96 229.3,137.96 226.86,135.52 226.86,134.28 196.52,103.94 196.52,51.74 CSDPS319.D15
  L13_SIGNAL w0.203: CSDPS319.A16 196.85,44.45 196.85,49.53 CSDPS319.D15
CSDPS323GS1: length 144.2
  L09_DPS w0.203: 6SA24.2 274.32,171.2 270.26,167.13 270.26,162.05 269.24,161.04 269.24,145.03 271.78,142.49 271.78,137.92 270.76,136.91 270.76,107.44 263.14,99.82 263.14,95.76 249.94,82.55 246.13,82.55 242.82,79.25 242.82,75.31 235.2,67.69 235.2,51.82 CSDPS323.D2
CSDPS323GS3: length 206.5
  L05_DPS w0.203: CSDPS323.D4 240.26,49.76 238.25,49.76 237.49,50.52 237.49,110.62 254.71,127.84 254.71,136.88 256.16,138.33 256.16,162.28 251.08,167.36 251.08,174.47 252.68,176.07 252.68,179.83 251.49,181.03 251.49,183.59 249.68,185.39 249.68,190.14 250.41,190.87 250.41,202.08 253.21,204.88 258.47,204.88 259.99,203.35 276.83,203.35 279.49,200.69 6SA15.2
CSDPS323GS6: length 152.3
  L11_DPS w0.203: CSDPS323.A5 245.11,41.91 252.3,41.91 253.06,42.67 253.06,81.36 268.1,96.39 268.1,101.22 270.4,103.53 270.4,136.27 271.37,137.24 271.37,140.61 269.19,142.79 269.19,161.7 269.88,162.38 269.88,166.27 275.03,171.42 6SA10.2
CSDPS323GS9: length 197.6
  L09_DPS w0.203: CSDPS323.D10 255.52,51.82 255.52,61.72 265.43,71.63 274.8,71.63 290.83,87.66 290.83,173.23 289.81,174.24 289.81,192.53 288.54,193.8 273.3,193.8 272.54,194.56 271.27,194.56 270.51,193.8 265.43,193.8 262.89,191.26 262.89,189.74 263.4,189.23 6SA7.2
CSDPS323GS11: length 159.2
  L05_DPS w0.203: 6SA20.2 263.49,179.76 263.24,179.5 263.24,177.85 265.58,175.51 272.26,175.51 272.99,176.25 274.9,176.25 278.51,172.64 278.51,143.78 278,143.28 278,137.77 278.61,137.16 278.61,125.4 257.81,104.6 257.81,50.52 258.57,49.76 260.58,49.76 CSDPS323.D12
CSDPS323GS13: length 163.1
  L07_DPS w0.203: 6SA18.2 281.81,192.46 289.86,184.4 289.86,174.42 291.16,173.13 291.16,138.99 290.4,138.23 290.4,124.87 270.13,104.6 268.05,104.6 265.68,102.23 265.68,51.82 CSDPS323.D14
CSDPS323GS14: length 186.9
  L11_DPS w0.203: CSDPS323.A13 265.43,41.91 277.52,41.91 278.79,43.18 278.79,77.83 290.55,89.59 290.55,167.59 290.8,167.84 290.8,172.85 289.99,173.66 289.99,193.17 288.7,194.46 277.5,194.46 276.53,195.43 6SA22.2
CSDPS323GS15: length 165
  L03_DPS w0.203: 6SA2.2 278.52,191.87 280.61,189.78 280.61,164.85 281.44,164.02 281.44,144.95 280.23,143.74 280.23,140.47 282.8,137.9 282.8,113.03 275.59,105.82 274.31,105.82 270.84,102.35 270.84,51.74 CSDPS323.D16
  L13_SIGNAL w0.203: CSDPS323.D16 270.76,51.82 268.48,51.82 267.97,51.31 267.97,44.45 CSDPS323.A15
CSDPS323P1: length 10.2
  L09_DPS w0.076: 273.43,178.81 273.43,181.85 273.25,182.03 271.48,182.03 v2(271.16,181.7)
  L09_DPS w0.203: 6SA23.1 273.04,176 273.43,176.39 273.43,178.81
  BOTTOM w0.508: UNK6CA36.1 v3(265.3,150.98)
  vias: v2(268.55,179.11) v2(269.85,181.06) v2(269.85,180.41) v2(270.5,181.7) v2(270.5,181.06) v2(271.16,181.06) v2(271.81,179.11) v3(265.3,153.01)
CSDPS323P3: length 12.5
  L05_DPS w0.076: v2(271.81,186.91) 272.13,187.23 276.07,187.23
  L05_DPS w0.203: 276.07,187.23 276.1,187.23 276.98,188.11 276.98,189.46 278.98,191.46 6SA16.1
  BOTTOM w0.508: UNK6CA27.1 v3(265.3,155.04)
  vias: v2(275.06,190.16) v3(265.3,157.07)
CSDPS323P6: length 7.8
  L11_DPS w0.076: v2(272.46,181.06) 272.78,180.73 273.24,180.73 273.43,180.54 273.43,179.45
  L11_DPS w0.203: 273.43,179.45 273.43,177.77 274.24,176.96 6SA9.1
  BOTTOM w0.508: UNK6CA25.1 v3(260.48,150.98)
  vias: v2(269.85,179.76) v2(270.5,180.41) v2(270.5,179.76) v2(271.16,179.76) v2(271.81,181.7) v2(272.46,181.7) v3(260.48,153.01)
CSDPS323P9: length 6.4
  L09_DPS w0.076: v2(267.9,182.35) 267.58,182.68 265.55,182.68
  L09_DPS w0.203: 6SA8.1 263.91,183.44 264.67,182.68 265.55,182.68
  BOTTOM w0.508: UNK6CA8.1 v3(279.75,152.5)
  vias: v2(272.46,183) v2(273.76,186.26) v2(275.06,183) v3(279.75,154.53)
CSDPS323P11: length 8.9
  L05_DPS w0.203: 6SA19.1 264.08,189.47 264.76,190.16 v2(266.61,190.16)
  BOTTOM w0.508: UNK6CA35.1 v3(284.57,152.5)
  vias: v2(266.61,185.61) v2(267.9,185.61) v2(273.11,184.96) v3(284.57,154.53)
CSDPS323P13: length 3.8
  L07_DPS w0.203: 6SA17.1 274.72,191.77 v2(273.11,190.16)
  BOTTOM w0.508: UNK6CA21.1 v3(270.12,150.98)
  vias: v2(267.9,186.26) v2(267.9,184.96) v2(268.55,187.56) v2(268.55,179.76) v2(269.2,179.76) v2(271.15,190.16) v2(271.8,190.16) v2(271.81,181.06) v2(272.46,190.16) v2(272.46,187.56) v2(272.46,186.26) v2(272.46,184.3) v2(273.11,184.3) v2(273.76,183.65) v3(270.12,153.01)
CSDPS323P14: length 11.2
  L11_DPS w0.076: 270.83,191.08 270.83,188.07 271.02,187.88 271.48,187.88 v2(271.81,187.56)
  L11_DPS w0.203: 270.83,191.08 270.83,191.53 270.21,192.15 270.21,192.74 270.76,193.29 272.31,193.29 272.97,193.95 6SA21.1
  BOTTOM w0.508: UNK6CA23.1 v3(279.75,147.83)
  vias: v3(279.75,149.86)
CSDPS323P15: length 7.6
  L03_DPS w0.203: v2(270.5,190.16) 270,190.66 270,191.13 270.23,191.36 6SA1.1
  BOTTOM w0.508: UNK6CA1.1 v3(260.48,155.04)
  vias: v2(268.55,181.7) v2(268.55,181.06) v2(269.2,186.26) v2(269.2,185.61) v2(269.2,184.96) v2(269.85,184.96) v2(270.5,186.91) v2(270.5,186.26) v2(270.5,185.61) v2(270.5,184.3) v2(271.16,186.26) v2(271.16,185.61) v2(271.16,184.96) v2(271.16,184.3) v2(271.81,184.96) v3(260.48,157.07)
CSDPS323PS1: length 144.9
  L09_DPS w0.203: CSDPS323.D1 234.67,51.79 234.67,67.91 242.29,75.53 242.29,79.47 245.9,83.09 249.71,83.09 262.64,96.01 262.64,100.08 270.26,107.7 270.26,123.95 268.99,125.22 268.99,135.85 271.27,138.13 271.27,142.28 268.73,144.82 268.73,161.29 269.75,162.31 269.75,167.39 273.04,170.68 6SA23.2
CSDPS323PS3: length 201.5
  L05_DPS w0.203: 6SA16.2 278.98,199.42 275.53,202.87 259.23,202.87 257.91,204.19 253.39,204.19 251.02,201.83 251.02,194.21 252.81,192.43 252.81,187.5 254,186.31 254,181.25 253.36,180.62 253.36,177.54 254.12,176.78 255.8,176.78 257.05,175.54 257.05,174.65 260.55,171.15 260.55,167.39 259.16,165.99 259.16,139.37 256.49,136.7 256.49,128.93 240.03,112.47 240.03,52.07 CSDPS323.D3
CSDPS323PS6: length 146.6
  L11_DPS w0.203: CSDPS323.A6 247.62,44.42 251.69,44.42 252.48,45.21 252.48,84.84 262.92,95.28 262.92,100.03 267.3,104.42 267.3,145.56 268.6,146.86 268.6,160.88 267.56,161.93 267.56,166.83 268.76,168.02 270.48,168.02 274.24,171.78 6SA9.2
CSDPS323PS9: length 193.6
  L09_DPS w0.203: 6SA8.2 263.91,190.5 266.45,193.04 272.29,193.04 272.67,192.66 288.16,192.66 289.31,191.51 289.31,173.74 290.32,172.72 290.32,87.87 274.59,72.14 265.22,72.14 255.02,61.93 255.02,51.82 CSDPS323.D9
CSDPS323PS11: length 152.6
  L05_DPS w0.203: CSDPS323.D11 260.35,52.07 260.35,103.33 279.22,122.2 279.22,135.86 279.45,136.09 279.45,142.42 278.99,142.88 278.99,173.51 276.92,175.58 276.92,175.96 275.36,177.52 266.14,177.52 264.08,179.58 6SA19.2
CSDPS323PS13: length 160
  L07_DPS w0.203: 6SA17.2 280.39,191.77 289.26,182.91 289.26,174.37 290.5,173.13 290.5,139.26 289.74,138.5 289.74,127.89 265.15,103.3 265.15,51.79 CSDPS323.D13
CSDPS323PS14: length 180.3
  L11_DPS w0.203: CSDPS323.A14 268.15,44.63 277.77,44.63 277.98,44.83 277.98,78.16 289.74,89.92 289.74,167.49 290.27,168.02 290.27,172.19 289.51,172.95 289.51,192.84 288.39,193.95 6SA21.2
CSDPS323PS15: length 157
  L03_DPS w0.203: CSDPS323.D15 270.18,51.74 270.18,103.94 280.97,114.73 280.97,135.23 279.55,136.65 279.55,144.2 280.55,145.19 280.55,155.22 279.51,156.26 279.51,188.87 277.02,191.36 6SA1.2
  L13_SIGNAL w0.203: CSDPS323.D15 270.51,49.53 270.51,44.45 CSDPS323.A16
CSDPS426GS1: length 122.6
  L03_DPS w0.203: CSDPS426.D2 271.78,319.84 266.31,314.37 266.31,289.68 265.18,288.54 265.18,254.76 264.54,254.13 264.54,252.48 264.87,252.15 2SA2.2
  L13_SIGNAL w0.203: CSDPS426.A1 273.3,366.78 271.02,366.78 270.51,366.27 270.51,359.41 CSDPS426.D2
CSDPS426GS3: length 186
  L05_DPS w0.203: CSDPS426.D4 267.72,359.16 269.75,359.16 270.26,358.65 270.26,335.28 296.93,308.61 296.93,297.69 297.81,296.8 297.81,292.83 297.05,292.06 297.05,267.21 298.45,265.8 298.45,264.03 302.66,259.82 302.66,253.01 299.18,249.53 299.18,237.19 296.36,234.37 290.36,234.37 289.12,235.61 279.65,235.61 279.06,235.03 269.72,235.03 268.83,235.92 264.89,235.92 262.96,237.85 262.96,239.55 263.49,240.08 2SA20.2
CSDPS426GS4: length 126.6
  L11_DPS w0.203: 2SA22.2 280.54,265.43 281.55,266.45 281.55,338.84 279.53,340.87 279.53,363.96 276.45,367.03 270.51,367.03 CSDPS426.A3
CSDPS426GS5: length 145.1
  L07_DPS w0.203: 2SA18.2 275.15,237.92 276.12,236.96 278.61,236.96 279.14,237.49 281.55,237.49 282.82,238.76 282.82,240.77 289.58,247.52 289.58,252.4 290.85,253.67 290.85,318.29 263.3,345.84 263.3,356.46 CSDPS426.D6
CSDPS426GS7: length 124.3
  L09_DPS w0.203: 2SA7.2 264.03,248.56 264.33,248.87 264.33,253.28 274.26,263.22 274.26,272.14 272.99,273.41 272.99,284.18 274.01,285.19 274.01,289.87 272.67,291.21 272.67,297.31 272.8,297.43 272.8,321.82 257.56,337.06 257.56,357.12 CSDPS426.D8
CSDPS426GS11: length 127.1
  L05_DPS w0.203: 2SA15.2 277.49,267.63 278.67,268.81 279.62,268.81 280.91,270.09 280.91,301.9 250.19,332.61 250.19,358.65 249.68,359.16 247.4,359.16 CSDPS426.D12
CSDPS426GS14: length 169.6
  L11_DPS w0.203: CSDPS426.A13 242.57,367.03 232.97,367.03 232.05,366.12 232.05,311.8 240.33,303.53 240.33,302.99 250.27,293.05 250.27,253.82 249.17,252.73 249.17,235.56 250.57,234.16 253.72,234.16 256.03,236.47 260.73,236.47 261.74,237.49 2SA10.2
CSDPS426GS15: length 158.6
  L09_DPS w0.203: CSDPS426.D16 237.24,357.12 237.24,332.49 249.94,319.79 249.94,264.28 250.24,263.97 250.24,257.56 249.8,257.12 249.8,240.96 249.15,240.31 249.15,237.38 252.34,234.19 259.46,234.19 262.45,231.19 268.4,231.19 269.71,232.5 271.39,234.19 273.68,234.19 274.31,234.82 274.31,235.84 274.06,236.09 2SA24.2
CSDPS426P1: length 5.7
  L03_DPS w0.203: v2(270.5,250.15) 270.04,250.15 268.86,251.33 266.83,251.33 266.52,251.64 2SA1.1
  BOTTOM w0.508: UNK2CA1.1 v3(213.61,295.91)
  vias: v2(268.55,241.7) v2(268.55,241.06) v2(269.2,246.26) v2(269.2,245.61) v2(269.2,244.96) v2(269.85,244.96) v2(270.5,246.91) v2(270.5,246.26) v2(270.5,245.61) v2(270.5,244.3) v2(271.16,246.26) v2(271.16,245.61) v2(271.16,244.96) v2(271.16,244.3) v2(271.81,244.96) v3(213.61,297.94)
CSDPS426P3: length 8.9
  L05_DPS w0.203: 2SA19.1 264.08,249.47 264.76,250.15 v2(266.61,250.15)
  BOTTOM w0.508: UNK2CA35.1 v3(283.87,275.59)
  vias: v2(266.61,245.61) v2(267.9,245.61) v2(273.11,244.96) v3(283.87,277.62)
CSDPS426P4: length 10
  L11_DPS w0.076: v2(271.81,247.56) 272.13,247.23 276.07,247.23
  L11_DPS w0.203: 2SA21.1 279.27,248.67 277.83,247.23 276.07,247.23
  BOTTOM w0.508: UNK2CA23.1 v3(261.51,275.59)
  vias: v3(261.51,277.62)
CSDPS426P5: length 5.2
  L07_DPS w0.203: 2SA17.1 269.62,238.53 269.2,238.94 v2(269.2,239.75)
  BOTTOM w0.508: UNK2CA21.1 v3(255.42,279.65)
  vias: v2(267.9,246.26) v2(267.9,244.96) v2(268.55,247.56) v2(268.55,239.75) v2(271.15,250.15) v2(271.8,250.15) v2(271.81,241.05) v2(272.46,250.15) v2(272.46,247.56) v2(272.46,246.26) v2(272.46,244.3) v2(273.11,250.15) v2(273.11,244.3) v2(273.76,243.65) v3(255.42,281.69)
CSDPS426P7: length 5.9
  L09_DPS w0.076: v2(267.9,242.35) 267.58,242.68 265.7,242.68 265.55,242.82
  L09_DPS w0.203: 265.55,242.82 265.3,243.08 2SA8.1
  BOTTOM w0.508: UNK2CA8.1 v3(283.87,279.65)
  vias: v2(272.46,243) v2(273.76,246.26) v2(275.06,243) v3(283.87,281.69)
CSDPS426P11: length 8
  L05_DPS w0.076: v2(271.81,246.91) 272.13,247.23 275.97,247.23
  L05_DPS w0.203: 275.97,247.23 276.1,247.23 276.98,248.11 2SA16.1
  BOTTOM w0.508: UNK2CA27.1 v3(273.93,275.59)
  vias: v2(275.06,250.15) v3(273.93,277.62)
CSDPS426P14: length 10.8
  L11_DPS w0.076: v2(272.46,241.06) 272.78,240.73 273.24,240.73 273.43,240.54 273.43,238.94 273.3,238.81
  L11_DPS w0.203: 2SA9.1 272.49,238 273.3,238.81
  BOTTOM w0.508: UNK2CA25.1 v3(255.42,275.59)
  vias: v2(269.85,239.75) v2(270.5,240.4) v2(270.5,239.76) v2(271.16,239.75) v2(271.81,241.7) v2(272.46,241.7) v3(255.42,277.62)
CSDPS426P15: length 7.1
  L09_DPS w0.076: v2(271.16,241.7) 271.48,242.03 273.24,242.03 273.43,241.84 273.43,239.4 273.41,239.38
  L09_DPS w0.203: 273.41,239.38 2SA23.1
  BOTTOM w0.508: UNK2CA36.1 v3(267.6,275.59)
  vias: v2(268.55,239.1) v2(269.85,241.05) v2(269.85,240.41) v2(270.5,241.7) v2(270.5,241.05) v2(271.16,241.05) v2(271.81,239.1) v3(267.6,277.62)
CSDPS426PS1: length 126.5
  L03_DPS w0.203: 2SA1.2 264.26,251.64 263.14,252.76 263.14,253.87 264.54,255.27 264.54,264.29 263.02,265.81 263.02,282.83 264.16,283.97 264.16,289.05 265.05,289.94 265.05,304.55 264.29,305.31 264.29,317.17 270.55,323.43 270.55,358.58 271.26,359.3 273.16,359.3 CSDPS426.D1
  L13_SIGNAL w0.203: CSDPS426.A2 273.05,364.49 273.05,359.41 CSDPS426.D1
CSDPS426PS3: length 175.3
  L05_DPS w0.203: CSDPS426.D3 269.24,335.03 294.77,309.5 294.77,294.13 296.29,292.61 296.29,265.43 300.99,260.73 300.99,255.45 298.72,253.19 298.72,237.64 296.74,235.66 291.03,235.66 290.44,236.25 277.06,236.25 275.81,237.49 266.19,237.49 264.08,239.6 2SA19.2
