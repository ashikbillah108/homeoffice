# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S3_1AWG_SHARE+: length 17.9
  L25_SIGNAL w0.091: UNK3K34.4 190.27,266.79 190.27,280.28 UNK3K107.2
S3_3V3_ETH_MUX: length 7.8
  BOTTOM w0.254: UNK3R990.1 UNK3C1081.1 v2(324.55,273.3) ; 316.97,269.95 UNK3C1077.1 UNK3R984.1 ; v2(323.75,269.49) UNK3C1080.1 UNK3R987.1
  BOTTOM w0.305: UNK3U452.10 324.08,272.67 UNK3R990.1 ; UNK3R984.1 317.01,268.86 UNK3U450.10 ; UNK3U451.10 323.27,268.86 UNK3R987.1
  BOTTOM w0.508: v2(316.97,270.47) 316.97,269.95
S3_3V3_RX0_MIPI: length 13.4
  TOP w0.305: UNK3R661.2 292.78,248.06 293.12,247.72 v1(293.66,247.72)
  TOP w0.381: v1(293.66,247.72) 294.36,247.72 294.87,248.23 294.87,251.5 v1(294.66,251.72)
  BOTTOM w0.381: v1(293.66,247.72) UNK3C922.2
  BOTTOM w0.508: UNK3BDB5.2 291.5,245.91 291.82,245.59 293.3,245.59 293.66,245.95 UNK3C922.2
S3_3V3_RX1_MIPI: length 13.4
  TOP w0.305: UNK3R663.2 292.78,236.49 293.12,236.15 v1(293.66,236.15)
  TOP w0.381: v1(293.66,236.15) 294.36,236.15 294.87,236.66 294.87,239.94 v1(294.66,240.15)
  BOTTOM w0.381: v1(293.66,236.15) UNK3C923.2
  BOTTOM w0.508: UNK3C923.2 293.66,234.38 293.3,234.02 291.82,234.02 291.5,234.35 UNK3BDB6.2
S3_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK3U31.4 305.48,233.24 304.6,232.36 UNK3C262.1
  BOTTOM w0.305: UNK3BD21.2 UNK3C262.1
S3_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 309.83,270.83 UNK3C1074.1 UNK3R981.1
  BOTTOM w0.356: UNK3U449.10 309.86,269.73 UNK3R981.1
  BOTTOM w0.508: UNK3BD1728.2 309.83,270.83
S3_AWG_2SHARE+: length 212.9
  L21_SIGNAL w0.102: 186.37,277.33 186.47,277.43 UNK3K107.4 ; 324.81,269.89 324.52,270.18 v2(324.3,270.18)
  L21_SIGNAL w0.105: 186.37,277.33 186.37,275.57 187.51,274.43 211.41,274.43 212.29,275.31 212.29,283.74 213.34,284.79 217.74,284.79 218.33,285.38 228.15,285.38 229.01,286.25 229.01,290.12 231.57,292.68 239.62,292.68 242.1,295.16 255.91,295.16 257.13,293.94 257.13,286.93 258.64,285.42 272.37,285.42 273.27,284.51 276.66,284.51 279.12,286.97 289.39,286.97 291.34,288.93 303.34,288.93 306.22,291.81 308.16,291.81 309.81,290.16 309.81,288.03 312.81,285.04 315.98,285.04 320.02,289.07 329.56,289.07 332.81,285.82 332.81,275.68 334.78,273.71 334.78,271.34 333.96,270.52 328.04,270.52 327.4,269.89 324.81,269.89
  BOTTOM w0.132: v2(324.3,270.18) 324.51,270.18 324.64,270.05 324.64,269.54 UNK3U451.1
S3_AWG_2SHARE-: length 212.9
  L21_SIGNAL w0.102: UNK3K107.5 185.89,277.43 186,277.33 ; v2(324.78,270.66) 324.78,270.44 324.96,270.26
  L21_SIGNAL w0.105: 324.96,270.26 327.25,270.26 327.88,270.89 333.81,270.89 334.41,271.5 334.41,273.56 332.44,275.53 332.44,285.67 329.41,288.7 320.17,288.7 316.14,284.67 312.65,284.67 309.45,287.88 309.45,290 308.01,291.44 306.38,291.44 303.49,288.56 291.49,288.56 289.54,286.6 279.27,286.6 276.81,284.14 273.12,284.14 272.21,285.05 258.49,285.05 256.76,286.78 256.76,293.79 255.76,294.79 242.25,294.79 239.77,292.31 231.72,292.31 229.38,289.96 229.38,286.09 228.3,285.02 218.48,285.02 217.89,284.43 213.49,284.43 212.66,283.59 212.66,275.15 211.57,274.06 187.36,274.06 186,275.42 186,276.08 185.89,276.18 185.68,276.18 185.58,276.29 185.58,276.5 185.68,276.6 185.89,276.6 186,276.71 186,277.33
  BOTTOM w0.132: UNK3U451.2 325.02,269.57 325.02,270.2 324.78,270.44 v2(324.78,270.66)
S3_AWG_3SHARE+: length 19.2
  L17_SIGNAL w0.079: 186.28,279.71 186.28,293.95
  L17_SIGNAL w0.091: 186.28,279.71 186.36,279.63 UNK3K107.3 ; 186.28,293.95 186.36,294.02 K111.2
S3_AWG_3SHARE-: length 19.2
  L17_SIGNAL w0.079: 186.09,293.95 186.09,279.71
  L17_SIGNAL w0.091: 186.09,293.95 186.01,294.02 K111.7 ; 186.09,279.71 186.01,279.63 UNK3K107.6
S3_DVDD_DDR_RX: length 13.6
  L17_SIGNAL w0.508: UNK3K39.3 306.46,228.57 309.79,231.91 309.79,238.4
  vias: v2(307.25,239.1) v2(307.9,240.4)
S3_DVDD_DDR_TX: length 18.3
  L23_SIGNAL w0.508: UNK3K39.6 308.06,224.54 309.83,224.54 310.72,225.43 310.72,237.26 309.87,238.11
  vias: v2(307.9,239.1) v2(308.55,240.4)
S3_ETH_RN_AB_CASE: length 31.5
  TOP w0.381: SITE3.H16 v2(316.35,244.96)
  L15_SIGNAL w0.508: 316.97,244.96 v2(316.35,244.96)
  L15_SIGNAL w0.889: 317.35,244.96 316.97,244.96 ; 325.12,265.76 325.9,266.54 v2(325.9,267.41)
  L15_SIGNAL w1.016: 317.35,244.96 318.99,246.59 318.99,263.68 319.66,264.35 324.55,264.35 325.12,264.92 325.12,265.76
  BOTTOM w0.305: v2(325.9,267.41) 325.6,267.72 UNK3U451.7
S3_ETH_RP_AB_CASE: length 31
  L15_SIGNAL w0.305: v2(315.05,244.96) 316.52,246.42
  L15_SIGNAL w0.889: 323.6,266.46 324.55,267.41 v2(324.79,267.41) ; 316.52,246.42 317.02,246.92
  L15_SIGNAL w1.016: 317.02,246.92 317.02,265.77 317.7,266.46 323.6,266.46
  BOTTOM w0.305: v2(324.79,267.41) 325.1,267.72 UNK3U451.8
S3_ETH_TN_AB_CASE: length 26.2
  TOP w0.381: SITE3.G15 v2(316.35,245.61)
  L21_SIGNAL w0.305: 316.81,245.48 316.48,245.48 v2(316.35,245.61)
  L21_SIGNAL w0.508: 316.81,245.48 317.39,245.48 319.03,247.12
  L21_SIGNAL w0.889: 319.64,266.7 v2(319.64,267.41)
  L21_SIGNAL w1.016: 319.03,247.12 319.03,265.82 319.64,266.43 319.64,266.7
  BOTTOM w0.305: UNK3U450.7 319.33,267.72 v2(319.64,267.41)
S3_ETH_TP_AB_CASE: length 25.5
  L21_SIGNAL w0.305: v2(314.41,245.61) 315.7,245.61 316.49,246.39
  L21_SIGNAL w0.762: 317.07,247.15 317.07,246.97 316.49,246.39
  L21_SIGNAL w0.889: v2(318.52,267.41) 318.09,267.41 317.07,266.4
  L21_SIGNAL w1.016: 317.07,247.15 317.07,266.4
  BOTTOM w0.305: v2(318.52,267.41) 318.83,267.72 UNK3U450.8
S3_M_2V5: length 4.8
  BOTTOM w0.508: UNK3C284.1 UNK3C285.1 ; UNK3C284.1 UNK3MR2.1 ; UNK3C284.1 317.42,293.35 UNK3MU2.6
S3_M_3V2: length 24.3
  BOTTOM w0.381: 307.96,293.87 307.83,293.99 UNK3MU3.7
  BOTTOM w0.508: UNK3MU2.2 318.69,283.18 UNK3C282.1 UNK3C283.1 317.46,283.1 UNK3MR1.1 314.18,283.1 UNK3MU1.5 315.14,284.21 315.14,289.56 314.29,290.41 312.62,290.41 311.53,291.5 UNK3C289.1 309.25,291.5 308.48,292.27 308.48,293.35 307.96,293.87
S3_MUX_3V3: length 1.5
  TOP w0.508: v2(307.1,267.19) v2(307.86,267.19)
  BOTTOM w0.508: v2(307.1,267.19) UNK3R512.1 v2(307.86,267.19)
  vias: v2(290.56,246.46) v2(290.56,234.89) v2(302.48,232.36) v2(309.83,272.29) v2(316.97,271.41)
S3_OUT_RX0_CH0_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(297.22,252.07) 297.05,252.24
  L21_SIGNAL w0.105: 297.05,252.24 297.05,253.92 297.17,254.04 298.32,254.04 298.53,253.83 298.53,253.13 299.24,252.41 300.27,252.41 300.37,252.31 300.37,252.15 300.48,252.05 300.69,252.05 300.79,252.15 300.79,252.31 300.9,252.41 301.1,252.41 301.21,252.31 301.21,252.15 301.31,252.05 301.52,252.05 301.63,252.15 301.63,252.31 301.73,252.41 301.94,252.41 302.05,252.31 302.05,252.15 302.15,252.05 302.36,252.05 302.47,252.15 302.47,252.31 302.57,252.41 305.65,252.41 307.25,250.81 v2(307.25,249.5)
  BOTTOM w0.132: v2(297.22,252.07) 297.06,251.91 297.06,251.37 296.57,250.88 295,250.88 UNK3U408.B2
S3_OUT_RX0_CH0_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 307.62,249.81 307.62,249.03 307.58,248.99 307.58,248.72 307.9,248.4 v2(307.9,248.2)
  L21_SIGNAL w0.102: v2(296.51,252.07) 296.68,252.24
  L21_SIGNAL w0.105: 307.62,249.81 307.62,250.96 305.81,252.78 299.4,252.78 298.89,253.28 298.89,253.98 298.47,254.41 297.02,254.41 296.68,254.08 296.68,252.24
  BOTTOM w0.132: UNK3U408.B1 295.19,251.25 296.41,251.25 296.68,251.52 296.68,251.9 v2(296.51,252.07)
S3_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK3R647.1 295.3,253.77 295.3,253.05 294.94,252.7 294.44,252.7 294.15,252.41 294.15,251.71 UNK3U408.B4
S3_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK3R646.1 294.46,253.86 294.38,253.78 294.38,253.57 294.45,253.5 294.81,253.5 294.92,253.38 294.92,253.21 294.79,253.07 294.28,253.07 293.78,252.57 293.78,251.83 UNK3U408.A4
S3_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK3R647.2 UNK3R646.2 UNK3C309.1
S3_OUT_RX0_CH1_ABC_CASE+: length 20.2
  L19_SIGNAL w0.102: v2(297.22,249.36) 297.05,249.19
  L19_SIGNAL w0.105: v2(306.6,249.5) 305.92,250.19 305,250.19 304.85,250.33 304.57,250.33 304.43,250.19 302.88,250.19 302.59,250.47 302.59,252.13 302.05,252.67 299.22,252.67 298.57,252.02 298.57,248.82 298.01,248.26 297.36,248.26 297.05,248.58 297.05,249.19
  BOTTOM w0.132: v2(297.22,249.36) 297.05,249.53 297.05,250.08 296.56,250.57 295.02,250.57 UNK3U408.D2
S3_OUT_RX0_CH1_ABC_CASE-: length 20.2
  L19_SIGNAL w0.076: 306.41,249.18 306.93,249.18 v2(307.25,248.85)
  L19_SIGNAL w0.102: v2(296.51,249.36) 296.68,249.19
  L19_SIGNAL w0.105: 306.41,249.18 305.77,249.82 302.73,249.82 302.22,250.32 302.22,251.98 301.9,252.31 299.37,252.31 298.93,251.87 298.93,248.67 298.17,247.9 297.21,247.9 296.68,248.42 296.68,249.19
  BOTTOM w0.132: v2(296.51,249.36) 296.68,249.53 296.68,249.93 296.41,250.2 295.18,250.2 UNK3U408.D1
S3_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: UNK3U408.B5 293.41,251.47 293.41,251.97
  BOTTOM w0.132: UNK3R168.1 293.82,253.7 293.82,253.24 293.41,252.83 293.41,251.97
S3_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK3R170.1 293.45,253.7 293.45,253.39 293.2,253.14 292.82,253.14 292.69,253.01 292.69,252.82 292.82,252.69 292.91,252.69 293.04,252.56 293.04,251.84 UNK3U408.A5
S3_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK3C310.1 UNK3R168.2 UNK3R170.2
S3_OUT_RX0_CH2_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(294.16,249.72) 294.62,249.72 294.73,249.82
  L21_SIGNAL w0.105: v2(306.6,248.85) 306.27,249.19 305.43,249.19 304.97,249.66 304.97,249.92 304.81,250.09 304.54,250.09 303.94,250.68 302.86,250.68 302.36,250.19 302.36,249.03 301.09,247.76 298.94,247.76 298.65,248.05 298.65,250.81 298.06,251.41 295.3,251.41 294.73,250.84 294.73,249.82
  BOTTOM w0.16: UNK3U408.E2 v2(294.16,249.72)
S3_OUT_RX0_CH2_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: v2(307.25,248.2) 306.93,248.53 305.81,248.53
  L21_SIGNAL w0.102: v2(295.66,249.72) 295.2,249.72 295.09,249.82
  L21_SIGNAL w0.105: 295.09,249.82 295.09,250.69 295.45,251.04 297.9,251.04 298.28,250.66 298.28,247.89 298.79,247.39 301.24,247.39 302.73,248.88 302.73,250.03 303.01,250.31 303.79,250.31 305.57,248.53 305.81,248.53
  BOTTOM w0.16: UNK3U408.E1 v2(295.66,249.72)
S3_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK3U408.B6 292.28,251.59 292.28,252.14 291.8,252.62 291.8,253.7 UNK3R176.1
S3_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK3U408.A6 292.66,251.72 292.66,251.73 292.66,252.29 292.17,252.78 292.17,253.1 292.47,253.4 292.66,253.4 292.77,253.51 292.77,253.73 292.64,253.86 UNK3R178.1
S3_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK3C318.1 UNK3R176.2 UNK3R178.2
S3_OUT_RX0_CH3_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: v2(306.6,248.2) 306.28,248.53 305.74,248.53
  L19_SIGNAL w0.102: v2(297.22,240.5) 297.05,240.67
  L19_SIGNAL w0.105: 297.05,240.67 297.05,243.91 296.55,244.42 296.55,245.39 296.87,245.72 302.19,245.72 305.01,248.53 305.74,248.53
  BOTTOM w0.132: UNK3U409.B2 295,239.31 296.57,239.31 297.06,239.8 297.06,240.34 v2(297.22,240.5)
S3_OUT_RX0_CH3_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(296.51,240.5) 296.68,240.67
  L19_SIGNAL w0.105: 296.68,240.67 296.68,243.76 296.18,244.26 296.18,245.54 296.72,246.08 302.04,246.08 302.93,246.97 302.93,247.12 302.82,247.22 302.82,247.37 302.97,247.52 303.12,247.52 303.22,247.41 303.37,247.41 303.52,247.56 303.52,247.71 303.41,247.81 303.41,247.96 303.56,248.11 303.71,248.11 303.82,248.01 303.97,248.01 304.11,248.15 304.11,248.3 304.01,248.41 304.01,248.56 304.16,248.71 304.31,248.71 304.41,248.6 304.56,248.6 304.86,248.9 305.91,248.9 v2(305.95,248.85)
  BOTTOM w0.132: v2(296.51,240.5) 296.68,240.34 296.68,239.96 296.41,239.69 295.19,239.69 UNK3U409.B1
S3_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK3R1089.1 295.3,242.21 295.3,241.48 294.94,241.13 294.44,241.13 294.15,240.85 294.15,240.14 UNK3U409.B4
S3_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK3U409.A4 293.78,240.27 293.78,241 294.28,241.51 294.79,241.51 294.92,241.64 294.92,241.81 294.81,241.93 294.45,241.93 294.38,242 294.38,242.21 294.46,242.3 UNK3R1088.1
S3_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK3C302.1 UNK3R1088.2 UNK3R1089.2
S3_OUT_RX0_CH4_ABC_CASE+: length 20.2
  L21_SIGNAL w0.076: 305.68,247.88 306.28,247.88 v2(306.6,247.56)
  L21_SIGNAL w0.102: v2(297.22,237.8) 297.05,237.97
  L21_SIGNAL w0.105: 297.05,237.97 297.05,238.34 297.46,238.76 298.18,238.76 298.69,239.27 298.69,242.83 301.86,246 302.33,246 303.37,247.03 303.37,247.53 303.67,247.84 305.64,247.84 305.68,247.88
  BOTTOM w0.132: v2(297.22,237.8) 297.05,237.96 297.05,238.51 296.56,239.01 295.02,239.01 UNK3U409.D2
S3_OUT_RX0_CH4_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 305.63,248.2 v2(305.95,248.2)
  L21_SIGNAL w0.102: v2(296.51,237.8) 296.68,237.97
  L21_SIGNAL w0.105: 296.68,237.97 296.68,238.5 297.31,239.13 298.03,239.13 298.33,239.43 298.33,240.87 298.22,240.98 297.94,240.98 297.84,241.08 297.84,241.29 297.94,241.4 298.22,241.4 298.33,241.5 298.33,241.71 298.22,241.82 297.94,241.82 297.84,241.92 297.84,242.13 297.94,242.24 298.22,242.24 298.33,242.34 298.33,242.99 301.7,246.36 302.18,246.36 303,247.18 303,247.69 303.52,248.2 305.63,248.2
  BOTTOM w0.132: v2(296.51,237.8) 296.68,237.96 296.68,238.36 296.41,238.63 295.18,238.63 UNK3U409.D1
S3_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK3U409.B5 293.41,239.9 293.41,240.41
  BOTTOM w0.132: 293.41,240.41 293.41,241.26 293.82,241.67 293.82,242.13 UNK3R180.1
S3_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK3R182.1 293.45,242.13 293.45,241.83 293.2,241.57 292.82,241.57 292.69,241.44 292.69,241.25 292.82,241.12 292.91,241.12 293.04,240.99 293.04,240.27 UNK3U409.A5
S3_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK3C320.1 UNK3R180.2 UNK3R182.2
S3_OUT_RX0_CH5_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 306.27,247.23 306.93,247.23 v2(307.25,247.56)
  L19_SIGNAL w0.102: 294.73,238.05 294.62,238.15 v2(294.16,238.15)
  L19_SIGNAL w0.105: 294.73,238.05 294.73,237.41 295.25,236.89 297.59,236.89 299.04,238.35 299.04,239.11 303.27,243.33 303.27,244.74 305.71,247.18 306.23,247.18 306.27,247.23
  BOTTOM w0.16: UNK3U409.E2 v2(294.16,238.15)
S3_OUT_RX0_CH5_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: 295.09,238.05 295.2,238.15 v2(295.66,238.15)
  L19_SIGNAL w0.105: 295.09,238.05 295.09,237.56 295.4,237.26 297.44,237.26 298.68,238.5 298.68,239.26 301.06,241.64 301.06,241.79 300.88,241.97 300.88,242.12 301.02,242.27 301.17,242.27 301.35,242.09 301.5,242.09 301.65,242.24 301.65,242.38 301.47,242.57 301.47,242.71 301.62,242.86 301.77,242.86 301.95,242.68 302.1,242.68 302.25,242.83 302.25,242.98 302.06,243.16 302.06,243.31 302.21,243.46 302.36,243.46 302.54,243.28 302.69,243.28 302.9,243.48 302.9,244.89 305.56,247.55 305.95,247.55 v2(305.95,247.56)
  BOTTOM w0.16: UNK3U409.E1 v2(295.66,238.15)
S3_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK3U409.B6 292.28,240.03 292.28,240.57 291.8,241.06 291.8,242.13 UNK3R666.1
S3_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK3U409.A6 292.66,240.15 292.66,240.16 292.66,240.72 292.17,241.21 292.17,241.53 292.47,241.84 292.66,241.84 292.77,241.94 292.77,242.17 292.64,242.3 UNK3R664.1
S3_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK3R664.2 UNK3R666.2 UNK3C924.1
S3_PAD_SZQ: length 24.9
  L21_SIGNAL w0.102: UNK3K113.5 323.89,221.31 323.89,223.18 315.2,231.86 315.2,235.74 312.46,238.49 v2(312.46,239.75)
S3_PM_SAR0: length 122.1
  L13_SIGNAL w0.091: v3(304.52,282.62) 304.07,282.62 299.71,278.26 251.58,278.26 246.17,272.85 228.41,272.85 226.63,271.07 192.36,271.07 UNK3K34.3
  vias: v2(313.11,248.85)
S3_SPI_CK_ABCD_CASE: length 194.9
  L15_SIGNAL w0.091: v2(315.05,241.7) 315.87,241.7 316.58,241 316.58,239.45 317.1,238.93 317.1,238.08 317.27,237.91 317.27,228.45 321.94,223.77 328.63,223.77 329.41,222.99 329.41,221.98 335.18,216.2 372.54,216.2 375.08,218.74 415.59,218.74 416.56,219.71 442.21,219.71 450.65,211.28 465.1,211.28 465.84,212.01 465.84,214.55 466.88,215.6 482.15,215.6 UNK3K2.6
S3_SPI_CK_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK3K2.5 481.72,210.87 479.19,210.87 478.45,211.61 478.45,212.95 UNK3K3.6
S3_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK3U18.6 458.75,202.18 460.83,204.27 460.83,209.22 459.4,210.65 459.4,217.21 460.54,218.35 475.25,218.35 UNK3K3.7
S3_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK3U19.6 476.37,202.18 476.85,202.66 UNK3K3.5
S3_SPI_CZ_ABCD_CASE: length 202.3
  L15_SIGNAL w0.076: v2(314.41,241.7) 314.73,241.38 314.73,239.58
  L15_SIGNAL w0.091: UNK3K2.3 484.68,212.83 484.68,211.71 481.52,208.54 449.44,208.54 447.73,210.26 371.04,210.26 369.01,208.23 353.95,208.23 352.55,209.63 347.09,209.63 346.1,210.62 335.46,210.62 329.62,216.46 320.27,216.46 318.47,218.26 318.47,223.82 314.3,227.99 314.3,239.15 314.73,239.58
S3_SPI_CZ_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK3K2.4 485.3,213.45 481.15,213.45 UNK3K3.3
S3_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: UNK3K3.2 478.45,218.35 463.58,218.35 462.57,217.34 462.57,210.14 v3(468,204.72)
  BOTTOM w0.16: v3(468,204.72) UNK3U18.1
S3_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK3R205.2 UNK3U19.1 481.97,204.72 480.05,206.64 UNK3K3.4
S3_SPI_DI_ABCD_CASE: length 182.3
  L15_SIGNAL w0.091: v2(315.7,241.06) 316.07,240.69 316.07,239.24 316.19,239.12 316.19,236.87 316.41,236.65 316.41,228.45 321.06,223.8 321.06,219.33 322.35,218.03 332.18,218.03 335.2,215.01 370.69,215.01 371.17,215.49 374.04,215.49 376.45,217.91 416.05,217.91 416.81,218.67 441.96,218.67 449.99,210.64 467.72,210.64 468.76,211.68 468.76,212.8 UNK3K4.6
S3_SPI_DI_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK3K4.5 469.02,210.87 466.49,210.87 465.75,211.61 465.75,212.95 UNK3K5.6
S3_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK3K5.7 462.57,215.17 462.57,204.61 458.87,200.91 UNK3U18.5
S3_SPI_DI_D_CASE: length 18.5
  TOP w0.16: UNK3K5.5 469.7,206.79 472.53,206.79 473.51,205.81 v3(473.51,200.91)
  BOTTOM w0.16: UNK3U19.5 v3(473.51,200.91)
S3_SPI_DO_ABCD_CASE: length 185.4
  L15_SIGNAL w0.076: 315.38,239.6 315.38,240.73 v2(315.05,241.05)
  L15_SIGNAL w0.091: 315.38,239.6 315.38,239.29 315.11,239.02 315.11,228.42 319.35,224.18 319.35,218.72 320.78,217.3 330.96,217.3 335.33,212.93 350.32,212.93 350.81,212.43 364.63,212.43 365.02,212.04 369.77,212.04 370.87,210.95 448.31,210.95 449.07,210.19 471.65,210.19 472.62,211.15 472.62,213.47 UNK3K4.3
S3_SPI_DO_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK3K4.4 472.6,213.45 468.45,213.45 UNK3K5.3
S3_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: UNK3U18.2 469.85,203.45 470.62,204.22 470.62,207.37 468.92,209.07 468.92,215.17 UNK3K5.2
S3_SPI_DO_D_CASE: length 24.7
  TOP w0.16: UNK3K5.4 469.01,210.69 474.21,210.69 481.45,203.45 v3(486.82,203.45)
  BOTTOM w0.16: UNK3U19.2 v3(486.82,203.45)
S3_SPI_HLD_ABCD_CASE: length 170.2
  L15_SIGNAL w0.076: 316.07,242.68 315.38,242.68 v2(315.05,242.36)
  L15_SIGNAL w0.091: UNK3K6.3 459.41,216.14 459.41,220.65 458.01,222.05 416.26,222.05 415.56,221.35 372.2,221.35 368.81,217.96 337.41,217.96 330.23,225.15 323.31,225.15 319.47,228.98 319.47,237.43 318.77,238.12 318.77,239.42 317.71,240.49 317.71,241.71 316.73,242.68 316.07,242.68
S3_SPI_HLD_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK3K7.3 455.75,213.45 459.9,213.45 UNK3K6.4
S3_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK3K7.2 456.22,215.17 456.22,210.53 459.49,207.26 459.49,204.06 458.87,203.45 UNK3U18.7 UNK3R202.1
S3_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK3K7.4 462.91,204.09 471.9,204.09 v3(472.54,203.45)
  BOTTOM w0.16: UNK3U19.7 v3(472.54,203.45)
S3_SPI_WPZ_ABCD_CASE: length 166.4
  L15_SIGNAL w0.091: UNK3K6.6 456.36,215.99 456.36,220.37 455.37,221.36 416.79,221.36 415.98,220.55 374.27,220.55 370.81,217.09 336.35,217.09 328.99,224.45 322.76,224.45 318.83,228.37 318.83,237.26 317.62,238.48 317.62,239.42 317.31,239.73 317.31,241.35 316.42,242.24 315.82,242.24 v2(315.7,242.36)
S3_SPI_WPZ_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK3K6.5 456.32,210.87 453.79,210.87 453.05,211.61 453.05,212.95 UNK3K7.6
S3_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v3(468,202.18) 462.81,202.18 453.05,211.94 453.05,215.15 UNK3K7.7
  BOTTOM w0.16: v3(468,202.18) UNK3U18.3
S3_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: UNK3K7.5 465.04,198.75 483.39,198.75 v3(486.82,202.18)
  BOTTOM w0.16: UNK3U19.3 v3(486.82,202.18) UNK3R207.2
S3_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK3R164.2 303.94,234.06 304.19,234.3 UNK3U31.6
S3_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK3U31.5 304.6,233.9 303.84,233.14 UNK3R163.2
S3_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK3U31.16 307.91,233.9 UNK3R165.2
S3_USB_D_AB_CASE+: length 15.4
  L21_SIGNAL w0.13: v2(306.01,236.49) 305.94,236.56 305.94,238.78 303.42,241.3 303.42,242.24 303.55,242.37 303.86,242.37 303.99,242.5 303.99,242.76 303.86,242.89 303.55,242.89 303.42,243.02 303.42,243.28 303.55,243.4 303.86,243.4 303.99,243.53 303.99,243.79 303.86,243.92 303.55,243.92 303.42,244.05 303.42,244.76 304.52,245.86 305.56,245.86 v2(305.95,246.26)
  BOTTOM w0.165: UNK3U31.10 305.88,236.36 v2(306.01,236.49)
S3_USB_D_AB_CASE-: length 15.4
  L21_SIGNAL w0.13: v2(305.35,236.49) 305.49,236.63 305.49,238.6 302.98,241.11 302.98,244.94 304.34,246.31 304.73,246.31 304.78,246.25 305.25,246.25 305.73,246.73 306.13,246.73 v2(306.6,246.26)
  BOTTOM w0.165: v2(305.35,236.49) 305.48,236.36 UNK3U31.9
S3_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK3U31.8 303.85,235.1 UNK3R160.2
S3_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK3U31.7 303.85,234.7 UNK3R161.2
S3_USER_3V3: length 2.6
  BOTTOM w0.305: UNK3R207.1 v3(489.2,202.18) ; UNK3R203.1 v3(469.39,202.18) ; UNK3R200.1 v3(469.39,204.72) ; UNK3R205.1 v3(489.2,204.72)
  vias: v3(452.86,205.99) v3(452.86,204.72) v3(452.86,203.45) v3(453.34,207.59) v3(465.84,193.83) v3(467.5,194.1) v3(471.29,205.99) v3(471.54,204.72) v3(471.54,203.45) v3(471.76,207.59)
S3_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(315.05,243.65) 315.35,243.95 315.57,244.17 318.02,244.17 319.01,243.18 319.01,238.84 316.33,236.15 316.33,230.9 317.03,230.19 UNK3K32.3
S3_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK3K32.4 UNK3R135.1
S3_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK3R135.2 UNK3R136.2 UNK3C267.1 316.55,224.48 317.49,223.54 317.49,220.49 316.93,219.93 UNK3Y1.3
S3_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: v2(315.7,243.65) 317,243.65 317.6,243.06 317.6,239.33 314.98,236.7 314.98,230.89 314.28,230.19 UNK3K32.6
S3_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK3K32.5 UNK3R137.1
S3_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK3R137.2 UNK3R136.1 UNK3C268.1 311.69,224.48 311.29,224.07 311.29,222.72 UNK3Y1.1
S3_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(312.49,268.29) 313.31,268.29 314.03,267.56 v2(314.03,257.96)
  BOTTOM w0.16: UNK3K29.7 v2(314.03,257.96) ; UNK3U449.7 312.19,268.59 v2(312.49,268.29)
S3_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 309.6,249.25 v2(309.2,248.85)
  BOTTOM w0.16: UNK3K29.6 313.38,260.16 312.71,259.49 312.71,253.39 311.11,251.79 310.61,251.79 309.85,251.04 309.85,249.5 309.6,249.25
S3_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK3K29.5 313.88,262.36 313.19,263.05 UNK3Y2.1 313.19,266.93 UNK3C271.1
S3_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK3U449.2 311.69,271.81 UNK3R973.2 311.92,273.09 UNK3R923.1
S3_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(311.38,268.29) 310.56,268.29 309.84,267.56 v2(309.84,257.96)
  BOTTOM w0.16: UNK3K29.2 v2(309.84,257.96) ; v2(311.38,268.29) 311.69,268.59 UNK3U449.8
S3_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: v2(309.2,249.5) 309.2,251.87 311.34,254.01 311.34,259.45 310.64,260.16 UNK3K29.3
S3_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK3C272.1 310.69,266.93 UNK3Y2.2 310.69,263.05 309.99,262.36 UNK3K29.4
S3_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK3U449.1 311.19,271.78 UNK3R973.1 310.92,273.09 UNK3R652.1
S4_0V5: length 41.7
  BOTTOM w0.305: 353.67,292.26 353.49,292.08 UNK4C288.1 353.44,292.06 353.24,292.26
  BOTTOM w0.381: UNK4MU3.3 352.17,293.34 352.29,293.22
  BOTTOM w0.508: 353.24,292.26 352.29,293.21 352.29,293.22 ; 353.67,292.26 354.32,292.91 UNK4C286.1 354.32,294.48 UNK4MR3.1 UNK4MR4.1 ; UNK4MK1.4 339.18,285.16 338.56,285.78 338.56,293.66 341.47,296.57 353.63,296.57 354.25,295.96 UNK4MR4.1 ; UNK4MR4.1 UNK4MR5.1 UNK4MR6.1 UNK4MR2.2
S4_0V25: length 2.8
  BOTTOM w0.508: UNK4MR18.2 341.88,286.63 UNK4MR19.1 344.45,286.63 UNK4MK4.3
S4_0V75: length 4.9
  BOTTOM w0.381: UNK4MU3.6 UNK4MR10.2
  BOTTOM w0.508: UNK4MR10.2 UNK4C290.1 344.85,290.82 UNK4MK2.4
S4_1AWG_SHARE+: length 17.9
  L25_SIGNAL w0.091: UNK4K107.2 199.92,280.28 199.92,266.79 UNK4K34.4
S4_3V3_ETH_MUX: length 7.8
  BOTTOM w0.254: UNK4R984.1 UNK4C1077.1 356.97,269.95 ; UNK4R990.1 UNK4C1081.1 v2(364.55,273.3) ; v2(363.75,269.49) UNK4C1080.1 UNK4R987.1
  BOTTOM w0.305: UNK4U450.10 357.01,268.86 UNK4R984.1 ; UNK4R987.1 363.27,268.86 UNK4U451.10 ; UNK4R990.1 364.08,272.67 UNK4U452.10
  BOTTOM w0.508: v2(356.97,270.47) 356.97,269.95
S4_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v1(333.66,247.72) 333.12,247.72 332.78,248.06 UNK4R661.2
  TOP w0.381: v1(333.66,247.72) 334.36,247.72 334.87,248.23 334.87,251.5 v1(334.66,251.72)
  BOTTOM w0.381: v1(333.66,247.72) UNK4C922.2
  BOTTOM w0.508: UNK4BDB5.2 331.5,245.91 331.82,245.59 333.3,245.59 333.66,245.95 UNK4C922.2
S4_3V3_RX1_MIPI: length 13.4
  TOP w0.305: UNK4R663.2 332.78,236.49 333.12,236.15 v1(333.66,236.15)
  TOP w0.381: v1(333.66,236.15) 334.36,236.15 334.87,236.66 334.87,239.94 v1(334.66,240.15)
  BOTTOM w0.381: v1(333.66,236.15) UNK4C923.2
  BOTTOM w0.508: UNK4C923.2 333.66,234.38 333.3,234.02 331.82,234.02 331.5,234.35 UNK4BDB6.2
S4_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK4U31.4 345.48,233.24 344.6,232.36 UNK4C262.1
  BOTTOM w0.305: UNK4BD21.2 UNK4C262.1
S4_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: UNK4R981.1 UNK4C1074.1 349.83,270.83
  BOTTOM w0.356: UNK4R981.1 349.86,269.73 UNK4U449.10
  BOTTOM w0.508: UNK4BD1728.2 349.83,270.83
S4_AWG_2SHARE+: length 212.9
  L21_SIGNAL w0.102: v2(364.3,270.18) 364.52,270.18 364.8,269.89 ; UNK4K107.4 196.12,277.43 196.02,277.33
  L21_SIGNAL w0.105: 196.02,277.33 196.02,276.39 196.5,275.9 208.67,275.9 209.79,277.03 209.79,285.31 213.61,289.13 223.87,289.13 231.83,297.09 261.15,297.09 263.71,294.53 270.85,294.53 272.73,292.66 277.13,292.66 280.57,289.21 289.08,289.21 291.06,291.19 300.52,291.19 303.72,294.39 310.51,294.39 312.21,292.69 315.67,292.69 317.08,291.27 331.38,291.27 343.86,278.79 354.08,278.79 355.07,277.81 355.07,273.3 355.55,272.82 367.02,272.82 368.06,271.78 368.06,270.62 367.33,269.89 364.8,269.89
  BOTTOM w0.132: v2(364.3,270.18) 364.51,270.18 364.64,270.05 364.64,269.54 UNK4U451.1
S4_AWG_2SHARE-: length 212.9
  L21_SIGNAL w0.102: 364.96,270.26 364.78,270.44 v2(364.78,270.66) ; 195.65,277.33 195.55,277.43 UNK4K107.5
  L21_SIGNAL w0.105: 195.65,277.33 195.65,277.04 195.55,276.94 195.34,276.94 195.23,276.83 195.23,276.62 195.34,276.52 195.55,276.52 195.65,276.41 195.65,276.24 196.35,275.54 208.82,275.54 210.16,276.88 210.16,285.16 213.77,288.76 224.02,288.76 231.98,296.72 261,296.72 263.56,294.17 270.7,294.17 272.58,292.29 276.97,292.29 280.42,288.84 289.24,288.84 291.21,290.82 300.67,290.82 303.87,294.02 310.36,294.02 312.06,292.32 315.51,292.32 316.93,290.9 331.23,290.9 343.71,278.43 353.93,278.43 354.7,277.66 354.7,273.15 355.39,272.45 366.87,272.45 367.69,271.63 367.69,270.77 367.18,270.26 364.96,270.26
  BOTTOM w0.132: v2(364.78,270.66) 364.78,270.44 365.02,270.2 365.02,269.57 UNK4U451.2
S4_AWG_3SHARE+: length 19.2
  L17_SIGNAL w0.079: 195.93,279.71 195.93,293.95
  L17_SIGNAL w0.091: 195.93,293.95 196.01,294.02 K112.2 ; UNK4K107.3 196.01,279.63 195.93,279.71
S4_AWG_3SHARE-: length 19.2
  L17_SIGNAL w0.079: 195.74,293.95 195.74,279.71
  L17_SIGNAL w0.091: 195.74,293.95 195.66,294.02 K112.7 ; UNK4K107.6 195.66,279.63 195.74,279.71
S4_DVDD_DDR_RX: length 13.6
  L17_SIGNAL w0.508: UNK4K39.3 346.46,228.57 349.79,231.91 349.79,238.4
  vias: v2(347.25,239.1) v2(347.9,240.4)
S4_DVDD_DDR_TX: length 18.3
  L23_SIGNAL w0.508: UNK4K39.6 348.06,224.54 349.83,224.54 350.72,225.43 350.72,237.26 349.87,238.11
  vias: v2(347.9,239.1) v2(348.55,240.4)
S4_ETH_RN_AB_CASE: length 31.5
  TOP w0.381: SITE4.H16 v2(356.35,244.96)
  L15_SIGNAL w0.508: 356.97,244.96 v2(356.35,244.96)
  L15_SIGNAL w0.889: 357.35,244.96 356.97,244.96 ; v2(365.9,267.41) 365.9,266.54 365.12,265.76
  L15_SIGNAL w1.016: 365.12,265.76 365.12,264.92 364.55,264.35 359.66,264.35 358.99,263.68 358.99,246.59 357.35,244.96
  BOTTOM w0.305: UNK4U451.7 365.6,267.72 v2(365.9,267.41)
S4_ETH_RP_AB_CASE: length 31
  L15_SIGNAL w0.305: v2(355.05,244.96) 356.52,246.42
  L15_SIGNAL w0.889: v2(364.79,267.41) 364.55,267.41 363.6,266.46 ; 356.52,246.42 357.02,246.92
  L15_SIGNAL w1.016: 357.02,246.92 357.02,265.77 357.7,266.46 363.6,266.46
  BOTTOM w0.305: UNK4U451.8 365.1,267.72 v2(364.79,267.41)
S4_ETH_TN_AB_CASE: length 26.2
  TOP w0.381: SITE4.G15 v2(356.35,245.61)
  L21_SIGNAL w0.305: 356.81,245.48 356.48,245.48 v2(356.35,245.61)
  L21_SIGNAL w0.508: 359.03,247.12 357.39,245.48 356.81,245.48
  L21_SIGNAL w0.889: 359.64,266.7 v2(359.64,267.41)
  L21_SIGNAL w1.016: 359.03,247.12 359.03,265.82 359.64,266.43 359.64,266.7
  BOTTOM w0.305: UNK4U450.7 359.33,267.72 v2(359.64,267.41)
S4_ETH_TP_AB_CASE: length 25.5
  L21_SIGNAL w0.305: 356.49,246.39 355.7,245.61 v2(354.4,245.61)
  L21_SIGNAL w0.762: 357.07,247.15 357.07,246.97 356.49,246.39
  L21_SIGNAL w0.889: v2(358.52,267.41) 358.09,267.41 357.07,266.4
  L21_SIGNAL w1.016: 357.07,247.15 357.07,266.4
  BOTTOM w0.305: UNK4U450.8 358.83,267.72 v2(358.52,267.41)
S4_M_2V5: length 4.8
  BOTTOM w0.508: UNK4MR2.1 UNK4C284.1 ; UNK4C284.1 UNK4C285.1 ; UNK4C284.1 357.42,293.35 UNK4MU2.6
S4_M_3V2: length 24.3
  BOTTOM w0.381: 347.96,293.87 347.83,293.99 UNK4MU3.7
  BOTTOM w0.508: UNK4MU2.2 358.69,283.18 UNK4C282.1 UNK4C283.1 357.46,283.1 UNK4MR1.1 354.18,283.1 UNK4MU1.5 355.14,284.21 355.14,289.56 354.29,290.41 352.62,290.41 351.53,291.5 UNK4C289.1 349.25,291.5 348.48,292.27 348.48,293.35 347.96,293.87
S4_MUX_3V3: length 1.5
  TOP w0.508: v2(347.1,267.19) v2(347.86,267.19)
  BOTTOM w0.508: v2(347.86,267.19) UNK4R512.1 v2(347.1,267.19)
  vias: v2(330.56,246.46) v2(330.56,234.89) v2(342.48,232.36) v2(349.83,272.29) v2(356.97,271.41)
S4_OUT_RX0_CH0_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(337.22,252.07) 337.05,252.24
  L21_SIGNAL w0.105: v2(347.25,249.5) 347.25,250.81 345.65,252.41 342.57,252.41 342.47,252.31 342.47,252.15 342.36,252.05 342.15,252.05 342.05,252.15 342.05,252.31 341.94,252.41 341.73,252.41 341.63,252.31 341.63,252.15 341.52,252.05 341.31,252.05 341.21,252.15 341.21,252.31 341.1,252.41 340.89,252.41 340.79,252.31 340.79,252.15 340.69,252.05 340.48,252.05 340.37,252.15 340.37,252.31 340.27,252.41 339.24,252.41 338.53,253.13 338.53,253.83 338.32,254.04 337.17,254.04 337.05,253.92 337.05,252.24
  BOTTOM w0.132: UNK4U408.B2 335,250.88 336.57,250.88 337.06,251.37 337.06,251.91 v2(337.22,252.07)
S4_OUT_RX0_CH0_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 347.62,249.81 347.62,249.03 347.58,248.99 347.58,248.72 347.9,248.4 v2(347.9,248.2)
  L21_SIGNAL w0.102: v2(336.51,252.07) 336.68,252.24
  L21_SIGNAL w0.105: 347.62,249.81 347.62,250.96 345.8,252.78 339.4,252.78 338.89,253.28 338.89,253.98 338.47,254.41 337.02,254.41 336.68,254.08 336.68,252.24
  BOTTOM w0.132: v2(336.51,252.07) 336.68,251.9 336.68,251.52 336.41,251.25 335.19,251.25 UNK4U408.B1
S4_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.076: UNK4U408.B4 334.15,251.71
  BOTTOM w0.132: 334.15,251.71 334.15,252.41 334.44,252.7 334.94,252.7 335.29,253.05 335.29,253.77 UNK4R647.1
S4_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK4R646.1 334.46,253.86 334.38,253.78 334.38,253.57 334.45,253.5 334.81,253.5 334.92,253.38 334.92,253.21 334.79,253.07 334.28,253.07 333.78,252.57 333.78,251.83 UNK4U408.A4
S4_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK4R647.2 UNK4R646.2 UNK4C309.1
S4_OUT_RX0_CH1_ABC_CASE+: length 20.2
  L19_SIGNAL w0.102: v2(337.22,249.36) 337.05,249.19
  L19_SIGNAL w0.105: 337.05,249.19 337.05,248.58 337.36,248.26 338.01,248.26 338.57,248.82 338.57,252.02 339.22,252.67 342.05,252.67 342.59,252.13 342.59,250.47 342.88,250.19 344.43,250.19 344.57,250.33 344.85,250.33 345,250.19 345.92,250.19 v2(346.6,249.5)
  BOTTOM w0.132: UNK4U408.D2 335.02,250.57 336.56,250.57 337.05,250.08 337.05,249.53 v2(337.22,249.36)
S4_OUT_RX0_CH1_ABC_CASE-: length 20.2
  L19_SIGNAL w0.076: 346.41,249.18 346.93,249.18 v2(347.25,248.85)
  L19_SIGNAL w0.102: v2(336.51,249.36) 336.68,249.19
  L19_SIGNAL w0.105: 336.68,249.19 336.68,248.42 337.21,247.9 338.17,247.9 338.93,248.67 338.93,251.87 339.37,252.31 341.9,252.31 342.22,251.98 342.22,250.32 342.73,249.82 345.77,249.82 346.41,249.18
  BOTTOM w0.132: v2(336.51,249.36) 336.68,249.53 336.68,249.93 336.4,250.2 335.18,250.2 UNK4U408.D1
S4_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: UNK4U408.B5 333.41,251.47 333.41,251.97
  BOTTOM w0.132: 333.41,251.97 333.41,252.83 333.82,253.24 333.82,253.7 UNK4R168.1
S4_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK4R170.1 333.45,253.7 333.45,253.39 333.2,253.14 332.82,253.14 332.69,253.01 332.69,252.82 332.82,252.69 332.91,252.69 333.04,252.56 333.04,251.84 UNK4U408.A5
S4_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK4C310.1 UNK4R168.2 UNK4R170.2
S4_OUT_RX0_CH2_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: 334.73,249.82 334.62,249.72 v2(334.16,249.72)
  L21_SIGNAL w0.105: v2(346.6,248.85) 346.27,249.19 345.43,249.19 344.97,249.66 344.97,249.92 344.81,250.09 344.54,250.09 343.94,250.68 342.86,250.68 342.36,250.19 342.36,249.03 341.09,247.76 338.94,247.76 338.65,248.05 338.65,250.81 338.06,251.41 335.3,251.41 334.73,250.84 334.73,249.82
  BOTTOM w0.16: UNK4U408.E2 v2(334.16,249.72)
S4_OUT_RX0_CH2_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 345.81,248.53 346.93,248.53 v2(347.25,248.2)
  L21_SIGNAL w0.102: v2(335.66,249.72) 335.2,249.72 335.09,249.82
  L21_SIGNAL w0.105: 335.09,249.82 335.09,250.69 335.45,251.04 337.9,251.04 338.28,250.66 338.28,247.89 338.79,247.39 341.24,247.39 342.73,248.88 342.73,250.03 343.01,250.31 343.79,250.31 345.57,248.53 345.81,248.53
  BOTTOM w0.16: UNK4U408.E1 v2(335.66,249.72)
S4_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK4U408.B6 332.28,251.59 332.28,252.14 331.8,252.62 331.8,253.7 UNK4R176.1
S4_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK4R178.1 332.64,253.86 332.77,253.73 332.77,253.51 332.66,253.4 332.47,253.4 332.17,253.1 332.17,252.78 332.66,252.29 332.66,251.72 UNK4U408.A6
S4_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK4R178.2 UNK4R176.2 UNK4C318.1
S4_OUT_RX0_CH3_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 345.74,248.53 346.28,248.53 v2(346.6,248.2)
  L19_SIGNAL w0.102: v2(337.22,240.5) 337.05,240.67
  L19_SIGNAL w0.105: 345.74,248.53 345.01,248.53 342.19,245.72 336.87,245.72 336.55,245.39 336.55,244.42 337.05,243.91 337.05,240.67
  BOTTOM w0.132: UNK4U409.B2 335,239.31 336.57,239.31 337.06,239.8 337.06,240.34 v2(337.22,240.5)
S4_OUT_RX0_CH3_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(336.51,240.5) 336.68,240.67
  L19_SIGNAL w0.105: 336.68,240.67 336.68,243.76 336.18,244.26 336.18,245.54 336.72,246.08 342.04,246.08 342.93,246.97 342.93,247.12 342.82,247.22 342.82,247.37 342.97,247.52 343.12,247.52 343.22,247.41 343.37,247.41 343.52,247.56 343.52,247.71 343.41,247.81 343.41,247.96 343.56,248.11 343.71,248.11 343.82,248.01 343.97,248.01 344.11,248.15 344.11,248.3 344.01,248.41 344.01,248.56 344.16,248.71 344.31,248.71 344.41,248.6 344.56,248.6 344.86,248.9 345.91,248.9 v2(345.95,248.85)
  BOTTOM w0.132: v2(336.51,240.5) 336.68,240.34 336.68,239.96 336.41,239.69 335.19,239.69 UNK4U409.B1
S4_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK4R1089.1 335.29,242.21 335.29,241.48 334.94,241.13 334.44,241.13 334.15,240.85 334.15,240.14 UNK4U409.B4
S4_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK4R1088.1 334.46,242.3 334.38,242.21 334.38,242 334.45,241.93 334.81,241.93 334.92,241.81 334.92,241.64 334.79,241.51 334.28,241.51 333.78,241 333.78,240.27 UNK4U409.A4
S4_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK4R1089.2 UNK4R1088.2 UNK4C302.1
S4_OUT_RX0_CH4_ABC_CASE+: length 20.2
  L21_SIGNAL w0.076: v2(346.6,247.56) 346.28,247.88 345.68,247.88
  L21_SIGNAL w0.102: v2(337.22,237.8) 337.05,237.97
  L21_SIGNAL w0.105: 337.05,237.97 337.05,238.34 337.46,238.76 338.18,238.76 338.69,239.27 338.69,242.83 341.86,246 342.33,246 343.37,247.03 343.37,247.53 343.67,247.84 345.64,247.84 345.68,247.88
  BOTTOM w0.132: UNK4U409.D2 335.02,239.01 336.56,239.01 337.05,238.51 337.05,237.96 v2(337.22,237.8)
S4_OUT_RX0_CH4_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 345.63,248.2 v2(345.95,248.2)
  L21_SIGNAL w0.102: v2(336.51,237.8) 336.68,237.97
  L21_SIGNAL w0.105: 336.68,237.97 336.68,238.5 337.31,239.13 338.03,239.13 338.33,239.43 338.33,240.87 338.22,240.98 337.94,240.98 337.84,241.08 337.84,241.29 337.94,241.4 338.22,241.4 338.33,241.5 338.33,241.71 338.22,241.82 337.94,241.82 337.84,241.92 337.84,242.13 337.94,242.24 338.22,242.24 338.33,242.34 338.33,242.99 341.7,246.36 342.18,246.36 343,247.18 343,247.69 343.52,248.2 345.63,248.2
  BOTTOM w0.132: UNK4U409.D1 335.18,238.63 336.4,238.63 336.68,238.36 336.68,237.96 v2(336.51,237.8)
S4_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: UNK4U409.B5 333.41,239.9 333.41,240.41
  BOTTOM w0.132: 333.41,240.41 333.41,241.26 333.82,241.67 333.82,242.13 UNK4R180.1
S4_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK4U409.A5 333.04,240.27 333.04,240.99 332.91,241.12 332.82,241.12 332.69,241.25 332.69,241.44 332.82,241.57 333.2,241.57 333.45,241.83 333.45,242.13 UNK4R182.1
S4_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK4C320.1 UNK4R180.2 UNK4R182.2
S4_OUT_RX0_CH5_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: v2(347.25,247.56) 346.93,247.23 346.27,247.23
  L19_SIGNAL w0.102: 334.73,238.05 334.62,238.15 v2(334.16,238.15)
  L19_SIGNAL w0.105: 334.73,238.05 334.73,237.41 335.25,236.89 337.59,236.89 339.04,238.35 339.04,239.11 343.27,243.33 343.27,244.74 345.71,247.18 346.23,247.18 346.27,247.23
  BOTTOM w0.16: UNK4U409.E2 v2(334.16,238.15)
S4_OUT_RX0_CH5_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(335.66,238.15) 335.2,238.15 335.09,238.05
  L19_SIGNAL w0.105: v2(345.95,247.56) 345.95,247.55 345.56,247.55 342.9,244.89 342.9,243.48 342.69,243.28 342.54,243.28 342.36,243.46 342.21,243.46 342.06,243.31 342.06,243.16 342.25,242.98 342.25,242.83 342.1,242.68 341.95,242.68 341.77,242.86 341.62,242.86 341.47,242.71 341.47,242.57 341.65,242.38 341.65,242.24 341.5,242.09 341.35,242.09 341.17,242.27 341.02,242.27 340.88,242.12 340.88,241.97 341.06,241.79 341.06,241.64 338.68,239.26 338.68,238.5 337.44,237.26 335.4,237.26 335.09,237.56 335.09,238.05
  BOTTOM w0.16: UNK4U409.E1 v2(335.66,238.15)
S4_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK4R666.1 331.8,242.13 331.8,241.06 332.28,240.57 332.28,240.03 UNK4U409.B6
S4_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK4U409.A6 332.66,240.15 332.66,240.16 332.66,240.72 332.17,241.21 332.17,241.53 332.47,241.84 332.66,241.84 332.77,241.94 332.77,242.17 332.64,242.3 UNK4R664.1
S4_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK4R664.2 UNK4R666.2 UNK4C924.1
S4_PAD_SZQ: length 24.9
  L21_SIGNAL w0.102: UNK4K113.5 363.89,221.31 363.89,223.18 355.2,231.86 355.2,235.74 352.45,238.49 v2(352.45,239.75)
S4_PM_SAR0: length 153
  L13_SIGNAL w0.091: v3(344.52,282.62) 343.83,282.62 338.07,276.86 250.7,276.86 246.32,272.49 230.82,272.49 228.47,270.13 227.2,270.13 225.55,268.48 220.6,268.48 219.88,269.2 218.39,269.2 217.83,268.64 199.58,268.64 UNK4K34.3
  vias: v2(353.1,248.85)
S4_SPI_CK_ABCD_CASE: length 139.2
  L15_SIGNAL w0.091: UNK4K2.6 482.15,247.35 466.88,247.35 465.84,246.3 465.84,243.76 465.1,243.03 449.28,243.03 441.48,250.82 368.66,250.82 361.52,243.69 361.52,243.36 359.69,241.53 357.92,241.53 357.75,241.7 v2(355.05,241.7)
S4_SPI_CK_B_CASE: length 7.3
  L13_SIGNAL w0.091: UNK4K3.6 477.86,245.29 482.01,245.29 UNK4K2.5
S4_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK4K3.7 475.25,250.1 460.54,250.1 459.4,248.96 459.4,242.4 460.83,240.97 460.83,236.02 458.75,233.93 UNK4U18.6
S4_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK4U19.6 476.37,233.93 476.85,234.41 UNK4K3.5
S4_SPI_CZ_ABCD_CASE: length 141.8
  L15_SIGNAL w0.076: 355.28,239.32 355.03,239.32 354.73,239.62 354.73,241.38 v2(354.4,241.7)
  L15_SIGNAL w0.091: 355.28,239.32 355.7,239.32 355.88,239.5 363.68,239.5 364.04,239.86 367.35,243.17 369.98,245.8 441.44,245.8 446.54,240.69 481.91,240.69 484.68,243.46 484.68,244.58 UNK4K2.3
S4_SPI_CZ_B_CASE: length 7.3
  L13_SIGNAL w0.091: UNK4K2.4 485.26,245.24 482.6,245.24 481.54,246.3 UNK4K3.3
S4_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: v3(468,236.47) 462.57,241.89 462.57,249.09 463.58,250.1 478.45,250.1 UNK4K3.2
  BOTTOM w0.16: v3(468,236.47) UNK4U18.1
S4_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK4R205.2 UNK4U19.1 481.97,236.47 480.05,238.39 UNK4K3.4
S4_SPI_DI_ABCD_CASE: length 123.2
  L15_SIGNAL w0.091: v2(355.7,241.06) 356.35,240.41 360.32,240.41 368.45,248.54 441.88,248.54 448.03,242.39 467.72,242.39 468.76,243.43 468.76,244.55 UNK4K4.6
S4_SPI_DI_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK4K5.6 465.75,244.7 465.75,243.36 466.49,242.62 469.02,242.62 UNK4K4.5
S4_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK4K5.7 462.57,246.92 462.57,236.36 458.87,232.66 UNK4U18.5
S4_SPI_DI_D_CASE: length 18.5
  TOP w0.16: UNK4K5.5 469.7,238.54 472.53,238.54 473.51,237.56 v3(473.51,232.66)
  BOTTOM w0.16: UNK4U19.5 v3(473.51,232.66)
S4_SPI_DO_ABCD_CASE: length 127.4
  L15_SIGNAL w0.076: v2(355.05,241.05) 355.38,240.73 355.38,240.04 355.56,239.86 355.82,239.86
  L15_SIGNAL w0.091: 355.82,239.86 361.86,239.86 366.26,244.26 368.53,246.53 441.83,246.53 446.43,241.94 471.65,241.94 472.62,242.9 472.62,245.22 UNK4K4.3
S4_SPI_DO_B_CASE: length 7.3
  L13_SIGNAL w0.091: UNK4K4.4 472.69,245.11 468.54,245.11 UNK4K5.3
S4_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: UNK4U18.2 469.85,235.2 470.62,235.97 470.62,239.12 468.92,240.82 468.92,246.92 UNK4K5.2
S4_SPI_DO_D_CASE: length 24.7
  TOP w0.16: UNK4K5.4 469.01,242.44 474.21,242.44 481.45,235.2 v3(486.82,235.2)
  BOTTOM w0.16: UNK4U19.2 v3(486.82,235.2)
S4_SPI_HLD_ABCD_CASE: length 118
  L15_SIGNAL w0.076: 356.07,242.68 355.38,242.68 v2(355.05,242.36)
  L15_SIGNAL w0.091: UNK4K6.3 459.41,247.89 459.41,252.4 458.06,253.75 367.54,253.75 360.55,246.76 360.55,244.37 358.55,242.37 358.12,242.37 357.81,242.68 356.07,242.68
S4_SPI_HLD_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK4K6.4 459.9,245.2 455.75,245.2 UNK4K7.3
S4_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK4R202.1 UNK4U18.7 458.87,235.2 459.49,235.81 459.49,239.01 456.22,242.28 456.22,246.92 UNK4K7.2
S4_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK4K7.4 462.91,235.84 471.9,235.84 v3(472.54,235.2)
  BOTTOM w0.16: UNK4U19.7 v3(472.54,235.2)
S4_SPI_WPZ_ABCD_CASE: length 113.5
  L15_SIGNAL w0.091: v2(355.7,242.36) 355.82,242.24 357.73,242.24 357.96,242.01 359.6,242.01 361.01,243.42 361.01,244.83 365.94,249.76 365.94,250.21 369.01,253.29 455.19,253.29 456.36,252.12 456.36,247.74 UNK4K6.6
S4_SPI_WPZ_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK4K6.5 456.32,242.62 453.79,242.62 453.05,243.36 453.05,244.7 UNK4K7.6
S4_SPI_WPZ_C_CASE: length 27
  TOP w0.16: UNK4K7.7 453.05,246.9 453.05,243.69 462.81,233.93 v3(468,233.93)
  BOTTOM w0.16: v3(468,233.93) UNK4U18.3
S4_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: v3(486.82,233.93) 483.39,230.5 465.04,230.5 UNK4K7.5
  BOTTOM w0.16: UNK4R207.2 v3(486.82,233.93) UNK4U19.3
S4_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK4U31.6 344.19,234.3 343.94,234.06 UNK4R164.2
S4_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK4U31.5 344.6,233.9 343.84,233.14 UNK4R163.2
S4_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK4U31.16 347.91,233.9 UNK4R165.2
S4_USB_D_AB_CASE+: length 15.4
  L21_SIGNAL w0.13: v2(345.95,246.26) 345.56,245.86 344.52,245.86 343.42,244.76 343.42,244.05 343.55,243.92 343.86,243.92 343.99,243.79 343.99,243.53 343.86,243.4 343.55,243.4 343.42,243.28 343.42,243.02 343.55,242.89 343.86,242.89 343.99,242.76 343.99,242.5 343.86,242.37 343.55,242.37 343.42,242.24 343.42,241.3 345.94,238.78 345.94,236.56 v2(346.01,236.49)
  BOTTOM w0.165: v2(346.01,236.49) 345.88,236.36 UNK4U31.10
S4_USB_D_AB_CASE-: length 15.4
  L21_SIGNAL w0.13: v2(345.35,236.49) 345.49,236.63 345.49,238.6 342.98,241.11 342.98,244.94 344.34,246.31 344.73,246.31 344.78,246.25 345.25,246.25 345.73,246.73 346.13,246.73 v2(346.6,246.26)
  BOTTOM w0.165: v2(345.35,236.49) 345.48,236.36 UNK4U31.9
S4_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK4U31.8 343.85,235.1 UNK4R160.2
S4_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK4R161.2 343.85,234.7 UNK4U31.7
S4_USER_3V3: length 2.6
  BOTTOM w0.305: UNK4R200.1 v3(469.39,236.47) ; UNK4R207.1 v3(489.2,233.93) ; UNK4R205.1 v3(489.2,236.47) ; UNK4R203.1 v3(469.39,233.93)
  vias: v3(452.86,237.74) v3(452.86,236.47) v3(452.86,235.2) v3(453.34,239.34) v3(465.84,225.58) v3(467.5,225.85) v3(471.29,237.74) v3(471.54,236.47) v3(471.54,235.2) v3(471.76,239.34)
S4_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: UNK4K32.3 357.03,230.19 356.33,230.9 356.33,236.15 359.01,238.84 359.01,243.18 358.02,244.17 355.57,244.17 355.35,243.95 v2(355.05,243.65)
S4_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK4K32.4 UNK4R135.1
S4_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK4Y1.3 356.93,219.93 357.49,220.49 357.49,223.54 356.55,224.48 UNK4C267.1 UNK4R136.2 UNK4R135.2
S4_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: v2(355.7,243.65) 357,243.65 357.6,243.06 357.6,239.33 354.98,236.7 354.98,230.89 354.28,230.19 UNK4K32.6
S4_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK4K32.5 UNK4R137.1
S4_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK4Y1.1 351.29,222.72 351.29,224.07 351.69,224.48 UNK4C268.1 UNK4R136.1 UNK4R137.2
S4_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(352.49,268.29) 353.31,268.29 354.03,267.56 v2(354.03,257.96)
  BOTTOM w0.16: UNK4U449.7 352.19,268.59 v2(352.49,268.29) ; UNK4K29.7 v2(354.03,257.96)
S4_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 349.6,249.25 v2(349.2,248.85)
  BOTTOM w0.16: 349.6,249.25 349.85,249.5 349.85,251.04 350.61,251.79 351.11,251.79 352.71,253.39 352.71,259.49 353.38,260.16 UNK4K29.6
S4_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK4C271.1 353.19,266.93 UNK4Y2.1 353.19,263.05 353.88,262.36 UNK4K29.5
S4_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK4U449.2 351.69,271.81 UNK4R973.2 351.92,273.09 UNK4R923.1
S4_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(351.38,268.29) 350.56,268.29 349.84,267.56 v2(349.84,257.96)
  BOTTOM w0.16: UNK4K29.2 v2(349.84,257.96) ; v2(351.38,268.29) 351.69,268.59 UNK4U449.8
S4_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: UNK4K29.3 350.64,260.16 351.34,259.45 351.34,254.01 349.2,251.87 v2(349.2,249.5)
S4_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK4K29.4 349.99,262.36 350.69,263.05 UNK4Y2.2 350.69,266.93 UNK4C272.1
S4_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK4R652.1 350.92,273.09 UNK4R973.1 351.19,271.78 UNK4U449.1
S5_0V5: length 41.7
  BOTTOM w0.305: 227.99,137 228.17,137.18 UNK5C288.1 228.22,137.2 228.42,137
  BOTTOM w0.381: 229.37,136.04 229.49,135.92 UNK5MU3.3
  BOTTOM w0.508: UNK5MR2.2 UNK5MR6.1 UNK5MR5.1 UNK5MR4.1 ; UNK5MR4.1 227.41,133.3 227.87,132.84 240.15,132.84 243.37,136.06 243.37,143.22 242.48,144.1 UNK5MK1.4 ; UNK5MR4.1 UNK5MR3.1 227.34,134.78 UNK5C286.1 227.34,136.35 227.99,137 ; 228.42,137 229.37,136.05 229.37,136.04
S5_0V25: length 2.8
  BOTTOM w0.508: UNK5MK4.3 237.21,142.63 UNK5MR19.1 239.78,142.63 UNK5MR18.2
S5_0V75: length 4.9
  BOTTOM w0.381: UNK5MU3.6 UNK5MR10.2
  BOTTOM w0.508: UNK5MK2.4 236.81,138.44 UNK5C290.1 UNK5MR10.2
S5_1AWG_SHARE+: length 17.9
  L21_SIGNAL w0.102: UNK5K34.4 170.99,242.43 170.99,255.87 UNK5K107.2
S5_3V3_ETH_MUX: length 7.8
  BOTTOM w0.254: v2(243.75,209.49) UNK5C1080.1 UNK5R987.1 ; UNK5R990.1 UNK5C1081.1 v2(244.55,213.3) ; 236.97,209.95 UNK5C1077.1 UNK5R984.1
  BOTTOM w0.305: UNK5U451.10 243.27,208.86 UNK5R987.1 ; UNK5U452.10 244.08,212.67 UNK5R990.1 ; UNK5R984.1 237.01,208.86 UNK5U450.10
  BOTTOM w0.508: v2(236.97,210.47) 236.97,209.95
S5_3V3_RX0_MIPI: length 13.4
  TOP w0.305: UNK5R661.2 212.78,188.06 213.12,187.72 v1(213.66,187.72)
  TOP w0.381: v1(213.66,187.72) 214.36,187.72 214.87,188.23 214.87,191.5 v1(214.66,191.72)
  BOTTOM w0.381: v1(213.66,187.72) UNK5C922.2
  BOTTOM w0.508: UNK5BDB5.2 211.5,185.91 211.82,185.59 213.3,185.59 213.66,185.95 UNK5C922.2
S5_3V3_RX1_MIPI: length 13.4
  TOP w0.305: UNK5R663.2 212.78,176.49 213.12,176.15 v1(213.66,176.15)
  TOP w0.381: v1(213.66,176.15) 214.36,176.15 214.87,176.66 214.87,179.94 v1(214.66,180.15)
  BOTTOM w0.381: v1(213.66,176.15) UNK5C923.2
  BOTTOM w0.508: UNK5BDB6.2 211.5,174.35 211.82,174.02 213.3,174.02 213.66,174.38 UNK5C923.2
S5_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK5C262.1 224.61,172.36 225.48,173.24 UNK5U31.4
  BOTTOM w0.305: UNK5BD21.2 UNK5C262.1
S5_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 229.83,210.83 UNK5C1074.1 UNK5R981.1
  BOTTOM w0.356: UNK5R981.1 229.86,209.73 UNK5U449.10
  BOTTOM w0.508: UNK5BD1728.2 229.83,210.83
S5_AWG_2SHARE+: length 212.9
  L21_SIGNAL w0.102: 244.81,209.89 244.52,210.18 v2(244.3,210.18) ; 167.06,252.94 167.17,253.05 UNK5K107.4
  L21_SIGNAL w0.105: 244.81,209.89 247.33,209.89 248.06,210.62 248.06,211.78 247.02,212.82 231.34,212.82 230.56,213.6 228.97,213.6 228.43,213.07 213.28,213.07 210,216.34 206.94,216.34 205.6,215 205.6,196.54 204.51,195.45 199.19,195.45 198.25,196.39 198.25,215.42 197.65,216.03 193.33,216.03 192.57,215.26 192.57,208.94 193.33,208.18 195.35,208.18 195.67,207.86 195.67,196.12 195.01,195.45 168.86,195.45 167.82,196.5 167.82,237.5 167.06,238.25 167.06,252.94
  BOTTOM w0.132: UNK5U451.1 244.64,209.54 244.64,210.05 244.51,210.18 v2(244.3,210.18)
S5_AWG_2SHARE-: length 212.9
  L21_SIGNAL w0.102: 244.96,210.26 244.78,210.44 v2(244.78,210.66) ; 166.69,252.94 166.59,253.05 UNK5K107.5
  L21_SIGNAL w0.105: 244.96,210.26 247.18,210.26 247.69,210.77 247.69,211.63 246.87,212.45 231.19,212.45 230.4,213.24 229.12,213.24 228.58,212.7 213.13,212.7 209.85,215.98 207.1,215.98 205.97,214.85 205.97,196.39 204.67,195.08 199.03,195.08 197.89,196.23 197.89,215.27 197.5,215.66 193.49,215.66 192.93,215.11 192.93,209.1 193.48,208.55 195.51,208.55 196.04,208.02 196.04,195.97 195.16,195.08 168.71,195.08 167.45,196.35 167.45,237.34 166.69,238.1 166.69,251.59 166.59,251.69 166.38,251.69 166.28,251.8 166.28,252.01 166.38,252.11 166.59,252.11 166.69,252.22 166.69,252.94
  BOTTOM w0.132: UNK5U451.2 245.02,209.57 245.02,210.2 244.78,210.44 v2(244.78,210.66)
