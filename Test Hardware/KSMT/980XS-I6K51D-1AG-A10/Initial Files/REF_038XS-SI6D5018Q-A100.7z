# Allegro board REF_038XS-SI6D5018Q-A100.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D41616: length 397.7
  L33_SIGNAL w0.091: v2(232.19,211.11) 232.19,212.1 227.08,217.21 227.08,220.83 225.3,222.61 225.3,228.22 224.91,228.61 224.91,235.57 223.92,236.55 223.92,237.61 222.25,239.27 222.25,250.96 222.43,251.13 222.43,251.14 225.03,253.74 225.03,265.67 226.52,267.16 226.52,296.62 226.95,297.05 226.95,319.91 259.7,352.66 279.51,352.66 284.23,357.38 284.23,383.55 304.31,403.64 426.09,403.64 429.44,400.28 456.16,400.28 D416.16
  BOTTOM w0.16: UNK5U449.3 v2(232.19,211.11)
S1_0V5: length 41.7
  BOTTOM w0.305: 233.67,292.26 233.49,292.08 C288.1 233.44,292.06 233.24,292.26
  BOTTOM w0.381: MU3.3 232.17,293.34 232.29,293.22
  BOTTOM w0.508: MK1.4 219.18,285.16 218.56,285.78 218.56,293.66 221.47,296.57 233.63,296.57 234.25,295.96 MR4.1 ; 232.29,293.22 232.29,293.21 233.24,292.26 ; MR4.1 MR3.1 234.32,294.48 C286.1 234.32,292.91 233.67,292.26 ; MR4.1 MR5.1 MR6.1 MR2.2
S1_0V25: length 2.8
  BOTTOM w0.508: MK4.3 224.45,286.63 MR19.1 221.88,286.63 MR18.2
S1_0V75: length 4.9
  BOTTOM w0.381: MU3.6 MR10.2
  BOTTOM w0.508: MR10.2 C290.1 224.85,290.82 MK2.4
S1_1AWG_SHARE+: length 17.9
  L25_SIGNAL w0.091: K34.4 170.97,266.79 170.97,280.28 K107.2
S1_3V3_ETH_MUX: length 7.8
  BOTTOM w0.254: 236.97,269.95 C1077.1 R984.1 ; v2(243.75,269.49) C1080.1 R987.1 ; R990.1 C1081.1 v2(244.55,273.3)
  BOTTOM w0.305: U451.10 243.27,268.86 R987.1 ; U452.10 244.08,272.67 R990.1 ; U450.10 237.01,268.86 R984.1
  BOTTOM w0.508: v2(236.97,270.47) 236.97,269.95
S1_3V3_RX0_MIPI: length 13.4
  TOP w0.305: v1(213.66,247.72) 213.12,247.72 212.78,248.06 R661.2
  TOP w0.381: v1(213.66,247.72) 214.36,247.72 214.87,248.23 214.87,251.5 v1(214.66,251.72)
  BOTTOM w0.381: v1(213.66,247.72) C922.2
  BOTTOM w0.508: C922.2 213.66,245.95 213.3,245.59 211.82,245.59 211.5,245.91 BDB5.2
S1_3V3_RX1_MIPI: length 13.4
  TOP w0.305: R663.2 212.78,236.49 213.12,236.15 v1(213.66,236.15)
  TOP w0.381: v1(214.66,240.15) 214.87,239.94 214.87,236.66 214.36,236.15 v1(213.66,236.15)
  BOTTOM w0.381: v1(213.66,236.15) C923.2
  BOTTOM w0.508: C923.2 213.66,234.38 213.3,234.02 211.82,234.02 211.5,234.35 BDB6.2
S1_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: U31.4 225.48,233.24 224.61,232.36 C262.1
  BOTTOM w0.305: BD21.2 C262.1
S1_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: R981.1 C1074.1 229.83,270.83
  BOTTOM w0.356: R981.1 229.86,269.73 U449.10
  BOTTOM w0.508: BD1728.2 229.83,270.83
S1_AWG_2SHARE+: length 212.9
  L21_SIGNAL w0.102: 244.81,269.89 244.52,270.18 v2(244.3,270.18) ; K107.4 167.17,277.43 167.06,277.33
  L21_SIGNAL w0.105: 167.06,277.33 167.06,265 169,263.06 199.75,263.06 200.81,264.12 206.7,264.12 211.41,268.82 215.7,268.82 218.71,271.83 218.71,280.07 219.33,280.7 222.06,280.7 223.12,279.64 223.12,275.5 225.91,272.71 228.09,272.71 230.85,275.47 230.85,279.97 233.57,282.7 235.18,282.7 241.52,289.03 244.66,289.03 245.39,288.3 245.39,277.31 245.92,276.79 246.75,276.79 247.11,277.15 247.11,290.15 247.99,291.02 252.04,291.02 252.89,290.18 252.89,275.56 253.98,274.46 268.12,274.46 268.74,273.85 268.74,272.83 268.28,272.37 251.58,272.37 249.61,270.41 247.84,270.41 247.33,269.89 244.81,269.89
  BOTTOM w0.132: v2(244.3,270.18) 244.51,270.18 244.64,270.05 244.64,269.54 U451.1
S1_AWG_2SHARE-: length 212.9
  L21_SIGNAL w0.102: K107.5 166.59,277.43 166.69,277.33 ; 244.96,270.26 244.78,270.44 v2(244.78,270.66)
  L21_SIGNAL w0.105: 166.69,277.33 166.69,276.33 166.59,276.23 166.38,276.23 166.28,276.12 166.28,275.91 166.38,275.81 166.59,275.81 166.69,275.7 166.69,264.84 168.84,262.69 199.91,262.69 200.96,263.75 206.85,263.75 211.56,268.45 215.85,268.45 219.07,271.67 219.07,279.92 219.48,280.33 221.91,280.33 222.75,279.48 222.75,275.35 225.76,272.35 228.24,272.35 231.21,275.32 231.21,279.82 233.72,282.33 235.33,282.33 241.67,288.67 244.51,288.67 245.03,288.15 245.03,277.16 245.77,276.42 246.9,276.42 247.48,276.99 247.48,289.99 248.14,290.66 251.89,290.66 252.52,290.03 252.52,275.41 253.83,274.1 267.97,274.1 268.37,273.69 268.37,272.98 268.13,272.74 251.42,272.74 249.46,270.77 247.69,270.77 247.18,270.26 244.96,270.26
  BOTTOM w0.132: U451.2 245.02,269.57 245.02,270.2 244.78,270.44 v2(244.78,270.66)
S1_AWG_3SHARE+: length 19.2
  L17_SIGNAL w0.079: 166.97,279.71 166.97,293.95
  L17_SIGNAL w0.091: 166.97,279.71 167.05,279.63 K107.3 ; K109.2 167.05,294.02 166.97,293.95
S1_AWG_3SHARE-: length 19.2
  L17_SIGNAL w0.079: 166.78,293.95 166.78,279.71
  L17_SIGNAL w0.091: K107.6 166.7,279.63 166.78,279.71 ; 166.78,293.95 166.7,294.02 K109.7
S1_CON1_0V6: length 2.5
  L15_SIGNAL w1.016: CON1.6 CON1.5
S1_CON1_0V8:
  vias: v3(36.7,203.82) v3(36.7,201.28) v3(36.7,198.74) v3(36.7,196.2) v3(36.7,177.15) v3(36.7,174.61) v3(36.7,172.07) v3(36.7,169.53)
S1_CON1_1V1_1V2: length 2.5
  L15_SIGNAL w1.016: CON1.26 CON1.25
S1_CON1_1V5_1V2:
  vias: v3(58.29,160.64) v3(58.29,158.1) v3(58.29,155.56) v3(58.29,153.02) v3(58.29,150.48) v3(58.29,147.94) v3(58.29,145.4) v3(58.29,142.86)
S1_CON1_1V8:
  vias: v3(36.7,160.64) v3(36.7,158.1) v3(36.7,155.56) v3(36.7,153.02) v3(36.7,150.48) v3(36.7,147.94) v3(36.7,145.4) v3(36.7,142.86) v3(58.29,213.98) v3(58.29,211.44) v3(58.29,208.9) v3(58.29,206.36)
S1_CON1_A3V3:
  vias: v3(58.29,187.31) v3(58.29,184.77) v3(58.29,182.23) v3(58.29,179.69) v3(58.29,177.15) v3(58.29,174.61) v3(58.29,172.07) v3(58.29,169.53)
S1_CON1_B3V3:
  vias: v3(58.29,203.82) v3(58.29,201.28) v3(58.29,198.74) v3(58.29,196.2)
S1_CON1_CORE_0V9:
  vias: v3(36.7,213.98) v3(36.7,211.44) v3(36.7,208.9) v3(36.7,206.36) v3(36.7,187.31) v3(36.7,184.77) v3(36.7,182.23) v3(36.7,179.69)
S1_CON1_CPU_0V9: length 2.5
  L15_SIGNAL w1.016: CON1.16 CON1.15
S1_CON1_DDR2DDR3: length 2.5
  L15_SIGNAL w1.016: CON1.24 CON1.23
S1_CON1_IPU_0V9: length 2.5
  L15_SIGNAL w1.016: CON1.18 CON1.17
S1_CON1_VDD_DSP: length 2.5
  L15_SIGNAL w1.016: CON1.28 CON1.27
S1_DVDD_DDR_RX: length 13.6
  L17_SIGNAL w0.508: K39.3 226.46,228.57 229.79,231.91 229.79,238.4
  vias: v2(227.26,239.1) v2(227.91,240.4)
S1_DVDD_DDR_TX: length 18.3
  L23_SIGNAL w0.508: 229.87,238.11 230.72,237.26 230.72,225.43 229.83,224.54 228.06,224.54 K39.6
  vias: v2(227.91,239.1) v2(228.56,240.4)
S1_ETH_RN_AB_CASE: length 31.5
  TOP w0.381: SITE1.H16 v2(236.36,244.96)
  L15_SIGNAL w0.508: v2(236.36,244.96) 236.97,244.96
  L15_SIGNAL w0.889: 236.97,244.96 237.35,244.96 ; 245.12,265.76 245.9,266.54 v2(245.9,267.41)
  L15_SIGNAL w1.016: 237.35,244.96 238.99,246.59 238.99,263.68 239.66,264.35 244.55,264.35 245.12,264.92 245.12,265.76
  BOTTOM w0.305: U451.7 245.6,267.72 v2(245.9,267.41)
S1_ETH_RP_AB_CASE: length 31
  L15_SIGNAL w0.305: v2(235.06,244.96) 236.52,246.42
  L15_SIGNAL w0.889: v2(244.79,267.41) 244.55,267.41 243.6,266.46 ; 236.52,246.42 237.02,246.92
  L15_SIGNAL w1.016: 237.02,246.92 237.02,265.77 237.7,266.46 243.6,266.46
  BOTTOM w0.305: U451.8 245.1,267.72 v2(244.79,267.41)
S1_ETH_TN_AB_CASE: length 26.2
  TOP w0.381: SITE1.G15 v2(236.36,245.61)
  L21_SIGNAL w0.305: v2(236.36,245.61) 236.48,245.48 236.81,245.48
  L21_SIGNAL w0.508: 236.81,245.48 237.39,245.48 239.03,247.12
  L21_SIGNAL w0.889: 239.64,266.7 v2(239.64,267.41)
  L21_SIGNAL w1.016: 239.03,247.12 239.03,265.82 239.64,266.43 239.64,266.7
  BOTTOM w0.305: U450.7 239.33,267.72 v2(239.64,267.41)
S1_ETH_TP_AB_CASE: length 25.5
  L21_SIGNAL w0.305: 236.49,246.39 235.71,245.61 v2(234.41,245.61)
  L21_SIGNAL w0.762: 237.07,247.15 237.07,246.97 236.49,246.39
  L21_SIGNAL w0.889: 237.07,266.4 238.09,267.41 v2(238.52,267.41)
  L21_SIGNAL w1.016: 237.07,247.15 237.07,266.4
  BOTTOM w0.305: v2(238.52,267.41) 238.83,267.72 U450.8
S1_M_2V5: length 4.8
  BOTTOM w0.508: MR2.1 C284.1 ; C284.1 C285.1 ; C284.1 237.42,293.35 MU2.6
S1_M_3V2: length 24.3
  BOTTOM w0.381: 227.96,293.87 227.83,293.99 MU3.7
  BOTTOM w0.508: 227.96,293.87 228.48,293.35 228.48,292.27 229.25,291.5 C289.1 231.53,291.5 232.62,290.41 234.29,290.41 235.14,289.56 235.14,284.21 MU1.5 234.18,283.1 MR1.1 237.46,283.1 C283.1 C282.1 238.69,283.18 MU2.2
S1_MUX_3V3: length 1.5
  TOP w0.508: v2(227.1,267.19) v2(227.86,267.19)
  BOTTOM w0.508: v2(227.86,267.19) R512.1 v2(227.1,267.19)
  vias: v2(210.56,246.46) v2(210.56,234.89) v2(222.48,232.36) v2(229.83,272.29) v2(236.97,271.41)
S1_OUT_RX0_CH0_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(217.22,252.07) 217.05,252.24
  L21_SIGNAL w0.105: v2(227.26,249.5) 227.26,250.81 225.65,252.41 222.57,252.41 222.47,252.31 222.47,252.15 222.36,252.05 222.15,252.05 222.05,252.15 222.05,252.31 221.94,252.41 221.73,252.41 221.63,252.31 221.63,252.15 221.52,252.05 221.31,252.05 221.21,252.15 221.21,252.31 221.1,252.41 220.9,252.41 220.79,252.31 220.79,252.15 220.69,252.05 220.48,252.05 220.37,252.15 220.37,252.31 220.27,252.41 219.24,252.41 218.53,253.13 218.53,253.83 218.32,254.04 217.17,254.04 217.05,253.92 217.05,252.24
  BOTTOM w0.132: v2(217.22,252.07) 217.06,251.91 217.06,251.37 216.57,250.88 215,250.88 U408.B2
S1_OUT_RX0_CH0_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 227.62,249.81 227.62,249.03 227.58,248.99 227.58,248.72 227.91,248.4 v2(227.91,248.2)
  L21_SIGNAL w0.102: v2(216.51,252.07) 216.68,252.24
  L21_SIGNAL w0.105: 216.68,252.24 216.68,254.08 217.02,254.41 218.47,254.41 218.89,253.98 218.89,253.28 219.4,252.78 225.81,252.78 227.62,250.96 227.62,249.81
  BOTTOM w0.132: U408.B1 215.19,251.25 216.41,251.25 216.68,251.52 216.68,251.9 v2(216.51,252.07)
S1_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: U408.B4 214.15,251.71 214.15,252.41 214.44,252.7 214.94,252.7 215.3,253.05 215.3,253.77 R647.1
S1_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: U408.A4 213.78,251.83 213.78,252.57 214.28,253.07 214.79,253.07 214.92,253.21 214.92,253.38 214.81,253.5 214.45,253.5 214.38,253.57 214.38,253.78 214.46,253.86 R646.1
S1_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: R647.2 R646.2 C309.1
S1_OUT_RX0_CH1_ABC_CASE+: length 20.2
  L19_SIGNAL w0.102: v2(217.22,249.36) 217.05,249.19
  L19_SIGNAL w0.105: 217.05,249.19 217.05,248.58 217.36,248.26 218.01,248.26 218.57,248.82 218.57,252.02 219.22,252.67 222.05,252.67 222.59,252.13 222.59,250.47 222.88,250.19 224.43,250.19 224.57,250.33 224.85,250.33 225,250.19 225.92,250.19 v2(226.61,249.5)
  BOTTOM w0.132: v2(217.22,249.36) 217.05,249.53 217.05,250.08 216.56,250.57 215.02,250.57 U408.D2
S1_OUT_RX0_CH1_ABC_CASE-: length 20.2
  L19_SIGNAL w0.076: v2(227.26,248.85) 226.93,249.18 226.41,249.18
  L19_SIGNAL w0.102: v2(216.51,249.36) 216.68,249.19
  L19_SIGNAL w0.105: 226.41,249.18 225.77,249.82 222.73,249.82 222.23,250.32 222.23,251.98 221.9,252.31 219.37,252.31 218.93,251.87 218.93,248.67 218.17,247.9 217.21,247.9 216.68,248.42 216.68,249.19
  BOTTOM w0.132: v2(216.51,249.36) 216.68,249.53 216.68,249.93 216.41,250.2 215.18,250.2 U408.D1
S1_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: U408.B5 213.41,251.47 213.41,251.97
  BOTTOM w0.132: 213.41,251.97 213.41,252.83 213.82,253.24 213.82,253.7 R168.1
S1_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: U408.A5 213.04,251.84 213.04,252.56 212.91,252.69 212.82,252.69 212.69,252.82 212.69,253.01 212.82,253.14 213.2,253.14 213.45,253.39 213.45,253.7 R170.1
S1_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: C310.1 R168.2 R170.2
S1_OUT_RX0_CH2_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: 214.73,249.82 214.62,249.72 v2(214.16,249.72)
  L21_SIGNAL w0.105: v2(226.61,248.85) 226.27,249.19 225.43,249.19 224.97,249.66 224.97,249.92 224.81,250.09 224.54,250.09 223.94,250.68 222.86,250.68 222.36,250.19 222.36,249.03 221.09,247.76 218.94,247.76 218.65,248.05 218.65,250.81 218.06,251.41 215.3,251.41 214.73,250.84 214.73,249.82
  BOTTOM w0.16: U408.E2 v2(214.16,249.72)
S1_OUT_RX0_CH2_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 225.81,248.53 226.93,248.53 v2(227.26,248.2)
  L21_SIGNAL w0.102: 215.09,249.82 215.2,249.72 v2(215.66,249.72)
  L21_SIGNAL w0.105: 215.09,249.82 215.09,250.69 215.45,251.04 217.9,251.04 218.28,250.66 218.28,247.89 218.79,247.39 221.24,247.39 222.73,248.88 222.73,250.03 223.01,250.31 223.79,250.31 225.57,248.53 225.81,248.53
  BOTTOM w0.16: U408.E1 v2(215.66,249.72)
S1_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: U408.B6 212.28,251.59 212.28,252.14 211.8,252.62 211.8,253.7 R176.1
S1_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: R178.1 212.64,253.86 212.77,253.73 212.77,253.51 212.66,253.4 212.47,253.4 212.17,253.1 212.17,252.78 212.66,252.29 212.66,251.72 U408.A6
S1_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: C318.1 R176.2 R178.2
S1_OUT_RX0_CH3_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: v2(226.61,248.2) 226.28,248.53 225.74,248.53
  L19_SIGNAL w0.102: v2(217.22,240.5) 217.05,240.67
  L19_SIGNAL w0.105: 217.05,240.67 217.05,243.91 216.55,244.42 216.55,245.39 216.87,245.72 222.19,245.72 225.01,248.53 225.74,248.53
  BOTTOM w0.132: U409.B2 215,239.31 216.57,239.31 217.06,239.8 217.06,240.34 v2(217.22,240.5)
S1_OUT_RX0_CH3_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(216.51,240.5) 216.68,240.67
  L19_SIGNAL w0.105: v2(225.96,248.85) 225.91,248.9 224.86,248.9 224.56,248.6 224.41,248.6 224.31,248.71 224.16,248.71 224.01,248.56 224.01,248.41 224.11,248.3 224.11,248.15 223.97,248.01 223.82,248.01 223.71,248.11 223.56,248.11 223.41,247.96 223.41,247.81 223.52,247.71 223.52,247.56 223.37,247.41 223.22,247.41 223.12,247.52 222.97,247.52 222.82,247.37 222.82,247.22 222.93,247.12 222.93,246.97 222.04,246.08 216.72,246.08 216.18,245.54 216.18,244.26 216.68,243.76 216.68,240.67
  BOTTOM w0.132: v2(216.51,240.5) 216.68,240.34 216.68,239.96 216.41,239.69 215.19,239.69 U409.B1
S1_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: R1089.1 215.3,242.21 215.3,241.48 214.94,241.13 214.44,241.13 214.15,240.85 214.15,240.14 U409.B4
S1_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: R1088.1 214.46,242.3 214.38,242.21 214.38,242 214.45,241.93 214.81,241.93 214.92,241.81 214.92,241.64 214.79,241.51 214.28,241.51 213.78,241 213.78,240.27 U409.A4
S1_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: R1089.2 R1088.2 C302.1
S1_OUT_RX0_CH4_ABC_CASE+: length 20.2
  L21_SIGNAL w0.076: 225.68,247.88 226.28,247.88 v2(226.61,247.56)
  L21_SIGNAL w0.102: v2(217.22,237.8) 217.05,237.97
  L21_SIGNAL w0.105: 225.68,247.88 225.64,247.84 223.67,247.84 223.37,247.53 223.37,247.03 222.33,246 221.86,246 218.69,242.83 218.69,239.27 218.18,238.76 217.46,238.76 217.05,238.34 217.05,237.97
  BOTTOM w0.132: U409.D2 215.02,239.01 216.56,239.01 217.05,238.51 217.05,237.96 v2(217.22,237.8)
S1_OUT_RX0_CH4_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 225.63,248.2 v2(225.96,248.2)
  L21_SIGNAL w0.102: v2(216.51,237.8) 216.68,237.97
  L21_SIGNAL w0.105: 216.68,237.97 216.68,238.5 217.31,239.13 218.03,239.13 218.33,239.43 218.33,240.87 218.22,240.98 217.94,240.98 217.84,241.08 217.84,241.29 217.94,241.4 218.22,241.4 218.33,241.5 218.33,241.71 218.22,241.82 217.94,241.82 217.84,241.92 217.84,242.13 217.94,242.24 218.22,242.24 218.33,242.34 218.33,242.99 221.7,246.36 222.18,246.36 223,247.18 223,247.69 223.52,248.2 225.63,248.2
  BOTTOM w0.132: U409.D1 215.18,238.63 216.41,238.63 216.68,238.36 216.68,237.96 v2(216.51,237.8)
S1_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: 213.41,240.41 213.41,239.9 U409.B5
  BOTTOM w0.132: 213.41,240.41 213.41,241.26 213.82,241.67 213.82,242.13 R180.1
S1_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: R182.1 213.45,242.13 213.45,241.83 213.2,241.57 212.82,241.57 212.69,241.44 212.69,241.25 212.82,241.12 212.91,241.12 213.04,240.99 213.04,240.27 U409.A5
S1_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: C320.1 R180.2 R182.2
S1_OUT_RX0_CH5_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 226.27,247.23 226.93,247.23 v2(227.26,247.56)
  L19_SIGNAL w0.102: v2(214.16,238.15) 214.62,238.15 214.73,238.05
  L19_SIGNAL w0.105: 226.27,247.23 226.23,247.18 225.71,247.18 223.27,244.74 223.27,243.33 219.04,239.11 219.04,238.35 217.59,236.89 215.25,236.89 214.73,237.41 214.73,238.05
  BOTTOM w0.16: U409.E2 v2(214.16,238.15)
S1_OUT_RX0_CH5_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: 215.09,238.05 215.2,238.15 v2(215.66,238.15)
  L19_SIGNAL w0.105: v2(225.96,247.56) 225.95,247.55 225.56,247.55 222.9,244.89 222.9,243.48 222.69,243.28 222.54,243.28 222.36,243.46 222.21,243.46 222.06,243.31 222.06,243.16 222.25,242.98 222.25,242.83 222.1,242.68 221.95,242.68 221.77,242.86 221.62,242.86 221.47,242.71 221.47,242.57 221.65,242.38 221.65,242.24 221.5,242.09 221.35,242.09 221.17,242.27 221.02,242.27 220.88,242.12 220.88,241.97 221.06,241.79 221.06,241.64 218.68,239.26 218.68,238.5 217.44,237.26 215.4,237.26 215.09,237.56 215.09,238.05
  BOTTOM w0.16: U409.E1 v2(215.66,238.15)
S1_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: R666.1 211.8,242.13 211.8,241.06 212.28,240.57 212.28,240.03 U409.B6
S1_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: R664.1 212.64,242.3 212.77,242.17 212.77,241.94 212.66,241.84 212.47,241.84 212.17,241.53 212.17,241.21 212.66,240.72 212.66,240.15 U409.A6
S1_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: R664.2 R666.2 C924.1
S1_PAD_SZQ: length 24.9
  L21_SIGNAL w0.102: K113.5 243.89,221.31 243.89,223.18 235.2,231.86 235.2,235.74 232.46,238.49 v2(232.46,239.75)
S1_PM_SAR0: length 67.5
  L13_SIGNAL w0.091: K34.3 171.7,269.73 171.7,271.98 173.91,274.19 223.65,274.19 224.92,275.46 224.92,282.22 v3(224.52,282.62)
  vias: v2(233.11,248.85)
S1_SPI_CK_ABCD_CASE: length 140.4
  L15_SIGNAL w0.091: K2.6 115.86,244.72 115.86,243.57 116.84,242.6 122.43,242.6 123.7,243.87 131.7,243.87 147.45,228.12 203.94,228.12 209.93,234.11 217.65,234.11 219.46,235.92 224.08,235.92 224.74,235.25 227.28,235.25 227.58,235.56 232.02,235.56 233.21,236.75 234.24,236.75 236.58,239.09 236.58,241 235.87,241.7 v2(235.06,241.7)
S1_SPI_CK_B_CASE: length 9.3
  L23_SIGNAL w0.091: K3.6 112.69,244.7 112.69,243.36 113.43,242.62 115.96,242.62 K2.5
S1_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: K3.7 109.49,250.1 94.78,250.1 93.64,248.96 93.64,242.4 95.07,240.97 95.07,236.02 92.99,233.93 U18.6
S1_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: K3.5 111.09,234.41 110.61,233.93 U19.6
S1_SPI_CZ_ABCD_CASE: length 130.1
  L15_SIGNAL w0.076: 234.73,239.58 234.73,241.38 v2(234.41,241.7)
  L15_SIGNAL w0.091: 234.73,239.58 233.63,238.48 230.99,238.48 230.39,237.88 226.87,237.88 226.28,238.48 225.6,238.48 222.2,241.88 209.91,241.88 201.42,233.4 148.29,233.4 132.33,249.35 123.69,249.35 K2.3
S1_SPI_CZ_B_CASE: length 7.3
  L23_SIGNAL w0.091: K2.4 119.54,245.2 115.39,245.2 K3.3
S1_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: v3(102.24,236.47) 96.81,241.89 96.81,249.09 97.82,250.1 112.69,250.1 K3.2
  BOTTOM w0.16: v3(102.24,236.47) U18.1
S1_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: R205.2 U19.1 116.21,236.47 114.29,238.39 K3.4
S1_SPI_DI_ABCD_CASE: length 152.4
  L15_SIGNAL w0.091: K4.6 105.84,245.2 108.27,245.2 110.42,247.35 117.93,247.35 118.99,246.29 118.99,243.49 119.4,243.09 121.53,243.09 125.17,246.72 131.11,246.72 148.81,229.03 203.76,229.03 210.13,235.41 217.3,235.41 219.46,237.57 223.44,237.57 225.07,235.94 226.69,235.94 227.08,236.32 232.08,236.32 233.04,237.29 234.11,237.29 236.07,239.24 236.07,240.69 v2(235.71,241.06)
S1_SPI_DI_B_CASE: length 9.3
  L23_SIGNAL w0.091: K4.5 103.26,242.62 100.73,242.62 99.99,243.36 99.99,244.7 K5.6
S1_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: K5.7 96.81,246.92 96.81,236.36 93.11,232.66 U18.5
S1_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v3(107.75,232.66) 107.75,237.56 106.77,238.54 103.94,238.54 K5.5
  BOTTOM w0.16: U19.5 v3(107.75,232.66)
S1_SPI_DO_ABCD_CASE: length 151.5
  L15_SIGNAL w0.076: 235.38,239.6 235.38,240.73 v2(235.06,241.05)
  L15_SIGNAL w0.091: 235.38,239.6 235.38,239.29 233.88,237.79 231.58,237.79 231.11,237.32 226.67,237.32 226.2,237.79 224.26,237.79 223.76,238.29 218.83,238.29 217.73,237.19 213.82,237.19 213.18,237.82 213.18,239.75 212.83,240.11 210.77,240.11 203.76,233.1 203.76,231.47 203.02,230.73 188.11,230.73 187.22,231.62 148.11,231.62 131.13,248.6 125.31,248.6 121.99,245.29 120.22,245.29 119.35,246.15 119.35,248.08 117.93,249.51 110.67,249.51 107.94,246.78 K4.3
S1_SPI_DO_B_CASE: length 7.3
  L23_SIGNAL w0.091: K5.3 102.69,245.2 106.84,245.2 K4.4
S1_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: U18.2 104.09,235.2 104.86,235.97 104.86,239.12 103.16,240.82 103.16,246.92 K5.2
S1_SPI_DO_D_CASE: length 24.7
  TOP w0.16: v3(121.06,235.2) 115.69,235.2 108.45,242.44 103.25,242.44 K5.4
  BOTTOM w0.16: U19.2 v3(121.06,235.2)
S1_SPI_HLD_ABCD_CASE: length 175
  L15_SIGNAL w0.076: 236.07,242.68 235.38,242.68 v2(235.06,242.36)
  L15_SIGNAL w0.091: K6.3 93.64,244.7 93.64,243.01 95.96,240.69 131.19,240.69 150.29,221.59 221.77,221.59 222.81,222.63 222.81,229.23 224.89,231.32 228.02,231.32 231.29,234.59 234.28,234.59 235,235.32 235.97,235.32 237.71,237.06 237.71,241.71 236.73,242.68 236.07,242.68
S1_SPI_HLD_B_CASE: length 7.3
  L23_SIGNAL w0.091: K6.4 94.14,245.2 89.99,245.2 K7.3
S1_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: K7.2 90.46,246.92 90.46,242.28 93.73,239.01 93.73,235.81 93.11,235.2 U18.7 R202.1
S1_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: v3(106.78,235.2) 106.14,235.84 97.15,235.84 K7.4
  BOTTOM w0.16: U19.7 v3(106.78,235.2)
S1_SPI_WPZ_ABCD_CASE: length 171.1
  L15_SIGNAL w0.091: v2(235.71,242.36) 235.82,242.24 236.42,242.24 237.31,241.35 237.31,237.19 236.09,235.97 235,235.97 234.12,235.09 229.53,235.09 228.69,234.25 226,234.25 220.01,228.27 220.01,225.22 218.49,223.7 149.78,223.7 131.55,241.94 97.98,241.94 96.81,243.1 96.81,246.43 95.84,247.4 93.14,247.4 K6.6
S1_SPI_WPZ_B_CASE: length 9.3
  L23_SIGNAL w0.091: K6.5 90.56,242.62 88.03,242.62 87.29,243.36 87.29,244.7 K7.6
S1_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v3(102.24,233.93) 97.05,233.93 87.29,243.69 87.29,246.9 K7.7
  BOTTOM w0.16: v3(102.24,233.93) U18.3
S1_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: K7.5 99.28,230.5 117.63,230.5 v3(121.06,233.93)
  BOTTOM w0.16: R207.2 v3(121.06,233.93) U19.3
S1_USB2_SEL0: length 1.2
  BOTTOM w0.16: R164.2 223.94,234.06 224.19,234.3 U31.6
S1_USB2_SEL1: length 1.5
  BOTTOM w0.16: U31.5 224.6,233.9 223.84,233.14 R163.2
S1_USB2_SELS: length 0.8
  BOTTOM w0.16: R165.2 227.91,233.9 U31.16
S1_USB_D_AB_CASE+: length 15.3
  L21_SIGNAL w0.13: v2(226.01,236.49) 225.91,236.6 225.91,238.85 223.56,241.19 223.56,242.42 223.69,242.55 223.97,242.55 224.11,242.69 224.11,242.94 223.98,243.07 223.69,243.07 223.56,243.2 223.56,243.46 223.69,243.59 223.97,243.59 224.11,243.73 224.11,243.98 223.98,244.11 223.69,244.11 223.56,244.24 223.56,245.04 224.78,246.26 v2(225.96,246.26)
  BOTTOM w0.165: U31.10 225.88,236.36 v2(226.01,236.49)
S1_USB_D_AB_CASE-: length 15.3
  L21_SIGNAL w0.13: v2(225.35,236.49) 225.46,236.6 225.46,238.67 223.12,241.01 223.12,245.22 224.61,246.71 226.15,246.71 v2(226.61,246.26)
  BOTTOM w0.165: v2(225.35,236.49) 225.48,236.36 U31.9
S1_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: U31.8 223.85,235.1 R160.2
S1_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: U31.7 223.85,234.7 R161.2
S1_USER_3V3: length 2.6
  BOTTOM w0.305: R207.1 v3(123.44,233.93) ; R205.1 v3(123.44,236.47) ; R200.1 v3(103.63,236.47) ; R203.1 v3(103.63,233.93)
  vias: v3(87.1,237.74) v3(87.1,236.47) v3(87.1,235.2) v3(87.58,239.34) v3(100.08,225.58) v3(101.74,225.85) v3(105.53,237.74) v3(105.78,236.47) v3(105.78,235.2) v3(106,239.34)
S1_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(235.06,243.65) 235.35,243.95 235.57,244.17 238.02,244.17 239.01,243.18 239.01,238.84 236.33,236.15 236.33,230.9 237.03,230.19 K32.3
S1_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: K32.4 R135.1
S1_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: Y1.3 236.93,219.93 237.49,220.49 237.49,223.54 236.55,224.48 C267.1 R136.2 R135.2
S1_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: K32.6 234.28,230.19 234.98,230.89 234.98,236.7 237.6,239.33 237.6,243.06 237.01,243.65 v2(235.71,243.65)
S1_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: K32.5 R137.1
S1_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: R137.2 R136.1 C268.1 231.69,224.48 231.29,224.07 231.29,222.72 Y1.1
S1_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(234.04,257.96) 234.04,267.56 233.31,268.29 v2(232.49,268.29)
  BOTTOM w0.16: K29.7 v2(234.04,257.96) ; U449.7 232.19,268.59 v2(232.49,268.29)
S1_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: v2(229.21,248.85) 229.6,249.25
  BOTTOM w0.16: K29.6 233.38,260.16 232.71,259.49 232.71,253.39 231.11,251.79 230.61,251.79 229.86,251.04 229.86,249.5 229.6,249.25
S1_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: C271.1 233.19,266.93 Y2.1 233.19,263.05 233.88,262.36 K29.5
S1_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: R923.1 231.92,273.09 R973.2 231.69,271.81 U449.2
S1_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(229.84,257.96) 229.84,267.56 230.56,268.29 v2(231.38,268.29)
  BOTTOM w0.16: v2(231.38,268.29) 231.69,268.59 U449.8 ; K29.2 v2(229.84,257.96)
S1_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: K29.3 230.64,260.16 231.34,259.45 231.34,254.01 229.21,251.87 v2(229.21,249.5)
S1_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: C272.1 230.69,266.93 Y2.2 230.69,263.05 229.99,262.36 K29.4
S1_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: R652.1 230.92,273.09 R973.1 231.19,271.78 U449.1
S2_0V5: length 41.7
  BOTTOM w0.305: 273.67,292.26 273.49,292.08 UNK2C288.1 273.44,292.06 273.24,292.26
  BOTTOM w0.381: UNK2MU3.3 272.17,293.34 272.29,293.22
  BOTTOM w0.508: UNK2MR4.1 UNK2MR5.1 UNK2MR6.1 UNK2MR2.2 ; UNK2MR4.1 274.25,295.96 273.63,296.57 261.47,296.57 258.56,293.66 258.56,285.78 259.18,285.16 UNK2MK1.4 ; UNK2MR4.1 UNK2MR3.1 274.32,294.48 UNK2C286.1 274.32,292.91 273.67,292.26 ; 272.29,293.22 272.29,293.21 273.24,292.26
S2_0V25: length 2.8
  BOTTOM w0.508: UNK2MK4.3 264.45,286.63 UNK2MR19.1 261.88,286.63 UNK2MR18.2
S2_0V75: length 4.9
  BOTTOM w0.381: UNK2MU3.6 UNK2MR10.2
  BOTTOM w0.508: UNK2MK2.4 264.85,290.82 UNK2C290.1 UNK2MR10.2
S2_1AWG_SHARE+: length 17.9
  L25_SIGNAL w0.091: UNK2K107.2 180.62,280.28 180.62,266.79 UNK2K34.4
S2_3V3_ETH_MUX: length 7.8
  BOTTOM w0.254: v2(284.55,273.3) UNK2C1081.1 UNK2R990.1 ; 276.97,269.95 UNK2C1077.1 UNK2R984.1 ; v2(283.75,269.49) UNK2C1080.1 UNK2R987.1
  BOTTOM w0.305: UNK2R990.1 284.08,272.67 UNK2U452.10 ; UNK2U451.10 283.27,268.86 UNK2R987.1 ; UNK2U450.10 277.01,268.86 UNK2R984.1
  BOTTOM w0.508: v2(276.97,270.47) 276.97,269.95
S2_3V3_RX0_MIPI: length 13.4
  TOP w0.305: UNK2R661.2 252.78,248.06 253.12,247.72 v1(253.66,247.72)
  TOP w0.381: v1(253.66,247.72) 254.36,247.72 254.87,248.23 254.87,251.5 v1(254.66,251.72)
  BOTTOM w0.381: v1(253.66,247.72) UNK2C922.2
  BOTTOM w0.508: UNK2BDB5.2 251.5,245.91 251.82,245.59 253.3,245.59 253.66,245.95 UNK2C922.2
S2_3V3_RX1_MIPI: length 13.4
  TOP w0.305: v1(253.66,236.15) 253.12,236.15 252.78,236.49 UNK2R663.2
  TOP w0.381: v1(254.66,240.15) 254.87,239.94 254.87,236.66 254.36,236.15 v1(253.66,236.15)
  BOTTOM w0.381: v1(253.66,236.15) UNK2C923.2
  BOTTOM w0.508: UNK2BDB6.2 251.5,234.35 251.82,234.02 253.3,234.02 253.66,234.38 UNK2C923.2
S2_3V3_USB2_MUX: length 2.9
  BOTTOM w0.229: UNK2U31.4 265.48,233.24 264.61,232.36 UNK2C262.1
  BOTTOM w0.305: UNK2BD21.2 UNK2C262.1
S2_3V3_XTAL32K: length 2.9
  BOTTOM w0.254: 269.83,270.83 UNK2C1074.1 UNK2R981.1
  BOTTOM w0.356: UNK2U449.10 269.86,269.73 UNK2R981.1
  BOTTOM w0.508: UNK2BD1728.2 269.83,270.83
S2_AWG_2SHARE+: length 212.9
  L21_SIGNAL w0.102: 284.81,269.89 284.52,270.18 v2(284.3,270.18) ; UNK2K107.4 176.82,277.43 176.71,277.33
  L21_SIGNAL w0.105: 284.81,269.89 287.33,269.89 290.26,272.82 290.26,275.93 290.75,276.42 291.81,276.42 292.37,275.86 292.37,271.28 293.13,270.52 298.2,270.52 299.05,271.36 299.05,277.77 303.03,281.75 303.03,284.09 302.16,284.95 281.79,284.95 280.91,284.07 280.91,281.4 280.16,280.65 269.61,280.65 267.97,279.01 263.61,279.01 259.43,283.19 257.46,283.19 254.84,285.81 254.84,292.27 254.16,292.96 243.91,292.96 241.49,290.54 235.87,290.54 234.62,289.29 234.62,284.88 234.11,284.37 233.35,284.37 232.3,285.42 230.89,285.42 228.63,283.16 228.63,279.39 228,278.76 226.04,278.76 221.61,283.2 217.52,283.2 216.63,282.31 216.63,273.5 215.77,272.64 210.69,272.64 207.96,269.91 201.7,269.91 200.58,271.03 178,271.03 176.71,272.32 176.71,277.33
  BOTTOM w0.132: v2(284.3,270.18) 284.51,270.18 284.64,270.05 284.64,269.54 UNK2U451.1
S2_AWG_2SHARE-: length 212.9
  L21_SIGNAL w0.102: UNK2K107.5 176.24,277.43 176.35,277.33 ; v2(284.78,270.66) 284.78,270.44 284.96,270.26
  L21_SIGNAL w0.105: 176.35,277.33 176.35,276.54 176.24,276.43 176.03,276.43 175.93,276.33 175.93,276.12 176.03,276.01 176.24,276.01 176.35,275.91 176.35,272.17 177.85,270.66 200.43,270.66 201.54,269.55 208.12,269.55 210.84,272.27 215.92,272.27 217,273.34 217,282.16 217.67,282.83 221.45,282.83 225.89,278.4 228.15,278.4 229,279.24 229,283.01 231.04,285.05 232.15,285.05 233.19,284 234.26,284 234.98,284.73 234.98,289.14 236.02,290.17 241.65,290.17 244.07,292.59 254,292.59 254.47,292.12 254.47,285.66 257.31,282.82 259.28,282.82 263.46,278.64 268.12,278.64 269.77,280.28 280.31,280.28 281.27,281.24 281.27,283.92 281.95,284.59 302.01,284.59 302.66,283.94 302.66,281.9 298.68,277.92 298.68,271.52 298.04,270.88 293.28,270.88 292.74,271.43 292.74,276.01 291.96,276.79 290.6,276.79 289.9,276.08 289.9,272.98 287.18,270.26 284.96,270.26
  BOTTOM w0.132: UNK2U451.2 285.02,269.57 285.02,270.2 284.78,270.44 v2(284.78,270.66)
S2_AWG_3SHARE+: length 19.2
  L17_SIGNAL w0.079: 176.63,279.71 176.63,293.95
  L17_SIGNAL w0.091: 176.63,279.71 176.71,279.63 UNK2K107.3 ; K110.2 176.71,294.02 176.63,293.95
S2_AWG_3SHARE-: length 19.2
  L17_SIGNAL w0.079: 176.43,293.95 176.43,279.71
  L17_SIGNAL w0.091: 176.43,293.95 176.35,294.02 K110.7 ; 176.43,279.71 176.35,279.63 UNK2K107.6
S2_DVDD_DDR_RX: length 13.6
  L17_SIGNAL w0.508: 269.79,238.4 269.79,231.91 266.46,228.57 UNK2K39.3
  vias: v2(267.25,239.1) v2(267.9,240.4)
S2_DVDD_DDR_TX: length 18.3
  L23_SIGNAL w0.508: 269.87,238.11 270.72,237.26 270.72,225.43 269.83,224.54 268.06,224.54 UNK2K39.6
  vias: v2(267.9,239.1) v2(268.55,240.4)
S2_ETH_RN_AB_CASE: length 31.5
  TOP w0.381: SITE2.H16 v2(276.36,244.96)
  L15_SIGNAL w0.508: 276.97,244.96 v2(276.36,244.96)
  L15_SIGNAL w0.889: v2(285.9,267.41) 285.9,266.54 285.12,265.76 ; 277.35,244.96 276.97,244.96
  L15_SIGNAL w1.016: 277.35,244.96 278.99,246.59 278.99,263.68 279.66,264.35 284.55,264.35 285.12,264.92 285.12,265.76
  BOTTOM w0.305: v2(285.9,267.41) 285.6,267.72 UNK2U451.7
S2_ETH_RP_AB_CASE: length 31
  L15_SIGNAL w0.305: v2(275.06,244.96) 276.52,246.42
  L15_SIGNAL w0.889: 276.52,246.42 277.02,246.92 ; 283.6,266.46 284.55,267.41 v2(284.79,267.41)
  L15_SIGNAL w1.016: 277.02,246.92 277.02,265.77 277.7,266.46 283.6,266.46
  BOTTOM w0.305: v2(284.79,267.41) 285.1,267.72 UNK2U451.8
S2_ETH_TN_AB_CASE: length 26.2
  TOP w0.381: SITE2.G15 v2(276.36,245.61)
  L21_SIGNAL w0.305: v2(276.36,245.61) 276.48,245.48 276.81,245.48
  L21_SIGNAL w0.508: 279.03,247.12 277.39,245.48 276.81,245.48
  L21_SIGNAL w0.889: 279.64,266.7 v2(279.64,267.41)
  L21_SIGNAL w1.016: 279.03,247.12 279.03,265.82 279.64,266.43 279.64,266.7
  BOTTOM w0.305: UNK2U450.7 279.33,267.72 v2(279.64,267.41)
S2_ETH_TP_AB_CASE: length 25.5
  L21_SIGNAL w0.305: v2(274.41,245.61) 275.71,245.61 276.49,246.39
  L21_SIGNAL w0.762: 276.49,246.39 277.07,246.97 277.07,247.15
  L21_SIGNAL w0.889: v2(278.52,267.41) 278.09,267.41 277.07,266.4
  L21_SIGNAL w1.016: 277.07,247.15 277.07,266.4
  BOTTOM w0.305: UNK2U450.8 278.83,267.72 v2(278.52,267.41)
S2_M_2V5: length 4.8
  BOTTOM w0.508: UNK2C284.1 277.42,293.35 UNK2MU2.6 ; UNK2C284.1 UNK2C285.1 ; UNK2C284.1 UNK2MR2.1
S2_M_3V2: length 24.3
  BOTTOM w0.381: 267.96,293.87 267.83,293.99 UNK2MU3.7
  BOTTOM w0.508: 267.96,293.87 268.48,293.35 268.48,292.27 269.25,291.5 UNK2C289.1 271.53,291.5 272.62,290.41 274.29,290.41 275.14,289.56 275.14,284.21 UNK2MU1.5 274.18,283.1 UNK2MR1.1 277.46,283.1 UNK2C283.1 UNK2C282.1 278.69,283.18 UNK2MU2.2
S2_MUX_3V3: length 1.5
  TOP w0.508: v2(267.1,267.19) v2(267.86,267.19)
  BOTTOM w0.508: v2(267.1,267.19) UNK2R512.1 v2(267.86,267.19)
  vias: v2(250.56,246.46) v2(250.56,234.89) v2(262.48,232.36) v2(269.83,272.29) v2(276.97,271.41)
S2_OUT_RX0_CH0_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(257.22,252.07) 257.05,252.24
  L21_SIGNAL w0.105: 257.05,252.24 257.05,253.92 257.17,254.04 258.32,254.04 258.53,253.83 258.53,253.13 259.24,252.41 260.27,252.41 260.37,252.31 260.37,252.15 260.48,252.05 260.69,252.05 260.79,252.15 260.79,252.31 260.9,252.41 261.1,252.41 261.21,252.31 261.21,252.15 261.31,252.05 261.52,252.05 261.63,252.15 261.63,252.31 261.73,252.41 261.94,252.41 262.05,252.31 262.05,252.15 262.15,252.05 262.36,252.05 262.47,252.15 262.47,252.31 262.57,252.41 265.65,252.41 267.25,250.81 v2(267.25,249.5)
  BOTTOM w0.132: v2(257.22,252.07) 257.06,251.91 257.06,251.37 256.57,250.88 255,250.88 UNK2U408.B2
S2_OUT_RX0_CH0_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 267.62,249.81 267.62,249.03 267.58,248.99 267.58,248.72 267.9,248.4 v2(267.9,248.2)
  L21_SIGNAL w0.102: v2(256.51,252.07) 256.68,252.24
  L21_SIGNAL w0.105: 267.62,249.81 267.62,250.96 265.81,252.78 259.4,252.78 258.89,253.28 258.89,253.98 258.47,254.41 257.02,254.41 256.68,254.08 256.68,252.24
  BOTTOM w0.132: v2(256.51,252.07) 256.68,251.9 256.68,251.52 256.41,251.25 255.19,251.25 UNK2U408.B1
S2_OUT_RX0_CH0_B_CASE+: length 3.7
  BOTTOM w0.132: UNK2U408.B4 254.15,251.71 254.15,252.41 254.44,252.7 254.94,252.7 255.3,253.05 255.3,253.77 UNK2R647.1
S2_OUT_RX0_CH0_B_CASE-: length 3.7
  BOTTOM w0.132: UNK2U408.A4 253.78,251.83 253.78,252.57 254.28,253.07 254.79,253.07 254.92,253.21 254.92,253.38 254.81,253.5 254.45,253.5 254.38,253.57 254.38,253.78 254.46,253.86 UNK2R646.1
S2_OUT_RX0_CH0_C_CASE: length 1.4
  BOTTOM w0.305: UNK2C309.1 UNK2R646.2 UNK2R647.2
S2_OUT_RX0_CH1_ABC_CASE+: length 20.2
  L19_SIGNAL w0.102: v2(257.22,249.36) 257.05,249.19
  L19_SIGNAL w0.105: 257.05,249.19 257.05,248.58 257.36,248.26 258.01,248.26 258.57,248.82 258.57,252.02 259.22,252.67 262.05,252.67 262.59,252.13 262.59,250.47 262.88,250.19 264.43,250.19 264.57,250.33 264.85,250.33 265,250.19 265.92,250.19 v2(266.61,249.5)
  BOTTOM w0.132: UNK2U408.D2 255.02,250.57 256.56,250.57 257.05,250.08 257.05,249.53 v2(257.22,249.36)
S2_OUT_RX0_CH1_ABC_CASE-: length 20.2
  L19_SIGNAL w0.076: 266.41,249.18 266.93,249.18 v2(267.25,248.85)
  L19_SIGNAL w0.102: v2(256.51,249.36) 256.68,249.19
  L19_SIGNAL w0.105: 256.68,249.19 256.68,248.42 257.21,247.9 258.17,247.9 258.93,248.67 258.93,251.87 259.37,252.31 261.9,252.31 262.23,251.98 262.23,250.32 262.73,249.82 265.77,249.82 266.41,249.18
  BOTTOM w0.132: v2(256.51,249.36) 256.68,249.53 256.68,249.93 256.41,250.2 255.18,250.2 UNK2U408.D1
S2_OUT_RX0_CH1_B_CASE+: length 3
  BOTTOM w0.076: UNK2U408.B5 253.41,251.47 253.41,251.97
  BOTTOM w0.132: UNK2R168.1 253.82,253.7 253.82,253.24 253.41,252.83 253.41,251.97
S2_OUT_RX0_CH1_B_CASE-: length 3
  BOTTOM w0.132: UNK2U408.A5 253.04,251.84 253.04,252.56 252.91,252.69 252.82,252.69 252.69,252.82 252.69,253.01 252.82,253.14 253.2,253.14 253.45,253.39 253.45,253.7 UNK2R170.1
S2_OUT_RX0_CH1_C_CASE: length 1.4
  BOTTOM w0.305: UNK2C310.1 UNK2R168.2 UNK2R170.2
S2_OUT_RX0_CH2_ABC_CASE+: length 20.2
  L21_SIGNAL w0.102: v2(254.16,249.72) 254.62,249.72 254.73,249.82
  L21_SIGNAL w0.105: 254.73,249.82 254.73,250.84 255.3,251.41 258.06,251.41 258.65,250.81 258.65,248.05 258.94,247.76 261.09,247.76 262.36,249.03 262.36,250.19 262.86,250.68 263.94,250.68 264.54,250.09 264.81,250.09 264.97,249.92 264.97,249.66 265.43,249.19 266.27,249.19 v2(266.61,248.85)
  BOTTOM w0.16: UNK2U408.E2 v2(254.16,249.72)
S2_OUT_RX0_CH2_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 265.81,248.53 266.93,248.53 v2(267.25,248.2)
  L21_SIGNAL w0.102: 255.09,249.82 255.2,249.72 v2(255.66,249.72)
  L21_SIGNAL w0.105: 265.81,248.53 265.57,248.53 263.79,250.31 263.01,250.31 262.73,250.03 262.73,248.88 261.24,247.39 258.79,247.39 258.28,247.89 258.28,250.66 257.9,251.04 255.45,251.04 255.09,250.69 255.09,249.82
  BOTTOM w0.16: UNK2U408.E1 v2(255.66,249.72)
S2_OUT_RX0_CH2_B_CASE+: length 3.1
  BOTTOM w0.132: UNK2U408.B6 252.28,251.59 252.28,252.14 251.8,252.62 251.8,253.7 UNK2R176.1
S2_OUT_RX0_CH2_B_CASE-: length 3.1
  BOTTOM w0.132: UNK2R178.1 252.64,253.86 252.77,253.73 252.77,253.51 252.66,253.4 252.47,253.4 252.17,253.1 252.17,252.78 252.66,252.29 252.66,251.72 UNK2U408.A6
S2_OUT_RX0_CH2_C_CASE: length 1.4
  BOTTOM w0.305: UNK2C318.1 UNK2R176.2 UNK2R178.2
S2_OUT_RX0_CH3_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 265.74,248.53 266.28,248.53 v2(266.61,248.2)
  L19_SIGNAL w0.102: v2(257.22,240.5) 257.05,240.67
  L19_SIGNAL w0.105: 265.74,248.53 265.01,248.53 262.19,245.72 256.87,245.72 256.55,245.39 256.55,244.42 257.05,243.91 257.05,240.67
  BOTTOM w0.132: v2(257.22,240.5) 257.06,240.34 257.06,239.8 256.57,239.31 255,239.31 UNK2U409.B2
S2_OUT_RX0_CH3_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(256.51,240.5) 256.68,240.67
  L19_SIGNAL w0.105: v2(265.96,248.85) 265.91,248.9 264.86,248.9 264.56,248.6 264.41,248.6 264.31,248.71 264.16,248.71 264.01,248.56 264.01,248.41 264.11,248.3 264.11,248.15 263.97,248.01 263.82,248.01 263.71,248.11 263.56,248.11 263.41,247.96 263.41,247.81 263.52,247.71 263.52,247.56 263.37,247.41 263.22,247.41 263.12,247.52 262.97,247.52 262.82,247.37 262.82,247.22 262.93,247.12 262.93,246.97 262.04,246.08 256.72,246.08 256.18,245.54 256.18,244.26 256.68,243.76 256.68,240.67
  BOTTOM w0.132: v2(256.51,240.5) 256.68,240.34 256.68,239.96 256.41,239.69 255.19,239.69 UNK2U409.B1
S2_OUT_RX0_CH3_B_CASE+: length 3.7
  BOTTOM w0.132: UNK2R1089.1 255.3,242.21 255.3,241.48 254.94,241.13 254.44,241.13 254.15,240.85 254.15,240.14 UNK2U409.B4
S2_OUT_RX0_CH3_B_CASE-: length 3.7
  BOTTOM w0.132: UNK2U409.A4 253.78,240.27 253.78,241 254.28,241.51 254.79,241.51 254.92,241.64 254.92,241.81 254.81,241.93 254.45,241.93 254.38,242 254.38,242.21 254.46,242.3 UNK2R1088.1
S2_OUT_RX0_CH3_C_CASE: length 1.4
  BOTTOM w0.305: UNK2R1089.2 UNK2R1088.2 UNK2C302.1
S2_OUT_RX0_CH4_ABC_CASE+: length 20.2
  L21_SIGNAL w0.076: v2(266.61,247.56) 266.28,247.88 265.68,247.88
  L21_SIGNAL w0.102: v2(257.22,237.8) 257.05,237.97
  L21_SIGNAL w0.105: 257.05,237.97 257.05,238.34 257.46,238.76 258.18,238.76 258.69,239.27 258.69,242.83 261.86,246 262.33,246 263.37,247.03 263.37,247.53 263.67,247.84 265.64,247.84 265.68,247.88
  BOTTOM w0.132: UNK2U409.D2 255.02,239.01 256.56,239.01 257.05,238.51 257.05,237.96 v2(257.22,237.8)
S2_OUT_RX0_CH4_ABC_CASE-: length 20.2
  L21_SIGNAL w0.076: 265.63,248.2 v2(265.96,248.2)
  L21_SIGNAL w0.102: v2(256.51,237.8) 256.68,237.97
  L21_SIGNAL w0.105: 256.68,237.97 256.68,238.5 257.31,239.13 258.03,239.13 258.33,239.43 258.33,240.87 258.22,240.98 257.94,240.98 257.84,241.08 257.84,241.29 257.94,241.4 258.22,241.4 258.33,241.5 258.33,241.71 258.22,241.82 257.94,241.82 257.84,241.92 257.84,242.13 257.94,242.24 258.22,242.24 258.33,242.34 258.33,242.99 261.7,246.36 262.18,246.36 263,247.18 263,247.69 263.52,248.2 265.63,248.2
  BOTTOM w0.132: UNK2U409.D1 255.18,238.63 256.41,238.63 256.68,238.36 256.68,237.96 v2(256.51,237.8)
S2_OUT_RX0_CH4_B_CASE+: length 3
  BOTTOM w0.076: 253.41,240.41 253.41,239.9 UNK2U409.B5
  BOTTOM w0.132: 253.41,240.41 253.41,241.26 253.82,241.67 253.82,242.13 UNK2R180.1
S2_OUT_RX0_CH4_B_CASE-: length 3
  BOTTOM w0.132: UNK2U409.A5 253.04,240.27 253.04,240.99 252.91,241.12 252.82,241.12 252.69,241.25 252.69,241.44 252.82,241.57 253.2,241.57 253.45,241.83 253.45,242.13 UNK2R182.1
S2_OUT_RX0_CH4_C_CASE: length 1.4
  BOTTOM w0.305: UNK2R182.2 UNK2R180.2 UNK2C320.1
S2_OUT_RX0_CH5_ABC_CASE+: length 20.2
  L19_SIGNAL w0.076: 266.27,247.23 266.93,247.23 v2(267.25,247.56)
  L19_SIGNAL w0.102: 254.73,238.05 254.62,238.15 v2(254.16,238.15)
  L19_SIGNAL w0.105: 266.27,247.23 266.23,247.18 265.71,247.18 263.27,244.74 263.27,243.33 259.04,239.11 259.04,238.35 257.59,236.89 255.25,236.89 254.73,237.41 254.73,238.05
  BOTTOM w0.16: UNK2U409.E2 v2(254.16,238.15)
S2_OUT_RX0_CH5_ABC_CASE-: length 20.2
  L19_SIGNAL w0.102: v2(255.66,238.15) 255.2,238.15 255.09,238.05
  L19_SIGNAL w0.105: 255.09,238.05 255.09,237.56 255.4,237.26 257.44,237.26 258.68,238.5 258.68,239.26 261.06,241.64 261.06,241.79 260.88,241.97 260.88,242.12 261.02,242.27 261.17,242.27 261.35,242.09 261.5,242.09 261.65,242.24 261.65,242.38 261.47,242.57 261.47,242.71 261.62,242.86 261.77,242.86 261.95,242.68 262.1,242.68 262.25,242.83 262.25,242.98 262.06,243.16 262.06,243.31 262.21,243.46 262.36,243.46 262.54,243.28 262.69,243.28 262.9,243.48 262.9,244.89 265.56,247.55 265.95,247.55 v2(265.96,247.56)
  BOTTOM w0.16: UNK2U409.E1 v2(255.66,238.15)
S2_OUT_RX0_CH5_B_CASE+: length 3.1
  BOTTOM w0.132: UNK2U409.B6 252.28,240.03 252.28,240.57 251.8,241.06 251.8,242.13 UNK2R666.1
S2_OUT_RX0_CH5_B_CASE-: length 3.1
  BOTTOM w0.132: UNK2R664.1 252.64,242.3 252.77,242.17 252.77,241.94 252.66,241.84 252.47,241.84 252.17,241.53 252.17,241.21 252.66,240.72 252.66,240.15 UNK2U409.A6
S2_OUT_RX0_CH5_C_CASE: length 1.4
  BOTTOM w0.305: UNK2R664.2 UNK2R666.2 UNK2C924.1
S2_PAD_SZQ: length 24.9
  L21_SIGNAL w0.102: UNK2K113.5 283.89,221.31 283.89,223.18 275.2,231.86 275.2,235.74 272.46,238.49 v2(272.46,239.75)
S2_PM_SAR0: length 91.7
  L13_SIGNAL w0.091: v3(264.52,282.62) 262.57,280.67 253.62,280.67 251.71,278.76 250.44,278.76 246.38,274.7 233.93,274.7 232.73,273.49 228.54,273.49 227.65,272.61 209.61,272.61 208.66,271.65 183.28,271.65 UNK2K34.3
  vias: v2(273.11,248.85)
S2_SPI_CK_ABCD_CASE: length 190.7
  L15_SIGNAL w0.091: v2(275.06,241.7) 275.87,241.7 276.58,241 276.58,239.09 275.06,237.57 275.06,228.78 269.77,223.49 269.77,221.69 264.85,216.76 259.84,216.76 257.38,214.3 247.9,214.3 246.43,212.83 159.89,212.83 154.89,207.82 140.92,207.82 135.33,213.41 124.99,213.41 122.43,210.85 116.84,210.85 115.86,211.82 115.86,212.97 UNK2K2.6
S2_SPI_CK_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK2K2.5 115.96,210.87 113.43,210.87 112.69,211.61 112.69,212.95 UNK2K3.6
S2_SPI_CK_C_CASE: length 37.2
  BOTTOM w0.16: UNK2K3.7 109.49,218.35 94.78,218.35 93.64,217.21 93.64,210.65 95.07,209.22 95.07,204.27 92.99,202.18 UNK2U18.6
S2_SPI_CK_D_CASE: length 11.7
  BOTTOM w0.16: UNK2U19.6 110.61,202.18 111.09,202.66 UNK2K3.5
S2_SPI_CZ_ABCD_CASE: length 168.7
  L15_SIGNAL w0.076: v2(274.41,241.7) 274.73,241.38 274.73,239.58
  L15_SIGNAL w0.091: 274.73,239.58 272.54,237.39 272.54,236.27 269.8,233.53 269.8,232.89 267.11,230.2 265.91,230.2 264.9,229.18 264.9,228.52 260.35,223.98 253.72,223.98 247.5,217.75 153.85,217.75 153.16,218.44 132.54,218.44 132.11,218.01 124.1,218.01 UNK2K2.3
S2_SPI_CZ_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK2K2.4 119.54,213.45 115.39,213.45 UNK2K3.3
S2_SPI_CZ_C_CASE: length 35.9
  TOP w0.16: v3(102.24,204.72) 96.81,210.14 96.81,217.34 97.82,218.35 112.69,218.35 UNK2K3.2
  BOTTOM w0.16: v3(102.24,204.72) UNK2U18.1
S2_SPI_CZ_D_CASE: length 14.4
  BOTTOM w0.16: UNK2R205.2 UNK2U19.1 116.21,204.72 114.29,206.64 UNK2K3.4
S2_SPI_DI_ABCD_CASE: length 200.5
  L15_SIGNAL w0.091: v2(275.71,241.06) 276.07,240.69 276.07,239.24 274.52,237.7 274.52,230.4 267.56,223.44 267.56,221.66 263.63,217.73 258.9,217.73 256.18,215.01 209.45,215.01 208.18,213.74 158.6,213.74 153.44,208.58 141.74,208.58 134.94,215.39 125.59,215.39 121.53,211.34 119.4,211.34 118.99,211.74 118.99,214.54 117.93,215.6 110.42,215.6 108.27,213.45 105.84,213.45 UNK2K4.6
S2_SPI_DI_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK2K4.5 103.26,210.87 100.73,210.87 99.99,211.61 99.99,212.95 UNK2K5.6
S2_SPI_DI_C_CASE: length 20.3
  BOTTOM w0.16: UNK2K5.7 96.81,215.17 96.81,204.61 93.11,200.91 UNK2U18.5
S2_SPI_DI_D_CASE: length 18.5
  TOP w0.16: v3(107.75,200.91) 107.75,205.81 106.77,206.79 103.94,206.79 UNK2K5.5
  BOTTOM w0.16: UNK2U19.5 v3(107.75,200.91)
S2_SPI_DO_ABCD_CASE: length 191.3
  L15_SIGNAL w0.076: v2(275.06,241.05) 275.38,240.73 275.38,239.6
  L15_SIGNAL w0.091: UNK2K4.3 107.94,215.03 110.67,217.76 117.93,217.76 119.35,216.33 119.35,214.4 120.22,213.54 121.99,213.54 124.74,216.28 136.08,216.28 141.69,210.67 153.47,210.67 159.11,216.31 256.11,216.31 265.32,225.52 265.32,227.18 270.59,232.44 270.59,233.58 272.91,235.91 272.91,236.82 275.38,239.29 275.38,239.6
S2_SPI_DO_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK2K5.3 102.69,213.45 106.84,213.45 UNK2K4.4
S2_SPI_DO_C_CASE: length 19.3
  BOTTOM w0.16: UNK2K5.2 103.16,215.17 103.16,209.07 104.86,207.37 104.86,204.22 104.09,203.45 UNK2U18.2
S2_SPI_DO_D_CASE: length 24.7
  TOP w0.16: UNK2K5.4 103.25,210.69 108.45,210.69 115.69,203.45 v3(121.06,203.45)
  BOTTOM w0.16: UNK2U19.2 v3(121.06,203.45)
S2_SPI_HLD_ABCD_CASE: length 227.7
  L15_SIGNAL w0.076: v2(275.06,242.36) 275.38,242.68 276.07,242.68
  L15_SIGNAL w0.091: 276.07,242.68 276.73,242.68 277.71,241.71 277.71,237.9 279.47,236.13 279.47,216.02 277.62,214.17 273,214.17 272.44,213.61 269.19,213.61 268.33,212.75 259.92,212.75 258.19,211.02 247.78,211.02 245.01,208.25 233.86,208.25 232.38,209.73 227.33,209.73 226.9,210.16 161.26,210.16 156.67,205.56 139.6,205.56 136.22,208.94 95.96,208.94 93.64,211.26 93.64,212.95 UNK2K6.3
S2_SPI_HLD_B_CASE: length 7.3
  L23_SIGNAL w0.091: UNK2K7.3 89.99,213.45 94.14,213.45 UNK2K6.4
S2_SPI_HLD_C_CASE: length 20.6
  BOTTOM w0.16: UNK2K7.2 90.46,215.17 90.46,210.53 93.73,207.26 93.73,204.06 93.11,203.45 UNK2U18.7 UNK2R202.1
S2_SPI_HLD_D_CASE: length 24.1
  TOP w0.16: UNK2K7.4 97.15,204.09 106.14,204.09 v3(106.78,203.45)
  BOTTOM w0.16: UNK2U19.7 v3(106.78,203.45)
S2_SPI_WPZ_ABCD_CASE: length 224.7
  L15_SIGNAL w0.091: UNK2K6.6 93.14,215.65 95.84,215.65 96.81,214.68 96.81,211.35 97.98,210.19 124.53,210.19 125.32,210.97 135.69,210.97 140.28,206.38 155.52,206.38 160.02,210.87 226.14,210.87 226.97,211.71 230.78,211.71 231.17,212.09 257.17,212.09 259.99,214.91 276.4,214.91 278.59,217.1 278.59,236.39 277.31,237.67 277.31,241.35 276.42,242.24 275.82,242.24 v2(275.71,242.36)
S2_SPI_WPZ_B_CASE: length 9.3
  L23_SIGNAL w0.091: UNK2K6.5 90.56,210.87 88.03,210.87 87.29,211.61 87.29,212.95 UNK2K7.6
S2_SPI_WPZ_C_CASE: length 27
  TOP w0.16: v3(102.24,202.18) 97.05,202.18 87.29,211.94 87.29,215.15 UNK2K7.7
  BOTTOM w0.16: v3(102.24,202.18) UNK2U18.3
S2_SPI_WPZ_D_CASE: length 45.1
  TOP w0.16: v3(121.06,202.18) 117.63,198.75 99.28,198.75 UNK2K7.5
  BOTTOM w0.16: UNK2R207.2 v3(121.06,202.18) UNK2U19.3
S2_USB2_SEL0: length 1.2
  BOTTOM w0.16: UNK2R164.2 263.94,234.06 264.19,234.3 UNK2U31.6
S2_USB2_SEL1: length 1.5
  BOTTOM w0.16: UNK2R163.2 263.84,233.14 264.6,233.9 UNK2U31.5
S2_USB2_SELS: length 0.8
  BOTTOM w0.16: UNK2R165.2 267.91,233.9 UNK2U31.16
S2_USB_D_AB_CASE+: length 15.4
  L21_SIGNAL w0.13: v2(266.01,236.49) 265.94,236.56 265.94,238.78 263.42,241.3 263.42,242.24 263.55,242.37 263.86,242.37 263.99,242.5 263.99,242.76 263.86,242.89 263.55,242.89 263.42,243.02 263.42,243.28 263.55,243.4 263.86,243.4 263.99,243.53 263.99,243.79 263.86,243.92 263.55,243.92 263.42,244.05 263.42,244.76 264.52,245.86 265.56,245.86 v2(265.96,246.26)
  BOTTOM w0.165: UNK2U31.10 265.88,236.36 v2(266.01,236.49)
S2_USB_D_AB_CASE-: length 15.4
  L21_SIGNAL w0.13: v2(266.61,246.26) 266.13,246.73 265.73,246.73 265.25,246.25 264.78,246.25 264.73,246.31 264.34,246.31 262.98,244.94 262.98,241.11 265.49,238.6 265.49,236.63 v2(265.35,236.49)
  BOTTOM w0.165: v2(265.35,236.49) 265.48,236.36 UNK2U31.9
S2_USB_D_B_CASE+: length 1.2
  BOTTOM w0.165: UNK2R160.2 263.85,235.1 UNK2U31.8
S2_USB_D_B_CASE-: length 1.2
  BOTTOM w0.165: UNK2R161.2 263.85,234.7 UNK2U31.7
S2_USER_3V3: length 2.6
  BOTTOM w0.305: UNK2R205.1 v3(123.44,204.72) ; UNK2R200.1 v3(103.63,204.72) ; UNK2R203.1 v3(103.63,202.18) ; UNK2R207.1 v3(123.44,202.18)
  vias: v3(87.1,205.99) v3(87.1,204.72) v3(87.1,203.45) v3(87.58,207.59) v3(100.08,193.83) v3(101.74,194.1) v3(105.53,205.99) v3(105.78,204.72) v3(105.78,203.45) v3(106,207.59)
S2_XTAL_24M_IN_ABC_CASE: length 21.2
  BOTTOM w0.16: v2(275.06,243.65) 275.35,243.95 275.57,244.17 278.02,244.17 279.01,243.18 279.01,238.84 276.33,236.15 276.33,230.9 277.03,230.19 UNK2K32.3
S2_XTAL_24M_IN_B_CASE: length 2.6
  BOTTOM w0.16: UNK2K32.4 UNK2R135.1
S2_XTAL_24M_IN_C_CASE: length 9.1
  BOTTOM w0.16: UNK2Y1.3 276.93,219.93 277.49,220.49 277.49,223.54 276.55,224.48 UNK2C267.1 UNK2R136.2 UNK2R135.2
S2_XTAL_24M_OUT_ABC_CASE: length 18.4
  BOTTOM w0.16: UNK2K32.6 274.28,230.19 274.98,230.89 274.98,236.7 277.6,239.33 277.6,243.06 277.01,243.65 v2(275.71,243.65)
S2_XTAL_24M_OUT_B_CASE: length 2.6
  BOTTOM w0.16: UNK2K32.5 UNK2R137.1
S2_XTAL_24M_OUT_C_CASE: length 9.1
  BOTTOM w0.16: UNK2R137.2 UNK2R136.1 UNK2C268.1 271.69,224.48 271.29,224.07 271.29,222.72 UNK2Y1.1
S2_XTAL_IN_32K_A_CASE: length 13.8
  TOP w0.16: v2(272.49,268.29) 273.31,268.29 274.04,267.56 v2(274.04,257.96)
  BOTTOM w0.16: UNK2U449.7 272.19,268.59 v2(272.49,268.29) ; UNK2K29.7 v2(274.04,257.96)
S2_XTAL_IN_32K_ABCD_CASE: length 15.4
  BOTTOM w0.076: 269.6,249.25 v2(269.2,248.85)
  BOTTOM w0.16: UNK2K29.6 273.38,260.16 272.71,259.49 272.71,253.39 271.11,251.79 270.61,251.79 269.85,251.04 269.85,249.5 269.6,249.25
S2_XTAL_IN_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK2K29.5 273.88,262.36 273.19,263.05 UNK2Y2.1 273.19,266.93 UNK2C271.1
S2_XTAL_IN_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK2R923.1 271.92,273.09 UNK2R973.2 271.69,271.81 UNK2U449.2
S2_XTAL_OUT_32K_A_CASE: length 13.8
  TOP w0.16: v2(269.84,257.96) 269.84,267.56 270.56,268.29 v2(271.38,268.29)
  BOTTOM w0.16: UNK2U449.8 271.69,268.59 v2(271.38,268.29) ; UNK2K29.2 v2(269.84,257.96)
S2_XTAL_OUT_32K_ABCD_CASE: length 14
  BOTTOM w0.16: v2(269.2,249.5) 269.2,251.87 271.34,254.01 271.34,259.45 270.64,260.16 UNK2K29.3
S2_XTAL_OUT_32K_B_CASE: length 6.8
  BOTTOM w0.16: UNK2C272.1 270.69,266.93 UNK2Y2.2 270.69,263.05 269.99,262.36 UNK2K29.4
S2_XTAL_OUT_32K_D_CASE: length 2.9
  BOTTOM w0.16: UNK2U449.1 271.19,271.78 UNK2R973.1 270.92,273.09 UNK2R652.1
S3_0V5: length 41.7
  BOTTOM w0.305: 313.24,292.26 313.44,292.06 UNK3C288.1 313.49,292.08 313.67,292.26
  BOTTOM w0.381: UNK3MU3.3 312.17,293.34 312.29,293.22
  BOTTOM w0.508: UNK3MR2.2 UNK3MR6.1 UNK3MR5.1 UNK3MR4.1 ; 313.67,292.26 314.32,292.91 UNK3C286.1 314.32,294.48 UNK3MR3.1 UNK3MR4.1 ; UNK3MR4.1 314.25,295.96 313.63,296.57 301.47,296.57 298.56,293.66 298.56,285.78 299.18,285.16 UNK3MK1.4 ; 312.29,293.22 312.29,293.21 313.24,292.26
S3_0V25: length 2.8
  BOTTOM w0.508: UNK3MR18.2 301.88,286.63 UNK3MR19.1 304.45,286.63 UNK3MK4.3
S3_0V75: length 4.9
  BOTTOM w0.381: UNK3MU3.6 UNK3MR10.2
  BOTTOM w0.508: UNK3MR10.2 UNK3C290.1 304.85,290.82 UNK3MK2.4
