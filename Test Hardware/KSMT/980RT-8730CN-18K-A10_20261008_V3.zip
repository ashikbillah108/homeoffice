# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Nets (continued)
S0_VDD33_J2: J2.1 R24.2
S0_VDD33_J3: J3.1 R30.2
S0_VREF_DRAM: C153.1 K16.3 SITE0.63(VREF_DRAM/NC(PSRAM))
S0_XI: C25.2 SITE0.22(XI) Y1.1
S0_XO: C23.2 SITE0.21(XO) Y1.3
S1_1_AOUT_LN: UNK1K10.4 UNK1R45.1 UNK1R67.1 UNK1R68.1
S1_1_AOUT_LP: UNK1K10.5 UNK1R69.1 UNK1R70.1 UNK1R75.1
S1_1_AOUT_RN: UNK1K14.4 UNK1R47.1 UNK1R63.1 UNK1R64.1
S1_1_AOUT_RP: UNK1K14.5 UNK1R65.1 UNK1R66.1 UNK1R74.1
S1_1_SPI_CLK: UNK1R15.1 UNK1U3.6
S1_1_SPI_CS: UNK1R10.2 UNK1U3.1
S1_1_SPI_DATA0: UNK1R17.1 UNK1U3.5
S1_1_SPI_DATA1: UNK1R11.2 UNK1U3.2
S1_1_SPI_DATA2: UNK1R14.2 UNK1R16.2 UNK1R18.2 UNK1U3.3
S1_1_SPI_DATA3: UNK1R12.1 UNK1R13.1 UNK1U3.7
S1_1_VDD09: UNK1BD1.1 UNK1BD2.1 UNK1BD37.1 UNK1C60.1 UNK1R48.2 UNK1R76.1 UNK1R77.1 UNK1R78.1 UNK1R79.1 UNK1ST13.2
S1_1_VDD18_A: S1_1V3.1(TP) UNK1K26.2 UNK1K26.5 UNK1R50.1
S1_1_VDD18_D: UNK1C113.2 UNK1R53.2 UNK1R81.1 UNK1R82.1 UNK1R83.1 UNK1ST15.1
S1_2_AOUT_LN: UNK1K12.4 UNK1R68.2
S1_2_AOUT_LP: UNK1K12.5 UNK1R69.2
S1_2_AOUT_RN: UNK1K15.4 UNK1R64.2
S1_2_AOUT_RP: UNK1K15.5 UNK1R65.2
S1_2_VDD18_A: UNK1BD16.1 UNK1BD17.1 UNK1BD19.1 UNK1BD20.1 UNK1C89.1 UNK1R50.2
S1_ATX_VD0V9: ATX_VD0V9.4 UNK1C65.1 UNK1C66.1 UNK1K21.6 UNK1ST3.2
S1_ATX_VD1V8: ATX_VD1V8.4 UNK1J7.1 UNK1J8.1 UNK1J9.1
S1_ATX_VD33: ATX_VD33.4 UNK1BD33.1 UNK1C131.1 UNK1C132.1 UNK1C133.1 UNK1C134.1 UNK1C135.1 UNK1J6.2
S1_AVCC_DRV: SITE1.53(AVCC_DRV) UNK1C75.1 UNK1C110.1 UNK1R55.2 UNK1ST14.1
S1_CHIP_EN_1: UNK1R34.2 UNK1SW5.1
S1_DPS_F001: UNK1C120.1 UNK1C121.1 UNK1J9.2 UNK1K29.6 UNK1ST11.2
S1_DPS_F002: UNK1C92.1 UNK1C93.1 UNK1C94.1 UNK1C95.1 UNK1J8.2 UNK1K26.6 UNK1ST8.2
S1_DPS_F004: UNK1C140.1 UNK1C141.1 UNK1J7.2 UNK1K20.6 UNK1ST12.2
S1_DPS_F006: S1_VD33_ALL1.1(TP) UNK1C68.1 UNK1C69.1 UNK1C70.1 UNK1C71.1 UNK1C72.1 UNK1K23.3 UNK1K23.6 UNK1ST4.2
S1_DPS_GS001: UNK1ST19.1
S1_DPS_GS002: UNK1ST18.1
S1_DPS_GS003-1: UNK1ST16.1
S1_DPS_GS004: UNK1ST17.1
S1_DPS_GS006: UNK1ST5.1
S1_DPS_S001: UNK1ST11.1
S1_DPS_S002: UNK1ST8.1
S1_DPS_S003-1: UNK1ST3.1
S1_DPS_S004: UNK1ST12.1
S1_DPS_S006: UNK1ST4.1
S1_HSDM: SITE1.79(HSDM) UNK1K5.8
S1_HSDP: SITE1.78(HSDP) UNK1K5.2
S1_LPC_001: UNK1K36.7
S1_LPC_002: UNK1K36.2
S1_LPC_003: UNK1K11.2
S1_LPC_005: UNK1K14.2
S1_LPC_006: UNK1K18.4
S1_LPC_007: UNK1K1.4
S1_LPC_008: UNK1K35.2
S1_LPC_009: K38.6
S1_LPC_010: UNK1K34.7
S1_LPC_012: K37.6
S1_LPC_013+: UNK1K5.3 UNK1K7.2
S1_LPC_013-: UNK1K5.7 UNK1K7.8
S1_LPC_016: UNK1K2.5
S1_LPC_017: UNK1K35.7
S1_LPC_019: UNK1K12.2
S1_LPC_021: UNK1K1.5
S1_LPC_022: UNK1K15.2
S1_LPC_023: UNK1K3.4
S1_LPC_024: SITE1.69(UART2_TXD/TEST_MODE_SEL/DMIC0_C) UNK1J4.2 UNK1R35.1
S1_LPC_025: SITE1.71(CHIP_EN) UNK1J4.1 UNK1R34.1
S1_LPC_026: UNK1K2.4
S1_LPC_027: UNK1K10.2
S1_LPC_028: UNK1K10.7
S1_LPC_029: UNK1K13.7
S1_LPC_030: UNK1K16.2
S1_LPC_032: UNK1K15.7
S1_LPC_033: UNK1K14.7
S1_LPC_034: UNK1K18.5
S1_LPC_035: UNK1K12.7
S1_LPC_036: UNK1K34.2
S1_LPC_038: UNK1K13.2
S1_LPC_039: UNK1K3.5
S1_LPC_040: UNK1K11.7
S1_LPC_041: SITE1.68(UART2_RXD/BOOT_SEL/DMIC0_DATA/G) UNK1J4.3 UNK1R36.1
S1_LPC_042: SITE1.50(MIC_BIAS2/GPIOC_13/PA[31]) UNK1C18.2
S1_LPC_043: K33.6
S1_LPC_044: SITE1.58(I2S3_DOUT1/DMIC_DATA2/ICFG1/GPI) UNK1J4.5 UNK1R39.1
S1_LPC_045: UNK1K39.3
S1_LPC_046: SITE1.67(I2S2_DIN3/I2S3_DOUT3/SPK_CLK/SP)
S1_LPC_047: SITE1.18(GPIOB_7/PA[16]/ICFG3/SPI0_CS/UA) UNK1J4.7 UNK1R41.1
S1_LPC_048: UNK1K6.4
S1_LPC_049: SITE1.8(GPIOA_5/PA[5]/TOUCH5/ADC5/UART1)
S1_LPC_050: SITE1.7(GPIOA_4/PA[4]/TOUCH4/ADC4/UART1)
S1_LPC_051: SITE1.49(MIC_BIAS1/GPIOC_12/PA[30]) UNK1C17.2
S1_LPC_052: SITE1.48(AVCC) UNK1C21.1
S1_LPC_053: SITE1.57(I2S3_DOUT0/DMIC_DATA1/ICFG0/BT_) UNK1J4.4 UNK1R37.1
S1_LPC_054: UNK1K6.5
S1_LPC_055: SITE1.10(VBAT_MEAS)
S1_LPC_057: UNK1K9.4
S1_LPC_058: SITE1.17(GPIOB_6/PA[15]/ICFG2/SPI0_CLK/U) UNK1J4.6 UNK1R40.1
S1_LPC_059: UNK1K39.6
S1_LPC_060: SITE1.66(I2S2_DIN2/I2S3_DOUT2/SPK_DATA/S)
S1_LPC_A_015: UNK1K8.4
S1_LPC_A_020: UNK1K8.5
S1_LPC_B_031: UNK1K4.4
S1_LPC_B_037: UNK1K4.5
S1_LPC_CH00: P5.A2(2)
S1_LPC_CH01: P5.A4(4)
S1_LPC_CH02: P5.A6(6)
S1_LPC_CH03: P5.A8(8)
S1_LPC_CH04: P5.A10(10)
S1_LPC_CH05: P5.A12(12)
S1_LPC_CH06: P5.B1(1)
S1_LPC_CH07: P5.B3(3)
S1_LPC_CH08: P5.B5(5)
S1_LPC_CH09: P5.B7(7)
S1_LPC_CH10: P5.B9(9)
S1_LPC_CH11: P5.B11(11)
S1_LPC_CH12: P5.C2(2)
S1_LPC_CH13: P5.C4(4)
S1_LPC_CH14: P5.C6(6)
S1_LPC_CH15: P5.C8(8)
S1_LPC_CH16: P5.C10(10)
S1_LPC_CH17: P5.C12(12)
S1_LPC_CH18: P5.D1(1)
S1_LPC_CH19: P5.D3(3)
S1_LPC_CH20: P5.D5(5)
S1_LPC_CH21: P5.D7(7)
S1_LPC_CH22: P5.D9(9)
S1_LPC_CH23: P5.D11(11)
S1_LPC_CH24: P5.E2(2)
S1_LPC_CH25: P5.E4(4)
S1_LPC_CH26: P5.E6(6)
S1_LPC_CH27: P5.E8(8)
S1_LPC_CH28: P5.E10(10)
S1_LPC_CH29: P5.E12(12)
S1_LPC_CH30: P5.F1(1)
S1_LPC_CH31: P5.F3(3)
S1_LPC_CH32: P10.M2(2)
S1_LPC_CH33: P10.M4(4)
S1_LPC_CH34: P10.M6(6)
S1_LPC_CH35: P10.M8(8)
S1_LPC_CH36: P10.M10(10)
S1_LPC_CH37: P10.M12(12)
S1_LPC_CH38: P10.L1(1)
S1_LPC_CH39: P10.L3(3)
S1_LPC_CH40: P10.L5(5)
S1_LPC_CH41: P10.L7(7)
S1_LPC_CH42: P10.L9(9)
S1_LPC_CH43: P10.L11(11)
S1_LPC_CH44: P10.K2(2)
S1_LPC_CH45: P10.K4(4)
S1_LPC_CH46: P10.K6(6)
S1_LPC_CH47: P10.K8(8)
S1_LPC_CH48: P10.K10(10)
S1_LPC_CH49: P10.K12(12)
S1_LPC_CH50: P10.J1(1)
S1_LPC_CH51: P10.J3(3)
S1_LPC_CH52: P10.J5(5)
S1_LPC_CH53: P10.J7(7)
S1_LPC_CH54: P10.J9(9)
S1_LPC_CH55: P10.J11(11)
S1_LPC_CH56: P10.I2(2)
S1_LPC_CH57: P10.I4(4)
S1_LPC_CH58: P10.I6(6)
S1_LPC_CH59: P10.I8(8)
S1_LPC_CH60: P10.I10(10)
S1_LPC_CH61: P10.I12(12)
S1_LPC_CH62: P10.H1(1)
S1_LPC_CH63: P10.H3(3)
S1_LPC_CH64: P5.F5(5)
S1_LPC_CH65: P5.F7(7)
S1_LPC_CH66: P5.F9(9)
S1_LPC_CH67: P5.F11(11)
S1_LPC_CH68: P5.G2(2)
S1_LPC_CH69: P5.G4(4)
S1_LPC_CH70: P5.G6(6)
S1_LPC_CH71: P5.G8(8)
S1_LPC_CH72: P5.G10(10)
S1_LPC_CH73: P5.G12(12)
S1_LPC_CH74: P5.H1(1)
S1_LPC_CH75: P5.H3(3)
S1_LPC_CH76: P5.H5(5)
S1_LPC_CH77: P5.H7(7)
S1_LPC_CH78: P5.H9(9)
S1_LPC_CH79: P5.H11(11)
S1_LPC_CH80: P5.I2(2)
S1_LPC_CH81: P5.I4(4)
S1_LPC_CH82: P5.I6(6)
S1_LPC_CH83: P5.I8(8)
S1_LPC_CH84: P5.I10(10)
S1_LPC_CH85: P5.I12(12)
S1_LPC_CH86: P5.J1(1)
S1_LPC_CH87: P5.J3(3)
S1_LPC_CH88: P5.J5(5)
S1_LPC_CH89: P5.J7(7)
S1_LPC_CH90: P5.J9(9)
S1_LPC_CH91: P5.J11(11)
S1_LPC_CH92: P5.K2(2)
S1_LPC_CH93: P5.K4(4)
S1_LPC_CH94: P5.K6(6)
S1_LPC_CH95: P5.K8(8)
S1_LPC_CH96: P10.H5(5)
S1_LPC_CH97: P10.H7(7)
S1_LPC_CH98: P10.H9(9)
S1_LPC_CH99: P10.H11(11)
S1_LPC_CH100: P10.G2(2)
S1_LPC_CH101: P10.G4(4)
S1_LPC_CH102: P10.G6(6)
S1_LPC_CH103: P10.G8(8)
S1_LPC_CH104: P10.G10(10)
S1_LPC_CH105: P10.G12(12)
S1_LPC_CH106: P10.F1(1)
S1_LPC_CH107: P10.F3(3)
S1_LPC_CH108: P10.F5(5)
S1_LPC_CH109: P10.F7(7)
S1_LPC_CH110: P10.F9(9)
S1_LPC_CH111: P10.F11(11)
S1_LPC_CH112: P10.E2(2)
S1_LPC_CH113: P10.E4(4)
S1_LPC_CH114: P10.E6(6)
S1_LPC_CH115: P10.E8(8)
S1_LPC_CH116: P10.E10(10)
S1_LPC_CH117: P10.E12(12)
S1_LPC_CH118: P10.D1(1)
S1_LPC_CH119: P10.D3(3)
S1_LPC_CH120: P10.D5(5)
S1_LPC_CH121: P10.D7(7)
S1_LPC_CH122: P10.D9(9)
S1_LPC_CH123: P10.D11(11)
S1_LPC_CH124: P10.C2(2)
S1_LPC_CH125: P10.C4(4)
S1_LPC_CH126: P10.C6(6)
S1_LPC_CH127: P10.C8(8)
S1_LPC_DGS00: P10.C12(12)
S1_LPC_DGS64: P5.K12(12)
S1_LPC_UB0: P10.A4(4)
S1_LPC_UB1: P10.B5(5)
S1_LPC_UB2: P10.A6(6)
S1_LPC_UB3: P10.B7(7)
S1_LPC_UB4: P10.A8(8)
S1_LPC_UB5: P10.B9(9)
S1_LPC_UB6: P10.A10(10)
S1_LPC_UB7: P10.B11(11)
S1_LPC_UB8: P10.A12(12)
S1_LPC_UB9: P5.L5(5)
S1_LPC_UB10: P5.M6(6)
S1_LPC_UB11: P5.L7(7)
S1_LPC_UB12: P5.M8(8)
S1_LPC_UB13: P5.L9(9)
S1_LPC_UB14: P5.M10(10)
S1_LPC_UB15: P5.L11(11)
S1_LX_AUD: SITE1.100(LX_AUD) UNK1K20.3
S1_LX_AUD_CH_1: K38.7 UNK1K20.4
S1_LX_AUD_CH_2: K38.5 UNK1ST14.2
S1_LX_DCORE: SITE1.3(LX_DCORE) UNK1K21.3
S1_LX_DCORE_CH: K37.7 UNK1K21.4
S1_LX_MEM: SITE1.75(LX_MEM) UNK1K29.3
S1_LX_MEM_CH_1: K33.7 UNK1K29.4
S1_LX_MEM_CH_2: K33.5 UNK1ST15.2
S1_MIPITX_CKN: SITE1.82(MIPITX_CKN) UNK1K36.6
S1_MIPITX_CKP: SITE1.83(MIPITX_CKP) UNK1K36.3
S1_MIPITX_DATAN_0: SITE1.85(MIPITX_DATAN_0) UNK1K34.6
S1_MIPITX_DATAN_1: SITE1.80(MIPITX_DATAN_1) UNK1K35.6
S1_MIPITX_DATAP_0: SITE1.86(MIPITX_DATAP_0) UNK1K34.3
S1_MIPITX_DATAP_1: SITE1.81(MIPITX_DATAP_1) UNK1K35.3
S1_PA2: SITE1.5(GPIOA_2/PA[2]/TOUCH2/ADC2/UART0) UNK1K18.3
S1_PA3: SITE1.6(GPIOA_3/PA[3]/TOUCH3/ADC3/UART0) UNK1K18.6
S1_PA9_CH: SITE1.12(GPIOB_0/PA[9]) UNK1K39.2
S1_PA10_CH: SITE1.13(GPIOB_1/PA[10]) UNK1K39.7
S1_PA13: SITE1.15(GPIOB_4/PA[13]/SWD_DATA/SPI0_MO) UNK1K6.3
S1_PA13_UART_RX: UNK1K6.2 UNK1R27.1
S1_PA13_UART_RX_1: UNK1J2.3 UNK1R27.2
S1_PA14: SITE1.16(GPIOB_5/PA[14]/SWD_CLK/SPI0_MIS) UNK1K6.6
S1_PA14_UART_TX: UNK1K6.7 UNK1R28.1
S1_PA14_UART_TX_1: UNK1J2.4 UNK1R28.2
S1_PA15_1: UNK1R40.2 UNK1SW5.6
S1_PA16_1: UNK1R41.2 UNK1SW5.7
S1_PA20: SITE1.45(MIC1_P/GPIOC_2/PA[20]) UNK1K15.6
S1_PA21: SITE1.46(MIC1_N/GPIOC_3/PA[21]) UNK1K15.3
S1_PA22: SITE1.43(MIC2_P/GPIOC_4/PA[22]) UNK1K11.6
S1_PA23: SITE1.44(MIC2_N/GPIOC_5/PA[23]) UNK1K11.3
S1_PA24: SITE1.41(MIC3_P/I2C_SDA/GPIOC_6/PA[24]) UNK1K12.6
S1_PA25: SITE1.42(MIC3_N/I2C_SCL/GPIOC_7/PA[25]) UNK1K12.3
S1_PA28: SITE1.39(MIC5_P/ANT_SEL_P/GPIOC_10/PA[28) UNK1K13.6
S1_PA29: SITE1.40(MIC5_N/ANT_SEL_N/GPIOC_11/PA[29) UNK1K13.3
S1_PB3: SITE1.52(AOUT_LP/GPIOC_17/PB[3]) UNK1K10.6
S1_PB3_AOUT_LP_2: UNK1K13.5 UNK1R70.2
S1_PB4: SITE1.51(AOUT_LN/GPIOC_18/PB[4]) UNK1K10.3
S1_PB4_AOUT_LN_2: UNK1K13.4 UNK1R67.2
S1_PB5: SITE1.54(AOUT_RP/GPIOC_19/PB[5]) UNK1K14.6
S1_PB5_AOUT_RP_2: UNK1K11.5 UNK1R66.2
S1_PB6: SITE1.55(AOUT_RN/GPIOC_20/PB[6]) UNK1K14.3
S1_PB6_AOUT_RN_2: UNK1K11.4 UNK1R63.2
S1_PB10_1: UNK1R37.2 UNK1SW5.4
S1_PB11_1: UNK1R39.2 UNK1SW5.5
S1_PB21_1: UNK1R36.2 UNK1SW5.3
S1_PB22_1: UNK1R35.2 UNK1SW5.2
S1_PB23: SITE1.72(UART_LOG_RXD/OTP_BYPASS/GPIOF_2) UNK1C144.2 UNK1K4.3 UNK1R57.1
S1_PB23_1: UNK1R57.2 UNK1SW6.1
S1_PB23_SICK: UNK1K4.2 UNK1R20.1
S1_PB23_SICK_1: UNK1J1.3 UNK1R20.2
S1_PB24: SITE1.73(UART_LOG_TXD/UART_DOWNLOAD/GPIO) UNK1C143.2 UNK1K4.6 UNK1R58.1
S1_PB24_1: UNK1R58.2 UNK1SW6.2
S1_PB24_SIDD: UNK1K4.7 UNK1R21.1
S1_PB24_SIDD_1: UNK1J1.4 UNK1R21.2
S1_PB25: SITE1.96(SPI0_CLK/SWD_CLK/SD_D2/ICFG2/GP) UNK1K8.3 UNK1R59.1
S1_PB25_1: UNK1R59.2 UNK1SW6.3
S1_PB25_I2C_SCL: UNK1K8.2 UNK1R31.1
S1_PB25_I2C_SCL_1: UNK1J3.3 UNK1R31.2
S1_PB26: SITE1.97(SPI0_CS/SWD_DATA/SD_D3/ICFG3/GP) UNK1K8.6 UNK1R60.1
S1_PB26_1: UNK1R60.2 UNK1SW6.4
S1_PB26_I2C_SDA: UNK1K8.7 UNK1R32.1
S1_PB26_I2C_SDA_1: UNK1J3.4 UNK1R32.2
S1_PMU0_F: P5.L1(1)
S1_PMU0_G: P5.L3(3)
S1_PMU0_S: P5.M2(2)
S1_PMU1_F: P10.B1(1)
S1_PMU1_G: P10.B3(3)
S1_PMU1_S: P10.A2(2)
S1_RF_A: UNK1C13.1 UNK1C14.1 UNK1C15.1 UNK1D3.1 UNK1SMP3.1
S1_RF_G: UNK1C6.1 UNK1C7.1 UNK1C8.1 UNK1D2.1 UNK1SMP2.1
S1_RFIN_A: SITE1.29(RFIN_A/GND (<750UM)) UNK1C16.2 UNK1R9.1
S1_RFIN_G: SITE1.31(RFIN_G/GND) UNK1C9.2 UNK1R5.1
S1_RFIO_A: SITE1.28(RFIO_A  (<750UM)) UNK1C11.2 UNK1R6.1
S1_RFIO_BT: SITE1.37(RFIO_BT) UNK1C1.2 UNK1R1.1
S1_RFIO_G: SITE1.32(RFIO_G) UNK1C4.2 UNK1R2.1
S1_RREF_MEM: SITE1.60(RREF_MEM) UNK1K9.3 UNK1R43.1
S1_SPI_CLK: UNK1K1.7 UNK1R15.2
S1_SPI_CLK/PB28: SITE1.90(SPI_FLASH_CLK/SD_CLK/GPIOG_3/PB) UNK1K1.6
S1_SPI_CS: UNK1K3.2 UNK1R10.1
S1_SPI_CS/PC0: SITE1.95(SPI_FLASH_CS/UART1_CTS/SD_CD/GP) UNK1K3.3
S1_SPI_D0/PB29: SITE1.91(SPI_FLASH_DATA0/UART1_RXD/SD_D0) UNK1K1.3
S1_SPI_D1/PB31: SITE1.94(SPI_FLASH_DATA1/UART1_RTS/SD_WP) UNK1K3.6
S1_SPI_D2/PB30: SITE1.92(SPI_FLASH_DATA2/UART1_TXD/SD_D1) UNK1K2.6
S1_SPI_D3/PB27: SITE1.89(SPI_FLASH_DATA3/SD_CMD/GPIOG_2/) UNK1K2.3
S1_SPI_DATA0: UNK1K1.2 UNK1R17.2
S1_SPI_DATA1: UNK1K3.7 UNK1R11.1
S1_SPI_DATA2: UNK1K2.7 UNK1R16.1
S1_SPI_DATA3: UNK1K2.2 UNK1R13.2
S1_U1_VC1: UNK1K39.5 UNK1U1.4
S1_U2_VC1: UNK1K39.4 UNK1U2.4
S1_VA09_MIPI: SITE1.84(VA09_MIPI/VA09_CK/VA09_DA) UNK1BD37.2 UNK1C152.1
S1_VA09_PLL: SITE1.11(VA09_PLL/VD09_CORE0) UNK1BD1.2 UNK1C44.1
S1_VA09_USB: SITE1.77(VA09_USB) UNK1BD2.2 UNK1C45.1
S1_VA13_AFE: SITE1.19(VA13_AFE) UNK1BD20.2 UNK1C88.1
S1_VA13_SYN: SITE1.23(VR13_SYN) UNK1BD16.2 UNK1C78.1
S1_VA33_SYN: SITE1.24(VR33_SYN) UNK1BD13.2 UNK1C64.1
S1_VA33_XTAL: SITE1.20(VA33_XTAL) UNK1BD5.2 UNK1C48.1
S1_VD09_CORE1: SITE1.56(VD09_CORE1/VD09MEM0) UNK1C47.1 UNK1R76.2
S1_VD09_CORE2: SITE1.64(VD09_CORE2/VD09_MEM1) UNK1C49.1 UNK1R77.2
S1_VD09_CORE3: SITE1.87(VD09_CORE3/VA09_PLL) UNK1C54.1 UNK1R78.2
S1_VD09_CORE4: SITE1.98(VD09_CORE4) UNK1C58.1 UNK1R79.2
S1_VD13_FE: SITE1.36(VD13_FE) UNK1BD19.2 UNK1C85.1
S1_VD13_RF: SITE1.25(VD13_RF) UNK1BD17.2 UNK1C79.1
S1_VD33_ALL: UNK1BD3.1 UNK1BD5.1 UNK1BD7.1 UNK1BD9.1 UNK1BD11.1 UNK1BD12.1 UNK1BD13.1 UNK1BD15.1 UNK1BD18.1 UNK1BD21.1 UNK1BD22.1 UNK1BD23.1 UNK1BD28.1 UNK1BD29.1 UNK1BD30.1 UNK1BD31.1 UNK1BD32.1 UNK1BD36.1 UNK1C67.1 UNK1C96.1 UNK1C101.1 UNK1C122.1 UNK1C129.1 UNK1J5.1 UNK1J6.1 UNK1K23.2 UNK1K23.7
S1_VD33_CM_BT: SITE1.35(VD33_CM_BT) UNK1BD21.2 UNK1C90.1 UNK1C91.1
S1_VD33_EX_FLASH: UNK1BD32.2 UNK1C22.1 UNK1C127.1 UNK1C128.1 UNK1R12.2 UNK1R14.1 UNK1U3.8
S1_VD33_IO0: SITE1.9(VA33_PLL/VD33_IO0) UNK1BD7.2 UNK1C52.1
S1_VD33_IO2: SITE1.59(VD33_IO2/VD33_MEM) UNK1BD9.2 UNK1C56.1
S1_VD33_IO3: SITE1.70(VD33_IO3/VDD_IO4/VA33_USB) UNK1BD11.2 UNK1C59.1
S1_VD33_IO6: SITE1.88(VD33_IO6/VDD33_IO5/VD33_FLASH) UNK1BD12.2 UNK1C61.1
S1_VD33_SPS_AUD: SITE1.1(VD33_SPS_AUD) UNK1BD30.2 UNK1C123.1 UNK1C124.1
S1_VD33_SPS_DCORE: SITE1.2(VD33_SPS_DCORE) UNK1BD28.2 UNK1C111.1 UNK1C112.1
S1_VD33_SPS_MEM: SITE1.76(VD33_SPS_MEM) UNK1BD31.2 UNK1C125.1 UNK1C126.1
S1_VD33PA_A: SITE1.27(VD33PA_A) UNK1BD23.2 UNK1C99.1 UNK1C100.1
S1_VD33PA_BT: SITE1.38(VD33PA_BT) UNK1BD18.2 UNK1C83.1 UNK1C84.1
S1_VD33PA_G: SITE1.33(VD33PA_G) UNK1BD15.2 UNK1C76.1 UNK1C77.1
S1_VD33PAD_A: SITE1.26(VD33PAD_A) UNK1BD22.2 UNK1C97.1 UNK1C98.1
S1_VD33PAD_G: SITE1.34(VD33PAD_G) UNK1BD36.2 UNK1C73.1 UNK1C74.1
S1_VD1833_IO1: SITE1.14(VD1833_IO1) UNK1BD3.2 UNK1C46.1
S1_VD1833_SDIO: SITE1.93(VD1833_SDIO) UNK1BD29.2 UNK1C118.1 UNK1C119.1
S1_VD_MEM0: SITE1.61(VD_MEM0) UNK1C102.1 UNK1R81.2
S1_VD_MEM1: SITE1.62(VD_MEM1) UNK1C105.1 UNK1R82.2
S1_VD_MEM2: SITE1.65(VD_MEM2) UNK1C107.1 UNK1R83.2
S1_VDD09: S1_VDD09.1(TP) UNK1K22.2 UNK1K22.5 UNK1K31.4 UNK1R48.1
S1_VDD09_CH: K37.5 UNK1ST13.1
S1_VDD18_A: S1_VDD18_A.1(TP) UNK1K25.2 UNK1K25.5 UNK1K26.3 UNK1K32.4 UNK1R55.1
S1_VDD18_D: S1_VDD18_D.1(TP) UNK1K28.2 UNK1K28.5 UNK1K30.4 UNK1R29.2 UNK1R53.1
S1_VDD33: UNK1BD33.2 UNK1C130.1 UNK1R19.1 UNK1R24.1 UNK1R30.1 UNK1R38.2 UNK1R61.2 UNK1U1.6 UNK1U2.6
S1_VDD33_J1: UNK1J1.1 UNK1R19.2
S1_VDD33_J2: UNK1J2.1 UNK1R24.2
S1_VDD33_J3: UNK1J3.1 UNK1R30.2
S1_VREF_DRAM: SITE1.63(VREF_DRAM/NC(PSRAM)) UNK1C153.1 UNK1K16.3
S1_XI: SITE1.22(XI) UNK1C25.2 UNK1Y1.1
S1_XO: SITE1.21(XO) UNK1C23.2 UNK1Y1.3
S2_1_AOUT_LN: UNK2K10.4 UNK2R45.1 UNK2R67.1 UNK2R68.1
S2_1_AOUT_LP: UNK2K10.5 UNK2R69.1 UNK2R70.1 UNK2R75.1
S2_1_AOUT_RN: UNK2K14.4 UNK2R47.1 UNK2R63.1 UNK2R64.1
S2_1_AOUT_RP: UNK2K14.5 UNK2R65.1 UNK2R66.1 UNK2R74.1
S2_1_SPI_CLK: UNK2R15.1 UNK2U3.6
S2_1_SPI_CS: UNK2R10.2 UNK2U3.1
S2_1_SPI_DATA0: UNK2R17.1 UNK2U3.5
S2_1_SPI_DATA1: UNK2R11.2 UNK2U3.2
S2_1_SPI_DATA2: UNK2R14.2 UNK2R16.2 UNK2R18.2 UNK2U3.3
S2_1_SPI_DATA3: UNK2R12.1 UNK2R13.1 UNK2U3.7
S2_1_VDD09: UNK2BD1.1 UNK2BD2.1 UNK2BD37.1 UNK2C60.1 UNK2R48.2 UNK2R76.1 UNK2R77.1 UNK2R78.1 UNK2R79.1 UNK2ST13.2
S2_1_VDD18_A: S2_1V3.1(TP) UNK2K26.2 UNK2K26.5 UNK2R50.1
S2_1_VDD18_D: UNK2C113.2 UNK2R53.2 UNK2R81.1 UNK2R82.1 UNK2R83.1 UNK2ST15.1
S2_2_AOUT_LN: UNK2K12.4 UNK2R68.2
S2_2_AOUT_LP: UNK2K12.5 UNK2R69.2
S2_2_AOUT_RN: UNK2K15.4 UNK2R64.2
S2_2_AOUT_RP: UNK2K15.5 UNK2R65.2
S2_2_VDD18_A: UNK2BD16.1 UNK2BD17.1 UNK2BD19.1 UNK2BD20.1 UNK2C89.1 UNK2R50.2
S2_ATX_VD0V9: ATX_VD0V9.6 UNK2C65.1 UNK2C66.1 UNK2K21.6 UNK2ST3.2
S2_ATX_VD1V8: ATX_VD1V8.6 UNK2J7.1 UNK2J8.1 UNK2J9.1
S2_ATX_VD33: ATX_VD33.6 UNK2BD33.1 UNK2C131.1 UNK2C132.1 UNK2C133.1 UNK2C134.1 UNK2C135.1 UNK2J6.2
S2_AVCC_DRV: SITE2.53(AVCC_DRV) UNK2C75.1 UNK2C110.1 UNK2R55.2 UNK2ST14.1
S2_CHIP_EN_1: UNK2R34.2 UNK2SW5.1
S2_DPS_F001: UNK2C120.1 UNK2C121.1 UNK2J9.2 UNK2K29.6 UNK2ST11.2
S2_DPS_F002: UNK2C92.1 UNK2C93.1 UNK2C94.1 UNK2C95.1 UNK2J8.2 UNK2K26.6 UNK2ST8.2
S2_DPS_F004: UNK2C140.1 UNK2C141.1 UNK2J7.2 UNK2K20.6 UNK2ST12.2
S2_DPS_F006: S2_VD33_ALL1.1(TP) UNK2C68.1 UNK2C69.1 UNK2C70.1 UNK2C71.1 UNK2C72.1 UNK2K23.3 UNK2K23.6 UNK2ST4.2
S2_DPS_GS001: UNK2ST19.1
S2_DPS_GS002: UNK2ST18.1
S2_DPS_GS003-1: UNK2ST16.1
S2_DPS_GS004: UNK2ST17.1
S2_DPS_GS006: UNK2ST5.1
S2_DPS_S001: UNK2ST11.1
S2_DPS_S002: UNK2ST8.1
S2_DPS_S003-1: UNK2ST3.1
S2_DPS_S004: UNK2ST12.1
S2_DPS_S006: UNK2ST4.1
S2_HSDM: SITE2.79(HSDM) UNK2K5.8
S2_HSDP: SITE2.78(HSDP) UNK2K5.2
S2_LPC_001: UNK2K36.7
S2_LPC_002: UNK2K36.2
S2_LPC_003: UNK2K11.2
S2_LPC_005: UNK2K14.2
S2_LPC_006: UNK2K18.4
S2_LPC_007: UNK2K1.4
S2_LPC_008: UNK2K35.2
S2_LPC_009: UNK2K38.3
S2_LPC_010: UNK2K34.7
S2_LPC_012: UNK2K37.3
S2_LPC_013+: UNK2K5.3 UNK2K7.2
S2_LPC_013-: UNK2K5.7 UNK2K7.8
S2_LPC_016: UNK2K2.5
S2_LPC_017: UNK2K35.7
S2_LPC_019: UNK2K12.2
S2_LPC_021: UNK2K1.5
S2_LPC_022: UNK2K15.2
S2_LPC_023: UNK2K3.4
S2_LPC_024: SITE2.69(UART2_TXD/TEST_MODE_SEL/DMIC0_C) UNK2J4.2 UNK2R35.1
S2_LPC_025: SITE2.71(CHIP_EN) UNK2J4.1 UNK2R34.1
S2_LPC_026: UNK2K2.4
S2_LPC_027: UNK2K10.2
S2_LPC_028: UNK2K10.7
S2_LPC_029: UNK2K13.7
S2_LPC_030: UNK2K16.2
S2_LPC_032: UNK2K15.7
S2_LPC_033: UNK2K14.7
S2_LPC_034: UNK2K18.5
S2_LPC_035: UNK2K12.7
S2_LPC_036: UNK2K34.2
S2_LPC_038: UNK2K13.2
S2_LPC_039: UNK2K3.5
S2_LPC_040: UNK2K11.7
S2_LPC_041: SITE2.68(UART2_RXD/BOOT_SEL/DMIC0_DATA/G) UNK2J4.3 UNK2R36.1
S2_LPC_042: SITE2.50(MIC_BIAS2/GPIOC_13/PA[31]) UNK2C18.2
S2_LPC_043: UNK2K33.3
S2_LPC_044: SITE2.58(I2S3_DOUT1/DMIC_DATA2/ICFG1/GPI) UNK2J4.5 UNK2R39.1
S2_LPC_045: UNK2K39.3
S2_LPC_046: SITE2.67(I2S2_DIN3/I2S3_DOUT3/SPK_CLK/SP)
S2_LPC_047: SITE2.18(GPIOB_7/PA[16]/ICFG3/SPI0_CS/UA) UNK2J4.7 UNK2R41.1
S2_LPC_048: UNK2K6.4
S2_LPC_049: SITE2.8(GPIOA_5/PA[5]/TOUCH5/ADC5/UART1)
S2_LPC_050: SITE2.7(GPIOA_4/PA[4]/TOUCH4/ADC4/UART1)
S2_LPC_051: SITE2.49(MIC_BIAS1/GPIOC_12/PA[30]) UNK2C17.2
S2_LPC_052: SITE2.48(AVCC) UNK2C21.1
S2_LPC_053: SITE2.57(I2S3_DOUT0/DMIC_DATA1/ICFG0/BT_) UNK2J4.4 UNK2R37.1
S2_LPC_054: UNK2K6.5
S2_LPC_055: SITE2.10(VBAT_MEAS)
S2_LPC_057: UNK2K9.4
S2_LPC_058: SITE2.17(GPIOB_6/PA[15]/ICFG2/SPI0_CLK/U) UNK2J4.6 UNK2R40.1
S2_LPC_059: UNK2K39.6
S2_LPC_060: SITE2.66(I2S2_DIN2/I2S3_DOUT2/SPK_DATA/S)
S2_LPC_A_015: UNK2K8.4
S2_LPC_A_020: UNK2K8.5
S2_LPC_B_031: UNK2K4.4
S2_LPC_B_037: UNK2K4.5
S2_LPC_CH00: P2.A2(2)
S2_LPC_CH01: P2.A4(4)
S2_LPC_CH02: P2.A6(6)
S2_LPC_CH03: P2.A8(8)
S2_LPC_CH04: P2.A10(10)
S2_LPC_CH05: P2.A12(12)
S2_LPC_CH06: P2.B1(1)
S2_LPC_CH07: P2.B3(3)
S2_LPC_CH08: P2.B5(5)
S2_LPC_CH09: P2.B7(7)
S2_LPC_CH10: P2.B9(9)
S2_LPC_CH11: P2.B11(11)
S2_LPC_CH12: P2.C2(2)
S2_LPC_CH13: P2.C4(4)
S2_LPC_CH14: P2.C6(6)
S2_LPC_CH15: P2.C8(8)
S2_LPC_CH16: P2.C10(10)
S2_LPC_CH17: P2.C12(12)
S2_LPC_CH18: P2.D1(1)
S2_LPC_CH19: P2.D3(3)
S2_LPC_CH20: P2.D5(5)
S2_LPC_CH21: P2.D7(7)
S2_LPC_CH22: P2.D9(9)
S2_LPC_CH23: P2.D11(11)
S2_LPC_CH24: P2.E2(2)
S2_LPC_CH25: P2.E4(4)
S2_LPC_CH26: P2.E6(6)
S2_LPC_CH27: P2.E8(8)
S2_LPC_CH28: P2.E10(10)
S2_LPC_CH29: P2.E12(12)
S2_LPC_CH30: P2.F1(1)
S2_LPC_CH31: P2.F3(3)
S2_LPC_CH32: P8.M2(2)
S2_LPC_CH33: P8.M4(4)
S2_LPC_CH34: P8.M6(6)
S2_LPC_CH35: P8.M8(8)
S2_LPC_CH36: P8.M10(10)
S2_LPC_CH37: P8.M12(12)
S2_LPC_CH38: P8.L1(1)
S2_LPC_CH39: P8.L3(3)
S2_LPC_CH40: P8.L5(5)
S2_LPC_CH41: P8.L7(7)
S2_LPC_CH42: P8.L9(9)
S2_LPC_CH43: P8.L11(11)
S2_LPC_CH44: P8.K2(2)
S2_LPC_CH45: P8.K4(4)
S2_LPC_CH46: P8.K6(6)
S2_LPC_CH47: P8.K8(8)
S2_LPC_CH48: P8.K10(10)
S2_LPC_CH49: P8.K12(12)
S2_LPC_CH50: P8.J1(1)
S2_LPC_CH51: P8.J3(3)
S2_LPC_CH52: P8.J5(5)
S2_LPC_CH53: P8.J7(7)
S2_LPC_CH54: P8.J9(9)
S2_LPC_CH55: P8.J11(11)
S2_LPC_CH56: P8.I2(2)
S2_LPC_CH57: P8.I4(4)
S2_LPC_CH58: P8.I6(6)
S2_LPC_CH59: P8.I8(8)
S2_LPC_CH60: P8.I10(10)
S2_LPC_CH61: P8.I12(12)
S2_LPC_CH62: P8.H1(1)
S2_LPC_CH63: P8.H3(3)
S2_LPC_CH64: P2.F5(5)
S2_LPC_CH65: P2.F7(7)
S2_LPC_CH66: P2.F9(9)
S2_LPC_CH67: P2.F11(11)
S2_LPC_CH68: P2.G2(2)
S2_LPC_CH69: P2.G4(4)
S2_LPC_CH70: P2.G6(6)
S2_LPC_CH71: P2.G8(8)
S2_LPC_CH72: P2.G10(10)
S2_LPC_CH73: P2.G12(12)
S2_LPC_CH74: P2.H1(1)
S2_LPC_CH75: P2.H3(3)
S2_LPC_CH76: P2.H5(5)
S2_LPC_CH77: P2.H7(7)
S2_LPC_CH78: P2.H9(9)
S2_LPC_CH79: P2.H11(11)
S2_LPC_CH80: P2.I2(2)
S2_LPC_CH81: P2.I4(4)
S2_LPC_CH82: P2.I6(6)
S2_LPC_CH83: P2.I8(8)
S2_LPC_CH84: P2.I10(10)
S2_LPC_CH85: P2.I12(12)
S2_LPC_CH86: P2.J1(1)
S2_LPC_CH87: P2.J3(3)
S2_LPC_CH88: P2.J5(5)
S2_LPC_CH89: P2.J7(7)
S2_LPC_CH90: P2.J9(9)
S2_LPC_CH91: P2.J11(11)
S2_LPC_CH92: P2.K2(2)
S2_LPC_CH93: P2.K4(4)
S2_LPC_CH94: P2.K6(6)
S2_LPC_CH95: P2.K8(8)
S2_LPC_CH96: P8.H5(5)
S2_LPC_CH97: P8.H7(7)
S2_LPC_CH98: P8.H9(9)
S2_LPC_CH99: P8.H11(11)
S2_LPC_CH100: P8.G2(2)
S2_LPC_CH101: P8.G4(4)
S2_LPC_CH102: P8.G6(6)
S2_LPC_CH103: P8.G8(8)
S2_LPC_CH104: P8.G10(10)
S2_LPC_CH105: P8.G12(12)
S2_LPC_CH106: P8.F1(1)
S2_LPC_CH107: P8.F3(3)
S2_LPC_CH108: P8.F5(5)
S2_LPC_CH109: P8.F7(7)
S2_LPC_CH110: P8.F9(9)
S2_LPC_CH111: P8.F11(11)
S2_LPC_CH112: P8.E2(2)
S2_LPC_CH113: P8.E4(4)
S2_LPC_CH114: P8.E6(6)
S2_LPC_CH115: P8.E8(8)
S2_LPC_CH116: P8.E10(10)
S2_LPC_CH117: P8.E12(12)
S2_LPC_CH118: P8.D1(1)
S2_LPC_CH119: P8.D3(3)
S2_LPC_CH120: P8.D5(5)
S2_LPC_CH121: P8.D7(7)
S2_LPC_CH122: P8.D9(9)
S2_LPC_CH123: P8.D11(11)
S2_LPC_CH124: P8.C2(2)
S2_LPC_CH125: P8.C4(4)
S2_LPC_CH126: P8.C6(6)
S2_LPC_CH127: P8.C8(8)
S2_LPC_DGS00: P8.C12(12)
S2_LPC_DGS64: P2.K12(12)
S2_LPC_UB0: P8.A4(4)
S2_LPC_UB1: P8.B5(5)
S2_LPC_UB2: P8.A6(6)
S2_LPC_UB3: P8.B7(7)
S2_LPC_UB4: P8.A8(8)
S2_LPC_UB5: P8.B9(9)
S2_LPC_UB6: P8.A10(10)
S2_LPC_UB7: P8.B11(11)
S2_LPC_UB8: P8.A12(12)
S2_LPC_UB9: P2.L5(5)
S2_LPC_UB10: P2.M6(6)
S2_LPC_UB11: P2.L7(7)
S2_LPC_UB12: P2.M8(8)
S2_LPC_UB13: P2.L9(9)
S2_LPC_UB14: P2.M10(10)
S2_LPC_UB15: P2.L11(11)
S2_LX_AUD: SITE2.100(LX_AUD) UNK2K20.3
S2_LX_AUD_CH_1: UNK2K20.4 UNK2K38.2
S2_LX_AUD_CH_2: UNK2K38.4 UNK2ST14.2
S2_LX_DCORE: SITE2.3(LX_DCORE) UNK2K21.3
S2_LX_DCORE_CH: UNK2K21.4 UNK2K37.2
S2_LX_MEM: SITE2.75(LX_MEM) UNK2K29.3
S2_LX_MEM_CH_1: UNK2K29.4 UNK2K33.2
S2_LX_MEM_CH_2: UNK2K33.4 UNK2ST15.2
S2_MIPITX_CKN: SITE2.82(MIPITX_CKN) UNK2K36.6
S2_MIPITX_CKP: SITE2.83(MIPITX_CKP) UNK2K36.3
S2_MIPITX_DATAN_0: SITE2.85(MIPITX_DATAN_0) UNK2K34.6
S2_MIPITX_DATAN_1: SITE2.80(MIPITX_DATAN_1) UNK2K35.6
S2_MIPITX_DATAP_0: SITE2.86(MIPITX_DATAP_0) UNK2K34.3
S2_MIPITX_DATAP_1: SITE2.81(MIPITX_DATAP_1) UNK2K35.3
S2_PA2: SITE2.5(GPIOA_2/PA[2]/TOUCH2/ADC2/UART0) UNK2K18.3
S2_PA3: SITE2.6(GPIOA_3/PA[3]/TOUCH3/ADC3/UART0) UNK2K18.6
S2_PA9_CH: SITE2.12(GPIOB_0/PA[9]) UNK2K39.2
S2_PA10_CH: SITE2.13(GPIOB_1/PA[10]) UNK2K39.7
S2_PA13: SITE2.15(GPIOB_4/PA[13]/SWD_DATA/SPI0_MO) UNK2K6.3
S2_PA13_UART_RX: UNK2K6.2 UNK2R27.1
S2_PA13_UART_RX_1: UNK2J2.3 UNK2R27.2
S2_PA14: SITE2.16(GPIOB_5/PA[14]/SWD_CLK/SPI0_MIS) UNK2K6.6
S2_PA14_UART_TX: UNK2K6.7 UNK2R28.1
S2_PA14_UART_TX_1: UNK2J2.4 UNK2R28.2
S2_PA15_1: UNK2R40.2 UNK2SW5.6
S2_PA16_1: UNK2R41.2 UNK2SW5.7
S2_PA20: SITE2.45(MIC1_P/GPIOC_2/PA[20]) UNK2K15.6
S2_PA21: SITE2.46(MIC1_N/GPIOC_3/PA[21]) UNK2K15.3
S2_PA22: SITE2.43(MIC2_P/GPIOC_4/PA[22]) UNK2K11.6
S2_PA23: SITE2.44(MIC2_N/GPIOC_5/PA[23]) UNK2K11.3
S2_PA24: SITE2.41(MIC3_P/I2C_SDA/GPIOC_6/PA[24]) UNK2K12.6
S2_PA25: SITE2.42(MIC3_N/I2C_SCL/GPIOC_7/PA[25]) UNK2K12.3
S2_PA28: SITE2.39(MIC5_P/ANT_SEL_P/GPIOC_10/PA[28) UNK2K13.6
S2_PA29: SITE2.40(MIC5_N/ANT_SEL_N/GPIOC_11/PA[29) UNK2K13.3
S2_PB3: SITE2.52(AOUT_LP/GPIOC_17/PB[3]) UNK2K10.6
S2_PB3_AOUT_LP_2: UNK2K13.5 UNK2R70.2
S2_PB4: SITE2.51(AOUT_LN/GPIOC_18/PB[4]) UNK2K10.3
S2_PB4_AOUT_LN_2: UNK2K13.4 UNK2R67.2
S2_PB5: SITE2.54(AOUT_RP/GPIOC_19/PB[5]) UNK2K14.6
S2_PB5_AOUT_RP_2: UNK2K11.5 UNK2R66.2
S2_PB6: SITE2.55(AOUT_RN/GPIOC_20/PB[6]) UNK2K14.3
S2_PB6_AOUT_RN_2: UNK2K11.4 UNK2R63.2
S2_PB10_1: UNK2R37.2 UNK2SW5.4
S2_PB11_1: UNK2R39.2 UNK2SW5.5
S2_PB21_1: UNK2R36.2 UNK2SW5.3
S2_PB22_1: UNK2R35.2 UNK2SW5.2
S2_PB23: SITE2.72(UART_LOG_RXD/OTP_BYPASS/GPIOF_2) UNK2C144.2 UNK2K4.3 UNK2R57.1
S2_PB23_1: UNK2R57.2 UNK2SW6.1
S2_PB23_SICK: UNK2K4.2 UNK2R20.1
S2_PB23_SICK_1: UNK2J1.3 UNK2R20.2
S2_PB24: SITE2.73(UART_LOG_TXD/UART_DOWNLOAD/GPIO) UNK2C143.2 UNK2K4.6 UNK2R58.1
S2_PB24_1: UNK2R58.2 UNK2SW6.2
S2_PB24_SIDD: UNK2K4.7 UNK2R21.1
S2_PB24_SIDD_1: UNK2J1.4 UNK2R21.2
S2_PB25: SITE2.96(SPI0_CLK/SWD_CLK/SD_D2/ICFG2/GP) UNK2K8.3 UNK2R59.1
S2_PB25_1: UNK2R59.2 UNK2SW6.3
S2_PB25_I2C_SCL: UNK2K8.2 UNK2R31.1
S2_PB25_I2C_SCL_1: UNK2J3.3 UNK2R31.2
S2_PB26: SITE2.97(SPI0_CS/SWD_DATA/SD_D3/ICFG3/GP) UNK2K8.6 UNK2R60.1
S2_PB26_1: UNK2R60.2 UNK2SW6.4
S2_PB26_I2C_SDA: UNK2K8.7 UNK2R32.1
S2_PB26_I2C_SDA_1: UNK2J3.4 UNK2R32.2
S2_PMU0_F: P2.L1(1)
S2_PMU0_G: P2.L3(3)
S2_PMU0_S: P2.M2(2)
S2_PMU1_F: P8.B1(1)
S2_PMU1_G: P8.B3(3)
S2_PMU1_S: P8.A2(2)
S2_RF_A: UNK2C13.1 UNK2C14.1 UNK2C15.1 UNK2D3.1 UNK2SMP3.1
S2_RF_G: UNK2C6.1 UNK2C7.1 UNK2C8.1 UNK2D2.1 UNK2SMP2.1
S2_RFIN_A: SITE2.29(RFIN_A/GND (<750UM)) UNK2C16.2 UNK2R9.1
S2_RFIN_G: SITE2.31(RFIN_G/GND) UNK2C9.2 UNK2R5.1
S2_RFIO_A: SITE2.28(RFIO_A  (<750UM)) UNK2C11.2 UNK2R6.1
S2_RFIO_BT: SITE2.37(RFIO_BT) UNK2C1.2 UNK2R1.1
S2_RFIO_G: SITE2.32(RFIO_G) UNK2C4.2 UNK2R2.1
S2_RREF_MEM: SITE2.60(RREF_MEM) UNK2K9.3 UNK2R43.1
S2_SPI_CLK: UNK2K1.7 UNK2R15.2
S2_SPI_CLK/PB28: SITE2.90(SPI_FLASH_CLK/SD_CLK/GPIOG_3/PB) UNK2K1.6
S2_SPI_CS: UNK2K3.2 UNK2R10.1
S2_SPI_CS/PC0: SITE2.95(SPI_FLASH_CS/UART1_CTS/SD_CD/GP) UNK2K3.3
S2_SPI_D0/PB29: SITE2.91(SPI_FLASH_DATA0/UART1_RXD/SD_D0) UNK2K1.3
S2_SPI_D1/PB31: SITE2.94(SPI_FLASH_DATA1/UART1_RTS/SD_WP) UNK2K3.6
S2_SPI_D2/PB30: SITE2.92(SPI_FLASH_DATA2/UART1_TXD/SD_D1) UNK2K2.6
S2_SPI_D3/PB27: SITE2.89(SPI_FLASH_DATA3/SD_CMD/GPIOG_2/) UNK2K2.3
S2_SPI_DATA0: UNK2K1.2 UNK2R17.2
S2_SPI_DATA1: UNK2K3.7 UNK2R11.1
S2_SPI_DATA2: UNK2K2.7 UNK2R16.1
S2_SPI_DATA3: UNK2K2.2 UNK2R13.2
S2_U1_VC1: UNK2K39.5 UNK2U1.4
S2_U2_VC1: UNK2K39.4 UNK2U2.4
S2_VA09_MIPI: SITE2.84(VA09_MIPI/VA09_CK/VA09_DA) UNK2BD37.2 UNK2C152.1
S2_VA09_PLL: SITE2.11(VA09_PLL/VD09_CORE0) UNK2BD1.2 UNK2C44.1
S2_VA09_USB: SITE2.77(VA09_USB) UNK2BD2.2 UNK2C45.1
S2_VA13_AFE: SITE2.19(VA13_AFE) UNK2BD20.2 UNK2C88.1
S2_VA13_SYN: SITE2.23(VR13_SYN) UNK2BD16.2 UNK2C78.1
S2_VA33_SYN: SITE2.24(VR33_SYN) UNK2BD13.2 UNK2C64.1
S2_VA33_XTAL: SITE2.20(VA33_XTAL) UNK2BD5.2 UNK2C48.1
S2_VD09_CORE1: SITE2.56(VD09_CORE1/VD09MEM0) UNK2C47.1 UNK2R76.2
S2_VD09_CORE2: SITE2.64(VD09_CORE2/VD09_MEM1) UNK2C49.1 UNK2R77.2
S2_VD09_CORE3: SITE2.87(VD09_CORE3/VA09_PLL) UNK2C54.1 UNK2R78.2
S2_VD09_CORE4: SITE2.98(VD09_CORE4) UNK2C58.1 UNK2R79.2
S2_VD13_FE: SITE2.36(VD13_FE) UNK2BD19.2 UNK2C85.1
S2_VD13_RF: SITE2.25(VD13_RF) UNK2BD17.2 UNK2C79.1
S2_VD33_ALL: UNK2BD3.1 UNK2BD5.1 UNK2BD7.1 UNK2BD9.1 UNK2BD11.1 UNK2BD12.1 UNK2BD13.1 UNK2BD15.1 UNK2BD18.1 UNK2BD21.1 UNK2BD22.1 UNK2BD23.1 UNK2BD28.1 UNK2BD29.1 UNK2BD30.1 UNK2BD31.1 UNK2BD32.1 UNK2BD36.1 UNK2C67.1 UNK2C96.1 UNK2C101.1 UNK2C122.1 UNK2C129.1 UNK2J5.1 UNK2J6.1 UNK2K23.2 UNK2K23.7
S2_VD33_CM_BT: SITE2.35(VD33_CM_BT) UNK2BD21.2 UNK2C90.1 UNK2C91.1
S2_VD33_EX_FLASH: UNK2BD32.2 UNK2C22.1 UNK2C127.1 UNK2C128.1 UNK2R12.2 UNK2R14.1 UNK2U3.8
S2_VD33_IO0: SITE2.9(VA33_PLL/VD33_IO0) UNK2BD7.2 UNK2C52.1
S2_VD33_IO2: SITE2.59(VD33_IO2/VD33_MEM) UNK2BD9.2 UNK2C56.1
S2_VD33_IO3: SITE2.70(VD33_IO3/VDD_IO4/VA33_USB) UNK2BD11.2 UNK2C59.1
S2_VD33_IO6: SITE2.88(VD33_IO6/VDD33_IO5/VD33_FLASH) UNK2BD12.2 UNK2C61.1
S2_VD33_SPS_AUD: SITE2.1(VD33_SPS_AUD) UNK2BD30.2 UNK2C123.1 UNK2C124.1
S2_VD33_SPS_DCORE: SITE2.2(VD33_SPS_DCORE) UNK2BD28.2 UNK2C111.1 UNK2C112.1
S2_VD33_SPS_MEM: SITE2.76(VD33_SPS_MEM) UNK2BD31.2 UNK2C125.1 UNK2C126.1
S2_VD33PA_A: SITE2.27(VD33PA_A) UNK2BD23.2 UNK2C99.1 UNK2C100.1
S2_VD33PA_BT: SITE2.38(VD33PA_BT) UNK2BD18.2 UNK2C83.1 UNK2C84.1
S2_VD33PA_G: SITE2.33(VD33PA_G) UNK2BD15.2 UNK2C76.1 UNK2C77.1
S2_VD33PAD_A: SITE2.26(VD33PAD_A) UNK2BD22.2 UNK2C97.1 UNK2C98.1
S2_VD33PAD_G: SITE2.34(VD33PAD_G) UNK2BD36.2 UNK2C73.1 UNK2C74.1
S2_VD1833_IO1: SITE2.14(VD1833_IO1) UNK2BD3.2 UNK2C46.1
S2_VD1833_SDIO: SITE2.93(VD1833_SDIO) UNK2BD29.2 UNK2C118.1 UNK2C119.1
S2_VD_MEM0: SITE2.61(VD_MEM0) UNK2C102.1 UNK2R81.2
S2_VD_MEM1: SITE2.62(VD_MEM1) UNK2C105.1 UNK2R82.2
S2_VD_MEM2: SITE2.65(VD_MEM2) UNK2C107.1 UNK2R83.2
S2_VDD09: S2_VDD09.1(TP) UNK2K22.2 UNK2K22.5 UNK2K31.4 UNK2R48.1
S2_VDD09_CH: UNK2K37.4 UNK2ST13.1
S2_VDD18_A: S2_VDD18_A.1(TP) UNK2K25.2 UNK2K25.5 UNK2K26.3 UNK2K32.4 UNK2R55.1
S2_VDD18_D: S2_VDD18_D.1(TP) UNK2K28.2 UNK2K28.5 UNK2K30.4 UNK2R29.2 UNK2R53.1
S2_VDD33: UNK2BD33.2 UNK2C130.1 UNK2R19.1 UNK2R24.1 UNK2R30.1 UNK2R38.2 UNK2R61.2 UNK2U1.6 UNK2U2.6
S2_VDD33_J1: UNK2J1.1 UNK2R19.2
S2_VDD33_J2: UNK2J2.1 UNK2R24.2
S2_VDD33_J3: UNK2J3.1 UNK2R30.2
S2_VREF_DRAM: SITE2.63(VREF_DRAM/NC(PSRAM)) UNK2C153.1 UNK2K16.3
S2_XI: SITE2.22(XI) UNK2C25.2 UNK2Y1.1
S2_XO: SITE2.21(XO) UNK2C23.2 UNK2Y1.3
S3_1_AOUT_LN: UNK3K10.4 UNK3R45.1 UNK3R67.1 UNK3R68.1
S3_1_AOUT_LP: UNK3K10.5 UNK3R69.1 UNK3R70.1 UNK3R75.1
S3_1_AOUT_RN: UNK3K14.4 UNK3R47.1 UNK3R63.1 UNK3R64.1
S3_1_AOUT_RP: UNK3K14.5 UNK3R65.1 UNK3R66.1 UNK3R74.1
S3_1_SPI_CLK: UNK3R15.1 UNK3U3.6
S3_1_SPI_CS: UNK3R10.2 UNK3U3.1
S3_1_SPI_DATA0: UNK3R17.1 UNK3U3.5
S3_1_SPI_DATA1: UNK3R11.2 UNK3U3.2
S3_1_SPI_DATA2: UNK3R14.2 UNK3R16.2 UNK3R18.2 UNK3U3.3
S3_1_SPI_DATA3: UNK3R12.1 UNK3R13.1 UNK3U3.7
S3_1_VDD09: UNK3BD1.1 UNK3BD2.1 UNK3BD37.1 UNK3C60.1 UNK3R48.2 UNK3R76.1 UNK3R77.1 UNK3R78.1 UNK3R79.1 UNK3ST13.2
S3_1_VDD18_A: S3_1V3.1(TP) UNK3K26.2 UNK3K26.5 UNK3R50.1
S3_1_VDD18_D: UNK3C113.2 UNK3R53.2 UNK3R81.1 UNK3R82.1 UNK3R83.1 UNK3ST15.1
S3_2_AOUT_LN: UNK3K12.4 UNK3R68.2
S3_2_AOUT_LP: UNK3K12.5 UNK3R69.2
S3_2_AOUT_RN: UNK3K15.4 UNK3R64.2
S3_2_AOUT_RP: UNK3K15.5 UNK3R65.2
S3_2_VDD18_A: UNK3BD16.1 UNK3BD17.1 UNK3BD19.1 UNK3BD20.1 UNK3C89.1 UNK3R50.2
S3_ATX_VD0V9: ATX_VD0V9.8 UNK3C65.1 UNK3C66.1 UNK3K21.6 UNK3ST3.2
S3_ATX_VD1V8: ATX_VD1V8.8 UNK3J7.1 UNK3J8.1 UNK3J9.1
S3_ATX_VD33: ATX_VD33.8 UNK3BD33.1 UNK3C131.1 UNK3C132.1 UNK3C133.1 UNK3C134.1 UNK3C135.1 UNK3J6.2
S3_AVCC_DRV: SITE3.53(AVCC_DRV) UNK3C75.1 UNK3C110.1 UNK3R55.2 UNK3ST14.1
S3_CHIP_EN_1: UNK3R34.2 UNK3SW5.1
S3_DPS_F001: UNK3C120.1 UNK3C121.1 UNK3J9.2 UNK3K29.6 UNK3ST11.2
S3_DPS_F002: UNK3C92.1 UNK3C93.1 UNK3C94.1 UNK3C95.1 UNK3J8.2 UNK3K26.6 UNK3ST8.2
S3_DPS_F004: UNK3C140.1 UNK3C141.1 UNK3J7.2 UNK3K20.6 UNK3ST12.2
S3_DPS_F006: S3_VD33_ALL1.1(TP) UNK3C68.1 UNK3C69.1 UNK3C70.1 UNK3C71.1 UNK3C72.1 UNK3K23.3 UNK3K23.6 UNK3ST4.2
S3_DPS_GS001: UNK3ST19.1
S3_DPS_GS002: UNK3ST18.1
S3_DPS_GS003-1: UNK3ST16.1
S3_DPS_GS004: UNK3ST17.1
S3_DPS_GS006: UNK3ST5.1
S3_DPS_S001: UNK3ST11.1
S3_DPS_S002: UNK3ST8.1
S3_DPS_S003-1: UNK3ST3.1
S3_DPS_S004: UNK3ST12.1
S3_DPS_S006: UNK3ST4.1
S3_HSDM: SITE3.79(HSDM) UNK3K5.8
S3_HSDP: SITE3.78(HSDP) UNK3K5.2
S3_LPC_001: UNK3K36.7
S3_LPC_002: UNK3K36.2
S3_LPC_003: UNK3K11.2
S3_LPC_005: UNK3K14.2
S3_LPC_006: UNK3K18.4
S3_LPC_007: UNK3K1.4
S3_LPC_008: UNK3K35.2
S3_LPC_009: UNK2K38.6
S3_LPC_010: UNK3K34.7
S3_LPC_012: UNK2K37.6
S3_LPC_013+: UNK3K5.3 UNK3K7.2
S3_LPC_013-: UNK3K5.7 UNK3K7.8
S3_LPC_016: UNK3K2.5
S3_LPC_017: UNK3K35.7
S3_LPC_019: UNK3K12.2
S3_LPC_021: UNK3K1.5
S3_LPC_022: UNK3K15.2
S3_LPC_023: UNK3K3.4
S3_LPC_024: SITE3.69(UART2_TXD/TEST_MODE_SEL/DMIC0_C) UNK3J4.2 UNK3R35.1
S3_LPC_025: SITE3.71(CHIP_EN) UNK3J4.1 UNK3R34.1
S3_LPC_026: UNK3K2.4
S3_LPC_027: UNK3K10.2
S3_LPC_028: UNK3K10.7
S3_LPC_029: UNK3K13.7
S3_LPC_030: UNK3K16.2
S3_LPC_032: UNK3K15.7
S3_LPC_033: UNK3K14.7
S3_LPC_034: UNK3K18.5
S3_LPC_035: UNK3K12.7
S3_LPC_036: UNK3K34.2
S3_LPC_038: UNK3K13.2
S3_LPC_039: UNK3K3.5
S3_LPC_040: UNK3K11.7
S3_LPC_041: SITE3.68(UART2_RXD/BOOT_SEL/DMIC0_DATA/G) UNK3J4.3 UNK3R36.1
S3_LPC_042: SITE3.50(MIC_BIAS2/GPIOC_13/PA[31]) UNK3C18.2
S3_LPC_043: UNK2K33.6
S3_LPC_044: SITE3.58(I2S3_DOUT1/DMIC_DATA2/ICFG1/GPI) UNK3J4.5 UNK3R39.1
S3_LPC_045: UNK3K39.3
S3_LPC_046: SITE3.67(I2S2_DIN3/I2S3_DOUT3/SPK_CLK/SP)
S3_LPC_047: SITE3.18(GPIOB_7/PA[16]/ICFG3/SPI0_CS/UA) UNK3J4.7 UNK3R41.1
S3_LPC_048: UNK3K6.4
S3_LPC_049: SITE3.8(GPIOA_5/PA[5]/TOUCH5/ADC5/UART1)
S3_LPC_050: SITE3.7(GPIOA_4/PA[4]/TOUCH4/ADC4/UART1)
S3_LPC_051: SITE3.49(MIC_BIAS1/GPIOC_12/PA[30]) UNK3C17.2
S3_LPC_052: SITE3.48(AVCC) UNK3C21.1
S3_LPC_053: SITE3.57(I2S3_DOUT0/DMIC_DATA1/ICFG0/BT_) UNK3J4.4 UNK3R37.1
S3_LPC_054: UNK3K6.5
S3_LPC_055: SITE3.10(VBAT_MEAS)
S3_LPC_057: UNK3K9.4
S3_LPC_058: SITE3.17(GPIOB_6/PA[15]/ICFG2/SPI0_CLK/U) UNK3J4.6 UNK3R40.1
S3_LPC_059: UNK3K39.6
S3_LPC_060: SITE3.66(I2S2_DIN2/I2S3_DOUT2/SPK_DATA/S)
S3_LPC_A_015: UNK3K8.4
S3_LPC_A_020: UNK3K8.5
S3_LPC_B_031: UNK3K4.4
S3_LPC_B_037: UNK3K4.5
S3_LPC_CH00: P5.N2(2)
S3_LPC_CH01: P5.N4(4)
S3_LPC_CH02: P5.N6(6)
S3_LPC_CH03: P5.N8(8)
S3_LPC_CH04: P5.N10(10)
S3_LPC_CH05: P5.N12(12)
S3_LPC_CH06: P5.O1(1)
S3_LPC_CH07: P5.O3(3)
S3_LPC_CH08: P5.O5(5)
S3_LPC_CH09: P5.O7(7)
S3_LPC_CH10: P5.O9(9)
S3_LPC_CH11: P5.O11(11)
S3_LPC_CH12: P5.P2(2)
S3_LPC_CH13: P5.P4(4)
S3_LPC_CH14: P5.P6(6)
S3_LPC_CH15: P5.P8(8)
S3_LPC_CH16: P5.P10(10)
S3_LPC_CH17: P5.P12(12)
S3_LPC_CH18: P5.Q1(1)
S3_LPC_CH19: P5.Q3(3)
S3_LPC_CH20: P5.Q5(5)
S3_LPC_CH21: P5.Q7(7)
S3_LPC_CH22: P5.Q9(9)
S3_LPC_CH23: P5.Q11(11)
S3_LPC_CH24: P5.R2(2)
S3_LPC_CH25: P5.R4(4)
S3_LPC_CH26: P5.R6(6)
S3_LPC_CH27: P5.R8(8)
S3_LPC_CH28: P5.R10(10)
S3_LPC_CH29: P5.R12(12)
S3_LPC_CH30: P5.S1(1)
S3_LPC_CH31: P5.S3(3)
S3_LPC_CH32: P10.Z2(2)
S3_LPC_CH33: P10.Z4(4)
S3_LPC_CH34: P10.Z6(6)
S3_LPC_CH35: P10.Z8(8)
S3_LPC_CH36: P10.Z10(10)
S3_LPC_CH37: P10.Z12(12)
S3_LPC_CH38: P10.Y1(1)
S3_LPC_CH39: P10.Y3(3)
S3_LPC_CH40: P10.Y5(5)
S3_LPC_CH41: P10.Y7(7)
S3_LPC_CH42: P10.Y9(9)
S3_LPC_CH43: P10.Y11(11)
S3_LPC_CH44: P10.X2(2)
S3_LPC_CH45: P10.X4(4)
S3_LPC_CH46: P10.X6(6)
S3_LPC_CH47: P10.X8(8)
S3_LPC_CH48: P10.X10(10)
S3_LPC_CH49: P10.X12(12)
S3_LPC_CH50: P10.W1(1)
S3_LPC_CH51: P10.W3(3)
S3_LPC_CH52: P10.W5(5)
S3_LPC_CH53: P10.W7(7)
S3_LPC_CH54: P10.W9(9)
S3_LPC_CH55: P10.W11(11)
S3_LPC_CH56: P10.V2(2)
S3_LPC_CH57: P10.V4(4)
S3_LPC_CH58: P10.V6(6)
S3_LPC_CH59: P10.V8(8)
S3_LPC_CH60: P10.V10(10)
S3_LPC_CH61: P10.V12(12)
S3_LPC_CH62: P10.U1(1)
S3_LPC_CH63: P10.U3(3)
S3_LPC_CH64: P5.S5(5)
S3_LPC_CH65: P5.S7(7)
S3_LPC_CH66: P5.S9(9)
S3_LPC_CH67: P5.S11(11)
S3_LPC_CH68: P5.T2(2)
S3_LPC_CH69: P5.T4(4)
S3_LPC_CH70: P5.T6(6)
S3_LPC_CH71: P5.T8(8)
S3_LPC_CH72: P5.T10(10)
S3_LPC_CH73: P5.T12(12)
S3_LPC_CH74: P5.U1(1)
S3_LPC_CH75: P5.U3(3)
S3_LPC_CH76: P5.U5(5)
S3_LPC_CH77: P5.U7(7)
S3_LPC_CH78: P5.U9(9)
S3_LPC_CH79: P5.U11(11)
S3_LPC_CH80: P5.V2(2)
S3_LPC_CH81: P5.V4(4)
S3_LPC_CH82: P5.V6(6)
S3_LPC_CH83: P5.V8(8)
S3_LPC_CH84: P5.V10(10)
S3_LPC_CH85: P5.V12(12)
S3_LPC_CH86: P5.W1(1)
S3_LPC_CH87: P5.W3(3)
S3_LPC_CH88: P5.W5(5)
S3_LPC_CH89: P5.W7(7)
S3_LPC_CH90: P5.W9(9)
S3_LPC_CH91: P5.W11(11)
S3_LPC_CH92: P5.X2(2)
S3_LPC_CH93: P5.X4(4)
S3_LPC_CH94: P5.X6(6)
S3_LPC_CH95: P5.X8(8)
S3_LPC_CH96: P10.U5(5)
S3_LPC_CH97: P10.U7(7)
S3_LPC_CH98: P10.U9(9)
S3_LPC_CH99: P10.U11(11)
S3_LPC_CH100: P10.T2(2)
S3_LPC_CH101: P10.T4(4)
S3_LPC_CH102: P10.T6(6)
S3_LPC_CH103: P10.T8(8)
S3_LPC_CH104: P10.T10(10)
S3_LPC_CH105: P10.T12(12)
S3_LPC_CH106: P10.S1(1)
S3_LPC_CH107: P10.S3(3)
S3_LPC_CH108: P10.S5(5)
S3_LPC_CH109: P10.S7(7)
S3_LPC_CH110: P10.S9(9)
S3_LPC_CH111: P10.S11(11)
S3_LPC_CH112: P10.R2(2)
S3_LPC_CH113: P10.R4(4)
S3_LPC_CH114: P10.R6(6)
S3_LPC_CH115: P10.R8(8)
S3_LPC_CH116: P10.R10(10)
S3_LPC_CH117: P10.R12(12)
S3_LPC_CH118: P10.Q1(1)
S3_LPC_CH119: P10.Q3(3)
S3_LPC_CH120: P10.Q5(5)
S3_LPC_CH121: P10.Q7(7)
S3_LPC_CH122: P10.Q9(9)
S3_LPC_CH123: P10.Q11(11)
S3_LPC_CH124: P10.P2(2)
S3_LPC_CH125: P10.P4(4)
S3_LPC_CH126: P10.P6(6)
S3_LPC_CH127: P10.P8(8)
S3_LPC_DGS00: P10.P12(12)
S3_LPC_DGS64: P5.X12(12)
S3_LPC_UB0: P10.N4(4)
S3_LPC_UB1: P10.O5(5)
S3_LPC_UB2: P10.N6(6)
S3_LPC_UB3: P10.O7(7)
S3_LPC_UB4: P10.N8(8)
S3_LPC_UB5: P10.O9(9)
S3_LPC_UB6: P10.N10(10)
S3_LPC_UB7: P10.O11(11)
S3_LPC_UB8: P10.N12(12)
S3_LPC_UB9: P5.Y5(5)
S3_LPC_UB10: P5.Z6(6)
S3_LPC_UB11: P5.Y7(7)
S3_LPC_UB12: P5.Z8(8)
S3_LPC_UB13: P5.Y9(9)
S3_LPC_UB14: P5.Z10(10)
S3_LPC_UB15: P5.Y11(11)
S3_LX_AUD: SITE3.100(LX_AUD) UNK3K20.3
S3_LX_AUD_CH_1: UNK2K38.7 UNK3K20.4
S3_LX_AUD_CH_2: UNK2K38.5 UNK3ST14.2
S3_LX_DCORE: SITE3.3(LX_DCORE) UNK3K21.3
S3_LX_DCORE_CH: UNK2K37.7 UNK3K21.4
S3_LX_MEM: SITE3.75(LX_MEM) UNK3K29.3
S3_LX_MEM_CH_1: UNK2K33.7 UNK3K29.4
S3_LX_MEM_CH_2: UNK2K33.5 UNK3ST15.2
S3_MIPITX_CKN: SITE3.82(MIPITX_CKN) UNK3K36.6
S3_MIPITX_CKP: SITE3.83(MIPITX_CKP) UNK3K36.3
S3_MIPITX_DATAN_0: SITE3.85(MIPITX_DATAN_0) UNK3K34.6
S3_MIPITX_DATAN_1: SITE3.80(MIPITX_DATAN_1) UNK3K35.6
S3_MIPITX_DATAP_0: SITE3.86(MIPITX_DATAP_0) UNK3K34.3
S3_MIPITX_DATAP_1: SITE3.81(MIPITX_DATAP_1) UNK3K35.3
S3_PA2: SITE3.5(GPIOA_2/PA[2]/TOUCH2/ADC2/UART0) UNK3K18.3
S3_PA3: SITE3.6(GPIOA_3/PA[3]/TOUCH3/ADC3/UART0) UNK3K18.6
S3_PA9_CH: SITE3.12(GPIOB_0/PA[9]) UNK3K39.2
S3_PA10_CH: SITE3.13(GPIOB_1/PA[10]) UNK3K39.7
S3_PA13: SITE3.15(GPIOB_4/PA[13]/SWD_DATA/SPI0_MO) UNK3K6.3
S3_PA13_UART_RX: UNK3K6.2 UNK3R27.1
S3_PA13_UART_RX_1: UNK3J2.3 UNK3R27.2
S3_PA14: SITE3.16(GPIOB_5/PA[14]/SWD_CLK/SPI0_MIS) UNK3K6.6
S3_PA14_UART_TX: UNK3K6.7 UNK3R28.1
S3_PA14_UART_TX_1: UNK3J2.4 UNK3R28.2
S3_PA15_1: UNK3R40.2 UNK3SW5.6
S3_PA16_1: UNK3R41.2 UNK3SW5.7
S3_PA20: SITE3.45(MIC1_P/GPIOC_2/PA[20]) UNK3K15.6
S3_PA21: SITE3.46(MIC1_N/GPIOC_3/PA[21]) UNK3K15.3
S3_PA22: SITE3.43(MIC2_P/GPIOC_4/PA[22]) UNK3K11.6
S3_PA23: SITE3.44(MIC2_N/GPIOC_5/PA[23]) UNK3K11.3
S3_PA24: SITE3.41(MIC3_P/I2C_SDA/GPIOC_6/PA[24]) UNK3K12.6
S3_PA25: SITE3.42(MIC3_N/I2C_SCL/GPIOC_7/PA[25]) UNK3K12.3
S3_PA28: SITE3.39(MIC5_P/ANT_SEL_P/GPIOC_10/PA[28) UNK3K13.6
S3_PA29: SITE3.40(MIC5_N/ANT_SEL_N/GPIOC_11/PA[29) UNK3K13.3
S3_PB3: SITE3.52(AOUT_LP/GPIOC_17/PB[3]) UNK3K10.6
S3_PB3_AOUT_LP_2: UNK3K13.5 UNK3R70.2
S3_PB4: SITE3.51(AOUT_LN/GPIOC_18/PB[4]) UNK3K10.3
S3_PB4_AOUT_LN_2: UNK3K13.4 UNK3R67.2
S3_PB5: SITE3.54(AOUT_RP/GPIOC_19/PB[5]) UNK3K14.6
S3_PB5_AOUT_RP_2: UNK3K11.5 UNK3R66.2
S3_PB6: SITE3.55(AOUT_RN/GPIOC_20/PB[6]) UNK3K14.3
S3_PB6_AOUT_RN_2: UNK3K11.4 UNK3R63.2
S3_PB10_1: UNK3R37.2 UNK3SW5.4
S3_PB11_1: UNK3R39.2 UNK3SW5.5
S3_PB21_1: UNK3R36.2 UNK3SW5.3
S3_PB22_1: UNK3R35.2 UNK3SW5.2
S3_PB23: SITE3.72(UART_LOG_RXD/OTP_BYPASS/GPIOF_2) UNK3C144.2 UNK3K4.3 UNK3R57.1
S3_PB23_1: UNK3R57.2 UNK3SW6.1
S3_PB23_SICK: UNK3K4.2 UNK3R20.1
S3_PB23_SICK_1: UNK3J1.3 UNK3R20.2
S3_PB24: SITE3.73(UART_LOG_TXD/UART_DOWNLOAD/GPIO) UNK3C143.2 UNK3K4.6 UNK3R58.1
S3_PB24_1: UNK3R58.2 UNK3SW6.2
S3_PB24_SIDD: UNK3K4.7 UNK3R21.1
S3_PB24_SIDD_1: UNK3J1.4 UNK3R21.2
S3_PB25: SITE3.96(SPI0_CLK/SWD_CLK/SD_D2/ICFG2/GP) UNK3K8.3 UNK3R59.1
S3_PB25_1: UNK3R59.2 UNK3SW6.3
S3_PB25_I2C_SCL: UNK3K8.2 UNK3R31.1
S3_PB25_I2C_SCL_1: UNK3J3.3 UNK3R31.2
S3_PB26: SITE3.97(SPI0_CS/SWD_DATA/SD_D3/ICFG3/GP) UNK3K8.6 UNK3R60.1
S3_PB26_1: UNK3R60.2 UNK3SW6.4
S3_PB26_I2C_SDA: UNK3K8.7 UNK3R32.1
S3_PB26_I2C_SDA_1: UNK3J3.4 UNK3R32.2
S3_PMU0_F: P5.Y1(1)
S3_PMU0_G: P5.Y3(3)
S3_PMU0_S: P5.Z2(2)
S3_PMU1_F: P10.O1(1)
S3_PMU1_G: P10.O3(3)
S3_PMU1_S: P10.N2(2)
S3_RF_A: UNK3C13.1 UNK3C14.1 UNK3C15.1 UNK3D3.1 UNK3SMP3.1
S3_RF_G: UNK3C6.1 UNK3C7.1 UNK3C8.1 UNK3D2.1 UNK3SMP2.1
S3_RFIN_A: SITE3.29(RFIN_A/GND (<750UM)) UNK3C16.2 UNK3R9.1
S3_RFIN_G: SITE3.31(RFIN_G/GND) UNK3C9.2 UNK3R5.1
S3_RFIO_A: SITE3.28(RFIO_A  (<750UM)) UNK3C11.2 UNK3R6.1
S3_RFIO_BT: SITE3.37(RFIO_BT) UNK3C1.2 UNK3R1.1
S3_RFIO_G: SITE3.32(RFIO_G) UNK3C4.2 UNK3R2.1
S3_RREF_MEM: SITE3.60(RREF_MEM) UNK3K9.3 UNK3R43.1
S3_SPI_CLK: UNK3K1.7 UNK3R15.2
S3_SPI_CLK/PB28: SITE3.90(SPI_FLASH_CLK/SD_CLK/GPIOG_3/PB) UNK3K1.6
S3_SPI_CS: UNK3K3.2 UNK3R10.1
S3_SPI_CS/PC0: SITE3.95(SPI_FLASH_CS/UART1_CTS/SD_CD/GP) UNK3K3.3
S3_SPI_D0/PB29: SITE3.91(SPI_FLASH_DATA0/UART1_RXD/SD_D0) UNK3K1.3
S3_SPI_D1/PB31: SITE3.94(SPI_FLASH_DATA1/UART1_RTS/SD_WP) UNK3K3.6
S3_SPI_D2/PB30: SITE3.92(SPI_FLASH_DATA2/UART1_TXD/SD_D1) UNK3K2.6
S3_SPI_D3/PB27: SITE3.89(SPI_FLASH_DATA3/SD_CMD/GPIOG_2/) UNK3K2.3
S3_SPI_DATA0: UNK3K1.2 UNK3R17.2
S3_SPI_DATA1: UNK3K3.7 UNK3R11.1
S3_SPI_DATA2: UNK3K2.7 UNK3R16.1
S3_SPI_DATA3: UNK3K2.2 UNK3R13.2
S3_U1_VC1: UNK3K39.5 UNK3U1.4
S3_U2_VC1: UNK3K39.4 UNK3U2.4
S3_VA09_MIPI: SITE3.84(VA09_MIPI/VA09_CK/VA09_DA) UNK3BD37.2 UNK3C152.1
S3_VA09_PLL: SITE3.11(VA09_PLL/VD09_CORE0) UNK3BD1.2 UNK3C44.1
S3_VA09_USB: SITE3.77(VA09_USB) UNK3BD2.2 UNK3C45.1
S3_VA13_AFE: SITE3.19(VA13_AFE) UNK3BD20.2 UNK3C88.1
S3_VA13_SYN: SITE3.23(VR13_SYN) UNK3BD16.2 UNK3C78.1
S3_VA33_SYN: SITE3.24(VR33_SYN) UNK3BD13.2 UNK3C64.1
S3_VA33_XTAL: SITE3.20(VA33_XTAL) UNK3BD5.2 UNK3C48.1
S3_VD09_CORE1: SITE3.56(VD09_CORE1/VD09MEM0) UNK3C47.1 UNK3R76.2
S3_VD09_CORE2: SITE3.64(VD09_CORE2/VD09_MEM1) UNK3C49.1 UNK3R77.2
S3_VD09_CORE3: SITE3.87(VD09_CORE3/VA09_PLL) UNK3C54.1 UNK3R78.2
S3_VD09_CORE4: SITE3.98(VD09_CORE4) UNK3C58.1 UNK3R79.2
S3_VD13_FE: SITE3.36(VD13_FE) UNK3BD19.2 UNK3C85.1
S3_VD13_RF: SITE3.25(VD13_RF) UNK3BD17.2 UNK3C79.1
S3_VD33_ALL: UNK3BD3.1 UNK3BD5.1 UNK3BD7.1 UNK3BD9.1 UNK3BD11.1 UNK3BD12.1 UNK3BD13.1 UNK3BD15.1 UNK3BD18.1 UNK3BD21.1 UNK3BD22.1 UNK3BD23.1 UNK3BD28.1 UNK3BD29.1 UNK3BD30.1 UNK3BD31.1 UNK3BD32.1 UNK3BD36.1 UNK3C67.1 UNK3C96.1 UNK3C101.1 UNK3C122.1 UNK3C129.1 UNK3J5.1 UNK3J6.1 UNK3K23.2 UNK3K23.7
S3_VD33_CM_BT: SITE3.35(VD33_CM_BT) UNK3BD21.2 UNK3C90.1 UNK3C91.1
S3_VD33_EX_FLASH: UNK3BD32.2 UNK3C22.1 UNK3C127.1 UNK3C128.1 UNK3R12.2 UNK3R14.1 UNK3U3.8
S3_VD33_IO0: SITE3.9(VA33_PLL/VD33_IO0) UNK3BD7.2 UNK3C52.1
S3_VD33_IO2: SITE3.59(VD33_IO2/VD33_MEM) UNK3BD9.2 UNK3C56.1
S3_VD33_IO3: SITE3.70(VD33_IO3/VDD_IO4/VA33_USB) UNK3BD11.2 UNK3C59.1
S3_VD33_IO6: SITE3.88(VD33_IO6/VDD33_IO5/VD33_FLASH) UNK3BD12.2 UNK3C61.1
S3_VD33_SPS_AUD: SITE3.1(VD33_SPS_AUD) UNK3BD30.2 UNK3C123.1 UNK3C124.1
S3_VD33_SPS_DCORE: SITE3.2(VD33_SPS_DCORE) UNK3BD28.2 UNK3C111.1 UNK3C112.1
S3_VD33_SPS_MEM: SITE3.76(VD33_SPS_MEM) UNK3BD31.2 UNK3C125.1 UNK3C126.1
S3_VD33PA_A: SITE3.27(VD33PA_A) UNK3BD23.2 UNK3C99.1 UNK3C100.1
S3_VD33PA_BT: SITE3.38(VD33PA_BT) UNK3BD18.2 UNK3C83.1 UNK3C84.1
S3_VD33PA_G: SITE3.33(VD33PA_G) UNK3BD15.2 UNK3C76.1 UNK3C77.1
S3_VD33PAD_A: SITE3.26(VD33PAD_A) UNK3BD22.2 UNK3C97.1 UNK3C98.1
S3_VD33PAD_G: SITE3.34(VD33PAD_G) UNK3BD36.2 UNK3C73.1 UNK3C74.1
S3_VD1833_IO1: SITE3.14(VD1833_IO1) UNK3BD3.2 UNK3C46.1
S3_VD1833_SDIO: SITE3.93(VD1833_SDIO) UNK3BD29.2 UNK3C118.1 UNK3C119.1
S3_VD_MEM0: SITE3.61(VD_MEM0) UNK3C102.1 UNK3R81.2
S3_VD_MEM1: SITE3.62(VD_MEM1) UNK3C105.1 UNK3R82.2
S3_VD_MEM2: SITE3.65(VD_MEM2) UNK3C107.1 UNK3R83.2
S3_VDD09: S3_VDD09.1(TP) UNK3K22.2 UNK3K22.5 UNK3K31.4 UNK3R48.1
S3_VDD09_CH: UNK2K37.5 UNK3ST13.1
S3_VDD18_A: S3_VDD18_A.1(TP) UNK3K25.2 UNK3K25.5 UNK3K26.3 UNK3K32.4 UNK3R55.1
S3_VDD18_D: S3_VDD18_D.1(TP) UNK3K28.2 UNK3K28.5 UNK3K30.4 UNK3R29.2 UNK3R53.1
S3_VDD33: UNK3BD33.2 UNK3C130.1 UNK3R19.1 UNK3R24.1 UNK3R30.1 UNK3R38.2 UNK3R61.2 UNK3U1.6 UNK3U2.6
S3_VDD33_J1: UNK3J1.1 UNK3R19.2
S3_VDD33_J2: UNK3J2.1 UNK3R24.2
S3_VDD33_J3: UNK3J3.1 UNK3R30.2
S3_VREF_DRAM: SITE3.63(VREF_DRAM/NC(PSRAM)) UNK3C153.1 UNK3K16.3
S3_XI: SITE3.22(XI) UNK3C25.2 UNK3Y1.1
S3_XO: SITE3.21(XO) UNK3C23.2 UNK3Y1.3
S4_1_AOUT_LN: UNK4K10.4 UNK4R45.1 UNK4R67.1 UNK4R68.1
S4_1_AOUT_LP: UNK4K10.5 UNK4R69.1 UNK4R70.1 UNK4R75.1
S4_1_AOUT_RN: UNK4K14.4 UNK4R47.1 UNK4R63.1 UNK4R64.1
S4_1_AOUT_RP: UNK4K14.5 UNK4R65.1 UNK4R66.1 UNK4R74.1
S4_1_SPI_CLK: UNK4R15.1 UNK4U3.6
S4_1_SPI_CS: UNK4R10.2 UNK4U3.1
S4_1_SPI_DATA0: UNK4R17.1 UNK4U3.5
S4_1_SPI_DATA1: UNK4R11.2 UNK4U3.2
S4_1_SPI_DATA2: UNK4R14.2 UNK4R16.2 UNK4R18.2 UNK4U3.3
S4_1_SPI_DATA3: UNK4R12.1 UNK4R13.1 UNK4U3.7
S4_1_VDD09: UNK4BD1.1 UNK4BD2.1 UNK4BD37.1 UNK4C60.1 UNK4R48.2 UNK4R76.1 UNK4R77.1 UNK4R78.1 UNK4R79.1 UNK4ST13.2
S4_1_VDD18_A: S4_1V3.1(TP) UNK4K26.2 UNK4K26.5 UNK4R50.1
S4_1_VDD18_D: UNK4C113.2 UNK4R53.2 UNK4R81.1 UNK4R82.1 UNK4R83.1 UNK4ST15.1
S4_2_AOUT_LN: UNK4K12.4 UNK4R68.2
S4_2_AOUT_LP: UNK4K12.5 UNK4R69.2
S4_2_AOUT_RN: UNK4K15.4 UNK4R64.2
S4_2_AOUT_RP: UNK4K15.5 UNK4R65.2
S4_2_VDD18_A: UNK4BD16.1 UNK4BD17.1 UNK4BD19.1 UNK4BD20.1 UNK4C89.1 UNK4R50.2
S4_ATX_VD0V9: ATX_VD0V9.10 UNK4C65.1 UNK4C66.1 UNK4K21.6 UNK4ST3.2
S4_ATX_VD1V8: ATX_VD1V8.10 UNK4J7.1 UNK4J8.1 UNK4J9.1
S4_ATX_VD33: ATX_VD33.10 UNK4BD33.1 UNK4C131.1 UNK4C132.1 UNK4C133.1 UNK4C134.1 UNK4C135.1 UNK4J6.2
S4_AVCC_DRV: SITE4.53(AVCC_DRV) UNK4C75.1 UNK4C110.1 UNK4R55.2 UNK4ST14.1
S4_CHIP_EN_1: UNK4R34.2 UNK4SW5.1
S4_DPS_F001: UNK4C120.1 UNK4C121.1 UNK4J9.2 UNK4K29.6 UNK4ST11.2
S4_DPS_F002: UNK4C92.1 UNK4C93.1 UNK4C94.1 UNK4C95.1 UNK4J8.2 UNK4K26.6 UNK4ST8.2
S4_DPS_F004: UNK4C140.1 UNK4C141.1 UNK4J7.2 UNK4K20.6 UNK4ST12.2
S4_DPS_F006: S4_VD33_ALL1.1(TP) UNK4C68.1 UNK4C69.1 UNK4C70.1 UNK4C71.1 UNK4C72.1 UNK4K23.3 UNK4K23.6 UNK4ST4.2
S4_DPS_GS001: UNK4ST19.1
S4_DPS_GS002: UNK4ST18.1
S4_DPS_GS003-1: UNK4ST16.1
S4_DPS_GS004: UNK4ST17.1
S4_DPS_GS006: UNK4ST5.1
S4_DPS_S001: UNK4ST11.1
S4_DPS_S002: UNK4ST8.1
S4_DPS_S003-1: UNK4ST3.1
S4_DPS_S004: UNK4ST12.1
S4_DPS_S006: UNK4ST4.1
S4_HSDM: SITE4.79(HSDM) UNK4K5.8
S4_HSDP: SITE4.78(HSDP) UNK4K5.2
S4_LPC_001: UNK4K36.7
S4_LPC_002: UNK4K36.2
S4_LPC_003: UNK4K11.2
S4_LPC_005: UNK4K14.2
S4_LPC_006: UNK4K18.4
S4_LPC_007: UNK4K1.4
S4_LPC_008: UNK4K35.2
S4_LPC_009: UNK4K38.3
S4_LPC_010: UNK4K34.7
S4_LPC_012: UNK4K37.3
S4_LPC_013+: UNK4K5.3 UNK4K7.2
S4_LPC_013-: UNK4K5.7 UNK4K7.8
S4_LPC_016: UNK4K2.5
S4_LPC_017: UNK4K35.7
S4_LPC_019: UNK4K12.2
S4_LPC_021: UNK4K1.5
S4_LPC_022: UNK4K15.2
S4_LPC_023: UNK4K3.4
S4_LPC_024: SITE4.69(UART2_TXD/TEST_MODE_SEL/DMIC0_C) UNK4J4.2 UNK4R35.1
S4_LPC_025: SITE4.71(CHIP_EN) UNK4J4.1 UNK4R34.1
S4_LPC_026: UNK4K2.4
S4_LPC_027: UNK4K10.2
S4_LPC_028: UNK4K10.7
S4_LPC_029: UNK4K13.7
S4_LPC_030: UNK4K16.2
S4_LPC_032: UNK4K15.7
S4_LPC_033: UNK4K14.7
S4_LPC_034: UNK4K18.5
S4_LPC_035: UNK4K12.7
S4_LPC_036: UNK4K34.2
S4_LPC_038: UNK4K13.2
S4_LPC_039: UNK4K3.5
S4_LPC_040: UNK4K11.7
S4_LPC_041: SITE4.68(UART2_RXD/BOOT_SEL/DMIC0_DATA/G) UNK4J4.3 UNK4R36.1
S4_LPC_042: SITE4.50(MIC_BIAS2/GPIOC_13/PA[31]) UNK4C18.2
S4_LPC_043: UNK4K33.3
S4_LPC_044: SITE4.58(I2S3_DOUT1/DMIC_DATA2/ICFG1/GPI) UNK4J4.5 UNK4R39.1
S4_LPC_045: UNK4K39.3
S4_LPC_046: SITE4.67(I2S2_DIN3/I2S3_DOUT3/SPK_CLK/SP)
S4_LPC_047: SITE4.18(GPIOB_7/PA[16]/ICFG3/SPI0_CS/UA) UNK4J4.7 UNK4R41.1
S4_LPC_048: UNK4K6.4
S4_LPC_049: SITE4.8(GPIOA_5/PA[5]/TOUCH5/ADC5/UART1)
S4_LPC_050: SITE4.7(GPIOA_4/PA[4]/TOUCH4/ADC4/UART1)
S4_LPC_051: SITE4.49(MIC_BIAS1/GPIOC_12/PA[30]) UNK4C17.2
S4_LPC_052: SITE4.48(AVCC) UNK4C21.1
S4_LPC_053: SITE4.57(I2S3_DOUT0/DMIC_DATA1/ICFG0/BT_) UNK4J4.4 UNK4R37.1
S4_LPC_054: UNK4K6.5
S4_LPC_055: SITE4.10(VBAT_MEAS)
S4_LPC_057: UNK4K9.4
S4_LPC_058: SITE4.17(GPIOB_6/PA[15]/ICFG2/SPI0_CLK/U) UNK4J4.6 UNK4R40.1
S4_LPC_059: UNK4K39.6
S4_LPC_060: SITE4.66(I2S2_DIN2/I2S3_DOUT2/SPK_DATA/S)
S4_LPC_A_015: UNK4K8.4
S4_LPC_A_020: UNK4K8.5
S4_LPC_B_031: UNK4K4.4
S4_LPC_B_037: UNK4K4.5
S4_LX_AUD: SITE4.100(LX_AUD) UNK4K20.3
S4_LX_AUD_CH_1: UNK4K20.4 UNK4K38.2
S4_LX_AUD_CH_2: UNK4K38.4 UNK4ST14.2
S4_LX_DCORE: SITE4.3(LX_DCORE) UNK4K21.3
S4_LX_DCORE_CH: UNK4K21.4 UNK4K37.2
S4_LX_MEM: SITE4.75(LX_MEM) UNK4K29.3
S4_LX_MEM_CH_1: UNK4K29.4 UNK4K33.2
S4_LX_MEM_CH_2: UNK4K33.4 UNK4ST15.2
S4_MIPITX_CKN: SITE4.82(MIPITX_CKN) UNK4K36.6
S4_MIPITX_CKP: SITE4.83(MIPITX_CKP) UNK4K36.3
S4_MIPITX_DATAN_0: SITE4.85(MIPITX_DATAN_0) UNK4K34.6
S4_MIPITX_DATAN_1: SITE4.80(MIPITX_DATAN_1) UNK4K35.6
S4_MIPITX_DATAP_0: SITE4.86(MIPITX_DATAP_0) UNK4K34.3
S4_MIPITX_DATAP_1: SITE4.81(MIPITX_DATAP_1) UNK4K35.3
S4_PA2: SITE4.5(GPIOA_2/PA[2]/TOUCH2/ADC2/UART0) UNK4K18.3
S4_PA3: SITE4.6(GPIOA_3/PA[3]/TOUCH3/ADC3/UART0) UNK4K18.6
S4_PA9_CH: SITE4.12(GPIOB_0/PA[9]) UNK4K39.2
S4_PA10_CH: SITE4.13(GPIOB_1/PA[10]) UNK4K39.7
S4_PA13: SITE4.15(GPIOB_4/PA[13]/SWD_DATA/SPI0_MO) UNK4K6.3
S4_PA13_UART_RX: UNK4K6.2 UNK4R27.1
S4_PA13_UART_RX_1: UNK4J2.3 UNK4R27.2
S4_PA14: SITE4.16(GPIOB_5/PA[14]/SWD_CLK/SPI0_MIS) UNK4K6.6
S4_PA14_UART_TX: UNK4K6.7 UNK4R28.1
S4_PA14_UART_TX_1: UNK4J2.4 UNK4R28.2
S4_PA15_1: UNK4R40.2 UNK4SW5.6
S4_PA16_1: UNK4R41.2 UNK4SW5.7
S4_PA20: SITE4.45(MIC1_P/GPIOC_2/PA[20]) UNK4K15.6
S4_PA21: SITE4.46(MIC1_N/GPIOC_3/PA[21]) UNK4K15.3
S4_PA22: SITE4.43(MIC2_P/GPIOC_4/PA[22]) UNK4K11.6
S4_PA23: SITE4.44(MIC2_N/GPIOC_5/PA[23]) UNK4K11.3
S4_PA24: SITE4.41(MIC3_P/I2C_SDA/GPIOC_6/PA[24]) UNK4K12.6
S4_PA25: SITE4.42(MIC3_N/I2C_SCL/GPIOC_7/PA[25]) UNK4K12.3
S4_PA28: SITE4.39(MIC5_P/ANT_SEL_P/GPIOC_10/PA[28) UNK4K13.6
S4_PA29: SITE4.40(MIC5_N/ANT_SEL_N/GPIOC_11/PA[29) UNK4K13.3
S4_PB3: SITE4.52(AOUT_LP/GPIOC_17/PB[3]) UNK4K10.6
S4_PB3_AOUT_LP_2: UNK4K13.5 UNK4R70.2
S4_PB4: SITE4.51(AOUT_LN/GPIOC_18/PB[4]) UNK4K10.3
S4_PB4_AOUT_LN_2: UNK4K13.4 UNK4R67.2
S4_PB5: SITE4.54(AOUT_RP/GPIOC_19/PB[5]) UNK4K14.6
S4_PB5_AOUT_RP_2: UNK4K11.5 UNK4R66.2
S4_PB6: SITE4.55(AOUT_RN/GPIOC_20/PB[6]) UNK4K14.3
S4_PB6_AOUT_RN_2: UNK4K11.4 UNK4R63.2
S4_PB10_1: UNK4R37.2 UNK4SW5.4
S4_PB11_1: UNK4R39.2 UNK4SW5.5
S4_PB21_1: UNK4R36.2 UNK4SW5.3
S4_PB22_1: UNK4R35.2 UNK4SW5.2
S4_PB23: SITE4.72(UART_LOG_RXD/OTP_BYPASS/GPIOF_2) UNK4C144.2 UNK4K4.3 UNK4R57.1
S4_PB23_1: UNK4R57.2 UNK4SW6.1
S4_PB23_SICK: UNK4K4.2 UNK4R20.1
S4_PB23_SICK_1: UNK4J1.3 UNK4R20.2
S4_PB24: SITE4.73(UART_LOG_TXD/UART_DOWNLOAD/GPIO) UNK4C143.2 UNK4K4.6 UNK4R58.1
S4_PB24_1: UNK4R58.2 UNK4SW6.2
S4_PB24_SIDD: UNK4K4.7 UNK4R21.1
S4_PB24_SIDD_1: UNK4J1.4 UNK4R21.2
S4_PB25: SITE4.96(SPI0_CLK/SWD_CLK/SD_D2/ICFG2/GP) UNK4K8.3 UNK4R59.1
S4_PB25_1: UNK4R59.2 UNK4SW6.3
S4_PB25_I2C_SCL: UNK4K8.2 UNK4R31.1
S4_PB25_I2C_SCL_1: UNK4J3.3 UNK4R31.2
S4_PB26: SITE4.97(SPI0_CS/SWD_DATA/SD_D3/ICFG3/GP) UNK4K8.6 UNK4R60.1
S4_PB26_1: UNK4R60.2 UNK4SW6.4
S4_PB26_I2C_SDA: UNK4K8.7 UNK4R32.1
S4_PB26_I2C_SDA_1: UNK4J3.4 UNK4R32.2
S4_RF_A: UNK4C13.1 UNK4C14.1 UNK4C15.1 UNK4D3.1 UNK4SMP3.1
S4_RF_G: UNK4C6.1 UNK4C7.1 UNK4C8.1 UNK4D2.1 UNK4SMP2.1
S4_RFIN_A: SITE4.29(RFIN_A/GND (<750UM)) UNK4C16.2 UNK4R9.1
S4_RFIN_G: SITE4.31(RFIN_G/GND) UNK4C9.2 UNK4R5.1
S4_RFIO_A: SITE4.28(RFIO_A  (<750UM)) UNK4C11.2 UNK4R6.1
S4_RFIO_BT: SITE4.37(RFIO_BT) UNK4C1.2 UNK4R1.1
S4_RFIO_G: SITE4.32(RFIO_G) UNK4C4.2 UNK4R2.1
S4_RREF_MEM: SITE4.60(RREF_MEM) UNK4K9.3 UNK4R43.1
S4_SPI_CLK: UNK4K1.7 UNK4R15.2
S4_SPI_CLK/PB28: SITE4.90(SPI_FLASH_CLK/SD_CLK/GPIOG_3/PB) UNK4K1.6
S4_SPI_CS: UNK4K3.2 UNK4R10.1
S4_SPI_CS/PC0: SITE4.95(SPI_FLASH_CS/UART1_CTS/SD_CD/GP) UNK4K3.3
S4_SPI_D0/PB29: SITE4.91(SPI_FLASH_DATA0/UART1_RXD/SD_D0) UNK4K1.3
S4_SPI_D1/PB31: SITE4.94(SPI_FLASH_DATA1/UART1_RTS/SD_WP) UNK4K3.6
S4_SPI_D2/PB30: SITE4.92(SPI_FLASH_DATA2/UART1_TXD/SD_D1) UNK4K2.6
S4_SPI_D3/PB27: SITE4.89(SPI_FLASH_DATA3/SD_CMD/GPIOG_2/) UNK4K2.3
S4_SPI_DATA0: UNK4K1.2 UNK4R17.2
S4_SPI_DATA1: UNK4K3.7 UNK4R11.1
S4_SPI_DATA2: UNK4K2.7 UNK4R16.1
S4_SPI_DATA3: UNK4K2.2 UNK4R13.2
S4_U1_VC1: UNK4K39.5 UNK4U1.4
S4_U2_VC1: UNK4K39.4 UNK4U2.4
S4_VA09_MIPI: SITE4.84(VA09_MIPI/VA09_CK/VA09_DA) UNK4BD37.2 UNK4C152.1
S4_VA09_PLL: SITE4.11(VA09_PLL/VD09_CORE0) UNK4BD1.2 UNK4C44.1
S4_VA09_USB: SITE4.77(VA09_USB) UNK4BD2.2 UNK4C45.1
S4_VA13_AFE: SITE4.19(VA13_AFE) UNK4BD20.2 UNK4C88.1
S4_VA13_SYN: SITE4.23(VR13_SYN) UNK4BD16.2 UNK4C78.1
S4_VA33_SYN: SITE4.24(VR33_SYN) UNK4BD13.2 UNK4C64.1
S4_VA33_XTAL: SITE4.20(VA33_XTAL) UNK4BD5.2 UNK4C48.1
S4_VD09_CORE1: SITE4.56(VD09_CORE1/VD09MEM0) UNK4C47.1 UNK4R76.2
