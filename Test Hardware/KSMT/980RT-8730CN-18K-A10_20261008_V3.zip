# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N27475489: length 3.2
  BOTTOM w0.277: UNK5R25.1 UNK5K5.4
N27475492: length 0.8
  TOP w0.152: 326.16,248.34 UNK5U2.3
  TOP w0.277: UNK5R8.1 326.16,248.34
N27475498: length 3.6
  TOP w0.277: UNK5R2.2 UNK5C5.1 330.47,253.16 arc(330.61,252.94) 330.67,252.68 UNK5R4.2
N27475526: length 5.1
  TOP w0.277: UNK5C2.1 332.42,253.43 arc(331.98,254.09) 331.45,254.69 331,255.15 UNK5C3.1 UNK5R1.2
N27475531: length 2.3
  TOP w0.277: UNK5C2.2 UNK5D1.1 UNK5SMP1.1
N27475649: length 3.2
  BOTTOM w0.277: UNK5R23.1 UNK5K7.6
N27475650: length 3.2
  BOTTOM w0.277: UNK5R26.1 UNK5K7.4
N27475655: length 2.3
  BOTTOM w0.508: UNK5BD27.1 UNK5R33.2 UNK5R29.1
N27475782: length 3.3
  TOP w0.249: SITE5.47 331.45,257.64 331.67,257.42
  TOP w0.277: v1(333.2,257.12) 331.98,257.12 331.67,257.42
N27479385: length 2
  BOTTOM w0.277: UNK5K19.4 UNK5C39.1
N27479386: length 2
  BOTTOM w0.277: UNK5K19.2 UNK5C38.2
N27479389: length 2
  BOTTOM w0.277: UNK5K19.5 UNK5C41.1
N27479390: length 2
  BOTTOM w0.277: UNK5K19.7 UNK5C40.2
N27479421: length 1.4
  BOTTOM w0.152: UNK5R74.2 UNK5R47.2
N27479503: length 1.4
  BOTTOM w0.152: UNK5R75.2 UNK5R45.2
N27479519: length 2
  TOP w0.277: UNK5K34.4 187.38,278.84 UNK5C145.2
N27479520: length 2
  TOP w0.277: UNK5C146.2 187.38,282.04 UNK5K34.5
N27479527: length 2
  TOP w0.277: UNK5K35.4 187.38,271.58 UNK5C147.2
N27479528: length 2
  TOP w0.277: UNK5K35.5 187.38,274.78 UNK5C148.2
N27479531: length 2
  TOP w0.277: UNK5C149.2 187.38,287.48 UNK5K36.4
N27479532: length 2
  TOP w0.277: UNK5C150.2 187.38,290.68 UNK5K36.5
N27480661: length 2.3
  BOTTOM w0.277: UNK5R54.1 UNK5K28.4
N27480665:
  vias: v1(328.97,280.27) v1(328.98,278.11)
N27480700: length 2
  BOTTOM w0.277: UNK5K22.4 UNK5R49.1
N27480704:
  vias: v1(306.68,276.76) v1(306.68,274.73)
N27480831: length 2.8
  BOTTOM w0.277: UNK5K25.4 316.15,289.96 UNK5R51.1
N27480833:
  vias: v1(316.49,286.51) v1(318.79,286.51)
N27480939: length 3.4
  BOTTOM w1.016: UNK5R71.1 UNK5K30.3
N27480941: length 3.4
  BOTTOM w1.016: UNK5R72.1 UNK5K31.3
N27480943: length 3.4
  BOTTOM w1.016: UNK5R73.1 UNK5K32.3
N27484303: length 3.5
  TOP w0.152: UNK6U1.3 368.47,252.35
  TOP w0.277: v1(367.51,253.08) 367.51,253.04 arc(367.71,252.56) 368.19,252.35 368.47,252.35
  BOTTOM w0.277: v1(367.51,253.08) 367.28,253.08 arc(367,253.13) 366.76,253.29 arc(366.62,253.5) UNK6C10.1 UNK6R5.2
N27484309: length 1.9
  TOP w0.152: 368.89,251.13 UNK6U1.5
  TOP w0.277: UNK6C7.2 369.55,250.47 arc(369.08,250.66) 368.89,251.13
N27484312: length 0.8
  TOP w0.152: 369.3,252.35 UNK6U1.1
  TOP w0.277: UNK6R4.1 369.3,252.35
N27484363: length 0.7
  TOP w0.277: UNK6R3.2 UNK6C6.2
N27484372: length 8.6
  TOP w0.152: UNK6U2.1 366.99,248.34
  TOP w0.277: v1(367.96,249.06) 367.96,249.03 arc(367.76,248.54) 367.27,248.34 366.99,248.34
  BOTTOM w0.277: UNK6R9.2 UNK6C19.1 arc(365.19,252.43) 366.31,250.75 v1(367.96,249.06)
N27484379: length 1.9
  TOP w0.152: 366.58,247.12 UNK6U2.5
  TOP w0.277: UNK6C14.2 365.92,246.46 arc(366.39,246.65) 366.58,247.12
N27484386: length 6.7
  TOP w0.277: UNK6R8.2 UNK6C12.1 UNK6R6.2
N27484388: length 0.7
  TOP w0.277: UNK6C13.2 UNK6R7.2
N27484407: length 3.1
  BOTTOM w0.508: UNK6BD27.2 UNK6C24.1 473.34,276.99 UNK6K16.4
N27484417: length 3.2
  BOTTOM w0.277: UNK6R22.1 UNK6K5.6
N27484419: length 3.2
  BOTTOM w0.277: UNK6R25.1 UNK6K5.4
N27484422: length 0.8
  TOP w0.152: 366.16,248.34 UNK6U2.3
  TOP w0.277: UNK6R8.1 366.16,248.34
N27484428: length 3.6
  TOP w0.277: UNK6R2.2 UNK6C5.1 370.47,253.16 arc(370.61,252.94) 370.67,252.68 UNK6R4.2
N27484456: length 5.1
  TOP w0.277: UNK6C2.1 372.42,253.43 arc(371.98,254.09) 371.45,254.69 371,255.15 UNK6C3.1 UNK6R1.2
N27484461: length 2.3
  TOP w0.277: UNK6C2.2 UNK6D1.1 UNK6SMP1.1
N27484579: length 3.2
  BOTTOM w0.277: UNK6R23.1 UNK6K7.6
N27484580: length 3.2
  BOTTOM w0.277: UNK6R26.1 UNK6K7.4
N27484585: length 2.3
  BOTTOM w0.508: UNK6R29.1 UNK6R33.2 UNK6BD27.1
N27484712: length 3.3
  TOP w0.249: SITE6.47 371.45,257.64 371.67,257.42
  TOP w0.277: v1(373.2,257.12) 371.98,257.12 371.67,257.42
N27488315: length 2
  BOTTOM w0.277: UNK6K19.4 UNK6C39.1
N27488316: length 2
  BOTTOM w0.277: UNK6K19.2 UNK6C38.2
N27488319: length 2
  BOTTOM w0.277: UNK6K19.5 UNK6C41.1
N27488320: length 2
  BOTTOM w0.277: UNK6K19.7 UNK6C40.2
N27488351: length 1.4
  BOTTOM w0.152: UNK6R74.2 UNK6R47.2
N27488433: length 1.4
  BOTTOM w0.152: UNK6R75.2 UNK6R45.2
N27488449: length 2
  TOP w0.277: UNK6K34.4 509.22,294.03 UNK6C145.2
N27488450: length 2
  TOP w0.277: UNK6K34.5 509.22,290.83 UNK6C146.2
N27488457: length 2
  TOP w0.277: UNK6K35.4 509.22,301.29 UNK6C147.2
N27488458: length 2
  TOP w0.277: UNK6K35.5 509.22,298.09 UNK6C148.2
N27488461: length 2
  TOP w0.277: UNK6C149.2 509.22,285.39 UNK6K36.4
N27488462: length 2
  TOP w0.277: UNK6C150.2 509.22,282.2 UNK6K36.5
N27489591: length 2.3
  BOTTOM w0.277: UNK6R54.1 UNK6K28.4
N27489595:
  vias: v1(368.97,280.27) v1(368.98,278.11)
N27489630: length 2
  BOTTOM w0.277: UNK6K22.4 UNK6R49.1
N27489634:
  vias: v1(346.68,276.76) v1(346.68,274.73)
N27489761: length 2.8
  BOTTOM w0.277: UNK6R51.1 356.15,289.96 UNK6K25.4
N27489763:
  vias: v1(356.49,286.51) v1(358.79,286.51)
N27489869: length 3.4
  BOTTOM w1.016: UNK6R71.1 UNK6K30.3
N27489871: length 3.4
  BOTTOM w1.016: UNK6R72.1 UNK6K31.3
N27489873: length 3.4
  BOTTOM w1.016: UNK6R73.1 UNK6K32.3
N27493233: length 3.5
  TOP w0.152: UNK7U1.3 408.47,252.35
  TOP w0.277: 408.47,252.35 408.19,252.35 arc(407.71,252.56) 407.51,253.04 v1(407.51,253.08)
  BOTTOM w0.277: UNK7R5.2 UNK7C10.1 arc(406.62,253.5) 406.76,253.29 arc(407,253.13) 407.28,253.08 v1(407.51,253.08)
N27493239: length 1.9
  TOP w0.152: 408.89,251.13 UNK7U1.5
  TOP w0.277: UNK7C7.2 409.55,250.47 arc(409.08,250.66) 408.89,251.13
N27493242: length 0.8
  TOP w0.152: 409.3,252.35 UNK7U1.1
  TOP w0.277: UNK7R4.1 409.3,252.35
N27493293: length 0.7
  TOP w0.277: UNK7R3.2 UNK7C6.2
N27493302: length 8.6
  TOP w0.152: UNK7U2.1 406.99,248.34
  TOP w0.277: v1(407.96,249.06) 407.96,249.03 arc(407.76,248.54) 407.27,248.34 406.99,248.34
  BOTTOM w0.277: v1(407.96,249.06) 406.31,250.75 arc(405.19,252.43) UNK7C19.1 UNK7R9.2
N27493309: length 1.9
  TOP w0.152: 406.58,247.12 UNK7U2.5
  TOP w0.277: UNK7C14.2 405.92,246.46 arc(406.39,246.65) 406.58,247.12
N27493316: length 6.7
  TOP w0.277: UNK7R7.1 UNK7C12.1 UNK7R6.2
N27493318: length 0.7
  TOP w0.277: UNK7C13.2 UNK7R7.2
N27493337: length 3.1
  BOTTOM w0.508: UNK7K16.4 473.34,242.7 UNK7C24.1 UNK7BD27.2
N27493347: length 3.2
  BOTTOM w0.277: UNK7R22.1 UNK7K5.6
N27493349: length 3.2
  BOTTOM w0.277: UNK7R25.1 UNK7K5.4
N27493352: length 0.8
  TOP w0.152: 406.16,248.34 UNK7U2.3
  TOP w0.277: UNK7R8.1 406.16,248.34
N27493358: length 3.6
  TOP w0.277: UNK7R2.2 UNK7C5.1 410.47,253.16 arc(410.61,252.94) 410.67,252.68 UNK7R3.1
N27493386: length 5.1
  TOP w0.277: UNK7R1.2 UNK7C3.1 411,255.15 411.45,254.69 arc(411.98,254.09) 412.42,253.43 UNK7C2.1
N27493391: length 2.3
  TOP w0.277: UNK7SMP1.1 UNK7D1.1 UNK7C2.2
N27493509: length 3.2
  BOTTOM w0.277: UNK7R23.1 UNK7K7.6
N27493510: length 3.2
  BOTTOM w0.277: UNK7R26.1 UNK7K7.4
N27493515: length 2.3
  BOTTOM w0.508: UNK7BD27.1 UNK7R33.2 UNK7R29.1
N27493642: length 3.3
  TOP w0.249: 411.67,257.42 411.45,257.64 SITE7.47
  TOP w0.277: v1(413.2,257.12) 411.98,257.12 411.67,257.42
N27497245: length 2
  BOTTOM w0.277: UNK7K19.4 UNK7C39.1
N27497246: length 2
  BOTTOM w0.277: UNK7K19.2 UNK7C38.2
N27497249: length 2
  BOTTOM w0.277: UNK7K19.5 UNK7C41.1
N27497250: length 2
  BOTTOM w0.277: UNK7K19.7 UNK7C40.2
N27497281: length 1.4
  BOTTOM w0.152: UNK7R74.2 UNK7R47.2
N27497363: length 1.4
  BOTTOM w0.152: UNK7R75.2 UNK7R45.2
N27497379: length 2
  TOP w0.277: UNK7C145.2 509.22,259.74 UNK7K34.4
N27497380: length 2
  TOP w0.277: UNK7C146.2 509.22,256.54 UNK7K34.5
N27497387: length 2
  TOP w0.277: UNK7C147.2 509.22,267 UNK7K35.4
N27497388: length 2
  TOP w0.277: UNK7C148.2 509.22,263.8 UNK7K35.5
N27497391: length 2
  TOP w0.277: UNK7K36.4 509.22,251.1 UNK7C149.2
N27497392: length 2
  TOP w0.277: UNK7C150.2 509.22,247.91 UNK7K36.5
N27498521: length 2.3
  BOTTOM w0.277: UNK7R54.1 UNK7K28.4
N27498525:
  vias: v1(408.97,280.27) v1(408.98,278.11)
N27498560: length 2
  BOTTOM w0.277: UNK7K22.4 UNK7R49.1
N27498564:
  vias: v1(386.68,276.76) v1(386.68,274.73)
N27498691: length 2.8
  BOTTOM w0.277: UNK7R51.1 396.15,289.96 UNK7K25.4
N27498693:
  vias: v1(396.49,286.51) v1(398.79,286.51)
N27498799: length 3.4
  BOTTOM w1.016: UNK7R71.1 UNK7K30.3
N27498801: length 3.4
  BOTTOM w1.016: UNK7R72.1 UNK7K31.3
N27498803: length 3.4
  BOTTOM w1.016: UNK7R73.1 UNK7K32.3
N27678036: length 1.8
  BOTTOM w0.305: UNK1R62.1 UNK1SW6.5
N27678040: length 1.8
  BOTTOM w0.305: UNK1R61.1 299.66,83.12
N27678099: length 1.9
  BOTTOM w0.277: UNK1R42.1 215.59,124.04
N27678103: length 1.9
  BOTTOM w0.277: UNK1R38.1 UNK1SW5.10
N27679333: length 1.8
  BOTTOM w0.305: UNK2R61.1 UNK2SW6.6
N27679337: length 1.8
  BOTTOM w0.305: UNK2R62.1 UNK2SW6.5
N27679417: length 1.9
  BOTTOM w0.305: UNK2R38.1 UNK2SW5.10
N27679421: length 1.9
  BOTTOM w0.305: UNK2R42.1 UNK2SW5.9
N27681031: length 1.8
  BOTTOM w0.305: UNK3R61.1 UNK3SW6.6
N27681035: length 1.8
  BOTTOM w0.305: UNK3R62.1 UNK3SW6.5
N27681115: length 1.9
  BOTTOM w0.305: UNK3R38.1 UNK3SW5.10
N27681119: length 1.9
  BOTTOM w0.305: UNK3R42.1 UNK3SW5.9
N27683469: length 1.8
  BOTTOM w0.277: UNK4R61.1 UNK4SW6.6
N27683473: length 1.8
  BOTTOM w0.277: UNK4R62.1 UNK4SW6.5
N27683595: length 1.9
  BOTTOM w0.277: UNK4R38.1 UNK4SW5.10
N27683599: length 1.9
  BOTTOM w0.277: UNK4R42.1 UNK4SW5.9
N27685777: length 1.8
  BOTTOM w0.277: UNK5R61.1 UNK5SW6.6
N27685781: length 1.8
  BOTTOM w0.277: UNK5R62.1 UNK5SW6.5
N27685861: length 1.9
  BOTTOM w0.277: UNK5R38.1 UNK5SW5.10
N27685865: length 1.9
  BOTTOM w0.277: UNK5R42.1 UNK5SW5.9
N27688167: length 1.8
  BOTTOM w0.305: UNK6R61.1 UNK6SW6.6
N27688171: length 1.8
  BOTTOM w0.305: UNK6R62.1 UNK6SW6.5
N27691430: length 1.8
  BOTTOM w0.277: UNK7R61.1 UNK7SW6.6
N27691434: length 1.8
  BOTTOM w0.277: UNK7R62.1 UNK7SW6.5
N27691556: length 1.9
  BOTTOM w0.277: UNK7R38.1 UNK7SW5.10
N27691560: length 1.9
  BOTTOM w0.277: UNK7R42.1 UNK7SW5.9

## Copper pours and planes (outline as drawn)
AGND on TOP: 370.54,197.26 370.9,197.26 374.83,192.71 379.79,187.76 379.79,185.83 373.16,179.2 368.32,179.2 367.35,178.24 361.75,178.24 361.65,178.33 361.65,184.63 363.53,186.51 363.53,195.94 363.76,196.16 363.76,196.38 363.89,196.52 364.09,196.52 364.22,196.38 364.22,195.93 364.18,195.9 364.18,194.91 364.23,194.86 364.34,194.97 364.34,195.1 364.39,195.1 364.43,195.05 364.43,195.09 364.47,195.05 364.62,195.05 365.05,195.48 365.05,195.55 364.9,195.55 364.9,196.01 365.42,196.01 365.42,196.36 365.64,196.57 366.18,196.57 366.74,196.01 366.74,196.06 366.68,196.11 366.68,196.16 366.35,196.49 366.4,196.49 366.12,196.77 365.74,196.77 365.6,196.63 365.44,196.63 365.33,196.52 365.33,196.42 364.9,196.42 364.9,197.56 364.34,198.12 364.45,198.22 364.45,198.5 369.7,198.5 370.49,197.71 369.42,197.71 369.32,197.61 369.32,197.43 369.51,197.24 369.5,197.23 369.5,197.1 369.98,196.62 370.23,196.62 370.21,196.6 370.41,196.29 370.72,196.31 370.29,196.73 370.24,196.64 370.24,196.95 ; 19 cut-outs
AGND on TOP: 290.54,197.26 290.9,197.26 294.83,192.71 299.79,187.76 299.79,185.83 293.16,179.2 288.32,179.2 287.35,178.24 281.75,178.24 281.65,178.33 281.65,184.63 283.53,186.51 283.53,195.94 283.76,196.16 283.76,196.38 283.89,196.52 284.09,196.52 284.22,196.38 284.22,195.93 284.18,195.9 284.18,194.91 284.23,194.86 284.34,194.97 284.34,195.1 284.39,195.1 284.43,195.05 284.43,195.09 284.47,195.05 284.62,195.05 285.06,195.48 285.06,195.55 284.9,195.55 284.9,196.01 285.42,196.01 285.42,196.36 285.64,196.57 286.18,196.57 286.74,196.01 286.74,196.06 286.68,196.11 286.68,196.16 286.35,196.49 286.4,196.49 286.12,196.77 285.74,196.77 285.6,196.63 285.44,196.63 285.33,196.52 285.33,196.42 284.9,196.42 284.9,197.56 284.34,198.12 284.45,198.22 284.45,198.5 289.7,198.5 290.49,197.71 289.42,197.71 289.32,197.61 289.32,197.43 289.51,197.24 289.5,197.23 289.5,197.1 289.98,196.62 290.23,196.62 290.21,196.6 290.41,196.29 290.72,196.31 290.29,196.73 290.24,196.64 290.24,196.95 ; 19 cut-outs
AGND on TOP: 370.54,257.26 370.9,257.26 374.83,252.71 379.79,247.76 379.79,245.83 373.16,239.2 368.32,239.2 367.35,238.24 361.75,238.24 361.65,238.33 361.65,244.63 363.53,246.51 363.53,255.94 363.76,256.16 363.76,256.38 363.89,256.52 364.09,256.52 364.22,256.38 364.22,255.93 364.18,255.9 364.18,254.91 364.23,254.86 364.34,254.97 364.34,255.1 364.39,255.1 364.43,255.05 364.43,255.09 364.47,255.05 364.62,255.05 365.05,255.48 365.05,255.55 364.9,255.55 364.9,256.01 365.42,256.01 365.42,256.36 365.64,256.57 366.18,256.57 366.74,256.01 366.74,256.06 366.68,256.11 366.68,256.16 366.35,256.49 366.4,256.49 366.12,256.77 365.74,256.77 365.6,256.63 365.44,256.63 365.33,256.52 365.33,256.42 364.9,256.42 364.9,257.56 364.34,258.12 364.45,258.22 364.45,258.5 369.7,258.5 370.49,257.71 369.42,257.71 369.32,257.61 369.32,257.43 369.51,257.24 369.5,257.23 369.5,257.1 369.98,256.62 370.23,256.62 370.21,256.6 370.41,256.29 370.72,256.31 370.29,256.73 370.24,256.64 370.24,256.95 ; 19 cut-outs
AGND on TOP: 410.54,257.26 410.9,257.26 414.83,252.71 419.79,247.76 419.79,245.83 413.16,239.2 408.32,239.2 407.35,238.24 401.75,238.24 401.65,238.33 401.65,244.63 403.53,246.51 403.53,255.94 403.76,256.16 403.76,256.38 403.89,256.52 404.09,256.52 404.22,256.38 404.22,255.93 404.18,255.9 404.18,254.91 404.23,254.86 404.34,254.97 404.34,255.1 404.39,255.1 404.43,255.05 404.43,255.09 404.47,255.05 404.62,255.05 405.05,255.48 405.05,255.55 404.9,255.55 404.9,256.01 405.42,256.01 405.42,256.36 405.64,256.57 406.18,256.57 406.74,256.01 406.74,256.06 406.68,256.11 406.68,256.16 406.35,256.49 406.4,256.49 406.12,256.77 405.74,256.77 405.6,256.63 405.44,256.63 405.33,256.52 405.33,256.42 404.9,256.42 404.9,257.56 404.34,258.12 404.45,258.22 404.45,258.5 409.7,258.5 410.49,257.71 409.42,257.71 409.32,257.61 409.32,257.43 409.51,257.24 409.5,257.23 409.5,257.1 409.98,256.62 410.23,256.62 410.21,256.6 410.41,256.29 410.72,256.31 410.29,256.73 410.24,256.64 410.24,256.95 ; 19 cut-outs
AGND on TOP: 410.54,197.26 410.9,197.26 414.83,192.71 419.79,187.76 419.79,185.83 413.16,179.2 408.32,179.2 407.35,178.24 401.75,178.24 401.65,178.33 401.65,184.63 403.53,186.51 403.53,195.94 403.76,196.16 403.76,196.38 403.89,196.52 404.09,196.52 404.22,196.38 404.22,195.93 404.18,195.9 404.18,194.91 404.23,194.86 404.34,194.97 404.34,195.1 404.39,195.1 404.43,195.05 404.43,195.09 404.47,195.05 404.62,195.05 405.05,195.48 405.05,195.55 404.9,195.55 404.9,196.01 405.42,196.01 405.42,196.36 405.64,196.57 406.18,196.57 406.74,196.01 406.74,196.06 406.68,196.11 406.68,196.16 406.35,196.49 406.4,196.49 406.12,196.77 405.74,196.77 405.6,196.63 405.44,196.63 405.33,196.52 405.33,196.42 404.9,196.42 404.9,197.56 404.34,198.12 404.45,198.22 404.45,198.5 409.7,198.5 410.49,197.71 409.42,197.71 409.32,197.61 409.32,197.43 409.51,197.24 409.5,197.23 409.5,197.1 409.98,196.62 410.23,196.62 410.21,196.6 410.41,196.29 410.72,196.31 410.29,196.73 410.24,196.64 410.24,196.95 ; 19 cut-outs
AGND on TOP: 330.54,197.26 330.9,197.26 334.83,192.71 339.79,187.76 339.79,185.83 333.16,179.2 328.32,179.2 327.35,178.24 321.75,178.24 321.65,178.33 321.65,184.63 323.53,186.51 323.53,195.94 323.76,196.16 323.76,196.38 323.89,196.52 324.09,196.52 324.22,196.38 324.22,195.93 324.18,195.9 324.18,194.91 324.23,194.86 324.34,194.97 324.34,195.1 324.39,195.1 324.43,195.05 324.43,195.09 324.47,195.05 324.62,195.05 325.05,195.48 325.05,195.55 324.9,195.55 324.9,196.01 325.42,196.01 325.42,196.36 325.64,196.57 326.18,196.57 326.74,196.01 326.74,196.06 326.68,196.11 326.68,196.16 326.35,196.49 326.4,196.49 326.12,196.77 325.74,196.77 325.6,196.63 325.44,196.63 325.33,196.52 325.33,196.42 324.9,196.42 324.9,197.56 324.34,198.12 324.45,198.22 324.45,198.5 329.7,198.5 330.49,197.71 329.42,197.71 329.32,197.61 329.32,197.43 329.51,197.24 329.5,197.23 329.5,197.1 329.98,196.62 330.23,196.62 330.21,196.6 330.41,196.29 330.72,196.31 330.29,196.73 330.24,196.64 330.24,196.95 ; 19 cut-outs
AGND on TOP: 290.54,257.26 290.9,257.26 294.83,252.71 299.79,247.76 299.79,245.83 293.16,239.2 288.32,239.2 287.35,238.24 281.75,238.24 281.65,238.33 281.65,244.63 283.53,246.51 283.53,255.94 283.76,256.16 283.76,256.38 283.89,256.52 284.09,256.52 284.22,256.38 284.22,255.93 284.18,255.9 284.18,254.91 284.23,254.86 284.34,254.97 284.34,255.1 284.39,255.1 284.43,255.05 284.43,255.09 284.47,255.05 284.62,255.05 285.06,255.48 285.06,255.55 284.9,255.55 284.9,256.01 285.42,256.01 285.42,256.36 285.64,256.57 286.18,256.57 286.74,256.01 286.74,256.06 286.68,256.11 286.68,256.16 286.35,256.49 286.4,256.49 286.12,256.77 285.74,256.77 285.6,256.63 285.44,256.63 285.33,256.52 285.33,256.42 284.9,256.42 284.9,257.56 284.34,258.12 284.45,258.22 284.45,258.5 289.7,258.5 290.49,257.71 289.42,257.71 289.32,257.61 289.32,257.43 289.51,257.24 289.5,257.23 289.5,257.1 289.98,256.62 290.23,256.62 290.21,256.6 290.41,256.29 290.72,256.31 290.29,256.73 290.24,256.64 290.24,256.95 ; 19 cut-outs
AGND on TOP: 330.54,257.26 330.9,257.26 334.83,252.71 339.79,247.76 339.79,245.83 333.16,239.2 328.32,239.2 327.35,238.24 321.75,238.24 321.65,238.33 321.65,244.63 323.53,246.51 323.53,255.94 323.76,256.16 323.76,256.38 323.89,256.52 324.09,256.52 324.22,256.38 324.22,255.93 324.18,255.9 324.18,254.91 324.23,254.86 324.34,254.97 324.34,255.1 324.39,255.1 324.43,255.05 324.43,255.09 324.47,255.05 324.62,255.05 325.05,255.48 325.05,255.55 324.9,255.55 324.9,256.01 325.42,256.01 325.42,256.36 325.64,256.57 326.18,256.57 326.74,256.01 326.74,256.06 326.68,256.11 326.68,256.16 326.35,256.49 326.4,256.49 326.12,256.77 325.74,256.77 325.6,256.63 325.44,256.63 325.33,256.52 325.33,256.42 324.9,256.42 324.9,257.56 324.34,258.12 324.45,258.22 324.45,258.5 329.7,258.5 330.49,257.71 329.42,257.71 329.32,257.61 329.32,257.43 329.51,257.24 329.5,257.23 329.5,257.1 329.98,256.62 330.23,256.62 330.21,256.6 330.41,256.29 330.72,256.31 330.29,256.73 330.24,256.64 330.24,256.95 ; 19 cut-outs
AGND on BOTTOM: 287.34,256.96 288.23,256.96 289.44,255.75 289.44,248.53 289.13,248.23 283.89,248.23 283.65,248.47 283.65,257.88 284.41,258.64 285.66,258.64 ; 5 cut-outs
AGND on BOTTOM: 287.34,196.96 288.23,196.96 289.44,195.75 289.44,188.53 289.13,188.23 283.89,188.23 283.65,188.47 283.65,197.88 284.41,198.64 285.66,198.64 ; 5 cut-outs
AGND on BOTTOM: 407.34,256.96 408.23,256.96 409.44,255.75 409.44,248.53 409.13,248.23 403.89,248.23 403.65,248.47 403.65,257.88 404.41,258.64 405.66,258.64 ; 5 cut-outs
AGND on BOTTOM: 367.34,196.96 368.23,196.96 369.44,195.75 369.44,188.53 369.13,188.23 363.89,188.23 363.65,188.47 363.65,197.88 364.41,198.64 365.66,198.64 ; 5 cut-outs
AGND on BOTTOM: 327.34,256.96 328.23,256.96 329.44,255.75 329.44,248.53 329.13,248.23 323.89,248.23 323.65,248.47 323.65,257.88 324.41,258.64 325.66,258.64 ; 5 cut-outs
AGND on BOTTOM: 367.34,256.96 368.23,256.96 369.44,255.75 369.44,248.53 369.13,248.23 363.89,248.23 363.65,248.47 363.65,257.88 364.41,258.64 365.66,258.64 ; 5 cut-outs
AGND on BOTTOM: 407.34,196.96 408.23,196.96 409.44,195.75 409.44,188.53 409.13,188.23 403.89,188.23 403.65,188.47 403.65,197.88 404.41,198.64 405.66,198.64 ; 5 cut-outs
AGND on BOTTOM: 327.34,196.96 328.23,196.96 329.44,195.75 329.44,188.53 329.13,188.23 323.89,188.23 323.65,188.47 323.65,197.88 324.41,198.64 325.66,198.64 ; 5 cut-outs
AGND on L02_DGND: outline of 124 points within 277.97,176.88 437,259.67
AGND on L04_DGND: 363.57,240.36 363.57,257.71 364.41,258.55 367.91,258.55 368.87,257.59 371.22,257.59 375.72,253.09 375.72,241.06 373.67,239 364.93,239
AGND on L04_DGND: 403.57,240.36 403.57,257.71 404.41,258.55 407.91,258.55 408.87,257.59 411.22,257.59 415.72,253.09 415.72,241.06 413.67,239 404.93,239
AGND on L04_DGND: 403.57,180.36 403.57,197.71 404.41,198.55 407.91,198.55 408.87,197.59 411.22,197.59 415.72,193.09 415.72,181.06 413.67,179 404.93,179
AGND on L04_DGND: 283.57,180.36 283.57,197.71 284.41,198.55 287.91,198.55 288.87,197.59 291.22,197.59 295.72,193.09 295.72,181.06 293.67,179 284.93,179
AGND on L04_DGND: 323.57,240.36 323.57,257.71 324.41,258.55 327.91,258.55 328.87,257.59 331.22,257.59 335.72,253.09 335.72,241.06 333.67,239 324.93,239
AGND on L04_DGND: 323.57,180.36 323.57,197.71 324.41,198.55 327.91,198.55 328.87,197.59 331.22,197.59 335.72,193.09 335.72,181.06 333.67,179 324.93,179
AGND on L04_DGND: 363.57,180.36 363.57,197.71 364.41,198.55 367.91,198.55 368.87,197.59 371.22,197.59 375.72,193.09 375.72,181.06 373.67,179 364.93,179
AGND on L04_DGND: 283.57,240.36 283.57,257.71 284.41,258.55 287.91,258.55 288.87,257.59 291.22,257.59 295.72,253.09 295.72,241.06 293.67,239 284.93,239
DGND on TOP: 480.78,239.44 480.78,241.35 480.4,241.73 478.75,241.73 478.37,241.35 478.37,239.44 478.75,239.06 480.4,239.06
DGND on TOP: 256.83,168.25 256.83,166.35 257.21,165.96 258.86,165.96 259.24,166.35 259.24,168.25 258.86,168.63 257.21,168.63
DGND on TOP: 387.62,303.18 387.62,301.28 388,300.9 389.65,300.9 390.03,301.28 390.03,303.18 389.65,303.56 388,303.56
DGND on TOP: 263.58,168.4 261.67,168.4 261.29,168.02 261.29,166.37 261.67,165.99 263.58,165.99 263.96,166.37 263.96,168.02
DGND on TOP: 480.78,170.86 480.78,172.77 480.4,173.15 478.75,173.15 478.37,172.77 478.37,170.86 478.75,170.48 480.4,170.48
DGND on TOP: 456.22,240.45 456.22,238.54 456.6,238.16 458.25,238.16 458.63,238.54 458.63,240.45 458.25,240.83 456.6,240.83
DGND on TOP: 312.13,260.75 312.13,262.91 313.57,264.36 317.66,264.36 319.37,262.66 319.37,261.31 317.69,259.64 313.23,259.64
DGND on TOP: 260.64,300.15 262.54,300.15 262.92,300.53 262.92,302.18 262.54,302.56 260.64,302.56 260.26,302.18 260.26,300.53
DGND on TOP: 392.13,200.75 392.13,202.91 393.57,204.36 397.66,204.36 399.37,202.66 399.37,201.31 397.69,199.64 393.23,199.64
DGND on TOP: 392.39,299.76 394.29,299.76 394.67,300.14 394.67,301.79 394.29,302.18 392.39,302.18 392,301.79 392,300.14
DGND on TOP: 384.81,166.81 384.81,168.72 384.43,169.1 382.78,169.1 382.4,168.72 382.4,166.81 382.78,166.43 384.43,166.43
DGND on TOP: 434.47,227.56 432.56,227.56 432.18,227.18 432.18,225.53 432.56,225.15 434.47,225.15 434.85,225.53 434.85,227.18
DGND on TOP: 420.48,241.55 422.38,241.55 422.76,241.93 422.76,243.58 422.38,243.96 420.48,243.96 420.1,243.58 420.1,241.93
DGND on TOP: 265.26,300.15 267.17,300.15 267.55,300.53 267.55,302.18 267.17,302.56 265.26,302.56 264.88,302.18 264.88,300.53
DGND on TOP: 327.95,299.49 329.85,299.49 330.23,299.87 330.23,301.52 329.85,301.9 327.95,301.9 327.57,301.52 327.57,299.87
DGND on TOP: 240.38,263.84 240.38,265.75 240,266.13 238.35,266.13 237.97,265.75 237.97,263.84 238.35,263.46 240,263.46
DGND on TOP: 433.7,280.47 431.79,280.47 431.41,280.09 431.41,278.44 431.79,278.06 433.7,278.06 434.08,278.44 434.08,280.09
DGND on TOP: 392.13,260.75 392.13,262.91 393.57,264.36 397.66,264.36 399.37,262.66 399.37,261.31 397.69,259.64 393.23,259.64
DGND on TOP: 216.83,297.71 216.83,295.81 217.22,295.42 218.87,295.42 219.25,295.81 219.25,297.71 218.87,298.09 217.22,298.09
DGND on TOP: 346.2,166.81 346.2,168.72 345.82,169.1 344.17,169.1 343.79,168.72 343.79,166.81 344.17,166.43 345.82,166.43
DGND on TOP: 267.26,227.94 265.35,227.94 264.97,227.56 264.97,225.91 265.35,225.53 267.26,225.53 267.64,225.91 267.64,227.56
DGND on TOP: 456.22,274.74 456.22,272.83 456.6,272.45 458.25,272.45 458.63,272.83 458.63,274.74 458.25,275.12 456.6,275.12
DGND on TOP: 352.13,260.75 352.13,262.91 353.57,264.36 357.66,264.36 359.37,262.66 359.37,261.31 357.69,259.64 353.23,259.64
DGND on TOP: 216.83,229.13 216.83,227.23 217.22,226.84 218.87,226.84 219.25,227.23 219.25,229.13 218.87,229.51 217.22,229.51
DGND on TOP: 240.38,195.26 240.38,197.17 240,197.55 238.35,197.55 237.97,197.17 237.97,195.26 238.35,194.88 240,194.88
DGND on TOP: 431.81,297.94 433.71,297.94 434.09,298.32 434.09,299.97 433.71,300.35 431.81,300.35 431.43,299.97 431.43,298.32
DGND on TOP: 431.55,166.81 431.55,168.72 431.16,169.1 429.51,169.1 429.13,168.72 429.13,166.81 429.51,166.43 431.16,166.43
DGND on TOP: 272.13,200.75 272.13,202.91 273.57,204.36 277.66,204.36 279.37,202.66 279.37,201.31 277.69,199.64 273.23,199.64
DGND on TOP: 240.38,229.55 240.38,231.46 240,231.84 238.35,231.84 237.97,231.46 237.97,229.55 238.35,229.17 240,229.17
DGND on TOP: 456.22,206.16 456.22,204.25 456.6,203.87 458.25,203.87 458.63,204.25 458.63,206.16 458.25,206.54 456.6,206.54
DGND on TOP: 431.87,188.53 431.87,190.44 431.49,190.82 429.84,190.82 429.46,190.44 429.46,188.53 429.84,188.15 431.49,188.15
DGND on TOP: 265.26,290.9 267.17,290.9 267.55,291.28 267.55,292.93 267.17,293.31 265.26,293.31 264.88,292.93 264.88,291.28
DGND on TOP: 312.13,200.75 312.13,202.91 313.57,204.36 317.66,204.36 319.37,202.66 319.37,201.31 317.69,199.64 313.23,199.64
DGND on TOP: 272.13,260.75 272.13,262.91 273.57,264.36 277.66,264.36 279.37,262.66 279.37,261.31 277.69,259.64 273.23,259.64
DGND on TOP: 418.11,176.9 418.11,178.81 417.73,179.19 416.08,179.19 415.7,178.81 415.7,176.9 416.08,176.52 417.73,176.52
DGND on TOP: 352.13,200.75 352.13,202.91 353.57,204.36 357.66,204.36 359.37,202.66 359.37,201.31 357.69,199.64 353.23,199.64
DGND on TOP: 262.63,227.94 260.73,227.94 260.35,227.56 260.35,225.91 260.73,225.53 262.63,225.53 263.02,225.91 263.02,227.56
DGND on TOP: 309.63,166.81 309.63,168.72 309.24,169.1 307.59,169.1 307.21,168.72 307.21,166.81 307.59,166.43 309.24,166.43
DGND on TOP: 456.22,171.87 456.22,169.96 456.6,169.58 458.25,169.58 458.63,169.96 458.63,171.87 458.25,172.25 456.6,172.25
DGND on TOP: 240.38,298.13 240.38,300.04 240,300.42 238.35,300.42 237.97,300.04 237.97,298.13 238.35,297.75 240,297.75
DGND on BOTTOM: 475.78,199.82 476.19,199.41 476.19,187.08 475.67,186.56 469.67,186.56 469.13,187.09 469.13,199.31 469.64,199.82
DGND on BOTTOM: 220.83,201.6 220.41,202.01 220.41,214.34 220.93,214.86 226.93,214.86 227.47,214.33 227.47,202.11 226.96,201.6
DGND on BOTTOM: 220.83,167.31 220.41,167.72 220.41,180.05 220.93,180.57 226.93,180.57 227.47,180.04 227.47,167.82 226.96,167.31
DGND on BOTTOM: 475.78,268.4 476.19,267.99 476.19,255.66 475.67,255.14 469.67,255.14 469.13,255.67 469.13,267.89 469.64,268.4
DGND on BOTTOM: 220.83,235.89 220.41,236.3 220.41,248.63 220.93,249.15 226.93,249.15 227.47,248.62 227.47,236.4 226.96,235.89
DGND on BOTTOM: 475.78,302.69 476.19,302.28 476.19,289.95 475.67,289.43 469.67,289.43 469.13,289.96 469.13,302.18 469.64,302.69
DGND on BOTTOM: 475.78,234.11 476.19,233.7 476.19,221.37 475.67,220.85 469.67,220.85 469.13,221.38 469.13,233.6 469.64,234.11
DGND on BOTTOM: 220.83,270.18 220.41,270.59 220.41,282.92 220.93,283.44 226.93,283.44 227.47,282.91 227.47,270.69 226.96,270.18
DGND on L02_DGND, L04_DGND, L06_DGND, L08_DGND, L10_DGND, L12_DGND, L14_DGND, L16_DGND, L18_DGND, L20_DGND, L22_DGND, L25_DGND, L27_DGND, L29_DGND, L31_DGND: 1.02,465 2.18,467.82 5,468.98 640.8,468.98 643.62,467.82 644.79,465 644.79,5 643.62,2.18 640.8,1.02 5,1.02 2.16,2.21 1.02,5.06 1.02,147.4 2.18,150.22 5,151.38 51.82,151.38 51.82,318.62 5,318.62 2.18,319.78 1.02,322.6 1.02,323.39
(no net) on L33_DGND: 283.72,196.64 283.72,193.43 283.89,193.25 287.14,193.25 287.39,193.51 287.39,196.62 287.22,196.79 283.88,196.79
(no net) on L33_DGND: 403.72,256.64 403.72,253.43 403.89,253.25 407.14,253.25 407.39,253.51 407.39,256.62 407.22,256.79 403.88,256.79
(no net) on L33_DGND: 323.72,256.64 323.72,253.43 323.89,253.25 327.14,253.25 327.39,253.51 327.39,256.62 327.22,256.79 323.88,256.79
(no net) on L33_DGND: 363.72,256.64 363.72,253.43 363.89,253.25 367.14,253.25 367.39,253.51 367.39,256.62 367.22,256.79 363.88,256.79
(no net) on L33_DGND: 283.72,256.64 283.72,253.43 283.89,253.25 287.14,253.25 287.39,253.51 287.39,256.62 287.22,256.79 283.88,256.79
(no net) on L33_DGND: 363.72,196.64 363.72,193.43 363.89,193.25 367.14,193.25 367.39,193.51 367.39,196.62 367.22,196.79 363.88,196.79
(no net) on L33_DGND: 403.72,196.64 403.72,193.43 403.89,193.25 407.14,193.25 407.39,193.51 407.39,196.62 407.22,196.79 403.88,196.79
(no net) on L33_DGND: 323.72,196.64 323.72,193.43 323.89,193.25 327.14,193.25 327.39,193.51 327.39,196.62 327.22,196.79 323.88,196.79
(no net) on L33_DGND, L35_DGND: 1.02,465 2.18,467.82 5,468.98 640.8,468.98 643.62,467.82 644.79,465 644.79,5 643.62,2.18 640.8,1.02 5,1.02 2.16,2.21 1.02,5.06 1.02,147.4 2.18,150.22 5,151.38 51.82,151.38 51.82,318.62 5,318.62 2.18,319.78 1.02,322.6 1.02,323.39
(no net) on L35_DGND: 409.95,195.96 409.95,188.32 409.13,187.5 403.9,187.5 402.88,188.52 402.88,197.57 404.04,198.74 406.28,198.74 407.55,197.47 408.44,197.47
(no net) on L35_DGND: 329.95,195.96 329.95,188.32 329.13,187.5 323.9,187.5 322.88,188.52 322.88,197.57 324.04,198.74 326.28,198.74 327.55,197.47 328.44,197.47
(no net) on L35_DGND: 329.95,255.96 329.95,248.32 329.13,247.5 323.9,247.5 322.88,248.52 322.88,257.57 324.04,258.74 326.28,258.74 327.55,257.47 328.44,257.47
(no net) on L35_DGND: 289.95,255.96 289.95,248.32 289.13,247.5 283.9,247.5 282.88,248.52 282.88,257.57 284.04,258.74 286.28,258.74 287.55,257.47 288.44,257.47
(no net) on L35_DGND: 369.95,255.96 369.95,248.32 369.13,247.5 363.9,247.5 362.88,248.52 362.88,257.57 364.04,258.74 366.28,258.74 367.55,257.47 368.44,257.47
(no net) on L35_DGND: 409.95,255.96 409.95,248.32 409.13,247.5 403.9,247.5 402.88,248.52 402.88,257.57 404.04,258.74 406.28,258.74 407.55,257.47 408.44,257.47
(no net) on L35_DGND: 369.95,195.96 369.95,188.32 369.13,187.5 363.9,187.5 362.88,188.52 362.88,197.57 364.04,198.74 366.28,198.74 367.55,197.47 368.44,197.47
(no net) on L35_DGND: 289.95,195.96 289.95,188.32 289.13,187.5 283.9,187.5 282.88,188.52 282.88,197.57 284.04,198.74 286.28,198.74 287.55,197.47 288.44,197.47
S0_1_VDD18_A on BOTTOM: 302.28,177.32 302.28,173.15 303.22,172.21 314.75,172.21 315.13,172.59 315.13,177.39 314.62,177.9 302.86,177.9
S0_ATX_VD0V9 on TOP: 242,197.15 242,195.25 242.38,194.87 244.03,194.87 244.42,195.25 244.42,197.15 244.03,197.54 242.38,197.54
S0_DPS_F001 on TOP: 255.21,166.36 255.21,168.27 254.83,168.65 253.18,168.65 252.8,168.27 252.8,166.36 253.18,165.98 254.83,165.98
S0_DPS_F002 on TOP: 311.24,168.7 311.24,166.8 311.63,166.42 313.28,166.42 313.66,166.8 313.66,168.7 313.28,169.08 311.63,169.08
S0_DPS_F004 on TOP: 261.69,170.02 263.59,170.02 263.97,170.4 263.97,172.05 263.59,172.43 261.69,172.43 261.31,172.05 261.31,170.4
S0_DPS_F006 on BOTTOM: 288.25,174.55 288.25,167.44 289.26,166.42 295.34,166.42 296.23,165.53 298.14,165.53 298.53,165.92 298.53,174.55 297.64,175.44 289.13,175.44
S0_LX_AUD on TOP: 283.53,220.73 283.53,217.04 282.73,216.24 282.73,214.98 282.92,214.78 283.68,214.78 283.9,214.99 283.9,215.98 284.19,216.28 286.2,216.28 286.58,216.66 286.58,220.72 286.07,221.23 284.03,221.23
S0_VDD18_D on TOP: 180.41,199.19 180.41,189.89 181.47,188.82 234.28,188.82 235.55,190.09 235.55,198.83 233.67,200.71 181.93,200.71
S1_1_VDD18_A on BOTTOM: 342.28,177.06 342.28,172.9 343.22,171.96 351.23,171.96 351.91,171.27 351.91,169.93 352.83,169.01 354.68,169.01 355.13,169.46 355.13,177.47 354.5,178.1 343.32,178.1
S1_ATX_VD0V9 on TOP: 242,231.44 242,229.54 242.38,229.16 244.03,229.16 244.42,229.54 244.42,231.44 244.03,231.83 242.38,231.83
S1_DPS_F001 on TOP: 260.75,229.56 262.65,229.56 263.03,229.94 263.03,231.59 262.65,231.97 260.75,231.97 260.36,231.59 260.36,229.94
S1_DPS_F002 on TOP: 347.82,168.7 347.82,166.8 348.2,166.42 349.85,166.42 350.23,166.8 350.23,168.7 349.85,169.08 348.2,169.08
S1_DPS_F004 on TOP: 265.37,229.56 267.28,229.56 267.66,229.94 267.66,231.59 267.28,231.97 265.37,231.97 264.99,231.59 264.99,229.94
S1_DPS_F006 on BOTTOM: 328.25,174.55 328.25,167.44 329.26,166.42 335.98,166.42 336.87,165.53 338.14,165.53 338.53,165.92 338.53,174.55 337.64,175.44 329.13,175.44
S1_LX_AUD on TOP: 323.53,220.73 323.53,217.04 322.73,216.24 322.73,214.98 322.92,214.78 323.68,214.78 323.9,214.99 323.9,215.98 324.19,216.28 326.2,216.28 326.58,216.66 326.58,220.72 326.07,221.23 324.03,221.23
S1_VDD18_D on TOP: 180.41,233.48 180.41,224.18 181.47,223.11 234.28,223.11 235.55,224.38 235.55,233.12 233.67,235 181.93,235
S2_1_VDD18_A on BOTTOM: 382.28,177.32 382.28,173.15 383.22,172.21 391.23,172.21 391.91,171.53 391.91,170.18 392.83,169.26 394.68,169.26 395.13,169.71 395.13,177.39 394.62,177.9 382.86,177.9
S2_ATX_VD0V9 on TOP: 454.6,204.27 454.6,206.17 454.22,206.55 452.57,206.55 452.19,206.17 452.19,204.27 452.57,203.89 454.22,203.89
S2_DPS_F001 on TOP: 432.58,229.18 434.48,229.18 434.86,229.56 434.86,231.21 434.48,231.59 432.58,231.59 432.2,231.21 432.2,229.56
S2_DPS_F002 on TOP: 386.43,168.7 386.43,166.8 386.81,166.42 388.46,166.42 388.84,166.8 388.84,168.7 388.46,169.08 386.81,169.08
S2_DPS_F004 on TOP: 422.37,239.93 420.46,239.93 420.08,239.54 420.08,237.89 420.46,237.51 422.37,237.51 422.75,237.89 422.75,239.54
S2_DPS_F006 on BOTTOM: 368.25,174.55 368.25,167.44 369.26,166.42 375.48,166.42 376.37,165.53 378.14,165.53 378.53,165.92 378.53,174.55 377.64,175.44 369.13,175.44
S2_LX_AUD on TOP: 363.53,220.73 363.53,217.04 362.73,216.24 362.73,214.98 362.92,214.78 363.68,214.78 363.9,214.99 363.9,215.98 364.19,216.28 366.2,216.28 366.58,216.66 366.58,220.72 366.07,221.23 364.03,221.23
S2_VDD18_D on TOP: 516.2,202.23 516.2,211.53 515.13,212.6 462.32,212.6 461.05,211.33 461.05,202.59 462.93,200.71 514.67,200.71
S3_1_VDD18_A on BOTTOM: 434.94,178.06 425.13,178.06 424.75,177.68 424.75,169.98 425.11,169.62 427.09,169.62 427.65,170.18 427.65,171.47 428.31,172.14 434.46,172.14 435.55,173.23 435.55,177.45
S3_ATX_VD0V9 on TOP: 454.6,169.98 454.6,171.88 454.22,172.26 452.57,172.26 452.19,171.88 452.19,169.98 452.57,169.6 454.22,169.6
S3_DPS_F001 on TOP: 419.73,178.79 419.73,176.89 420.11,176.51 421.76,176.51 422.14,176.89 422.14,178.79 421.76,179.17 420.11,179.17
S3_DPS_F002 on TOP: 433.16,168.7 433.16,166.8 433.55,166.42 435.2,166.42 435.58,166.8 435.58,168.7 435.2,169.08 433.55,169.08
S3_DPS_F004 on TOP: 433.49,190.42 433.49,188.52 433.88,188.14 435.53,188.14 435.91,188.52 435.91,190.42 435.53,190.8 433.88,190.8
S3_DPS_F006 on BOTTOM: 408.25,174.55 408.25,167.44 409.26,166.42 415.48,166.42 416.37,165.53 418.14,165.53 418.53,165.92 418.53,174.55 417.64,175.44 409.13,175.44
S3_LX_AUD on TOP: 403.53,220.73 403.53,217.04 402.73,216.24 402.73,214.98 402.92,214.78 403.68,214.78 403.9,214.99 403.9,215.98 404.19,216.28 406.2,216.28 406.58,216.66 406.58,220.72 406.07,221.23 404.03,221.23
S3_VDD18_D on TOP: 516.2,167.94 516.2,177.24 515.13,178.31 462.32,178.31 461.05,177.04 461.05,168.3 462.93,166.42 514.67,166.42
S4_1_VDD18_A on BOTTOM: 299.4,302.34 299.4,294.54 300.06,293.88 306.36,293.88 307.07,294.59 307.07,302.18 306.25,303 300.06,303
S4_ATX_VD0V9 on TOP: 242,265.73 242,263.83 242.38,263.45 244.03,263.45 244.42,263.83 244.42,265.73 244.03,266.12 242.38,266.12
S4_DPS_F001 on TOP: 267.15,298.53 265.25,298.53 264.86,298.15 264.86,296.5 265.25,296.12 267.15,296.12 267.53,296.5 267.53,298.15
S4_DPS_F002 on TOP: 215.22,227.24 215.22,229.15 214.83,229.53 213.18,229.53 212.8,229.15 212.8,227.24 213.18,226.86 214.83,226.86
S4_DPS_F004 on TOP: 267.15,289.28 265.25,289.28 264.86,288.9 264.86,287.25 265.25,286.87 267.15,286.87 267.53,287.25 267.53,288.9
S4_DPS_F006 on BOTTOM: 280.1,295.58 280.1,294.44 280.61,293.93 282.64,293.93 283.02,294.31 283.02,302.95 282.39,303.58 280.36,303.58 279.85,303.07 272.61,303.07 271.34,301.8 271.34,296.98 272.1,296.21 279.47,296.21
S4_LX_AUD on TOP: 283.53,280.73 283.53,277.04 282.73,276.24 282.73,274.98 282.92,274.78 283.68,274.78 283.9,274.99 283.9,275.98 284.19,276.28 286.2,276.28 286.58,276.66 286.58,280.72 286.07,281.23 284.03,281.23
S4_VDD18_D on TOP: 180.41,267.77 180.41,258.47 181.47,257.4 234.28,257.4 235.55,258.67 235.55,267.41 233.67,269.29 181.93,269.29
S5_1_VDD18_A on BOTTOM: 339.4,302.34 339.4,294.54 340.06,293.88 346.36,293.88 347.07,294.59 347.07,302.18 346.25,303 340.06,303
S5_ATX_VD0V9 on TOP: 242,300.02 242,298.12 242.38,297.74 244.03,297.74 244.42,298.12 244.42,300.02 244.03,300.41 242.38,300.41
S5_DPS_F001 on TOP: 329.84,297.87 327.93,297.87 327.55,297.49 327.55,295.84 327.93,295.46 329.84,295.46 330.22,295.84 330.22,297.49
S5_DPS_F002 on TOP: 215.22,295.82 215.22,297.73 214.83,298.11 213.18,298.11 212.8,297.73 212.8,295.82 213.18,295.44 214.83,295.44
S5_DPS_F004 on TOP: 262.53,298.53 260.62,298.53 260.24,298.15 260.24,296.5 260.62,296.12 262.53,296.12 262.91,296.5 262.91,298.15
S5_DPS_F006 on BOTTOM: 310.71,302.44 310.71,298.25 311.47,297.48 318.71,297.48 320.11,296.09 320.11,294.44 320.62,293.93 322.65,293.93 323.03,294.31 323.03,302.95 322.39,303.58 320.36,303.58 319.85,303.07 311.34,303.07
S5_LX_AUD on TOP: 323.53,280.73 323.53,277.04 322.73,276.24 322.73,274.98 322.92,274.78 323.68,274.78 323.9,274.99 323.9,275.98 324.19,276.28 326.2,276.28 326.58,276.66 326.58,280.72 326.07,281.23 324.03,281.23
S5_VDD18_D on TOP: 180.41,302.06 180.41,292.76 181.47,291.69 234.28,291.69 235.55,292.96 235.55,301.7 233.67,303.58 181.93,303.58
S6_1_VDD18_A on BOTTOM: 379.2,302.32 379.2,294.52 379.86,293.86 386.16,293.86 386.87,294.57 386.87,299.81 386.43,300.25 383.33,300.25 382.62,300.96 382.62,302.56 382.2,302.98 379.86,302.98
S6_ATX_VD0V9 on TOP: 454.6,272.85 454.6,274.75 454.22,275.13 452.57,275.13 452.19,274.75 452.19,272.85 452.57,272.47 454.22,272.47
S6_DPS_F001 on TOP: 386,301.29 386,303.2 385.62,303.58 383.97,303.58 383.59,303.2 383.59,301.29 383.97,300.91 385.62,300.91
S6_DPS_F002 on TOP: 482.4,241.33 482.4,239.43 482.78,239.05 484.43,239.05 484.81,239.43 484.81,241.33 484.43,241.71 482.78,241.71
S6_DPS_F004 on TOP: 394.28,298.14 392.37,298.14 391.99,297.76 391.99,296.11 392.37,295.73 394.28,295.73 394.66,296.11 394.66,297.76
S6_DPS_F006 on BOTTOM: 350.71,302.44 350.71,298.25 351.48,297.48 358.72,297.48 360.11,296.09 360.11,294.44 360.62,293.93 362.65,293.93 363.03,294.31 363.03,302.95 362.4,303.58 360.37,303.58 359.86,303.07 351.35,303.07
S6_LX_AUD on TOP: 363.53,280.73 363.53,277.04 362.73,276.24 362.73,274.98 362.92,274.78 363.68,274.78 363.9,274.99 363.9,275.98 364.19,276.28 366.2,276.28 366.58,276.66 366.58,280.72 366.07,281.23 364.03,281.23
S6_VDD18_D on TOP: 516.2,270.81 516.2,280.11 515.13,281.18 462.32,281.18 461.05,279.91 461.05,271.17 462.93,269.29 514.67,269.29
S7_1_VDD18_A on BOTTOM: 419.4,302.34 419.4,294.54 420.06,293.88 426.36,293.88 427.07,294.59 427.07,302.18 426.25,303 420.06,303
S7_ATX_VD0V9 on TOP: 454.6,238.56 454.6,240.46 454.22,240.84 452.57,240.84 452.19,240.46 452.19,238.56 452.57,238.18 454.22,238.18
S7_DPS_F001 on TOP: 433.7,296.32 431.79,296.32 431.41,295.94 431.41,294.29 431.79,293.91 433.7,293.91 434.08,294.29 434.08,295.94
S7_DPS_F002 on TOP: 482.4,172.75 482.4,170.85 482.78,170.47 484.43,170.47 484.81,170.85 484.81,172.75 484.43,173.13 482.78,173.13
S7_DPS_F004 on TOP: 431.81,282.09 433.71,282.09 434.09,282.47 434.09,284.13 433.71,284.51 431.81,284.51 431.43,284.13 431.43,282.47
S7_DPS_F006 on BOTTOM: 405.45,300.41 405.45,294.31 405.96,293.8 414.85,293.8 415.36,294.31 415.36,303.2 414.85,303.71 412.82,303.71 411.93,302.82 411.93,301.55 411.55,301.17 406.21,301.17
S7_LX_AUD on TOP: 403.53,280.73 403.53,277.04 402.73,276.24 402.73,274.98 402.92,274.78 403.68,274.78 403.9,274.99 403.9,275.98 404.19,276.28 406.2,276.28 406.58,276.66 406.58,280.72 406.07,281.23 404.03,281.23
S7_VDD18_D on TOP: 516.2,236.52 516.2,245.82 515.13,246.89 462.32,246.89 461.05,245.62 461.05,236.88 462.93,235 514.67,235
N25018635 on BOTTOM: 271.14,206.43 272.99,206.43 273.17,206.6 273.17,209.4 272.79,209.78 270.32,209.78 269.99,209.45 269.99,208.23 270.93,207.29 270.93,206.63
N25019559 on BOTTOM: 293.83,223.29 294.99,223.29 295.32,222.96 298.67,222.96 298.81,222.82 298.81,221.72 298.63,221.54 293.98,221.54 293.52,222 293.52,222.98
N25019667 on BOTTOM: 291.75,230.49 291.33,230.07 291.33,227.49 292.37,226.46 292.37,224.59 292.85,224.1 295.78,224.1 296.16,223.73 299.33,223.73 299.67,224.06 299.67,229.83 299.01,230.49
N25019726 on TOP: 288.41,232.89 288.41,217.6 288.79,217.22 292.8,217.22 293.56,217.98 293.56,226.75 293.82,227 295.72,227 296.23,227.51 296.23,232.97 295.6,233.6 289.12,233.6
N25019871 on BOTTOM: 267.38,206.22 267.38,198.09 268.09,197.38 270.48,197.38 271.8,198.71 271.8,203.46 273.02,204.67 273.02,205.61 272.96,205.66 270.82,205.66 270.18,206.3 267.45,206.3
N25019943 on TOP: 263.8,214.63 263.8,198.01 264.71,197.09 270.1,197.09 271.43,198.42 271.43,203.81 272.59,204.97 272.59,214.92 270.13,217.38 266.55,217.38
N25095240 on BOTTOM: 284.01,223.29 285.17,223.29 285.5,222.96 288.85,222.96 288.99,222.82 288.99,221.72 288.81,221.54 284.17,221.54 283.71,222 283.71,222.98
N25095242 on BOTTOM: 278.71,230.49 278.71,230.48 278.32,230.1 278.32,228.04 278.71,227.66 279.72,227.66 280.03,227.35 280.03,224.56 280.48,224.1 285.97,224.1 286.34,223.73 289.72,223.73 290.1,224.1 290.1,226.94 289.7,227.33 286.88,227.33 286.61,227.6 286.61,229.97 286.1,230.49
N25095276 on TOP: 275.91,233.6 282.26,233.6 282.9,232.97 282.9,217.47 282.64,217.22 280.74,217.22 279.64,218.31 279.64,219.46 277.44,221.67 276.67,221.67 275.4,222.94 275.4,233.1
N27444901 on BOTTOM: 311.14,206.43 312.99,206.43 313.17,206.6 313.17,209.4 312.79,209.78 310.32,209.78 309.99,209.45 309.99,208.23 310.93,207.29 310.93,206.63
N27444931 on BOTTOM: 333.83,223.29 334.99,223.29 335.32,222.96 338.67,222.96 338.81,222.82 338.81,221.72 338.63,221.54 333.98,221.54 333.52,222 333.52,222.98
N27444932 on BOTTOM: 331.75,230.49 331.33,230.07 331.33,227.49 332.37,226.46 332.37,224.59 332.85,224.1 335.78,224.1 336.16,223.73 339.33,223.73 339.67,224.06 339.67,229.83 339.01,230.49
N27444947 on TOP: 328.41,232.89 328.41,217.6 328.79,217.22 332.8,217.22 333.56,217.98 333.56,226.75 333.82,227 335.72,227 336.23,227.51 336.23,232.97 335.6,233.6 329.12,233.6
N27444970 on BOTTOM: 307.38,206.22 307.38,198.09 308.09,197.38 310.48,197.38 311.8,198.71 311.8,203.46 313.02,204.67 313.02,205.61 312.96,205.66 310.82,205.66 310.18,206.3 307.45,206.3
N27444986 on TOP: 303.8,214.63 303.8,198.01 304.71,197.09 310.1,197.09 311.43,198.42 311.43,203.81 312.59,204.97 312.59,214.92 310.13,217.38 306.55,217.38
N27445101 on BOTTOM: 324.01,223.29 325.17,223.29 325.5,222.96 328.85,222.96 328.99,222.82 328.99,221.72 328.81,221.54 324.16,221.54 323.71,222 323.71,222.98
N27445102 on BOTTOM: 318.7,230.49 318.7,230.48 318.32,230.1 318.32,228.04 318.7,227.66 319.72,227.66 320.03,227.35 320.03,224.56 320.48,224.1 325.97,224.1 326.34,223.73 329.72,223.73 330.1,224.1 330.1,226.94 329.7,227.33 326.88,227.33 326.61,227.6 326.61,229.97 326.1,230.49
N27445115 on TOP: 315.91,233.6 322.26,233.6 322.9,232.97 322.9,217.47 322.64,217.22 320.74,217.22 319.64,218.31 319.64,219.46 317.43,221.67 316.67,221.67 315.4,222.94 315.4,233.1
N27453831 on BOTTOM: 351.14,206.43 352.99,206.43 353.17,206.6 353.17,209.4 352.79,209.78 350.32,209.78 349.99,209.45 349.99,208.23 350.93,207.29 350.93,206.63
N27453861 on BOTTOM: 373.83,223.29 374.99,223.29 375.32,222.96 378.67,222.96 378.81,222.82 378.81,221.72 378.63,221.54 373.98,221.54 373.52,222 373.52,222.98
N27453862 on BOTTOM: 371.75,230.49 371.33,230.07 371.33,227.49 372.37,226.46 372.37,224.59 372.85,224.1 375.78,224.1 376.16,223.73 379.33,223.73 379.67,224.06 379.67,229.83 379.01,230.49
N27453877 on TOP: 368.41,232.89 368.41,217.6 368.79,217.22 372.8,217.22 373.56,217.98 373.56,226.75 373.82,227 375.72,227 376.23,227.51 376.23,232.97 375.6,233.6 369.12,233.6
N27453900 on BOTTOM: 347.38,206.22 347.38,198.09 348.09,197.38 350.48,197.38 351.8,198.71 351.8,203.46 353.02,204.67 353.02,205.61 352.96,205.66 350.82,205.66 350.18,206.3 347.45,206.3
N27453916 on TOP: 343.8,214.63 343.8,198.01 344.71,197.09 350.1,197.09 351.43,198.42 351.43,203.81 352.59,204.97 352.59,214.92 350.13,217.38 346.55,217.38
N27454031 on BOTTOM: 364.01,223.29 365.17,223.29 365.5,222.96 368.85,222.96 368.99,222.82 368.99,221.72 368.81,221.54 364.16,221.54 363.71,222 363.71,222.98
N27454032 on BOTTOM: 358.7,230.49 358.7,230.48 358.32,230.1 358.32,228.04 358.7,227.66 359.72,227.66 360.03,227.35 360.03,224.56 360.48,224.1 365.97,224.1 366.34,223.73 369.72,223.73 370.1,224.1 370.1,226.94 369.7,227.33 366.88,227.33 366.61,227.6 366.61,229.97 366.1,230.49
N27454045 on TOP: 355.91,233.6 362.26,233.6 362.9,232.97 362.9,217.47 362.64,217.22 360.74,217.22 359.64,218.31 359.64,219.46 357.43,221.67 356.67,221.67 355.4,222.94 355.4,233.1
N27462760 on BOTTOM: 391.14,206.43 392.99,206.43 393.17,206.6 393.17,209.4 392.79,209.78 390.32,209.78 389.99,209.45 389.99,208.23 390.93,207.29 390.93,206.63
N27462790 on BOTTOM: 413.83,223.29 414.99,223.29 415.32,222.96 418.67,222.96 418.81,222.82 418.81,221.72 418.63,221.54 413.98,221.54 413.52,222 413.52,222.98
N27462791 on BOTTOM: 411.75,230.49 411.33,230.07 411.33,227.49 412.37,226.46 412.37,224.59 412.85,224.1 415.78,224.1 416.16,223.73 419.33,223.73 419.67,224.06 419.67,229.83 419.01,230.49
N27462806 on TOP: 408.41,232.89 408.41,217.6 408.79,217.22 412.8,217.22 413.56,217.98 413.56,226.75 413.82,227 415.72,227 416.23,227.51 416.23,232.97 415.6,233.6 409.12,233.6
N27462829 on BOTTOM: 387.38,206.22 387.38,198.09 388.09,197.38 390.48,197.38 391.8,198.71 391.8,203.46 393.02,204.67 393.02,205.61 392.96,205.66 390.82,205.66 390.18,206.3 387.45,206.3
N27462845 on TOP: 383.8,214.63 383.8,198.01 384.71,197.09 390.1,197.09 391.43,198.42 391.43,203.81 392.59,204.97 392.59,214.92 390.13,217.38 386.55,217.38
N27462960 on BOTTOM: 404.01,223.29 405.17,223.29 405.5,222.96 408.85,222.96 408.99,222.82 408.99,221.72 408.81,221.54 404.16,221.54 403.71,222 403.71,222.98
N27462961 on BOTTOM: 398.7,230.49 398.7,230.48 398.32,230.1 398.32,228.04 398.7,227.66 399.72,227.66 400.03,227.35 400.03,224.56 400.48,224.1 405.97,224.1 406.34,223.73 409.72,223.73 410.1,224.1 410.1,226.94 409.7,227.33 406.88,227.33 406.61,227.6 406.61,229.97 406.1,230.49
N27462974 on TOP: 395.91,233.6 402.26,233.6 402.9,232.97 402.9,217.47 402.64,217.22 400.74,217.22 399.64,218.31 399.64,219.46 397.43,221.67 396.67,221.67 395.4,222.94 395.4,233.1
N27471689 on BOTTOM: 271.14,266.42 272.99,266.42 273.17,266.6 273.17,269.4 272.79,269.78 270.32,269.78 269.99,269.45 269.99,268.23 270.93,267.29 270.93,266.63
N27471719 on BOTTOM: 293.83,283.29 294.99,283.29 295.32,282.96 298.67,282.96 298.81,282.82 298.81,281.72 298.63,281.54 293.98,281.54 293.52,282 293.52,282.98
N27471720 on BOTTOM: 291.75,290.49 291.33,290.07 291.33,287.49 292.37,286.46 292.37,284.58 292.85,284.1 295.78,284.1 296.16,283.73 299.33,283.73 299.67,284.06 299.67,289.83 299.01,290.49
N27471735 on TOP: 288.41,292.89 288.41,277.6 288.79,277.22 292.8,277.22 293.56,277.98 293.56,286.74 293.82,287 295.72,287 296.23,287.51 296.23,292.97 295.6,293.6 289.12,293.6
N27471758 on BOTTOM: 267.38,266.22 267.38,258.09 268.09,257.38 270.48,257.38 271.8,258.71 271.8,263.46 273.02,264.67 273.02,265.61 272.96,265.66 270.82,265.66 270.18,266.3 267.45,266.3
N27471774 on TOP: 263.8,274.63 263.8,258.01 264.71,257.09 270.1,257.09 271.43,258.42 271.43,263.81 272.59,264.97 272.59,274.92 270.13,277.38 266.55,277.38
N27471889 on BOTTOM: 284.01,283.29 285.17,283.29 285.5,282.96 288.85,282.96 288.99,282.82 288.99,281.72 288.81,281.54 284.17,281.54 283.71,282 283.71,282.98
N27471890 on BOTTOM: 278.71,290.49 278.71,290.48 278.32,290.1 278.32,288.04 278.71,287.66 279.72,287.66 280.03,287.35 280.03,284.56 280.48,284.1 285.97,284.1 286.34,283.73 289.72,283.73 290.1,284.1 290.1,286.94 289.7,287.33 286.88,287.33 286.61,287.6 286.61,289.97 286.1,290.49
N27471903 on TOP: 275.91,293.6 282.26,293.6 282.9,292.97 282.9,277.47 282.64,277.22 280.74,277.22 279.64,278.31 279.64,279.46 277.44,281.66 276.67,281.66 275.4,282.93 275.4,293.09
N27480619 on BOTTOM: 311.14,266.42 312.99,266.42 313.17,266.6 313.17,269.4 312.79,269.78 310.32,269.78 309.99,269.45 309.99,268.23 310.93,267.29 310.93,266.63
N27480649 on BOTTOM: 333.83,283.29 334.99,283.29 335.32,282.96 338.67,282.96 338.81,282.82 338.81,281.72 338.63,281.54 333.98,281.54 333.52,282 333.52,282.98
N27480650 on BOTTOM: 331.75,290.49 331.33,290.07 331.33,287.49 332.37,286.46 332.37,284.58 332.85,284.1 335.78,284.1 336.16,283.73 339.33,283.73 339.67,284.06 339.67,289.83 339.01,290.49
N27480665 on TOP: 328.41,292.89 328.41,277.6 328.79,277.22 332.8,277.22 333.56,277.98 333.56,286.74 333.82,287 335.72,287 336.23,287.51 336.23,292.97 335.6,293.6 329.12,293.6
N27480688 on BOTTOM: 307.38,266.22 307.38,258.09 308.09,257.38 310.48,257.38 311.8,258.71 311.8,263.46 313.02,264.67 313.02,265.61 312.96,265.66 310.82,265.66 310.18,266.3 307.45,266.3
N27480704 on TOP: 303.8,274.63 303.8,258.01 304.71,257.09 310.1,257.09 311.43,258.42 311.43,263.81 312.59,264.97 312.59,274.92 310.13,277.38 306.55,277.38
N27480819 on BOTTOM: 324.01,283.29 325.17,283.29 325.5,282.96 328.85,282.96 328.99,282.82 328.99,281.72 328.81,281.54 324.16,281.54 323.71,282 323.71,282.98
N27480820 on BOTTOM: 318.7,290.49 318.7,290.48 318.32,290.1 318.32,288.04 318.7,287.66 319.72,287.66 320.03,287.35 320.03,284.56 320.48,284.1 325.97,284.1 326.34,283.73 329.72,283.73 330.1,284.1 330.1,286.94 329.7,287.33 326.88,287.33 326.61,287.6 326.61,289.97 326.1,290.49
N27480833 on TOP: 315.91,293.6 322.26,293.6 322.9,292.97 322.9,277.47 322.64,277.22 320.74,277.22 319.64,278.31 319.64,279.46 317.43,281.66 316.67,281.66 315.4,282.93 315.4,293.09
N27489549 on BOTTOM: 351.14,266.42 352.99,266.42 353.17,266.6 353.17,269.4 352.79,269.78 350.32,269.78 349.99,269.45 349.99,268.23 350.93,267.29 350.93,266.63
N27489579 on BOTTOM: 373.83,283.29 374.99,283.29 375.32,282.96 378.67,282.96 378.81,282.82 378.81,281.72 378.63,281.54 373.98,281.54 373.52,282 373.52,282.98
N27489580 on BOTTOM: 371.75,290.49 371.33,290.07 371.33,287.49 372.37,286.46 372.37,284.58 372.85,284.1 375.78,284.1 376.16,283.73 379.33,283.73 379.67,284.06 379.67,289.83 379.01,290.49
N27489595 on TOP: 368.41,292.89 368.41,277.6 368.79,277.22 372.8,277.22 373.56,277.98 373.56,286.74 373.82,287 375.72,287 376.23,287.51 376.23,292.97 375.6,293.6 369.12,293.6
