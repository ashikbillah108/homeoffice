# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
SW_DIPX8P_2P54_MM_V2
  round 1.626 hole 1.041: 1(-8.89,3.81) 2(-6.35,3.81) 3(-3.81,3.81) 4(-1.27,3.81) 5(1.27,3.81) 6(3.81,3.81) 7(6.35,3.81) 8(8.89,3.81) 9(8.89,-3.81) 10(-8.89,-3.81)
TP_060_040
  round 1.524 hole 1.016: 1(0,0)
TQFN5X5_20P_0P65MM_G_V2
  rect 0.991x0.356 smd: 1(-2.34,1.3) 2(-2.34,0.65) 3(-2.34,0) 4(-2.34,-0.65) 5(-2.34,-1.3) 11(2.34,-1.3) 12(2.34,-0.65) 13(2.34,0) 14(2.34,0.65) 15(2.34,1.3)
  rect 0.356x0.991 smd: 6(-1.3,-2.34) 7(-0.65,-2.34) 8(0,-2.34) 9(0.65,-2.34) 10(1.3,-2.34) 16(1.3,2.34) 17(0.65,2.34) 18(0,2.34) 19(-0.65,2.34) 20(-1.3,2.34)
  rect 3.15x3.15 smd: EP(0,0)
VRD_3296W_BOURNS_SKPIN
  rect 1.524x1.524 hole 1.041: 1(0,-2.54)
  round 1.524 hole 1.041: 2(0,0) 3(0,2.54)
XTAL_2X1P6MM_4P_0P8MM
  rect 0.889x0.787 smd: 1(-0.7,-0.55) 2(0.7,-0.55) 3(0.7,0.55) 4(-0.7,0.55)

## Nets
AGND: BD34.2 BD35.2 C1.1 C3.2 C4.1 C5.2 C8.2 C9.1 C10.2 C11.1 C12.2 C15.2 C16.1 C19.2 D1.2(CATHODE_D2) D2.2(CATHODE_D2) D3.2(CATHODE_D2) SMP1.G2 SMP1.G3 SMP1.G4 SMP1.G5 SMP1.G6 SMP1.G7 SMP1.G8 SMP1.G9 SMP2.G2 SMP2.G3 SMP2.G4 SMP2.G5 SMP2.G6 SMP2.G7 SMP2.G8 SMP2.G9 SMP3.G2 SMP3.G3 SMP3.G4 SMP3.G5 SMP3.G6 SMP3.G7 SMP3.G8 SMP3.G9 U1.2(GND) U2.2(GND) UNK1BD34.2 UNK1BD35.2 UNK1C1.1 UNK1C3.2 UNK1C4.1 UNK1C5.2 UNK1C8.2 UNK1C9.1 UNK1C10.2 UNK1C11.1 UNK1C12.2 UNK1C15.2 UNK1C16.1 UNK1C19.2 UNK1D1.2 UNK1D2.2 UNK1D3.2 UNK1SMP1.G2 UNK1SMP1.G3 UNK1SMP1.G4 UNK1SMP1.G5 UNK1SMP1.G6 UNK1SMP1.G7 UNK1SMP1.G8 UNK1SMP1.G9 UNK1SMP2.G2 UNK1SMP2.G3 UNK1SMP2.G4 UNK1SMP2.G5 UNK1SMP2.G6 UNK1SMP2.G7 UNK1SMP2.G8 UNK1SMP2.G9 UNK1SMP3.G2 UNK1SMP3.G3 UNK1SMP3.G4 UNK1SMP3.G5 UNK1SMP3.G6 UNK1SMP3.G7 UNK1SMP3.G8 UNK1SMP3.G9 UNK1U1.2 UNK1U2.2 UNK2BD34.2 UNK2BD35.2 UNK2C1.1 UNK2C3.2 UNK2C4.1 UNK2C5.2 UNK2C8.2 UNK2C9.1 UNK2C10.2 UNK2C11.1 UNK2C12.2 UNK2C15.2 UNK2C16.1 UNK2C19.2 UNK2D1.2 UNK2D2.2 UNK2D3.2 UNK2SMP1.G2 UNK2SMP1.G3 UNK2SMP1.G4 UNK2SMP1.G5 UNK2SMP1.G6 UNK2SMP1.G7 UNK2SMP1.G8 UNK2SMP1.G9 UNK2SMP2.G2 UNK2SMP2.G3 UNK2SMP2.G4 UNK2SMP2.G5 UNK2SMP2.G6 UNK2SMP2.G7 UNK2SMP2.G8 UNK2SMP2.G9 UNK2SMP3.G2 UNK2SMP3.G3 UNK2SMP3.G4 UNK2SMP3.G5 UNK2SMP3.G6 UNK2SMP3.G7 UNK2SMP3.G8 UNK2SMP3.G9 UNK2U1.2 UNK2U2.2 UNK3BD34.2 UNK3BD35.2 UNK3C1.1 UNK3C3.2 UNK3C4.1 UNK3C5.2 UNK3C8.2 UNK3C9.1 UNK3C10.2 UNK3C11.1 UNK3C12.2 UNK3C15.2 UNK3C16.1 UNK3C19.2 UNK3D1.2 UNK3D2.2 UNK3D3.2 UNK3SMP1.G2 UNK3SMP1.G3 UNK3SMP1.G4 UNK3SMP1.G5 UNK3SMP1.G6 UNK3SMP1.G7 UNK3SMP1.G8 UNK3SMP1.G9 UNK3SMP2.G2 UNK3SMP2.G3 UNK3SMP2.G4 UNK3SMP2.G5 UNK3SMP2.G6 UNK3SMP2.G7 UNK3SMP2.G8 UNK3SMP2.G9 UNK3SMP3.G2 UNK3SMP3.G3 UNK3SMP3.G4 UNK3SMP3.G5 UNK3SMP3.G6 UNK3SMP3.G7 UNK3SMP3.G8 UNK3SMP3.G9 UNK3U1.2 UNK3U2.2 UNK4BD34.2 UNK4BD35.2 UNK4C1.1 UNK4C3.2 UNK4C4.1 UNK4C5.2 UNK4C8.2 UNK4C9.1 UNK4C10.2 UNK4C11.1 UNK4C12.2 UNK4C15.2 UNK4C16.1 UNK4C19.2 UNK4D1.2 UNK4D2.2 UNK4D3.2 UNK4SMP1.G2 UNK4SMP1.G3 UNK4SMP1.G4 UNK4SMP1.G5 UNK4SMP1.G6 UNK4SMP1.G7 UNK4SMP1.G8 UNK4SMP1.G9 UNK4SMP2.G2 UNK4SMP2.G3 UNK4SMP2.G4 UNK4SMP2.G5 UNK4SMP2.G6 UNK4SMP2.G7 UNK4SMP2.G8 UNK4SMP2.G9 UNK4SMP3.G2 UNK4SMP3.G3 UNK4SMP3.G4 UNK4SMP3.G5 UNK4SMP3.G6 UNK4SMP3.G7 UNK4SMP3.G8 UNK4SMP3.G9 UNK4U1.2 UNK4U2.2 UNK5BD34.2 UNK5BD35.2 UNK5C1.1 UNK5C3.2 UNK5C4.1 UNK5C5.2 UNK5C8.2 UNK5C9.1 UNK5C10.2 UNK5C11.1 UNK5C12.2 UNK5C15.2 UNK5C16.1 UNK5C19.2 UNK5D1.2 UNK5D2.2 UNK5D3.2 UNK5SMP1.G2 UNK5SMP1.G3 UNK5SMP1.G4 UNK5SMP1.G5 UNK5SMP1.G6 UNK5SMP1.G7 UNK5SMP1.G8 UNK5SMP1.G9 UNK5SMP2.G2 UNK5SMP2.G3 UNK5SMP2.G4 UNK5SMP2.G5 UNK5SMP2.G6 UNK5SMP2.G7 UNK5SMP2.G8 UNK5SMP2.G9 UNK5SMP3.G2 UNK5SMP3.G3 UNK5SMP3.G4 UNK5SMP3.G5 UNK5SMP3.G6 UNK5SMP3.G7 UNK5SMP3.G8 UNK5SMP3.G9 UNK5U1.2 UNK5U2.2 UNK6BD34.2 UNK6BD35.2 UNK6C1.1 UNK6C3.2 UNK6C4.1 UNK6C5.2 UNK6C8.2 UNK6C9.1 UNK6C10.2 UNK6C11.1 UNK6C12.2 UNK6C15.2 UNK6C16.1 UNK6C19.2 UNK6D1.2 UNK6D2.2 UNK6D3.2 UNK6SMP1.G2 UNK6SMP1.G3 UNK6SMP1.G4 UNK6SMP1.G5 UNK6SMP1.G6 UNK6SMP1.G7 UNK6SMP1.G8 UNK6SMP1.G9 UNK6SMP2.G2 UNK6SMP2.G3 UNK6SMP2.G4 UNK6SMP2.G5 UNK6SMP2.G6 UNK6SMP2.G7 UNK6SMP2.G8 UNK6SMP2.G9 UNK6SMP3.G2 UNK6SMP3.G3 UNK6SMP3.G4 UNK6SMP3.G5 UNK6SMP3.G6 UNK6SMP3.G7 UNK6SMP3.G8 UNK6SMP3.G9 UNK6U1.2 UNK6U2.2 UNK7BD34.2 UNK7BD35.2 UNK7C1.1 UNK7C3.2 UNK7C4.1 UNK7C5.2 UNK7C8.2 UNK7C9.1 UNK7C10.2 UNK7C11.1 UNK7C12.2 UNK7C15.2 UNK7C16.1 UNK7C19.2 UNK7D1.2 UNK7D2.2 UNK7D3.2 UNK7SMP1.G2 UNK7SMP1.G3 UNK7SMP1.G4 UNK7SMP1.G5 UNK7SMP1.G6 UNK7SMP1.G7 UNK7SMP1.G8 UNK7SMP1.G9 UNK7SMP2.G2 UNK7SMP2.G3 UNK7SMP2.G4 UNK7SMP2.G5 UNK7SMP2.G6 UNK7SMP2.G7 UNK7SMP2.G8 UNK7SMP2.G9 UNK7SMP3.G2 UNK7SMP3.G3 UNK7SMP3.G4 UNK7SMP3.G5 UNK7SMP3.G6 UNK7SMP3.G7 UNK7SMP3.G8 UNK7SMP3.G9 UNK7U1.2 UNK7U2.2
DGND: BD34.1 BD35.1 BD42.2 BD43.2 BD44.2 BD48.2 BD50.2 BD51.2 BD52.2 BD56.2 BD57.1 BD58.1 BD59.1 BD60.1 BD61.1 BD62.1 BD63.1 BD64.1 BD65.1 BD66.1 BD67.1 BD68.1 BD69.2 BD70.2 BD71.2 BD72.2 C17.1 C18.1 C20.2 C21.2 C22.2 C23.1 C24.2 C25.1 C38.1 C39.2 C40.1 C41.2 C44.2 C45.2 C46.2 C47.2 C48.2 C49.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C78.2 C79.2 C83.2 C84.2 C85.2 C88.2 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C96.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.1 C116.2 C117.2 C118.2 C119.2 C120.2 C121.2 C122.2 C123.2 C124.2 C125.2 C126.2 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C133.2 C134.2 C135.2 C136.2 C137.2 C138.2 C139.2 C140.2 C141.2 C142.2 C143.1 C144.1 C145.1 C146.1 C147.1 C148.1 C149.1 C150.1 C152.2 C153.2 CB631.2 CB632.2 CB633.2 CB634.2 CB635.2 CB636.2 CB637.2 CB638.2 CB639.2 CB640.2 CB641.2 CB642.2 CB643.2 CB647.2 CB648.2 CB649.2 CB650.1 CB652.2 CB653.1 CB654.2 CB655.2 CB656.2 CB657.1 CB659.2 CB661.2 CB662.2 CB663.2 CB664.2 CB665.1 CB667.2 CB668.1 CB669.2 CB670.2 CB671.2 CB672.1 CB674.2 CB676.2 CB677.2 CB678.2 CB679.2 CB695.1 CB697.2 CB698.1 CB699.2 CB700.2 CB701.2 CB702.1 CB704.2 CB706.2 CB707.2 CB708.2 CB709.2 CT1.2 CT14.2 CT15.2 CT16.2 CT17.2 CT18.2 CT19.2 CT20.2 CT21.2 HOLE_CABLE3.G1 HOLE_CABLE3.G2 HOLE_CABLE3.G3 HOLE_CABLE3.G4 HOLE_CABLE3.G5 HOLE_CABLE3.G6 HOLE_CABLE3.G7 HOLE_CABLE3.G8 HOLE_CABLE3.G9 HOLE_CABLE3.G10 HOLE_CABLE3.G11 HOLE_CABLE3.G12 HOLE_CABLE3.G13 HOLE_CABLE3.G14 HOLE_CABLE3.G15 HOLE_CABLE3.G16 HOLE_CABLE3.G17 HOLE_CABLE3.G18 HOLE_CABLE3.G19 HOLE_CABLE3.G20 HOLE_CABLE3.G21 HOLE_CABLE3.G22 HOLE_CABLE3.G23 HOLE_CABLE3.G24 HOLE_CABLE3.G25 HOLE_CABLE3.G26 HOLE_CABLE3.G27 HOLE_CABLE3.G28 HOLE_CABLE3.G29 HOLE_CABLE3.G30 HOLE_CABLE3.G31 HOLE_CABLE3.G32 HOLE_CABLE3.G33 HOLE_CABLE3.G34 HOLE_CABLE3.G35 HOLE_CABLE3.G36 HOLE_CABLE3.G37 HOLE_CABLE3.G38 HOLE_CABLE3.G39 HOLE_CABLE3.G40 HOLE_CABLE3.G41 HOLE_CABLE3.G42 HOLE_CABLE3.G43 HOLE_CABLE3.G44 HOLE_CABLE3.G45 HOLE_CABLE3.G46 HOLE_CABLE3.G47 HOLE_CABLE3.G48 HOLE_CABLE3.G49 HOLE_CABLE3.G50 HOLE_CABLE3.G51 HOLE_CABLE3.G52 HOLE_CABLE3.G53 HOLE_CABLE3.G54 HOLE_CABLE3.G55 HOLE_CABLE3.G56 HOLE_CABLE3.G57 HOLE_CABLE3.G58 HOLE_CABLE3.G59 HOLE_CABLE3.G60 HOLE_CABLE3.G61 HOLE_CABLE3.G62 HOLE_CABLE3.G63 HOLE_CABLE3.G64 HOLE_CABLE3.G65 HOLE_CABLE3.G66 HOLE_CABLE3.G67 HOLE_CABLE3.G68 HOLE_CABLE4.G1 HOLE_CABLE4.G2 HOLE_CABLE4.G3 HOLE_CABLE4.G4 HOLE_CABLE4.G5 HOLE_CABLE4.G6 HOLE_CABLE4.G7 HOLE_CABLE4.G8 HOLE_CABLE4.G9 HOLE_CABLE4.G10 HOLE_CABLE4.G11 HOLE_CABLE4.G12 HOLE_CABLE4.G13 HOLE_CABLE4.G14 HOLE_CABLE4.G15 HOLE_CABLE4.G16 HOLE_CABLE4.G17 HOLE_CABLE4.G18 HOLE_CABLE4.G19 HOLE_CABLE4.G20 HOLE_CABLE4.G21 HOLE_CABLE4.G22 HOLE_CABLE4.G23 HOLE_CABLE4.G24 HOLE_CABLE4.G25 HOLE_CABLE4.G26 HOLE_CABLE4.G27 HOLE_CABLE4.G28 HOLE_CABLE4.G29 HOLE_CABLE4.G30 HOLE_CABLE4.G31 HOLE_CABLE4.G32 HOLE_CABLE4.G33 HOLE_CABLE4.G34 HOLE_CABLE4.G35 HOLE_CABLE4.G36 HOLE_CABLE4.G37 HOLE_CABLE4.G38 HOLE_CABLE4.G39 HOLE_CABLE4.G40 HOLE_CABLE4.G41 HOLE_CABLE4.G42 HOLE_CABLE4.G43 HOLE_CABLE4.G44 HOLE_CABLE4.G45 HOLE_CABLE4.G46 HOLE_CABLE4.G47 HOLE_CABLE4.G48 HOLE_CABLE4.G49 HOLE_CABLE4.G50 HOLE_CABLE4.G51 HOLE_CABLE4.G52 HOLE_CABLE4.G53 HOLE_CABLE4.G54 HOLE_CABLE4.G55 HOLE_CABLE4.G56 HOLE_CABLE4.G57 HOLE_CABLE4.G58 HOLE_CABLE4.G59 HOLE_CABLE4.G60 HOLE_CABLE4.G61 HOLE_CABLE4.G62 HOLE_CABLE4.G63 HOLE_CABLE4.G64 HOLE_CABLE4.G65 HOLE_CABLE4.G66 HOLE_CABLE4.G67 HOLE_CABLE4.G68 J1.2 J2.2 J3.2 J4.8 JB1.3(GND) JB1.5(GND(1)) JB1.7(GND(2)) JB1.13(GND(3)) JB1.15(GND(4)) JB1.16(GND(5)) JB1.17(GND(6)) LDB19.2(B) LDB20.2(B) LDB22.2(B) P2.A1(1) P2.A3(3) P2.A5(5) P2.A7(7) P2.A9(9) P2.A11(11) P2.B2(2) P2.B4(4) P2.B6(6) P2.B8(8) P2.B10(10) P2.B12(12) P2.C1(1) P2.C3(3) P2.C5(5) P2.C7(7) P2.C9(9) P2.C11(11) P2.D2(2) P2.D4(4) P2.D6(6) P2.D8(8) P2.D10(10) P2.D12(12) P2.E1(1) P2.E3(3) P2.E5(5) P2.E7(7) P2.E9(9) P2.E11(11) P2.F2(2) P2.F4(4) P2.F6(6) P2.F8(8) P2.F10(10) P2.F12(12) P2.G1(1) P2.G3(3) P2.G5(5) P2.G7(7) P2.G9(9) P2.G11(11) P2.H2(2) P2.H4(4) P2.H6(6) P2.H8(8) P2.H10(10) P2.H12(12) P2.I1(1) P2.I3(3) P2.I5(5) P2.I7(7) P2.I9(9) P2.I11(11) P2.J2(2) P2.J4(4) P2.J6(6) P2.J8(8) P2.J10(10) P2.J12(12) P2.K1(1) P2.K3(3) P2.K5(5) P2.K7(7) P2.K9(9) P2.K11(11) P2.L2(2) P2.L4(4) P2.L6(6) P2.L8(8) P2.L10(10) P2.L12(12) P2.M1(1) P2.M3(3) P2.M5(5) P2.M7(7) P2.M9(9) P2.M11(11) P2.N1(1) P2.N3(3) P2.N5(5) P2.N7(7) P2.N9(9) P2.N11(11) P2.O2(2) P2.O4(4) P2.O6(6) P2.O8(8) P2.O10(10) P2.O12(12) P2.P1(1) P2.P3(3) P2.P5(5) P2.P7(7) P2.P9(9) P2.P11(11) P2.Q2(2) P2.Q4(4) P2.Q6(6) P2.Q8(8) P2.Q10(10) P2.Q12(12) P2.R1(1) P2.R3(3) P2.R5(5) P2.R7(7) P2.R9(9) P2.R11(11) P2.S2(2) P2.S4(4) P2.S6(6) P2.S8(8) P2.S10(10) P2.S12(12) P2.T1(1) P2.T3(3) P2.T5(5) P2.T7(7) P2.T9(9) P2.T11(11) P2.U2(2) P2.U4(4) P2.U6(6) P2.U8(8) P2.U10(10) P2.U12(12) P2.V1(1) P2.V3(3) P2.V5(5) P2.V7(7) P2.V9(9) P2.V11(11) P2.W2(2) P2.W4(4) P2.W6(6) P2.W8(8) P2.W10(10) P2.W12(12) P2.X1(1) P2.X3(3) P2.X5(5) P2.X7(7) P2.X9(9) P2.X11(11) P2.Y2(2) P2.Y4(4) P2.Y6(6) P2.Y8(8) P2.Y10(10) P2.Y12(12) P2.Z1(1) P2.Z3(3) P2.Z5(5) P2.Z7(7) P2.Z9(9) P2.Z11(11) P5.A1(1) P5.A3(3) P5.A5(5) P5.A7(7) P5.A9(9) P5.A11(11) P5.B2(2) P5.B4(4) P5.B6(6) P5.B8(8) P5.B10(10) P5.B12(12) P5.C1(1) P5.C3(3) P5.C5(5) P5.C7(7) P5.C9(9) P5.C11(11) P5.D2(2) P5.D4(4) P5.D6(6) P5.D8(8) P5.D10(10) P5.D12(12) P5.E1(1) P5.E3(3) P5.E5(5) P5.E7(7) P5.E9(9) P5.E11(11) P5.F2(2) P5.F4(4) P5.F6(6) P5.F8(8) P5.F10(10) P5.F12(12) P5.G1(1) P5.G3(3) P5.G5(5) P5.G7(7) P5.G9(9) P5.G11(11) P5.H2(2) P5.H4(4) P5.H6(6) P5.H8(8) P5.H10(10) P5.H12(12) P5.I1(1) P5.I3(3) P5.I5(5) P5.I7(7) P5.I9(9) P5.I11(11) P5.J2(2) P5.J4(4) P5.J6(6) P5.J8(8) P5.J10(10) P5.J12(12) P5.K1(1) P5.K3(3) P5.K5(5) P5.K7(7) P5.K9(9) P5.K11(11) P5.L2(2) P5.L4(4) P5.L6(6) P5.L8(8) P5.L10(10) P5.L12(12) P5.M1(1) P5.M3(3) P5.M5(5) P5.M7(7) P5.M9(9) P5.M11(11) P5.N1(1) P5.N3(3) P5.N5(5) P5.N7(7) P5.N9(9) P5.N11(11) P5.O2(2) P5.O4(4) P5.O6(6) P5.O8(8) P5.O10(10) P5.O12(12) P5.P1(1) P5.P3(3) P5.P5(5) P5.P7(7) P5.P9(9) P5.P11(11) P5.Q2(2) P5.Q4(4) P5.Q6(6) P5.Q8(8) P5.Q10(10) P5.Q12(12) P5.R1(1) P5.R3(3) P5.R5(5) P5.R7(7) P5.R9(9) P5.R11(11) P5.S2(2) P5.S4(4) P5.S6(6) P5.S8(8) P5.S10(10) P5.S12(12) P5.T1(1) P5.T3(3) P5.T5(5) P5.T7(7) P5.T9(9) P5.T11(11) P5.U2(2) P5.U4(4) P5.U6(6) P5.U8(8) P5.U10(10) P5.U12(12) P5.V1(1) P5.V3(3) P5.V5(5) P5.V7(7) P5.V9(9) P5.V11(11) P5.W2(2) P5.W4(4) P5.W6(6) P5.W8(8) P5.W10(10) P5.W12(12) P5.X1(1) P5.X3(3) P5.X5(5) P5.X7(7) P5.X9(9) P5.X11(11) P5.Y2(2) P5.Y4(4) P5.Y6(6) P5.Y8(8) P5.Y10(10) P5.Y12(12) P5.Z1(1) P5.Z3(3) P5.Z5(5) P5.Z7(7) P5.Z9(9) P5.Z11(11) P8.A1(1) P8.A3(3) P8.A5(5) P8.A7(7) P8.A9(9) P8.A11(11) P8.B2(2) P8.B4(4) P8.B6(6) P8.B8(8) P8.B10(10) P8.B12(12) P8.C1(1) P8.C3(3) P8.C5(5) P8.C7(7) P8.C9(9) P8.C11(11) P8.D2(2) P8.D4(4) P8.D6(6) P8.D8(8) P8.D10(10) P8.D12(12) P8.E1(1) P8.E3(3) P8.E5(5) P8.E7(7) P8.E9(9) P8.E11(11) P8.F2(2) P8.F4(4) P8.F6(6) P8.F8(8) P8.F10(10) P8.F12(12) P8.G1(1) P8.G3(3) P8.G5(5) P8.G7(7) P8.G9(9) P8.G11(11) P8.H2(2) P8.H4(4) P8.H6(6) P8.H8(8) P8.H10(10) P8.H12(12) P8.I1(1) P8.I3(3) P8.I5(5) P8.I7(7) P8.I9(9) P8.I11(11) P8.J2(2) P8.J4(4) P8.J6(6) P8.J8(8) P8.J10(10) P8.J12(12) P8.K1(1) P8.K3(3) P8.K5(5) P8.K7(7) P8.K9(9) P8.K11(11) P8.L2(2) P8.L4(4) P8.L6(6) P8.L8(8) P8.L10(10) P8.L12(12) P8.M1(1) P8.M3(3) P8.M5(5) P8.M7(7) P8.M9(9) P8.M11(11) P8.N1(1) P8.N3(3) P8.N5(5) P8.N7(7) P8.N9(9) P8.N11(11) P8.O2(2) P8.O4(4) P8.O6(6) P8.O8(8) P8.O10(10) P8.O12(12) P8.P1(1) P8.P3(3) P8.P5(5) P8.P7(7) P8.P9(9) P8.P11(11) P8.Q2(2) P8.Q4(4) P8.Q6(6) P8.Q8(8) P8.Q10(10) P8.Q12(12) P8.R1(1) P8.R3(3) P8.R5(5) P8.R7(7) P8.R9(9) P8.R11(11) P8.S2(2) P8.S4(4) P8.S6(6) P8.S8(8) P8.S10(10) P8.S12(12) P8.T1(1) P8.T3(3) P8.T5(5) P8.T7(7) P8.T9(9) P8.T11(11) P8.U2(2) P8.U4(4) P8.U6(6) P8.U8(8) P8.U10(10) P8.U12(12) P8.V1(1) P8.V3(3) P8.V5(5) P8.V7(7) P8.V9(9) P8.V11(11) P8.W2(2) P8.W4(4) P8.W6(6) P8.W8(8) P8.W10(10) P8.W12(12) P8.X1(1) P8.X3(3) P8.X5(5) P8.X7(7) P8.X9(9) P8.X11(11) P8.Y2(2) P8.Y4(4) P8.Y6(6) P8.Y8(8) P8.Y10(10) P8.Y12(12) P8.Z1(1) P8.Z3(3) P8.Z5(5) P8.Z7(7) P8.Z9(9) P8.Z11(11) P10.A1(1) P10.A3(3) P10.A5(5) P10.A7(7) P10.A9(9) P10.A11(11) P10.B2(2) P10.B4(4) P10.B6(6) P10.B8(8) P10.B10(10) P10.B12(12) P10.C1(1) P10.C3(3) P10.C5(5) P10.C7(7) P10.C9(9) P10.C11(11) P10.D2(2) P10.D4(4) P10.D6(6) P10.D8(8) P10.D10(10) P10.D12(12) P10.E1(1) P10.E3(3) P10.E5(5) P10.E7(7) P10.E9(9) P10.E11(11) P10.F2(2) P10.F4(4) P10.F6(6) P10.F8(8) P10.F10(10) P10.F12(12) P10.G1(1) P10.G3(3) P10.G5(5) P10.G7(7) P10.G9(9) P10.G11(11) P10.H2(2) P10.H4(4) P10.H6(6) P10.H8(8) P10.H10(10) P10.H12(12) P10.I1(1) P10.I3(3) P10.I5(5) P10.I7(7) P10.I9(9) P10.I11(11) P10.J2(2) P10.J4(4) P10.J6(6) P10.J8(8) P10.J10(10) P10.J12(12) P10.K1(1) P10.K3(3) P10.K5(5) P10.K7(7) P10.K9(9) P10.K11(11) P10.L2(2) P10.L4(4) P10.L6(6) P10.L8(8) P10.L10(10) P10.L12(12) P10.M1(1) P10.M3(3) P10.M5(5) P10.M7(7) P10.M9(9) P10.M11(11) P10.N1(1) P10.N3(3) P10.N5(5) P10.N7(7) P10.N9(9) P10.N11(11) P10.O2(2) P10.O4(4) P10.O6(6) P10.O8(8) P10.O10(10) P10.O12(12) P10.P1(1) P10.P3(3) P10.P5(5) P10.P7(7) P10.P9(9) P10.P11(11) P10.Q2(2) P10.Q4(4) P10.Q6(6) P10.Q8(8) P10.Q10(10) P10.Q12(12) P10.R1(1) P10.R3(3) P10.R5(5) P10.R7(7) P10.R9(9) P10.R11(11) P10.S2(2) P10.S4(4) P10.S6(6) P10.S8(8) P10.S10(10) P10.S12(12) P10.T1(1) P10.T3(3) P10.T5(5) P10.T7(7) P10.T9(9) P10.T11(11) P10.U2(2) P10.U4(4) P10.U6(6) P10.U8(8) P10.U10(10) P10.U12(12) P10.V1(1) P10.V3(3) P10.V5(5) P10.V7(7) P10.V9(9) P10.V11(11) P10.W2(2) P10.W4(4) P10.W6(6) P10.W8(8) P10.W10(10) P10.W12(12) P10.X1(1) P10.X3(3) P10.X5(5) P10.X7(7) P10.X9(9) P10.X11(11) P10.Y2(2) P10.Y4(4) P10.Y6(6) P10.Y8(8) P10.Y10(10) P10.Y12(12) P10.Z1(1) P10.Z3(3) P10.Z5(5) P10.Z7(7) P10.Z9(9) P10.Z11(11) R18.1 R22.2 R23.2 R25.2 R26.2 R33.1 R42.2 R43.2 R49.2 R51.2 R54.2 R62.2 R71.2 R72.2 R73.2 RB595.2 RB599.3 RB600.2 RB606.3 RB607.2 RB620.3 RB621.2 RB623.2 RB624.2 RB627.2 RB628.2 S0_GND1.1(TP) S0_GND2.1(TP) S0_GND3.1(TP) S0_GND4.1(TP) S1_GND1.1(TP) S1_GND2.1(TP) S1_GND3.1(TP) S1_GND4.1(TP) S2_GND1.1(TP) S2_GND2.1(TP) S2_GND3.1(TP) S2_GND4.1(TP) S3_GND1.1(TP) S3_GND2.1(TP) S3_GND3.1(TP) S3_GND4.1(TP) S4_GND1.1(TP) S4_GND2.1(TP) S4_GND3.1(TP) S4_GND4.1(TP) S5_GND1.1(TP) S5_GND2.1(TP) S5_GND3.1(TP) S5_GND4.1(TP) S6_GND1.1(TP) S6_GND2.1(TP) S6_GND3.1(TP) S6_GND4.1(TP) S7_GND1.1(TP) S7_GND2.1(TP) S7_GND3.1(TP) S7_GND4.1(TP) SITE0.4(GND_SPS_DCORE) SITE0.30(GND) SITE0.74(GND_SPS_MEM) SITE0.99(GND_SPS_AUD) SITE0.EP(EPAD) SITE0.G1 SITE0.G2 SITE0.G3 SITE0.G4 SITE0.G5 SITE0.G6 SITE0.G7 SITE0.G8 SITE0.G9 SITE0.G10 SITE0.G11 SITE0.G12 SITE0.G13 SITE0.G14 SITE0.G15 SITE0.G16 SITE0.G17 SITE0.G18 SITE0.G19 SITE0.G20 SITE0.G21 SITE0.G22 SITE0.G23 SITE0.G24 SITE0.G25 SITE0.G26 SITE0.G27 SITE0.G28 SITE0.G29 SITE0.G30 SITE0.G31 SITE0.G32 SITE0.G33 SITE1.4(GND_SPS_DCORE) SITE1.30(GND) SITE1.74(GND_SPS_MEM) SITE1.99(GND_SPS_AUD) SITE1.EP(EPAD) SITE1.G1 SITE1.G2 SITE1.G3 SITE1.G4 SITE1.G5 SITE1.G6 SITE1.G7 SITE1.G8 SITE1.G9 SITE1.G10 SITE1.G11 SITE1.G12 SITE1.G13 SITE1.G14 SITE1.G15 SITE1.G16 SITE1.G17 SITE1.G18 SITE1.G19 SITE1.G20 SITE1.G21 SITE1.G22 SITE1.G23 SITE1.G24 SITE1.G25 SITE1.G26 SITE1.G27 SITE1.G28 SITE1.G29 SITE1.G30 SITE1.G31 SITE1.G32 SITE1.G33 SITE2.4(GND_SPS_DCORE) SITE2.30(GND) SITE2.74(GND_SPS_MEM) SITE2.99(GND_SPS_AUD) SITE2.EP(EPAD) SITE2.G1 SITE2.G2 SITE2.G3 SITE2.G4 SITE2.G5 SITE2.G6 SITE2.G7 SITE2.G8 SITE2.G9 SITE2.G10 SITE2.G11 SITE2.G12 SITE2.G13 SITE2.G14 SITE2.G15 SITE2.G16 SITE2.G17 SITE2.G18 SITE2.G19 SITE2.G20 SITE2.G21 SITE2.G22 SITE2.G23 SITE2.G24 SITE2.G25 SITE2.G26 SITE2.G27 SITE2.G28 SITE2.G29 SITE2.G30 SITE2.G31 SITE2.G32 SITE2.G33 SITE3.4(GND_SPS_DCORE) SITE3.30(GND) SITE3.74(GND_SPS_MEM) SITE3.99(GND_SPS_AUD) SITE3.EP(EPAD) SITE3.G1 SITE3.G2 SITE3.G3 SITE3.G4 SITE3.G5 SITE3.G6 SITE3.G7 SITE3.G8 SITE3.G9 SITE3.G10 SITE3.G11 SITE3.G12 SITE3.G13 SITE3.G14 SITE3.G15 SITE3.G16 SITE3.G17 SITE3.G18 SITE3.G19 SITE3.G20 SITE3.G21 SITE3.G22 SITE3.G23 SITE3.G24 SITE3.G25 SITE3.G26 SITE3.G27 SITE3.G28 SITE3.G29 SITE3.G30 SITE3.G31 SITE3.G32 SITE3.G33 SITE4.4(GND_SPS_DCORE) SITE4.30(GND) SITE4.74(GND_SPS_MEM) SITE4.99(GND_SPS_AUD) SITE4.EP(EPAD) SITE4.G1 SITE4.G2 SITE4.G3 SITE4.G4 SITE4.G5 SITE4.G6 SITE4.G7 SITE4.G8 SITE4.G9 SITE4.G10 SITE4.G11 SITE4.G12 SITE4.G13 SITE4.G14 SITE4.G15 SITE4.G16 SITE4.G17 SITE4.G18 SITE4.G19 SITE4.G20 SITE4.G21 SITE4.G22 SITE4.G23 SITE4.G24 SITE4.G25 SITE4.G26 SITE4.G27 SITE4.G28 SITE4.G29 SITE4.G30 SITE4.G31 SITE4.G32 SITE4.G33 SITE5.4(GND_SPS_DCORE) SITE5.30(GND) SITE5.74(GND_SPS_MEM) SITE5.99(GND_SPS_AUD) SITE5.EP(EPAD) SITE5.G1 SITE5.G2 SITE5.G3 SITE5.G4 SITE5.G5 SITE5.G6 SITE5.G7 SITE5.G8 SITE5.G9 SITE5.G10 SITE5.G11 SITE5.G12 SITE5.G13 SITE5.G14 SITE5.G15 SITE5.G16 SITE5.G17 SITE5.G18 SITE5.G19 SITE5.G20 SITE5.G21 SITE5.G22 SITE5.G23 SITE5.G24 SITE5.G25 SITE5.G26 SITE5.G27 SITE5.G28 SITE5.G29 SITE5.G30 SITE5.G31 SITE5.G32 SITE5.G33 SITE6.4(GND_SPS_DCORE) SITE6.30(GND) SITE6.74(GND_SPS_MEM) SITE6.99(GND_SPS_AUD) SITE6.EP(EPAD) SITE6.G1 SITE6.G2 SITE6.G3 SITE6.G4 SITE6.G5 SITE6.G6 SITE6.G7 SITE6.G8 SITE6.G9 SITE6.G10 SITE6.G11 SITE6.G12 SITE6.G13 SITE6.G14 SITE6.G15 SITE6.G16 SITE6.G17 SITE6.G18 SITE6.G19 SITE6.G20 SITE6.G21 SITE6.G22 SITE6.G23 SITE6.G24 SITE6.G25 SITE6.G26 SITE6.G27 SITE6.G28 SITE6.G29 SITE6.G30 SITE6.G31 SITE6.G32 SITE6.G33 SITE7.4(GND_SPS_DCORE) SITE7.30(GND) SITE7.74(GND_SPS_MEM) SITE7.99(GND_SPS_AUD) SITE7.EP(EPAD) SITE7.G1 SITE7.G2 SITE7.G3 SITE7.G4 SITE7.G5 SITE7.G6 SITE7.G7 SITE7.G8 SITE7.G9 SITE7.G10 SITE7.G11 SITE7.G12 SITE7.G13 SITE7.G14 SITE7.G15 SITE7.G16 SITE7.G17 SITE7.G18 SITE7.G19 SITE7.G20 SITE7.G21 SITE7.G22 SITE7.G23 SITE7.G24 SITE7.G25 SITE7.G26 SITE7.G27 SITE7.G28 SITE7.G29 SITE7.G30 SITE7.G31 SITE7.G32 SITE7.G33 ST2.2 ST5.2 ST16.2 ST17.2 ST18.2 ST19.2 SW1.9 SW1.10 SW1.11 SW1.12 SW1.13 SW1.14 SW1.15 SW1.16 SW2.9 SW2.10 SW2.11 SW2.12 SW2.13 SW2.14 SW2.15 SW2.16 SW3.9 SW3.10 SW3.11 SW3.12 SW3.13 SW3.14 SW3.15 SW3.16 SW4.9 SW4.10 SW4.11 SW4.12 SW4.13 SW4.14 SW4.15 SW4.16 SW7.9 SW7.10 SW7.11 SW7.12 SW7.13 SW7.14 SW7.15 SW7.16 SWB1.3 U3.4(GND) UB70.4(GND) UB70.G1(EP) UB71.4(GND) UB71.G1(EP) UB73.4(GND) UB73.G1(EP) UNK1BD34.1 UNK1BD35.1 UNK1C17.1 UNK1C18.1 UNK1C20.2 UNK1C21.2 UNK1C22.2 UNK1C23.1 UNK1C24.2 UNK1C25.1 UNK1C38.1 UNK1C39.2 UNK1C40.1 UNK1C41.2 UNK1C44.2 UNK1C45.2 UNK1C46.2 UNK1C47.2 UNK1C48.2 UNK1C49.2 UNK1C52.2 UNK1C53.2 UNK1C54.2 UNK1C55.2 UNK1C56.2 UNK1C57.2 UNK1C58.2 UNK1C59.2 UNK1C60.2 UNK1C61.2 UNK1C62.2 UNK1C63.2 UNK1C64.2 UNK1C65.2 UNK1C66.2 UNK1C67.2 UNK1C68.2 UNK1C69.2 UNK1C70.2 UNK1C71.2 UNK1C72.2 UNK1C73.2 UNK1C74.2 UNK1C75.2 UNK1C76.2 UNK1C77.2 UNK1C78.2 UNK1C79.2 UNK1C83.2 UNK1C84.2 UNK1C85.2 UNK1C88.2 UNK1C89.2 UNK1C90.2 UNK1C91.2 UNK1C92.2 UNK1C93.2 UNK1C94.2 UNK1C95.2 UNK1C96.2 UNK1C97.2 UNK1C98.2 UNK1C99.2 UNK1C100.2 UNK1C101.2 UNK1C102.2 UNK1C105.2 UNK1C106.2 UNK1C107.2 UNK1C108.2 UNK1C109.2 UNK1C110.2 UNK1C111.2 UNK1C112.2 UNK1C113.1 UNK1C116.2 UNK1C117.2 UNK1C118.2 UNK1C119.2 UNK1C120.2 UNK1C121.2 UNK1C122.2 UNK1C123.2 UNK1C124.2 UNK1C125.2 UNK1C126.2 UNK1C127.2 UNK1C128.2 UNK1C129.2 UNK1C130.2 UNK1C131.2 UNK1C132.2 UNK1C133.2 UNK1C134.2 UNK1C135.2 UNK1C136.2 UNK1C137.2 UNK1C138.2 UNK1C139.2 UNK1C140.2 UNK1C141.2 UNK1C142.2 UNK1C143.1 UNK1C144.1 UNK1C145.1 UNK1C146.1 UNK1C147.1 UNK1C148.1 UNK1C149.1 UNK1C150.1 UNK1C152.2 UNK1C153.2 UNK1J1.2 UNK1J2.2 UNK1J3.2 UNK1J4.8 UNK1R18.1 UNK1R22.2 UNK1R23.2 UNK1R25.2 UNK1R26.2 UNK1R33.1 UNK1R42.2 UNK1R43.2 UNK1R49.2 UNK1R51.2 UNK1R54.2 UNK1R62.2 UNK1R71.2 UNK1R72.2 UNK1R73.2 UNK1ST5.2 UNK1ST16.2 UNK1ST17.2 UNK1ST18.2 UNK1ST19.2 UNK1U3.4 UNK1Y1.2 UNK1Y1.4 UNK2BD34.1 UNK2BD35.1 UNK2C17.1 UNK2C18.1 UNK2C20.2 UNK2C21.2 UNK2C22.2 UNK2C23.1 UNK2C24.2 UNK2C25.1 UNK2C38.1 UNK2C39.2 UNK2C40.1 UNK2C41.2 UNK2C44.2 UNK2C45.2 UNK2C46.2 UNK2C47.2 UNK2C48.2 UNK2C49.2 UNK2C52.2 UNK2C53.2 UNK2C54.2 UNK2C55.2 UNK2C56.2 UNK2C57.2 UNK2C58.2 UNK2C59.2 UNK2C60.2 UNK2C61.2 UNK2C62.2 UNK2C63.2 UNK2C64.2 UNK2C65.2 UNK2C66.2 UNK2C67.2 UNK2C68.2 UNK2C69.2 UNK2C70.2 UNK2C71.2 UNK2C72.2 UNK2C73.2 UNK2C74.2 UNK2C75.2 UNK2C76.2 UNK2C77.2 UNK2C78.2 UNK2C79.2 UNK2C83.2 UNK2C84.2 UNK2C85.2 UNK2C88.2 UNK2C89.2 UNK2C90.2 UNK2C91.2 UNK2C92.2 UNK2C93.2 UNK2C94.2 UNK2C95.2 UNK2C96.2 UNK2C97.2 UNK2C98.2 UNK2C99.2 UNK2C100.2 UNK2C101.2 UNK2C102.2 UNK2C105.2 UNK2C106.2 UNK2C107.2 UNK2C108.2 UNK2C109.2 UNK2C110.2 UNK2C111.2 UNK2C112.2 UNK2C113.1 UNK2C116.2 UNK2C117.2 UNK2C118.2 UNK2C119.2 UNK2C120.2 UNK2C121.2 UNK2C122.2 UNK2C123.2 UNK2C124.2 UNK2C125.2 UNK2C126.2 UNK2C127.2 UNK2C128.2 UNK2C129.2 UNK2C130.2 UNK2C131.2 UNK2C132.2 UNK2C133.2 UNK2C134.2 UNK2C135.2 UNK2C136.2 UNK2C137.2 UNK2C138.2 UNK2C139.2 UNK2C140.2 UNK2C141.2 UNK2C142.2 UNK2C143.1 UNK2C144.1 UNK2C145.1 UNK2C146.1 UNK2C147.1 UNK2C148.1 UNK2C149.1 UNK2C150.1 UNK2C152.2 UNK2C153.2 UNK2J1.2 UNK2J2.2 UNK2J3.2 UNK2J4.8 UNK2R18.1 UNK2R22.2 UNK2R23.2 UNK2R25.2 UNK2R26.2 UNK2R33.1 UNK2R42.2 UNK2R43.2 UNK2R49.2 UNK2R51.2 UNK2R54.2 UNK2R62.2 UNK2R71.2 UNK2R72.2 UNK2R73.2 UNK2ST5.2 UNK2ST16.2 UNK2ST17.2 UNK2ST18.2 UNK2ST19.2 UNK2U3.4 UNK2Y1.2 UNK2Y1.4 UNK3BD34.1 UNK3BD35.1 UNK3C17.1 UNK3C18.1 UNK3C20.2 UNK3C21.2 UNK3C22.2 UNK3C23.1 UNK3C24.2 UNK3C25.1 UNK3C38.1 UNK3C39.2 UNK3C40.1 UNK3C41.2 UNK3C44.2 UNK3C45.2 UNK3C46.2 UNK3C47.2 UNK3C48.2 UNK3C49.2 UNK3C52.2 UNK3C53.2 UNK3C54.2 UNK3C55.2 UNK3C56.2 UNK3C57.2 UNK3C58.2 UNK3C59.2 UNK3C60.2 UNK3C61.2 UNK3C62.2 UNK3C63.2 UNK3C64.2 UNK3C65.2 UNK3C66.2 UNK3C67.2 UNK3C68.2 UNK3C69.2 UNK3C70.2 UNK3C71.2 UNK3C72.2 UNK3C73.2 UNK3C74.2 UNK3C75.2 UNK3C76.2 UNK3C77.2 UNK3C78.2 UNK3C79.2 UNK3C83.2 UNK3C84.2 UNK3C85.2 UNK3C88.2 UNK3C89.2 UNK3C90.2 UNK3C91.2 UNK3C92.2 UNK3C93.2 UNK3C94.2 UNK3C95.2 UNK3C96.2 UNK3C97.2 UNK3C98.2 UNK3C99.2 UNK3C100.2 UNK3C101.2 UNK3C102.2 UNK3C105.2 UNK3C106.2 UNK3C107.2 UNK3C108.2 UNK3C109.2 UNK3C110.2 UNK3C111.2 UNK3C112.2 UNK3C113.1 UNK3C116.2 UNK3C117.2 UNK3C118.2 UNK3C119.2 UNK3C120.2 UNK3C121.2 UNK3C122.2 UNK3C123.2 UNK3C124.2 UNK3C125.2 UNK3C126.2 UNK3C127.2 UNK3C128.2 UNK3C129.2 UNK3C130.2 UNK3C131.2 UNK3C132.2 UNK3C133.2 UNK3C134.2 UNK3C135.2 UNK3C136.2 UNK3C137.2 UNK3C138.2 UNK3C139.2 UNK3C140.2 UNK3C141.2 UNK3C142.2 UNK3C143.1 UNK3C144.1 UNK3C145.1 UNK3C146.1 UNK3C147.1 UNK3C148.1 UNK3C149.1 UNK3C150.1 UNK3C152.2 UNK3C153.2 UNK3J1.2 UNK3J2.2 UNK3J3.2 UNK3J4.8 UNK3R18.1 UNK3R22.2 UNK3R23.2 UNK3R25.2 UNK3R26.2 UNK3R33.1 UNK3R42.2 UNK3R43.2 UNK3R49.2 UNK3R51.2 UNK3R54.2 UNK3R62.2 UNK3R71.2 UNK3R72.2 UNK3R73.2 UNK3ST5.2 UNK3ST16.2 UNK3ST17.2 UNK3ST18.2 UNK3ST19.2 UNK3U3.4 UNK3Y1.2 UNK3Y1.4 UNK4BD34.1 UNK4BD35.1 UNK4C17.1 UNK4C18.1 UNK4C20.2 UNK4C21.2 UNK4C22.2 UNK4C23.1 UNK4C24.2 UNK4C25.1 UNK4C38.1 UNK4C39.2 UNK4C40.1 UNK4C41.2 UNK4C44.2 UNK4C45.2 UNK4C46.2 UNK4C47.2 UNK4C48.2 UNK4C49.2 UNK4C52.2 UNK4C53.2 UNK4C54.2 UNK4C55.2 UNK4C56.2 UNK4C57.2 UNK4C58.2 UNK4C59.2 UNK4C60.2 UNK4C61.2 UNK4C62.2 UNK4C63.2 UNK4C64.2 UNK4C65.2 UNK4C66.2 UNK4C67.2 UNK4C68.2 UNK4C69.2 UNK4C70.2 UNK4C71.2 UNK4C72.2 UNK4C73.2 UNK4C74.2 UNK4C75.2 UNK4C76.2 UNK4C77.2 UNK4C78.2 UNK4C79.2 UNK4C83.2 UNK4C84.2 UNK4C85.2 UNK4C88.2 UNK4C89.2 UNK4C90.2 UNK4C91.2 UNK4C92.2 UNK4C93.2 UNK4C94.2 UNK4C95.2 UNK4C96.2 UNK4C97.2 UNK4C98.2 UNK4C99.2 UNK4C100.2 UNK4C101.2 UNK4C102.2 UNK4C105.2 UNK4C106.2 UNK4C107.2 UNK4C108.2 UNK4C109.2 UNK4C110.2 UNK4C111.2 UNK4C112.2 UNK4C113.1 UNK4C116.2 UNK4C117.2 UNK4C118.2 UNK4C119.2 UNK4C120.2 UNK4C121.2 UNK4C122.2 UNK4C123.2 UNK4C124.2 UNK4C125.2 UNK4C126.2 UNK4C127.2 UNK4C128.2 UNK4C129.2 UNK4C130.2 UNK4C131.2 UNK4C132.2 UNK4C133.2 UNK4C134.2 UNK4C135.2 UNK4C136.2 UNK4C137.2 UNK4C138.2 UNK4C139.2 UNK4C140.2 UNK4C141.2 UNK4C142.2 UNK4C143.1 UNK4C144.1 UNK4C145.1 UNK4C146.1 UNK4C147.1 UNK4C148.1 UNK4C149.1 UNK4C150.1 UNK4C152.2 UNK4C153.2 UNK4J1.2 UNK4J2.2 UNK4J3.2 UNK4J4.8 UNK4R18.1 UNK4R22.2 UNK4R23.2 UNK4R25.2 UNK4R26.2 UNK4R33.1 UNK4R42.2 UNK4R43.2 UNK4R49.2 UNK4R51.2 UNK4R54.2 UNK4R62.2 UNK4R71.2 UNK4R72.2 UNK4R73.2 UNK4ST5.2 UNK4ST16.2 UNK4ST17.2 UNK4ST18.2 UNK4ST19.2 UNK4SW1.9 UNK4SW1.10 UNK4SW1.11 UNK4SW1.12 UNK4SW1.13 UNK4SW1.14 UNK4SW1.15 UNK4SW1.16 UNK4SW2.9 UNK4SW2.10 UNK4SW2.11 UNK4SW2.12 UNK4SW2.13 UNK4SW2.14 UNK4SW2.15 UNK4SW2.16 UNK4SW3.9 UNK4SW3.10 UNK4SW3.11 UNK4SW3.12 UNK4SW3.13 UNK4SW3.14 UNK4SW3.15 UNK4SW3.16 UNK4SW4.9 UNK4SW4.10 UNK4SW4.11 UNK4SW4.12 UNK4SW4.13 UNK4SW4.14 UNK4SW4.15 UNK4SW4.16 UNK4SW7.9 UNK4SW7.10 UNK4SW7.11 UNK4SW7.12 UNK4SW7.13 UNK4SW7.14 UNK4SW7.15 UNK4SW7.16 UNK4U3.4 UNK4Y1.2 UNK4Y1.4 UNK5BD34.1 UNK5BD35.1 UNK5C17.1 UNK5C18.1 UNK5C20.2 UNK5C21.2 UNK5C22.2 UNK5C23.1 UNK5C24.2 UNK5C25.1 UNK5C38.1 UNK5C39.2 UNK5C40.1 UNK5C41.2 UNK5C44.2 UNK5C45.2 UNK5C46.2 UNK5C47.2 UNK5C48.2 UNK5C49.2 UNK5C52.2 UNK5C53.2 UNK5C54.2 UNK5C55.2 UNK5C56.2 UNK5C57.2 UNK5C58.2 UNK5C59.2 UNK5C60.2 UNK5C61.2 UNK5C62.2 UNK5C63.2 UNK5C64.2 UNK5C65.2 UNK5C66.2 UNK5C67.2 UNK5C68.2 UNK5C69.2 UNK5C70.2 UNK5C71.2 UNK5C72.2 UNK5C73.2 UNK5C74.2 UNK5C75.2 UNK5C76.2 UNK5C77.2 UNK5C78.2 UNK5C79.2 UNK5C83.2 UNK5C84.2 UNK5C85.2 UNK5C88.2 UNK5C89.2 UNK5C90.2 UNK5C91.2 UNK5C92.2 UNK5C93.2 UNK5C94.2 UNK5C95.2 UNK5C96.2 UNK5C97.2 UNK5C98.2 UNK5C99.2 UNK5C100.2 UNK5C101.2 UNK5C102.2 UNK5C105.2 UNK5C106.2 UNK5C107.2 UNK5C108.2 UNK5C109.2 UNK5C110.2 UNK5C111.2 UNK5C112.2 UNK5C113.1 UNK5C116.2 UNK5C117.2 UNK5C118.2 UNK5C119.2 UNK5C120.2 UNK5C121.2 UNK5C122.2 UNK5C123.2 UNK5C124.2 UNK5C125.2 UNK5C126.2 UNK5C127.2 UNK5C128.2 UNK5C129.2 UNK5C130.2 UNK5C131.2 UNK5C132.2 UNK5C133.2 UNK5C134.2 UNK5C135.2 UNK5C136.2 UNK5C137.2 UNK5C138.2 UNK5C139.2 UNK5C140.2 UNK5C141.2 UNK5C142.2 UNK5C143.1 UNK5C144.1 UNK5C145.1 UNK5C146.1 UNK5C147.1 UNK5C148.1 UNK5C149.1 UNK5C150.1 UNK5C152.2 UNK5C153.2 UNK5J1.2 UNK5J2.2 UNK5J3.2 UNK5J4.8 UNK5R18.1 UNK5R22.2 UNK5R23.2 UNK5R25.2 UNK5R26.2 UNK5R33.1 UNK5R42.2 UNK5R43.2 UNK5R49.2 UNK5R51.2 UNK5R54.2 UNK5R62.2 UNK5R71.2 UNK5R72.2 UNK5R73.2 UNK5ST5.2 UNK5ST16.2 UNK5ST17.2 UNK5ST18.2 UNK5ST19.2 UNK5U3.4 UNK5Y1.2 UNK5Y1.4 UNK6BD34.1 UNK6BD35.1 UNK6C17.1 UNK6C18.1 UNK6C20.2 UNK6C21.2 UNK6C22.2 UNK6C23.1 UNK6C24.2 UNK6C25.1 UNK6C38.1 UNK6C39.2 UNK6C40.1 UNK6C41.2 UNK6C44.2 UNK6C45.2 UNK6C46.2 UNK6C47.2 UNK6C48.2 UNK6C49.2 UNK6C52.2 UNK6C53.2 UNK6C54.2 UNK6C55.2 UNK6C56.2 UNK6C57.2 UNK6C58.2 UNK6C59.2 UNK6C60.2 UNK6C61.2 UNK6C62.2 UNK6C63.2 UNK6C64.2 UNK6C65.2 UNK6C66.2 UNK6C67.2 UNK6C68.2 UNK6C69.2 UNK6C70.2 UNK6C71.2 UNK6C72.2 UNK6C73.2 UNK6C74.2 UNK6C75.2 UNK6C76.2 UNK6C77.2 UNK6C78.2 UNK6C79.2 UNK6C83.2 UNK6C84.2 UNK6C85.2 UNK6C88.2 UNK6C89.2 UNK6C90.2 UNK6C91.2 UNK6C92.2 UNK6C93.2 UNK6C94.2 UNK6C95.2 UNK6C96.2 UNK6C97.2 UNK6C98.2 UNK6C99.2 UNK6C100.2 UNK6C101.2 UNK6C102.2 UNK6C105.2 UNK6C106.2 UNK6C107.2 UNK6C108.2 UNK6C109.2 UNK6C110.2 UNK6C111.2 UNK6C112.2 UNK6C113.1 UNK6C116.2 UNK6C117.2 UNK6C118.2 UNK6C119.2 UNK6C120.2 UNK6C121.2 UNK6C122.2 UNK6C123.2 UNK6C124.2 UNK6C125.2 UNK6C126.2 UNK6C127.2 UNK6C128.2 UNK6C129.2 UNK6C130.2 UNK6C131.2 UNK6C132.2 UNK6C133.2 UNK6C134.2 UNK6C135.2 UNK6C136.2 UNK6C137.2 UNK6C138.2 UNK6C139.2 UNK6C140.2 UNK6C141.2 UNK6C142.2 UNK6C143.1 UNK6C144.1 UNK6C145.1 UNK6C146.1 UNK6C147.1 UNK6C148.1 UNK6C149.1 UNK6C150.1 UNK6C152.2 UNK6C153.2 UNK6J1.2 UNK6J2.2 UNK6J3.2 UNK6J4.8 UNK6R18.1 UNK6R22.2 UNK6R23.2 UNK6R25.2 UNK6R26.2 UNK6R33.1 UNK6R42.2 UNK6R43.2 UNK6R49.2 UNK6R51.2 UNK6R54.2 UNK6R62.2 UNK6R71.2 UNK6R72.2 UNK6R73.2 UNK6ST5.2 UNK6ST16.2 UNK6ST17.2 UNK6ST18.2 UNK6ST19.2 UNK6U3.4 UNK6Y1.2 UNK6Y1.4 UNK7BD34.1 UNK7BD35.1 UNK7C17.1 UNK7C18.1 UNK7C20.2 UNK7C21.2 UNK7C22.2 UNK7C23.1 UNK7C24.2 UNK7C25.1 UNK7C38.1 UNK7C39.2 UNK7C40.1 UNK7C41.2 UNK7C44.2 UNK7C45.2 UNK7C46.2 UNK7C47.2 UNK7C48.2 UNK7C49.2 UNK7C52.2 UNK7C53.2 UNK7C54.2 UNK7C55.2 UNK7C56.2 UNK7C57.2 UNK7C58.2 UNK7C59.2 UNK7C60.2 UNK7C61.2 UNK7C62.2 UNK7C63.2 UNK7C64.2 UNK7C65.2 UNK7C66.2 UNK7C67.2 UNK7C68.2 UNK7C69.2 UNK7C70.2 UNK7C71.2 UNK7C72.2 UNK7C73.2 UNK7C74.2 UNK7C75.2 UNK7C76.2 UNK7C77.2 UNK7C78.2 UNK7C79.2 UNK7C83.2 UNK7C84.2 UNK7C85.2 UNK7C88.2 UNK7C89.2 UNK7C90.2 UNK7C91.2 UNK7C92.2 UNK7C93.2 UNK7C94.2 UNK7C95.2 UNK7C96.2 UNK7C97.2 UNK7C98.2 UNK7C99.2 UNK7C100.2 UNK7C101.2 UNK7C102.2 UNK7C105.2 UNK7C106.2 UNK7C107.2 UNK7C108.2 UNK7C109.2 UNK7C110.2 UNK7C111.2 UNK7C112.2 UNK7C113.1 UNK7C116.2 UNK7C117.2 UNK7C118.2 UNK7C119.2 UNK7C120.2 UNK7C121.2 UNK7C122.2 UNK7C123.2 UNK7C124.2 UNK7C125.2 UNK7C126.2 UNK7C127.2 UNK7C128.2 UNK7C129.2 UNK7C130.2 UNK7C131.2 UNK7C132.2 UNK7C133.2 UNK7C134.2 UNK7C135.2 UNK7C136.2 UNK7C137.2 UNK7C138.2 UNK7C139.2 UNK7C140.2 UNK7C141.2 UNK7C142.2 UNK7C143.1 UNK7C144.1 UNK7C145.1 UNK7C146.1 UNK7C147.1 UNK7C148.1 UNK7C149.1 UNK7C150.1 UNK7C152.2 UNK7C153.2 UNK7J1.2 UNK7J2.2 UNK7J3.2 UNK7J4.8 UNK7R18.1 UNK7R22.2 UNK7R23.2 UNK7R25.2 UNK7R26.2 UNK7R33.1 UNK7R42.2 UNK7R43.2 UNK7R49.2 UNK7R51.2 UNK7R54.2 UNK7R62.2 UNK7R71.2 UNK7R72.2 UNK7R73.2 UNK7ST5.2 UNK7ST16.2 UNK7ST17.2 UNK7ST18.2 UNK7ST19.2 UNK7U3.4 UNK7Y1.2 UNK7Y1.4 UT1.1(NC) UT1.2(GND) UT1.5(NC[1]) Y1.2 Y1.4
VDD5_ATX: BDB76.2 BDB77.2 BDB80.1 BDB82.1 BDB86.1 CB641.1 CB642.1 CB643.1 CB656.1 CB657.2 CB671.1 CB672.2 CB701.1 CB702.2
VDD12_ATX: BDB74.2 BDB75.2 CB647.1 CB648.1 CB649.1 VDD12_ATX.1 VDD12_ATX.3
VDD33_ATX: CB632.1 CB633.1 CB634.1 FUSEB1.2
AVO_GND: P1.N1(1) P1.N3(3) P1.N5(5) P1.N7(7) P1.N9(9) P1.N11(11) P1.O2(2) P1.O4(4) P1.O6(6) P1.O8(8) P1.O10(10) P1.O12(12) P1.P1(1) P1.P3(3) P1.P5(5) P1.P7(7) P1.P9(9) P1.P11(11) P1.Q2(2) P1.Q4(4) P1.Q6(6) P1.Q8(8) P1.Q10(10) P1.Q12(12) P1.R1(1) P1.R3(3) P1.R5(5) P1.R7(7) P1.R9(9) P1.R11(11) P1.S2(2) P1.S4(4) P1.S6(6) P1.S8(8) P1.S10(10) P1.S12(12) P1.T1(1) P1.T3(3) P1.T5(5) P1.T7(7) P1.T9(9) P1.T11(11) P1.U2(2) P1.U4(4) P1.U6(6) P1.U8(8) P1.U10(10) P1.U12(12) P1.V1(1) P1.V3(3) P1.V5(5) P1.V7(7) P1.V9(9) P1.V11(11) P1.W2(2) P1.W4(4) P1.W6(6) P1.W8(8) P1.W10(10) P1.W12(12) P1.X1(1) P1.X3(3) P1.X5(5) P1.X7(7) P1.X9(9) P1.X11(11) P1.Y2(2) P1.Y4(4) P1.Y6(6) P1.Y8(8) P1.Y10(10) P1.Y12(12) P1.Z1(1) P1.Z3(3) P1.Z5(5) P1.Z7(7) P1.Z9(9) P1.Z11(11) P6.A1(1) P6.A3(3) P6.A5(5) P6.A7(7) P6.A9(9) P6.A11(11) P6.B2(2) P6.B4(4) P6.B6(6) P6.B8(8) P6.B10(10) P6.B12(12) P6.C1(1) P6.C3(3) P6.C5(5) P6.C7(7) P6.C9(9) P6.C11(11) P6.D2(2) P6.D4(4) P6.D6(6) P6.D8(8) P6.D10(10) P6.D12(12) P6.E1(1) P6.E3(3) P6.E5(5) P6.E7(7) P6.E9(9) P6.E11(11) P6.F2(2) P6.F4(4) P6.F6(6) P6.F8(8) P6.F10(10) P6.F12(12) P6.G1(1) P6.G3(3) P6.G5(5) P6.G7(7) P6.G9(9) P6.G11(11) P6.H2(2) P6.H4(4) P6.H6(6) P6.H8(8) P6.H10(10) P6.H12(12) P6.I1(1) P6.I3(3) P6.I5(5) P6.I7(7) P6.I9(9) P6.I11(11) P6.J2(2) P6.J4(4) P6.J6(6) P6.J8(8) P6.J10(10) P6.J12(12) P6.K1(1) P6.K3(3) P6.K5(5) P6.K7(7) P6.K9(9) P6.K11(11) P6.L2(2) P6.L4(4) P6.L6(6) P6.L8(8) P6.L10(10) P6.L12(12) P6.M1(1) P6.M3(3) P6.M5(5) P6.M7(7) P6.M9(9) P6.M11(11) P7.N1(1) P7.N3(3) P7.N5(5) P7.N7(7) P7.N9(9) P7.N11(11) P7.O2(2) P7.O4(4) P7.O6(6) P7.O8(8) P7.O10(10) P7.O12(12) P7.P1(1) P7.P3(3) P7.P5(5) P7.P7(7) P7.P9(9) P7.P11(11) P7.Q2(2) P7.Q4(4) P7.Q6(6) P7.Q8(8) P7.Q10(10) P7.Q12(12) P7.R1(1) P7.R3(3) P7.R5(5) P7.R7(7) P7.R9(9) P7.R11(11) P7.S2(2) P7.S4(4) P7.S6(6) P7.S8(8) P7.S10(10) P7.S12(12) P7.T1(1) P7.T3(3) P7.T5(5) P7.T7(7) P7.T9(9) P7.T11(11) P7.U2(2) P7.U4(4) P7.U6(6) P7.U8(8) P7.U10(10) P7.U12(12) P7.V1(1) P7.V3(3) P7.V5(5) P7.V7(7) P7.V9(9) P7.V11(11) P7.W2(2) P7.W4(4) P7.W6(6) P7.W8(8) P7.W10(10) P7.W12(12) P7.X1(1) P7.X3(3) P7.X5(5) P7.X7(7) P7.X9(9) P7.X11(11) P7.Y2(2) P7.Y4(4) P7.Y6(6) P7.Y8(8) P7.Y10(10) P7.Y12(12) P7.Z1(1) P7.Z3(3) P7.Z5(5) P7.Z7(7) P7.Z9(9) P7.Z11(11) P11.A1(1) P11.A3(3) P11.A5(5) P11.A7(7) P11.A9(9) P11.A11(11) P11.B2(2) P11.B4(4) P11.B6(6) P11.B8(8) P11.B10(10) P11.B12(12) P11.C1(1) P11.C3(3) P11.C5(5) P11.C7(7) P11.C9(9) P11.C11(11) P11.D2(2) P11.D4(4) P11.D6(6) P11.D8(8) P11.D10(10) P11.D12(12) P11.E1(1) P11.E3(3) P11.E5(5) P11.E7(7) P11.E9(9) P11.E11(11) P11.F2(2) P11.F4(4) P11.F6(6) P11.F8(8) P11.F10(10) P11.F12(12) P11.G1(1) P11.G3(3) P11.G5(5) P11.G7(7) P11.G9(9) P11.G11(11) P11.H2(2) P11.H4(4) P11.H6(6) P11.H8(8) P11.H10(10) P11.H12(12) P11.I1(1) P11.I3(3) P11.I5(5) P11.I7(7) P11.I9(9) P11.I11(11) P11.J2(2) P11.J4(4) P11.J6(6) P11.J8(8) P11.J10(10) P11.J12(12) P11.K1(1) P11.K3(3) P11.K5(5) P11.K7(7) P11.K9(9) P11.K11(11) P11.L2(2) P11.L4(4) P11.L6(6) P11.L8(8) P11.L10(10) P11.L12(12) P11.M1(1) P11.M3(3) P11.M5(5) P11.M7(7) P11.M9(9) P11.M11(11)
CAL_SPI_CK0: P9.B2(2) U5.4(SCLK) U6.4(SCLK) U7.4(SCLK) U8.4(SCLK) U9.4(SCLK) U10.4(SCLK) U11.4(SCLK) U12.4(SCLK) U13.4(SCLK) U14.4(SCLK) U15.4(SCLK) U16.4(SCLK)
CAL_SPI_CK1: P9.B7(7)
CAL_SPI_CK2: P9.A2(2)
CAL_SPI_CK3: P9.A7(7)
CAL_SPI_DIN0: P9.B4(4) U7.3(DIN)
CAL_SPI_DIN1: P9.B9(9)
CAL_SPI_DIN2: P9.A4(4)
CAL_SPI_DIN3: P9.A9(9)
CAL_SPI_DO0: P9.B5(5) U16.5(DOUT)
CAL_SPI_DO1: P9.B10(10)
CAL_SPI_DO2: P9.A5(5)
CAL_SPI_DO3: P9.A10(10)
CAL_SPI_SL0: P9.B3(3) U5.2(C\S\) U6.2(C\S\) U7.2(C\S\) U8.2(C\S\) U9.2(C\S\) U10.2(C\S\) U11.2(C\S\) U12.2(C\S\) U13.2(C\S\) U14.2(C\S\) U15.2(C\S\) U16.2(C\S\)
CAL_SPI_SL1: P9.B8(8)
CAL_SPI_SL2: P9.A3(3)
CAL_SPI_SL3: P9.A8(8)
DPS_GND: BD57.2 BD58.2 BD59.2 BD60.2 BD61.2 BD62.2 BD63.2 BD64.2 BD65.2 BD66.2 BD67.2 BD68.2 P1.A1(1) P1.A5(5) P1.A9(9) P1.B4(4) P1.B8(8) P1.B12(12) P1.C1(1) P1.C5(5) P1.C9(9) P1.D4(4) P1.D8(8) P1.D12(12) P1.E1(1) P1.E5(5) P1.E9(9) P1.F4(4) P1.F8(8) P1.F12(12) P1.G1(1) P1.G5(5) P1.G9(9) P1.H4(4) P1.H8(8) P1.H12(12) P1.I1(1) P1.I5(5) P1.I9(9) P1.J4(4) P1.J8(8) P1.J12(12) P1.K1(1) P1.K5(5) P1.K9(9) P1.K11(11) P1.L2(2) P1.L4(4) P1.L6(6) P1.L8(8) P1.L10(10) P1.L12(12) P1.M1(1) P1.M3(3) P1.M5(5) P1.M7(7) P1.M9(9) P1.M11(11) P4.A1(1) P4.A5(5) P4.A9(9) P4.B4(4) P4.B8(8) P4.B12(12) P4.C1(1) P4.C5(5) P4.C9(9) P4.D4(4) P4.D8(8) P4.D12(12) P4.E1(1) P4.E5(5) P4.E9(9) P4.F4(4) P4.F8(8) P4.F12(12) P4.G1(1) P4.G5(5) P4.G9(9) P4.H4(4) P4.H8(8) P4.H12(12) P4.I1(1) P4.I5(5) P4.I9(9) P4.J4(4) P4.J8(8) P4.J12(12) P4.K1(1) P4.K5(5) P4.K9(9) P4.K11(11) P4.L2(2) P4.L4(4) P4.L6(6) P4.L8(8) P4.L10(10) P4.L12(12) P4.M1(1) P4.M3(3) P4.M5(5) P4.M7(7) P4.M9(9) P4.M11(11) P4.N1(1) P4.N3(3) P4.N5(5) P4.N7(7) P4.N9(9) P4.N11(11) P4.O2(2) P4.O4(4) P4.O6(6) P4.O8(8) P4.O10(10) P4.O12(12) P4.P1(1) P4.P3(3) P4.P5(5) P4.P7(7) P4.P9(9) P4.P11(11) P4.Q2(2) P4.Q4(4) P4.Q6(6) P4.Q8(8) P4.Q10(10) P4.Q12(12) P4.R1(1) P4.R3(3) P4.R5(5) P4.R7(7) P4.R9(9) P4.R11(11) P4.S2(2) P4.S4(4) P4.S6(6) P4.S8(8) P4.S10(10) P4.S12(12) P4.T1(1) P4.T3(3) P4.T5(5) P4.T7(7) P4.T9(9) P4.T11(11) P4.U2(2) P4.U4(4) P4.U6(6) P4.U8(8) P4.U10(10) P4.U12(12) P4.V1(1) P4.V3(3) P4.V5(5) P4.V7(7) P4.V9(9) P4.V11(11) P4.W2(2) P4.W4(4) P4.W6(6) P4.W8(8) P4.W10(10) P4.W12(12) P4.X1(1) P4.X3(3) P4.X5(5) P4.X7(7) P4.X9(9) P4.X11(11) P4.Y2(2) P4.Y4(4) P4.Y6(6) P4.Y8(8) P4.Y10(10) P4.Y12(12) P4.Z1(1) P4.Z3(3) P4.Z5(5) P4.Z7(7) P4.Z9(9) P4.Z11(11) P6.N1(1) P6.N5(5) P6.N9(9) P6.O4(4) P6.O8(8) P6.O12(12) P6.P1(1) P6.P5(5) P6.P9(9) P6.Q4(4) P6.Q8(8) P6.Q12(12) P6.R1(1) P6.R5(5) P6.R9(9) P6.S4(4) P6.S8(8) P6.S12(12) P6.T1(1) P6.T5(5) P6.T9(9) P6.U4(4) P6.U8(8) P6.U12(12) P6.V1(1) P6.V5(5) P6.V9(9) P6.W4(4) P6.W8(8) P6.W12(12) P6.X1(1) P6.X5(5) P6.X9(9) P6.X11(11) P6.Y2(2) P6.Y4(4) P6.Y6(6) P6.Y8(8) P6.Y10(10) P6.Y12(12) P6.Z1(1) P6.Z3(3) P6.Z5(5) P6.Z7(7) P6.Z9(9) P6.Z11(11) P7.A1(1) P7.A3(3) P7.A5(5) P7.A7(7) P7.A9(9) P7.A11(11) P7.B2(2) P7.B4(4) P7.B6(6) P7.B8(8) P7.B10(10) P7.B12(12) P7.C1(1) P7.C5(5) P7.C9(9) P7.C11(11) P7.D4(4) P7.D8(8) P7.D12(12) P7.E1(1) P7.E5(5) P7.E9(9) P7.F4(4) P7.F8(8) P7.F12(12) P7.G1(1) P7.G5(5) P7.G9(9) P7.H4(4) P7.H8(8) P7.H12(12) P7.I1(1) P7.I5(5) P7.I9(9) P7.J4(4) P7.J8(8) P7.J12(12) P7.K1(1) P7.K5(5) P7.K9(9) P7.L4(4) P7.L8(8) P7.L12(12) P7.M1(1) P7.M5(5) P7.M9(9) P11.N1(1) P11.N3(3) P11.N5(5) P11.N7(7) P11.N9(9) P11.N11(11) P11.O2(2) P11.O4(4) P11.O6(6) P11.O8(8) P11.O10(10) P11.O12(12) P11.P1(1) P11.P5(5) P11.P9(9) P11.P11(11) P11.Q4(4) P11.Q8(8) P11.Q12(12) P11.R1(1) P11.R5(5) P11.R9(9) P11.S4(4) P11.S8(8) P11.S12(12) P11.T1(1) P11.T5(5) P11.T9(9) P11.U4(4) P11.U8(8) P11.U12(12) P11.V1(1) P11.V5(5) P11.V9(9) P11.W4(4) P11.W8(8) P11.W12(12) P11.X1(1) P11.X5(5) P11.X9(9) P11.Y4(4) P11.Y8(8) P11.Y12(12) P11.Z1(1) P11.Z5(5) P11.Z9(9)
IDCE1: P9.D8(8) UB5.1(C\S\)
IDDI: P9.D9(9) UB5.5(SI)
IDDO: P9.D10(10) UB5.2(SO)
IDSK: P9.D7(7) UB5.6(SCK)
LB_GND: BD42.1 BD43.1 BD44.1 BD48.1 BD50.1 BD51.1 BD52.1 BD56.1 BD69.1 BD70.1 BD71.1 BD72.1 C524.2 C525.2 C528.2 C539.2 C540.2 C541.2 C542.2 C543.2 C544.2 C545.2 C546.2 C547.2 C548.2 C549.2 C550.2 C551.2 C552.2 C553.2 C554.2 C555.2 CT2.2 CT3.2 CT4.2 CT5.2 CT6.2 CT7.2 CT8.2 CT9.2 CT10.2 CT11.2 CT12.2 CT13.2 LDB1.2(B) LDB2.2(B) LDB3.2(B) LDB4.2(B) LDB5.2(B) LRB6.2 P9.A1(1) P9.A6(6) P9.A11(11) P9.B1(1) P9.B6(6) P9.B11(11) P9.C1(1) P9.C2(2) P9.C3(3) P9.C4(4) P9.C5(5) P9.C6(6) P9.C7(7) P9.C9(9) P9.C11(11) P9.D1(1) P9.D2(2) P9.D3(3) P9.D4(4) P9.D6(6) P9.D11(11) P9.D12(12) P9.E1(1) P9.E3(3) P9.E5(5) P9.E7(7) P9.E9(9) P9.E11(11) P9.F1(1) P9.F3(3) P9.F5(5) P9.F7(7) P9.F9(9) P9.F11(11) P9.G1(1) P9.G3(3) P9.G5(5) P9.G7(7) P9.G9(9) P9.G11(11) P9.H1(1) P9.H3(3) P9.H5(5) P9.H7(7) P9.H9(9) P9.H11(11) RB8.2 U5.7(SPLD) U5.10(PGND[1]) U5.13(GND) U5.16(PGND[2]) U5.EP(EP(GND)) U6.7(SPLD) U6.10(PGND[1]) U6.13(GND) U6.16(PGND[2]) U6.EP(EP(GND)) U7.7(SPLD) U7.10(PGND[1]) U7.13(GND) U7.16(PGND[2]) U7.EP(EP(GND)) U8.7(SPLD) U8.10(PGND[1]) U8.13(GND) U8.16(PGND[2]) U8.EP(EP(GND)) U9.7(SPLD) U9.10(PGND[1]) U9.13(GND) U9.16(PGND[2]) U9.EP(EP(GND)) U10.7(SPLD) U10.10(PGND[1]) U10.13(GND) U10.16(PGND[2]) U10.EP(EP(GND)) U11.7(SPLD) U11.10(PGND[1]) U11.13(GND) U11.16(PGND[2]) U11.EP(EP(GND)) U12.7(SPLD) U12.10(PGND[1]) U12.13(GND) U12.16(PGND[2]) U12.EP(EP(GND)) U13.7(SPLD) U13.10(PGND[1]) U13.13(GND) U13.16(PGND[2]) U13.EP(EP(GND)) U14.7(SPLD) U14.10(PGND[1]) U14.13(GND) U14.16(PGND[2]) U14.EP(EP(GND)) U15.7(SPLD) U15.10(PGND[1]) U15.13(GND) U15.16(PGND[2]) U15.EP(EP(GND)) U16.7(SPLD) U16.10(PGND[1]) U16.13(GND) U16.16(PGND[2]) U16.EP(EP(GND)) UB5.4(VSS)
S0_1_AOUT_LN: K10.4 R45.1 R67.1 R68.1
S0_1_AOUT_LP: K10.5 R69.1 R70.1 R75.1
S0_1_AOUT_RN: K14.4 R47.1 R63.1 R64.1
S0_1_AOUT_RP: K14.5 R65.1 R66.1 R74.1
S0_1_SPI_CLK: R15.1 U3.6(SCLK)
S0_1_SPI_CS: R10.2 U3.1(CS#)
S0_1_SPI_DATA0: R17.1 U3.5(SI/SIO0)
S0_1_SPI_DATA1: R11.2 U3.2(SO/SIO1)
S0_1_SPI_DATA2: R14.2 R16.2 R18.2 U3.3(WP#/SIO2)
S0_1_SPI_DATA3: R12.1 R13.1 U3.7(RST#/SIO3)
S0_1_VDD09: BD1.1 BD2.1 BD37.1 C60.1 R48.2 R76.1 R77.1 R78.1 R79.1 ST13.2
S0_1_VDD18_A: K26.2 K26.5 R50.1 S0_1V3.1(TP)
S0_1_VDD18_D: C113.2 R53.2 R81.1 R82.1 R83.1 ST15.1
S0_2_AOUT_LN: K12.4 R68.2
S0_2_AOUT_LP: K12.5 R69.2
S0_2_AOUT_RN: K15.4 R64.2
S0_2_AOUT_RP: K15.5 R65.2
S0_2_VDD18_A: BD16.1 BD17.1 BD19.1 BD20.1 C89.1 R50.2
S0_ATX_VD0V9: ATX_VD0V9.2 C65.1 C66.1 K21.6 ST3.2
S0_ATX_VD1V8: ATX_VD1V8.2 J7.1 J8.1 J9.1
S0_ATX_VD33: ATX_VD33.2 BD33.1 C131.1 C132.1 C133.1 C134.1 C135.1 J6.2
S0_AVCC_DRV: C75.1 C110.1 R55.2 SITE0.53(AVCC_DRV) ST14.1
S0_CHIP_EN_1: R34.2 SW5.1
S0_DPS_F001: C120.1 C121.1 J9.2 K29.6 ST11.2
S0_DPS_F002: C92.1 C93.1 C94.1 C95.1 J8.2 K26.6 ST8.2
S0_DPS_F004: C140.1 C141.1 J7.2 K20.6 ST12.2
S0_DPS_F006: C68.1 C69.1 C70.1 C71.1 C72.1 K23.3 K23.6 S0_VD33_ALL1.1(TP) ST4.2
S0_DPS_GS001: ST19.1
S0_DPS_GS002: ST18.1
S0_DPS_GS003-1: ST16.1
S0_DPS_GS004: ST17.1
S0_DPS_GS006: ST5.1
S0_DPS_S001: ST11.1
S0_DPS_S002: ST8.1
S0_DPS_S003-1: ST3.1
S0_DPS_S004: ST12.1
S0_DPS_S006: ST4.1
S0_GPIO5_CH: KT1.2 SITE0.66(I2S2_DIN2/I2S3_DOUT2/SPK_DATA/S)
S0_HSDM: K5.8 SITE0.79(HSDM)
S0_HSDP: K5.2 SITE0.78(HSDP)
S0_LPC_001: K36.7
S0_LPC_002: K36.2
S0_LPC_003: K11.2
S0_LPC_005: K14.2
S0_LPC_006: K18.4
S0_LPC_007: K1.4
S0_LPC_008: K35.2
S0_LPC_009: K38.3
S0_LPC_010: K34.7
S0_LPC_012: K37.3
S0_LPC_013+: K5.3 K7.2
S0_LPC_013-: K5.7 K7.8
S0_LPC_016: K2.5
S0_LPC_017: K35.7
S0_LPC_019: K12.2
S0_LPC_021: K1.5
S0_LPC_022: K15.2
S0_LPC_023: K3.4
S0_LPC_024: J4.2 R35.1 SITE0.69(UART2_TXD/TEST_MODE_SEL/DMIC0_C)
S0_LPC_025: J4.1 R34.1 SITE0.71(CHIP_EN)
S0_LPC_026: K2.4
S0_LPC_027: K10.2
S0_LPC_028: K10.7
S0_LPC_029: K13.7
S0_LPC_030: K16.2
S0_LPC_032: K15.7
S0_LPC_033: K14.7
S0_LPC_034: K18.5
S0_LPC_035: K12.7
S0_LPC_036: K34.2
S0_LPC_038: K13.2
S0_LPC_039: K3.5
S0_LPC_040: K11.7
S0_LPC_041: J4.3 R36.1 SITE0.68(UART2_RXD/BOOT_SEL/DMIC0_DATA/G)
S0_LPC_042: C18.2 SITE0.50(MIC_BIAS2/GPIOC_13/PA[31])
S0_LPC_043: K33.3
S0_LPC_044: J4.5 R39.1 SITE0.58(I2S3_DOUT1/DMIC_DATA2/ICFG1/GPI)
S0_LPC_045: K39.3
S0_LPC_046: SITE0.67(I2S2_DIN3/I2S3_DOUT3/SPK_CLK/SP)
S0_LPC_047: J4.7 R41.1 SITE0.18(GPIOB_7/PA[16]/ICFG3/SPI0_CS/UA)
S0_LPC_048: K6.4
S0_LPC_049: SITE0.8(GPIOA_5/PA[5]/TOUCH5/ADC5/UART1)
S0_LPC_050: SITE0.7(GPIOA_4/PA[4]/TOUCH4/ADC4/UART1)
S0_LPC_051: C17.2 SITE0.49(MIC_BIAS1/GPIOC_12/PA[30])
S0_LPC_052: C21.1 SITE0.48(AVCC)
S0_LPC_053: J4.4 R37.1 SITE0.57(I2S3_DOUT0/DMIC_DATA1/ICFG0/BT_)
S0_LPC_054: K6.5
S0_LPC_055: SITE0.10(VBAT_MEAS)
S0_LPC_057: K9.4
S0_LPC_058: J4.6 R40.1 SITE0.17(GPIOB_6/PA[15]/ICFG2/SPI0_CLK/U)
S0_LPC_059: K39.6
S0_LPC_060: KT1.3
S0_LPC_A_015: K8.4
S0_LPC_A_020: K8.5
S0_LPC_B_031: K4.4
S0_LPC_B_037: K4.5
S0_LPC_CH00: P2.N2(2)
S0_LPC_CH01: P2.N4(4)
S0_LPC_CH02: P2.N6(6)
S0_LPC_CH03: P2.N8(8)
S0_LPC_CH04: P2.N10(10)
S0_LPC_CH05: P2.N12(12)
S0_LPC_CH06: P2.O1(1)
S0_LPC_CH07: P2.O3(3)
S0_LPC_CH08: P2.O5(5)
S0_LPC_CH09: P2.O7(7)
S0_LPC_CH10: P2.O9(9)
S0_LPC_CH11: P2.O11(11)
S0_LPC_CH12: P2.P2(2)
S0_LPC_CH13: P2.P4(4)
S0_LPC_CH14: P2.P6(6)
S0_LPC_CH15: P2.P8(8)
S0_LPC_CH16: P2.P10(10)
S0_LPC_CH17: P2.P12(12)
S0_LPC_CH18: P2.Q1(1)
S0_LPC_CH19: P2.Q3(3)
S0_LPC_CH20: P2.Q5(5)
S0_LPC_CH21: P2.Q7(7)
S0_LPC_CH22: P2.Q9(9)
S0_LPC_CH23: P2.Q11(11)
S0_LPC_CH24: P2.R2(2)
S0_LPC_CH25: P2.R4(4)
S0_LPC_CH26: P2.R6(6)
S0_LPC_CH27: P2.R8(8)
S0_LPC_CH28: P2.R10(10)
S0_LPC_CH29: P2.R12(12)
S0_LPC_CH30: P2.S1(1)
S0_LPC_CH31: P2.S3(3)
S0_LPC_CH32: P8.Z2(2)
S0_LPC_CH33: P8.Z4(4)
S0_LPC_CH34: P8.Z6(6)
S0_LPC_CH35: P8.Z8(8)
S0_LPC_CH36: P8.Z10(10)
S0_LPC_CH37: P8.Z12(12)
S0_LPC_CH38: P8.Y1(1)
S0_LPC_CH39: P8.Y3(3)
S0_LPC_CH40: P8.Y5(5)
S0_LPC_CH41: P8.Y7(7)
S0_LPC_CH42: P8.Y9(9)
S0_LPC_CH43: P8.Y11(11)
S0_LPC_CH44: P8.X2(2)
S0_LPC_CH45: P8.X4(4)
S0_LPC_CH46: P8.X6(6)
S0_LPC_CH47: P8.X8(8)
S0_LPC_CH48: P8.X10(10)
S0_LPC_CH49: P8.X12(12)
S0_LPC_CH50: P8.W1(1)
S0_LPC_CH51: P8.W3(3)
S0_LPC_CH52: P8.W5(5)
S0_LPC_CH53: P8.W7(7)
S0_LPC_CH54: P8.W9(9)
S0_LPC_CH55: P8.W11(11)
S0_LPC_CH56: P8.V2(2)
S0_LPC_CH57: P8.V4(4)
S0_LPC_CH58: P8.V6(6)
S0_LPC_CH59: P8.V8(8)
S0_LPC_CH60: P8.V10(10)
S0_LPC_CH61: P8.V12(12)
S0_LPC_CH62: P8.U1(1)
S0_LPC_CH63: P8.U3(3)
S0_LPC_CH64: P2.S5(5)
S0_LPC_CH65: P2.S7(7)
S0_LPC_CH66: P2.S9(9)
S0_LPC_CH67: P2.S11(11)
S0_LPC_CH68: P2.T2(2)
S0_LPC_CH69: P2.T4(4)
S0_LPC_CH70: P2.T6(6)
S0_LPC_CH71: P2.T8(8)
S0_LPC_CH72: P2.T10(10)
S0_LPC_CH73: P2.T12(12)
S0_LPC_CH74: P2.U1(1)
S0_LPC_CH75: P2.U3(3)
S0_LPC_CH76: P2.U5(5)
S0_LPC_CH77: P2.U7(7)
S0_LPC_CH78: P2.U9(9)
S0_LPC_CH79: P2.U11(11)
S0_LPC_CH80: P2.V2(2)
S0_LPC_CH81: P2.V4(4)
S0_LPC_CH82: P2.V6(6)
S0_LPC_CH83: P2.V8(8)
S0_LPC_CH84: P2.V10(10)
S0_LPC_CH85: P2.V12(12)
S0_LPC_CH86: P2.W1(1)
S0_LPC_CH87: P2.W3(3)
S0_LPC_CH88: P2.W5(5)
S0_LPC_CH89: P2.W7(7)
S0_LPC_CH90: P2.W9(9)
S0_LPC_CH91: P2.W11(11)
S0_LPC_CH92: P2.X2(2)
S0_LPC_CH93: P2.X4(4)
S0_LPC_CH94: P2.X6(6)
S0_LPC_CH95: P2.X8(8)
S0_LPC_CH96: P8.U5(5)
S0_LPC_CH97: P8.U7(7)
S0_LPC_CH98: P8.U9(9)
S0_LPC_CH99: P8.U11(11)
S0_LPC_CH100: P8.T2(2)
S0_LPC_CH101: P8.T4(4)
S0_LPC_CH102: P8.T6(6)
S0_LPC_CH103: P8.T8(8)
S0_LPC_CH104: P8.T10(10)
S0_LPC_CH105: P8.T12(12)
S0_LPC_CH106: P8.S1(1)
S0_LPC_CH107: P8.S3(3)
S0_LPC_CH108: P8.S5(5)
S0_LPC_CH109: P8.S7(7)
S0_LPC_CH110: P8.S9(9)
S0_LPC_CH111: P8.S11(11)
S0_LPC_CH112: P8.R2(2)
S0_LPC_CH113: P8.R4(4)
S0_LPC_CH114: P8.R6(6)
S0_LPC_CH115: P8.R8(8)
S0_LPC_CH116: P8.R10(10)
S0_LPC_CH117: P8.R12(12)
S0_LPC_CH118: P8.Q1(1)
S0_LPC_CH119: P8.Q3(3)
S0_LPC_CH120: P8.Q5(5)
S0_LPC_CH121: P8.Q7(7)
S0_LPC_CH122: P8.Q9(9)
S0_LPC_CH123: P8.Q11(11)
S0_LPC_CH124: P8.P2(2)
S0_LPC_CH125: P8.P4(4)
S0_LPC_CH126: P8.P6(6)
S0_LPC_CH127: P8.P8(8)
S0_LPC_DGS00: P8.P12(12)
S0_LPC_DGS64: P2.X12(12)
S0_LPC_UB0: P8.N4(4)
S0_LPC_UB1: P8.O5(5)
S0_LPC_UB2: P8.N6(6)
S0_LPC_UB3: P8.O7(7)
S0_LPC_UB4: P8.N8(8)
S0_LPC_UB5: P8.O9(9)
S0_LPC_UB6: P8.N10(10)
S0_LPC_UB7: P8.O11(11)
S0_LPC_UB8: P8.N12(12)
S0_LPC_UB9: P2.Y5(5)
S0_LPC_UB10: P2.Z6(6)
S0_LPC_UB11: P2.Y7(7)
S0_LPC_UB12: P2.Z8(8)
S0_LPC_UB13: P2.Y9(9)
S0_LPC_UB14: P2.Z10(10)
S0_LPC_UB15: P2.Y11(11)
S0_LX_AUD: K20.3 SITE0.100(LX_AUD)
S0_LX_AUD_CH_1: K20.4 K38.2
S0_LX_AUD_CH_2: K38.4 ST14.2
S0_LX_DCORE: K21.3 SITE0.3(LX_DCORE)
S0_LX_DCORE_CH: K21.4 K37.2
S0_LX_MEM: K29.3 SITE0.75(LX_MEM)
S0_LX_MEM_CH_1: K29.4 K33.2
S0_LX_MEM_CH_2: K33.4 ST15.2
S0_MIPITX_CKN: K36.6 SITE0.82(MIPITX_CKN)
S0_MIPITX_CKP: K36.3 SITE0.83(MIPITX_CKP)
S0_MIPITX_DATAN_0: K34.6 SITE0.85(MIPITX_DATAN_0)
S0_MIPITX_DATAN_1: K35.6 SITE0.80(MIPITX_DATAN_1)
S0_MIPITX_DATAP_0: K34.3 SITE0.86(MIPITX_DATAP_0)
S0_MIPITX_DATAP_1: K35.3 SITE0.81(MIPITX_DATAP_1)
S0_PA2: K18.3 SITE0.5(GPIOA_2/PA[2]/TOUCH2/ADC2/UART0)
S0_PA3: K18.6 SITE0.6(GPIOA_3/PA[3]/TOUCH3/ADC3/UART0)
S0_PA9_CH: K39.2 SITE0.12(GPIOB_0/PA[9])
S0_PA10_CH: K39.7 SITE0.13(GPIOB_1/PA[10])
S0_PA13: K6.3 SITE0.15(GPIOB_4/PA[13]/SWD_DATA/SPI0_MO)
S0_PA13_UART_RX: K6.2 R27.1
S0_PA13_UART_RX_1: J2.3 R27.2
S0_PA14: K6.6 SITE0.16(GPIOB_5/PA[14]/SWD_CLK/SPI0_MIS)
S0_PA14_UART_TX: K6.7 R28.1
S0_PA14_UART_TX_1: J2.4 R28.2
S0_PA15_1: R40.2 SW5.6
S0_PA16_1: R41.2 SW5.7
S0_PA20: K15.6 SITE0.45(MIC1_P/GPIOC_2/PA[20])
S0_PA21: K15.3 SITE0.46(MIC1_N/GPIOC_3/PA[21])
S0_PA22: K11.6 SITE0.43(MIC2_P/GPIOC_4/PA[22])
S0_PA23: K11.3 SITE0.44(MIC2_N/GPIOC_5/PA[23])
S0_PA24: K12.6 SITE0.41(MIC3_P/I2C_SDA/GPIOC_6/PA[24])
S0_PA25: K12.3 SITE0.42(MIC3_N/I2C_SCL/GPIOC_7/PA[25])
S0_PA28: K13.6 SITE0.39(MIC5_P/ANT_SEL_P/GPIOC_10/PA[28)
S0_PA29: K13.3 SITE0.40(MIC5_N/ANT_SEL_N/GPIOC_11/PA[29)
S0_PB3: K10.6 SITE0.52(AOUT_LP/GPIOC_17/PB[3])
S0_PB3_AOUT_LP_2: K13.5 R70.2
S0_PB4: K10.3 SITE0.51(AOUT_LN/GPIOC_18/PB[4])
S0_PB4_AOUT_LN_2: K13.4 R67.2
S0_PB5: K14.6 SITE0.54(AOUT_RP/GPIOC_19/PB[5])
S0_PB5_AOUT_RP_2: K11.5 R66.2
S0_PB6: K14.3 SITE0.55(AOUT_RN/GPIOC_20/PB[6])
S0_PB6_AOUT_RN_2: K11.4 R63.2
S0_PB10_1: R37.2 SW5.4
S0_PB11_1: R39.2 SW5.5
S0_PB21_1: R36.2 SW5.3
S0_PB22_1: R35.2 SW5.2
S0_PB23: C144.2 K4.3 R57.1 SITE0.72(UART_LOG_RXD/OTP_BYPASS/GPIOF_2)
S0_PB23_1: R57.2 SW6.1
S0_PB23_SICK: K4.2 R20.1
S0_PB23_SICK_1: J1.3 R20.2
S0_PB24: C143.2 K4.6 R58.1 SITE0.73(UART_LOG_TXD/UART_DOWNLOAD/GPIO)
S0_PB24_1: R58.2 SW6.2
S0_PB24_SIDD: K4.7 R21.1
S0_PB24_SIDD_1: J1.4 R21.2
S0_PB25: K8.3 R59.1 SITE0.96(SPI0_CLK/SWD_CLK/SD_D2/ICFG2/GP)
S0_PB25_1: R59.2 SW6.3
S0_PB25_I2C_SCL: K8.2 R31.1
S0_PB25_I2C_SCL_1: J3.3 R31.2
S0_PB26: K8.6 R60.1 SITE0.97(SPI0_CS/SWD_DATA/SD_D3/ICFG3/GP)
S0_PB26_1: R60.2 SW6.4
S0_PB26_I2C_SDA: K8.7 R32.1
S0_PB26_I2C_SDA_1: J3.4 R32.2
S0_PMU0_F: P2.Y1(1)
S0_PMU0_G: P2.Y3(3)
S0_PMU0_S: P2.Z2(2)
S0_PMU1_F: P8.O1(1)
S0_PMU1_G: P8.O3(3)
S0_PMU1_S: P8.N2(2)
S0_RF_A: C13.1 C14.1 C15.1 D3.1(CATHODE_D1) SMP3.1
S0_RF_G: C6.1 C7.1 C8.1 D2.1(CATHODE_D1) SMP2.1
S0_RFIN_A: C16.2 R9.1 SITE0.29(RFIN_A/GND (<750UM))
S0_RFIN_G: C9.2 R5.1 SITE0.31(RFIN_G/GND)
S0_RFIO_A: C11.2 R6.1 SITE0.28(RFIO_A  (<750UM))
S0_RFIO_BT: C1.2 R1.1 SITE0.37(RFIO_BT)
S0_RFIO_G: C4.2 R2.1 SITE0.32(RFIO_G)
S0_RREF_MEM: K9.3 R43.1 SITE0.60(RREF_MEM)
S0_SPI_CLK: K1.7 R15.2
S0_SPI_CLK/PB28: K1.6 SITE0.90(SPI_FLASH_CLK/SD_CLK/GPIOG_3/PB)
S0_SPI_CS: K3.2 R10.1
S0_SPI_CS/PC0: K3.3 SITE0.95(SPI_FLASH_CS/UART1_CTS/SD_CD/GP)
S0_SPI_D0/PB29: K1.3 SITE0.91(SPI_FLASH_DATA0/UART1_RXD/SD_D0)
S0_SPI_D1/PB31: K3.6 SITE0.94(SPI_FLASH_DATA1/UART1_RTS/SD_WP)
S0_SPI_D2/PB30: K2.6 SITE0.92(SPI_FLASH_DATA2/UART1_TXD/SD_D1)
S0_SPI_D3/PB27: K2.3 SITE0.89(SPI_FLASH_DATA3/SD_CMD/GPIOG_2/)
S0_SPI_DATA0: K1.2 R17.2
S0_SPI_DATA1: K3.7 R11.1
S0_SPI_DATA2: K2.7 R16.1
S0_SPI_DATA3: K2.2 R13.2
S0_U1_VC1: K39.5 U1.4(VCTL)
S0_U2_VC1: K39.4 U2.4(VCTL)
S0_VA09_MIPI: BD37.2 C152.1 SITE0.84(VA09_MIPI/VA09_CK/VA09_DA)
S0_VA09_PLL: BD1.2 C44.1 SITE0.11(VA09_PLL/VD09_CORE0)
S0_VA09_USB: BD2.2 C45.1 SITE0.77(VA09_USB)
S0_VA13_AFE: BD20.2 C88.1 SITE0.19(VA13_AFE)
S0_VA13_SYN: BD16.2 C78.1 SITE0.23(VR13_SYN)
S0_VA33_SYN: BD13.2 C64.1 SITE0.24(VR33_SYN)
S0_VA33_XTAL: BD5.2 C48.1 SITE0.20(VA33_XTAL)
S0_VD09_CORE1: C47.1 R76.2 SITE0.56(VD09_CORE1/VD09MEM0)
S0_VD09_CORE2: C49.1 R77.2 SITE0.64(VD09_CORE2/VD09_MEM1)
S0_VD09_CORE3: C54.1 R78.2 SITE0.87(VD09_CORE3/VA09_PLL)
S0_VD09_CORE4: C58.1 R79.2 SITE0.98(VD09_CORE4)
S0_VD13_FE: BD19.2 C85.1 SITE0.36(VD13_FE)
S0_VD13_RF: BD17.2 C79.1 SITE0.25(VD13_RF)
S0_VD33_ALL: BD3.1 BD5.1 BD7.1 BD9.1 BD11.1 BD12.1 BD13.1 BD15.1 BD18.1 BD21.1 BD22.1 BD23.1 BD28.1 BD29.1 BD30.1 BD31.1 BD32.1 BD36.1 C67.1 C96.1 C101.1 C122.1 C129.1 J5.1 J6.1 K23.2 K23.7
S0_VD33_CM_BT: BD21.2 C90.1 C91.1 SITE0.35(VD33_CM_BT)
S0_VD33_EX_FLASH: BD32.2 C22.1 C127.1 C128.1 R12.2 R14.1 U3.8(VCC)
S0_VD33_IO0: BD7.2 C52.1 SITE0.9(VA33_PLL/VD33_IO0)
S0_VD33_IO2: BD9.2 C56.1 SITE0.59(VD33_IO2/VD33_MEM)
S0_VD33_IO3: BD11.2 C59.1 SITE0.70(VD33_IO3/VDD_IO4/VA33_USB)
S0_VD33_IO6: BD12.2 C61.1 SITE0.88(VD33_IO6/VDD33_IO5/VD33_FLASH)
S0_VD33_SPS_AUD: BD30.2 C123.1 C124.1 SITE0.1(VD33_SPS_AUD)
S0_VD33_SPS_DCORE: BD28.2 C111.1 C112.1 SITE0.2(VD33_SPS_DCORE)
S0_VD33_SPS_MEM: BD31.2 C125.1 C126.1 SITE0.76(VD33_SPS_MEM)
S0_VD33PA_A: BD23.2 C99.1 C100.1 SITE0.27(VD33PA_A)
S0_VD33PA_BT: BD18.2 C83.1 C84.1 SITE0.38(VD33PA_BT)
S0_VD33PA_G: BD15.2 C76.1 C77.1 SITE0.33(VD33PA_G)
S0_VD33PAD_A: BD22.2 C97.1 C98.1 SITE0.26(VD33PAD_A)
S0_VD33PAD_G: BD36.2 C73.1 C74.1 SITE0.34(VD33PAD_G)
S0_VD1833_IO1: BD3.2 C46.1 SITE0.14(VD1833_IO1)
S0_VD1833_SDIO: BD29.2 C118.1 C119.1 SITE0.93(VD1833_SDIO)
S0_VD_MEM0: C102.1 R81.2 SITE0.61(VD_MEM0)
S0_VD_MEM1: C105.1 R82.2 SITE0.62(VD_MEM1)
S0_VD_MEM2: C107.1 R83.2 SITE0.65(VD_MEM2)
S0_VDD09: K22.2 K22.5 K31.4 R48.1 S0_VDD09.1(TP)
S0_VDD09_CH: K37.4 ST13.1
S0_VDD18_A: K25.2 K25.5 K26.3 K32.4 R55.1 S0_VDD18_A.1(TP)
S0_VDD18_D: K28.2 K28.5 K30.4 R29.2 R53.1 S0_VDD18_D.1(TP)
S0_VDD33: BD33.2 C130.1 R19.1 R24.1 R30.1 R38.2 R61.2 U1.6(VDD) U2.6(VDD)
S0_VDD33_J1: J1.1 R19.2
