# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UNK1C12  NC/1.2P-50-N-S2-MU  [C0201]  324.5 194.4 180 top
UNK1C13  10P-50-N-S2-MU  [C0201]  324.8 186.76 90 top
UNK1C14  NC/10P-50-N-S2-MU  [C0201]  325.1 186.46 0 top
UNK1C15  CNC-S2  [C0201]  325.1 184.64 0 top
UNK1C16  NC/1P-25-N-S2-WA  [C0201]  325.1 196.37 180 bottom
UNK1C17  NC/0.1U-35-X-S2-MU  [C0201]  333.62 200.2 180 bottom
UNK1C18  NC/0.1U-35-X-S2-MU  [C0201]  333.62 199.35 180 bottom
UNK1C19  NC/1.2P-50-N-S2-MU  [C0201]  324.5 194.4 180 bottom
UNK1C20  0.1U-35-X-S2-MU  [C0201]  333.62 197.12 0 bottom
UNK1C21  0.1U-35-X-S2-MU  [C0201]  333.62 197.97 0 bottom
UNK1C22  0.1U-16-X-S4-MU  [C0402]  243.74 224.55 90 top
UNK1C23  0.9P-50-N-S4-MU  [C0402]  316.6 203.41 270 top
UNK1C24  0.1U-25-X-S4-TY  [C0402]  223.76 225.24 0 bottom
UNK1C25  0.9P-50-N-S4-MU  [C0402]  316.6 200.64 90 top
UNK1C38  1P-50-N-S4-WA  [C0402]  215.74 216.86 0 bottom
UNK1C39  22P-50-N-S4-AVX  [C0402]  212.34 216.86 0 bottom
UNK1C40  1P-50-N-S4-WA  [C0402]  215.74 224.13 0 bottom
UNK1C41  22P-50-N-S4-AVX  [C0402]  212.34 224.13 0 bottom
UNK1C44  0.1U-35-X-S2-MU  [C0201]  323.93 205.5 0 bottom
UNK1C45  0.1U-35-X-S2-MU  [C0201]  332.4 209.41 270 bottom
UNK1C46  0.1U-35-X-S2-MU  [C0201]  323.93 204.65 0 bottom
UNK1C47  0.1U-35-X-S2-MU  [C0201]  332.63 202.19 180 bottom
UNK1C48  0.1U-35-X-S2-MU  [C0201]  319.77 202.74 180 top
UNK1C49  0.1U-35-X-S2-MU  [C0201]  332.63 205.91 180 bottom
UNK1C52  0.1U-35-X-S2-MU  [C0201]  323.93 206.35 0 bottom
UNK1C53  10U-10-X-S4-SS  [C0402]  307.75 206.49 90 bottom
UNK1C54  0.1U-35-X-S2-MU  [C0201]  328.82 209.41 270 bottom
UNK1C55  0.1U-25-X-S4-TY  [C0402]  310.03 206.49 90 bottom
UNK1C56  0.1U-35-X-S2-MU  [C0201]  336.74 203.42 0 top
UNK1C57  NC/10U-10-X-S4-SS  [C0402]  308.88 206.49 90 bottom
UNK1C58  0.1U-35-X-S2-MU  [C0201]  323.66 213.94 90 top
UNK1C59  0.1U-35-X-S2-MU  [C0201]  332.63 207.4 180 bottom
UNK1C60  10U-10-X-S4-SS  [C0402]  339.1 212.43 0 bottom
UNK1C61  0.1U-35-X-S2-MU  [C0201]  327.88 209.4 270 bottom
UNK1C62  22U-25-X-S8-MU  [C0805]  307.63 214.73 0 bottom
UNK1C63  22U-25-X-S8-MU  [C0805]  307.63 216.76 0 bottom
UNK1C64  0.1U-35-X-S2-MU  [C0201]  319.77 200.61 180 top
UNK1C65  47U-16-T-SC  [CODE_C]  241.16 230.5 180 bottom
UNK1C66  10U-16-T-SA  [CODE_A]  241.19 230.5 180 top
UNK1C67  10U-10-X-S4-SS  [C0402]  339.1 211.31 0 bottom
UNK1C68  22U-10-T-SA  [CODE_A]  338.49 169.02 0 bottom
UNK1C69  22U-10-T-SA  [CODE_A]  338.49 171.61 0 bottom
UNK1C70  22U-10-T-SA  [CODE_A]  338.49 174.18 0 bottom
UNK1C71  22U-10-T-SA  [CODE_A]  338.49 171.61 0 top
UNK1C72  22U-10-T-SA  [CODE_A]  338.49 169.02 0 top
UNK1C73  10U-10-X-S4-SS  [C0402]  315.28 197.76 180 bottom
UNK1C74  0.1U-35-X-S2-MU  [C0201]  326.58 200.79 90 bottom
UNK1C75  0.1U-35-X-S2-MU  [C0201]  336.74 200.67 0 top
UNK1C76  10U-10-X-S4-SS  [C0402]  320.45 196.1 180 bottom
UNK1C77  0.1U-35-X-S2-MU  [C0201]  325.76 200.79 90 bottom
UNK1C78  0.1U-35-X-S2-MU  [C0201]  319.77 201.29 180 top
UNK1C79  0.1U-35-X-S2-MU  [C0201]  319.77 199.92 180 top
UNK1C83  10U-10-X-S4-SS  [C0402]  335.74 198.66 0 bottom
UNK1C84  0.1U-35-X-S2-MU  [C0201]  328.09 200.79 90 bottom
UNK1C85  0.1U-35-X-S2-MU  [C0201]  327.36 200.79 90 bottom
UNK1C88  0.1U-35-X-S2-MU  [C0201]  319.77 203.4 180 top
UNK1C89  10U-10-X-S4-SS  [C0402]  314.26 206.99 180 bottom
UNK1C90  10U-10-X-S4-SS  [C0402]  335.74 195.29 0 bottom
UNK1C91  0.1U-35-X-S2-MU  [C0201]  327.68 198.01 0 bottom
UNK1C92  22U-25-X-S8-MU  [C0805]  347.46 171.07 180 bottom
UNK1C93  22U-25-X-S8-MU  [C0805]  347.46 171.07 180 top
UNK1C94  47U-16-T-SC  [CODE_C]  347.01 167.76 180 bottom
UNK1C95  10U-16-T-SA  [CODE_A]  347.01 167.76 180 top
UNK1C96  10U-10-X-S4-SS  [C0402]  337.82 198.66 0 bottom
UNK1C97  10U-10-X-S4-SS  [C0402]  321.83 190.88 270 top
UNK1C98  0.1U-35-X-S2-MU  [C0201]  320.89 191.78 270 top
UNK1C99  10U-10-X-S4-SS  [C0402]  322.77 192.94 270 top
UNK1C100  0.1U-35-X-S2-MU  [C0201]  323.05 196.09 270 top
UNK1C101  10U-10-X-S4-SS  [C0402]  314.26 205.15 180 bottom
UNK1C102  0.1U-35-X-S2-MU  [C0201]  332.63 203.7 180 bottom
UNK1C105  0.1U-35-X-S2-MU  [C0201]  332.63 204.49 180 bottom
UNK1C106  10U-10-X-S4-SS  [C0402]  337.65 225.88 90 bottom
UNK1C107  0.1U-35-X-S2-MU  [C0201]  336.74 204.79 0 top
UNK1C108  0.1U-25-X-S4-TY  [C0402]  336.53 225.88 90 bottom
UNK1C109  NC/10U-10-X-S4-SS  [C0402]  338.77 225.88 90 bottom
UNK1C110  1U-10-X-S4-MU  [C0402]  338.36 200.67 180 top
UNK1C111  10U-10-X-S4-SS  [C0402]  316.81 207.48 270 top
UNK1C112  0.1U-35-X-S2-MU  [C0201]  318.83 208.2 270 top
UNK1C113  10U-25-X-S6-MU  [C0603]  342.96 205.99 90 bottom
UNK1C116  22U-25-X-S8-MU  [C0805]  328.03 218.11 180 bottom
UNK1C117  22U-25-X-S8-MU  [C0805]  328.02 220.27 180 bottom
UNK1C118  10U-10-X-S4-SS  [C0402]  325.72 215.27 90 bottom
UNK1C119  0.1U-35-X-S2-MU  [C0201]  326.94 209.4 270 bottom
UNK1C120  47U-16-T-SC  [CODE_C]  261.69 228.75 270 bottom
UNK1C121  10U-16-T-SA  [CODE_A]  261.69 228.75 270 top
UNK1C122  10U-10-X-S4-SS  [C0402]  337.82 197.55 0 bottom
UNK1C123  10U-10-X-S4-SS  [C0402]  316.28 211.28 135 top
UNK1C124  0.1U-35-X-S2-MU  [C0201]  319.77 210.08 180 top
UNK1C125  10U-10-X-S4-SS  [C0402]  333.38 215.27 90 top
UNK1C126  0.1U-35-X-S2-MU  [C0201]  333.33 213.89 180 top
UNK1C127  10U-10-X-S4-SS  [C0402]  245.01 224.55 90 top
UNK1C128  0.1U-35-X-S2-MU  [C0201]  242.47 224.55 90 top
UNK1C129  10U-10-X-S4-SS  [C0402]  313.26 198.82 180 bottom
UNK1C130  0.1U-25-X-S4-TY  [C0402]  319.18 86.06 90 bottom
UNK1C131  22U-10-T-SA  [CODE_A]  324.72 88.62 0 bottom
UNK1C132  22U-10-T-SA  [CODE_A]  324.72 83.49 0 top
UNK1C133  22U-10-T-SA  [CODE_A]  324.72 86.06 0 top
UNK1C134  22U-10-T-SA  [CODE_A]  324.72 86.06 0 bottom
UNK1C135  22U-10-T-SA  [CODE_A]  324.72 83.49 0 bottom
UNK1C136  10U-10-X-S4-SS  [C0402]  327.84 225.88 90 bottom
UNK1C137  0.1U-25-X-S4-TY  [C0402]  326.72 225.88 90 bottom
UNK1C138  NC/10U-10-X-S4-SS  [C0402]  328.95 225.88 90 bottom
UNK1C139  22U-25-X-S8-MU  [C0805]  316.49 225.56 270 bottom
UNK1C140  47U-16-T-SC  [CODE_C]  266.31 228.75 270 bottom
UNK1C141  10U-16-T-SA  [CODE_A]  266.31 228.75 270 top
UNK1C142  22U-25-X-S8-MU  [C0805]  318.79 225.56 270 bottom
UNK1C143  NC/10P-50-N-S4-WA  [C0402]  337 208.8 180 bottom
UNK1C144  NC/10P-50-N-S4-WA  [C0402]  337 207.63 180 bottom
UNK1C145  NC/10P-50-N-S4-WA  [C0402]  187.11 209.49 90 top
UNK1C146  NC/10P-50-N-S4-WA  [C0402]  187.11 212.69 90 top
UNK1C147  NC/10P-50-N-S4-WA  [C0402]  187.11 202.22 90 top
UNK1C148  NC/10P-50-N-S4-WA  [C0402]  187.11 205.42 90 top
UNK1C149  NC/10P-50-N-S4-WA  [C0402]  187.11 218.12 90 top
UNK1C150  NC/10P-50-N-S4-WA  [C0402]  187.11 221.32 90 top
UNK1C152  0.1U-35-X-S2-MU  [C0201]  329.67 209.41 270 bottom
UNK1C153  CNC-S2  [C0201]  332.12 205.24 180 bottom
UNK1D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  333.73 190.31 30 top
UNK1D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  330.24 186.49 0 top
UNK1D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  325.23 185.52 180 top
UNK1J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  194.53 225.86 270 top
UNK1J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  313.78 83.52 270 top
UNK1J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  188.31 225.86 270 top
UNK1J4  HDR-8X1-M  [JP_8P_100]  197.81 136.74 270 top
UNK1J5  HDR-1X1-M  [JP_1P_RD070_040]  328.7 91.4 90 top
UNK1J6  HDR-2X1-M  [JP_2P_100]  325.79 91.4 90 top
UNK1J7  HDR-2X1-M  [JP_2P_100]  302.68 115.4 0 top
UNK1J8  HDR-2X1-M  [JP_2P_100]  298.87 115.4 0 top
UNK1J9  HDR-2X1-M  [JP_2P_100]  306.49 115.4 0 top
UNK1K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 221.05 0 bottom
UNK1K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 214.04 0 bottom
UNK1K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 207.03 0 bottom
UNK1K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 228.9 0 bottom
UNK1K5  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  345.5 228.94 270 bottom
UNK1K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  322.5 99.22 90 bottom
UNK1K7  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  253.64 229.28 270 bottom
UNK1K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 220.5 0 bottom
UNK1K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  349.74 181.5 180 bottom
UNK1K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  230.24 211.86 0 bottom
UNK1K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 204.6 0 bottom
UNK1K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 211.86 0 bottom
UNK1K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 211.86 0 bottom
UNK1K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  230.24 204.6 0 bottom
UNK1K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 204.6 0 bottom
UNK1K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  227.27 228.9 0 bottom
UNK1K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  227.27 220.5 0 bottom
UNK1K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 220.5 0 bottom
UNK1K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  323.15 222.11 90 bottom
UNK1K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  310.68 210.58 0 bottom
UNK1K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  307.58 200.09 90 bottom
UNK1K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  331.3 173.15 90 bottom
UNK1K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  321.15 230.56 0 bottom
UNK1K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  349.74 175.14 180 bottom
UNK1K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  334.18 230.49 0 bottom
UNK1K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  332.97 222.11 90 bottom
UNK1K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 229.1 270 bottom
UNK1K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 217.67 270 bottom
UNK1K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 206.24 270 bottom
UNK1K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 211.86 0 bottom
UNK1K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 204.6 0 bottom
UNK1K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 220.5 0 bottom
UNK1K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  315.53 99.22 90 bottom
UNK1L1  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  311.97 206.04 270 bottom
UNK1L3  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  337.28 223.34 90 bottom
UNK1L4  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  327.47 223.34 90 bottom
UNK1R1  0-5-S2  [R0201]  330.07 196.08 315 top
UNK1R2  0-5-S2  [R0201]  328.29 195.34 315 top
UNK1R3  0-5-S2  [R0201]  330.67 192.05 270 top
UNK1R4  NC/0-5-S2  [R0201]  330.37 192.35 0 top
UNK1R5  0-5-S2  [R0201]  326.57 194.73 270 bottom
UNK1R6  0-5-S2  [R0201]  324.8 195.39 270 top
UNK1R7  0-5-S2  [R0201]  324.8 188.04 270 top
UNK1R8  NC/0-5-S2  [R0201]  325.1 188.34 180 top
UNK1R9  0-5-S2  [R0201]  324.8 195.39 270 bottom
UNK1R10  0-5-S4  [R0402]  243.59 205.13 90 top
UNK1R11  0-5-S4  [R0402]  242.32 205.13 90 top
UNK1R12  NC/10K-1-S4  [R0402]  239.68 224.55 90 top
UNK1R13  0-5-S4  [R0402]  240.95 224.55 90 top
UNK1R14  NC/10K-1-S4  [R0402]  241.05 205.13 90 top
UNK1R15  0-5-S4  [R0402]  238.41 224.55 90 top
UNK1R16  0-5-S4  [R0402]  239.78 205.13 90 top
UNK1R17  0-5-S4  [R0402]  237.14 224.55 90 top
UNK1R18  NC/10K-1-S4  [R0402]  238.67 205.13 90 top
UNK1R19  0-5-S4  [R0402]  196.97 225.86 180 bottom
UNK1R20  0-5-S4  [R0402]  196.97 230.94 180 bottom
UNK1R21  0-5-S4  [R0402]  196.97 233.48 180 bottom
UNK1R22  45.3-1-S4  [R0402]  340.29 230.93 90 bottom
UNK1R23  45.3-1-S4  [R0402]  248.43 231.28 90 bottom
UNK1R24  0-5-S4  [R0402]  316.37 83.54 180 bottom
UNK1R25  45.3-1-S4  [R0402]  340.29 226.94 270 bottom
UNK1R26  45.3-1-S4  [R0402]  248.43 227.29 270 bottom
UNK1R27  0-5-S4  [R0402]  316.37 88.62 180 bottom
UNK1R28  0-5-S4  [R0402]  316.37 91.16 180 bottom
UNK1R29  NC/45.3-1-S4  [R0402]  226.55 224.66 90 bottom
UNK1R30  0-5-S4  [R0402]  190.74 225.86 180 bottom
UNK1R31  0-5-S4  [R0402]  190.74 230.94 180 bottom
UNK1R32  0-5-S4  [R0402]  190.74 233.48 180 bottom
UNK1R33  NC/45.3-1-S4  [R0402]  225.41 224.66 270 bottom
UNK1R34  10K-1-S4  [R0402]  197.81 134.2 270 bottom
UNK1R35  10K-1-S4  [R0402]  200.35 134.2 270 bottom
UNK1R36  10K-1-S4  [R0402]  202.89 134.2 270 bottom
UNK1R37  10K-1-S4  [R0402]  205.43 134.2 270 bottom
UNK1R38  0-5-S4  [R0402]  200.22 124.04 0 bottom
UNK1R39  10K-1-S4  [R0402]  207.97 134.2 270 bottom
UNK1R40  10K-1-S4  [R0402]  210.51 134.2 270 bottom
UNK1R41  10K-1-S4  [R0402]  213.05 134.2 270 bottom
UNK1R42  0-5-S4  [R0402]  213.17 124.04 180 bottom
UNK1R43  12K-1-S4  [R0402]  341.23 205.74 0 bottom
UNK1R45  32.4-1-S4  [R0402]  224 210.65 90 bottom
UNK1R47  32.4-1-S4  [R0402]  224 203.39 90 bottom
UNK1R48  0-5-S4  [R0402]  303.96 196.59 90 bottom
UNK1R49  NC/0-5-S4  [R0402]  311.19 196.59 90 bottom
UNK1R50  0-5-S4  [R0402]  343.65 174.38 270 top
UNK1R51  NC/0-5-S4  [R0402]  314.8 229.46 270 bottom
UNK1R53  0-5-S4  [R0402]  327.84 232.59 90 bottom
UNK1R54  NC/0-5-S4  [R0402]  327.84 228.39 270 bottom
UNK1R55  0-5-S4  [R0402]  316.65 234.23 180 bottom
UNK1R57  NC/10K-1-S4  [R0402]  203.11 225.27 0 bottom
UNK1R58  NC/10K-1-S4  [R0402]  203.11 232.53 0 bottom
UNK1R59  NC/10K-1-S4  [R0402]  203.11 216.86 0 bottom
UNK1R60  NC/10K-1-S4  [R0402]  203.11 224.13 0 bottom
UNK1R61  0-5-S4  [R0402]  301.97 83.12 0 bottom
UNK1R62  0-5-S4  [R0402]  304.97 83.12 180 bottom
UNK1R63  0-5-S4  [R0402]  221.67 203.39 90 bottom
UNK1R64  0-5-S4  [R0402]  222.84 203.39 90 bottom
UNK1R65  0-5-S4  [R0402]  222.84 205.81 270 bottom
UNK1R66  0-5-S4  [R0402]  221.67 205.81 270 bottom
UNK1R67  0-5-S4  [R0402]  221.67 210.65 90 bottom
UNK1R68  0-5-S4  [R0402]  222.84 210.65 90 bottom
UNK1R69  0-5-S4  [R0402]  222.84 213.07 270 bottom
UNK1R70  0-5-S4  [R0402]  221.67 213.07 270 bottom
UNK1R71  2-5-D-2  [RC02W_27MM]  167.18 230.9 180 bottom
UNK1R72  2-5-D-2  [RC02W_27MM]  167.18 219.47 180 bottom
UNK1R73  2-5-D-2  [RC02W_27MM]  167.18 208.04 180 bottom
UNK1R74  0-5-S4  [R0402]  224 205.81 270 bottom
UNK1R75  0-5-S4  [R0402]  224 213.07 270 bottom
UNK1R76  0-5-S4  [R0402]  341.23 201.38 180 bottom
UNK1R77  0-5-S4  [R0402]  336.99 210.27 180 bottom
UNK1R78  0-5-S4  [R0402]  330.14 215.27 270 bottom
UNK1R79  0-5-S4  [R0402]  324.6 215.27 270 bottom
UNK1R81  0-5-S4  [R0402]  341.23 203.52 180 bottom
UNK1R82  0-5-S4  [R0402]  341.23 206.84 180 bottom
UNK1R83  0-5-S4  [R0402]  341.23 204.64 180 bottom
UNK1SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  335.98 187.27 210 top
UNK1SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  330.67 182.17 180 top
UNK1SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  324.8 181.21 180 top
UNK1ST3  SHORT  [DEFAULT_SHORT_SMALL]  121.33 471.8 0 top
UNK1ST4  SHORT  [DEFAULT_SHORT_SMALL]  124.55 471.8 0 top
UNK1ST5  SHORT  [DEFAULT_SHORT_SMALL]  127.77 471.8 0 top
UNK1ST8  SHORT  [DEFAULT_SHORT_SMALL]  130.99 471.8 0 top
UNK1ST11  SHORT  [DEFAULT_SHORT_SMALL]  105.23 471.8 0 top
UNK1ST12  SHORT  [DEFAULT_SHORT_SMALL]  108.45 471.8 0 top
UNK1ST13  SHORT  [DEFAULT_SHORT_SMALL]  111.67 471.8 0 top
UNK1ST14  SHORT  [DEFAULT_SHORT_SMALL]  114.89 471.8 0 top
UNK1ST15  SHORT  [DEFAULT_SHORT_SMALL]  118.11 471.8 0 top
UNK1ST16  SHORT  [DEFAULT_SHORT_SMALL]  2.22 471.8 0 top
UNK1ST17  SHORT  [DEFAULT_SHORT_SMALL]  5.44 471.8 0 top
UNK1ST18  SHORT  [DEFAULT_SHORT_SMALL]  8.66 471.8 0 top
UNK1ST19  SHORT  [DEFAULT_SHORT_SMALL]  11.88 471.8 0 top
UNK1SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  206.7 127.85 0 top
UNK1SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  303.47 86.93 0 top
UNK1U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  328.89 191.89 270 top
UNK1U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  326.58 187.88 270 top
UNK1U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  241.68 214.1 180 bottom
UNK1Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  314.22 202.03 45 top
UNK2BD1  BD120-1.5A-S4-MU  [FB0402]  361.19 215.24 270 bottom
UNK2BD2  BD120-1.5A-S4-MU  [FB0402]  376.96 212.38 180 bottom
UNK2BD3  BD120-1.5A-S4-MU  [FB0402]  360.15 215.24 270 bottom
UNK2BD5  BD120-1.5A-S4-MU  [FB0402]  357.33 205.67 0 bottom
UNK2BD7  BD120-1.5A-S4-MU  [FB0402]  362.23 215.24 270 bottom
UNK2BD9  BD120-1.5A-S4-MU  [FB0402]  381.2 202.45 180 bottom
UNK2BD11  BD120-1.5A-S4-MU  [FB0402]  376.96 211.34 180 bottom
UNK2BD12  BD120-1.5A-S4-MU  [FB0402]  369.07 215.24 270 bottom
UNK2BD13  BD120-1.5A-S4-MU  [FB0402]  357.36 198.82 0 bottom
UNK2BD15  BD120-1.5A-S4-MU  [FB0402]  360.48 195.03 0 bottom
UNK2BD16  BD120-1.5A-S4-MU  [FB0402]  363.8 201.66 180 bottom
UNK2BD17  BD120-1.5A-S4-MU  [FB0402]  363.8 200.62 180 bottom
UNK2BD18  BD120-1.5A-S4-MU  [FB0402]  375.71 197.57 180 bottom
UNK2BD19  BD120-1.5A-S4-MU  [FB0402]  375.71 196.37 180 bottom
UNK2BD20  BD120-1.5A-S4-MU  [FB0402]  355.79 205.62 270 bottom
UNK2BD21  BD120-1.5A-S4-MU  [FB0402]  375.71 194.23 180 bottom
UNK2BD22  BD120-1.5A-S4-MU  [FB0402]  362.3 191.38 180 bottom
UNK2BD23  BD120-1.5A-S4-MU  [FB0402]  362.3 193.44 0 bottom
UNK2BD27  NC/BD120-1.5A-S4-MU  [FB0402]  472.87 211.55 0 bottom
UNK2BD28  BD120-1.5A-S4-MU  [FB0402]  356.81 208.45 270 bottom
UNK2BD29  BD120-1.5A-S4-MU  [FB0402]  366.81 215.24 270 bottom
UNK2BD30  BD120-1.5A-S4-MU  [FB0402]  356.96 211.26 225 bottom
UNK2BD31  BD120-1.5A-S4-MU  [FB0402]  373.85 214.77 180 bottom
UNK2BD32  BD120-1.5A-S4-MU  [FB0402]  450.32 211.13 90 top
UNK2BD33  BD120-1.5A-S4-MU  [FB0402]  411.31 86.03 270 bottom
UNK2BD34  BD120-1.5A-S4-MU  [FB0402]  363.48 189.65 0 bottom
UNK2BD35  BD120-1.5A-S4-MU  [FB0402]  373.63 194.23 180 bottom
UNK2BD36  BD120-1.5A-S4-MU  [FB0402]  355.32 198.83 0 bottom
UNK2BD37  BD120-1.5A-S4-MU  [FB0402]  371.2 215.24 270 bottom
UNK2C1  NC/1P-25-N-S2-WA  [C0201]  369.16 196.56 45 top
UNK2C2  10P-50-N-S2-MU  [C0201]  373.49 191.58 300 top
UNK2C3  NC/1.2P-50-N-S2-MU  [C0201]  370.97 195.6 45 top
UNK2C4  NC/1P-25-N-S2-WA  [C0201]  367.8 196.25 225 top
UNK2C5  NC/1.2P-50-N-S2-MU  [C0201]  368.77 194.43 225 top
UNK2C6  10P-50-N-S2-MU  [C0201]  370.67 190.77 90 top
UNK2C7  NC/10P-50-N-S2-MU  [C0201]  370.37 190.47 180 top
UNK2C8  CNC-S2  [C0201]  370.37 185.6 180 top
UNK2C9  NC/1P-25-N-S2-WA  [C0201]  366.87 195.72 180 bottom
UNK2C10  NC/1.2P-50-N-S2-MU  [C0201]  366.27 193.75 180 bottom
UNK2C11  NC/1P-25-N-S2-WA  [C0201]  365.1 196.37 180 top
UNK2C12  NC/1.2P-50-N-S2-MU  [C0201]  364.5 194.4 180 top
UNK2C13  10P-50-N-S2-MU  [C0201]  364.8 186.76 90 top
UNK2C14  NC/10P-50-N-S2-MU  [C0201]  365.1 186.46 0 top
UNK2C15  CNC-S2  [C0201]  365.1 184.64 0 top
UNK2C16  NC/1P-25-N-S2-WA  [C0201]  365.1 196.37 180 bottom
UNK2C17  NC/0.1U-35-X-S2-MU  [C0201]  373.62 200.2 180 bottom
UNK2C18  NC/0.1U-35-X-S2-MU  [C0201]  373.62 199.35 180 bottom
UNK2C19  NC/1.2P-50-N-S2-MU  [C0201]  364.5 194.4 180 bottom
UNK2C20  0.1U-35-X-S2-MU  [C0201]  373.62 197.12 0 bottom
UNK2C21  0.1U-35-X-S2-MU  [C0201]  373.62 197.97 0 bottom
UNK2C22  0.1U-16-X-S4-MU  [C0402]  452.86 211.16 270 top
UNK2C23  0.9P-50-N-S4-MU  [C0402]  356.6 203.41 270 top
UNK2C24  0.1U-25-X-S4-TY  [C0402]  472.84 210.47 180 bottom
UNK2C25  0.9P-50-N-S4-MU  [C0402]  356.6 200.64 90 top
UNK2C38  1P-50-N-S4-WA  [C0402]  480.86 218.85 180 bottom
UNK2C39  22P-50-N-S4-AVX  [C0402]  484.26 218.85 180 bottom
UNK2C40  1P-50-N-S4-WA  [C0402]  480.86 211.58 180 bottom
UNK2C41  22P-50-N-S4-AVX  [C0402]  484.26 211.58 180 bottom
UNK2C44  0.1U-35-X-S2-MU  [C0201]  363.93 205.5 0 bottom
UNK2C45  0.1U-35-X-S2-MU  [C0201]  372.4 209.41 270 bottom
UNK2C46  0.1U-35-X-S2-MU  [C0201]  363.93 204.65 0 bottom
UNK2C47  0.1U-35-X-S2-MU  [C0201]  372.63 202.19 180 bottom
UNK2C48  0.1U-35-X-S2-MU  [C0201]  359.77 202.74 180 top
UNK2C49  0.1U-35-X-S2-MU  [C0201]  372.63 205.91 180 bottom
UNK2C52  0.1U-35-X-S2-MU  [C0201]  363.93 206.35 0 bottom
UNK2C53  10U-10-X-S4-SS  [C0402]  347.75 206.49 90 bottom
UNK2C54  0.1U-35-X-S2-MU  [C0201]  368.82 209.41 270 bottom
UNK2C55  0.1U-25-X-S4-TY  [C0402]  350.03 206.49 90 bottom
UNK2C56  0.1U-35-X-S2-MU  [C0201]  376.74 203.42 0 top
UNK2C57  NC/10U-10-X-S4-SS  [C0402]  348.88 206.49 90 bottom
UNK2C58  0.1U-35-X-S2-MU  [C0201]  363.66 213.94 90 top
UNK2C59  0.1U-35-X-S2-MU  [C0201]  372.63 207.4 180 bottom
UNK2C60  10U-10-X-S4-SS  [C0402]  379.1 212.43 0 bottom
UNK2C61  0.1U-35-X-S2-MU  [C0201]  367.88 209.4 270 bottom
UNK2C62  22U-25-X-S8-MU  [C0805]  347.63 214.73 0 bottom
UNK2C63  22U-25-X-S8-MU  [C0805]  347.63 216.76 0 bottom
UNK2C64  0.1U-35-X-S2-MU  [C0201]  359.77 200.61 180 top
UNK2C65  47U-16-T-SC  [CODE_C]  455.45 205.21 0 bottom
UNK2C66  10U-16-T-SA  [CODE_A]  455.41 205.21 0 top
UNK2C67  10U-10-X-S4-SS  [C0402]  379.1 211.31 0 bottom
UNK2C68  22U-10-T-SA  [CODE_A]  378.49 169.02 0 bottom
UNK2C69  22U-10-T-SA  [CODE_A]  378.49 171.61 0 bottom
UNK2C70  22U-10-T-SA  [CODE_A]  378.49 174.18 0 bottom
UNK2C71  22U-10-T-SA  [CODE_A]  378.49 171.61 0 top
UNK2C72  22U-10-T-SA  [CODE_A]  378.49 169.02 0 top
UNK2C73  10U-10-X-S4-SS  [C0402]  355.28 197.76 180 bottom
UNK2C74  0.1U-35-X-S2-MU  [C0201]  366.58 200.79 90 bottom
UNK2C75  0.1U-35-X-S2-MU  [C0201]  376.74 200.67 0 top
UNK2C76  10U-10-X-S4-SS  [C0402]  360.45 196.1 180 bottom
UNK2C77  0.1U-35-X-S2-MU  [C0201]  365.76 200.79 90 bottom
UNK2C78  0.1U-35-X-S2-MU  [C0201]  359.77 201.29 180 top
UNK2C79  0.1U-35-X-S2-MU  [C0201]  359.77 199.92 180 top
UNK2C83  10U-10-X-S4-SS  [C0402]  375.74 198.66 0 bottom
UNK2C84  0.1U-35-X-S2-MU  [C0201]  368.09 200.79 90 bottom
UNK2C85  0.1U-35-X-S2-MU  [C0201]  367.36 200.79 90 bottom
UNK2C88  0.1U-35-X-S2-MU  [C0201]  359.77 203.4 180 top
UNK2C89  10U-10-X-S4-SS  [C0402]  354.26 206.99 180 bottom
UNK2C90  10U-10-X-S4-SS  [C0402]  375.74 195.29 0 bottom
UNK2C91  0.1U-35-X-S2-MU  [C0201]  367.68 198.01 0 bottom
UNK2C92  22U-25-X-S8-MU  [C0805]  386.32 171.07 180 bottom
UNK2C93  22U-25-X-S8-MU  [C0805]  386.32 171.07 180 top
UNK2C94  47U-16-T-SC  [CODE_C]  385.62 167.76 180 bottom
UNK2C95  10U-16-T-SA  [CODE_A]  385.62 167.76 180 top
UNK2C96  10U-10-X-S4-SS  [C0402]  377.82 198.66 0 bottom
UNK2C97  10U-10-X-S4-SS  [C0402]  361.83 190.88 270 top
UNK2C98  0.1U-35-X-S2-MU  [C0201]  360.89 191.78 270 top
UNK2C99  10U-10-X-S4-SS  [C0402]  362.77 192.94 270 top
UNK2C100  0.1U-35-X-S2-MU  [C0201]  363.05 196.09 270 top
UNK2C101  10U-10-X-S4-SS  [C0402]  354.26 205.15 180 bottom
UNK2C102  0.1U-35-X-S2-MU  [C0201]  372.63 203.7 180 bottom
UNK2C105  0.1U-35-X-S2-MU  [C0201]  372.63 204.49 180 bottom
UNK2C106  10U-10-X-S4-SS  [C0402]  377.65 225.88 90 bottom
UNK2C107  0.1U-35-X-S2-MU  [C0201]  376.74 204.79 0 top
UNK2C108  0.1U-25-X-S4-TY  [C0402]  376.53 225.88 90 bottom
UNK2C109  NC/10U-10-X-S4-SS  [C0402]  378.77 225.88 90 bottom
UNK2C110  1U-10-X-S4-MU  [C0402]  378.36 200.67 180 top
UNK2C111  10U-10-X-S4-SS  [C0402]  356.81 207.48 270 top
UNK2C112  0.1U-35-X-S2-MU  [C0201]  358.83 208.2 270 top
UNK2C113  10U-25-X-S6-MU  [C0603]  382.96 205.99 90 bottom
UNK2C116  22U-25-X-S8-MU  [C0805]  368.03 218.11 180 bottom
UNK2C117  22U-25-X-S8-MU  [C0805]  368.02 220.27 180 bottom
UNK2C118  10U-10-X-S4-SS  [C0402]  365.72 215.27 90 bottom
UNK2C119  0.1U-35-X-S2-MU  [C0201]  366.94 209.4 270 bottom
UNK2C120  47U-16-T-SC  [CODE_C]  433.52 228.37 270 bottom
UNK2C121  10U-16-T-SA  [CODE_A]  433.52 228.37 270 top
UNK2C122  10U-10-X-S4-SS  [C0402]  377.82 197.55 0 bottom
UNK2C123  10U-10-X-S4-SS  [C0402]  356.28 211.28 135 top
UNK2C124  0.1U-35-X-S2-MU  [C0201]  359.77 210.08 180 top
UNK2C125  10U-10-X-S4-SS  [C0402]  373.38 215.27 90 top
UNK2C126  0.1U-35-X-S2-MU  [C0201]  373.33 213.89 180 top
UNK2C127  10U-10-X-S4-SS  [C0402]  451.59 211.16 270 top
UNK2C128  0.1U-35-X-S2-MU  [C0201]  454.13 211.16 270 top
UNK2C129  10U-10-X-S4-SS  [C0402]  353.26 198.82 180 bottom
UNK2C130  0.1U-25-X-S4-TY  [C0402]  410.22 86.06 90 bottom
UNK2C131  22U-10-T-SA  [CODE_A]  415.76 88.62 0 bottom
UNK2C132  22U-10-T-SA  [CODE_A]  415.76 83.49 0 top
UNK2C133  22U-10-T-SA  [CODE_A]  415.76 86.06 0 top
UNK2C134  22U-10-T-SA  [CODE_A]  415.76 86.06 0 bottom
UNK2C135  22U-10-T-SA  [CODE_A]  415.76 83.49 0 bottom
UNK2C136  10U-10-X-S4-SS  [C0402]  367.84 225.88 90 bottom
UNK2C137  0.1U-25-X-S4-TY  [C0402]  366.72 225.88 90 bottom
UNK2C138  NC/10U-10-X-S4-SS  [C0402]  368.95 225.88 90 bottom
UNK2C139  22U-25-X-S8-MU  [C0805]  356.49 225.56 270 bottom
UNK2C140  47U-16-T-SC  [CODE_C]  421.42 240.74 90 bottom
UNK2C141  10U-16-T-SA  [CODE_A]  421.42 240.74 90 top
UNK2C142  22U-25-X-S8-MU  [C0805]  358.79 225.56 270 bottom
UNK2C143  NC/10P-50-N-S4-WA  [C0402]  377 208.8 180 bottom
UNK2C144  NC/10P-50-N-S4-WA  [C0402]  377 207.63 180 bottom
UNK2C145  NC/10P-50-N-S4-WA  [C0402]  509.5 226.22 270 top
UNK2C146  NC/10P-50-N-S4-WA  [C0402]  509.5 223.02 270 top
UNK2C147  NC/10P-50-N-S4-WA  [C0402]  509.5 233.49 270 top
UNK2C148  NC/10P-50-N-S4-WA  [C0402]  509.5 230.29 270 top
UNK2C149  NC/10P-50-N-S4-WA  [C0402]  509.5 217.59 270 top
UNK2C150  NC/10P-50-N-S4-WA  [C0402]  509.5 214.39 270 top
UNK2C152  0.1U-35-X-S2-MU  [C0201]  369.67 209.41 270 bottom
UNK2C153  CNC-S2  [C0201]  372.12 205.24 180 bottom
UNK2D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  373.73 190.31 30 top
UNK2D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  370.24 186.49 0 top
UNK2D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  365.23 185.52 180 top
UNK2J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  502.07 209.86 90 top
UNK2J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  404.81 83.52 270 top
UNK2J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  508.3 209.86 90 top
UNK2J4  HDR-8X1-M  [JP_8P_100]  482.67 141.57 270 top
UNK2J5  HDR-1X1-M  [JP_1P_RD070_040]  419.74 91.4 90 top
UNK2J6  HDR-2X1-M  [JP_2P_100]  416.82 91.4 90 top
UNK2J7  HDR-2X1-M  [JP_2P_100]  486.2 115.4 0 top
UNK2J8  HDR-2X1-M  [JP_2P_100]  490.01 115.4 0 top
UNK2J9  HDR-2X1-M  [JP_2P_100]  482.39 115.4 0 top
UNK2K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 214.66 180 bottom
UNK2K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 221.67 180 bottom
UNK2K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 228.68 180 bottom
UNK2K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 206.81 180 bottom
UNK2K5  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  385.5 228.94 270 bottom
UNK2K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  413.53 99.22 90 bottom
UNK2K7  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  442.97 206.43 90 bottom
UNK2K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 215.21 180 bottom
UNK2K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  389.74 181.5 180 bottom
UNK2K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  466.36 223.85 180 bottom
UNK2K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 231.11 180 bottom
UNK2K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 223.85 180 bottom
UNK2K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 223.85 180 bottom
UNK2K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  466.36 231.11 180 bottom
UNK2K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 231.11 180 bottom
UNK2K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  469.33 206.81 180 bottom
UNK2K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  469.33 215.21 180 bottom
UNK2K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 215.21 180 bottom
UNK2K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  363.15 222.11 90 bottom
UNK2K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  350.68 210.58 0 bottom
UNK2K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  347.58 200.09 90 bottom
UNK2K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  371.3 173.15 90 bottom
UNK2K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  361.15 230.56 0 bottom
UNK2K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  389.74 175.14 180 bottom
UNK2K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  374.18 230.49 0 bottom
UNK2K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  372.97 222.11 90 bottom
UNK2K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 206.62 90 bottom
UNK2K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 218.05 90 bottom
UNK2K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 229.48 90 bottom
UNK2K33  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  404.95 173.14 90 bottom
UNK2K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 223.85 180 bottom
UNK2K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 231.11 180 bottom
UNK2K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 215.21 180 bottom
UNK2K37  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 206.81 180 bottom
UNK2K38  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  398.61 173.14 90 bottom
UNK2K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  406.57 99.22 90 bottom
UNK2L1  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  351.97 206.04 270 bottom
UNK2L3  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  377.28 223.34 90 bottom
UNK2L4  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  367.47 223.34 90 bottom
UNK2R1  0-5-S2  [R0201]  370.07 196.08 315 top
UNK2R2  0-5-S2  [R0201]  368.29 195.34 315 top
UNK2R3  0-5-S2  [R0201]  370.67 192.05 270 top
UNK2R4  NC/0-5-S2  [R0201]  370.37 192.35 0 top
UNK2R5  0-5-S2  [R0201]  366.57 194.73 270 bottom
UNK2R6  0-5-S2  [R0201]  364.8 195.39 270 top
UNK2R7  0-5-S2  [R0201]  364.8 188.04 270 top
UNK2R8  NC/0-5-S2  [R0201]  365.1 188.34 180 top
UNK2R9  0-5-S2  [R0201]  364.8 195.39 270 bottom
UNK2R10  0-5-S4  [R0402]  453.01 230.58 270 top
UNK2R11  0-5-S4  [R0402]  454.28 230.58 270 top
UNK2R12  NC/10K-1-S4  [R0402]  456.92 211.16 270 top
UNK2R13  0-5-S4  [R0402]  455.65 211.16 270 top
UNK2R14  NC/10K-1-S4  [R0402]  455.55 230.58 270 top
UNK2R15  0-5-S4  [R0402]  458.19 211.16 270 top
UNK2R16  0-5-S4  [R0402]  456.82 230.58 270 top
UNK2R17  0-5-S4  [R0402]  459.46 211.16 270 top
UNK2R18  NC/10K-1-S4  [R0402]  457.94 230.58 270 top
UNK2R19  0-5-S4  [R0402]  499.63 209.86 0 bottom
UNK2R20  0-5-S4  [R0402]  499.63 204.78 0 bottom
UNK2R21  0-5-S4  [R0402]  499.63 202.24 0 bottom
UNK2R22  45.3-1-S4  [R0402]  380.29 230.93 90 bottom
UNK2R23  45.3-1-S4  [R0402]  448.17 204.43 270 bottom
UNK2R24  0-5-S4  [R0402]  407.41 83.54 180 bottom
UNK2R25  45.3-1-S4  [R0402]  380.29 226.94 270 bottom
UNK2R26  45.3-1-S4  [R0402]  448.17 208.42 90 bottom
UNK2R27  0-5-S4  [R0402]  407.41 88.62 180 bottom
UNK2R28  0-5-S4  [R0402]  407.41 91.16 180 bottom
UNK2R29  NC/45.3-1-S4  [R0402]  470.05 211.05 270 bottom
UNK2R30  0-5-S4  [R0402]  505.86 209.86 0 bottom
UNK2R31  0-5-S4  [R0402]  505.86 204.78 0 bottom
UNK2R32  0-5-S4  [R0402]  505.86 202.24 0 bottom
UNK2R33  NC/45.3-1-S4  [R0402]  471.2 211.05 90 bottom
UNK2R34  10K-1-S4  [R0402]  482.67 139.03 270 bottom
UNK2R35  10K-1-S4  [R0402]  485.21 139.03 270 bottom
UNK2R36  10K-1-S4  [R0402]  487.75 139.03 270 bottom
UNK2R37  10K-1-S4  [R0402]  490.29 139.03 270 bottom
UNK2R38  0-5-S4  [R0402]  485.08 128.87 0 bottom
UNK2R39  10K-1-S4  [R0402]  492.83 139.03 270 bottom
UNK2R40  10K-1-S4  [R0402]  495.37 139.03 270 bottom
UNK2R41  10K-1-S4  [R0402]  497.91 139.03 270 bottom
UNK2R42  0-5-S4  [R0402]  498.03 128.87 180 bottom
UNK2R43  12K-1-S4  [R0402]  381.23 205.74 0 bottom
UNK2R45  32.4-1-S4  [R0402]  472.6 225.06 270 bottom
UNK2R47  32.4-1-S4  [R0402]  472.6 232.32 270 bottom
UNK2R48  0-5-S4  [R0402]  343.96 196.59 90 bottom
UNK2R49  NC/0-5-S4  [R0402]  351.19 196.59 90 bottom
UNK2R50  0-5-S4  [R0402]  383.65 174.38 270 top
UNK2R51  NC/0-5-S4  [R0402]  354.8 229.46 270 bottom
UNK2R53  0-5-S4  [R0402]  367.84 232.59 90 bottom
UNK2R54  NC/0-5-S4  [R0402]  367.84 228.39 270 bottom
UNK2R55  0-5-S4  [R0402]  356.65 234.23 180 bottom
UNK2R57  NC/10K-1-S4  [R0402]  493.49 210.44 180 bottom
UNK2R58  NC/10K-1-S4  [R0402]  493.49 203.18 180 bottom
UNK2R59  NC/10K-1-S4  [R0402]  493.49 218.85 180 bottom
UNK2R60  NC/10K-1-S4  [R0402]  493.49 211.58 180 bottom
UNK2R61  0-5-S4  [R0402]  393 83.12 0 bottom
UNK2R62  0-5-S4  [R0402]  396 83.12 180 bottom
UNK2R63  0-5-S4  [R0402]  474.93 232.32 270 bottom
UNK2R64  0-5-S4  [R0402]  473.76 232.32 270 bottom
UNK2R65  0-5-S4  [R0402]  473.76 229.9 90 bottom
UNK2R66  0-5-S4  [R0402]  474.93 229.9 90 bottom
UNK2R67  0-5-S4  [R0402]  474.93 225.06 270 bottom
UNK2R68  0-5-S4  [R0402]  473.76 225.06 270 bottom
UNK2R69  0-5-S4  [R0402]  473.76 222.64 90 bottom
UNK2R70  0-5-S4  [R0402]  474.93 222.64 90 bottom
UNK2R71  2-5-D-2  [RC02W_27MM]  529.42 204.81 0 bottom
UNK2R72  2-5-D-2  [RC02W_27MM]  529.42 216.24 0 bottom
UNK2R73  2-5-D-2  [RC02W_27MM]  529.42 227.67 0 bottom
UNK2R74  0-5-S4  [R0402]  472.6 229.9 90 bottom
UNK2R75  0-5-S4  [R0402]  472.6 222.64 90 bottom
UNK2R76  0-5-S4  [R0402]  381.23 201.38 180 bottom
UNK2R77  0-5-S4  [R0402]  376.99 210.27 180 bottom
UNK2R78  0-5-S4  [R0402]  370.14 215.27 270 bottom
UNK2R79  0-5-S4  [R0402]  364.6 215.27 270 bottom
UNK2R81  0-5-S4  [R0402]  381.23 203.52 180 bottom
UNK2R82  0-5-S4  [R0402]  381.23 206.84 180 bottom
UNK2R83  0-5-S4  [R0402]  381.23 204.64 180 bottom
UNK2SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  375.98 187.27 210 top
UNK2SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  370.67 182.17 180 top
UNK2SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  364.8 181.21 180 top
UNK2ST3  SHORT  [DEFAULT_SHORT_SMALL]  150.3 471.8 0 top
UNK2ST4  SHORT  [DEFAULT_SHORT_SMALL]  153.52 471.8 0 top
UNK2ST5  SHORT  [DEFAULT_SHORT_SMALL]  156.74 471.8 0 top
UNK2ST8  SHORT  [DEFAULT_SHORT_SMALL]  159.96 471.8 0 top
UNK2ST11  SHORT  [DEFAULT_SHORT_SMALL]  134.21 471.8 0 top
UNK2ST12  SHORT  [DEFAULT_SHORT_SMALL]  137.43 471.8 0 top
UNK2ST13  SHORT  [DEFAULT_SHORT_SMALL]  140.64 471.8 0 top
UNK2ST14  SHORT  [DEFAULT_SHORT_SMALL]  143.86 471.8 0 top
UNK2ST15  SHORT  [DEFAULT_SHORT_SMALL]  147.08 471.8 0 top
UNK2ST16  SHORT  [DEFAULT_SHORT_SMALL]  15.1 471.8 0 top
UNK2ST17  SHORT  [DEFAULT_SHORT_SMALL]  18.32 471.8 0 top
UNK2ST18  SHORT  [DEFAULT_SHORT_SMALL]  21.53 471.8 0 top
UNK2ST19  SHORT  [DEFAULT_SHORT_SMALL]  24.75 471.8 0 top
UNK2SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  491.56 132.68 0 top
UNK2SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  394.5 86.93 0 top
UNK2U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  368.89 191.89 270 top
UNK2U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  366.58 187.88 270 top
UNK2U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  454.92 221.61 0 bottom
UNK2Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  354.22 202.03 45 top
UNK3BD1  BD120-1.5A-S4-MU  [FB0402]  401.19 215.24 270 bottom
UNK3BD2  BD120-1.5A-S4-MU  [FB0402]  416.96 212.38 180 bottom
UNK3BD3  BD120-1.5A-S4-MU  [FB0402]  400.15 215.24 270 bottom
UNK3BD5  BD120-1.5A-S4-MU  [FB0402]  397.33 205.67 0 bottom
UNK3BD7  BD120-1.5A-S4-MU  [FB0402]  402.23 215.24 270 bottom
UNK3BD9  BD120-1.5A-S4-MU  [FB0402]  421.2 202.45 180 bottom
UNK3BD11  BD120-1.5A-S4-MU  [FB0402]  416.96 211.34 180 bottom
UNK3BD12  BD120-1.5A-S4-MU  [FB0402]  409.07 215.24 270 bottom
UNK3BD13  BD120-1.5A-S4-MU  [FB0402]  397.36 198.82 0 bottom
UNK3BD15  BD120-1.5A-S4-MU  [FB0402]  400.48 195.03 0 bottom
UNK3BD16  BD120-1.5A-S4-MU  [FB0402]  403.79 201.66 180 bottom
UNK3BD17  BD120-1.5A-S4-MU  [FB0402]  403.79 200.62 180 bottom
UNK3BD18  BD120-1.5A-S4-MU  [FB0402]  415.71 197.57 180 bottom
UNK3BD19  BD120-1.5A-S4-MU  [FB0402]  415.71 196.37 180 bottom
UNK3BD20  BD120-1.5A-S4-MU  [FB0402]  395.79 205.62 270 bottom
UNK3BD21  BD120-1.5A-S4-MU  [FB0402]  415.71 194.23 180 bottom
UNK3BD22  BD120-1.5A-S4-MU  [FB0402]  402.3 191.38 180 bottom
UNK3BD23  BD120-1.5A-S4-MU  [FB0402]  402.3 193.44 0 bottom
UNK3BD27  NC/BD120-1.5A-S4-MU  [FB0402]  472.87 177.26 0 bottom
UNK3BD28  BD120-1.5A-S4-MU  [FB0402]  396.81 208.45 270 bottom
UNK3BD29  BD120-1.5A-S4-MU  [FB0402]  406.81 215.24 270 bottom
UNK3BD30  BD120-1.5A-S4-MU  [FB0402]  396.96 211.26 225 bottom
UNK3BD31  BD120-1.5A-S4-MU  [FB0402]  413.85 214.77 180 bottom
UNK3BD32  BD120-1.5A-S4-MU  [FB0402]  450.32 176.84 90 top
UNK3BD33  BD120-1.5A-S4-MU  [FB0402]  449.7 86.03 270 bottom
UNK3BD34  BD120-1.5A-S4-MU  [FB0402]  403.48 189.65 0 bottom
UNK3BD35  BD120-1.5A-S4-MU  [FB0402]  413.63 194.23 180 bottom
UNK3BD36  BD120-1.5A-S4-MU  [FB0402]  395.31 198.83 0 bottom
UNK3BD37  BD120-1.5A-S4-MU  [FB0402]  411.2 215.24 270 bottom
UNK3C1  NC/1P-25-N-S2-WA  [C0201]  409.16 196.56 45 top
UNK3C2  10P-50-N-S2-MU  [C0201]  413.49 191.58 300 top
UNK3C3  NC/1.2P-50-N-S2-MU  [C0201]  410.97 195.6 45 top
UNK3C4  NC/1P-25-N-S2-WA  [C0201]  407.8 196.25 225 top
UNK3C5  NC/1.2P-50-N-S2-MU  [C0201]  408.77 194.43 225 top
UNK3C6  10P-50-N-S2-MU  [C0201]  410.67 190.77 90 top
UNK3C7  NC/10P-50-N-S2-MU  [C0201]  410.37 190.47 180 top
UNK3C8  CNC-S2  [C0201]  410.37 185.6 180 top
UNK3C9  NC/1P-25-N-S2-WA  [C0201]  406.87 195.72 180 bottom
UNK3C10  NC/1.2P-50-N-S2-MU  [C0201]  406.27 193.75 180 bottom
UNK3C11  NC/1P-25-N-S2-WA  [C0201]  405.1 196.37 180 top
UNK3C12  NC/1.2P-50-N-S2-MU  [C0201]  404.5 194.4 180 top
UNK3C13  10P-50-N-S2-MU  [C0201]  404.8 186.76 90 top
UNK3C14  NC/10P-50-N-S2-MU  [C0201]  405.1 186.46 0 top
UNK3C15  CNC-S2  [C0201]  405.1 184.64 0 top
UNK3C16  NC/1P-25-N-S2-WA  [C0201]  405.1 196.37 180 bottom
UNK3C17  NC/0.1U-35-X-S2-MU  [C0201]  413.62 200.2 180 bottom
UNK3C18  NC/0.1U-35-X-S2-MU  [C0201]  413.62 199.35 180 bottom
UNK3C19  NC/1.2P-50-N-S2-MU  [C0201]  404.5 194.4 180 bottom
UNK3C20  0.1U-35-X-S2-MU  [C0201]  413.62 197.12 0 bottom
UNK3C21  0.1U-35-X-S2-MU  [C0201]  413.62 197.97 0 bottom
UNK3C22  0.1U-16-X-S4-MU  [C0402]  452.86 176.87 270 top
UNK3C23  0.9P-50-N-S4-MU  [C0402]  396.6 203.41 270 top
UNK3C24  0.1U-25-X-S4-TY  [C0402]  472.84 176.18 180 bottom
UNK3C25  0.9P-50-N-S4-MU  [C0402]  396.6 200.64 90 top
UNK3C38  1P-50-N-S4-WA  [C0402]  480.86 184.56 180 bottom
UNK3C39  22P-50-N-S4-AVX  [C0402]  484.26 184.56 180 bottom
UNK3C40  1P-50-N-S4-WA  [C0402]  480.86 177.29 180 bottom
UNK3C41  22P-50-N-S4-AVX  [C0402]  484.26 177.29 180 bottom
UNK3C44  0.1U-35-X-S2-MU  [C0201]  403.93 205.5 0 bottom
UNK3C45  0.1U-35-X-S2-MU  [C0201]  412.4 209.41 270 bottom
UNK3C46  0.1U-35-X-S2-MU  [C0201]  403.93 204.65 0 bottom
UNK3C47  0.1U-35-X-S2-MU  [C0201]  412.63 202.19 180 bottom
UNK3C48  0.1U-35-X-S2-MU  [C0201]  399.77 202.74 180 top
UNK3C49  0.1U-35-X-S2-MU  [C0201]  412.63 205.91 180 bottom
UNK3C52  0.1U-35-X-S2-MU  [C0201]  403.93 206.35 0 bottom
UNK3C53  10U-10-X-S4-SS  [C0402]  387.75 206.49 90 bottom
UNK3C54  0.1U-35-X-S2-MU  [C0201]  408.82 209.41 270 bottom
UNK3C55  0.1U-25-X-S4-TY  [C0402]  390.03 206.49 90 bottom
UNK3C56  0.1U-35-X-S2-MU  [C0201]  416.74 203.42 0 top
UNK3C57  NC/10U-10-X-S4-SS  [C0402]  388.88 206.49 90 bottom
UNK3C58  0.1U-35-X-S2-MU  [C0201]  403.66 213.94 90 top
UNK3C59  0.1U-35-X-S2-MU  [C0201]  412.63 207.4 180 bottom
UNK3C60  10U-10-X-S4-SS  [C0402]  419.1 212.43 0 bottom
UNK3C61  0.1U-35-X-S2-MU  [C0201]  407.88 209.4 270 bottom
UNK3C62  22U-25-X-S8-MU  [C0805]  387.63 214.73 0 bottom
UNK3C63  22U-25-X-S8-MU  [C0805]  387.63 216.76 0 bottom
UNK3C64  0.1U-35-X-S2-MU  [C0201]  399.77 200.61 180 top
UNK3C65  47U-16-T-SC  [CODE_C]  455.45 170.92 0 bottom
UNK3C66  10U-16-T-SA  [CODE_A]  455.41 170.92 0 top
UNK3C67  10U-10-X-S4-SS  [C0402]  419.1 211.31 0 bottom
UNK3C68  22U-10-T-SA  [CODE_A]  418.49 169.02 0 bottom
UNK3C69  22U-10-T-SA  [CODE_A]  418.49 171.61 0 bottom
UNK3C70  22U-10-T-SA  [CODE_A]  418.49 174.18 0 bottom
UNK3C71  22U-10-T-SA  [CODE_A]  418.49 171.61 0 top
UNK3C72  22U-10-T-SA  [CODE_A]  418.49 169.02 0 top
UNK3C73  10U-10-X-S4-SS  [C0402]  395.28 197.76 180 bottom
UNK3C74  0.1U-35-X-S2-MU  [C0201]  406.58 200.79 90 bottom
UNK3C75  0.1U-35-X-S2-MU  [C0201]  416.74 200.67 0 top
UNK3C76  10U-10-X-S4-SS  [C0402]  400.45 196.1 180 bottom
UNK3C77  0.1U-35-X-S2-MU  [C0201]  405.76 200.79 90 bottom
UNK3C78  0.1U-35-X-S2-MU  [C0201]  399.77 201.29 180 top
UNK3C79  0.1U-35-X-S2-MU  [C0201]  399.77 199.92 180 top
UNK3C83  10U-10-X-S4-SS  [C0402]  415.74 198.66 0 bottom
UNK3C84  0.1U-35-X-S2-MU  [C0201]  408.09 200.79 90 bottom
UNK3C85  0.1U-35-X-S2-MU  [C0201]  407.36 200.79 90 bottom
UNK3C88  0.1U-35-X-S2-MU  [C0201]  399.77 203.4 180 top
UNK3C89  10U-10-X-S4-SS  [C0402]  394.26 206.99 180 bottom
UNK3C90  10U-10-X-S4-SS  [C0402]  415.74 195.29 0 bottom
UNK3C91  0.1U-35-X-S2-MU  [C0201]  407.68 198.01 0 bottom
UNK3C92  22U-25-X-S8-MU  [C0805]  432.93 171.07 180 bottom
UNK3C93  22U-25-X-S8-MU  [C0805]  432.93 171.07 180 top
UNK3C94  47U-16-T-SC  [CODE_C]  432.35 167.76 180 bottom
UNK3C95  10U-16-T-SA  [CODE_A]  432.35 167.76 180 top
UNK3C96  10U-10-X-S4-SS  [C0402]  417.82 198.66 0 bottom
UNK3C97  10U-10-X-S4-SS  [C0402]  401.83 190.88 270 top
UNK3C98  0.1U-35-X-S2-MU  [C0201]  400.89 191.78 270 top
UNK3C99  10U-10-X-S4-SS  [C0402]  402.77 192.94 270 top
UNK3C100  0.1U-35-X-S2-MU  [C0201]  403.05 196.09 270 top
UNK3C101  10U-10-X-S4-SS  [C0402]  394.26 205.15 180 bottom
UNK3C102  0.1U-35-X-S2-MU  [C0201]  412.63 203.7 180 bottom
UNK3C105  0.1U-35-X-S2-MU  [C0201]  412.63 204.49 180 bottom
UNK3C106  10U-10-X-S4-SS  [C0402]  417.65 225.88 90 bottom
UNK3C107  0.1U-35-X-S2-MU  [C0201]  416.74 204.79 0 top
UNK3C108  0.1U-25-X-S4-TY  [C0402]  416.53 225.88 90 bottom
UNK3C109  NC/10U-10-X-S4-SS  [C0402]  418.77 225.88 90 bottom
UNK3C110  1U-10-X-S4-MU  [C0402]  418.36 200.67 180 top
UNK3C111  10U-10-X-S4-SS  [C0402]  396.81 207.48 270 top
UNK3C112  0.1U-35-X-S2-MU  [C0201]  398.83 208.2 270 top
UNK3C113  10U-25-X-S6-MU  [C0603]  422.96 205.99 90 bottom
UNK3C116  22U-25-X-S8-MU  [C0805]  408.03 218.11 180 bottom
UNK3C117  22U-25-X-S8-MU  [C0805]  408.02 220.27 180 bottom
UNK3C118  10U-10-X-S4-SS  [C0402]  405.72 215.27 90 bottom
UNK3C119  0.1U-35-X-S2-MU  [C0201]  406.94 209.4 270 bottom
UNK3C120  47U-16-T-SC  [CODE_C]  418.92 177.85 180 bottom
UNK3C121  10U-16-T-SA  [CODE_A]  418.92 177.85 180 top
UNK3C122  10U-10-X-S4-SS  [C0402]  417.82 197.55 0 bottom
UNK3C123  10U-10-X-S4-SS  [C0402]  396.28 211.28 135 top
UNK3C124  0.1U-35-X-S2-MU  [C0201]  399.77 210.08 180 top
UNK3C125  10U-10-X-S4-SS  [C0402]  413.38 215.27 90 top
UNK3C126  0.1U-35-X-S2-MU  [C0201]  413.33 213.89 180 top
UNK3C127  10U-10-X-S4-SS  [C0402]  451.59 176.87 270 top
UNK3C128  0.1U-35-X-S2-MU  [C0201]  454.13 176.87 270 top
UNK3C129  10U-10-X-S4-SS  [C0402]  393.26 198.82 180 bottom
UNK3C130  0.1U-25-X-S4-TY  [C0402]  448.6 86.06 90 bottom
UNK3C131  22U-10-T-SA  [CODE_A]  454.15 88.62 0 bottom
UNK3C132  22U-10-T-SA  [CODE_A]  454.15 83.49 0 top
UNK3C133  22U-10-T-SA  [CODE_A]  454.15 86.06 0 top
UNK3C134  22U-10-T-SA  [CODE_A]  454.15 86.06 0 bottom
UNK3C135  22U-10-T-SA  [CODE_A]  454.15 83.49 0 bottom
UNK3C136  10U-10-X-S4-SS  [C0402]  407.84 225.88 90 bottom
UNK3C137  0.1U-25-X-S4-TY  [C0402]  406.72 225.88 90 bottom
UNK3C138  NC/10U-10-X-S4-SS  [C0402]  408.95 225.88 90 bottom
UNK3C139  22U-25-X-S8-MU  [C0805]  396.49 225.56 270 bottom
UNK3C140  47U-16-T-SC  [CODE_C]  432.68 189.48 180 bottom
UNK3C141  10U-16-T-SA  [CODE_A]  432.68 189.48 180 top
UNK3C142  22U-25-X-S8-MU  [C0805]  398.79 225.56 270 bottom
UNK3C143  NC/10P-50-N-S4-WA  [C0402]  417 208.8 180 bottom
UNK3C144  NC/10P-50-N-S4-WA  [C0402]  417 207.63 180 bottom
UNK3C145  NC/10P-50-N-S4-WA  [C0402]  509.5 191.93 270 top
UNK3C146  NC/10P-50-N-S4-WA  [C0402]  509.5 188.73 270 top
UNK3C147  NC/10P-50-N-S4-WA  [C0402]  509.5 199.2 270 top
UNK3C148  NC/10P-50-N-S4-WA  [C0402]  509.5 196 270 top
UNK3C149  NC/10P-50-N-S4-WA  [C0402]  509.5 183.3 270 top
UNK3C150  NC/10P-50-N-S4-WA  [C0402]  509.5 180.1 270 top
UNK3C152  0.1U-35-X-S2-MU  [C0201]  409.67 209.41 270 bottom
UNK3C153  CNC-S2  [C0201]  412.12 205.24 180 bottom
UNK3D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  413.73 190.31 30 top
UNK3D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  410.24 186.49 0 top
UNK3D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  405.23 185.52 180 top
UNK3J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  502.07 175.57 90 top
UNK3J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  443.2 83.52 270 top
UNK3J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  508.3 175.57 90 top
UNK3J4  HDR-8X1-M  [JP_8P_100]  412.06 141.44 270 top
UNK3J5  HDR-1X1-M  [JP_1P_RD070_040]  458.13 91.4 90 top
UNK3J6  HDR-2X1-M  [JP_2P_100]  455.21 91.4 90 top
UNK3J7  HDR-2X1-M  [JP_2P_100]  428.79 115.4 0 top
UNK3J8  HDR-2X1-M  [JP_2P_100]  432.6 115.4 0 top
UNK3J9  HDR-2X1-M  [JP_2P_100]  424.98 115.4 0 top
UNK3K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 180.37 180 bottom
UNK3K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 187.38 180 bottom
UNK3K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 194.39 180 bottom
UNK3K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 172.52 180 bottom
UNK3K5  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  425.5 228.94 270 bottom
UNK3K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  451.92 99.22 90 bottom
UNK3K7  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  442.97 172.14 90 bottom
UNK3K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 180.92 180 bottom
UNK3K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  429.74 181.5 180 bottom
UNK3K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  466.36 189.56 180 bottom
UNK3K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 196.82 180 bottom
UNK3K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 189.56 180 bottom
UNK3K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 189.56 180 bottom
UNK3K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  466.36 196.82 180 bottom
UNK3K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 196.82 180 bottom
UNK3K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  469.33 172.52 180 bottom
UNK3K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  469.33 180.92 180 bottom
UNK3K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 180.92 180 bottom
UNK3K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  403.15 222.11 90 bottom
UNK3K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  390.68 210.58 0 bottom
UNK3K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  387.58 200.09 90 bottom
UNK3K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  411.3 173.15 90 bottom
UNK3K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  401.15 230.56 0 bottom
UNK3K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  429.74 175.14 180 bottom
UNK3K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  414.18 230.49 0 bottom
UNK3K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  412.97 222.11 90 bottom
UNK3K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 172.33 90 bottom
UNK3K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 183.76 90 bottom
UNK3K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 195.19 90 bottom
UNK3K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 189.56 180 bottom
UNK3K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 196.82 180 bottom
UNK3K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 180.92 180 bottom
UNK3K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  444.96 99.22 90 bottom
UNK3L1  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  391.97 206.04 270 bottom
UNK3L3  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  417.28 223.34 90 bottom
UNK3L4  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  407.47 223.34 90 bottom
UNK3R1  0-5-S2  [R0201]  410.07 196.08 315 top
UNK3R2  0-5-S2  [R0201]  408.29 195.34 315 top
UNK3R3  0-5-S2  [R0201]  410.67 192.05 270 top
UNK3R4  NC/0-5-S2  [R0201]  410.37 192.35 0 top
UNK3R5  0-5-S2  [R0201]  406.57 194.73 270 bottom
UNK3R6  0-5-S2  [R0201]  404.8 195.39 270 top
UNK3R7  0-5-S2  [R0201]  404.8 188.04 270 top
UNK3R8  NC/0-5-S2  [R0201]  405.1 188.34 180 top
UNK3R9  0-5-S2  [R0201]  404.8 195.39 270 bottom
UNK3R10  0-5-S4  [R0402]  453.01 196.29 270 top
UNK3R11  0-5-S4  [R0402]  454.28 196.29 270 top
UNK3R12  NC/10K-1-S4  [R0402]  456.92 176.87 270 top
UNK3R13  0-5-S4  [R0402]  455.65 176.87 270 top
UNK3R14  NC/10K-1-S4  [R0402]  455.55 196.29 270 top
UNK3R15  0-5-S4  [R0402]  458.19 176.87 270 top
UNK3R16  0-5-S4  [R0402]  456.82 196.29 270 top
UNK3R17  0-5-S4  [R0402]  459.46 176.87 270 top
UNK3R18  NC/10K-1-S4  [R0402]  457.94 196.29 270 top
UNK3R19  0-5-S4  [R0402]  499.63 175.57 0 bottom
UNK3R20  0-5-S4  [R0402]  499.63 170.49 0 bottom
UNK3R21  0-5-S4  [R0402]  499.63 167.95 0 bottom
UNK3R22  45.3-1-S4  [R0402]  420.29 230.93 90 bottom
UNK3R23  45.3-1-S4  [R0402]  448.17 170.14 270 bottom
UNK3R24  0-5-S4  [R0402]  445.8 83.54 180 bottom
UNK3R25  45.3-1-S4  [R0402]  420.29 226.94 270 bottom
UNK3R26  45.3-1-S4  [R0402]  448.17 174.13 90 bottom
UNK3R27  0-5-S4  [R0402]  445.8 88.62 180 bottom
UNK3R28  0-5-S4  [R0402]  445.8 91.16 180 bottom
UNK3R29  NC/45.3-1-S4  [R0402]  470.05 176.76 270 bottom
UNK3R30  0-5-S4  [R0402]  505.86 175.57 0 bottom
UNK3R31  0-5-S4  [R0402]  505.86 170.49 0 bottom
UNK3R32  0-5-S4  [R0402]  505.86 167.95 0 bottom
UNK3R33  NC/45.3-1-S4  [R0402]  471.2 176.76 90 bottom
UNK3R34  10K-1-S4  [R0402]  412.06 138.9 270 bottom
UNK3R35  10K-1-S4  [R0402]  414.6 138.9 270 bottom
UNK3R36  10K-1-S4  [R0402]  417.14 138.9 270 bottom
UNK3R37  10K-1-S4  [R0402]  419.68 138.9 270 bottom
UNK3R38  0-5-S4  [R0402]  414.47 128.74 0 bottom
UNK3R39  10K-1-S4  [R0402]  422.22 138.9 270 bottom
UNK3R40  10K-1-S4  [R0402]  424.76 138.9 270 bottom
UNK3R41  10K-1-S4  [R0402]  427.3 138.9 270 bottom
UNK3R42  0-5-S4  [R0402]  427.42 128.74 180 bottom
UNK3R43  12K-1-S4  [R0402]  421.23 205.74 0 bottom
UNK3R45  32.4-1-S4  [R0402]  472.6 190.77 270 bottom
UNK3R47  32.4-1-S4  [R0402]  472.6 198.03 270 bottom
UNK3R48  0-5-S4  [R0402]  383.96 196.59 90 bottom
UNK3R49  NC/0-5-S4  [R0402]  391.19 196.59 90 bottom
UNK3R50  0-5-S4  [R0402]  423.65 174.38 270 top
UNK3R51  NC/0-5-S4  [R0402]  394.8 229.46 270 bottom
UNK3R53  0-5-S4  [R0402]  407.84 232.59 90 bottom
UNK3R54  NC/0-5-S4  [R0402]  407.84 228.39 270 bottom
UNK3R55  0-5-S4  [R0402]  396.65 234.23 180 bottom
UNK3R57  NC/10K-1-S4  [R0402]  493.49 176.15 180 bottom
UNK3R58  NC/10K-1-S4  [R0402]  493.49 168.89 180 bottom
UNK3R59  NC/10K-1-S4  [R0402]  493.49 184.56 180 bottom
UNK3R60  NC/10K-1-S4  [R0402]  493.49 177.29 180 bottom
UNK3R61  0-5-S4  [R0402]  431.39 83.12 0 bottom
UNK3R62  0-5-S4  [R0402]  434.39 83.12 180 bottom
UNK3R63  0-5-S4  [R0402]  474.93 198.03 270 bottom
UNK3R64  0-5-S4  [R0402]  473.76 198.03 270 bottom
UNK3R65  0-5-S4  [R0402]  473.76 195.61 90 bottom
UNK3R66  0-5-S4  [R0402]  474.93 195.61 90 bottom
UNK3R67  0-5-S4  [R0402]  474.93 190.77 270 bottom
UNK3R68  0-5-S4  [R0402]  473.76 190.77 270 bottom
UNK3R69  0-5-S4  [R0402]  473.76 188.35 90 bottom
UNK3R70  0-5-S4  [R0402]  474.93 188.35 90 bottom
UNK3R71  2-5-D-2  [RC02W_27MM]  529.42 170.52 0 bottom
UNK3R72  2-5-D-2  [RC02W_27MM]  529.42 181.95 0 bottom
UNK3R73  2-5-D-2  [RC02W_27MM]  529.42 193.38 0 bottom
UNK3R74  0-5-S4  [R0402]  472.6 195.61 90 bottom
UNK3R75  0-5-S4  [R0402]  472.6 188.35 90 bottom
UNK3R76  0-5-S4  [R0402]  421.23 201.38 180 bottom
UNK3R77  0-5-S4  [R0402]  416.99 210.27 180 bottom
UNK3R78  0-5-S4  [R0402]  410.14 215.27 270 bottom
UNK3R79  0-5-S4  [R0402]  404.6 215.27 270 bottom
UNK3R81  0-5-S4  [R0402]  421.23 203.52 180 bottom
UNK3R82  0-5-S4  [R0402]  421.23 206.84 180 bottom
UNK3R83  0-5-S4  [R0402]  421.23 204.64 180 bottom
UNK3SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  415.98 187.27 210 top
