# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#4372  -  []  188.98 253.19 0 top
NOREF#4373  -  []  155.68 230.9 0 top
NOREF#4374  -  []  187.33 286.08 0 top
NOREF#4375  -  []  327.36 200.49 90 top
NOREF#4376  -  []  228.44 203 0 top
NOREF#4377  -  []  366.9 256.05 90 top
NOREF#4378  -  []  196.33 258.1 90 top
NOREF#4379  -  []  300.53 264.49 0 top
NOREF#4380  -  []  364.2 254.4 0 top
NOREF#4381  -  []  364.75 222.51 90 top
NOREF#4382  -  []  232.52 294.48 90 top
NOREF#4383  -  []  231.37 322.52 90 top
NOREF#4384  -  []  404.8 255.09 90 top
NOREF#4385  -  []  219.44 244.55 90 top
NOREF#4386  -  []  355.33 300.88 90 top
NOREF#4387  -  []  334.43 264.17 90 top
NOREF#4388  -  []  320.8 260 0 top
NOREF#4389  -  []  403.05 255.79 90 top
NOREF#4390  -  []  326.9 187.37 90 top
NOREF#4391  -  []  273.3 240 90 top
NOREF#4392  -  []  486.38 173.71 0 top
NOREF#4393  -  []  211.2 294.86 0 top
NOREF#4394  -  []  366.3 267 0 top
NOREF#4395  -  []  170.58 270.42 0 top
NOREF#4396  -  []  333.29 148.79 90 top
NOREF#4397  -  []  188.98 244.55 0 top
NOREF#4398  -  []  293.34 251.84 0 top
NOREF#4399  -  []  404.8 187.74 90 top
NOREF#4400  -  []  510.1 188.5 0 top
NOREF#4401  -  []  429.76 229.64 0 top
NOREF#4402  -  []  410.97 185.28 0 top
NOREF#4403  -  []  194.53 294.44 90 top
NOREF#4404  -  []  355.5 227.56 0 top
NOREF#4405  -  []  442.87 181.97 0 top
NOREF#4406  -  []  409.7 209.37 90 top
NOREF#4407  -  []  349.57 117.27 90 top
NOREF#4408  -  []  521.42 230.85 90 top
NOREF#4409  -  []  451.91 226.85 0 top
NOREF#4410  -  []  400.37 262.42 0 top
NOREF#4411  -  []  286.35 187.8 0 top
NOREF#4412  -  []  376.44 200.67 0 top
NOREF#4413  -  []  284.1 259 90 top
NOREF#4414  -  []  331.55 249.53 90 top
NOREF#4415  -  []  281.21 252.38 0 top
NOREF#4416  -  []  290.62 253.99 90 top
NOREF#4417  -  []  390.69 90.74 0 top
NOREF#4418  -  []  333.92 204.92 90 top
NOREF#4419  -  []  336.84 169.02 0 top
NOREF#4420  -  []  293.33 197.12 0 top
NOREF#4421  -  []  212.27 229.46 0 top
NOREF#4422  -  []  324.2 194.4 0 top
NOREF#4423  -  []  366.82 247.81 90 top
NOREF#4424  -  []  443.2 83.52 90 top
NOREF#4425  -  []  50.8 465 0 top
NOREF#4426  -  []  282.41 251.74 90 top
NOREF#4427  -  []  415.42 259.03 90 top
NOREF#4428  -  []  498.77 361.76 90 top
NOREF#4429  -  []  402.3 209.2 0 top
NOREF#4430  -  []  198.76 183.21 0 top
NOREF#4431  -  []  302.85 246 45 top
NOREF#4432  -  []  509.5 211.37 0 top
NOREF#4433  -  []  285.3 207 90 top
NOREF#4434  -  []  288.09 200.49 90 top
NOREF#4435  -  []  516.65 173.54 90 top
NOREF#4436  -  []  408.17 97.42 90 top
NOREF#4437  -  []  326.55 169.14 90 top
NOREF#4438  -  []  283.05 255.9 90 top
NOREF#4439  -  []  348.37 137.35 0 top
NOREF#4440  -  []  406.57 255.72 0 top
NOREF#4441  -  []  275.5 287.55 0 top
NOREF#4442  -  []  284.8 248.34 0 top
NOREF#4443  -  []  428.82 300.26 0 top
NOREF#4444  -  []  520.87 212.4 90 top
NOREF#4445  -  []  408.07 193.43 90 top
NOREF#4446  -  []  294.3 208.85 90 top
NOREF#4447  -  []  223.27 227.3 0 top
NOREF#4448  -  []  503.87 222.79 0 top
NOREF#4449  -  []  488.59 187.96 90 top
NOREF#4450  -  []  333.23 202.51 0 top
NOREF#4451  -  []  395.5 227.56 0 top
NOREF#4452  -  []  290.97 252.03 90 top
NOREF#4453  -  []  330.3 206.6 90 top
NOREF#4454  -  []  263.49 294.51 0 top
NOREF#4455  -  []  315.48 254.44 90 top
NOREF#4456  -  []  432.22 232.1 90 top
NOREF#4457  -  []  326.25 195.33 0 top
NOREF#4458  -  []  413.22 264.81 0 top
NOREF#4459  -  []  287.13 82.22 90 top
NOREF#4460  -  []  407.47 256.04 0 top
NOREF#4461  -  []  412.38 258.4 0 top
NOREF#4462  -  []  385.16 302.45 0 top
NOREF#4463  -  []  292.53 269.23 90 top
NOREF#4464  -  []  414.73 175.45 0 top
NOREF#4465  -  []  321.21 192.38 0 top
NOREF#4466  -  []  296.84 169.02 0 top
NOREF#4467  -  []  288.46 256.44 0 top
NOREF#4468  -  []  388.3 245 90 top
NOREF#4469  -  []  323.33 205.18 0 top
NOREF#4470  -  []  249.33 205.43 0 top
NOREF#4471  -  []  324.54 272.7 90 top
NOREF#4472  -  []  204.81 184.61 0 top
NOREF#4473  -  []  361.57 209.12 90 top
NOREF#4474  -  []  326.37 293.68 90 top
NOREF#4475  -  []  520.87 292.41 90 top
NOREF#4476  -  []  514.57 252.74 90 top
NOREF#4477  -  []  211.84 210.26 0 top
NOREF#4478  -  []  409.29 195.34 90 top
NOREF#4479  -  []  213.15 375.96 0 top
NOREF#4480  -  []  285.1 194.08 0 top
NOREF#4481  -  []  182.03 182.97 90 top
NOREF#4482  -  []  286.58 200.49 90 top
NOREF#4483  -  []  33.9 374.02 0 top
NOREF#4484  -  []  145.13 384.68 90 top
NOREF#4485  -  []  349.18 260.49 90 top
NOREF#4486  -  []  284.75 278.11 90 top
NOREF#4487  -  []  214.04 261.59 0 top
NOREF#4488  -  []  332.4 209.11 90 top
NOREF#4489  -  []  258.58 183.76 90 top
NOREF#4490  -  []  191.18 244.55 0 top
NOREF#4491  -  []  508.74 220.85 90 top
NOREF#4492  -  []  216.24 210.26 0 top
NOREF#4493  -  []  305.03 207.58 0 top
NOREF#4494  -  []  282.56 83.49 0 top
NOREF#4495  -  []  296.24 259.17 0 top
NOREF#4496  -  []  442.87 223.27 0 top
NOREF#4497  -  []  454.88 244.1 0 top
NOREF#4498  -  []  372.33 263.7 0 top
NOREF#4499  -  []  439.67 261.37 90 top
NOREF#4500  -  []  175.18 187.93 0 top
NOREF#4501  -  []  418.69 293.68 90 top
NOREF#4502  -  []  406.55 173.54 90 top
NOREF#4503  -  []  50.8 5 0 top
NOREF#4504  -  []  323.98 199.6 90 top
NOREF#4505  -  []  335.29 244.5 0 top
NOREF#4506  -  []  327.38 198.01 0 top
NOREF#4507  -  []  324.53 263.69 90 top
NOREF#4508  -  []  339.43 287.49 90 top
NOREF#4509  -  []  380.81 206.84 90 top
NOREF#4510  -  []  330.18 228.89 0 top
NOREF#4511  -  []  315 367.16 90 top
NOREF#4512  -  []  294.67 191.62 90 top
NOREF#4513  -  []  295.42 259.88 90 top
NOREF#4514  -  []  488.59 222.25 90 top
NOREF#4515  -  []  280.37 203.08 0 top
NOREF#4516  -  []  409.67 269.11 90 top
NOREF#4517  -  []  215.59 124.04 90 top
NOREF#4518  -  []  451.91 295.43 0 top
NOREF#4519  -  []  55.8 0 90 top
NOREF#4520  -  []  283.63 265.5 0 top
NOREF#4521  -  []  374.73 170.29 0 top
NOREF#4522  -  []  213.03 232.99 0 top
NOREF#4523  -  []  364.81 132.51 90 top
NOREF#4524  -  []  520.87 235.26 90 top
NOREF#4525  -  []  329.87 196.73 0 top
NOREF#4526  -  []  413.32 257.97 0 top
NOREF#4527  -  []  333.23 264.81 0 top
NOREF#4528  -  []  459.82 287.25 90 top
NOREF#4529  -  []  328.89 296.14 90 top
NOREF#4530  -  []  393.33 297.3 90 top
NOREF#4531  -  []  290.67 190.47 90 top
NOREF#4532  -  []  326.3 254.08 90 top
NOREF#4533  -  []  285.7 207.17 0 top
NOREF#4534  -  []  324.75 220.31 90 top
NOREF#4535  -  []  482.56 301.29 0 top
NOREF#4536  -  []  507.47 257.08 90 top
NOREF#4537  -  []  320.3 293 0 top
NOREF#4538  -  []  245.98 300.98 0 top
NOREF#4539  -  []  369.31 191.29 90 top
NOREF#4540  -  []  285.68 185.52 90 top
NOREF#4541  -  []  377.34 200.35 90 top
NOREF#4542  -  []  275.5 227.56 0 top
NOREF#4543  -  []  367.45 194.68 90 top
NOREF#4544  -  []  505.92 256.74 0 top
NOREF#4545  -  []  429.84 128.74 90 top
NOREF#4546  -  []  332.59 75.65 0 top
NOREF#4547  -  []  368.76 269.36 90 top
NOREF#4548  -  []  368.82 209.11 90 top
NOREF#4549  -  []  326.99 187.3 90 top
NOREF#4550  -  []  401.21 192.38 0 top
NOREF#4551  -  []  413.34 251.84 0 top
NOREF#4552  -  []  244.11 229.23 90 top
NOREF#4553  -  []  477.16 225.45 0 top
NOREF#4554  -  []  370.67 191.75 90 top
NOREF#4555  -  []  361.55 225.71 0 top
NOREF#4556  -  []  221.09 191.61 90 top
NOREF#4557  -  []  505.42 285.39 0 top
NOREF#4558  -  []  468.93 216.81 0 top
NOREF#4559  -  []  514.57 202.62 90 top
NOREF#4560  -  []  346.14 173.54 90 top
NOREF#4561  -  []  479.06 138.18 0 top
NOREF#4562  -  []  509.09 378.52 90 top
NOREF#4563  -  []  364.8 256.37 0 top
NOREF#4564  -  []  13.59 349.99 90 top
NOREF#4565  -  []  211.84 278.84 0 top
NOREF#4566  -  []  391.08 268.98 0 top
NOREF#4567  -  []  388.3 285 0 top
NOREF#4568  -  []  364.48 195.99 0 top
NOREF#4569  -  []  408.88 259.55 90 top
NOREF#4570  -  []  283.98 258.4 90 top
NOREF#4571  -  []  303.3 190 90 top
NOREF#4572  -  []  503.22 251.1 0 top
NOREF#4573  -  []  413.02 196.8 0 top
NOREF#4574  -  []  228.44 271.58 0 top
NOREF#4575  -  []  459.82 280.24 90 top
NOREF#4576  -  []  477.74 234.11 0 top
NOREF#4577  -  []  345.36 167.76 0 top
NOREF#4578  -  []  284.75 222.51 90 top
NOREF#4579  -  []  503.22 191.16 0 top
NOREF#4580  -  []  142.13 387.68 0 top
NOREF#4581  -  []  293.92 264.92 90 top
NOREF#4582  -  []  488.59 294.03 0 top
NOREF#4583  -  []  359.47 260.61 0 top
NOREF#4584  -  []  291.82 265.24 0 top
NOREF#4585  -  []  389.18 256.09 90 top
NOREF#4586  -  []  363.77 120.26 90 top
NOREF#4587  -  []  340.53 204.49 0 top
NOREF#4588  -  []  225.47 218.9 0 top
NOREF#4589  -  []  181.48 201.84 90 top
NOREF#4590  -  []  371.37 225.71 0 top
NOREF#4591  -  []  305.98 263.69 0 top
NOREF#4592  -  []  413.32 200.2 0 top
NOREF#4593  -  []  361.81 297.54 0 top
NOREF#4594  -  []  333.34 251.84 0 top
NOREF#4595  -  []  439.67 264.57 0 top
NOREF#4596  -  []  468.93 285.39 0 top
NOREF#4597  -  []  258.87 170.48 0 top
NOREF#4598  -  []  296.14 265.11 0 top
NOREF#4599  -  []  320.97 87.33 0 top
NOREF#4600  -  []  349.18 198.29 90 top
NOREF#4601  -  []  477.16 179.33 90 top
NOREF#4602  -  []  360.37 269.76 0 top
NOREF#4603  -  []  374.58 298.52 90 top
NOREF#4604  -  []  366.57 254.43 90 top
NOREF#4605  -  []  351.54 176.74 0 top
NOREF#4606  -  []  361.55 288.95 0 top
NOREF#4607  -  []  27.87 381.01 0 top
NOREF#4608  -  []  284.8 244.64 0 top
NOREF#4609  -  []  500.02 285.39 0 top
NOREF#4610  -  []  286.25 195.33 0 top
NOREF#4611  -  []  333.23 264.02 0 top
NOREF#4612  -  []  320.37 200.29 0 top
NOREF#4613  -  []  403.01 81.48 0 top
NOREF#4614  -  []  286.82 187.81 90 top
NOREF#4615  -  []  281.21 192.38 0 top
NOREF#4616  -  []  414.11 86.06 0 top
NOREF#4617  -  []  284.8 184.64 0 top
NOREF#4618  -  []  396.16 262.17 90 top
NOREF#4619  -  []  497.31 289.43 90 top
NOREF#4620  -  []  362.3 269.2 0 top
NOREF#4621  -  []  324.1 199 90 top
NOREF#4622  -  []  374.73 172.88 0 top
NOREF#4623  -  []  459.82 245.95 90 top
NOREF#4624  -  []  235.49 277.44 90 top
NOREF#4625  -  []  325.1 194.72 0 top
NOREF#4626  -  []  488.59 174.12 0 top
NOREF#4627  -  []  328.56 194.22 0 top
NOREF#4628  -  []  333.29 136.15 0 top
NOREF#4629  -  []  482.56 182.52 0 top
NOREF#4630  -  []  332.38 258.4 0 top
NOREF#4631  -  []  363.98 258.4 90 top
NOREF#4632  -  []  52.77 68.06 0 top
NOREF#4633  -  []  330.3 203 90 top
NOREF#4634  -  []  290.97 185.28 0 top
NOREF#4635  -  []  317.29 377.26 90 top
NOREF#4636  -  []  319.47 202.74 0 top
NOREF#4637  -  []  473.72 87.58 0 top
NOREF#4638  -  []  175.18 273.87 90 top
NOREF#4639  -  []  477.74 209.81 0 top
NOREF#4640  -  []  570.55 87.96 0 top
NOREF#4641  -  []  293.23 206.23 0 top
NOREF#4642  -  []  175.18 302.23 0 top
NOREF#4643  -  []  326.9 195.41 90 top
NOREF#4644  -  []  508.3 167.95 90 top
NOREF#4645  -  []  293.33 197.97 0 top
NOREF#4646  -  []  415.42 199.03 90 top
NOREF#4647  -  []  283.59 99.62 90 top
NOREF#4648  -  []  324.53 204.54 90 top
NOREF#4649  -  []  430.3 293.92 90 top
NOREF#4650  -  []  281.57 269.12 90 top
NOREF#4651  -  []  233.84 203 90 top
NOREF#4652  -  []  367.88 209.1 90 top
NOREF#4653  -  []  168.6 131.66 0 top
NOREF#4654  -  []  182.03 191.21 0 top
NOREF#4655  -  []  240.78 288.38 0 top
NOREF#4656  -  []  305.3 188 90 top
NOREF#4657  -  []  361.81 300.11 0 top
NOREF#4658  -  []  325.7 256.69 0 top
NOREF#4659  -  []  488.59 251.1 0 top
NOREF#4660  -  []  291.03 203 90 top
NOREF#4661  -  []  364.75 228.96 90 top
NOREF#4662  -  []  333.36 190.09 0 top
NOREF#4663  -  []  198.76 225.9 0 top
NOREF#4664  -  []  317.89 152.59 0 top
NOREF#4665  -  []  404.8 248.34 0 top
NOREF#4666  -  []  408.54 191.43 0 top
NOREF#4667  -  []  364.8 246.46 0 top
NOREF#4668  -  []  480.36 301.29 0 top
NOREF#4669  -  []  52.77 6.56 0 top
NOREF#4670  -  []  419.82 243.73 90 top
NOREF#4671  -  []  312.58 82 0 top
NOREF#4672  -  []  285.13 195.99 0 top
NOREF#4673  -  []  52.77 405.06 0 top
NOREF#4674  -  []  505.42 232.71 0 top
NOREF#4675  -  []  179.95 256.79 0 top
NOREF#4676  -  []  439.67 281.64 90 top
NOREF#4677  -  []  334.3 208.85 90 top
NOREF#4678  -  []  286.33 187.99 90 top
NOREF#4679  -  []  365.68 255.34 90 top
NOREF#4680  -  []  247.68 176.75 0 top
NOREF#4681  -  []  414.5 249.29 90 top
NOREF#4682  -  []  352.13 304.08 0 top
NOREF#4683  -  []  284.1 199 0 top
NOREF#4684  -  []  222.39 364.96 90 top
NOREF#4685  -  []  366.9 255.41 90 top
NOREF#4686  -  []  497.31 186.56 90 top
NOREF#4687  -  []  416.14 205.11 0 top
NOREF#4688  -  []  289.82 186.49 0 top
NOREF#4689  -  []  466.61 367.16 90 top
NOREF#4690  -  []  367.38 198.01 0 top
NOREF#4691  -  []  402.9 209.33 0 top
NOREF#4692  -  []  365.7 256.69 0 top
NOREF#4693  -  []  13.59 390.63 90 top
NOREF#4694  -  []  405.68 245.52 90 top
NOREF#4695  -  []  307.92 350.14 0 top
NOREF#4696  -  []  284.2 194.4 0 top
NOREF#4697  -  []  286.87 254.07 0 top
NOREF#4698  -  []  181.48 281.85 90 top
NOREF#4699  -  []  50.8 465 0 top
NOREF#4700  -  []  488.59 205.21 90 top
NOREF#4701  -  []  188.31 294.44 90 top
NOREF#4702  -  []  181.48 167.55 90 top
NOREF#4703  -  []  288.28 197.05 90 top
NOREF#4704  -  []  364.54 272.7 90 top
NOREF#4705  -  []  450.39 87.33 0 top
NOREF#4706  -  []  365.35 71.53 0 top
NOREF#4707  -  []  182.03 179.78 90 top
NOREF#4708  -  []  368.56 194.22 0 top
NOREF#4709  -  []  281.55 225.71 0 top
NOREF#4710  -  []  386.78 335.34 0 top
NOREF#4711  -  []  326.99 187.5 90 top
NOREF#4712  -  []  516.65 248.17 0 top
NOREF#4713  -  []  439.67 257.56 0 top
NOREF#4714  -  []  285.76 260.49 90 top
NOREF#4715  -  []  339.4 293.92 0 top
NOREF#4716  -  []  503.27 211.37 0 top
NOREF#4717  -  []  380.53 204.49 0 top
NOREF#4718  -  []  324.8 195.09 90 top
NOREF#4719  -  []  289.29 255.34 90 top
NOREF#4720  -  []  514.57 275.6 90 top
NOREF#4721  -  []  290.3 203 90 top
NOREF#4722  -  []  381.41 172.91 90 top
NOREF#4723  -  []  418.68 84.79 90 top
NOREF#4724  -  []  413.32 199.35 0 top
NOREF#4725  -  []  396.1 226.51 0 top
NOREF#4726  -  []  268.67 229.77 90 top
NOREF#4727  -  []  383.05 303.72 0 top
NOREF#4728  -  []  326.94 209.1 90 top
NOREF#4729  -  []  182.03 205.83 90 top
NOREF#4730  -  []  404.48 255.99 0 top
NOREF#4731  -  []  330.67 251.75 90 top
NOREF#4732  -  []  399.33 165.85 90 top
NOREF#4733  -  []  411.37 225.71 0 top
NOREF#4734  -  []  442.87 298.86 0 top
NOREF#4735  -  []  317.29 131.75 90 top
NOREF#4736  -  []  258.58 218.05 90 top
NOREF#4737  -  []  491.79 294.03 0 top
NOREF#4738  -  []  284.57 196.05 90 top
NOREF#4739  -  []  266.21 288.44 90 top
NOREF#4740  -  []  50.8 465 0 top
NOREF#4741  -  []  321.3 304.88 0 top
NOREF#4742  -  []  303.3 280 0 top
NOREF#4743  -  []  414.43 201.87 90 top
NOREF#4744  -  []  39.35 387.99 90 top
NOREF#4745  -  []  369.42 194.63 0 top
NOREF#4746  -  []  412.33 202.19 0 top
NOREF#4747  -  []  454.13 210.86 90 top
NOREF#4748  -  []  358.8 23.5 90 top
NOREF#4749  -  []  349.93 166.49 90 top
NOREF#4750  -  []  370.07 192.35 0 top
NOREF#4751  -  []  405.7 246.14 90 top
NOREF#4752  -  []  312.12 304.08 0 top
NOREF#4753  -  []  406.62 210 0 top
NOREF#4754  -  []  423.25 295.32 0 top
NOREF#4755  -  []  505.42 225.45 0 top
NOREF#4756  -  []  209.66 243.15 90 top
NOREF#4757  -  []  285.1 254.08 0 top
NOREF#4758  -  []  361.63 294.83 90 top
NOREF#4759  -  []  410.67 190.47 90 top
NOREF#4760  -  []  409.31 251.57 90 top
NOREF#4761  -  []  477.16 285.39 0 top
NOREF#4762  -  []  380.53 264.49 0 top
NOREF#4763  -  []  503.87 188.5 0 top
NOREF#4764  -  []  325.13 195.99 0 top
NOREF#4765  -  []  311.3 188 90 top
NOREF#4766  -  []  445.07 257.56 0 top
NOREF#4767  -  []  457.07 84.79 90 top
NOREF#4768  -  []  305.76 359.03 90 top
NOREF#4769  -  []  306.14 179.9 90 top
NOREF#4770  -  []  247.68 169.74 0 top
NOREF#4771  -  []  328.56 254.22 0 top
NOREF#4772  -  []  340.81 266.84 90 top
NOREF#4773  -  []  403.33 266.03 0 top
NOREF#4774  -  []  469.97 373.44 90 top
NOREF#4775  -  []  367.38 258.01 0 top
NOREF#4776  -  []  317.29 379.82 90 top
NOREF#4777  -  []  274.28 208.98 90 top
NOREF#4778  -  []  217.72 379.82 90 top
NOREF#4779  -  []  410.32 195.4 0 top
NOREF#4780  -  []  404.53 204.54 90 top
NOREF#4781  -  []  292.33 263.7 0 top
NOREF#4782  -  []  285.47 128.74 90 top
NOREF#4783  -  []  363.66 213.64 90 top
NOREF#4784  -  []  459.82 93.57 90 top
NOREF#4785  -  []  266.68 268.98 0 top
NOREF#4786  -  []  365.7 186.14 90 top
NOREF#4787  -  []  209.66 174.57 90 top
NOREF#4788  -  []  373.23 202.51 0 top
NOREF#4789  -  []  488.59 208.41 0 top
NOREF#4790  -  []  407.68 260.19 0 top
NOREF#4791  -  []  320.89 251.48 90 top
NOREF#4792  -  []  354.28 208.98 90 top
NOREF#4793  -  []  329.42 254.63 0 top
NOREF#4794  -  []  386.14 243.1 0 top
NOREF#4795  -  []  285.7 248.01 0 top
NOREF#4796  -  []  419.43 287.49 90 top
NOREF#4797  -  []  279.47 201.29 0 top
NOREF#4798  -  []  280.3 177 90 top
NOREF#4799  -  []  24.62 456.29 0 top
NOREF#4800  -  []  371.52 254.76 90 top
NOREF#4801  -  []  360.73 165.85 90 top
NOREF#4802  -  []  365.13 195.99 0 top
NOREF#4803  -  []  334.43 263.38 90 top
NOREF#4804  -  []  400.3 293 0 top
NOREF#4805  -  []  477.74 302.69 0 top
NOREF#4806  -  []  345.98 203.69 0 top
NOREF#4807  -  []  482.56 225.45 0 top
NOREF#4808  -  []  297.34 264.47 90 top
NOREF#4809  -  []  399.47 203.4 0 top
NOREF#4810  -  []  309.34 183.1 0 top
NOREF#4811  -  []  409.66 255.8 90 top
NOREF#4812  -  []  513.7 257.08 90 top
NOREF#4813  -  []  454.88 175.52 0 top
NOREF#4814  -  []  395.93 267.58 90 top
NOREF#4815  -  []  326.9 267.17 0 top
NOREF#4816  -  []  284.23 199.6 90 top
NOREF#4817  -  []  355.33 298.68 90 top
NOREF#4818  -  []  417.34 200.35 90 top
NOREF#4819  -  []  401.57 261.78 90 top
NOREF#4820  -  []  170.58 281.85 0 top
NOREF#4821  -  []  182.03 214.07 90 top
NOREF#4822  -  []  488.59 276.99 0 top
NOREF#4823  -  []  435.28 166.49 90 top
NOREF#4824  -  []  348.53 120.91 0 top
NOREF#4825  -  []  452.91 273.79 0 top
NOREF#4826  -  []  179.95 279.65 0 top
NOREF#4827  -  []  372.33 207.4 0 top
NOREF#4828  -  []  294.58 288.89 0 top
NOREF#4829  -  []  431.15 300.13 90 top
NOREF#4830  -  []  289.89 93.57 90 top
NOREF#4831  -  []  289.13 191.83 90 top
NOREF#4832  -  []  277.82 335.72 0 top
NOREF#4833  -  []  286.23 187.42 0 top
NOREF#4834  -  []  326.62 270 0 top
NOREF#4835  -  []  457.07 82.22 90 top
NOREF#4836  -  []  480.8 23.5 90 top
NOREF#4837  -  []  439.67 227.08 90 top
NOREF#4838  -  []  500.02 259.74 0 top
NOREF#4839  -  []  275.6 252.3 90 top
NOREF#4840  -  []  247.68 211.04 0 top
NOREF#4841  -  []  292.19 192 90 top
NOREF#4842  -  []  489.17 183.92 0 top
NOREF#4843  -  []  287.08 197.69 0 top
NOREF#4844  -  []  292.33 265.91 0 top
NOREF#4845  -  []  360.37 200.29 0 top
NOREF#4846  -  []  294.22 200.52 0 top
NOREF#4847  -  []  452.45 244.3 0 top
NOREF#4848  -  []  428.82 197.39 0 top
NOREF#4849  -  []  324.8 188.34 0 top
NOREF#4850  -  []  429.13 228.57 0 top
NOREF#4851  -  []  230.87 227.3 90 top
NOREF#4852  -  []  394.08 260.75 0 top
NOREF#4853  -  []  294.43 201.87 90 top
NOREF#4854  -  []  292.19 252 90 top
NOREF#4855  -  []  289.31 251.57 90 top
NOREF#4856  -  []  366.58 260.49 90 top
NOREF#4857  -  []  508.3 270.82 90 top
NOREF#4858  -  []  374.42 204.17 90 top
NOREF#4859  -  []  279.47 260.61 0 top
NOREF#4860  -  []  217.72 377.26 90 top
NOREF#4861  -  []  319.09 152.43 0 top
NOREF#4862  -  []  543.4 383.9 90 top
NOREF#4863  -  []  281.8 297.54 0 top
NOREF#4864  -  []  374.57 282.51 90 top
NOREF#4865  -  []  503.27 279.95 0 top
NOREF#4866  -  []  342.85 186 45 top
NOREF#4867  -  []  285.92 226.51 0 top
NOREF#4868  -  []  498.8 45.5 0 top
NOREF#4869  -  []  191.18 278.84 0 top
NOREF#4870  -  []  404.8 255.09 90 top
NOREF#4871  -  []  296.14 203.74 0 top
NOREF#4872  -  []  330.07 252.35 0 top
NOREF#4873  -  []  428.82 217.66 0 top
NOREF#4874  -  []  401.57 202.44 90 top
NOREF#4875  -  []  333.23 262.51 0 top
NOREF#4876  -  []  225.47 184.61 0 top
NOREF#4877  -  []  284.2 194.4 0 top
NOREF#4878  -  []  331.37 285.71 0 top
NOREF#4879  -  []  293.03 213.89 0 top
NOREF#4880  -  []  514.57 168.33 90 top
NOREF#4881  -  []  413.36 190.09 0 top
NOREF#4882  -  []  404.1 199 0 top
NOREF#4883  -  []  269.18 198.29 90 top
NOREF#4884  -  []  334.3 260.8 90 top
NOREF#4885  -  []  391.3 222 0 top
NOREF#4886  -  []  214.04 193.01 0 top
NOREF#4887  -  []  370.9 262.85 90 top
NOREF#4888  -  []  330.35 190.17 0 top
NOREF#4889  -  []  268.88 208.98 0 top
NOREF#4890  -  []  363.37 256.69 0 top
NOREF#4891  -  []  329.31 251.57 90 top
NOREF#4892  -  []  319.47 210.08 0 top
NOREF#4893  -  []  314.08 260.75 90 top
NOREF#4894  -  []  281.57 260.33 90 top
NOREF#4895  -  []  419.4 293.92 0 top
NOREF#4896  -  []  318.05 148.79 90 top
NOREF#4897  -  []  288.88 259.55 90 top
NOREF#4898  -  []  403.33 265.18 0 top
NOREF#4899  -  []  489.17 286.79 0 top
NOREF#4900  -  []  412.17 244.64 90 top
NOREF#4901  -  []  323.63 204.65 0 top
NOREF#4902  -  []  285.7 207.15 0 top
NOREF#4903  -  []  284.53 205.39 90 top
NOREF#4904  -  []  288.07 193.43 90 top
NOREF#4905  -  []  408.88 199.55 90 top
NOREF#4906  -  []  280.46 84.76 0 top
NOREF#4907  -  []  260.3 257 90 top
NOREF#4908  -  []  260.53 204.49 0 top
NOREF#4909  -  []  355.26 71.53 0 top
NOREF#4910  -  []  50.8 5 0 top
NOREF#4911  -  []  270.8 446.5 0 top
NOREF#4912  -  []  288.54 251.43 0 top
NOREF#4913  -  []  361.81 294.95 0 top
NOREF#4914  -  []  357.12 89.06 90 top
NOREF#4915  -  []  413.32 259.35 0 top
NOREF#4916  -  []  419.43 227.49 90 top
NOREF#4917  -  []  366.8 247.3 90 top
NOREF#4918  -  []  264.61 302.34 90 top
NOREF#4919  -  []  269.62 170.23 90 top
NOREF#4920  -  []  367.88 269.1 90 top
NOREF#4921  -  []  432.75 278.74 90 top
NOREF#4922  -  []  317.29 374.69 90 top
NOREF#4923  -  []  374.57 278.11 90 top
NOREF#4924  -  []  221.84 360.96 90 top
NOREF#4925  -  []  414.12 297.54 0 top
NOREF#4926  -  []  405.92 286.51 0 top
NOREF#4927  -  []  284.8 195.09 90 top
NOREF#4928  -  []  319.09 121.95 0 top
NOREF#4929  -  []  196.58 271.58 90 top
NOREF#4930  -  []  36.22 366.45 90 top
NOREF#4931  -  []  294.66 70.62 0 top
NOREF#4932  -  []  305.45 295.32 0 top
NOREF#4933  -  []  285.3 207 90 top
NOREF#4934  -  []  329.71 195.72 90 top
NOREF#4935  -  []  370.07 185.6 0 top
NOREF#4936  -  []  404.53 265.39 90 top
NOREF#4937  -  []  374.57 222.51 90 top
NOREF#4938  -  []  238.16 194.61 90 top
NOREF#4939  -  []  371.07 196.08 90 top
NOREF#4940  -  []  404.75 222.51 90 top
NOREF#4941  -  []  221.09 174.57 90 top
NOREF#4942  -  []  170.58 293.28 0 top
NOREF#4943  -  []  367 187.55 90 top
NOREF#4944  -  []  461.95 374.69 90 top
NOREF#4945  -  []  333.29 118.31 90 top
NOREF#4946  -  []  408.89 191.89 0 top
NOREF#4947  -  []  373.93 273.57 0 top
NOREF#4948  -  []  349.34 176.74 0 top
NOREF#4949  -  []  369.11 191.32 90 top
NOREF#4950  -  []  334.3 200.8 90 top
NOREF#4951  -  []  329.66 255.8 90 top
NOREF#4952  -  []  328.46 196.44 0 top
NOREF#4953  -  []  348.37 122.11 0 top
NOREF#4954  -  []  57.77 1.56 90 top
NOREF#4955  -  []  327.59 196.03 0 top
NOREF#4956  -  []  465.73 276.99 0 top
NOREF#4957  -  []  175.18 296.73 90 top
NOREF#4958  -  []  267.97 103.62 0 top
NOREF#4959  -  []  404.2 194.4 0 top
NOREF#4960  -  []  412 87.33 0 top
NOREF#4961  -  []  452.91 205.21 0 top
NOREF#4962  -  []  370.35 190.17 0 top
NOREF#4963  -  []  402.41 191.74 90 top
NOREF#4964  -  []  289.61 259.55 90 top
NOREF#4965  -  []  471.13 182.52 0 top
NOREF#4966  -  []  308.48 103.62 0 top
NOREF#4967  -  []  55.8 0 90 top
NOREF#4968  -  []  452.45 175.72 0 top
NOREF#4969  -  []  462.76 187.96 90 top
NOREF#4970  -  []  403.37 256.69 0 top
NOREF#4971  -  []  363.66 273.64 90 top
NOREF#4972  -  []  324.54 212.7 90 top
NOREF#4973  -  []  365.13 255.99 0 top
NOREF#4974  -  []  391.54 176.74 0 top
NOREF#4975  -  []  406.01 82 90 top
NOREF#4976  -  []  437.51 191.38 0 top
NOREF#4977  -  []  330.07 250.47 0 top
NOREF#4978  -  []  52.77 405.06 0 top
NOREF#4979  -  []  362.41 251.74 90 top
NOREF#4980  -  []  351.52 137.19 0 top
NOREF#4981  -  []  493.51 89.06 90 top
NOREF#4982  -  []  368.53 287.49 0 top
NOREF#4983  -  []  372.17 244.64 90 top
NOREF#4984  -  []  366.94 269.1 90 top
NOREF#4985  -  []  297.43 210.27 0 top
NOREF#4986  -  []  521.42 288 90 top
NOREF#4987  -  []  413.02 257.65 0 top
NOREF#4988  -  []  416.44 264.79 0 top
NOREF#4989  -  []  280.35 268.16 90 top
NOREF#4990  -  []  503.27 245.66 0 top
NOREF#4991  -  []  406.8 247.3 90 top
NOREF#4992  -  []  288.95 256.35 0 top
NOREF#4993  -  []  410.76 195.38 0 top
NOREF#4994  -  []  226.24 278.84 0 top
NOREF#4995  -  []  237.43 300.35 0 top
NOREF#4996  -  []  209.66 286.08 90 top
NOREF#4997  -  []  462.76 191.16 0 top
NOREF#4998  -  []  337.78 288.89 90 top
NOREF#4999  -  []  520.17 262.4 90 top
NOREF#5000  -  []  466.31 209.81 0 top
NOREF#5001  -  []  270.96 80.68 90 top
NOREF#5002  -  []  289.87 256.73 0 top
NOREF#5003  -  []  258.58 204.03 90 top
NOREF#5004  -  []  336.8 259 90 top
NOREF#5005  -  []  367 247.28 90 top
NOREF#5006  -  []  371.07 256.08 90 top
NOREF#5007  -  []  219.2 122.35 90 top
NOREF#5008  -  []  349.18 196.09 90 top
NOREF#5009  -  []  170.58 258.99 0 top
NOREF#5010  -  []  230.87 193.01 90 top
NOREF#5011  -  []  189.51 292.92 90 top
NOREF#5012  -  []  358.8 23.5 90 top
NOREF#5013  -  []  363.61 147.59 90 top
NOREF#5014  -  []  377.78 228.89 90 top
NOREF#5015  -  []  279.47 262.74 0 top
NOREF#5016  -  []  450.39 87.33 0 top
NOREF#5017  -  []  434.66 292.3 0 top
NOREF#5018  -  []  240.95 291.89 90 top
NOREF#5019  -  []  418.69 296.27 90 top
NOREF#5020  -  []  288.3 265 0 top
NOREF#5021  -  []  325.92 286.51 0 top
NOREF#5022  -  []  329.77 252.68 0 top
NOREF#5023  -  []  365.13 248.64 0 top
NOREF#5024  -  []  377.34 260.35 90 top
NOREF#5025  -  []  181.48 236.13 90 top
NOREF#5026  -  []  349.34 183.1 0 top
NOREF#5027  -  []  227.67 218.9 0 top
NOREF#5028  -  []  291.37 225.71 0 top
NOREF#5029  -  []  516.65 282.46 0 top
NOREF#5030  -  []  408.09 200.49 90 top
NOREF#5031  -  []  488.59 179.33 90 top
NOREF#5032  -  []  347.77 146.99 90 top
NOREF#5033  -  []  317.13 97.42 90 top
NOREF#5034  -  []  406.57 254.43 90 top
NOREF#5035  -  []  287.47 196.04 0 top
NOREF#5036  -  []  332.53 122.71 0 top
NOREF#5037  -  []  408.56 194.22 0 top
NOREF#5038  -  []  328.89 297.03 90 top
NOREF#5039  -  []  480.8 424.5 90 top
NOREF#5040  -  []  412.9 173.55 90 top
NOREF#5041  -  []  330.9 262.85 90 top
NOREF#5042  -  []  312.72 381.09 0 top
NOREF#5043  -  []  500.02 179.33 90 top
NOREF#5044  -  []  297.78 288.89 90 top
NOREF#5045  -  []  368.94 72.94 0 top
NOREF#5046  -  []  271.3 248 90 top
NOREF#5047  -  []  204.46 105.96 90 top
NOREF#5048  -  []  196.58 210.26 90 top
NOREF#5049  -  []  281.57 261.78 90 top
NOREF#5050  -  []  372.72 265.56 0 top
NOREF#5051  -  []  35.19 392.68 0 top
NOREF#5052  -  []  188.92 108.35 90 top
NOREF#5053  -  []  293.3 197.5 90 top
NOREF#5054  -  []  477.74 244.1 0 top
NOREF#5055  -  []  322.3 269.2 0 top
NOREF#5056  -  []  238.62 299.08 0 top
NOREF#5057  -  []  341.41 167.75 90 top
NOREF#5058  -  []  473.79 96.1 0 top
NOREF#5059  -  []  475.76 97.97 0 top
NOREF#5060  -  []  517.92 227.67 0 top
NOREF#5061  -  []  334.22 257.01 90 top
NOREF#5062  -  []  324.1 259 0 top
NOREF#5063  -  []  520.87 223.83 90 top
NOREF#5064  -  []  333.32 197.12 0 top
NOREF#5065  -  []  385.03 207.58 0 top
NOREF#5066  -  []  254.87 297.17 90 top
NOREF#5067  -  []  317.01 176.74 0 top
NOREF#5068  -  []  324.5 246.78 0 top
NOREF#5069  -  []  320.3 233 0 top
NOREF#5070  -  []  294.73 170.29 0 top
NOREF#5071  -  []  370.67 190.47 90 top
NOREF#5072  -  []  211.45 97.07 90 top
NOREF#5073  -  []  496.49 375.96 0 top
NOREF#5074  -  []  323.63 265.5 0 top
NOREF#5075  -  []  288.28 257.05 90 top
NOREF#5076  -  []  285.7 256.69 0 top
NOREF#5077  -  []  521.42 247.78 0 top
NOREF#5078  -  []  361.57 261.78 90 top
NOREF#5079  -  []  281.55 228.96 0 top
NOREF#5080  -  []  284.8 195.09 90 top
NOREF#5081  -  []  366.9 260.19 0 top
NOREF#5082  -  []  479.01 171.81 0 top
NOREF#5083  -  []  505.73 361.76 0 top
NOREF#5084  -  []  508.3 241.61 90 top
NOREF#5085  -  []  500.02 263.8 90 top
NOREF#5086  -  []  403.05 195.79 90 top
NOREF#5087  -  []  186.38 124.04 90 top
NOREF#5088  -  []  326.4 287.55 90 top
NOREF#5089  -  []  375.42 259.88 90 top
NOREF#5090  -  []  319.47 260.61 0 top
NOREF#5091  -  []  407.08 257.69 0 top
NOREF#5092  -  []  362.3 209.2 0 top
NOREF#5093  -  []  361.21 252.38 0 top
NOREF#5094  -  []  292.09 270.01 0 top
NOREF#5095  -  []  262.58 350.14 90 top
NOREF#5096  -  []  520.87 178.11 90 top
NOREF#5097  -  []  289.67 269.11 90 top
NOREF#5098  -  []  476.08 89.67 0 top
NOREF#5099  -  []  355.93 267.58 90 top
NOREF#5100  -  []  321.55 285.71 0 top
NOREF#5101  -  []  324.8 256.37 0 top
NOREF#5102  -  []  294.22 199.67 0 top
NOREF#5103  -  []  455.16 360.96 0 top
NOREF#5104  -  []  408.76 269.36 90 top
NOREF#5105  -  []  365.68 185.52 90 top
NOREF#5106  -  []  240.95 189.02 90 top
NOREF#5107  -  []  195.73 190.05 90 top
NOREF#5108  -  []  179.95 216.45 90 top
NOREF#5109  -  []  510.29 382.58 0 top
NOREF#5110  -  []  253.73 281.02 0 top
NOREF#5111  -  []  321.57 260.33 90 top
NOREF#5112  -  []  288.53 287.49 0 top
NOREF#5113  -  []  426.14 243.1 0 top
NOREF#5114  -  []  371.14 245.99 90 top
NOREF#5115  -  []  401.7 209.33 0 top
NOREF#5116  -  []  308.3 225 0 top
NOREF#5117  -  []  405.7 256.69 0 top
NOREF#5118  -  []  445.07 216.26 0 top
NOREF#5119  -  []  403.93 113.43 90 top
NOREF#5120  -  []  431.54 176.74 0 top
NOREF#5121  -  []  409.77 252.68 0 top
NOREF#5122  -  []  287.45 254.68 90 top
NOREF#5123  -  []  292.33 205.91 0 top
NOREF#5124  -  []  514.57 236.91 90 top
NOREF#5125  -  []  266.21 287.55 90 top
NOREF#5126  -  []  373.32 199.35 0 top
NOREF#5127  -  []  488.59 259.74 0 top
NOREF#5128  -  []  416.14 263.74 0 top
NOREF#5129  -  []  52.77 405.06 0 top
NOREF#5130  -  []  170.58 178.98 0 top
NOREF#5131  -  []  334.22 197.01 90 top
NOREF#5132  -  []  359.47 263.4 0 top
NOREF#5133  -  []  482.56 285.39 0 top
NOREF#5134  -  []  202.61 175.97 0 top
NOREF#5135  -  []  404.54 212.7 90 top
NOREF#5136  -  []  409.31 191.57 90 top
NOREF#5137  -  []  319.15 208.8 0 top
NOREF#5138  -  []  182.03 262.98 90 top
NOREF#5139  -  []  230.64 203 0 top
NOREF#5140  -  []  292.38 228.89 0 top
NOREF#5141  -  []  410.99 252.65 0 top
NOREF#5142  -  []  57.77 1.56 90 top
NOREF#5143  -  []  311.3 282 0 top
NOREF#5144  -  []  290.32 195.4 0 top
NOREF#5145  -  []  401.39 114.7 90 top
NOREF#5146  -  []  489.17 192.56 0 top
NOREF#5147  -  []  430.85 286.11 0 top
NOREF#5148  -  []  474.62 89.67 0 top
NOREF#5149  -  []  214.04 278.84 0 top
NOREF#5150  -  []  366.08 260.19 0 top
NOREF#5151  -  []  406.3 267 0 top
NOREF#5152  -  []  345.03 267.58 0 top
NOREF#5153  -  []  365.3 267 90 top
NOREF#5154  -  []  366.58 247.42 0 top
NOREF#5155  -  []  324.1 199 0 top
NOREF#5156  -  []  374.3 268.85 90 top
NOREF#5157  -  []  280.37 200.97 0 top
NOREF#5158  -  []  287.28 199.55 90 top
NOREF#5159  -  []  426.14 173.54 90 top
NOREF#5160  -  []  215.43 361.76 0 top
NOREF#5161  -  []  421.42 239.08 90 top
NOREF#5162  -  []  209.66 183.21 90 top
NOREF#5163  -  []  209.66 294.48 90 top
NOREF#5164  -  []  404.13 290.32 90 top
NOREF#5165  -  []  382.85 186 45 top
NOREF#5166  -  []  477.16 229.51 90 top
NOREF#5167  -  []  452.45 278.59 0 top
NOREF#5168  -  []  263.3 220 0 top
NOREF#5169  -  []  359.7 298.81 0 top
NOREF#5170  -  []  284.48 195.99 0 top
NOREF#5171  -  []  462.76 294.03 0 top
NOREF#5172  -  []  326.3 193.44 90 top
NOREF#5173  -  []  309.18 198.29 90 top
NOREF#5174  -  []  188.31 260.15 90 top
NOREF#5175  -  []  320.37 203.08 0 top
NOREF#5176  -  []  516.65 196.4 90 top
NOREF#5177  -  []  244.11 297.81 90 top
NOREF#5178  -  []  170.58 213.27 0 top
NOREF#5179  -  []  366.57 195.72 0 top
NOREF#5180  -  []  510.89 359.7 0 top
NOREF#5181  -  []  409.11 191.32 90 top
NOREF#5182  -  []  271.3 188 90 top
NOREF#5183  -  []  367.45 254.68 90 top
NOREF#5184  -  []  182.03 294.08 0 top
NOREF#5185  -  []  374.3 260.8 90 top
NOREF#5186  -  []  230.87 253.19 90 top
NOREF#5187  -  []  260.3 197 90 top
NOREF#5188  -  []  404.5 244.96 0 top
NOREF#5189  -  []  439.67 230.28 0 top
NOREF#5190  -  []  404.75 280.31 90 top
NOREF#5191  -  []  327.93 184.02 90 top
NOREF#5192  -  []  332.9 169.15 90 top
NOREF#5193  -  []  31.6 368.94 90 top
NOREF#5194  -  []  386.78 335.34 90 top
NOREF#5195  -  []  330.55 269.37 90 top
NOREF#5196  -  []  410.35 250.17 0 top
NOREF#5197  -  []  412 87.33 0 top
NOREF#5198  -  []  321.57 209.12 90 top
NOREF#5199  -  []  413.23 204.02 0 top
NOREF#5200  -  []  497.31 262.4 90 top
NOREF#5201  -  []  488.59 267 0 top
NOREF#5202  -  []  418.68 87.35 90 top
NOREF#5203  -  []  318.05 135.5 90 top
NOREF#5204  -  []  299.66 90.74 0 top
NOREF#5205  -  []  281.55 288.95 0 top
NOREF#5206  -  []  307.51 72.06 90 top
NOREF#5207  -  []  275.1 262.13 90 top
NOREF#5208  -  []  413.32 197.97 0 top
P1  HIGH-SIDE  [PG_3680_DPS64_HDAV_H_P1]  348.3 235 0 top
P2  HIGH-SIDE  [PG_3680_HDRF3_LPC_P2]  348.3 235 0 top
P4  HIGH-SIDE  [PG_3680_HDRF3_DPS32_P4]  348.3 235 0 top
P5  HIGH-SIDE  [PG_3680_HDRF3_LPC_P5]  348.3 235 0 top
P6  HIGH-SIDE  [PG_3680_HDRF3_DPS32_HDAV_H_P6]  348.3 235 0 top
P7  LOW-SIDE  [PG_3680_DPS64_HDAV_L_P7]  348.3 235 0 top
P8  LOW-SIDE  [PG_3680_HDRF3_LPC_P8]  348.3 235 0 top
P9  SYS  [PG_3680_SYS_P9]  348.3 235 0 top
P10  LOW-SIDE  [PG_3680_HDRF3_LPC_P10]  348.3 235 0 top
P11  LOW-SIDE  [PG_3680_DPS64_HDAV_L_P11]  348.3 235 0 top
PJ07604-1982  REF-CODE-SOCKET  [SOCKET_CODE]  10.59 336.03 90 top
PT1  PT-ULTRAFLEX-TESTER-75X35  [PROTECTOR_75X35MM]  28.17 365.77 270 bottom
QFN100-10X10  REF-CODE-SOCKET  [SOCKET_CODE]  356.56 399.85 0 top
R1  0-5-S2  [R0201]  290.07 196.08 315 top
R2  0-5-S2  [R0201]  288.29 195.34 315 top
R3  0-5-S2  [R0201]  290.67 192.05 270 top
R4  NC/0-5-S2  [R0201]  290.37 192.35 0 top
R5  0-5-S2  [R0201]  286.57 194.73 270 bottom
R6  0-5-S2  [R0201]  284.8 195.39 270 top
R7  0-5-S2  [R0201]  284.8 188.04 270 top
R8  NC/0-5-S2  [R0201]  285.1 188.34 180 top
R9  0-5-S2  [R0201]  284.8 195.39 270 bottom
R10  0-5-S4  [R0402]  243.59 170.84 90 top
R11  0-5-S4  [R0402]  242.32 170.84 90 top
R12  NC/10K-1-S4  [R0402]  239.68 190.26 90 top
R13  0-5-S4  [R0402]  240.95 190.26 90 top
R14  NC/10K-1-S4  [R0402]  241.05 170.84 90 top
R15  0-5-S4  [R0402]  238.41 190.26 90 top
R16  0-5-S4  [R0402]  239.78 170.84 90 top
R17  0-5-S4  [R0402]  237.14 190.26 90 top
R18  NC/10K-1-S4  [R0402]  238.67 170.84 90 top
R19  0-5-S4  [R0402]  196.97 191.57 180 bottom
R20  0-5-S4  [R0402]  196.97 196.65 180 bottom
R21  0-5-S4  [R0402]  196.97 199.19 180 bottom
R22  45.3-1-S4  [R0402]  300.3 230.93 90 bottom
R23  45.3-1-S4  [R0402]  248.43 196.99 90 bottom
R24  0-5-S4  [R0402]  275.86 83.54 180 bottom
R25  45.3-1-S4  [R0402]  300.3 226.94 270 bottom
R26  45.3-1-S4  [R0402]  248.43 193 270 bottom
R27  0-5-S4  [R0402]  275.86 88.62 180 bottom
R28  0-5-S4  [R0402]  275.86 91.16 180 bottom
R29  NC/45.3-1-S4  [R0402]  226.55 190.37 90 bottom
R30  0-5-S4  [R0402]  190.74 191.57 180 bottom
R31  0-5-S4  [R0402]  190.74 196.65 180 bottom
R32  0-5-S4  [R0402]  190.74 199.19 180 bottom
R33  NC/45.3-1-S4  [R0402]  225.41 190.37 270 bottom
R34  10K-1-S4  [R0402]  267.69 138.9 270 bottom
R35  10K-1-S4  [R0402]  270.23 138.9 270 bottom
R36  10K-1-S4  [R0402]  272.77 138.9 270 bottom
R37  10K-1-S4  [R0402]  275.31 138.9 270 bottom
R38  0-5-S4  [R0402]  270.1 128.74 0 bottom
R39  10K-1-S4  [R0402]  277.85 138.9 270 bottom
R40  10K-1-S4  [R0402]  280.39 138.9 270 bottom
R41  10K-1-S4  [R0402]  282.93 138.9 270 bottom
R42  0-5-S4  [R0402]  283.06 128.74 180 bottom
R43  12K-1-S4  [R0402]  301.23 205.74 0 bottom
R45  32.4-1-S4  [R0402]  224 176.36 90 bottom
R47  32.4-1-S4  [R0402]  224 169.1 90 bottom
R48  0-5-S4  [R0402]  263.96 196.59 90 bottom
R49  NC/0-5-S4  [R0402]  271.19 196.59 90 bottom
R50  0-5-S4  [R0402]  303.65 174.38 270 top
R51  NC/0-5-S4  [R0402]  274.8 229.46 270 bottom
R53  0-5-S4  [R0402]  287.84 232.59 90 bottom
R54  NC/0-5-S4  [R0402]  287.84 228.39 270 bottom
R55  0-5-S4  [R0402]  276.65 234.23 180 bottom
R57  NC/10K-1-S4  [R0402]  203.11 190.98 0 bottom
R58  NC/10K-1-S4  [R0402]  203.11 198.24 0 bottom
R59  NC/10K-1-S4  [R0402]  203.11 182.57 0 bottom
R60  NC/10K-1-S4  [R0402]  203.11 189.84 0 bottom
R61  0-5-S4  [R0402]  261.46 83.12 0 bottom
R62  0-5-S4  [R0402]  264.46 83.12 180 bottom
R63  0-5-S4  [R0402]  221.67 169.1 90 bottom
R64  0-5-S4  [R0402]  222.84 169.1 90 bottom
R65  0-5-S4  [R0402]  222.84 171.52 270 bottom
R66  0-5-S4  [R0402]  221.67 171.52 270 bottom
R67  0-5-S4  [R0402]  221.67 176.36 90 bottom
R68  0-5-S4  [R0402]  222.84 176.36 90 bottom
R69  0-5-S4  [R0402]  222.84 178.78 270 bottom
R70  0-5-S4  [R0402]  221.67 178.78 270 bottom
R71  2-5-D-2  [RC02W_27MM]  167.18 196.61 180 bottom
R72  2-5-D-2  [RC02W_27MM]  167.18 185.18 180 bottom
R73  2-5-D-2  [RC02W_27MM]  167.18 173.75 180 bottom
R74  0-5-S4  [R0402]  224 171.52 270 bottom
R75  0-5-S4  [R0402]  224 178.78 270 bottom
R76  0-5-S4  [R0402]  301.23 201.38 180 bottom
R77  0-5-S4  [R0402]  296.99 210.27 180 bottom
R78  0-5-S4  [R0402]  290.14 215.27 270 bottom
R79  0-5-S4  [R0402]  284.6 215.27 270 bottom
R81  0-5-S4  [R0402]  301.23 203.52 180 bottom
R82  0-5-S4  [R0402]  301.23 206.84 180 bottom
R83  0-5-S4  [R0402]  301.23 204.64 180 bottom
R327  4.7K-0.1-S4-YA  [R0402]  324.2 153.4 90 top
R338  4.7K-0.1-S4-YA  [R0402]  338.94 153.9 0 bottom
R342  4.7K-0.1-S4-YA  [R0402]  323.7 153.9 0 bottom
R346  4.7K-0.1-S4-YA  [R0402]  339.44 153.4 90 top
R347  4.7K-0.1-S4-YA  [R0402]  354.68 153.4 90 top
R348  4.7K-0.1-S4-YA  [R0402]  369.92 153.4 90 top
R349  4.7K-0.1-S4-YA  [R0402]  323.7 138.66 0 bottom
R350  4.7K-0.1-S4-YA  [R0402]  338.94 138.66 0 bottom
R351  4.7K-0.1-S4-YA  [R0402]  369.42 138.66 0 bottom
R352  4.7K-0.1-S4-YA  [R0402]  354.68 138.16 90 top
R353  4.7K-0.1-S4-YA  [R0402]  354.18 138.66 0 bottom
R354  4.7K-0.1-S4-YA  [R0402]  369.92 138.16 90 top
R355  4.7K-0.1-S4-YA  [R0402]  339.44 138.16 90 top
R356  4.7K-0.1-S4-YA  [R0402]  324.2 138.16 90 top
R357  4.7K-0.1-S4-YA  [R0402]  369.42 123.42 0 bottom
R358  4.7K-0.1-S4-YA  [R0402]  354.18 123.42 0 bottom
R359  4.7K-0.1-S4-YA  [R0402]  323.7 123.42 0 bottom
R360  4.7K-0.1-S4-YA  [R0402]  339.44 122.92 90 top
R361  4.7K-0.1-S4-YA  [R0402]  338.94 123.42 0 bottom
R362  4.7K-0.1-S4-YA  [R0402]  324.2 122.92 90 top
R363  4.7K-0.1-S4-YA  [R0402]  354.68 122.92 90 top
R364  4.7K-0.1-S4-YA  [R0402]  369.92 122.92 90 top
R365  4.7K-0.1-S4-YA  [R0402]  354.18 153.9 0 bottom
R366  4.7K-0.1-S4-YA  [R0402]  369.42 153.9 0 bottom
RB8  0-5-S4  [R0402]  340.71 69.41 90 bottom
RB205  10K-1-S4  [R0402]  383.64 71.53 180 bottom
RB595  13K-1-S4  [R0402]  212.08 85.3 270 bottom
RB596  100K-0.1-S4  [R0402]  208.27 96.1 270 bottom
RB597  0-5-S4  [R0402]  210.18 99.27 0 bottom
RB598  NC/10-1-S6  [R0603]  215.89 96.1 270 bottom
RB599  200K-10-D-Regulate  [VRD_3296W_BOURNS_SKPIN]  220.34 84.03 270 top
RB600  20K-1-S4  [R0402]  215.89 91.02 90 bottom
RB601  200-1-S4  [R0402]  230.5 85.3 270 bottom
RB603  100K-0.1-S4  [R0402]  336.52 96.1 270 bottom
RB604  0-5-S4  [R0402]  338.42 99.27 0 bottom
RB605  NC/10-1-S6  [R0603]  344.14 96.1 270 bottom
RB606  200K-10-D-Regulate  [VRD_3296W_BOURNS_SKPIN]  348.58 84.03 270 top
RB607  20K-1-S4  [R0402]  344.14 91.02 90 bottom
RB608  200-1-S4  [R0402]  358.74 85.3 270 bottom
RB617  100K-0.1-S4  [R0402]  472.9 96.1 270 bottom
RB618  0-5-S4  [R0402]  474.81 99.27 0 bottom
RB619  NC/10-1-S6  [R0603]  480.52 96.1 270 bottom
RB620  200K-10-D-Regulate  [VRD_3296W_BOURNS_SKPIN]  484.97 84.03 270 top
RB621  20K-1-S4  [R0402]  480.52 91.02 90 bottom
RB622  200-1-S4  [R0402]  495.13 85.3 270 bottom
RB623  7.15K-1-S4  [R0402]  339.06 85.3 270 bottom
RB624  NC/9.1K-1-S4  [R0402]  340.33 85.3 270 bottom
RB627  7.15K-1-S4  [R0402]  475.44 85.3 270 bottom
RB628  NC/9.1K-1-S4  [R0402]  476.71 85.3 270 bottom
RT1  1K-1-S4  [R0402]  295.96 74.28 270 bottom
RTL8730EAH  REF-CODE-CHIP  [CHIP_CODE]  24.88 467.11 0 top
S0_1V3  TP03-D  [TP_060_040]  303.07 176.74 270 top
S0_GND1  TP03-D  [TP_060_040]  271.47 226.49 0 top
S0_GND2  TP03-D  [TP_060_040]  178.68 168.35 0 top
S0_GND3  TP03-D  [TP_060_040]  178.68 192.26 0 top
S0_GND4  TP03-D  [TP_060_040]  249.33 168.21 0 top
S0_VD33_ALL1  TP03-D  [TP_060_040]  296.84 166.41 0 top
S0_VDD09  TP03-D  [TP_060_040]  178.68 189.54 0 top
S0_VDD18_A  TP03-D  [TP_060_040]  273.12 232.15 0 top
S0_VDD18_D  TP03-D  [TP_060_040]  233.87 196.21 0 top
S1_1V3  TP03-D  [TP_060_040]  353.74 170.41 270 top
S1_GND1  TP03-D  [TP_060_040]  311.47 226.49 0 top
S1_GND2  TP03-D  [TP_060_040]  178.68 202.64 0 top
S1_GND3  TP03-D  [TP_060_040]  178.68 226.55 0 top
S1_GND4  TP03-D  [TP_060_040]  249.33 202.5 0 top
S1_VD33_ALL1  TP03-D  [TP_060_040]  337.73 166.41 0 top
S1_VDD09  TP03-D  [TP_060_040]  178.68 223.83 0 top
S1_VDD18_A  TP03-D  [TP_060_040]  313.12 232.15 0 top
S1_VDD18_D  TP03-D  [TP_060_040]  233.87 230.5 0 top
S2_1V3  TP03-D  [TP_060_040]  393.74 170.66 270 top
S2_GND1  TP03-D  [TP_060_040]  351.47 226.49 0 top
S2_GND2  TP03-D  [TP_060_040]  517.92 233.07 180 top
S2_GND3  TP03-D  [TP_060_040]  517.92 209.16 180 top
S2_GND4  TP03-D  [TP_060_040]  447.27 233.21 180 top
S2_VD33_ALL1  TP03-D  [TP_060_040]  376.84 166.41 0 top
S2_VDD09  TP03-D  [TP_060_040]  517.92 211.88 180 top
S2_VDD18_A  TP03-D  [TP_060_040]  353.12 232.15 0 top
S2_VDD18_D  TP03-D  [TP_060_040]  462.73 205.21 180 top
S3_1V3  TP03-D  [TP_060_040]  426.12 170.69 270 top
S3_GND1  TP03-D  [TP_060_040]  391.47 226.49 0 top
S3_GND2  TP03-D  [TP_060_040]  517.92 198.78 180 top
S3_GND3  TP03-D  [TP_060_040]  517.92 174.87 180 top
S3_GND4  TP03-D  [TP_060_040]  447.27 198.92 180 top
S3_VD33_ALL1  TP03-D  [TP_060_040]  416.84 166.41 0 top
S3_VDD09  TP03-D  [TP_060_040]  517.92 177.59 180 top
S3_VDD18_A  TP03-D  [TP_060_040]  393.12 232.15 0 top
S3_VDD18_D  TP03-D  [TP_060_040]  462.73 170.92 180 top
S4_1V3  TP03-D  [TP_060_040]  300.67 301.65 90 top
S4_GND1  TP03-D  [TP_060_040]  271.47 286.49 0 top
S4_GND2  TP03-D  [TP_060_040]  178.68 236.93 0 top
S4_GND3  TP03-D  [TP_060_040]  178.68 260.84 0 top
S4_GND4  TP03-D  [TP_060_040]  249.33 236.79 0 top
S4_VD33_ALL1  TP03-D  [TP_060_040]  281.8 302.75 0 top
S4_VDD09  TP03-D  [TP_060_040]  178.68 258.12 0 top
S4_VDD18_A  TP03-D  [TP_060_040]  273.12 292.15 0 top
S4_VDD18_D  TP03-D  [TP_060_040]  233.87 264.79 0 top
S5_1V3  TP03-D  [TP_060_040]  340.67 301.65 90 top
S5_GND1  TP03-D  [TP_060_040]  311.47 286.49 0 top
S5_GND2  TP03-D  [TP_060_040]  178.68 271.22 0 top
S5_GND3  TP03-D  [TP_060_040]  178.68 295.13 0 top
S5_GND4  TP03-D  [TP_060_040]  249.33 271.08 0 top
S5_VD33_ALL1  TP03-D  [TP_060_040]  321.8 302.75 0 top
S5_VDD09  TP03-D  [TP_060_040]  178.68 292.41 0 top
S5_VDD18_A  TP03-D  [TP_060_040]  313.12 292.15 0 top
S5_VDD18_D  TP03-D  [TP_060_040]  233.87 299.08 0 top
S6_1V3  TP03-D  [TP_060_040]  380.47 301.63 90 top
S6_GND1  TP03-D  [TP_060_040]  351.47 286.49 0 top
S6_GND2  TP03-D  [TP_060_040]  517.92 301.65 180 top
S6_GND3  TP03-D  [TP_060_040]  517.92 277.74 180 top
S6_GND4  TP03-D  [TP_060_040]  447.27 301.79 180 top
S6_VD33_ALL1  TP03-D  [TP_060_040]  361.81 302.75 0 top
S6_VDD09  TP03-D  [TP_060_040]  517.92 280.46 180 top
S6_VDD18_A  TP03-D  [TP_060_040]  353.12 292.15 0 top
S6_VDD18_D  TP03-D  [TP_060_040]  462.73 273.79 180 top
S7_1V3  TP03-D  [TP_060_040]  420.67 301.65 90 top
S7_GND1  TP03-D  [TP_060_040]  391.47 286.49 0 top
S7_GND2  TP03-D  [TP_060_040]  517.92 267.36 180 top
S7_GND3  TP03-D  [TP_060_040]  517.92 243.45 180 top
S7_GND4  TP03-D  [TP_060_040]  447.27 267.5 180 top
S7_VD33_ALL1  TP03-D  [TP_060_040]  414.12 302.75 0 top
S7_VDD09  TP03-D  [TP_060_040]  517.92 246.17 180 top
S7_VDD18_A  TP03-D  [TP_060_040]  393.12 292.15 0 top
S7_VDD18_D  TP03-D  [TP_060_040]  462.73 239.5 180 top
SCREW3  CHROMA3680-OUTLINE-RF-TYPE2  [PG_3680_FT_RF_OUTLINE_CHROMA_V2]  348.3 235 0 top
SITE0  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  288.3 205 0 top
SITE1  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  328.3 205 0 top
SITE2  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  368.3 205 0 top
SITE3  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  408.3 205 0 top
SITE4  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  288.3 265 0 top
SITE5  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  328.3 265 0 top
SITE6  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  368.3 265 0 top
SITE7  RTL8730A-QFN100  [SK_QFN100P_0P35MM_MJC_L8730A]  408.3 265 0 top
SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  295.98 187.27 210 top
SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  290.67 182.17 180 top
SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  284.8 181.21 180 top
ST1  SHORT  [DEFAULT_SHORT_SMALL]  308.04 471.8 0 top
ST2  SHORT  [DEFAULT_SHORT_SMALL]  311.26 471.8 0 top
ST3  SHORT  [DEFAULT_SHORT_SMALL]  330.58 471.8 0 top
ST4  SHORT  [DEFAULT_SHORT_SMALL]  333.8 471.8 0 top
ST5  SHORT  [DEFAULT_SHORT_SMALL]  337.02 471.8 0 top
ST8  SHORT  [DEFAULT_SHORT_SMALL]  340.23 471.8 0 top
ST11  SHORT  [DEFAULT_SHORT_SMALL]  324.14 471.8 0 top
ST12  SHORT  [DEFAULT_SHORT_SMALL]  327.36 471.8 0 top
ST13  SHORT  [DEFAULT_SHORT_SMALL]  314.48 471.8 0 top
ST14  SHORT  [DEFAULT_SHORT_SMALL]  317.7 471.8 0 top
ST15  SHORT  [DEFAULT_SHORT_SMALL]  320.92 471.8 0 top
ST16  SHORT  [DEFAULT_SHORT_SMALL]  92.36 471.8 0 top
ST17  SHORT  [DEFAULT_SHORT_SMALL]  95.58 471.8 0 top
ST18  SHORT  [DEFAULT_SHORT_SMALL]  98.8 471.8 0 top
ST19  SHORT  [DEFAULT_SHORT_SMALL]  102.01 471.8 0 top
SW1  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  206.7 113.43 0 top
SW2  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  177.49 127.85 0 top
SW3  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  177.49 113.43 0 top
SW4  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  392.5 132.93 0 top
SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  276.58 132.55 0 top
SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  262.96 86.93 0 top
SW7  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  392.5 118.51 0 top
SWB1  SW-SLIDE-1-D4.7  [SW_5P_UTP0030B]  29.2 440.49 270 top
TEMP_MEASUREMENT  TP03-D  [TP_060_040]  295.96 68.23 0 top
TP_VN15  TP03-D  [TP_060_040]  369.42 69.49 0 top
TP_VP5A  TP03-D  [TP_060_040]  341.1 73.07 0 top
TP_VP5B  TP03-D  [TP_060_040]  327.1 69.17 0 top
TP_VP12  TP03-D  [TP_060_040]  278.13 69.87 180 top
TP_VP15  TP03-D  [TP_060_040]  359.32 69.49 0 top
TP_VP24  TP03-D  [TP_060_040]  330.88 69.49 0 top
U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  288.89 191.89 270 top
U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  286.58 187.88 270 top
U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  241.68 179.81 180 bottom
U5  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  335.63 150.09 180 bottom
U6  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  350.87 150.09 180 bottom
U7  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  320.39 150.09 180 bottom
U8  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  366.11 150.09 180 bottom
U9  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  350.87 134.85 180 bottom
U10  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  335.63 134.85 180 bottom
U11  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  366.11 134.85 180 bottom
U12  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  320.39 134.85 180 bottom
U13  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  320.39 119.61 180 bottom
U14  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  335.63 119.61 180 bottom
U15  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  350.87 119.61 180 bottom
U16  MAX4896ETP+-TQFN20  [TQFN5X5_20P_0P65MM_G_V2]  366.11 119.61 180 bottom
UB5  25LC256-SOIC8  [SO8_206X127MM]  378.32 72.16 180 bottom
UB70  RT8293A-SOP8  [SO8_206X127MM_G]  212.08 92.29 270 bottom
UB71  RT8293A-SOP8  [SO8_206X127MM_G]  340.33 92.29 270 bottom
UB73  RT8293A-SOP8  [SO8_206X127MM_G]  476.71 92.29 270 bottom
UNK1BD1  BD120-1.5A-S4-MU  [FB0402]  321.19 215.24 270 bottom
UNK1BD2  BD120-1.5A-S4-MU  [FB0402]  336.96 212.38 180 bottom
UNK1BD3  BD120-1.5A-S4-MU  [FB0402]  320.15 215.24 270 bottom
UNK1BD5  BD120-1.5A-S4-MU  [FB0402]  317.33 205.67 0 bottom
UNK1BD7  BD120-1.5A-S4-MU  [FB0402]  322.24 215.24 270 bottom
UNK1BD9  BD120-1.5A-S4-MU  [FB0402]  341.2 202.45 180 bottom
UNK1BD11  BD120-1.5A-S4-MU  [FB0402]  336.96 211.34 180 bottom
UNK1BD12  BD120-1.5A-S4-MU  [FB0402]  329.07 215.24 270 bottom
UNK1BD13  BD120-1.5A-S4-MU  [FB0402]  317.36 198.82 0 bottom
UNK1BD15  BD120-1.5A-S4-MU  [FB0402]  320.48 195.03 0 bottom
UNK1BD16  BD120-1.5A-S4-MU  [FB0402]  323.8 201.66 180 bottom
UNK1BD17  BD120-1.5A-S4-MU  [FB0402]  323.8 200.62 180 bottom
UNK1BD18  BD120-1.5A-S4-MU  [FB0402]  335.71 197.57 180 bottom
UNK1BD19  BD120-1.5A-S4-MU  [FB0402]  335.71 196.37 180 bottom
UNK1BD20  BD120-1.5A-S4-MU  [FB0402]  315.79 205.62 270 bottom
UNK1BD21  BD120-1.5A-S4-MU  [FB0402]  335.71 194.23 180 bottom
UNK1BD22  BD120-1.5A-S4-MU  [FB0402]  322.3 191.38 180 bottom
UNK1BD23  BD120-1.5A-S4-MU  [FB0402]  322.3 193.44 0 bottom
UNK1BD27  NC/BD120-1.5A-S4-MU  [FB0402]  223.73 224.16 180 bottom
UNK1BD28  BD120-1.5A-S4-MU  [FB0402]  316.81 208.45 270 bottom
UNK1BD29  BD120-1.5A-S4-MU  [FB0402]  326.81 215.24 270 bottom
UNK1BD30  BD120-1.5A-S4-MU  [FB0402]  316.96 211.26 225 bottom
UNK1BD31  BD120-1.5A-S4-MU  [FB0402]  333.85 214.77 180 bottom
UNK1BD32  BD120-1.5A-S4-MU  [FB0402]  246.28 224.58 270 top
UNK1BD33  BD120-1.5A-S4-MU  [FB0402]  320.27 86.03 270 bottom
UNK1BD34  BD120-1.5A-S4-MU  [FB0402]  323.48 189.65 0 bottom
UNK1BD35  BD120-1.5A-S4-MU  [FB0402]  333.63 194.23 180 bottom
UNK1BD36  BD120-1.5A-S4-MU  [FB0402]  315.32 198.83 0 bottom
UNK1BD37  BD120-1.5A-S4-MU  [FB0402]  331.21 215.24 270 bottom
UNK1C1  NC/1P-25-N-S2-WA  [C0201]  329.16 196.56 45 top
UNK1C2  10P-50-N-S2-MU  [C0201]  333.49 191.58 300 top
UNK1C3  NC/1.2P-50-N-S2-MU  [C0201]  330.97 195.6 45 top
UNK1C4  NC/1P-25-N-S2-WA  [C0201]  327.81 196.25 225 top
UNK1C5  NC/1.2P-50-N-S2-MU  [C0201]  328.77 194.43 225 top
UNK1C6  10P-50-N-S2-MU  [C0201]  330.67 190.77 90 top
UNK1C7  NC/10P-50-N-S2-MU  [C0201]  330.37 190.47 180 top
UNK1C8  CNC-S2  [C0201]  330.37 185.6 180 top
UNK1C9  NC/1P-25-N-S2-WA  [C0201]  326.87 195.72 180 bottom
UNK1C10  NC/1.2P-50-N-S2-MU  [C0201]  326.27 193.75 180 bottom
UNK1C11  NC/1P-25-N-S2-WA  [C0201]  325.1 196.37 180 top
