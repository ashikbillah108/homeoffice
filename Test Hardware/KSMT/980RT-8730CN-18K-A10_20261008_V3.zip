# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UNK6K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  468.21 365.36 270 bottom
UNK6L1  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  351.97 266.04 270 bottom
UNK6L3  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  377.28 283.34 90 bottom
UNK6L4  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  367.47 283.34 90 bottom
UNK6R1  0-5-S2  [R0201]  370.07 256.08 315 top
UNK6R2  0-5-S2  [R0201]  368.29 255.34 315 top
UNK6R3  0-5-S2  [R0201]  370.67 252.05 270 top
UNK6R4  NC/0-5-S2  [R0201]  370.37 252.35 0 top
UNK6R5  0-5-S2  [R0201]  366.57 254.73 270 bottom
UNK6R6  0-5-S2  [R0201]  364.8 255.39 270 top
UNK6R7  0-5-S2  [R0201]  364.8 248.04 270 top
UNK6R8  NC/0-5-S2  [R0201]  365.1 248.34 180 top
UNK6R9  0-5-S2  [R0201]  364.8 255.39 270 bottom
UNK6R10  0-5-S4  [R0402]  453.01 299.16 270 top
UNK6R11  0-5-S4  [R0402]  454.28 299.16 270 top
UNK6R12  NC/10K-1-S4  [R0402]  456.92 279.74 270 top
UNK6R13  0-5-S4  [R0402]  455.65 279.74 270 top
UNK6R14  NC/10K-1-S4  [R0402]  455.55 299.16 270 top
UNK6R15  0-5-S4  [R0402]  458.19 279.74 270 top
UNK6R16  0-5-S4  [R0402]  456.82 299.16 270 top
UNK6R17  0-5-S4  [R0402]  459.46 279.74 270 top
UNK6R18  NC/10K-1-S4  [R0402]  457.94 299.16 270 top
UNK6R19  0-5-S4  [R0402]  499.63 278.44 0 bottom
UNK6R20  0-5-S4  [R0402]  499.63 273.36 0 bottom
UNK6R21  0-5-S4  [R0402]  499.63 270.82 0 bottom
UNK6R22  45.3-1-S4  [R0402]  380.29 290.93 90 bottom
UNK6R23  45.3-1-S4  [R0402]  448.17 273.01 270 bottom
UNK6R24  0-5-S4  [R0402]  467.38 381.04 0 bottom
UNK6R25  45.3-1-S4  [R0402]  380.29 286.94 270 bottom
UNK6R26  45.3-1-S4  [R0402]  448.17 277 90 bottom
UNK6R27  0-5-S4  [R0402]  467.38 375.96 0 bottom
UNK6R28  0-5-S4  [R0402]  467.38 373.42 0 bottom
UNK6R29  NC/45.3-1-S4  [R0402]  470.05 279.63 270 bottom
UNK6R30  0-5-S4  [R0402]  505.86 278.44 0 bottom
UNK6R31  0-5-S4  [R0402]  505.86 273.36 0 bottom
UNK6R32  0-5-S4  [R0402]  505.86 270.82 0 bottom
UNK6R33  NC/45.3-1-S4  [R0402]  471.2 279.63 90 bottom
UNK6R34  10K-1-S4  [R0402]  404.56 332.8 90 bottom
UNK6R35  10K-1-S4  [R0402]  402.02 332.8 90 bottom
UNK6R36  10K-1-S4  [R0402]  399.48 332.8 90 bottom
UNK6R37  10K-1-S4  [R0402]  396.94 332.8 90 bottom
UNK6R38  0-5-S4  [R0402]  402.15 342.96 180 bottom
UNK6R39  10K-1-S4  [R0402]  394.4 332.8 90 bottom
UNK6R40  10K-1-S4  [R0402]  391.86 332.8 90 bottom
UNK6R41  10K-1-S4  [R0402]  389.32 332.8 90 bottom
UNK6R42  0-5-S4  [R0402]  389.2 342.96 0 bottom
UNK6R43  12K-1-S4  [R0402]  381.23 265.74 0 bottom
UNK6R45  32.4-1-S4  [R0402]  472.6 293.64 270 bottom
UNK6R47  32.4-1-S4  [R0402]  472.6 300.9 270 bottom
UNK6R48  0-5-S4  [R0402]  343.96 256.59 90 bottom
UNK6R49  NC/0-5-S4  [R0402]  351.19 256.59 90 bottom
UNK6R50  0-5-S4  [R0402]  386.55 300.63 180 top
UNK6R51  NC/0-5-S4  [R0402]  354.8 289.46 270 bottom
UNK6R53  0-5-S4  [R0402]  367.84 292.59 90 bottom
UNK6R54  NC/0-5-S4  [R0402]  367.84 288.39 270 bottom
UNK6R55  0-5-S4  [R0402]  356.65 294.23 180 bottom
UNK6R57  NC/10K-1-S4  [R0402]  493.49 279.02 180 bottom
UNK6R58  NC/10K-1-S4  [R0402]  493.49 271.76 180 bottom
UNK6R59  NC/10K-1-S4  [R0402]  493.49 287.43 180 bottom
UNK6R60  NC/10K-1-S4  [R0402]  493.49 280.16 180 bottom
UNK6R61  0-5-S4  [R0402]  481.78 381.46 180 bottom
UNK6R62  0-5-S4  [R0402]  478.78 381.46 0 bottom
UNK6R63  0-5-S4  [R0402]  474.93 300.9 270 bottom
UNK6R64  0-5-S4  [R0402]  473.76 300.9 270 bottom
UNK6R65  0-5-S4  [R0402]  473.76 298.48 90 bottom
UNK6R66  0-5-S4  [R0402]  474.93 298.48 90 bottom
UNK6R67  0-5-S4  [R0402]  474.93 293.64 270 bottom
UNK6R68  0-5-S4  [R0402]  473.76 293.64 270 bottom
UNK6R69  0-5-S4  [R0402]  473.76 291.22 90 bottom
UNK6R70  0-5-S4  [R0402]  474.93 291.22 90 bottom
UNK6R71  2-5-D-2  [RC02W_27MM]  529.42 273.39 0 bottom
UNK6R72  2-5-D-2  [RC02W_27MM]  529.42 284.82 0 bottom
UNK6R73  2-5-D-2  [RC02W_27MM]  529.42 296.25 0 bottom
UNK6R74  0-5-S4  [R0402]  472.6 298.48 90 bottom
UNK6R75  0-5-S4  [R0402]  472.6 291.22 90 bottom
UNK6R76  0-5-S4  [R0402]  381.23 261.38 180 bottom
UNK6R77  0-5-S4  [R0402]  376.99 270.27 180 bottom
UNK6R78  0-5-S4  [R0402]  370.14 275.27 270 bottom
UNK6R79  0-5-S4  [R0402]  364.6 275.27 270 bottom
UNK6R81  0-5-S4  [R0402]  381.23 263.52 180 bottom
UNK6R82  0-5-S4  [R0402]  381.23 266.84 180 bottom
UNK6R83  0-5-S4  [R0402]  381.23 264.64 180 bottom
UNK6SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  375.98 247.27 210 top
UNK6SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  370.67 242.17 180 top
UNK6SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  364.8 241.21 180 top
UNK6ST3  SHORT  [DEFAULT_SHORT_SMALL]  266.19 471.8 0 top
UNK6ST4  SHORT  [DEFAULT_SHORT_SMALL]  269.41 471.8 0 top
UNK6ST5  SHORT  [DEFAULT_SHORT_SMALL]  272.63 471.8 0 top
UNK6ST8  SHORT  [DEFAULT_SHORT_SMALL]  275.85 471.8 0 top
UNK6ST11  SHORT  [DEFAULT_SHORT_SMALL]  250.1 471.8 0 top
UNK6ST12  SHORT  [DEFAULT_SHORT_SMALL]  253.32 471.8 0 top
UNK6ST13  SHORT  [DEFAULT_SHORT_SMALL]  256.54 471.8 0 top
UNK6ST14  SHORT  [DEFAULT_SHORT_SMALL]  259.75 471.8 0 top
UNK6ST15  SHORT  [DEFAULT_SHORT_SMALL]  262.97 471.8 0 top
UNK6ST16  SHORT  [DEFAULT_SHORT_SMALL]  66.6 471.8 0 top
UNK6ST17  SHORT  [DEFAULT_SHORT_SMALL]  69.82 471.8 0 top
UNK6ST18  SHORT  [DEFAULT_SHORT_SMALL]  73.04 471.8 0 top
UNK6ST19  SHORT  [DEFAULT_SHORT_SMALL]  76.26 471.8 0 top
UNK6SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  395.67 339.15 180 top
UNK6SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  480.28 377.65 180 top
UNK6U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  368.89 251.89 270 top
UNK6U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  366.58 247.88 270 top
UNK6U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  454.92 290.19 0 bottom
UNK6Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  354.22 262.03 45 top
UNK7BD1  BD120-1.5A-S4-MU  [FB0402]  401.19 275.24 270 bottom
UNK7BD2  BD120-1.5A-S4-MU  [FB0402]  416.96 272.38 180 bottom
UNK7BD3  BD120-1.5A-S4-MU  [FB0402]  400.15 275.24 270 bottom
UNK7BD5  BD120-1.5A-S4-MU  [FB0402]  397.33 265.67 0 bottom
UNK7BD7  BD120-1.5A-S4-MU  [FB0402]  402.23 275.24 270 bottom
UNK7BD9  BD120-1.5A-S4-MU  [FB0402]  421.2 262.45 180 bottom
UNK7BD11  BD120-1.5A-S4-MU  [FB0402]  416.96 271.34 180 bottom
UNK7BD12  BD120-1.5A-S4-MU  [FB0402]  409.07 275.24 270 bottom
UNK7BD13  BD120-1.5A-S4-MU  [FB0402]  397.36 258.82 0 bottom
UNK7BD15  BD120-1.5A-S4-MU  [FB0402]  400.48 255.03 0 bottom
UNK7BD16  BD120-1.5A-S4-MU  [FB0402]  403.79 261.66 180 bottom
UNK7BD17  BD120-1.5A-S4-MU  [FB0402]  403.79 260.62 180 bottom
UNK7BD18  BD120-1.5A-S4-MU  [FB0402]  415.71 257.57 180 bottom
UNK7BD19  BD120-1.5A-S4-MU  [FB0402]  415.71 256.37 180 bottom
UNK7BD20  BD120-1.5A-S4-MU  [FB0402]  395.79 265.62 270 bottom
UNK7BD21  BD120-1.5A-S4-MU  [FB0402]  415.71 254.23 180 bottom
UNK7BD22  BD120-1.5A-S4-MU  [FB0402]  402.3 251.38 180 bottom
UNK7BD23  BD120-1.5A-S4-MU  [FB0402]  402.3 253.44 0 bottom
UNK7BD27  NC/BD120-1.5A-S4-MU  [FB0402]  472.87 245.84 0 bottom
UNK7BD28  BD120-1.5A-S4-MU  [FB0402]  396.81 268.45 270 bottom
UNK7BD29  BD120-1.5A-S4-MU  [FB0402]  406.81 275.24 270 bottom
UNK7BD30  BD120-1.5A-S4-MU  [FB0402]  396.96 271.26 225 bottom
UNK7BD31  BD120-1.5A-S4-MU  [FB0402]  413.85 274.77 180 bottom
UNK7BD32  BD120-1.5A-S4-MU  [FB0402]  450.32 245.42 90 top
UNK7BD33  BD120-1.5A-S4-MU  [FB0402]  502.59 378.55 90 bottom
UNK7BD34  BD120-1.5A-S4-MU  [FB0402]  403.48 249.65 0 bottom
UNK7BD35  BD120-1.5A-S4-MU  [FB0402]  413.63 254.23 180 bottom
UNK7BD36  BD120-1.5A-S4-MU  [FB0402]  395.31 258.83 0 bottom
UNK7BD37  BD120-1.5A-S4-MU  [FB0402]  411.2 275.24 270 bottom
UNK7C1  NC/1P-25-N-S2-WA  [C0201]  409.16 256.56 45 top
UNK7C2  10P-50-N-S2-MU  [C0201]  413.49 251.58 300 top
UNK7C3  NC/1.2P-50-N-S2-MU  [C0201]  410.97 255.6 45 top
UNK7C4  NC/1P-25-N-S2-WA  [C0201]  407.8 256.25 225 top
UNK7C5  NC/1.2P-50-N-S2-MU  [C0201]  408.77 254.43 225 top
UNK7C6  10P-50-N-S2-MU  [C0201]  410.67 250.77 90 top
UNK7C7  NC/10P-50-N-S2-MU  [C0201]  410.37 250.47 180 top
UNK7C8  CNC-S2  [C0201]  410.37 245.6 180 top
UNK7C9  NC/1P-25-N-S2-WA  [C0201]  406.87 255.72 180 bottom
UNK7C10  NC/1.2P-50-N-S2-MU  [C0201]  406.27 253.75 180 bottom
UNK7C11  NC/1P-25-N-S2-WA  [C0201]  405.1 256.37 180 top
UNK7C12  NC/1.2P-50-N-S2-MU  [C0201]  404.5 254.4 180 top
UNK7C13  10P-50-N-S2-MU  [C0201]  404.8 246.76 90 top
UNK7C14  NC/10P-50-N-S2-MU  [C0201]  405.1 246.46 0 top
UNK7C15  CNC-S2  [C0201]  405.1 244.64 0 top
UNK7C16  NC/1P-25-N-S2-WA  [C0201]  405.1 256.37 180 bottom
UNK7C17  NC/0.1U-35-X-S2-MU  [C0201]  413.62 260.2 180 bottom
UNK7C18  NC/0.1U-35-X-S2-MU  [C0201]  413.62 259.35 180 bottom
UNK7C19  NC/1.2P-50-N-S2-MU  [C0201]  404.5 254.4 180 bottom
UNK7C20  0.1U-35-X-S2-MU  [C0201]  413.62 257.12 0 bottom
UNK7C21  0.1U-35-X-S2-MU  [C0201]  413.62 257.97 0 bottom
UNK7C22  0.1U-16-X-S4-MU  [C0402]  452.86 245.45 270 top
UNK7C23  0.9P-50-N-S4-MU  [C0402]  396.6 263.41 270 top
UNK7C24  0.1U-25-X-S4-TY  [C0402]  472.84 244.76 180 bottom
UNK7C25  0.9P-50-N-S4-MU  [C0402]  396.6 260.64 90 top
UNK7C38  1P-50-N-S4-WA  [C0402]  480.86 253.14 180 bottom
UNK7C39  22P-50-N-S4-AVX  [C0402]  484.26 253.14 180 bottom
UNK7C40  1P-50-N-S4-WA  [C0402]  480.86 245.87 180 bottom
UNK7C41  22P-50-N-S4-AVX  [C0402]  484.26 245.87 180 bottom
UNK7C44  0.1U-35-X-S2-MU  [C0201]  403.93 265.5 0 bottom
UNK7C45  0.1U-35-X-S2-MU  [C0201]  412.4 269.41 270 bottom
UNK7C46  0.1U-35-X-S2-MU  [C0201]  403.93 264.65 0 bottom
UNK7C47  0.1U-35-X-S2-MU  [C0201]  412.63 262.19 180 bottom
UNK7C48  0.1U-35-X-S2-MU  [C0201]  399.77 262.74 180 top
UNK7C49  0.1U-35-X-S2-MU  [C0201]  412.63 265.91 180 bottom
UNK7C52  0.1U-35-X-S2-MU  [C0201]  403.93 266.35 0 bottom
UNK7C53  10U-10-X-S4-SS  [C0402]  387.75 266.49 90 bottom
UNK7C54  0.1U-35-X-S2-MU  [C0201]  408.82 269.41 270 bottom
UNK7C55  0.1U-25-X-S4-TY  [C0402]  390.03 266.49 90 bottom
UNK7C56  0.1U-35-X-S2-MU  [C0201]  416.74 263.42 0 top
UNK7C57  NC/10U-10-X-S4-SS  [C0402]  388.88 266.49 90 bottom
UNK7C58  0.1U-35-X-S2-MU  [C0201]  403.66 273.94 90 top
UNK7C59  0.1U-35-X-S2-MU  [C0201]  412.63 267.4 180 bottom
UNK7C60  10U-10-X-S4-SS  [C0402]  419.1 272.43 0 bottom
UNK7C61  0.1U-35-X-S2-MU  [C0201]  407.88 269.4 270 bottom
UNK7C62  22U-25-X-S8-MU  [C0805]  387.63 274.73 0 bottom
UNK7C63  22U-25-X-S8-MU  [C0805]  387.63 276.76 0 bottom
UNK7C64  0.1U-35-X-S2-MU  [C0201]  399.77 260.61 180 top
UNK7C65  47U-16-T-SC  [CODE_C]  455.45 239.5 0 bottom
UNK7C66  10U-16-T-SA  [CODE_A]  455.41 239.5 0 top
UNK7C67  10U-10-X-S4-SS  [C0402]  419.1 271.31 0 bottom
UNK7C68  22U-10-T-SA  [CODE_A]  415.77 294.95 0 bottom
UNK7C69  22U-10-T-SA  [CODE_A]  415.77 297.54 0 bottom
UNK7C70  22U-10-T-SA  [CODE_A]  415.77 300.11 0 bottom
UNK7C71  22U-10-T-SA  [CODE_A]  415.77 297.54 0 top
UNK7C72  22U-10-T-SA  [CODE_A]  415.77 294.95 0 top
UNK7C73  10U-10-X-S4-SS  [C0402]  395.28 257.76 180 bottom
UNK7C74  0.1U-35-X-S2-MU  [C0201]  406.58 260.79 90 bottom
UNK7C75  0.1U-35-X-S2-MU  [C0201]  416.74 260.67 0 top
UNK7C76  10U-10-X-S4-SS  [C0402]  400.45 256.1 180 bottom
UNK7C77  0.1U-35-X-S2-MU  [C0201]  405.76 260.79 90 bottom
UNK7C78  0.1U-35-X-S2-MU  [C0201]  399.77 261.29 180 top
UNK7C79  0.1U-35-X-S2-MU  [C0201]  399.77 259.92 180 top
UNK7C83  10U-10-X-S4-SS  [C0402]  415.74 258.66 0 bottom
UNK7C84  0.1U-35-X-S2-MU  [C0201]  408.09 260.79 90 bottom
UNK7C85  0.1U-35-X-S2-MU  [C0201]  407.36 260.79 90 bottom
UNK7C88  0.1U-35-X-S2-MU  [C0201]  399.77 263.4 180 top
UNK7C89  10U-10-X-S4-SS  [C0402]  394.26 266.99 180 bottom
UNK7C90  10U-10-X-S4-SS  [C0402]  415.74 255.29 0 bottom
UNK7C91  0.1U-35-X-S2-MU  [C0201]  407.68 258.01 0 bottom
UNK7C92  22U-25-X-S8-MU  [C0805]  481.52 175.23 180 bottom
UNK7C93  22U-25-X-S8-MU  [C0805]  481.52 175.23 180 top
UNK7C94  47U-16-T-SC  [CODE_C]  481.55 171.81 180 bottom
UNK7C95  10U-16-T-SA  [CODE_A]  481.58 171.81 180 top
UNK7C96  10U-10-X-S4-SS  [C0402]  417.82 258.66 0 bottom
UNK7C97  10U-10-X-S4-SS  [C0402]  401.83 250.88 270 top
UNK7C98  0.1U-35-X-S2-MU  [C0201]  400.89 251.78 270 top
UNK7C99  10U-10-X-S4-SS  [C0402]  402.77 252.94 270 top
UNK7C100  0.1U-35-X-S2-MU  [C0201]  403.05 256.09 270 top
UNK7C101  10U-10-X-S4-SS  [C0402]  394.26 265.15 180 bottom
UNK7C102  0.1U-35-X-S2-MU  [C0201]  412.63 263.7 180 bottom
UNK7C105  0.1U-35-X-S2-MU  [C0201]  412.63 264.49 180 bottom
UNK7C106  10U-10-X-S4-SS  [C0402]  417.65 285.88 90 bottom
UNK7C107  0.1U-35-X-S2-MU  [C0201]  416.74 264.79 0 top
UNK7C108  0.1U-25-X-S4-TY  [C0402]  416.53 285.88 90 bottom
UNK7C109  NC/10U-10-X-S4-SS  [C0402]  418.77 285.88 90 bottom
UNK7C110  1U-10-X-S4-MU  [C0402]  418.36 260.67 180 top
UNK7C111  10U-10-X-S4-SS  [C0402]  396.81 267.48 270 top
UNK7C112  0.1U-35-X-S2-MU  [C0201]  398.83 268.2 270 top
UNK7C113  10U-25-X-S6-MU  [C0603]  422.96 265.99 90 bottom
UNK7C116  22U-25-X-S8-MU  [C0805]  408.03 278.11 180 bottom
UNK7C117  22U-25-X-S8-MU  [C0805]  408.02 280.27 180 bottom
UNK7C118  10U-10-X-S4-SS  [C0402]  405.72 275.27 90 bottom
UNK7C119  0.1U-35-X-S2-MU  [C0201]  406.94 269.4 270 bottom
UNK7C120  47U-16-T-SC  [CODE_C]  432.75 297.13 90 bottom
UNK7C121  10U-16-T-SA  [CODE_A]  432.75 297.13 90 top
UNK7C122  10U-10-X-S4-SS  [C0402]  417.82 257.55 0 bottom
UNK7C123  10U-10-X-S4-SS  [C0402]  396.28 271.28 135 top
UNK7C124  0.1U-35-X-S2-MU  [C0201]  399.77 270.08 180 top
UNK7C125  10U-10-X-S4-SS  [C0402]  413.38 275.27 90 top
UNK7C126  0.1U-35-X-S2-MU  [C0201]  413.33 273.89 180 top
UNK7C127  10U-10-X-S4-SS  [C0402]  451.59 245.45 270 top
UNK7C128  0.1U-35-X-S2-MU  [C0201]  454.13 245.45 270 top
UNK7C129  10U-10-X-S4-SS  [C0402]  393.26 258.82 180 bottom
UNK7C130  0.1U-25-X-S4-TY  [C0402]  503.68 378.52 270 bottom
UNK7C131  22U-10-T-SA  [CODE_A]  498.14 375.96 180 bottom
UNK7C132  22U-10-T-SA  [CODE_A]  498.14 381.09 180 top
UNK7C133  22U-10-T-SA  [CODE_A]  498.14 378.53 180 top
UNK7C134  22U-10-T-SA  [CODE_A]  498.14 378.53 180 bottom
UNK7C135  22U-10-T-SA  [CODE_A]  498.14 381.09 180 bottom
UNK7C136  10U-10-X-S4-SS  [C0402]  407.84 285.88 90 bottom
UNK7C137  0.1U-25-X-S4-TY  [C0402]  406.72 285.88 90 bottom
UNK7C138  NC/10U-10-X-S4-SS  [C0402]  408.95 285.88 90 bottom
UNK7C139  22U-25-X-S8-MU  [C0805]  396.49 285.56 270 bottom
UNK7C140  47U-16-T-SC  [CODE_C]  432.75 281.28 270 bottom
UNK7C141  10U-16-T-SA  [CODE_A]  432.75 281.28 270 top
UNK7C142  22U-25-X-S8-MU  [C0805]  398.79 285.56 270 bottom
UNK7C143  NC/10P-50-N-S4-WA  [C0402]  417 268.8 180 bottom
UNK7C144  NC/10P-50-N-S4-WA  [C0402]  417 267.63 180 bottom
UNK7C145  NC/10P-50-N-S4-WA  [C0402]  509.5 260.51 270 top
UNK7C146  NC/10P-50-N-S4-WA  [C0402]  509.5 257.31 270 top
UNK7C147  NC/10P-50-N-S4-WA  [C0402]  509.5 267.78 270 top
UNK7C148  NC/10P-50-N-S4-WA  [C0402]  509.5 264.58 270 top
UNK7C149  NC/10P-50-N-S4-WA  [C0402]  509.5 251.88 270 top
UNK7C150  NC/10P-50-N-S4-WA  [C0402]  509.5 248.68 270 top
UNK7C152  0.1U-35-X-S2-MU  [C0201]  409.67 269.41 270 bottom
UNK7C153  CNC-S2  [C0201]  412.12 265.24 180 bottom
UNK7D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  413.73 250.31 30 top
UNK7D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  410.24 246.49 0 top
UNK7D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  405.23 245.52 180 top
UNK7J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  502.07 244.15 90 top
UNK7J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  509.09 381.06 90 top
UNK7J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  508.3 244.15 90 top
UNK7J4  HDR-8X1-M  [JP_8P_100]  524.83 329.88 90 top
UNK7J5  HDR-1X1-M  [JP_1P_RD070_040]  494.16 373.18 270 top
UNK7J6  HDR-2X1-M  [JP_2P_100]  497.08 373.18 270 top
UNK7J7  HDR-2X1-M  [JP_2P_100]  502.07 115.4 0 top
UNK7J8  HDR-2X1-M  [JP_2P_100]  505.88 115.4 0 top
UNK7J9  HDR-2X1-M  [JP_2P_100]  498.26 115.4 0 top
UNK7K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 248.95 180 bottom
UNK7K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 255.96 180 bottom
UNK7K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 262.97 180 bottom
UNK7K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 241.1 180 bottom
UNK7K5  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  425.5 288.94 270 bottom
UNK7K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  500.37 365.36 270 bottom
UNK7K7  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  442.97 240.72 90 bottom
UNK7K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 249.5 180 bottom
UNK7K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  429.74 241.5 180 bottom
UNK7K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  466.36 258.14 180 bottom
UNK7K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 265.4 180 bottom
UNK7K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 258.14 180 bottom
UNK7K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 258.14 180 bottom
UNK7K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  466.36 265.4 180 bottom
UNK7K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 265.4 180 bottom
UNK7K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  469.33 241.1 180 bottom
UNK7K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  469.33 249.5 180 bottom
UNK7K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 249.5 180 bottom
UNK7K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  403.15 282.11 90 bottom
UNK7K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  390.68 270.58 0 bottom
UNK7K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  387.58 260.09 90 bottom
UNK7K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  408.58 299.34 90 bottom
UNK7K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  401.15 290.55 0 bottom
UNK7K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  425.05 296.92 0 bottom
UNK7K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  414.18 290.49 0 bottom
UNK7K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  412.97 282.11 90 bottom
UNK7K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 240.91 90 bottom
UNK7K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 252.34 90 bottom
UNK7K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 263.77 90 bottom
UNK7K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 258.14 180 bottom
UNK7K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 265.4 180 bottom
UNK7K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 249.5 180 bottom
UNK7K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  507.33 365.36 270 bottom
UNK7L1  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  391.97 266.04 270 bottom
UNK7L3  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  417.28 283.34 90 bottom
UNK7L4  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  407.47 283.34 90 bottom
UNK7R1  0-5-S2  [R0201]  410.07 256.08 315 top
UNK7R2  0-5-S2  [R0201]  408.29 255.34 315 top
UNK7R3  0-5-S2  [R0201]  410.67 252.05 270 top
UNK7R4  NC/0-5-S2  [R0201]  410.37 252.35 0 top
UNK7R5  0-5-S2  [R0201]  406.57 254.73 270 bottom
UNK7R6  0-5-S2  [R0201]  404.8 255.39 270 top
UNK7R7  0-5-S2  [R0201]  404.8 248.04 270 top
UNK7R8  NC/0-5-S2  [R0201]  405.1 248.34 180 top
UNK7R9  0-5-S2  [R0201]  404.8 255.39 270 bottom
UNK7R10  0-5-S4  [R0402]  453.01 264.87 270 top
UNK7R11  0-5-S4  [R0402]  454.28 264.87 270 top
UNK7R12  NC/10K-1-S4  [R0402]  456.92 245.45 270 top
UNK7R13  0-5-S4  [R0402]  455.65 245.45 270 top
UNK7R14  NC/10K-1-S4  [R0402]  455.55 264.87 270 top
UNK7R15  0-5-S4  [R0402]  458.19 245.45 270 top
UNK7R16  0-5-S4  [R0402]  456.82 264.87 270 top
UNK7R17  0-5-S4  [R0402]  459.46 245.45 270 top
UNK7R18  NC/10K-1-S4  [R0402]  457.94 264.87 270 top
UNK7R19  0-5-S4  [R0402]  499.63 244.15 0 bottom
UNK7R20  0-5-S4  [R0402]  499.63 239.07 0 bottom
UNK7R21  0-5-S4  [R0402]  499.63 236.53 0 bottom
UNK7R22  45.3-1-S4  [R0402]  420.29 290.93 90 bottom
UNK7R23  45.3-1-S4  [R0402]  448.17 238.72 270 bottom
UNK7R24  0-5-S4  [R0402]  506.49 381.04 0 bottom
UNK7R25  45.3-1-S4  [R0402]  420.29 286.94 270 bottom
UNK7R26  45.3-1-S4  [R0402]  448.17 242.71 90 bottom
UNK7R27  0-5-S4  [R0402]  506.49 375.96 0 bottom
UNK7R28  0-5-S4  [R0402]  506.49 373.42 0 bottom
UNK7R29  NC/45.3-1-S4  [R0402]  470.05 245.34 270 bottom
UNK7R30  0-5-S4  [R0402]  505.86 244.15 0 bottom
UNK7R31  0-5-S4  [R0402]  505.86 239.07 0 bottom
UNK7R32  0-5-S4  [R0402]  505.86 236.53 0 bottom
UNK7R33  NC/45.3-1-S4  [R0402]  471.2 245.34 90 bottom
UNK7R34  10K-1-S4  [R0402]  524.83 332.42 90 bottom
UNK7R35  10K-1-S4  [R0402]  522.29 332.42 90 bottom
UNK7R36  10K-1-S4  [R0402]  519.75 332.42 90 bottom
UNK7R37  10K-1-S4  [R0402]  517.21 332.42 90 bottom
UNK7R38  0-5-S4  [R0402]  522.42 342.58 180 bottom
UNK7R39  10K-1-S4  [R0402]  514.67 332.42 90 bottom
UNK7R40  10K-1-S4  [R0402]  512.13 332.42 90 bottom
UNK7R41  10K-1-S4  [R0402]  509.59 332.42 90 bottom
UNK7R42  0-5-S4  [R0402]  509.46 342.58 0 bottom
UNK7R43  12K-1-S4  [R0402]  421.23 265.74 0 bottom
UNK7R45  32.4-1-S4  [R0402]  472.6 259.35 270 bottom
UNK7R47  32.4-1-S4  [R0402]  472.6 266.61 270 bottom
UNK7R48  0-5-S4  [R0402]  383.96 256.59 90 bottom
UNK7R49  NC/0-5-S4  [R0402]  391.19 256.59 90 bottom
UNK7R50  0-5-S4  [R0402]  426.55 300.63 180 top
UNK7R51  NC/0-5-S4  [R0402]  394.8 289.46 270 bottom
UNK7R53  0-5-S4  [R0402]  407.84 292.59 90 bottom
UNK7R54  NC/0-5-S4  [R0402]  407.84 288.39 270 bottom
UNK7R55  0-5-S4  [R0402]  396.65 294.23 180 bottom
UNK7R57  NC/10K-1-S4  [R0402]  493.49 244.73 180 bottom
UNK7R58  NC/10K-1-S4  [R0402]  493.49 237.47 180 bottom
UNK7R59  NC/10K-1-S4  [R0402]  493.49 253.14 180 bottom
UNK7R60  NC/10K-1-S4  [R0402]  493.49 245.87 180 bottom
UNK7R61  0-5-S4  [R0402]  520.9 381.46 180 bottom
UNK7R62  0-5-S4  [R0402]  517.9 381.46 0 bottom
UNK7R63  0-5-S4  [R0402]  474.93 266.61 270 bottom
UNK7R64  0-5-S4  [R0402]  473.76 266.61 270 bottom
UNK7R65  0-5-S4  [R0402]  473.76 264.19 90 bottom
UNK7R66  0-5-S4  [R0402]  474.93 264.19 90 bottom
UNK7R67  0-5-S4  [R0402]  474.93 259.35 270 bottom
UNK7R68  0-5-S4  [R0402]  473.76 259.35 270 bottom
UNK7R69  0-5-S4  [R0402]  473.76 256.93 90 bottom
UNK7R70  0-5-S4  [R0402]  474.93 256.93 90 bottom
UNK7R71  2-5-D-2  [RC02W_27MM]  529.42 239.1 0 bottom
UNK7R72  2-5-D-2  [RC02W_27MM]  529.42 250.53 0 bottom
UNK7R73  2-5-D-2  [RC02W_27MM]  529.42 261.96 0 bottom
UNK7R74  0-5-S4  [R0402]  472.6 264.19 90 bottom
UNK7R75  0-5-S4  [R0402]  472.6 256.93 90 bottom
UNK7R76  0-5-S4  [R0402]  421.23 261.38 180 bottom
UNK7R77  0-5-S4  [R0402]  416.99 270.27 180 bottom
UNK7R78  0-5-S4  [R0402]  410.14 275.27 270 bottom
UNK7R79  0-5-S4  [R0402]  404.6 275.27 270 bottom
UNK7R81  0-5-S4  [R0402]  421.23 263.52 180 bottom
UNK7R82  0-5-S4  [R0402]  421.23 266.84 180 bottom
UNK7R83  0-5-S4  [R0402]  421.23 264.64 180 bottom
UNK7SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  415.98 247.27 210 top
UNK7SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  410.67 242.17 180 top
UNK7SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  404.8 241.21 180 top
UNK7ST3  SHORT  [DEFAULT_SHORT_SMALL]  295.17 471.8 0 top
UNK7ST4  SHORT  [DEFAULT_SHORT_SMALL]  298.39 471.8 0 top
UNK7ST5  SHORT  [DEFAULT_SHORT_SMALL]  301.6 471.8 0 top
UNK7ST8  SHORT  [DEFAULT_SHORT_SMALL]  304.82 471.8 0 top
UNK7ST11  SHORT  [DEFAULT_SHORT_SMALL]  279.07 471.8 0 top
UNK7ST12  SHORT  [DEFAULT_SHORT_SMALL]  282.29 471.8 0 top
UNK7ST13  SHORT  [DEFAULT_SHORT_SMALL]  285.51 471.8 0 top
UNK7ST14  SHORT  [DEFAULT_SHORT_SMALL]  288.73 471.8 0 top
UNK7ST15  SHORT  [DEFAULT_SHORT_SMALL]  291.95 471.8 0 top
UNK7ST16  SHORT  [DEFAULT_SHORT_SMALL]  79.48 471.8 0 top
UNK7ST17  SHORT  [DEFAULT_SHORT_SMALL]  82.7 471.8 0 top
UNK7ST18  SHORT  [DEFAULT_SHORT_SMALL]  85.92 471.8 0 top
UNK7ST19  SHORT  [DEFAULT_SHORT_SMALL]  89.14 471.8 0 top
UNK7SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  515.94 338.77 180 top
UNK7SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  519.4 377.65 180 top
UNK7U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  408.89 251.89 270 top
UNK7U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  406.58 247.88 270 top
UNK7U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  454.92 255.9 0 bottom
UNK7Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  394.22 262.03 45 top
UNK038RT-8730CN16Q-A100  REF-CODE-PCB  [PCB_CODE]  20.92 467.05 0 top
UNK980RT-8730CN-18K-  REF-CODE-CHIP  [CHIP_CODE]  18.41 467.16 0 top
UT1  TMP235A2DCKR-SC70  [SC70_5P]  295.31 71.57 0 bottom
VDD12_ATX  HDR-2X2-M  [CONN_2X2_2P54MM_PH]  33.25 375.93 270 top
Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  274.22 202.03 45 top

## Library data of the parts
ATX_VD0V9 ATX_VD1V8 ATX_VD33 = HDR-8X2-M: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
BD1-BD3 BD5 BD7 BD9 BD11-BD13 BD15-BD23 BD27-BD37 UNK1BD1-UNK1BD3 UNK1BD5 UNK1BD7 UNK1BD9 UNK1BD11-UNK1BD13 UNK1BD15-UNK1BD23 UNK1BD27-UNK1BD37 UNK2BD1-UNK2BD3 UNK2BD5 UNK2BD7 UNK2BD9 UNK2BD11-UNK2BD13 UNK2BD15-UNK2BD23 UNK2BD27-UNK2BD37 UNK3BD1-UNK3BD3 UNK3BD5 UNK3BD7 UNK3BD9 UNK3BD11-UNK3BD13 UNK3BD15-UNK3BD23 UNK3BD27-UNK3BD37 UNK4BD1-UNK4BD3 UNK4BD5 UNK4BD7 UNK4BD9 UNK4BD11-UNK4BD13 UNK4BD15-UNK4BD23 UNK4BD27-UNK4BD37 UNK5BD1-UNK5BD3 UNK5BD5 UNK5BD7 UNK5BD9 UNK5BD11-UNK5BD13 UNK5BD15-UNK5BD23 UNK5BD27-UNK5BD37 UNK6BD1-UNK6BD3 UNK6BD5 UNK6BD7 UNK6BD9 UNK6BD11-UNK6BD13 UNK6BD15-UNK6BD23 UNK6BD27-UNK6BD37 UNK7BD1-UNK7BD3 UNK7BD5 UNK7BD7 UNK7BD9 UNK7BD11-UNK7BD13 UNK7BD15-UNK7BD23 UNK7BD27-UNK7BD37 = BD120-1.5A-S4-MU: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
BD42-BD44 BD48 BD50-BD52 BD56-BD72 = BD120-3A-S8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
BDB74-BDB77 BDB80-BDB83 BDB86 BDB87 = BD100-3A-SA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C1 C4 C9 C11 C16 UNK1C1 UNK1C4 UNK1C9 UNK1C11 UNK1C16 UNK2C1 UNK2C4 UNK2C9 UNK2C11 UNK2C16 UNK3C1 UNK3C4 UNK3C9 UNK3C11 UNK3C16 UNK4C1 UNK4C4 UNK4C9 UNK4C11 UNK4C16 UNK5C1 UNK5C4 UNK5C9 UNK5C11 UNK5C16 UNK6C1 UNK6C4 UNK6C9 UNK6C11 UNK6C16 UNK7C1 UNK7C4 UNK7C9 UNK7C11 UNK7C16 = 1P-25-N-S2-WA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C2 C6 C7 C13 C14 UNK1C2 UNK1C6 UNK1C7 UNK1C13 UNK1C14 UNK2C2 UNK2C6 UNK2C7 UNK2C13 UNK2C14 UNK3C2 UNK3C6 UNK3C7 UNK3C13 UNK3C14 UNK4C2 UNK4C6 UNK4C7 UNK4C13 UNK4C14 UNK5C2 UNK5C6 UNK5C7 UNK5C13 UNK5C14 UNK6C2 UNK6C6 UNK6C7 UNK6C13 UNK6C14 UNK7C2 UNK7C6 UNK7C7 UNK7C13 UNK7C14 = 10P-50-N-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C3 C5 C10 C12 C19 UNK1C3 UNK1C5 UNK1C10 UNK1C12 UNK1C19 UNK2C3 UNK2C5 UNK2C10 UNK2C12 UNK2C19 UNK3C3 UNK3C5 UNK3C10 UNK3C12 UNK3C19 UNK4C3 UNK4C5 UNK4C10 UNK4C12 UNK4C19 UNK5C3 UNK5C5 UNK5C10 UNK5C12 UNK5C19 UNK6C3 UNK6C5 UNK6C10 UNK6C12 UNK6C19 UNK7C3 UNK7C5 UNK7C10 UNK7C12 UNK7C19 = 1.2P-50-N-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C8 C15 CB652 CB660 CB667 CB675 CB697 CB705 UNK1C8 UNK1C15 UNK2C8 UNK2C15 UNK3C8 UNK3C15 UNK4C8 UNK4C15 UNK5C8 UNK5C15 UNK6C8 UNK6C15 UNK7C8 UNK7C15 = CNC-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C17 C18 C20 C21 C44-C49 C52 C54 C56 C58 C59 C61 C64 C74 C75 C77-C79 C84 C85 C88 C91 C98 C100 C102 C105 C107 C112 C119 C124 C126 C128 C152 C153 UNK1C17 UNK1C18 UNK1C20 UNK1C21 UNK1C44-UNK1C49 UNK1C52 UNK1C54 UNK1C56 UNK1C58 UNK1C59 UNK1C61 UNK1C64 UNK1C74 UNK1C75 UNK1C77-UNK1C79 UNK1C84 UNK1C85 UNK1C88 UNK1C91 UNK1C98 UNK1C100 UNK1C102 UNK1C105 UNK1C107 UNK1C112 UNK1C119 UNK1C124 UNK1C126 UNK1C128 UNK1C152 UNK1C153 UNK2C17 UNK2C18 UNK2C20 UNK2C21 UNK2C44-UNK2C49 UNK2C52 UNK2C54 UNK2C56 UNK2C58 UNK2C59 UNK2C61 UNK2C64 UNK2C74 UNK2C75 UNK2C77-UNK2C79 UNK2C84 UNK2C85 UNK2C88 UNK2C91 UNK2C98 UNK2C100 UNK2C102 UNK2C105 UNK2C107 UNK2C112 UNK2C119 UNK2C124 UNK2C126 UNK2C128 UNK2C152 UNK2C153 UNK3C17 UNK3C18 UNK3C20 UNK3C21 UNK3C44-UNK3C49 UNK3C52 UNK3C54 UNK3C56 UNK3C58 UNK3C59 UNK3C61 UNK3C64 UNK3C74 UNK3C75 UNK3C77-UNK3C79 UNK3C84 UNK3C85 UNK3C88 UNK3C91 UNK3C98 UNK3C100 UNK3C102 UNK3C105 UNK3C107 UNK3C112 UNK3C119 UNK3C124 UNK3C126 UNK3C128 UNK3C152 UNK3C153 UNK4C17 UNK4C18 UNK4C20 UNK4C21 UNK4C44-UNK4C49 UNK4C52 UNK4C54 UNK4C56 UNK4C58 UNK4C59 UNK4C61 UNK4C64 UNK4C74 UNK4C75 UNK4C77-UNK4C79 UNK4C84 UNK4C85 UNK4C88 UNK4C91 UNK4C98 UNK4C100 UNK4C102 UNK4C105 UNK4C107 UNK4C112 UNK4C119 UNK4C124 UNK4C126 UNK4C128 UNK4C152 UNK4C153 UNK5C17 UNK5C18 UNK5C20 UNK5C21 UNK5C44-UNK5C49 UNK5C52 UNK5C54 UNK5C56 UNK5C58 UNK5C59 UNK5C61 UNK5C64 UNK5C74 UNK5C75 UNK5C77-UNK5C79 UNK5C84 UNK5C85 UNK5C88 UNK5C91 UNK5C98 UNK5C100 UNK5C102 UNK5C105 UNK5C107 UNK5C112 UNK5C119 UNK5C124 UNK5C126 UNK5C128 UNK5C152 UNK5C153 UNK6C17 UNK6C18 UNK6C20 UNK6C21 UNK6C44-UNK6C49 UNK6C52 UNK6C54 UNK6C56 UNK6C58 UNK6C59 UNK6C61 UNK6C64 UNK6C74 UNK6C75 UNK6C77-UNK6C79 UNK6C84 UNK6C85 UNK6C88 UNK6C91 UNK6C98 UNK6C100 UNK6C102 UNK6C105 UNK6C107 UNK6C112 UNK6C119 UNK6C124 UNK6C126 UNK6C128 UNK6C152 UNK6C153 UNK7C17 UNK7C18 UNK7C20 UNK7C21 UNK7C44-UNK7C49 UNK7C52 UNK7C54 UNK7C56 UNK7C58 UNK7C59 UNK7C61 UNK7C64 UNK7C74 UNK7C75 UNK7C77-UNK7C79 UNK7C84 UNK7C85 UNK7C88 UNK7C91 UNK7C98 UNK7C100 UNK7C102 UNK7C105 UNK7C107 UNK7C112 UNK7C119 UNK7C124 UNK7C126 UNK7C128 UNK7C152 UNK7C153 = 0.1U-35-X-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C22 CB662 CB677 CB707 UNK1C22 UNK2C22 UNK3C22 UNK4C22 UNK5C22 UNK6C22 UNK7C22 = 0.1U-16-X-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C23 C25 C38 C40 UNK1C23 UNK1C25 UNK1C38 UNK1C40 UNK2C23 UNK2C25 UNK2C38 UNK2C40 UNK3C23 UNK3C25 UNK3C38 UNK3C40 UNK4C23 UNK4C25 UNK4C38 UNK4C40 UNK5C23 UNK5C25 UNK5C38 UNK5C40 UNK6C23 UNK6C25 UNK6C38 UNK6C40 UNK7C23 UNK7C25 UNK7C38 UNK7C40 = 10P-50-N-S4-MU-1: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C24 C55 C108 C130 C137 UNK1C24 UNK1C55 UNK1C108 UNK1C130 UNK1C137 UNK2C24 UNK2C55 UNK2C108 UNK2C130 UNK2C137 UNK3C24 UNK3C55 UNK3C108 UNK3C130 UNK3C137 UNK4C24 UNK4C55 UNK4C108 UNK4C130 UNK4C137 UNK5C24 UNK5C55 UNK5C108 UNK5C130 UNK5C137 UNK6C24 UNK6C55 UNK6C108 UNK6C130 UNK6C137 UNK7C24 UNK7C55 UNK7C108 UNK7C130 UNK7C137 = 0.1U-25-X-S4-TY: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C39 C41 UNK1C39 UNK1C41 UNK2C39 UNK2C41 UNK3C39 UNK3C41 UNK4C39 UNK4C41 UNK5C39 UNK5C41 UNK6C39 UNK6C41 UNK7C39 UNK7C41 = 33P-50-N-S4-WA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C53 C57 C60 C67 C73 C76 C83 C89 C90 C96 C97 C99 C101 C106 C109-C111 C118 C122 C123 C125 C127 C129 C136 C138 UNK1C53 UNK1C57 UNK1C60 UNK1C67 UNK1C73 UNK1C76 UNK1C83 UNK1C89 UNK1C90 UNK1C96 UNK1C97 UNK1C99 UNK1C101 UNK1C106 UNK1C109-UNK1C111 UNK1C118 UNK1C122 UNK1C123 UNK1C125 UNK1C127 UNK1C129 UNK1C136 UNK1C138 UNK2C53 UNK2C57 UNK2C60 UNK2C67 UNK2C73 UNK2C76 UNK2C83 UNK2C89 UNK2C90 UNK2C96 UNK2C97 UNK2C99 UNK2C101 UNK2C106 UNK2C109-UNK2C111 UNK2C118 UNK2C122 UNK2C123 UNK2C125 UNK2C127 UNK2C129 UNK2C136 UNK2C138 UNK3C53 UNK3C57 UNK3C60 UNK3C67 UNK3C73 UNK3C76 UNK3C83 UNK3C89 UNK3C90 UNK3C96 UNK3C97 UNK3C99 UNK3C101 UNK3C106 UNK3C109-UNK3C111 UNK3C118 UNK3C122 UNK3C123 UNK3C125 UNK3C127 UNK3C129 UNK3C136 UNK3C138 UNK4C53 UNK4C57 UNK4C60 UNK4C67 UNK4C73 UNK4C76 UNK4C83 UNK4C89 UNK4C90 UNK4C96 UNK4C97 UNK4C99 UNK4C101 UNK4C106 UNK4C109-UNK4C111 UNK4C118 UNK4C122 UNK4C123 UNK4C125 UNK4C127 UNK4C129 UNK4C136 UNK4C138 UNK5C53 UNK5C57 UNK5C60 UNK5C67 UNK5C73 UNK5C76 UNK5C83 UNK5C89 UNK5C90 UNK5C96 UNK5C97 UNK5C99 UNK5C101 UNK5C106 UNK5C109-UNK5C111 UNK5C118 UNK5C122 UNK5C123 UNK5C125 UNK5C127 UNK5C129 UNK5C136 UNK5C138 UNK6C53 UNK6C57 UNK6C60 UNK6C67 UNK6C73 UNK6C76 UNK6C83 UNK6C89 UNK6C90 UNK6C96 UNK6C97 UNK6C99 UNK6C101 UNK6C106 UNK6C109-UNK6C111 UNK6C118 UNK6C122 UNK6C123 UNK6C125 UNK6C127 UNK6C129 UNK6C136 UNK6C138 UNK7C53 UNK7C57 UNK7C60 UNK7C67 UNK7C73 UNK7C76 UNK7C83 UNK7C89 UNK7C90 UNK7C96 UNK7C97 UNK7C99 UNK7C101 UNK7C106 UNK7C109-UNK7C111 UNK7C118 UNK7C122 UNK7C123 UNK7C125 UNK7C127 UNK7C129 UNK7C136 UNK7C138 = 10U-10-X-S4-SS: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C62 C63 C92 C93 C116 C117 C139 C142 UNK1C62 UNK1C63 UNK1C92 UNK1C93 UNK1C116 UNK1C117 UNK1C139 UNK1C142 UNK2C62 UNK2C63 UNK2C92 UNK2C93 UNK2C116 UNK2C117 UNK2C139 UNK2C142 UNK3C62 UNK3C63 UNK3C92 UNK3C93 UNK3C116 UNK3C117 UNK3C139 UNK3C142 UNK4C62 UNK4C63 UNK4C92 UNK4C93 UNK4C116 UNK4C117 UNK4C139 UNK4C142 UNK5C62 UNK5C63 UNK5C92 UNK5C93 UNK5C116 UNK5C117 UNK5C139 UNK5C142 UNK6C62 UNK6C63 UNK6C92 UNK6C93 UNK6C116 UNK6C117 UNK6C139 UNK6C142 UNK7C62 UNK7C63 UNK7C92 UNK7C93 UNK7C116 UNK7C117 UNK7C139 UNK7C142 = 22U-25-X-S8-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C65 C94 C120 C140 UNK1C65 UNK1C94 UNK1C120 UNK1C140 UNK2C65 UNK2C94 UNK2C120 UNK2C140 UNK3C65 UNK3C94 UNK3C120 UNK3C140 UNK4C65 UNK4C94 UNK4C120 UNK4C140 UNK5C65 UNK5C94 UNK5C120 UNK5C140 UNK6C65 UNK6C94 UNK6C120 UNK6C140 UNK7C65 UNK7C94 UNK7C120 UNK7C140 = 47U-16-T-SC: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
C66 C95 C121 C141 UNK1C66 UNK1C95 UNK1C121 UNK1C141 UNK2C66 UNK2C95 UNK2C121 UNK2C141 UNK3C66 UNK3C95 UNK3C121 UNK3C141 UNK4C66 UNK4C95 UNK4C121 UNK4C141 UNK5C66 UNK5C95 UNK5C121 UNK5C141 UNK6C66 UNK6C95 UNK6C121 UNK6C141 UNK7C66 UNK7C95 UNK7C121 UNK7C141 = 10U-16-T-SA: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
C68-C72 C131-C135 CT17-CT21 UNK1C68-UNK1C72 UNK1C131-UNK1C135 UNK2C68-UNK2C72 UNK2C131-UNK2C135 UNK3C68-UNK3C72 UNK3C131-UNK3C135 UNK4C68-UNK4C72 UNK4C131-UNK4C135 UNK5C68-UNK5C72 UNK5C131-UNK5C135 UNK6C68-UNK6C72 UNK6C131-UNK6C135 UNK7C68-UNK7C72 UNK7C131-UNK7C135 = 22U-10-T-SA: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
C113 UNK1C113 UNK2C113 UNK3C113 UNK4C113 UNK5C113 UNK6C113 UNK7C113 = 10U-25-X-S6-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C143-C150 UNK1C143-UNK1C150 UNK2C143-UNK2C150 UNK3C143-UNK3C150 UNK4C143-UNK4C150 UNK5C143-UNK5C150 UNK6C143-UNK6C150 UNK7C143-UNK7C150 = 10P-50-N-S4-WA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C524 C525 C528 C539 C548-C555 = 0.1U-50-X7R-S4-YA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C540-C547 = 0.1U-50-X-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB631 CB632 CB635 CB643 CB654 CB661 CB664 CB669 CB676 CB679 CB699 CB706 CB709 = 220U-10-T-SD: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
CB633 CB636 CB642 = 10U-10-T-SA-AVX: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
CB634 CB637 CB638 CB641 CB647 CB650 CB653 CB657 CB665 CB668 CB672 CB695 CB698 CB702 = 0.1U-10-X-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB639 CB648 = 10U-35-T-SC: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
CB640 CB649 = 47U-25-T-SD-AVX: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
CB651 CB666 CB696 = 3300P-50-X-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB655 CB663 CB670 CB678 CB700 CB708 = 10U-10-X-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB656 CB671 CB701 = 100P-50-N-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB658 CB673 CB703 = 0.1U-16-X-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB659 CB674 CB704 = 100P-50-N-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CT1 CT15 = 680P-50-X-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CT2 CT4 CT6 = 10U-25-X7R-SA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CT3 CT5 CT7 = 4.7U-25-X7R-S8-TY: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CT8 CT10 CT12 = 10U-50-X-SB-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CT9 CT11 CT13 = 4.7U-50-X-S8-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CT14 = 0.1U-16-X-S4-MU-1: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CT16 = 0.1U-25-X-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
D1-D3 UNK1D1-UNK1D3 UNK2D1-UNK2D3 UNK3D1-UNK3D3 UNK4D1-UNK4D3 UNK5D1-UNK5D3 UNK6D1-UNK6D3 UNK7D1-UNK7D3 = RCLAMP3321P-SLP1006P2: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
FD1-FD16 = TP01: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
FUSEB1-FUSEB3 = MF-R185-40A-D: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
H1-H4 = M3-HOLE: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
HOLE_CABLE3 HOLE_CABLE4 = DEBUGHOLE-15X15MM: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
J1-J3 UNK1J1-UNK1J3 UNK2J1-UNK2J3 UNK3J1-UNK3J3 UNK4J1-UNK4J3 UNK5J1-UNK5J3 UNK6J1-UNK6J3 UNK7J1-UNK7J3 = HDR-4X1-F-1: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
J4 UNK1J4 UNK2J4 UNK3J4 UNK4J4 UNK5J4 UNK6J4 UNK7J4 = HDR-8X1-M: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
J5 UNK1J5 UNK2J5 UNK3J5 UNK4J5 UNK5J5 UNK6J5 UNK7J5 = HDR-1X1-M: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
J6-J9 UNK1J6-UNK1J9 UNK2J6-UNK2J9 UNK3J6-UNK3J9 UNK4J6-UNK4J9 UNK5J6-UNK5J9 UNK6J6-UNK6J9 UNK7J6-UNK7J9 = HDR-2X1-M: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
JB1 = ATX-10X2-MR: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
K1-K4 K6 K8-K16 K18-K23 K25 K26 K28-K39 KT1 UNK1K1-UNK1K4 UNK1K6 UNK1K8-UNK1K16 UNK1K18-UNK1K23 UNK1K25 UNK1K26 UNK1K28-UNK1K32 UNK1K34-UNK1K36 UNK1K39 UNK2K1-UNK2K4 UNK2K6 UNK2K8-UNK2K16 UNK2K18-UNK2K23 UNK2K25 UNK2K26 UNK2K28-UNK2K39 UNK3K1-UNK3K4 UNK3K6 UNK3K8-UNK3K16 UNK3K18-UNK3K23 UNK3K25 UNK3K26 UNK3K28-UNK3K32 UNK3K34-UNK3K36 UNK3K39 UNK4K1-UNK4K4 UNK4K6 UNK4K8-UNK4K16 UNK4K18-UNK4K23 UNK4K25 UNK4K26 UNK4K28-UNK4K39 UNK5K1-UNK5K4 UNK5K6 UNK5K8-UNK5K16 UNK5K18-UNK5K23 UNK5K25 UNK5K26 UNK5K28-UNK5K32 UNK5K34-UNK5K36 UNK5K39 UNK6K1-UNK6K4 UNK6K6 UNK6K8-UNK6K16 UNK6K18-UNK6K23 UNK6K25 UNK6K26 UNK6K28-UNK6K39 UNK7K1-UNK7K4 UNK7K6 UNK7K8-UNK7K16 UNK7K18-UNK7K23 UNK7K25 UNK7K26 UNK7K28-UNK7K32 UNK7K34-UNK7K36 UNK7K39 = CU/UA2-12NJ-A-V2: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
K5 K7 UNK1K5 UNK1K7 UNK2K5 UNK2K7 UNK3K5 UNK3K7 UNK4K5 UNK4K7 UNK5K5 UNK5K7 UNK6K5 UNK6K7 UNK7K5 UNK7K7 = CU/RF303-12-A-V2_EX: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
L1 L3 L4 UNK1L1 UNK1L3 UNK1L4 UNK2L1 UNK2L3 UNK2L4 UNK3L1 UNK3L3 UNK3L4 UNK4L1 UNK4L3 UNK4L4 UNK5L1 UNK5L3 UNK5L4 UNK6L1 UNK6L3 UNK6L4 UNK7L1 UNK7L3 UNK7L4 = L2.2U-1.15A-S2.0X1.6-TDK: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
LB1 LB2 LB4 = L10U-3.6A-S10X10: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
LDB1-LDB6 = LDG-2-S8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
LDB19 LDB20 LDB22 = LDR-2-S8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
LOGO1 = LOGO_RT_Realtek
LOGO2 = LOGO_KT_KSMT
LRB1 LRB2 = 330-1-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
LRB3 = 1K-1-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
LRB4 = 2K-1-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
LRB5 LRB6 = 1.5K-1-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
P1 P2 P4-P6 = HIGH-SIDE: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
P7 P8 P10 P11 = LOW-SIDE: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
P9 = SYS: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
PJ07604-1982 QFN100-10X10 = REF-CODE-SOCKET
PT1 = PT-ULTRAFLEX-TESTER-75X35: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
R1-R9 UNK1R1-UNK1R9 UNK2R1-UNK2R9 UNK3R1-UNK3R9 UNK4R1-UNK4R9 UNK5R1-UNK5R9 UNK6R1-UNK6R9 UNK7R1-UNK7R9 = 0-5-S2: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R10 R11 R13 R15-R17 R19-R21 R24 R27 R28 R30-R32 R38 R42 R48-R51 R53-R55 R61-R70 R74-R79 R81-R83 RB8 RB597 RB604 RB618 UNK1R10 UNK1R11 UNK1R13 UNK1R15-UNK1R17 UNK1R19-UNK1R21 UNK1R24 UNK1R27 UNK1R28 UNK1R30-UNK1R32 UNK1R38 UNK1R42 UNK1R48-UNK1R51 UNK1R53-UNK1R55 UNK1R61-UNK1R70 UNK1R74-UNK1R79 UNK1R81-UNK1R83 UNK2R10 UNK2R11 UNK2R13 UNK2R15-UNK2R17 UNK2R19-UNK2R21 UNK2R24 UNK2R27 UNK2R28 UNK2R30-UNK2R32 UNK2R38 UNK2R42 UNK2R48-UNK2R51 UNK2R53-UNK2R55 UNK2R61-UNK2R70 UNK2R74-UNK2R79 UNK2R81-UNK2R83 UNK3R10 UNK3R11 UNK3R13 UNK3R15-UNK3R17 UNK3R19-UNK3R21 UNK3R24 UNK3R27 UNK3R28 UNK3R30-UNK3R32 UNK3R38 UNK3R42 UNK3R48-UNK3R51 UNK3R53-UNK3R55 UNK3R61-UNK3R70 UNK3R74-UNK3R79 UNK3R81-UNK3R83 UNK4R10 UNK4R11 UNK4R13 UNK4R15-UNK4R17 UNK4R19-UNK4R21 UNK4R24 UNK4R27 UNK4R28 UNK4R30-UNK4R32 UNK4R38 UNK4R42 UNK4R48-UNK4R51 UNK4R53-UNK4R55 UNK4R61-UNK4R70 UNK4R74-UNK4R79 UNK4R81-UNK4R83 UNK5R10 UNK5R11 UNK5R13 UNK5R15-UNK5R17 UNK5R19-UNK5R21 UNK5R24 UNK5R27 UNK5R28 UNK5R30-UNK5R32 UNK5R38 UNK5R42 UNK5R48-UNK5R51 UNK5R53-UNK5R55 UNK5R61-UNK5R70 UNK5R74-UNK5R79 UNK5R81-UNK5R83 UNK6R10 UNK6R11 UNK6R13 UNK6R15-UNK6R17 UNK6R19-UNK6R21 UNK6R24 UNK6R27 UNK6R28 UNK6R30-UNK6R32 UNK6R38 UNK6R42 UNK6R48-UNK6R51 UNK6R53-UNK6R55 UNK6R61-UNK6R70 UNK6R74-UNK6R79 UNK6R81-UNK6R83 UNK7R10 UNK7R11 UNK7R13 UNK7R15-UNK7R17 UNK7R19-UNK7R21 UNK7R24 UNK7R27 UNK7R28 UNK7R30-UNK7R32 UNK7R38 UNK7R42 UNK7R48-UNK7R51 UNK7R53-UNK7R55 UNK7R61-UNK7R70 UNK7R74-UNK7R79 UNK7R81-UNK7R83 = 0-5-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R12 R14 R18 R34-R37 R39-R41 R57-R60 RB205 UNK1R12 UNK1R14 UNK1R18 UNK1R34-UNK1R37 UNK1R39-UNK1R41 UNK1R57-UNK1R60 UNK2R12 UNK2R14 UNK2R18 UNK2R34-UNK2R37 UNK2R39-UNK2R41 UNK2R57-UNK2R60 UNK3R12 UNK3R14 UNK3R18 UNK3R34-UNK3R37 UNK3R39-UNK3R41 UNK3R57-UNK3R60 UNK4R12 UNK4R14 UNK4R18 UNK4R34-UNK4R37 UNK4R39-UNK4R41 UNK4R57-UNK4R60 UNK5R12 UNK5R14 UNK5R18 UNK5R34-UNK5R37 UNK5R39-UNK5R41 UNK5R57-UNK5R60 UNK6R12 UNK6R14 UNK6R18 UNK6R34-UNK6R37 UNK6R39-UNK6R41 UNK6R57-UNK6R60 UNK7R12 UNK7R14 UNK7R18 UNK7R34-UNK7R37 UNK7R39-UNK7R41 UNK7R57-UNK7R60 = 10K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R22 R23 R25 R26 R29 R33 UNK1R22 UNK1R23 UNK1R25 UNK1R26 UNK1R29 UNK1R33 UNK2R22 UNK2R23 UNK2R25 UNK2R26 UNK2R29 UNK2R33 UNK3R22 UNK3R23 UNK3R25 UNK3R26 UNK3R29 UNK3R33 UNK4R22 UNK4R23 UNK4R25 UNK4R26 UNK4R29 UNK4R33 UNK5R22 UNK5R23 UNK5R25 UNK5R26 UNK5R29 UNK5R33 UNK6R22 UNK6R23 UNK6R25 UNK6R26 UNK6R29 UNK6R33 UNK7R22 UNK7R23 UNK7R25 UNK7R26 UNK7R29 UNK7R33 = 45.3-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R43 UNK1R43 UNK2R43 UNK3R43 UNK4R43 UNK5R43 UNK6R43 UNK7R43 = 12K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R45 R47 UNK1R45 UNK1R47 UNK2R45 UNK2R47 UNK3R45 UNK3R47 UNK4R45 UNK4R47 UNK5R45 UNK5R47 UNK6R45 UNK6R47 UNK7R45 UNK7R47 = 32.4-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
R71-R73 UNK1R71-UNK1R73 UNK2R71-UNK2R73 UNK3R71-UNK3R73 UNK4R71-UNK4R73 UNK5R71-UNK5R73 UNK6R71-UNK6R73 UNK7R71-UNK7R73 = 2-5-D-2: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
R327 R338 R342 R346-R366 = 4.7K-0.1-S4-YA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RB595 = 13K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RB596 RB603 RB617 = 100K-0.1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RB598 RB605 RB619 = 10-1-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RB599 RB606 RB620 = 200K-10-D-Regulate: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RB600 RB607 RB621 = 20K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RB601 RB608 RB622 = 200-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RB623 RB627 = 7.15K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RB624 RB628 = 9.1K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RT1 = 1K-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
RTL8730EAH UNK980RT-8730CN-18K- = REF-CODE-CHIP
S0_1V3 S0_GND1-S0_GND4 S0_VD33_ALL1 S0_VDD09 S0_VDD18_A S0_VDD18_D S1_1V3 S1_GND1-S1_GND4 S1_VD33_ALL1 S1_VDD09 S1_VDD18_A S1_VDD18_D S2_1V3 S2_GND1-S2_GND4 S2_VD33_ALL1 S2_VDD09 S2_VDD18_A S2_VDD18_D S3_1V3 S3_GND1-S3_GND4 S3_VD33_ALL1 S3_VDD09 S3_VDD18_A S3_VDD18_D S4_1V3 S4_GND1-S4_GND4 S4_VD33_ALL1 S4_VDD09 S4_VDD18_A S4_VDD18_D S5_1V3 S5_GND1-S5_GND4 S5_VD33_ALL1 S5_VDD09 S5_VDD18_A S5_VDD18_D S6_1V3 S6_GND1-S6_GND4 S6_VD33_ALL1 S6_VDD09 S6_VDD18_A S6_VDD18_D S7_1V3 S7_GND1-S7_GND4 S7_VD33_ALL1 S7_VDD09 S7_VDD18_A S7_VDD18_D TEMP_MEASUREMENT TP_VN15 TP_VP5A TP_VP5B TP_VP12 TP_VP15 TP_VP24 = TP03-D: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
SCREW3 = CHROMA3680-OUTLINE-RF-TYPE2: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
SITE0-SITE7 = RTL8730A-QFN100: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
SMP1-SMP3 UNK1SMP1-UNK1SMP3 UNK2SMP1-UNK2SMP3 UNK3SMP1-UNK3SMP3 UNK4SMP1-UNK4SMP3 UNK5SMP1-UNK5SMP3 UNK6SMP1-UNK6SMP3 UNK7SMP1-UNK7SMP3 = MINI-SMP-18S107-40ML5-V2: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
ST1-ST5 ST8 ST11-ST19 UNK1ST3-UNK1ST5 UNK1ST8 UNK1ST11-UNK1ST19 UNK2ST3-UNK2ST5 UNK2ST8 UNK2ST11-UNK2ST19 UNK3ST3-UNK3ST5 UNK3ST8 UNK3ST11-UNK3ST19 UNK4ST3-UNK4ST5 UNK4ST8 UNK4ST11-UNK4ST19 UNK5ST3-UNK5ST5 UNK5ST8 UNK5ST11-UNK5ST19 UNK6ST3-UNK6ST5 UNK6ST8 UNK6ST11-UNK6ST19 UNK7ST3-UNK7ST5 UNK7ST8 UNK7ST11-UNK7ST19 = SHORT: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
SW1-SW4 SW7 UNK4SW1-UNK4SW4 UNK4SW7 = SW-SLIDE-8-D2.54-ECE: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
SW5 UNK1SW5 UNK2SW5 UNK3SW5 UNK4SW5 UNK5SW5 UNK6SW5 UNK7SW5 = SW-SLIDE-8-D2.54-TRI-ECE: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
SW6 UNK1SW6 UNK2SW6 UNK3SW6 UNK4SW6 UNK5SW6 UNK6SW6 UNK7SW6 = SW-SLIDE-4-D2.54-TRI-ECE: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
SWB1 = SW-SLIDE-1-D4.7: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U1 U2 UNK1U1 UNK1U2 UNK2U1 UNK2U2 UNK3U1 UNK3U2 UNK4U1 UNK4U2 UNK5U1 UNK5U2 UNK6U1 UNK6U2 UNK7U1 UNK7U2 = RFASWA358ATF0G: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
U3 UNK1U3 UNK2U3 UNK3U3 UNK4U3 UNK5U3 UNK6U3 UNK7U3 = MX25R6435FM2IL0-SOP8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
U5-U16 = MAX4896ETP+-TQFN-EP-20: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
UB5 = 25LC256-SOIC8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
UB70 UB71 UB73 = RT8293A-SOP8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
UNK1Y1 UNK2Y1 UNK3Y1 UNK4Y1 UNK5Y1 UNK6Y1 UNK7Y1 Y1 = XTAL40M-S2016-TAI-12P: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
UNK038RT-8730CN16Q-A100 = REF-CODE-PCB
UT1 = TMP235_0: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
VDD12_ATX = HDR-2X2-M: Tolerance: TOL; User Part Number: PNXXXXXXXXXX

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
C0201
  rect 0.305x0.356 smd: 1(-0.3,0) 2(0.3,0)
C0402
  custom 0.15x0.15 smd: 1(-0.5,0) 2(0.5,0)
C0603
  rect 0.889x0.889 smd: 1(-0.85,0) 2(0.85,0)
C0805
  rect 1.118x1.372 smd: 1(-0.95,0) 2(0.95,0)
C1206
  rect 1.321x1.829 smd: 1(-1.25,0) 2(1.25,0)
C1210
  rect 1.27x2.794 smd: 1(-1.524,0) 2(1.524,0)
CHIP_CODE
  round 0.051 smd: 1(0,0)
CODE_A
  rect 1.524x1.524 smd: 1(-1.651,0) 2(1.651,0)
CODE_C
  rect 2.286x2.54 smd: 1(-2.54,0) 2(2.54,0)
CODE_D
  rect 2.54x3.302 smd: 1(-3.556,0) 2(3.556,0)
CONN_2X2_2P54MM_PH
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(0,-2.54) 3(-2.54,0) 4(-2.54,-2.54)
CONN_4X1_2P54MM_FL10P5MM
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(-2.54,0) 3(-5.08,0) 4(-7.62,0)
CONN_8X2_2P54MM_PH
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(0,-2.54) 3(-2.54,0) 4(-2.54,-2.54) 5(-5.08,0) 6(-5.08,-2.54) 7(-7.62,0) 8(-7.62,-2.54) 9(-10.16,0) 10(-10.16,-2.54) 11(-12.7,0) 12(-12.7,-2.54) 13(-15.24,0) 14(-15.24,-2.54) 15(-17.78,0) 16(-17.78,-2.54)
CONN_PWR10X2_4P2MM_ML
  rect 3.683x3.683 hole 1.803: 1(18.9,-2.75)
  round 3.683 hole 1.803: 2(14.7,-2.75) 3(10.5,-2.75) 4(6.3,-2.75) 5(2.1,-2.75) 6(-2.1,-2.75) 7(-6.3,-2.75) 8(-10.5,-2.75) 9(-14.7,-2.75) 10(-18.9,-2.75) 11(18.9,2.75) 12(14.7,2.75) 13(10.5,2.75) 14(6.3,2.75) 15(2.1,2.75) 16(-2.1,2.75) 17(-6.3,2.75) 18(-10.5,2.75) 19(-14.7,2.75) 20(-18.9,2.75)
CONN_SMP_18S107
  custom 1.15x1.15 hole 3.5 unplated: (0,0)
  rect 0.6x0.89 smd: 1(0,-2.386)
  round 0.61 hole 0.305: G2(-1.3,-1.95) G3(1.3,-1.95) G4(-1.95,-1.3) G5(1.95,-1.3) G6(-1.95,1.3) G7(1.95,1.3) G8(-1.3,1.95) G9(1.3,1.95)
DEFAULT_SHORT_SMALL
  custom 0.07x0.07 smd: 1(-0.5,0) 2(0.5,0)
DIODE_1X0P6MM
  rect 0.559x0.61 smd: 1(0.425,0) 2(-0.425,0)
FB0402
  rect 0.584x0.508 smd: 1(-0.47,0) 2(0.47,0)
FB0805
  rect 1.118x1.372 smd: 1(-0.965,0) 2(0.965,0)
FB1206
  rect 1.016x1.778 smd: 1(-1.397,0) 2(1.397,0)
FD_040_V2
  round 1.016 smd: 1(0,0)
FUSE_12X9P2MM
  round 1.524 hole 1.016: 1(-2.9,0) 2(2.9,0)
IND_GSSR2104
  rect 3.048x4.064 smd: 1(-5,0) 2(5,0)
IND_VL252012E
  rect 0.864x2.032 smd: 1(-0.825,0) 2(0.825,0)
JP_1P_RD070_040
  round 1.778 hole 1.016: 1(0,0)
JP_2P_100
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(0,2.54)
JP_8P_100
  round 1.524 hole 1.016: 1(0,0) 2(0,2.54) 3(0,5.08) 4(0,7.62) 5(0,10.16) 6(0,12.7) 7(0,15.24) 8(0,17.78)
LED_0805
  rect 1.118x1.372 smd: 1(0.95,0) 2(-0.95,0)
LOGO_KT_KSMT
  round 0.051 smd: 1(-0.711,-0.711)
LOGO_RT_REALTEK
  round 0.051 smd: 1(-0.711,-0.711)
M3_NPTH169
  round 0.508 hole 4.293 unplated: (0,0)
PCB_CODE
  round 0.051 smd: 1(0,0)
PG_3680_DPS64_HDAV_H_P1
  rect 0.864x0.864 hole 0.356: A1(-193.5,189.5) A5(-193.5,197.5) A9(-193.5,205.5) B4(-191.5,195.5) B8(-191.5,203.5) B12(-191.5,211.5) C1(-189.5,189.5) C5(-189.5,197.5) C9(-189.5,205.5) D4(-187.5,195.5) D8(-187.5,203.5) D12(-187.5,211.5) E1(-185.5,189.5) E5(-185.5,197.5) E9(-185.5,205.5) F4(-183.5,195.5) F8(-183.5,203.5) F12(-183.5,211.5) G1(-181.5,189.5) G5(-181.5,197.5) G9(-181.5,205.5) H4(-179.5,195.5) H8(-179.5,203.5) H12(-179.5,211.5) I1(-177.5,189.5) I5(-177.5,197.5) I9(-177.5,205.5) J4(-175.5,195.5) J8(-175.5,203.5) J12(-175.5,211.5) K1(-173.5,189.5) K5(-173.5,197.5) K9(-173.5,205.5) K11(-173.5,209.5) L2(-171.5,191.5) L4(-171.5,195.5) L6(-171.5,199.5) L8(-171.5,203.5) L10(-171.5,207.5) L12(-171.5,211.5) M1(-169.5,189.5) M3(-169.5,193.5) M5(-169.5,197.5) M7(-169.5,201.5) M9(-169.5,205.5) M11(-169.5,209.5) N1(-167.5,189.5) N3(-167.5,193.5) N5(-167.5,197.5) N7(-167.5,201.5) N9(-167.5,205.5) N11(-167.5,209.5) O2(-165.5,191.5) O4(-165.5,195.5) O6(-165.5,199.5) O8(-165.5,203.5) O10(-165.5,207.5) O12(-165.5,211.5) P1(-163.5,189.5) P3(-163.5,193.5) P5(-163.5,197.5) P7(-163.5,201.5) P9(-163.5,205.5) P11(-163.5,209.5) Q2(-161.5,191.5) Q4(-161.5,195.5) Q6(-161.5,199.5) Q8(-161.5,203.5) Q10(-161.5,207.5) Q12(-161.5,211.5) R1(-159.5,189.5) R3(-159.5,193.5) R5(-159.5,197.5) R7(-159.5,201.5) R9(-159.5,205.5) R11(-159.5,209.5) S2(-157.5,191.5) S4(-157.5,195.5) S6(-157.5,199.5) S8(-157.5,203.5) S10(-157.5,207.5) S12(-157.5,211.5) T1(-155.5,189.5) T3(-155.5,193.5) T5(-155.5,197.5) T7(-155.5,201.5) T9(-155.5,205.5) T11(-155.5,209.5) U2(-153.5,191.5) U4(-153.5,195.5) U6(-153.5,199.5) U8(-153.5,203.5) U10(-153.5,207.5) U12(-153.5,211.5) V1(-151.5,189.5) V3(-151.5,193.5) V5(-151.5,197.5) V7(-151.5,201.5) V9(-151.5,205.5) V11(-151.5,209.5) W2(-149.5,191.5) W4(-149.5,195.5) W6(-149.5,199.5) W8(-149.5,203.5) W10(-149.5,207.5) W12(-149.5,211.5) X1(-147.5,189.5) X3(-147.5,193.5) X5(-147.5,197.5) X7(-147.5,201.5) X9(-147.5,205.5) X11(-147.5,209.5) Y2(-145.5,191.5) Y4(-145.5,195.5) Y6(-145.5,199.5) Y8(-145.5,203.5) Y10(-145.5,207.5) Y12(-145.5,211.5) Z1(-143.5,189.5) Z3(-143.5,193.5) Z5(-143.5,197.5) Z7(-143.5,201.5) Z9(-143.5,205.5) Z11(-143.5,209.5)
  round 0.864 hole 0.356: A2(-193.5,191.5) A3(-193.5,193.5) A4(-193.5,195.5) A6(-193.5,199.5) A7(-193.5,201.5) A8(-193.5,203.5) A10(-193.5,207.5) A11(-193.5,209.5) A12(-193.5,211.5) B1(-191.5,189.5) B2(-191.5,191.5) B3(-191.5,193.5) B5(-191.5,197.5) B6(-191.5,199.5) B7(-191.5,201.5) B9(-191.5,205.5) B10(-191.5,207.5) B11(-191.5,209.5) C2(-189.5,191.5) C3(-189.5,193.5) C4(-189.5,195.5) C6(-189.5,199.5) C7(-189.5,201.5) C8(-189.5,203.5) C10(-189.5,207.5) C11(-189.5,209.5) C12(-189.5,211.5) D1(-187.5,189.5) D2(-187.5,191.5) D3(-187.5,193.5) D5(-187.5,197.5) D6(-187.5,199.5) D7(-187.5,201.5) D9(-187.5,205.5) D10(-187.5,207.5) D11(-187.5,209.5) E2(-185.5,191.5) E3(-185.5,193.5) E4(-185.5,195.5) E6(-185.5,199.5) E7(-185.5,201.5) E8(-185.5,203.5) E10(-185.5,207.5) E11(-185.5,209.5) E12(-185.5,211.5) F1(-183.5,189.5) F2(-183.5,191.5) F3(-183.5,193.5) F5(-183.5,197.5) F6(-183.5,199.5) F7(-183.5,201.5) F9(-183.5,205.5) F10(-183.5,207.5) F11(-183.5,209.5) G2(-181.5,191.5) G3(-181.5,193.5) G4(-181.5,195.5) G6(-181.5,199.5) G7(-181.5,201.5) G8(-181.5,203.5) G10(-181.5,207.5) G11(-181.5,209.5) G12(-181.5,211.5) H1(-179.5,189.5) H2(-179.5,191.5) H3(-179.5,193.5) H5(-179.5,197.5) H6(-179.5,199.5) H7(-179.5,201.5) H9(-179.5,205.5) H10(-179.5,207.5) H11(-179.5,209.5) I2(-177.5,191.5) I3(-177.5,193.5) I4(-177.5,195.5) I6(-177.5,199.5) I7(-177.5,201.5) I8(-177.5,203.5) I10(-177.5,207.5) I11(-177.5,209.5) I12(-177.5,211.5) J1(-175.5,189.5) J2(-175.5,191.5) J3(-175.5,193.5) J5(-175.5,197.5) J6(-175.5,199.5) J7(-175.5,201.5) J9(-175.5,205.5) J10(-175.5,207.5) J11(-175.5,209.5) K2(-173.5,191.5) K3(-173.5,193.5) K4(-173.5,195.5) K6(-173.5,199.5) K7(-173.5,201.5) K8(-173.5,203.5) K10(-173.5,207.5) K12(-173.5,211.5) L1(-171.5,189.5) L3(-171.5,193.5) L5(-171.5,197.5) L7(-171.5,201.5) L9(-171.5,205.5) L11(-171.5,209.5) M2(-169.5,191.5) M4(-169.5,195.5) M6(-169.5,199.5) M8(-169.5,203.5) M10(-169.5,207.5) M12(-169.5,211.5) N2(-167.5,191.5) N4(-167.5,195.5) N6(-167.5,199.5) N8(-167.5,203.5) N10(-167.5,207.5) N12(-167.5,211.5) O1(-165.5,189.5) O3(-165.5,193.5) O5(-165.5,197.5) O7(-165.5,201.5) O9(-165.5,205.5) O11(-165.5,209.5) P2(-163.5,191.5) P4(-163.5,195.5) P6(-163.5,199.5) P8(-163.5,203.5) P10(-163.5,207.5) P12(-163.5,211.5) Q1(-161.5,189.5) Q3(-161.5,193.5) Q5(-161.5,197.5) Q7(-161.5,201.5) Q9(-161.5,205.5) Q11(-161.5,209.5) R2(-159.5,191.5) R4(-159.5,195.5) R6(-159.5,199.5) R8(-159.5,203.5) R10(-159.5,207.5) R12(-159.5,211.5) S1(-157.5,189.5) S3(-157.5,193.5) S5(-157.5,197.5) S7(-157.5,201.5) S9(-157.5,205.5) S11(-157.5,209.5) T2(-155.5,191.5) T4(-155.5,195.5) T6(-155.5,199.5) T8(-155.5,203.5) T10(-155.5,207.5) T12(-155.5,211.5) U1(-153.5,189.5) U3(-153.5,193.5) U5(-153.5,197.5) U7(-153.5,201.5) U9(-153.5,205.5) U11(-153.5,209.5) V2(-151.5,191.5) V4(-151.5,195.5) V6(-151.5,199.5) V8(-151.5,203.5) V10(-151.5,207.5) V12(-151.5,211.5) W1(-149.5,189.5) W3(-149.5,193.5) W5(-149.5,197.5) W7(-149.5,201.5) W9(-149.5,205.5) W11(-149.5,209.5) X2(-147.5,191.5) X4(-147.5,195.5) X6(-147.5,199.5) X8(-147.5,203.5) X10(-147.5,207.5) X12(-147.5,211.5) Y1(-145.5,189.5) Y3(-145.5,193.5) Y5(-145.5,197.5) Y7(-145.5,201.5) Y9(-145.5,205.5) Y11(-145.5,209.5) Z2(-143.5,191.5) Z4(-143.5,195.5) Z6(-143.5,199.5) Z8(-143.5,203.5) Z10(-143.5,207.5) Z12(-143.5,211.5)
