# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UNK3SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  410.67 182.17 180 top
UNK3SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  404.8 181.21 180 top
UNK3ST3  SHORT  [DEFAULT_SHORT_SMALL]  179.27 471.8 0 top
UNK3ST4  SHORT  [DEFAULT_SHORT_SMALL]  182.49 471.8 0 top
UNK3ST5  SHORT  [DEFAULT_SHORT_SMALL]  185.71 471.8 0 top
UNK3ST8  SHORT  [DEFAULT_SHORT_SMALL]  188.93 471.8 0 top
UNK3ST11  SHORT  [DEFAULT_SHORT_SMALL]  163.18 471.8 0 top
UNK3ST12  SHORT  [DEFAULT_SHORT_SMALL]  166.4 471.8 0 top
UNK3ST13  SHORT  [DEFAULT_SHORT_SMALL]  169.62 471.8 0 top
UNK3ST14  SHORT  [DEFAULT_SHORT_SMALL]  172.84 471.8 0 top
UNK3ST15  SHORT  [DEFAULT_SHORT_SMALL]  176.06 471.8 0 top
UNK3ST16  SHORT  [DEFAULT_SHORT_SMALL]  27.97 471.8 0 top
UNK3ST17  SHORT  [DEFAULT_SHORT_SMALL]  31.19 471.8 0 top
UNK3ST18  SHORT  [DEFAULT_SHORT_SMALL]  34.41 471.8 0 top
UNK3ST19  SHORT  [DEFAULT_SHORT_SMALL]  37.63 471.8 0 top
UNK3SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  420.95 132.55 0 top
UNK3SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  432.89 86.93 0 top
UNK3U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  408.89 191.89 270 top
UNK3U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  406.58 187.88 270 top
UNK3U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  454.92 187.32 0 bottom
UNK3Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  394.22 202.03 45 top
UNK4BD1  BD120-1.5A-S4-MU  [FB0402]  281.19 275.24 270 bottom
UNK4BD2  BD120-1.5A-S4-MU  [FB0402]  296.96 272.38 180 bottom
UNK4BD3  BD120-1.5A-S4-MU  [FB0402]  280.15 275.24 270 bottom
UNK4BD5  BD120-1.5A-S4-MU  [FB0402]  277.33 265.67 0 bottom
UNK4BD7  BD120-1.5A-S4-MU  [FB0402]  282.24 275.24 270 bottom
UNK4BD9  BD120-1.5A-S4-MU  [FB0402]  301.2 262.45 180 bottom
UNK4BD11  BD120-1.5A-S4-MU  [FB0402]  296.96 271.34 180 bottom
UNK4BD12  BD120-1.5A-S4-MU  [FB0402]  289.07 275.24 270 bottom
UNK4BD13  BD120-1.5A-S4-MU  [FB0402]  277.36 258.82 0 bottom
UNK4BD15  BD120-1.5A-S4-MU  [FB0402]  280.48 255.03 0 bottom
UNK4BD16  BD120-1.5A-S4-MU  [FB0402]  283.8 261.66 180 bottom
UNK4BD17  BD120-1.5A-S4-MU  [FB0402]  283.8 260.62 180 bottom
UNK4BD18  BD120-1.5A-S4-MU  [FB0402]  295.71 257.57 180 bottom
UNK4BD19  BD120-1.5A-S4-MU  [FB0402]  295.71 256.37 180 bottom
UNK4BD20  BD120-1.5A-S4-MU  [FB0402]  275.79 265.62 270 bottom
UNK4BD21  BD120-1.5A-S4-MU  [FB0402]  295.71 254.23 180 bottom
UNK4BD22  BD120-1.5A-S4-MU  [FB0402]  282.3 251.38 180 bottom
UNK4BD23  BD120-1.5A-S4-MU  [FB0402]  282.3 253.44 0 bottom
UNK4BD27  NC/BD120-1.5A-S4-MU  [FB0402]  223.73 258.45 180 bottom
UNK4BD28  BD120-1.5A-S4-MU  [FB0402]  276.81 268.45 270 bottom
UNK4BD29  BD120-1.5A-S4-MU  [FB0402]  286.81 275.24 270 bottom
UNK4BD30  BD120-1.5A-S4-MU  [FB0402]  276.96 271.26 225 bottom
UNK4BD31  BD120-1.5A-S4-MU  [FB0402]  293.85 274.77 180 bottom
UNK4BD32  BD120-1.5A-S4-MU  [FB0402]  246.28 258.87 270 top
UNK4BD33  BD120-1.5A-S4-MU  [FB0402]  219.25 378.55 90 bottom
UNK4BD34  BD120-1.5A-S4-MU  [FB0402]  283.48 249.65 0 bottom
UNK4BD35  BD120-1.5A-S4-MU  [FB0402]  293.63 254.23 180 bottom
UNK4BD36  BD120-1.5A-S4-MU  [FB0402]  275.32 258.83 0 bottom
UNK4BD37  BD120-1.5A-S4-MU  [FB0402]  291.21 275.24 270 bottom
UNK4C1  NC/1P-25-N-S2-WA  [C0201]  289.16 256.56 45 top
UNK4C2  10P-50-N-S2-MU  [C0201]  293.49 251.58 300 top
UNK4C3  NC/1.2P-50-N-S2-MU  [C0201]  290.97 255.6 45 top
UNK4C4  NC/1P-25-N-S2-WA  [C0201]  287.81 256.25 225 top
UNK4C5  NC/1.2P-50-N-S2-MU  [C0201]  288.77 254.43 225 top
UNK4C6  10P-50-N-S2-MU  [C0201]  290.67 250.77 90 top
UNK4C7  NC/10P-50-N-S2-MU  [C0201]  290.37 250.47 180 top
UNK4C8  CNC-S2  [C0201]  290.37 245.6 180 top
UNK4C9  NC/1P-25-N-S2-WA  [C0201]  286.87 255.72 180 bottom
UNK4C10  NC/1.2P-50-N-S2-MU  [C0201]  286.27 253.75 180 bottom
UNK4C11  NC/1P-25-N-S2-WA  [C0201]  285.1 256.37 180 top
UNK4C12  NC/1.2P-50-N-S2-MU  [C0201]  284.5 254.4 180 top
UNK4C13  10P-50-N-S2-MU  [C0201]  284.8 246.76 90 top
UNK4C14  NC/10P-50-N-S2-MU  [C0201]  285.1 246.46 0 top
UNK4C15  CNC-S2  [C0201]  285.1 244.64 0 top
UNK4C16  NC/1P-25-N-S2-WA  [C0201]  285.1 256.37 180 bottom
UNK4C17  NC/0.1U-35-X-S2-MU  [C0201]  293.63 260.2 180 bottom
UNK4C18  NC/0.1U-35-X-S2-MU  [C0201]  293.63 259.35 180 bottom
UNK4C19  NC/1.2P-50-N-S2-MU  [C0201]  284.5 254.4 180 bottom
UNK4C20  0.1U-35-X-S2-MU  [C0201]  293.63 257.12 0 bottom
UNK4C21  0.1U-35-X-S2-MU  [C0201]  293.63 257.97 0 bottom
UNK4C22  0.1U-16-X-S4-MU  [C0402]  243.74 258.84 90 top
UNK4C23  0.9P-50-N-S4-MU  [C0402]  276.6 263.41 270 top
UNK4C24  0.1U-25-X-S4-TY  [C0402]  223.76 259.53 0 bottom
UNK4C25  0.9P-50-N-S4-MU  [C0402]  276.6 260.64 90 top
UNK4C38  1P-50-N-S4-WA  [C0402]  215.74 251.15 0 bottom
UNK4C39  22P-50-N-S4-AVX  [C0402]  212.34 251.15 0 bottom
UNK4C40  1P-50-N-S4-WA  [C0402]  215.74 258.42 0 bottom
UNK4C41  22P-50-N-S4-AVX  [C0402]  212.34 258.42 0 bottom
UNK4C44  0.1U-35-X-S2-MU  [C0201]  283.93 265.5 0 bottom
UNK4C45  0.1U-35-X-S2-MU  [C0201]  292.41 269.41 270 bottom
UNK4C46  0.1U-35-X-S2-MU  [C0201]  283.93 264.65 0 bottom
UNK4C47  0.1U-35-X-S2-MU  [C0201]  292.63 262.19 180 bottom
UNK4C48  0.1U-35-X-S2-MU  [C0201]  279.77 262.74 180 top
UNK4C49  0.1U-35-X-S2-MU  [C0201]  292.63 265.91 180 bottom
UNK4C52  0.1U-35-X-S2-MU  [C0201]  283.93 266.35 0 bottom
UNK4C53  10U-10-X-S4-SS  [C0402]  267.75 266.49 90 bottom
UNK4C54  0.1U-35-X-S2-MU  [C0201]  288.82 269.41 270 bottom
UNK4C55  0.1U-25-X-S4-TY  [C0402]  270.03 266.49 90 bottom
UNK4C56  0.1U-35-X-S2-MU  [C0201]  296.74 263.42 0 top
UNK4C57  NC/10U-10-X-S4-SS  [C0402]  268.88 266.49 90 bottom
UNK4C58  0.1U-35-X-S2-MU  [C0201]  283.66 273.94 90 top
UNK4C59  0.1U-35-X-S2-MU  [C0201]  292.63 267.4 180 bottom
UNK4C60  10U-10-X-S4-SS  [C0402]  299.1 272.43 0 bottom
UNK4C61  0.1U-35-X-S2-MU  [C0201]  287.88 269.4 270 bottom
UNK4C62  22U-25-X-S8-MU  [C0805]  267.63 274.73 0 bottom
UNK4C63  22U-25-X-S8-MU  [C0805]  267.63 276.76 0 bottom
UNK4C64  0.1U-35-X-S2-MU  [C0201]  279.77 260.61 180 top
UNK4C65  47U-16-T-SC  [CODE_C]  241.16 264.79 180 bottom
UNK4C66  10U-16-T-SA  [CODE_A]  241.19 264.79 180 top
UNK4C67  10U-10-X-S4-SS  [C0402]  299.1 271.31 0 bottom
UNK4C68  22U-10-T-SA  [CODE_A]  283.45 294.95 0 bottom
UNK4C69  22U-10-T-SA  [CODE_A]  283.45 297.54 0 bottom
UNK4C70  22U-10-T-SA  [CODE_A]  283.45 300.11 0 bottom
UNK4C71  22U-10-T-SA  [CODE_A]  283.45 297.54 0 top
UNK4C72  22U-10-T-SA  [CODE_A]  283.45 294.95 0 top
UNK4C73  10U-10-X-S4-SS  [C0402]  275.28 257.76 180 bottom
UNK4C74  0.1U-35-X-S2-MU  [C0201]  286.58 260.79 90 bottom
UNK4C75  0.1U-35-X-S2-MU  [C0201]  296.74 260.67 0 top
UNK4C76  10U-10-X-S4-SS  [C0402]  280.45 256.1 180 bottom
UNK4C77  0.1U-35-X-S2-MU  [C0201]  285.76 260.79 90 bottom
UNK4C78  0.1U-35-X-S2-MU  [C0201]  279.77 261.29 180 top
UNK4C79  0.1U-35-X-S2-MU  [C0201]  279.77 259.92 180 top
UNK4C83  10U-10-X-S4-SS  [C0402]  295.74 258.66 0 bottom
UNK4C84  0.1U-35-X-S2-MU  [C0201]  288.09 260.79 90 bottom
UNK4C85  0.1U-35-X-S2-MU  [C0201]  287.36 260.79 90 bottom
UNK4C88  0.1U-35-X-S2-MU  [C0201]  279.77 263.4 180 top
UNK4C89  10U-10-X-S4-SS  [C0402]  274.26 266.99 180 bottom
UNK4C90  10U-10-X-S4-SS  [C0402]  295.74 255.29 0 bottom
UNK4C91  0.1U-35-X-S2-MU  [C0201]  287.68 258.01 0 bottom
UNK4C92  22U-25-X-S8-MU  [C0805]  215.96 231.61 0 bottom
UNK4C93  22U-25-X-S8-MU  [C0805]  215.96 231.61 0 top
UNK4C94  47U-16-T-SC  [CODE_C]  216.03 228.19 0 bottom
UNK4C95  10U-16-T-SA  [CODE_A]  216.03 228.19 0 top
UNK4C96  10U-10-X-S4-SS  [C0402]  297.82 258.66 0 bottom
UNK4C97  10U-10-X-S4-SS  [C0402]  281.83 250.88 270 top
UNK4C98  0.1U-35-X-S2-MU  [C0201]  280.89 251.78 270 top
UNK4C99  10U-10-X-S4-SS  [C0402]  282.77 252.94 270 top
UNK4C100  0.1U-35-X-S2-MU  [C0201]  283.05 256.09 270 top
UNK4C101  10U-10-X-S4-SS  [C0402]  274.26 265.15 180 bottom
UNK4C102  0.1U-35-X-S2-MU  [C0201]  292.63 263.7 180 bottom
UNK4C105  0.1U-35-X-S2-MU  [C0201]  292.63 264.49 180 bottom
UNK4C106  10U-10-X-S4-SS  [C0402]  297.65 285.88 90 bottom
UNK4C107  0.1U-35-X-S2-MU  [C0201]  296.74 264.79 0 top
UNK4C108  0.1U-25-X-S4-TY  [C0402]  296.53 285.88 90 bottom
UNK4C109  NC/10U-10-X-S4-SS  [C0402]  298.77 285.88 90 bottom
UNK4C110  1U-10-X-S4-MU  [C0402]  298.36 260.67 180 top
UNK4C111  10U-10-X-S4-SS  [C0402]  276.81 267.48 270 top
UNK4C112  0.1U-35-X-S2-MU  [C0201]  278.83 268.2 270 top
UNK4C113  10U-25-X-S6-MU  [C0603]  302.96 265.99 90 bottom
UNK4C116  22U-25-X-S8-MU  [C0805]  288.03 278.11 180 bottom
UNK4C117  22U-25-X-S8-MU  [C0805]  288.02 280.27 180 bottom
UNK4C118  10U-10-X-S4-SS  [C0402]  285.72 275.27 90 bottom
UNK4C119  0.1U-35-X-S2-MU  [C0201]  286.94 269.4 270 bottom
UNK4C120  47U-16-T-SC  [CODE_C]  266.21 299.34 90 bottom
UNK4C121  10U-16-T-SA  [CODE_A]  266.21 299.34 90 top
UNK4C122  10U-10-X-S4-SS  [C0402]  297.82 257.55 0 bottom
UNK4C123  10U-10-X-S4-SS  [C0402]  276.28 271.28 135 top
UNK4C124  0.1U-35-X-S2-MU  [C0201]  279.77 270.08 180 top
UNK4C125  10U-10-X-S4-SS  [C0402]  293.38 275.27 90 top
UNK4C126  0.1U-35-X-S2-MU  [C0201]  293.33 273.89 180 top
UNK4C127  10U-10-X-S4-SS  [C0402]  245.01 258.84 90 top
UNK4C128  0.1U-35-X-S2-MU  [C0201]  242.47 258.84 90 top
UNK4C129  10U-10-X-S4-SS  [C0402]  273.26 258.82 180 bottom
UNK4C130  0.1U-25-X-S4-TY  [C0402]  220.35 378.52 270 bottom
UNK4C131  22U-10-T-SA  [CODE_A]  214.8 375.96 180 bottom
UNK4C132  22U-10-T-SA  [CODE_A]  214.8 381.09 180 top
UNK4C133  22U-10-T-SA  [CODE_A]  214.8 378.53 180 top
UNK4C134  22U-10-T-SA  [CODE_A]  214.8 378.53 180 bottom
UNK4C135  22U-10-T-SA  [CODE_A]  214.8 381.09 180 bottom
UNK4C136  10U-10-X-S4-SS  [C0402]  287.84 285.88 90 bottom
UNK4C137  0.1U-25-X-S4-TY  [C0402]  286.72 285.88 90 bottom
UNK4C138  NC/10U-10-X-S4-SS  [C0402]  288.95 285.88 90 bottom
UNK4C139  22U-25-X-S8-MU  [C0805]  276.49 285.56 270 bottom
UNK4C140  47U-16-T-SC  [CODE_C]  266.21 290.09 90 bottom
UNK4C141  10U-16-T-SA  [CODE_A]  266.21 290.09 90 top
UNK4C142  22U-25-X-S8-MU  [C0805]  278.79 285.56 270 bottom
UNK4C143  NC/10P-50-N-S4-WA  [C0402]  297 268.8 180 bottom
UNK4C144  NC/10P-50-N-S4-WA  [C0402]  297 267.63 180 bottom
UNK4C145  NC/10P-50-N-S4-WA  [C0402]  187.11 243.78 90 top
UNK4C146  NC/10P-50-N-S4-WA  [C0402]  187.11 246.98 90 top
UNK4C147  NC/10P-50-N-S4-WA  [C0402]  187.11 236.51 90 top
UNK4C148  NC/10P-50-N-S4-WA  [C0402]  187.11 239.71 90 top
UNK4C149  NC/10P-50-N-S4-WA  [C0402]  187.11 252.41 90 top
UNK4C150  NC/10P-50-N-S4-WA  [C0402]  187.11 255.61 90 top
UNK4C152  0.1U-35-X-S2-MU  [C0201]  289.67 269.41 270 bottom
UNK4C153  CNC-S2  [C0201]  292.12 265.24 180 bottom
UNK4D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  293.73 250.31 30 top
UNK4D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  290.24 246.49 0 top
UNK4D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  285.23 245.52 180 top
UNK4J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  194.53 260.15 270 top
UNK4J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  225.75 381.06 90 top
UNK4J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  188.31 260.15 270 top
UNK4J4  HDR-8X1-M  [JP_8P_100]  202.76 330.13 90 top
UNK4J5  HDR-1X1-M  [JP_1P_RD070_040]  210.83 373.18 270 top
UNK4J6  HDR-2X1-M  [JP_2P_100]  213.74 373.18 270 top
UNK4J7  HDR-2X1-M  [JP_2P_100]  286.81 115.4 0 top
UNK4J8  HDR-2X1-M  [JP_2P_100]  290.62 115.4 0 top
UNK4J9  HDR-2X1-M  [JP_2P_100]  283 115.4 0 top
UNK4K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 255.34 0 bottom
UNK4K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 248.33 0 bottom
UNK4K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 241.32 0 bottom
UNK4K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 263.19 0 bottom
UNK4K5  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  305.5 288.94 270 bottom
UNK4K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  217.03 365.36 270 bottom
UNK4K7  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  253.64 263.57 270 bottom
UNK4K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 254.79 0 bottom
UNK4K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  309.74 241.5 180 bottom
UNK4K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  230.24 246.15 0 bottom
UNK4K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 238.89 0 bottom
UNK4K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 246.15 0 bottom
UNK4K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 246.15 0 bottom
UNK4K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  230.24 238.89 0 bottom
UNK4K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 238.89 0 bottom
UNK4K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  227.27 263.19 0 bottom
UNK4K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  227.27 254.79 0 bottom
UNK4K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 254.79 0 bottom
UNK4K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  283.15 282.11 90 bottom
UNK4K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  270.68 270.58 0 bottom
UNK4K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  267.58 260.09 90 bottom
UNK4K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  273.8 299.27 180 bottom
UNK4K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  281.15 290.55 0 bottom
UNK4K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  305.05 296.92 0 bottom
UNK4K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  294.18 290.49 0 bottom
UNK4K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  292.97 282.11 90 bottom
UNK4K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 263.39 270 bottom
UNK4K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 251.96 270 bottom
UNK4K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 240.53 270 bottom
UNK4K33  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  289.84 298.91 270 bottom
UNK4K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 246.15 0 bottom
UNK4K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 238.89 0 bottom
UNK4K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 254.79 0 bottom
UNK4K37  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 263.19 0 bottom
UNK4K38  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  296.18 298.92 270 bottom
UNK4K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  223.99 365.36 270 bottom
UNK4L1  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  271.97 266.04 270 bottom
UNK4L3  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  297.28 283.34 90 bottom
UNK4L4  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  287.47 283.34 90 bottom
UNK4R1  0-5-S2  [R0201]  290.07 256.08 315 top
UNK4R2  0-5-S2  [R0201]  288.29 255.34 315 top
UNK4R3  0-5-S2  [R0201]  290.67 252.05 270 top
UNK4R4  NC/0-5-S2  [R0201]  290.37 252.35 0 top
UNK4R5  0-5-S2  [R0201]  286.57 254.73 270 bottom
UNK4R6  0-5-S2  [R0201]  284.8 255.39 270 top
UNK4R7  0-5-S2  [R0201]  284.8 248.04 270 top
UNK4R8  NC/0-5-S2  [R0201]  285.1 248.34 180 top
UNK4R9  0-5-S2  [R0201]  284.8 255.39 270 bottom
UNK4R10  0-5-S4  [R0402]  243.59 239.42 90 top
UNK4R11  0-5-S4  [R0402]  242.32 239.42 90 top
UNK4R12  NC/10K-1-S4  [R0402]  239.68 258.84 90 top
UNK4R13  0-5-S4  [R0402]  240.95 258.84 90 top
UNK4R14  NC/10K-1-S4  [R0402]  241.05 239.42 90 top
UNK4R15  0-5-S4  [R0402]  238.41 258.84 90 top
UNK4R16  0-5-S4  [R0402]  239.78 239.42 90 top
UNK4R17  0-5-S4  [R0402]  237.14 258.84 90 top
UNK4R18  NC/10K-1-S4  [R0402]  238.67 239.42 90 top
UNK4R19  0-5-S4  [R0402]  196.97 260.15 180 bottom
UNK4R20  0-5-S4  [R0402]  196.97 265.23 180 bottom
UNK4R21  0-5-S4  [R0402]  196.97 267.77 180 bottom
UNK4R22  45.3-1-S4  [R0402]  300.3 290.93 90 bottom
UNK4R23  45.3-1-S4  [R0402]  248.43 265.57 90 bottom
UNK4R24  0-5-S4  [R0402]  223.16 381.04 0 bottom
UNK4R25  45.3-1-S4  [R0402]  300.3 286.94 270 bottom
UNK4R26  45.3-1-S4  [R0402]  248.43 261.58 270 bottom
UNK4R27  0-5-S4  [R0402]  223.16 375.96 0 bottom
UNK4R28  0-5-S4  [R0402]  223.16 373.42 0 bottom
UNK4R29  NC/45.3-1-S4  [R0402]  226.55 258.95 90 bottom
UNK4R30  0-5-S4  [R0402]  190.74 260.15 180 bottom
UNK4R31  0-5-S4  [R0402]  190.74 265.23 180 bottom
UNK4R32  0-5-S4  [R0402]  190.74 267.77 180 bottom
UNK4R33  NC/45.3-1-S4  [R0402]  225.41 258.95 270 bottom
UNK4R34  10K-1-S4  [R0402]  202.76 332.67 90 bottom
UNK4R35  10K-1-S4  [R0402]  200.22 332.67 90 bottom
UNK4R36  10K-1-S4  [R0402]  197.68 332.67 90 bottom
UNK4R37  10K-1-S4  [R0402]  195.14 332.67 90 bottom
UNK4R38  0-5-S4  [R0402]  200.35 342.83 180 bottom
UNK4R39  10K-1-S4  [R0402]  192.6 332.67 90 bottom
UNK4R40  10K-1-S4  [R0402]  190.06 332.67 90 bottom
UNK4R41  10K-1-S4  [R0402]  187.52 332.67 90 bottom
UNK4R42  0-5-S4  [R0402]  187.39 342.83 0 bottom
UNK4R43  12K-1-S4  [R0402]  301.23 265.74 0 bottom
UNK4R45  32.4-1-S4  [R0402]  224 244.94 90 bottom
UNK4R47  32.4-1-S4  [R0402]  224 237.68 90 bottom
UNK4R48  0-5-S4  [R0402]  263.96 256.59 90 bottom
UNK4R49  NC/0-5-S4  [R0402]  271.19 256.59 90 bottom
UNK4R50  0-5-S4  [R0402]  306.55 300.63 180 top
UNK4R51  NC/0-5-S4  [R0402]  274.8 289.46 270 bottom
UNK4R53  0-5-S4  [R0402]  287.84 292.59 90 bottom
UNK4R54  NC/0-5-S4  [R0402]  287.84 288.39 270 bottom
UNK4R55  0-5-S4  [R0402]  276.65 294.23 180 bottom
UNK4R57  NC/10K-1-S4  [R0402]  203.11 259.56 0 bottom
UNK4R58  NC/10K-1-S4  [R0402]  203.11 266.82 0 bottom
UNK4R59  NC/10K-1-S4  [R0402]  203.11 251.15 0 bottom
UNK4R60  NC/10K-1-S4  [R0402]  203.11 258.42 0 bottom
UNK4R61  0-5-S4  [R0402]  237.56 381.46 180 bottom
UNK4R62  0-5-S4  [R0402]  234.56 381.46 0 bottom
UNK4R63  0-5-S4  [R0402]  221.67 237.68 90 bottom
UNK4R64  0-5-S4  [R0402]  222.84 237.68 90 bottom
UNK4R65  0-5-S4  [R0402]  222.84 240.1 270 bottom
UNK4R66  0-5-S4  [R0402]  221.67 240.1 270 bottom
UNK4R67  0-5-S4  [R0402]  221.67 244.94 90 bottom
UNK4R68  0-5-S4  [R0402]  222.84 244.94 90 bottom
UNK4R69  0-5-S4  [R0402]  222.84 247.36 270 bottom
UNK4R70  0-5-S4  [R0402]  221.67 247.36 270 bottom
UNK4R71  2-5-D-2  [RC02W_27MM]  167.18 265.19 180 bottom
UNK4R72  2-5-D-2  [RC02W_27MM]  167.18 253.76 180 bottom
UNK4R73  2-5-D-2  [RC02W_27MM]  167.18 242.33 180 bottom
UNK4R74  0-5-S4  [R0402]  224 240.1 270 bottom
UNK4R75  0-5-S4  [R0402]  224 247.36 270 bottom
UNK4R76  0-5-S4  [R0402]  301.23 261.38 180 bottom
UNK4R77  0-5-S4  [R0402]  296.99 270.27 180 bottom
UNK4R78  0-5-S4  [R0402]  290.14 275.27 270 bottom
UNK4R79  0-5-S4  [R0402]  284.6 275.27 270 bottom
UNK4R81  0-5-S4  [R0402]  301.23 263.52 180 bottom
UNK4R82  0-5-S4  [R0402]  301.23 266.84 180 bottom
UNK4R83  0-5-S4  [R0402]  301.23 264.64 180 bottom
UNK4SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  295.98 247.27 210 top
UNK4SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  290.67 242.17 180 top
UNK4SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  284.8 241.21 180 top
UNK4ST3  SHORT  [DEFAULT_SHORT_SMALL]  208.25 471.8 0 top
UNK4ST4  SHORT  [DEFAULT_SHORT_SMALL]  211.47 471.8 0 top
UNK4ST5  SHORT  [DEFAULT_SHORT_SMALL]  214.69 471.8 0 top
UNK4ST8  SHORT  [DEFAULT_SHORT_SMALL]  217.91 471.8 0 top
UNK4ST11  SHORT  [DEFAULT_SHORT_SMALL]  192.15 471.8 0 top
UNK4ST12  SHORT  [DEFAULT_SHORT_SMALL]  195.37 471.8 0 top
UNK4ST13  SHORT  [DEFAULT_SHORT_SMALL]  198.59 471.8 0 top
UNK4ST14  SHORT  [DEFAULT_SHORT_SMALL]  201.81 471.8 0 top
UNK4ST15  SHORT  [DEFAULT_SHORT_SMALL]  205.03 471.8 0 top
UNK4ST16  SHORT  [DEFAULT_SHORT_SMALL]  40.85 471.8 0 top
UNK4ST17  SHORT  [DEFAULT_SHORT_SMALL]  44.07 471.8 0 top
UNK4ST18  SHORT  [DEFAULT_SHORT_SMALL]  47.29 471.8 0 top
UNK4ST19  SHORT  [DEFAULT_SHORT_SMALL]  50.51 471.8 0 top
UNK4SW1  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  271.47 339.53 180 top
UNK4SW2  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  426.91 339.35 180 top
UNK4SW3  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  301.57 353.95 180 top
UNK4SW4  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  426.91 352.05 180 top
UNK4SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  193.87 339.02 180 top
UNK4SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  236.06 377.65 180 top
UNK4SW7  SW-SLIDE-8-D2.54-ECE  [SW_DIPX8_16P_H5MM]  271.47 353.95 180 top
UNK4U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  288.89 251.89 270 top
UNK4U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  286.58 247.88 270 top
UNK4U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  241.68 248.39 180 bottom
UNK4Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  274.22 262.03 45 top
UNK5BD1  BD120-1.5A-S4-MU  [FB0402]  321.19 275.24 270 bottom
UNK5BD2  BD120-1.5A-S4-MU  [FB0402]  336.96 272.38 180 bottom
UNK5BD3  BD120-1.5A-S4-MU  [FB0402]  320.15 275.24 270 bottom
UNK5BD5  BD120-1.5A-S4-MU  [FB0402]  317.33 265.67 0 bottom
UNK5BD7  BD120-1.5A-S4-MU  [FB0402]  322.24 275.24 270 bottom
UNK5BD9  BD120-1.5A-S4-MU  [FB0402]  341.2 262.45 180 bottom
UNK5BD11  BD120-1.5A-S4-MU  [FB0402]  336.96 271.34 180 bottom
UNK5BD12  BD120-1.5A-S4-MU  [FB0402]  329.07 275.24 270 bottom
UNK5BD13  BD120-1.5A-S4-MU  [FB0402]  317.36 258.82 0 bottom
UNK5BD15  BD120-1.5A-S4-MU  [FB0402]  320.48 255.03 0 bottom
UNK5BD16  BD120-1.5A-S4-MU  [FB0402]  323.8 261.66 180 bottom
UNK5BD17  BD120-1.5A-S4-MU  [FB0402]  323.8 260.62 180 bottom
UNK5BD18  BD120-1.5A-S4-MU  [FB0402]  335.71 257.57 180 bottom
UNK5BD19  BD120-1.5A-S4-MU  [FB0402]  335.71 256.37 180 bottom
UNK5BD20  BD120-1.5A-S4-MU  [FB0402]  315.79 265.62 270 bottom
UNK5BD21  BD120-1.5A-S4-MU  [FB0402]  335.71 254.23 180 bottom
UNK5BD22  BD120-1.5A-S4-MU  [FB0402]  322.3 251.38 180 bottom
UNK5BD23  BD120-1.5A-S4-MU  [FB0402]  322.3 253.44 0 bottom
UNK5BD27  NC/BD120-1.5A-S4-MU  [FB0402]  223.73 292.74 180 bottom
UNK5BD28  BD120-1.5A-S4-MU  [FB0402]  316.81 268.45 270 bottom
UNK5BD29  BD120-1.5A-S4-MU  [FB0402]  326.81 275.24 270 bottom
UNK5BD30  BD120-1.5A-S4-MU  [FB0402]  316.96 271.26 225 bottom
UNK5BD31  BD120-1.5A-S4-MU  [FB0402]  333.85 274.77 180 bottom
UNK5BD32  BD120-1.5A-S4-MU  [FB0402]  246.28 293.16 270 top
UNK5BD33  BD120-1.5A-S4-MU  [FB0402]  318.82 378.55 90 bottom
UNK5BD34  BD120-1.5A-S4-MU  [FB0402]  323.48 249.65 0 bottom
UNK5BD35  BD120-1.5A-S4-MU  [FB0402]  333.63 254.23 180 bottom
UNK5BD36  BD120-1.5A-S4-MU  [FB0402]  315.32 258.83 0 bottom
UNK5BD37  BD120-1.5A-S4-MU  [FB0402]  331.21 275.24 270 bottom
UNK5C1  NC/1P-25-N-S2-WA  [C0201]  329.16 256.56 45 top
UNK5C2  10P-50-N-S2-MU  [C0201]  333.49 251.58 300 top
UNK5C3  NC/1.2P-50-N-S2-MU  [C0201]  330.97 255.6 45 top
UNK5C4  NC/1P-25-N-S2-WA  [C0201]  327.81 256.25 225 top
UNK5C5  NC/1.2P-50-N-S2-MU  [C0201]  328.77 254.43 225 top
UNK5C6  10P-50-N-S2-MU  [C0201]  330.67 250.77 90 top
UNK5C7  NC/10P-50-N-S2-MU  [C0201]  330.37 250.47 180 top
UNK5C8  CNC-S2  [C0201]  330.37 245.6 180 top
UNK5C9  NC/1P-25-N-S2-WA  [C0201]  326.87 255.72 180 bottom
UNK5C10  NC/1.2P-50-N-S2-MU  [C0201]  326.27 253.75 180 bottom
UNK5C11  NC/1P-25-N-S2-WA  [C0201]  325.1 256.37 180 top
UNK5C12  NC/1.2P-50-N-S2-MU  [C0201]  324.5 254.4 180 top
UNK5C13  10P-50-N-S2-MU  [C0201]  324.8 246.76 90 top
UNK5C14  NC/10P-50-N-S2-MU  [C0201]  325.1 246.46 0 top
UNK5C15  CNC-S2  [C0201]  325.1 244.64 0 top
UNK5C16  NC/1P-25-N-S2-WA  [C0201]  325.1 256.37 180 bottom
UNK5C17  NC/0.1U-35-X-S2-MU  [C0201]  333.62 260.2 180 bottom
UNK5C18  NC/0.1U-35-X-S2-MU  [C0201]  333.62 259.35 180 bottom
UNK5C19  NC/1.2P-50-N-S2-MU  [C0201]  324.5 254.4 180 bottom
UNK5C20  0.1U-35-X-S2-MU  [C0201]  333.62 257.12 0 bottom
UNK5C21  0.1U-35-X-S2-MU  [C0201]  333.62 257.97 0 bottom
UNK5C22  0.1U-16-X-S4-MU  [C0402]  243.74 293.13 90 top
UNK5C23  0.9P-50-N-S4-MU  [C0402]  316.6 263.41 270 top
UNK5C24  0.1U-25-X-S4-TY  [C0402]  223.76 293.82 0 bottom
UNK5C25  0.9P-50-N-S4-MU  [C0402]  316.6 260.64 90 top
UNK5C38  1P-50-N-S4-WA  [C0402]  215.74 285.44 0 bottom
UNK5C39  22P-50-N-S4-AVX  [C0402]  212.34 285.44 0 bottom
UNK5C40  1P-50-N-S4-WA  [C0402]  215.74 292.71 0 bottom
UNK5C41  22P-50-N-S4-AVX  [C0402]  212.34 292.71 0 bottom
UNK5C44  0.1U-35-X-S2-MU  [C0201]  323.93 265.5 0 bottom
UNK5C45  0.1U-35-X-S2-MU  [C0201]  332.4 269.41 270 bottom
UNK5C46  0.1U-35-X-S2-MU  [C0201]  323.93 264.65 0 bottom
UNK5C47  0.1U-35-X-S2-MU  [C0201]  332.63 262.19 180 bottom
UNK5C48  0.1U-35-X-S2-MU  [C0201]  319.77 262.74 180 top
UNK5C49  0.1U-35-X-S2-MU  [C0201]  332.63 265.91 180 bottom
UNK5C52  0.1U-35-X-S2-MU  [C0201]  323.93 266.35 0 bottom
UNK5C53  10U-10-X-S4-SS  [C0402]  307.75 266.49 90 bottom
UNK5C54  0.1U-35-X-S2-MU  [C0201]  328.82 269.41 270 bottom
UNK5C55  0.1U-25-X-S4-TY  [C0402]  310.03 266.49 90 bottom
UNK5C56  0.1U-35-X-S2-MU  [C0201]  336.74 263.42 0 top
UNK5C57  NC/10U-10-X-S4-SS  [C0402]  308.88 266.49 90 bottom
UNK5C58  0.1U-35-X-S2-MU  [C0201]  323.66 273.94 90 top
UNK5C59  0.1U-35-X-S2-MU  [C0201]  332.63 267.4 180 bottom
UNK5C60  10U-10-X-S4-SS  [C0402]  339.1 272.43 0 bottom
UNK5C61  0.1U-35-X-S2-MU  [C0201]  327.88 269.4 270 bottom
UNK5C62  22U-25-X-S8-MU  [C0805]  307.63 274.73 0 bottom
UNK5C63  22U-25-X-S8-MU  [C0805]  307.63 276.76 0 bottom
UNK5C64  0.1U-35-X-S2-MU  [C0201]  319.77 260.61 180 top
UNK5C65  47U-16-T-SC  [CODE_C]  241.16 299.08 180 bottom
UNK5C66  10U-16-T-SA  [CODE_A]  241.19 299.08 180 top
UNK5C67  10U-10-X-S4-SS  [C0402]  339.1 271.31 0 bottom
UNK5C68  22U-10-T-SA  [CODE_A]  323.45 294.95 0 bottom
UNK5C69  22U-10-T-SA  [CODE_A]  323.45 297.54 0 bottom
UNK5C70  22U-10-T-SA  [CODE_A]  323.45 300.11 0 bottom
UNK5C71  22U-10-T-SA  [CODE_A]  323.45 297.54 0 top
UNK5C72  22U-10-T-SA  [CODE_A]  323.45 294.95 0 top
UNK5C73  10U-10-X-S4-SS  [C0402]  315.28 257.76 180 bottom
UNK5C74  0.1U-35-X-S2-MU  [C0201]  326.58 260.79 90 bottom
UNK5C75  0.1U-35-X-S2-MU  [C0201]  336.74 260.67 0 top
UNK5C76  10U-10-X-S4-SS  [C0402]  320.45 256.1 180 bottom
UNK5C77  0.1U-35-X-S2-MU  [C0201]  325.76 260.79 90 bottom
UNK5C78  0.1U-35-X-S2-MU  [C0201]  319.77 261.29 180 top
UNK5C79  0.1U-35-X-S2-MU  [C0201]  319.77 259.92 180 top
UNK5C83  10U-10-X-S4-SS  [C0402]  335.74 258.66 0 bottom
UNK5C84  0.1U-35-X-S2-MU  [C0201]  328.09 260.79 90 bottom
UNK5C85  0.1U-35-X-S2-MU  [C0201]  327.36 260.79 90 bottom
UNK5C88  0.1U-35-X-S2-MU  [C0201]  319.77 263.4 180 top
UNK5C89  10U-10-X-S4-SS  [C0402]  314.26 266.99 180 bottom
UNK5C90  10U-10-X-S4-SS  [C0402]  335.74 255.29 0 bottom
UNK5C91  0.1U-35-X-S2-MU  [C0201]  327.68 258.01 0 bottom
UNK5C92  22U-25-X-S8-MU  [C0805]  215.96 300.19 0 bottom
UNK5C93  22U-25-X-S8-MU  [C0805]  215.96 300.19 0 top
UNK5C94  47U-16-T-SC  [CODE_C]  216.03 296.77 0 bottom
UNK5C95  10U-16-T-SA  [CODE_A]  216.03 296.77 0 top
UNK5C96  10U-10-X-S4-SS  [C0402]  337.82 258.66 0 bottom
UNK5C97  10U-10-X-S4-SS  [C0402]  321.83 250.88 270 top
UNK5C98  0.1U-35-X-S2-MU  [C0201]  320.89 251.78 270 top
UNK5C99  10U-10-X-S4-SS  [C0402]  322.77 252.94 270 top
UNK5C100  0.1U-35-X-S2-MU  [C0201]  323.05 256.09 270 top
UNK5C101  10U-10-X-S4-SS  [C0402]  314.26 265.15 180 bottom
UNK5C102  0.1U-35-X-S2-MU  [C0201]  332.63 263.7 180 bottom
UNK5C105  0.1U-35-X-S2-MU  [C0201]  332.63 264.49 180 bottom
UNK5C106  10U-10-X-S4-SS  [C0402]  337.65 285.88 90 bottom
UNK5C107  0.1U-35-X-S2-MU  [C0201]  336.74 264.79 0 top
UNK5C108  0.1U-25-X-S4-TY  [C0402]  336.53 285.88 90 bottom
UNK5C109  NC/10U-10-X-S4-SS  [C0402]  338.77 285.88 90 bottom
UNK5C110  1U-10-X-S4-MU  [C0402]  338.36 260.67 180 top
UNK5C111  10U-10-X-S4-SS  [C0402]  316.81 267.48 270 top
UNK5C112  0.1U-35-X-S2-MU  [C0201]  318.83 268.2 270 top
UNK5C113  10U-25-X-S6-MU  [C0603]  342.96 265.99 90 bottom
UNK5C116  22U-25-X-S8-MU  [C0805]  328.03 278.11 180 bottom
UNK5C117  22U-25-X-S8-MU  [C0805]  328.02 280.27 180 bottom
UNK5C118  10U-10-X-S4-SS  [C0402]  325.72 275.27 90 bottom
UNK5C119  0.1U-35-X-S2-MU  [C0201]  326.94 269.4 270 bottom
UNK5C120  47U-16-T-SC  [CODE_C]  328.89 298.68 90 bottom
UNK5C121  10U-16-T-SA  [CODE_A]  328.89 298.68 90 top
UNK5C122  10U-10-X-S4-SS  [C0402]  337.82 257.55 0 bottom
UNK5C123  10U-10-X-S4-SS  [C0402]  316.28 271.28 135 top
UNK5C124  0.1U-35-X-S2-MU  [C0201]  319.77 270.08 180 top
UNK5C125  10U-10-X-S4-SS  [C0402]  333.38 275.27 90 top
UNK5C126  0.1U-35-X-S2-MU  [C0201]  333.33 273.89 180 top
UNK5C127  10U-10-X-S4-SS  [C0402]  245.01 293.13 90 top
UNK5C128  0.1U-35-X-S2-MU  [C0201]  242.47 293.13 90 top
UNK5C129  10U-10-X-S4-SS  [C0402]  313.26 258.82 180 bottom
UNK5C130  0.1U-25-X-S4-TY  [C0402]  319.91 378.52 270 bottom
UNK5C131  22U-10-T-SA  [CODE_A]  314.37 375.96 180 bottom
UNK5C132  22U-10-T-SA  [CODE_A]  314.37 381.09 180 top
UNK5C133  22U-10-T-SA  [CODE_A]  314.37 378.53 180 top
UNK5C134  22U-10-T-SA  [CODE_A]  314.37 378.53 180 bottom
UNK5C135  22U-10-T-SA  [CODE_A]  314.37 381.09 180 bottom
UNK5C136  10U-10-X-S4-SS  [C0402]  327.84 285.88 90 bottom
UNK5C137  0.1U-25-X-S4-TY  [C0402]  326.72 285.88 90 bottom
UNK5C138  NC/10U-10-X-S4-SS  [C0402]  328.95 285.88 90 bottom
UNK5C139  22U-25-X-S8-MU  [C0805]  316.49 285.56 270 bottom
UNK5C140  47U-16-T-SC  [CODE_C]  261.58 299.34 90 bottom
UNK5C141  10U-16-T-SA  [CODE_A]  261.58 299.34 90 top
UNK5C142  22U-25-X-S8-MU  [C0805]  318.79 285.56 270 bottom
UNK5C143  NC/10P-50-N-S4-WA  [C0402]  337 268.8 180 bottom
UNK5C144  NC/10P-50-N-S4-WA  [C0402]  337 267.63 180 bottom
UNK5C145  NC/10P-50-N-S4-WA  [C0402]  187.11 278.07 90 top
UNK5C146  NC/10P-50-N-S4-WA  [C0402]  187.11 281.27 90 top
UNK5C147  NC/10P-50-N-S4-WA  [C0402]  187.11 270.8 90 top
UNK5C148  NC/10P-50-N-S4-WA  [C0402]  187.11 274 90 top
UNK5C149  NC/10P-50-N-S4-WA  [C0402]  187.11 286.7 90 top
UNK5C150  NC/10P-50-N-S4-WA  [C0402]  187.11 289.9 90 top
UNK5C152  0.1U-35-X-S2-MU  [C0201]  329.67 269.41 270 bottom
UNK5C153  CNC-S2  [C0201]  332.12 265.24 180 bottom
UNK5D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  333.73 250.31 30 top
UNK5D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  330.24 246.49 0 top
UNK5D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  325.23 245.52 180 top
UNK5J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  194.53 294.44 270 top
UNK5J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  325.32 381.06 90 top
UNK5J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  188.31 294.44 270 top
UNK5J4  HDR-8X1-M  [JP_8P_100]  310.33 330.39 90 top
UNK5J5  HDR-1X1-M  [JP_1P_RD070_040]  310.39 373.18 270 top
UNK5J6  HDR-2X1-M  [JP_2P_100]  313.31 373.18 270 top
UNK5J7  HDR-2X1-M  [JP_2P_100]  270.93 115.4 0 top
UNK5J8  HDR-2X1-M  [JP_2P_100]  274.74 115.4 0 top
UNK5J9  HDR-2X1-M  [JP_2P_100]  267.12 115.4 0 top
UNK5K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 289.63 0 bottom
UNK5K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 282.62 0 bottom
UNK5K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  253.33 275.61 0 bottom
UNK5K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 297.48 0 bottom
UNK5K5  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  345.5 288.94 270 bottom
UNK5K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  316.6 365.36 270 bottom
UNK5K7  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  253.64 297.86 270 bottom
UNK5K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 289.08 0 bottom
UNK5K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  349.74 241.5 180 bottom
UNK5K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  230.24 280.44 0 bottom
UNK5K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 273.18 0 bottom
UNK5K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 280.44 0 bottom
UNK5K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  204.41 280.44 0 bottom
UNK5K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  230.24 273.18 0 bottom
UNK5K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 273.18 0 bottom
UNK5K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  227.27 297.48 0 bottom
UNK5K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  227.27 289.08 0 bottom
UNK5K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  215.84 289.08 0 bottom
UNK5K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  323.15 282.11 90 bottom
UNK5K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  310.68 270.58 0 bottom
UNK5K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  307.58 260.09 90 bottom
UNK5K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  313.72 300.48 90 bottom
UNK5K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  321.15 290.55 0 bottom
UNK5K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  345.05 296.92 0 bottom
UNK5K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  334.18 290.49 0 bottom
UNK5K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  332.97 282.11 90 bottom
UNK5K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 297.68 270 bottom
UNK5K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 286.25 270 bottom
UNK5K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  183.63 274.82 270 bottom
UNK5K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 280.44 0 bottom
UNK5K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 273.18 0 bottom
UNK5K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  192.98 289.08 0 bottom
UNK5K39  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  323.56 365.36 270 bottom
UNK5L1  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  311.97 266.04 270 bottom
UNK5L3  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  337.28 283.34 90 bottom
UNK5L4  L2.2U-1.15A-S2.0X1.6-TDK  [IND_VL252012E]  327.47 283.34 90 bottom
UNK5R1  0-5-S2  [R0201]  330.07 256.08 315 top
UNK5R2  0-5-S2  [R0201]  328.29 255.34 315 top
UNK5R3  0-5-S2  [R0201]  330.67 252.05 270 top
UNK5R4  NC/0-5-S2  [R0201]  330.37 252.35 0 top
UNK5R5  0-5-S2  [R0201]  326.57 254.73 270 bottom
UNK5R6  0-5-S2  [R0201]  324.8 255.39 270 top
UNK5R7  0-5-S2  [R0201]  324.8 248.04 270 top
UNK5R8  NC/0-5-S2  [R0201]  325.1 248.34 180 top
UNK5R9  0-5-S2  [R0201]  324.8 255.39 270 bottom
UNK5R10  0-5-S4  [R0402]  243.59 273.71 90 top
UNK5R11  0-5-S4  [R0402]  242.32 273.71 90 top
UNK5R12  NC/10K-1-S4  [R0402]  239.68 293.13 90 top
UNK5R13  0-5-S4  [R0402]  240.95 293.13 90 top
UNK5R14  NC/10K-1-S4  [R0402]  241.05 273.71 90 top
UNK5R15  0-5-S4  [R0402]  238.41 293.13 90 top
UNK5R16  0-5-S4  [R0402]  239.78 273.71 90 top
UNK5R17  0-5-S4  [R0402]  237.14 293.13 90 top
UNK5R18  NC/10K-1-S4  [R0402]  238.67 273.71 90 top
UNK5R19  0-5-S4  [R0402]  196.97 294.44 180 bottom
UNK5R20  0-5-S4  [R0402]  196.97 299.52 180 bottom
UNK5R21  0-5-S4  [R0402]  196.97 302.06 180 bottom
UNK5R22  45.3-1-S4  [R0402]  340.29 290.93 90 bottom
UNK5R23  45.3-1-S4  [R0402]  248.43 299.86 90 bottom
UNK5R24  0-5-S4  [R0402]  322.72 381.04 0 bottom
UNK5R25  45.3-1-S4  [R0402]  340.29 286.94 270 bottom
UNK5R26  45.3-1-S4  [R0402]  248.43 295.87 270 bottom
UNK5R27  0-5-S4  [R0402]  322.72 375.96 0 bottom
UNK5R28  0-5-S4  [R0402]  322.72 373.42 0 bottom
UNK5R29  NC/45.3-1-S4  [R0402]  226.55 293.24 90 bottom
UNK5R30  0-5-S4  [R0402]  190.74 294.44 180 bottom
UNK5R31  0-5-S4  [R0402]  190.74 299.52 180 bottom
UNK5R32  0-5-S4  [R0402]  190.74 302.06 180 bottom
UNK5R33  NC/45.3-1-S4  [R0402]  225.41 293.24 270 bottom
UNK5R34  10K-1-S4  [R0402]  310.33 332.93 90 bottom
UNK5R35  10K-1-S4  [R0402]  307.79 332.93 90 bottom
UNK5R36  10K-1-S4  [R0402]  305.25 332.93 90 bottom
UNK5R37  10K-1-S4  [R0402]  302.71 332.93 90 bottom
UNK5R38  0-5-S4  [R0402]  307.92 343.09 180 bottom
UNK5R39  10K-1-S4  [R0402]  300.17 332.93 90 bottom
UNK5R40  10K-1-S4  [R0402]  297.63 332.93 90 bottom
UNK5R41  10K-1-S4  [R0402]  295.09 332.93 90 bottom
UNK5R42  0-5-S4  [R0402]  294.96 343.09 0 bottom
UNK5R43  12K-1-S4  [R0402]  341.23 265.74 0 bottom
UNK5R45  32.4-1-S4  [R0402]  224 279.23 90 bottom
UNK5R47  32.4-1-S4  [R0402]  224 271.97 90 bottom
UNK5R48  0-5-S4  [R0402]  303.96 256.59 90 bottom
UNK5R49  NC/0-5-S4  [R0402]  311.19 256.59 90 bottom
UNK5R50  0-5-S4  [R0402]  346.55 300.63 180 top
UNK5R51  NC/0-5-S4  [R0402]  314.8 289.46 270 bottom
UNK5R53  0-5-S4  [R0402]  327.84 292.59 90 bottom
UNK5R54  NC/0-5-S4  [R0402]  327.84 288.39 270 bottom
UNK5R55  0-5-S4  [R0402]  316.65 294.23 180 bottom
UNK5R57  NC/10K-1-S4  [R0402]  203.11 293.85 0 bottom
UNK5R58  NC/10K-1-S4  [R0402]  203.11 301.11 0 bottom
UNK5R59  NC/10K-1-S4  [R0402]  203.11 285.44 0 bottom
UNK5R60  NC/10K-1-S4  [R0402]  203.11 292.71 0 bottom
UNK5R61  0-5-S4  [R0402]  337.13 381.46 180 bottom
UNK5R62  0-5-S4  [R0402]  334.13 381.46 0 bottom
UNK5R63  0-5-S4  [R0402]  221.67 271.97 90 bottom
UNK5R64  0-5-S4  [R0402]  222.84 271.97 90 bottom
UNK5R65  0-5-S4  [R0402]  222.84 274.39 270 bottom
UNK5R66  0-5-S4  [R0402]  221.67 274.39 270 bottom
UNK5R67  0-5-S4  [R0402]  221.67 279.23 90 bottom
UNK5R68  0-5-S4  [R0402]  222.84 279.23 90 bottom
UNK5R69  0-5-S4  [R0402]  222.84 281.65 270 bottom
UNK5R70  0-5-S4  [R0402]  221.67 281.65 270 bottom
UNK5R71  2-5-D-2  [RC02W_27MM]  167.18 299.48 180 bottom
UNK5R72  2-5-D-2  [RC02W_27MM]  167.18 288.05 180 bottom
UNK5R73  2-5-D-2  [RC02W_27MM]  167.18 276.62 180 bottom
UNK5R74  0-5-S4  [R0402]  224 274.39 270 bottom
UNK5R75  0-5-S4  [R0402]  224 281.65 270 bottom
UNK5R76  0-5-S4  [R0402]  341.23 261.38 180 bottom
UNK5R77  0-5-S4  [R0402]  336.99 270.27 180 bottom
UNK5R78  0-5-S4  [R0402]  330.14 275.27 270 bottom
UNK5R79  0-5-S4  [R0402]  324.6 275.27 270 bottom
UNK5R81  0-5-S4  [R0402]  341.23 263.52 180 bottom
UNK5R82  0-5-S4  [R0402]  341.23 266.84 180 bottom
UNK5R83  0-5-S4  [R0402]  341.23 264.64 180 bottom
UNK5SMP1  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  335.98 247.27 210 top
UNK5SMP2  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  330.67 242.17 180 top
UNK5SMP3  MINI-SMP-18S107-40ML5-V2  [CONN_SMP_18S107]  324.8 241.21 180 top
UNK5ST3  SHORT  [DEFAULT_SHORT_SMALL]  237.22 471.8 0 top
UNK5ST4  SHORT  [DEFAULT_SHORT_SMALL]  240.44 471.8 0 top
UNK5ST5  SHORT  [DEFAULT_SHORT_SMALL]  243.66 471.8 0 top
UNK5ST8  SHORT  [DEFAULT_SHORT_SMALL]  246.88 471.8 0 top
UNK5ST11  SHORT  [DEFAULT_SHORT_SMALL]  221.12 471.8 0 top
UNK5ST12  SHORT  [DEFAULT_SHORT_SMALL]  224.34 471.8 0 top
UNK5ST13  SHORT  [DEFAULT_SHORT_SMALL]  227.56 471.8 0 top
UNK5ST14  SHORT  [DEFAULT_SHORT_SMALL]  230.78 471.8 0 top
UNK5ST15  SHORT  [DEFAULT_SHORT_SMALL]  234 471.8 0 top
UNK5ST16  SHORT  [DEFAULT_SHORT_SMALL]  53.73 471.8 0 top
UNK5ST17  SHORT  [DEFAULT_SHORT_SMALL]  56.95 471.8 0 top
UNK5ST18  SHORT  [DEFAULT_SHORT_SMALL]  60.16 471.8 0 top
UNK5ST19  SHORT  [DEFAULT_SHORT_SMALL]  63.38 471.8 0 top
UNK5SW5  SW-SLIDE-8-D2.54-TRI-ECE  [SW_DIPX8P_2P54_MM_V2]  301.44 339.28 180 top
UNK5SW6  SW-SLIDE-4-D2.54-TRI-ECE  [SW_DIPX4P_2P54MM_ETD]  335.63 377.65 180 top
UNK5U1  RFASWA358ATF0G  [RF_SW_GW2159_6P]  328.89 251.89 270 top
UNK5U2  RFASWA358ATF0G  [RF_SW_GW2159_6P]  326.58 247.88 270 top
UNK5U3  MX25L25645GM2I-08G/SK-SO8-1.27  [SK_SO8_1P27MM_LOTES]  241.68 282.68 180 bottom
UNK5Y1  XTAL40M-S2016-TAI-12P  [XTAL_2X1P6MM_4P_0P8MM]  314.22 262.03 45 top
UNK6BD1  BD120-1.5A-S4-MU  [FB0402]  361.19 275.24 270 bottom
UNK6BD2  BD120-1.5A-S4-MU  [FB0402]  376.96 272.38 180 bottom
UNK6BD3  BD120-1.5A-S4-MU  [FB0402]  360.15 275.24 270 bottom
UNK6BD5  BD120-1.5A-S4-MU  [FB0402]  357.33 265.67 0 bottom
UNK6BD7  BD120-1.5A-S4-MU  [FB0402]  362.23 275.24 270 bottom
UNK6BD9  BD120-1.5A-S4-MU  [FB0402]  381.2 262.45 180 bottom
UNK6BD11  BD120-1.5A-S4-MU  [FB0402]  376.96 271.34 180 bottom
UNK6BD12  BD120-1.5A-S4-MU  [FB0402]  369.07 275.24 270 bottom
UNK6BD13  BD120-1.5A-S4-MU  [FB0402]  357.36 258.82 0 bottom
UNK6BD15  BD120-1.5A-S4-MU  [FB0402]  360.48 255.03 0 bottom
UNK6BD16  BD120-1.5A-S4-MU  [FB0402]  363.8 261.66 180 bottom
UNK6BD17  BD120-1.5A-S4-MU  [FB0402]  363.8 260.62 180 bottom
UNK6BD18  BD120-1.5A-S4-MU  [FB0402]  375.71 257.57 180 bottom
UNK6BD19  BD120-1.5A-S4-MU  [FB0402]  375.71 256.37 180 bottom
UNK6BD20  BD120-1.5A-S4-MU  [FB0402]  355.79 265.62 270 bottom
UNK6BD21  BD120-1.5A-S4-MU  [FB0402]  375.71 254.23 180 bottom
UNK6BD22  BD120-1.5A-S4-MU  [FB0402]  362.3 251.38 180 bottom
UNK6BD23  BD120-1.5A-S4-MU  [FB0402]  362.3 253.44 0 bottom
UNK6BD27  NC/BD120-1.5A-S4-MU  [FB0402]  472.87 280.13 0 bottom
UNK6BD28  BD120-1.5A-S4-MU  [FB0402]  356.81 268.45 270 bottom
UNK6BD29  BD120-1.5A-S4-MU  [FB0402]  366.81 275.24 270 bottom
UNK6BD30  BD120-1.5A-S4-MU  [FB0402]  356.96 271.26 225 bottom
UNK6BD31  BD120-1.5A-S4-MU  [FB0402]  373.85 274.77 180 bottom
UNK6BD32  BD120-1.5A-S4-MU  [FB0402]  450.32 279.71 90 top
UNK6BD33  BD120-1.5A-S4-MU  [FB0402]  463.48 378.55 90 bottom
UNK6BD34  BD120-1.5A-S4-MU  [FB0402]  363.48 249.65 0 bottom
UNK6BD35  BD120-1.5A-S4-MU  [FB0402]  373.63 254.23 180 bottom
UNK6BD36  BD120-1.5A-S4-MU  [FB0402]  355.32 258.83 0 bottom
UNK6BD37  BD120-1.5A-S4-MU  [FB0402]  371.2 275.24 270 bottom
UNK6C1  NC/1P-25-N-S2-WA  [C0201]  369.16 256.56 45 top
UNK6C2  10P-50-N-S2-MU  [C0201]  373.49 251.58 300 top
UNK6C3  NC/1.2P-50-N-S2-MU  [C0201]  370.97 255.6 45 top
UNK6C4  NC/1P-25-N-S2-WA  [C0201]  367.8 256.25 225 top
UNK6C5  NC/1.2P-50-N-S2-MU  [C0201]  368.77 254.43 225 top
UNK6C6  10P-50-N-S2-MU  [C0201]  370.67 250.77 90 top
UNK6C7  NC/10P-50-N-S2-MU  [C0201]  370.37 250.47 180 top
UNK6C8  CNC-S2  [C0201]  370.37 245.6 180 top
UNK6C9  NC/1P-25-N-S2-WA  [C0201]  366.87 255.72 180 bottom
UNK6C10  NC/1.2P-50-N-S2-MU  [C0201]  366.27 253.75 180 bottom
UNK6C11  NC/1P-25-N-S2-WA  [C0201]  365.1 256.37 180 top
UNK6C12  NC/1.2P-50-N-S2-MU  [C0201]  364.5 254.4 180 top
UNK6C13  10P-50-N-S2-MU  [C0201]  364.8 246.76 90 top
UNK6C14  NC/10P-50-N-S2-MU  [C0201]  365.1 246.46 0 top
UNK6C15  CNC-S2  [C0201]  365.1 244.64 0 top
UNK6C16  NC/1P-25-N-S2-WA  [C0201]  365.1 256.37 180 bottom
UNK6C17  NC/0.1U-35-X-S2-MU  [C0201]  373.62 260.2 180 bottom
UNK6C18  NC/0.1U-35-X-S2-MU  [C0201]  373.62 259.35 180 bottom
UNK6C19  NC/1.2P-50-N-S2-MU  [C0201]  364.5 254.4 180 bottom
UNK6C20  0.1U-35-X-S2-MU  [C0201]  373.62 257.12 0 bottom
UNK6C21  0.1U-35-X-S2-MU  [C0201]  373.62 257.97 0 bottom
UNK6C22  0.1U-16-X-S4-MU  [C0402]  452.86 279.74 270 top
UNK6C23  0.9P-50-N-S4-MU  [C0402]  356.6 263.41 270 top
UNK6C24  0.1U-25-X-S4-TY  [C0402]  472.84 279.05 180 bottom
UNK6C25  0.9P-50-N-S4-MU  [C0402]  356.6 260.64 90 top
UNK6C38  1P-50-N-S4-WA  [C0402]  480.86 287.43 180 bottom
UNK6C39  22P-50-N-S4-AVX  [C0402]  484.26 287.43 180 bottom
UNK6C40  1P-50-N-S4-WA  [C0402]  480.86 280.16 180 bottom
UNK6C41  22P-50-N-S4-AVX  [C0402]  484.26 280.16 180 bottom
UNK6C44  0.1U-35-X-S2-MU  [C0201]  363.93 265.5 0 bottom
UNK6C45  0.1U-35-X-S2-MU  [C0201]  372.4 269.41 270 bottom
UNK6C46  0.1U-35-X-S2-MU  [C0201]  363.93 264.65 0 bottom
UNK6C47  0.1U-35-X-S2-MU  [C0201]  372.63 262.19 180 bottom
UNK6C48  0.1U-35-X-S2-MU  [C0201]  359.77 262.74 180 top
UNK6C49  0.1U-35-X-S2-MU  [C0201]  372.63 265.91 180 bottom
UNK6C52  0.1U-35-X-S2-MU  [C0201]  363.93 266.35 0 bottom
UNK6C53  10U-10-X-S4-SS  [C0402]  347.75 266.49 90 bottom
UNK6C54  0.1U-35-X-S2-MU  [C0201]  368.82 269.41 270 bottom
UNK6C55  0.1U-25-X-S4-TY  [C0402]  350.03 266.49 90 bottom
UNK6C56  0.1U-35-X-S2-MU  [C0201]  376.74 263.42 0 top
UNK6C57  NC/10U-10-X-S4-SS  [C0402]  348.88 266.49 90 bottom
UNK6C58  0.1U-35-X-S2-MU  [C0201]  363.66 273.94 90 top
UNK6C59  0.1U-35-X-S2-MU  [C0201]  372.63 267.4 180 bottom
UNK6C60  10U-10-X-S4-SS  [C0402]  379.1 272.43 0 bottom
UNK6C61  0.1U-35-X-S2-MU  [C0201]  367.88 269.4 270 bottom
UNK6C62  22U-25-X-S8-MU  [C0805]  347.63 274.73 0 bottom
UNK6C63  22U-25-X-S8-MU  [C0805]  347.63 276.76 0 bottom
UNK6C64  0.1U-35-X-S2-MU  [C0201]  359.77 260.61 180 top
UNK6C65  47U-16-T-SC  [CODE_C]  455.45 273.79 0 bottom
UNK6C66  10U-16-T-SA  [CODE_A]  455.41 273.79 0 top
UNK6C67  10U-10-X-S4-SS  [C0402]  379.1 271.31 0 bottom
UNK6C68  22U-10-T-SA  [CODE_A]  363.46 294.95 0 bottom
UNK6C69  22U-10-T-SA  [CODE_A]  363.46 297.54 0 bottom
UNK6C70  22U-10-T-SA  [CODE_A]  363.46 300.11 0 bottom
UNK6C71  22U-10-T-SA  [CODE_A]  363.46 297.54 0 top
UNK6C72  22U-10-T-SA  [CODE_A]  363.46 294.95 0 top
UNK6C73  10U-10-X-S4-SS  [C0402]  355.28 257.76 180 bottom
UNK6C74  0.1U-35-X-S2-MU  [C0201]  366.58 260.79 90 bottom
UNK6C75  0.1U-35-X-S2-MU  [C0201]  376.74 260.67 0 top
UNK6C76  10U-10-X-S4-SS  [C0402]  360.45 256.1 180 bottom
UNK6C77  0.1U-35-X-S2-MU  [C0201]  365.76 260.79 90 bottom
UNK6C78  0.1U-35-X-S2-MU  [C0201]  359.77 261.29 180 top
UNK6C79  0.1U-35-X-S2-MU  [C0201]  359.77 259.92 180 top
UNK6C83  10U-10-X-S4-SS  [C0402]  375.74 258.66 0 bottom
UNK6C84  0.1U-35-X-S2-MU  [C0201]  368.09 260.79 90 bottom
UNK6C85  0.1U-35-X-S2-MU  [C0201]  367.36 260.79 90 bottom
UNK6C88  0.1U-35-X-S2-MU  [C0201]  359.77 263.4 180 top
UNK6C89  10U-10-X-S4-SS  [C0402]  354.26 266.99 180 bottom
UNK6C90  10U-10-X-S4-SS  [C0402]  375.74 255.29 0 bottom
UNK6C91  0.1U-35-X-S2-MU  [C0201]  367.68 258.01 0 bottom
UNK6C92  22U-25-X-S8-MU  [C0805]  481.52 243.81 180 bottom
UNK6C93  22U-25-X-S8-MU  [C0805]  481.52 243.81 180 top
UNK6C94  47U-16-T-SC  [CODE_C]  481.55 240.39 180 bottom
UNK6C95  10U-16-T-SA  [CODE_A]  481.58 240.39 180 top
UNK6C96  10U-10-X-S4-SS  [C0402]  377.82 258.66 0 bottom
UNK6C97  10U-10-X-S4-SS  [C0402]  361.83 250.88 270 top
UNK6C98  0.1U-35-X-S2-MU  [C0201]  360.89 251.78 270 top
UNK6C99  10U-10-X-S4-SS  [C0402]  362.77 252.94 270 top
UNK6C100  0.1U-35-X-S2-MU  [C0201]  363.05 256.09 270 top
UNK6C101  10U-10-X-S4-SS  [C0402]  354.26 265.15 180 bottom
UNK6C102  0.1U-35-X-S2-MU  [C0201]  372.63 263.7 180 bottom
UNK6C105  0.1U-35-X-S2-MU  [C0201]  372.63 264.49 180 bottom
UNK6C106  10U-10-X-S4-SS  [C0402]  377.65 285.88 90 bottom
UNK6C107  0.1U-35-X-S2-MU  [C0201]  376.74 264.79 0 top
UNK6C108  0.1U-25-X-S4-TY  [C0402]  376.53 285.88 90 bottom
UNK6C109  NC/10U-10-X-S4-SS  [C0402]  378.77 285.88 90 bottom
UNK6C110  1U-10-X-S4-MU  [C0402]  378.36 260.67 180 top
UNK6C111  10U-10-X-S4-SS  [C0402]  356.81 267.48 270 top
UNK6C112  0.1U-35-X-S2-MU  [C0201]  358.83 268.2 270 top
UNK6C113  10U-25-X-S6-MU  [C0603]  382.96 265.99 90 bottom
UNK6C116  22U-25-X-S8-MU  [C0805]  368.03 278.11 180 bottom
UNK6C117  22U-25-X-S8-MU  [C0805]  368.02 280.27 180 bottom
UNK6C118  10U-10-X-S4-SS  [C0402]  365.72 275.27 90 bottom
UNK6C119  0.1U-35-X-S2-MU  [C0201]  366.94 269.4 270 bottom
UNK6C120  47U-16-T-SC  [CODE_C]  386.81 302.45 0 bottom
UNK6C121  10U-16-T-SA  [CODE_A]  386.81 302.45 0 top
UNK6C122  10U-10-X-S4-SS  [C0402]  377.82 257.55 0 bottom
UNK6C123  10U-10-X-S4-SS  [C0402]  356.28 271.28 135 top
UNK6C124  0.1U-35-X-S2-MU  [C0201]  359.77 270.08 180 top
UNK6C125  10U-10-X-S4-SS  [C0402]  373.38 275.27 90 top
UNK6C126  0.1U-35-X-S2-MU  [C0201]  373.33 273.89 180 top
UNK6C127  10U-10-X-S4-SS  [C0402]  451.59 279.74 270 top
UNK6C128  0.1U-35-X-S2-MU  [C0201]  454.13 279.74 270 top
UNK6C129  10U-10-X-S4-SS  [C0402]  353.26 258.82 180 bottom
UNK6C130  0.1U-25-X-S4-TY  [C0402]  464.57 378.52 270 bottom
UNK6C131  22U-10-T-SA  [CODE_A]  459.02 375.96 180 bottom
UNK6C132  22U-10-T-SA  [CODE_A]  459.02 381.09 180 top
UNK6C133  22U-10-T-SA  [CODE_A]  459.02 378.53 180 top
UNK6C134  22U-10-T-SA  [CODE_A]  459.02 378.53 180 bottom
UNK6C135  22U-10-T-SA  [CODE_A]  459.02 381.09 180 bottom
UNK6C136  10U-10-X-S4-SS  [C0402]  367.84 285.88 90 bottom
UNK6C137  0.1U-25-X-S4-TY  [C0402]  366.72 285.88 90 bottom
UNK6C138  NC/10U-10-X-S4-SS  [C0402]  368.95 285.88 90 bottom
UNK6C139  22U-25-X-S8-MU  [C0805]  356.49 285.56 270 bottom
UNK6C140  47U-16-T-SC  [CODE_C]  393.33 298.95 90 bottom
UNK6C141  10U-16-T-SA  [CODE_A]  393.33 298.95 90 top
UNK6C142  22U-25-X-S8-MU  [C0805]  358.79 285.56 270 bottom
UNK6C143  NC/10P-50-N-S4-WA  [C0402]  377 268.8 180 bottom
UNK6C144  NC/10P-50-N-S4-WA  [C0402]  377 267.63 180 bottom
UNK6C145  NC/10P-50-N-S4-WA  [C0402]  509.5 294.8 270 top
UNK6C146  NC/10P-50-N-S4-WA  [C0402]  509.5 291.6 270 top
UNK6C147  NC/10P-50-N-S4-WA  [C0402]  509.5 302.07 270 top
UNK6C148  NC/10P-50-N-S4-WA  [C0402]  509.5 298.87 270 top
UNK6C149  NC/10P-50-N-S4-WA  [C0402]  509.5 286.17 270 top
UNK6C150  NC/10P-50-N-S4-WA  [C0402]  509.5 282.97 270 top
UNK6C152  0.1U-35-X-S2-MU  [C0201]  369.67 269.41 270 bottom
UNK6C153  CNC-S2  [C0201]  372.12 265.24 180 bottom
UNK6D1  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  373.73 250.31 30 top
UNK6D2  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  370.24 246.49 0 top
UNK6D3  RCLAMP3321P-SLP1006P2  [DIODE_1X0P6MM]  365.23 245.52 180 top
UNK6J1  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  502.07 278.44 90 top
UNK6J2  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  469.97 381.06 90 top
UNK6J3  HDR-4X1-F-1  [CONN_4X1_2P54MM_FL10P5MM]  508.3 278.44 90 top
UNK6J4  HDR-8X1-M  [JP_8P_100]  404.56 330.26 90 top
UNK6J5  HDR-1X1-M  [JP_1P_RD070_040]  455.05 373.18 270 top
UNK6J6  HDR-2X1-M  [JP_2P_100]  457.96 373.18 270 top
UNK6J7  HDR-2X1-M  [JP_2P_100]  519.22 115.4 0 top
UNK6J8  HDR-2X1-M  [JP_2P_100]  523.03 115.4 0 top
UNK6J9  HDR-2X1-M  [JP_2P_100]  515.41 115.4 0 top
UNK6K1  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 283.24 180 bottom
UNK6K2  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 290.25 180 bottom
UNK6K3  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  443.27 297.26 180 bottom
UNK6K4  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 275.39 180 bottom
UNK6K5  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  385.5 288.94 270 bottom
UNK6K6  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  461.25 365.36 270 bottom
UNK6K7  CU/RF303-12-A-V2_EX  [RL_RF303_12V_V2]  442.97 275.01 90 bottom
UNK6K8  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 283.79 180 bottom
UNK6K9  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  389.74 241.5 180 bottom
UNK6K10  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  466.36 292.43 180 bottom
UNK6K11  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 299.69 180 bottom
UNK6K12  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 292.43 180 bottom
UNK6K13  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  492.19 292.43 180 bottom
UNK6K14  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  466.36 299.69 180 bottom
UNK6K15  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 299.69 180 bottom
UNK6K16  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  469.33 275.39 180 bottom
UNK6K18  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  469.33 283.79 180 bottom
UNK6K19  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 283.79 180 bottom
UNK6K20  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  363.15 282.11 90 bottom
UNK6K21  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  350.68 270.58 0 bottom
UNK6K22  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  347.58 260.09 90 bottom
UNK6K23  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  353.73 300.48 90 bottom
UNK6K25  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  361.15 290.55 0 bottom
UNK6K26  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  385.05 296.92 0 bottom
UNK6K28  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  374.18 290.49 0 bottom
UNK6K29  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  372.97 282.11 90 bottom
UNK6K30  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 275.2 90 bottom
UNK6K31  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 286.63 90 bottom
UNK6K32  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  512.97 298.06 90 bottom
UNK6K33  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  369.84 298.91 270 bottom
UNK6K34  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 292.43 180 bottom
UNK6K35  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 299.69 180 bottom
UNK6K36  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  503.62 283.79 180 bottom
UNK6K37  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  480.76 275.39 180 bottom
UNK6K38  CU/UA2-12NJ-A-V2  [RL_NECUA2_12V_V2]  376.18 298.92 270 bottom
