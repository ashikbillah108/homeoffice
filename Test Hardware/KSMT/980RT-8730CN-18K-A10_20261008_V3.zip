# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
PG_3680_DPS64_HDAV_L_P7
  rect 0.864x0.864 hole 0.356: A1(-193.5,-211.5) A3(-193.5,-207.5) A5(-193.5,-203.5) A7(-193.5,-199.5) A9(-193.5,-195.5) A11(-193.5,-191.5) B2(-191.5,-209.5) B4(-191.5,-205.5) B6(-191.5,-201.5) B8(-191.5,-197.5) B10(-191.5,-193.5) B12(-191.5,-189.5) C1(-189.5,-211.5) C5(-189.5,-203.5) C9(-189.5,-195.5) C11(-189.5,-191.5) D4(-187.5,-205.5) D8(-187.5,-197.5) D12(-187.5,-189.5) E1(-185.5,-211.5) E5(-185.5,-203.5) E9(-185.5,-195.5) F4(-183.5,-205.5) F8(-183.5,-197.5) F12(-183.5,-189.5) G1(-181.5,-211.5) G5(-181.5,-203.5) G9(-181.5,-195.5) H4(-179.5,-205.5) H8(-179.5,-197.5) H12(-179.5,-189.5) I1(-177.5,-211.5) I5(-177.5,-203.5) I9(-177.5,-195.5) J4(-175.5,-205.5) J8(-175.5,-197.5) J12(-175.5,-189.5) K1(-173.5,-211.5) K5(-173.5,-203.5) K9(-173.5,-195.5) L4(-171.5,-205.5) L8(-171.5,-197.5) L12(-171.5,-189.5) M1(-169.5,-211.5) M5(-169.5,-203.5) M9(-169.5,-195.5) N1(-167.5,-211.5) N3(-167.5,-207.5) N5(-167.5,-203.5) N7(-167.5,-199.5) N9(-167.5,-195.5) N11(-167.5,-191.5) O2(-165.5,-209.5) O4(-165.5,-205.5) O6(-165.5,-201.5) O8(-165.5,-197.5) O10(-165.5,-193.5) O12(-165.5,-189.5) P1(-163.5,-211.5) P3(-163.5,-207.5) P5(-163.5,-203.5) P7(-163.5,-199.5) P9(-163.5,-195.5) P11(-163.5,-191.5) Q2(-161.5,-209.5) Q4(-161.5,-205.5) Q6(-161.5,-201.5) Q8(-161.5,-197.5) Q10(-161.5,-193.5) Q12(-161.5,-189.5) R1(-159.5,-211.5) R3(-159.5,-207.5) R5(-159.5,-203.5) R7(-159.5,-199.5) R9(-159.5,-195.5) R11(-159.5,-191.5) S2(-157.5,-209.5) S4(-157.5,-205.5) S6(-157.5,-201.5) S8(-157.5,-197.5) S10(-157.5,-193.5) S12(-157.5,-189.5) T1(-155.5,-211.5) T3(-155.5,-207.5) T5(-155.5,-203.5) T7(-155.5,-199.5) T9(-155.5,-195.5) T11(-155.5,-191.5) U2(-153.5,-209.5) U4(-153.5,-205.5) U6(-153.5,-201.5) U8(-153.5,-197.5) U10(-153.5,-193.5) U12(-153.5,-189.5) V1(-151.5,-211.5) V3(-151.5,-207.5) V5(-151.5,-203.5) V7(-151.5,-199.5) V9(-151.5,-195.5) V11(-151.5,-191.5) W2(-149.5,-209.5) W4(-149.5,-205.5) W6(-149.5,-201.5) W8(-149.5,-197.5) W10(-149.5,-193.5) W12(-149.5,-189.5) X1(-147.5,-211.5) X3(-147.5,-207.5) X5(-147.5,-203.5) X7(-147.5,-199.5) X9(-147.5,-195.5) X11(-147.5,-191.5) Y2(-145.5,-209.5) Y4(-145.5,-205.5) Y6(-145.5,-201.5) Y8(-145.5,-197.5) Y10(-145.5,-193.5) Y12(-145.5,-189.5) Z1(-143.5,-211.5) Z3(-143.5,-207.5) Z5(-143.5,-203.5) Z7(-143.5,-199.5) Z9(-143.5,-195.5) Z11(-143.5,-191.5)
  round 0.864 hole 0.356: A2(-193.5,-209.5) A4(-193.5,-205.5) A6(-193.5,-201.5) A8(-193.5,-197.5) A10(-193.5,-193.5) A12(-193.5,-189.5) B1(-191.5,-211.5) B3(-191.5,-207.5) B5(-191.5,-203.5) B7(-191.5,-199.5) B9(-191.5,-195.5) B11(-191.5,-191.5) C2(-189.5,-209.5) C3(-189.5,-207.5) C4(-189.5,-205.5) C6(-189.5,-201.5) C7(-189.5,-199.5) C8(-189.5,-197.5) C10(-189.5,-193.5) C12(-189.5,-189.5) D1(-187.5,-211.5) D2(-187.5,-209.5) D3(-187.5,-207.5) D5(-187.5,-203.5) D6(-187.5,-201.5) D7(-187.5,-199.5) D9(-187.5,-195.5) D10(-187.5,-193.5) D11(-187.5,-191.5) E2(-185.5,-209.5) E3(-185.5,-207.5) E4(-185.5,-205.5) E6(-185.5,-201.5) E7(-185.5,-199.5) E8(-185.5,-197.5) E10(-185.5,-193.5) E11(-185.5,-191.5) E12(-185.5,-189.5) F1(-183.5,-211.5) F2(-183.5,-209.5) F3(-183.5,-207.5) F5(-183.5,-203.5) F6(-183.5,-201.5) F7(-183.5,-199.5) F9(-183.5,-195.5) F10(-183.5,-193.5) F11(-183.5,-191.5) G2(-181.5,-209.5) G3(-181.5,-207.5) G4(-181.5,-205.5) G6(-181.5,-201.5) G7(-181.5,-199.5) G8(-181.5,-197.5) G10(-181.5,-193.5) G11(-181.5,-191.5) G12(-181.5,-189.5) H1(-179.5,-211.5) H2(-179.5,-209.5) H3(-179.5,-207.5) H5(-179.5,-203.5) H6(-179.5,-201.5) H7(-179.5,-199.5) H9(-179.5,-195.5) H10(-179.5,-193.5) H11(-179.5,-191.5) I2(-177.5,-209.5) I3(-177.5,-207.5) I4(-177.5,-205.5) I6(-177.5,-201.5) I7(-177.5,-199.5) I8(-177.5,-197.5) I10(-177.5,-193.5) I11(-177.5,-191.5) I12(-177.5,-189.5) J1(-175.5,-211.5) J2(-175.5,-209.5) J3(-175.5,-207.5) J5(-175.5,-203.5) J6(-175.5,-201.5) J7(-175.5,-199.5) J9(-175.5,-195.5) J10(-175.5,-193.5) J11(-175.5,-191.5) K2(-173.5,-209.5) K3(-173.5,-207.5) K4(-173.5,-205.5) K6(-173.5,-201.5) K7(-173.5,-199.5) K8(-173.5,-197.5) K10(-173.5,-193.5) K11(-173.5,-191.5) K12(-173.5,-189.5) L1(-171.5,-211.5) L2(-171.5,-209.5) L3(-171.5,-207.5) L5(-171.5,-203.5) L6(-171.5,-201.5) L7(-171.5,-199.5) L9(-171.5,-195.5) L10(-171.5,-193.5) L11(-171.5,-191.5) M2(-169.5,-209.5) M3(-169.5,-207.5) M4(-169.5,-205.5) M6(-169.5,-201.5) M7(-169.5,-199.5) M8(-169.5,-197.5) M10(-169.5,-193.5) M11(-169.5,-191.5) M12(-169.5,-189.5) N2(-167.5,-209.5) N4(-167.5,-205.5) N6(-167.5,-201.5) N8(-167.5,-197.5) N10(-167.5,-193.5) N12(-167.5,-189.5) O1(-165.5,-211.5) O3(-165.5,-207.5) O5(-165.5,-203.5) O7(-165.5,-199.5) O9(-165.5,-195.5) O11(-165.5,-191.5) P2(-163.5,-209.5) P4(-163.5,-205.5) P6(-163.5,-201.5) P8(-163.5,-197.5) P10(-163.5,-193.5) P12(-163.5,-189.5) Q1(-161.5,-211.5) Q3(-161.5,-207.5) Q5(-161.5,-203.5) Q7(-161.5,-199.5) Q9(-161.5,-195.5) Q11(-161.5,-191.5) R2(-159.5,-209.5) R4(-159.5,-205.5) R6(-159.5,-201.5) R8(-159.5,-197.5) R10(-159.5,-193.5) R12(-159.5,-189.5) S1(-157.5,-211.5) S3(-157.5,-207.5) S5(-157.5,-203.5) S7(-157.5,-199.5) S9(-157.5,-195.5) S11(-157.5,-191.5) T2(-155.5,-209.5) T4(-155.5,-205.5) T6(-155.5,-201.5) T8(-155.5,-197.5) T10(-155.5,-193.5) T12(-155.5,-189.5) U1(-153.5,-211.5) U3(-153.5,-207.5) U5(-153.5,-203.5) U7(-153.5,-199.5) U9(-153.5,-195.5) U11(-153.5,-191.5) V2(-151.5,-209.5) V4(-151.5,-205.5) V6(-151.5,-201.5) V8(-151.5,-197.5) V10(-151.5,-193.5) V12(-151.5,-189.5) W1(-149.5,-211.5) W3(-149.5,-207.5) W5(-149.5,-203.5) W7(-149.5,-199.5) W9(-149.5,-195.5) W11(-149.5,-191.5) X2(-147.5,-209.5) X4(-147.5,-205.5) X6(-147.5,-201.5) X8(-147.5,-197.5) X10(-147.5,-193.5) X12(-147.5,-189.5) Y1(-145.5,-211.5) Y3(-145.5,-207.5) Y5(-145.5,-203.5) Y7(-145.5,-199.5) Y9(-145.5,-195.5) Y11(-145.5,-191.5) Z2(-143.5,-209.5) Z4(-143.5,-205.5) Z6(-143.5,-201.5) Z8(-143.5,-197.5) Z10(-143.5,-193.5) Z12(-143.5,-189.5)
PG_3680_DPS64_HDAV_L_P11
  rect 0.864x0.864 hole 0.356: A1(150.5,-211.5) A3(150.5,-207.5) A5(150.5,-203.5) A7(150.5,-199.5) A9(150.5,-195.5) A11(150.5,-191.5) B2(152.5,-209.5) B4(152.5,-205.5) B6(152.5,-201.5) B8(152.5,-197.5) B10(152.5,-193.5) B12(152.5,-189.5) C1(154.5,-211.5) C3(154.5,-207.5) C5(154.5,-203.5) C7(154.5,-199.5) C9(154.5,-195.5) C11(154.5,-191.5) D2(156.5,-209.5) D4(156.5,-205.5) D6(156.5,-201.5) D8(156.5,-197.5) D10(156.5,-193.5) D12(156.5,-189.5) E1(158.5,-211.5) E3(158.5,-207.5) E5(158.5,-203.5) E7(158.5,-199.5) E9(158.5,-195.5) E11(158.5,-191.5) F2(160.5,-209.5) F4(160.5,-205.5) F6(160.5,-201.5) F8(160.5,-197.5) F10(160.5,-193.5) F12(160.5,-189.5) G1(162.5,-211.5) G3(162.5,-207.5) G5(162.5,-203.5) G7(162.5,-199.5) G9(162.5,-195.5) G11(162.5,-191.5) H2(164.5,-209.5) H4(164.5,-205.5) H6(164.5,-201.5) H8(164.5,-197.5) H10(164.5,-193.5) H12(164.5,-189.5) I1(166.5,-211.5) I3(166.5,-207.5) I5(166.5,-203.5) I7(166.5,-199.5) I9(166.5,-195.5) I11(166.5,-191.5) J2(168.5,-209.5) J4(168.5,-205.5) J6(168.5,-201.5) J8(168.5,-197.5) J10(168.5,-193.5) J12(168.5,-189.5) K1(170.5,-211.5) K3(170.5,-207.5) K5(170.5,-203.5) K7(170.5,-199.5) K9(170.5,-195.5) K11(170.5,-191.5) L2(172.5,-209.5) L4(172.5,-205.5) L6(172.5,-201.5) L8(172.5,-197.5) L10(172.5,-193.5) L12(172.5,-189.5) M1(174.5,-211.5) M3(174.5,-207.5) M5(174.5,-203.5) M7(174.5,-199.5) M9(174.5,-195.5) M11(174.5,-191.5) N1(176.5,-211.5) N3(176.5,-207.5) N5(176.5,-203.5) N7(176.5,-199.5) N9(176.5,-195.5) N11(176.5,-191.5) O2(178.5,-209.5) O4(178.5,-205.5) O6(178.5,-201.5) O8(178.5,-197.5) O10(178.5,-193.5) O12(178.5,-189.5) P1(180.5,-211.5) P5(180.5,-203.5) P9(180.5,-195.5) P11(180.5,-191.5) Q4(182.5,-205.5) Q8(182.5,-197.5) Q12(182.5,-189.5) R1(184.5,-211.5) R5(184.5,-203.5) R9(184.5,-195.5) S4(186.5,-205.5) S8(186.5,-197.5) S12(186.5,-189.5) T1(188.5,-211.5) T5(188.5,-203.5) T9(188.5,-195.5) U4(190.5,-205.5) U8(190.5,-197.5) U12(190.5,-189.5) V1(192.5,-211.5) V5(192.5,-203.5) V9(192.5,-195.5) W4(194.5,-205.5) W8(194.5,-197.5) W12(194.5,-189.5) X1(196.5,-211.5) X5(196.5,-203.5) X9(196.5,-195.5) Y4(198.5,-205.5) Y8(198.5,-197.5) Y12(198.5,-189.5) Z1(200.5,-211.5) Z5(200.5,-203.5) Z9(200.5,-195.5)
  round 0.864 hole 0.356: A2(150.5,-209.5) A4(150.5,-205.5) A6(150.5,-201.5) A8(150.5,-197.5) A10(150.5,-193.5) A12(150.5,-189.5) B1(152.5,-211.5) B3(152.5,-207.5) B5(152.5,-203.5) B7(152.5,-199.5) B9(152.5,-195.5) B11(152.5,-191.5) C2(154.5,-209.5) C4(154.5,-205.5) C6(154.5,-201.5) C8(154.5,-197.5) C10(154.5,-193.5) C12(154.5,-189.5) D1(156.5,-211.5) D3(156.5,-207.5) D5(156.5,-203.5) D7(156.5,-199.5) D9(156.5,-195.5) D11(156.5,-191.5) E2(158.5,-209.5) E4(158.5,-205.5) E6(158.5,-201.5) E8(158.5,-197.5) E10(158.5,-193.5) E12(158.5,-189.5) F1(160.5,-211.5) F3(160.5,-207.5) F5(160.5,-203.5) F7(160.5,-199.5) F9(160.5,-195.5) F11(160.5,-191.5) G2(162.5,-209.5) G4(162.5,-205.5) G6(162.5,-201.5) G8(162.5,-197.5) G10(162.5,-193.5) G12(162.5,-189.5) H1(164.5,-211.5) H3(164.5,-207.5) H5(164.5,-203.5) H7(164.5,-199.5) H9(164.5,-195.5) H11(164.5,-191.5) I2(166.5,-209.5) I4(166.5,-205.5) I6(166.5,-201.5) I8(166.5,-197.5) I10(166.5,-193.5) I12(166.5,-189.5) J1(168.5,-211.5) J3(168.5,-207.5) J5(168.5,-203.5) J7(168.5,-199.5) J9(168.5,-195.5) J11(168.5,-191.5) K2(170.5,-209.5) K4(170.5,-205.5) K6(170.5,-201.5) K8(170.5,-197.5) K10(170.5,-193.5) K12(170.5,-189.5) L1(172.5,-211.5) L3(172.5,-207.5) L5(172.5,-203.5) L7(172.5,-199.5) L9(172.5,-195.5) L11(172.5,-191.5) M2(174.5,-209.5) M4(174.5,-205.5) M6(174.5,-201.5) M8(174.5,-197.5) M10(174.5,-193.5) M12(174.5,-189.5) N2(176.5,-209.5) N4(176.5,-205.5) N6(176.5,-201.5) N8(176.5,-197.5) N10(176.5,-193.5) N12(176.5,-189.5) O1(178.5,-211.5) O3(178.5,-207.5) O5(178.5,-203.5) O7(178.5,-199.5) O9(178.5,-195.5) O11(178.5,-191.5) P2(180.5,-209.5) P3(180.5,-207.5) P4(180.5,-205.5) P6(180.5,-201.5) P7(180.5,-199.5) P8(180.5,-197.5) P10(180.5,-193.5) P12(180.5,-189.5) Q1(182.5,-211.5) Q2(182.5,-209.5) Q3(182.5,-207.5) Q5(182.5,-203.5) Q6(182.5,-201.5) Q7(182.5,-199.5) Q9(182.5,-195.5) Q10(182.5,-193.5) Q11(182.5,-191.5) R2(184.5,-209.5) R3(184.5,-207.5) R4(184.5,-205.5) R6(184.5,-201.5) R7(184.5,-199.5) R8(184.5,-197.5) R10(184.5,-193.5) R11(184.5,-191.5) R12(184.5,-189.5) S1(186.5,-211.5) S2(186.5,-209.5) S3(186.5,-207.5) S5(186.5,-203.5) S6(186.5,-201.5) S7(186.5,-199.5) S9(186.5,-195.5) S10(186.5,-193.5) S11(186.5,-191.5) T2(188.5,-209.5) T3(188.5,-207.5) T4(188.5,-205.5) T6(188.5,-201.5) T7(188.5,-199.5) T8(188.5,-197.5) T10(188.5,-193.5) T11(188.5,-191.5) T12(188.5,-189.5) U1(190.5,-211.5) U2(190.5,-209.5) U3(190.5,-207.5) U5(190.5,-203.5) U6(190.5,-201.5) U7(190.5,-199.5) U9(190.5,-195.5) U10(190.5,-193.5) U11(190.5,-191.5) V2(192.5,-209.5) V3(192.5,-207.5) V4(192.5,-205.5) V6(192.5,-201.5) V7(192.5,-199.5) V8(192.5,-197.5) V10(192.5,-193.5) V11(192.5,-191.5) V12(192.5,-189.5) W1(194.5,-211.5) W2(194.5,-209.5) W3(194.5,-207.5) W5(194.5,-203.5) W6(194.5,-201.5) W7(194.5,-199.5) W9(194.5,-195.5) W10(194.5,-193.5) W11(194.5,-191.5) X2(196.5,-209.5) X3(196.5,-207.5) X4(196.5,-205.5) X6(196.5,-201.5) X7(196.5,-199.5) X8(196.5,-197.5) X10(196.5,-193.5) X11(196.5,-191.5) X12(196.5,-189.5) Y1(198.5,-211.5) Y2(198.5,-209.5) Y3(198.5,-207.5) Y5(198.5,-203.5) Y6(198.5,-201.5) Y7(198.5,-199.5) Y9(198.5,-195.5) Y10(198.5,-193.5) Y11(198.5,-191.5) Z2(200.5,-209.5) Z3(200.5,-207.5) Z4(200.5,-205.5) Z6(200.5,-201.5) Z7(200.5,-199.5) Z8(200.5,-197.5) Z10(200.5,-193.5) Z11(200.5,-191.5) Z12(200.5,-189.5)
PG_3680_FT_RF_OUTLINE_CHROMA_V2
  round 0.508 hole 3.505 unplated: (-291.5,210) (-291.5,70) (-291.5,-70) (-291.5,-210) (-248.5,174.5) (-248.5,-174.5) (-236.5,229) (-236.5,-229) (-235.45,70) (-235.45,-70) (-168.5,229) (-168.5,174.5) (-168.5,-174.5) (-168.5,-229) (-100.5,229) (-100.5,174.5) (-100.5,-174.5) (-100.5,-229) (-36.5,-174.5) (-36.5,-229) (-32.5,229) (-32.5,174.5) (3.5,-174.5) (3.5,-229) (39.5,229) (39.5,174.5) (43.5,-174.5) (43.5,-229) (107.5,229) (107.5,174.5) (107.5,-174.5) (107.5,-229) (175.5,229) (175.5,174.5) (175.5,-174.5) (175.5,-229) (235.45,70) (235.45,-70) (243.5,229) (243.5,-229) (255.5,174.5) (255.5,-174.5) (291.5,210) (291.5,70) (291.5,-70) (291.5,-210)
  round 0.508 hole 4.089 unplated: (-277.8,210) (-277.8,-210) (279.8,210) (279.8,-210)
  round 0.508 hole 10.998 unplated: (-274.8,170)
  round 0.508 hole 13.995 unplated: (274.8,-170)
PG_3680_HDRF3_DPS32_HDAV_H_P6
  rect 0.864x0.864 hole 0.356: A1(150.5,189.5) A3(150.5,193.5) A5(150.5,197.5) A7(150.5,201.5) A9(150.5,205.5) A11(150.5,209.5) B2(152.5,191.5) B4(152.5,195.5) B6(152.5,199.5) B8(152.5,203.5) B10(152.5,207.5) B12(152.5,211.5) C1(154.5,189.5) C3(154.5,193.5) C5(154.5,197.5) C7(154.5,201.5) C9(154.5,205.5) C11(154.5,209.5) D2(156.5,191.5) D4(156.5,195.5) D6(156.5,199.5) D8(156.5,203.5) D10(156.5,207.5) D12(156.5,211.5) E1(158.5,189.5) E3(158.5,193.5) E5(158.5,197.5) E7(158.5,201.5) E9(158.5,205.5) E11(158.5,209.5) F2(160.5,191.5) F4(160.5,195.5) F6(160.5,199.5) F8(160.5,203.5) F10(160.5,207.5) F12(160.5,211.5) G1(162.5,189.5) G3(162.5,193.5) G5(162.5,197.5) G7(162.5,201.5) G9(162.5,205.5) G11(162.5,209.5) H2(164.5,191.5) H4(164.5,195.5) H6(164.5,199.5) H8(164.5,203.5) H10(164.5,207.5) H12(164.5,211.5) I1(166.5,189.5) I3(166.5,193.5) I5(166.5,197.5) I7(166.5,201.5) I9(166.5,205.5) I11(166.5,209.5) J2(168.5,191.5) J4(168.5,195.5) J6(168.5,199.5) J8(168.5,203.5) J10(168.5,207.5) J12(168.5,211.5) K1(170.5,189.5) K3(170.5,193.5) K5(170.5,197.5) K7(170.5,201.5) K9(170.5,205.5) K11(170.5,209.5) L2(172.5,191.5) L4(172.5,195.5) L6(172.5,199.5) L8(172.5,203.5) L10(172.5,207.5) L12(172.5,211.5) M1(174.5,189.5) M3(174.5,193.5) M5(174.5,197.5) M7(174.5,201.5) M9(174.5,205.5) M11(174.5,209.5) N1(176.5,189.5) N5(176.5,197.5) N9(176.5,205.5) O4(178.5,195.5) O8(178.5,203.5) O12(178.5,211.5) P1(180.5,189.5) P5(180.5,197.5) P9(180.5,205.5) Q4(182.5,195.5) Q8(182.5,203.5) Q12(182.5,211.5) R1(184.5,189.5) R5(184.5,197.5) R9(184.5,205.5) S4(186.5,195.5) S8(186.5,203.5) S12(186.5,211.5) T1(188.5,189.5) T5(188.5,197.5) T9(188.5,205.5) U4(190.5,195.5) U8(190.5,203.5) U12(190.5,211.5) V1(192.5,189.5) V5(192.5,197.5) V9(192.5,205.5) W4(194.5,195.5) W8(194.5,203.5) W12(194.5,211.5) X1(196.5,189.5) X5(196.5,197.5) X9(196.5,205.5) X11(196.5,209.5) Y2(198.5,191.5) Y4(198.5,195.5) Y6(198.5,199.5) Y8(198.5,203.5) Y10(198.5,207.5) Y12(198.5,211.5) Z1(200.5,189.5) Z3(200.5,193.5) Z5(200.5,197.5) Z7(200.5,201.5) Z9(200.5,205.5) Z11(200.5,209.5)
  round 0.864 hole 0.356: A2(150.5,191.5) A4(150.5,195.5) A6(150.5,199.5) A8(150.5,203.5) A10(150.5,207.5) A12(150.5,211.5) B1(152.5,189.5) B3(152.5,193.5) B5(152.5,197.5) B7(152.5,201.5) B9(152.5,205.5) B11(152.5,209.5) C2(154.5,191.5) C4(154.5,195.5) C6(154.5,199.5) C8(154.5,203.5) C10(154.5,207.5) C12(154.5,211.5) D1(156.5,189.5) D3(156.5,193.5) D5(156.5,197.5) D7(156.5,201.5) D9(156.5,205.5) D11(156.5,209.5) E2(158.5,191.5) E4(158.5,195.5) E6(158.5,199.5) E8(158.5,203.5) E10(158.5,207.5) E12(158.5,211.5) F1(160.5,189.5) F3(160.5,193.5) F5(160.5,197.5) F7(160.5,201.5) F9(160.5,205.5) F11(160.5,209.5) G2(162.5,191.5) G4(162.5,195.5) G6(162.5,199.5) G8(162.5,203.5) G10(162.5,207.5) G12(162.5,211.5) H1(164.5,189.5) H3(164.5,193.5) H5(164.5,197.5) H7(164.5,201.5) H9(164.5,205.5) H11(164.5,209.5) I2(166.5,191.5) I4(166.5,195.5) I6(166.5,199.5) I8(166.5,203.5) I10(166.5,207.5) I12(166.5,211.5) J1(168.5,189.5) J3(168.5,193.5) J5(168.5,197.5) J7(168.5,201.5) J9(168.5,205.5) J11(168.5,209.5) K2(170.5,191.5) K4(170.5,195.5) K6(170.5,199.5) K8(170.5,203.5) K10(170.5,207.5) K12(170.5,211.5) L1(172.5,189.5) L3(172.5,193.5) L5(172.5,197.5) L7(172.5,201.5) L9(172.5,205.5) L11(172.5,209.5) M2(174.5,191.5) M4(174.5,195.5) M6(174.5,199.5) M8(174.5,203.5) M10(174.5,207.5) M12(174.5,211.5) N2(176.5,191.5) N3(176.5,193.5) N4(176.5,195.5) N6(176.5,199.5) N7(176.5,201.5) N8(176.5,203.5) N10(176.5,207.5) N11(176.5,209.5) N12(176.5,211.5) O1(178.5,189.5) O2(178.5,191.5) O3(178.5,193.5) O5(178.5,197.5) O6(178.5,199.5) O7(178.5,201.5) O9(178.5,205.5) O10(178.5,207.5) O11(178.5,209.5) P2(180.5,191.5) P3(180.5,193.5) P4(180.5,195.5) P6(180.5,199.5) P7(180.5,201.5) P8(180.5,203.5) P10(180.5,207.5) P11(180.5,209.5) P12(180.5,211.5) Q1(182.5,189.5) Q2(182.5,191.5) Q3(182.5,193.5) Q5(182.5,197.5) Q6(182.5,199.5) Q7(182.5,201.5) Q9(182.5,205.5) Q10(182.5,207.5) Q11(182.5,209.5) R2(184.5,191.5) R3(184.5,193.5) R4(184.5,195.5) R6(184.5,199.5) R7(184.5,201.5) R8(184.5,203.5) R10(184.5,207.5) R11(184.5,209.5) R12(184.5,211.5) S1(186.5,189.5) S2(186.5,191.5) S3(186.5,193.5) S5(186.5,197.5) S6(186.5,199.5) S7(186.5,201.5) S9(186.5,205.5) S10(186.5,207.5) S11(186.5,209.5) T2(188.5,191.5) T3(188.5,193.5) T4(188.5,195.5) T6(188.5,199.5) T7(188.5,201.5) T8(188.5,203.5) T10(188.5,207.5) T11(188.5,209.5) T12(188.5,211.5) U1(190.5,189.5) U2(190.5,191.5) U3(190.5,193.5) U5(190.5,197.5) U6(190.5,199.5) U7(190.5,201.5) U9(190.5,205.5) U10(190.5,207.5) U11(190.5,209.5) V2(192.5,191.5) V3(192.5,193.5) V4(192.5,195.5) V6(192.5,199.5) V7(192.5,201.5) V8(192.5,203.5) V10(192.5,207.5) V11(192.5,209.5) V12(192.5,211.5) W1(194.5,189.5) W2(194.5,191.5) W3(194.5,193.5) W5(194.5,197.5) W6(194.5,199.5) W7(194.5,201.5) W9(194.5,205.5) W10(194.5,207.5) W11(194.5,209.5) X2(196.5,191.5) X3(196.5,193.5) X4(196.5,195.5) X6(196.5,199.5) X7(196.5,201.5) X8(196.5,203.5) X10(196.5,207.5) X12(196.5,211.5) Y1(198.5,189.5) Y3(198.5,193.5) Y5(198.5,197.5) Y7(198.5,201.5) Y9(198.5,205.5) Y11(198.5,209.5) Z2(200.5,191.5) Z4(200.5,195.5) Z6(200.5,199.5) Z8(200.5,203.5) Z10(200.5,207.5) Z12(200.5,211.5)
PG_3680_HDRF3_DPS32_P4
  rect 0.864x0.864 hole 0.356: A1(14.5,189.5) A5(14.5,197.5) A9(14.5,205.5) B4(16.5,195.5) B8(16.5,203.5) B12(16.5,211.5) C1(18.5,189.5) C5(18.5,197.5) C9(18.5,205.5) D4(20.5,195.5) D8(20.5,203.5) D12(20.5,211.5) E1(22.5,189.5) E5(22.5,197.5) E9(22.5,205.5) F4(24.5,195.5) F8(24.5,203.5) F12(24.5,211.5) G1(26.5,189.5) G5(26.5,197.5) G9(26.5,205.5) H4(28.5,195.5) H8(28.5,203.5) H12(28.5,211.5) I1(30.5,189.5) I5(30.5,197.5) I9(30.5,205.5) J4(32.5,195.5) J8(32.5,203.5) J12(32.5,211.5) K1(34.5,189.5) K5(34.5,197.5) K9(34.5,205.5) K11(34.5,209.5) L2(36.5,191.5) L4(36.5,195.5) L6(36.5,199.5) L8(36.5,203.5) L10(36.5,207.5) L12(36.5,211.5) M1(38.5,189.5) M3(38.5,193.5) M5(38.5,197.5) M7(38.5,201.5) M9(38.5,205.5) M11(38.5,209.5) N1(40.5,189.5) N3(40.5,193.5) N5(40.5,197.5) N7(40.5,201.5) N9(40.5,205.5) N11(40.5,209.5) O2(42.5,191.5) O4(42.5,195.5) O6(42.5,199.5) O8(42.5,203.5) O10(42.5,207.5) O12(42.5,211.5) P1(44.5,189.5) P3(44.5,193.5) P5(44.5,197.5) P7(44.5,201.5) P9(44.5,205.5) P11(44.5,209.5) Q2(46.5,191.5) Q4(46.5,195.5) Q6(46.5,199.5) Q8(46.5,203.5) Q10(46.5,207.5) Q12(46.5,211.5) R1(48.5,189.5) R3(48.5,193.5) R5(48.5,197.5) R7(48.5,201.5) R9(48.5,205.5) R11(48.5,209.5) S2(50.5,191.5) S4(50.5,195.5) S6(50.5,199.5) S8(50.5,203.5) S10(50.5,207.5) S12(50.5,211.5) T1(52.5,189.5) T3(52.5,193.5) T5(52.5,197.5) T7(52.5,201.5) T9(52.5,205.5) T11(52.5,209.5) U2(54.5,191.5) U4(54.5,195.5) U6(54.5,199.5) U8(54.5,203.5) U10(54.5,207.5) U12(54.5,211.5) V1(56.5,189.5) V3(56.5,193.5) V5(56.5,197.5) V7(56.5,201.5) V9(56.5,205.5) V11(56.5,209.5) W2(58.5,191.5) W4(58.5,195.5) W6(58.5,199.5) W8(58.5,203.5) W10(58.5,207.5) W12(58.5,211.5) X1(60.5,189.5) X3(60.5,193.5) X5(60.5,197.5) X7(60.5,201.5) X9(60.5,205.5) X11(60.5,209.5) Y2(62.5,191.5) Y4(62.5,195.5) Y6(62.5,199.5) Y8(62.5,203.5) Y10(62.5,207.5) Y12(62.5,211.5) Z1(64.5,189.5) Z3(64.5,193.5) Z5(64.5,197.5) Z7(64.5,201.5) Z9(64.5,205.5) Z11(64.5,209.5)
  round 0.864 hole 0.356: A2(14.5,191.5) A3(14.5,193.5) A4(14.5,195.5) A6(14.5,199.5) A7(14.5,201.5) A8(14.5,203.5) A10(14.5,207.5) A11(14.5,209.5) A12(14.5,211.5) B1(16.5,189.5) B2(16.5,191.5) B3(16.5,193.5) B5(16.5,197.5) B6(16.5,199.5) B7(16.5,201.5) B9(16.5,205.5) B10(16.5,207.5) B11(16.5,209.5) C2(18.5,191.5) C3(18.5,193.5) C4(18.5,195.5) C6(18.5,199.5) C7(18.5,201.5) C8(18.5,203.5) C10(18.5,207.5) C11(18.5,209.5) C12(18.5,211.5) D1(20.5,189.5) D2(20.5,191.5) D3(20.5,193.5) D5(20.5,197.5) D6(20.5,199.5) D7(20.5,201.5) D9(20.5,205.5) D10(20.5,207.5) D11(20.5,209.5) E2(22.5,191.5) E3(22.5,193.5) E4(22.5,195.5) E6(22.5,199.5) E7(22.5,201.5) E8(22.5,203.5) E10(22.5,207.5) E11(22.5,209.5) E12(22.5,211.5) F1(24.5,189.5) F2(24.5,191.5) F3(24.5,193.5) F5(24.5,197.5) F6(24.5,199.5) F7(24.5,201.5) F9(24.5,205.5) F10(24.5,207.5) F11(24.5,209.5) G2(26.5,191.5) G3(26.5,193.5) G4(26.5,195.5) G6(26.5,199.5) G7(26.5,201.5) G8(26.5,203.5) G10(26.5,207.5) G11(26.5,209.5) G12(26.5,211.5) H1(28.5,189.5) H2(28.5,191.5) H3(28.5,193.5) H5(28.5,197.5) H6(28.5,199.5) H7(28.5,201.5) H9(28.5,205.5) H10(28.5,207.5) H11(28.5,209.5) I2(30.5,191.5) I3(30.5,193.5) I4(30.5,195.5) I6(30.5,199.5) I7(30.5,201.5) I8(30.5,203.5) I10(30.5,207.5) I11(30.5,209.5) I12(30.5,211.5) J1(32.5,189.5) J2(32.5,191.5) J3(32.5,193.5) J5(32.5,197.5) J6(32.5,199.5) J7(32.5,201.5) J9(32.5,205.5) J10(32.5,207.5) J11(32.5,209.5) K2(34.5,191.5) K3(34.5,193.5) K4(34.5,195.5) K6(34.5,199.5) K7(34.5,201.5) K8(34.5,203.5) K10(34.5,207.5) K12(34.5,211.5) L1(36.5,189.5) L3(36.5,193.5) L5(36.5,197.5) L7(36.5,201.5) L9(36.5,205.5) L11(36.5,209.5) M2(38.5,191.5) M4(38.5,195.5) M6(38.5,199.5) M8(38.5,203.5) M10(38.5,207.5) M12(38.5,211.5) N2(40.5,191.5) N4(40.5,195.5) N6(40.5,199.5) N8(40.5,203.5) N10(40.5,207.5) N12(40.5,211.5) O1(42.5,189.5) O3(42.5,193.5) O5(42.5,197.5) O7(42.5,201.5) O9(42.5,205.5) O11(42.5,209.5) P2(44.5,191.5) P4(44.5,195.5) P6(44.5,199.5) P8(44.5,203.5) P10(44.5,207.5) P12(44.5,211.5) Q1(46.5,189.5) Q3(46.5,193.5) Q5(46.5,197.5) Q7(46.5,201.5) Q9(46.5,205.5) Q11(46.5,209.5) R2(48.5,191.5) R4(48.5,195.5) R6(48.5,199.5) R8(48.5,203.5) R10(48.5,207.5) R12(48.5,211.5) S1(50.5,189.5) S3(50.5,193.5) S5(50.5,197.5) S7(50.5,201.5) S9(50.5,205.5) S11(50.5,209.5) T2(52.5,191.5) T4(52.5,195.5) T6(52.5,199.5) T8(52.5,203.5) T10(52.5,207.5) T12(52.5,211.5) U1(54.5,189.5) U3(54.5,193.5) U5(54.5,197.5) U7(54.5,201.5) U9(54.5,205.5) U11(54.5,209.5) V2(56.5,191.5) V4(56.5,195.5) V6(56.5,199.5) V8(56.5,203.5) V10(56.5,207.5) V12(56.5,211.5) W1(58.5,189.5) W3(58.5,193.5) W5(58.5,197.5) W7(58.5,201.5) W9(58.5,205.5) W11(58.5,209.5) X2(60.5,191.5) X4(60.5,195.5) X6(60.5,199.5) X8(60.5,203.5) X10(60.5,207.5) X12(60.5,211.5) Y1(62.5,189.5) Y3(62.5,193.5) Y5(62.5,197.5) Y7(62.5,201.5) Y9(62.5,205.5) Y11(62.5,209.5) Z2(64.5,191.5) Z4(64.5,195.5) Z6(64.5,199.5) Z8(64.5,203.5) Z10(64.5,207.5) Z12(64.5,211.5)
PG_3680_HDRF3_LPC_P2
  rect 0.864x0.864 hole 0.356: A1(-125.5,189.5) A3(-125.5,193.5) A5(-125.5,197.5) A7(-125.5,201.5) A9(-125.5,205.5) A11(-125.5,209.5) B2(-123.5,191.5) B4(-123.5,195.5) B6(-123.5,199.5) B8(-123.5,203.5) B10(-123.5,207.5) B12(-123.5,211.5) C1(-121.5,189.5) C3(-121.5,193.5) C5(-121.5,197.5) C7(-121.5,201.5) C9(-121.5,205.5) C11(-121.5,209.5) D2(-119.5,191.5) D4(-119.5,195.5) D6(-119.5,199.5) D8(-119.5,203.5) D10(-119.5,207.5) D12(-119.5,211.5) E1(-117.5,189.5) E3(-117.5,193.5) E5(-117.5,197.5) E7(-117.5,201.5) E9(-117.5,205.5) E11(-117.5,209.5) F2(-115.5,191.5) F4(-115.5,195.5) F6(-115.5,199.5) F8(-115.5,203.5) F10(-115.5,207.5) F12(-115.5,211.5) G1(-113.5,189.5) G3(-113.5,193.5) G5(-113.5,197.5) G7(-113.5,201.5) G9(-113.5,205.5) G11(-113.5,209.5) H2(-111.5,191.5) H4(-111.5,195.5) H6(-111.5,199.5) H8(-111.5,203.5) H10(-111.5,207.5) H12(-111.5,211.5) I1(-109.5,189.5) I3(-109.5,193.5) I5(-109.5,197.5) I7(-109.5,201.5) I9(-109.5,205.5) I11(-109.5,209.5) J2(-107.5,191.5) J4(-107.5,195.5) J6(-107.5,199.5) J8(-107.5,203.5) J10(-107.5,207.5) J12(-107.5,211.5) K1(-105.5,189.5) K3(-105.5,193.5) K5(-105.5,197.5) K7(-105.5,201.5) K9(-105.5,205.5) K11(-105.5,209.5) L2(-103.5,191.5) L4(-103.5,195.5) L6(-103.5,199.5) L8(-103.5,203.5) L10(-103.5,207.5) L12(-103.5,211.5) M1(-101.5,189.5) M3(-101.5,193.5) M5(-101.5,197.5) M7(-101.5,201.5) M9(-101.5,205.5) M11(-101.5,209.5) N1(-99.5,189.5) N3(-99.5,193.5) N5(-99.5,197.5) N7(-99.5,201.5) N9(-99.5,205.5) N11(-99.5,209.5) O2(-97.5,191.5) O4(-97.5,195.5) O6(-97.5,199.5) O8(-97.5,203.5) O10(-97.5,207.5) O12(-97.5,211.5) P1(-95.5,189.5) P3(-95.5,193.5) P5(-95.5,197.5) P7(-95.5,201.5) P9(-95.5,205.5) P11(-95.5,209.5) Q2(-93.5,191.5) Q4(-93.5,195.5) Q6(-93.5,199.5) Q8(-93.5,203.5) Q10(-93.5,207.5) Q12(-93.5,211.5) R1(-91.5,189.5) R3(-91.5,193.5) R5(-91.5,197.5) R7(-91.5,201.5) R9(-91.5,205.5) R11(-91.5,209.5) S2(-89.5,191.5) S4(-89.5,195.5) S6(-89.5,199.5) S8(-89.5,203.5) S10(-89.5,207.5) S12(-89.5,211.5) T1(-87.5,189.5) T3(-87.5,193.5) T5(-87.5,197.5) T7(-87.5,201.5) T9(-87.5,205.5) T11(-87.5,209.5) U2(-85.5,191.5) U4(-85.5,195.5) U6(-85.5,199.5) U8(-85.5,203.5) U10(-85.5,207.5) U12(-85.5,211.5) V1(-83.5,189.5) V3(-83.5,193.5) V5(-83.5,197.5) V7(-83.5,201.5) V9(-83.5,205.5) V11(-83.5,209.5) W2(-81.5,191.5) W4(-81.5,195.5) W6(-81.5,199.5) W8(-81.5,203.5) W10(-81.5,207.5) W12(-81.5,211.5) X1(-79.5,189.5) X3(-79.5,193.5) X5(-79.5,197.5) X7(-79.5,201.5) X9(-79.5,205.5) X11(-79.5,209.5) Y2(-77.5,191.5) Y4(-77.5,195.5) Y6(-77.5,199.5) Y8(-77.5,203.5) Y10(-77.5,207.5) Y12(-77.5,211.5) Z1(-75.5,189.5) Z3(-75.5,193.5) Z5(-75.5,197.5) Z7(-75.5,201.5) Z9(-75.5,205.5) Z11(-75.5,209.5)
  round 0.864 hole 0.356: A2(-125.5,191.5) A4(-125.5,195.5) A6(-125.5,199.5) A8(-125.5,203.5) A10(-125.5,207.5) A12(-125.5,211.5) B1(-123.5,189.5) B3(-123.5,193.5) B5(-123.5,197.5) B7(-123.5,201.5) B9(-123.5,205.5) B11(-123.5,209.5) C2(-121.5,191.5) C4(-121.5,195.5) C6(-121.5,199.5) C8(-121.5,203.5) C10(-121.5,207.5) C12(-121.5,211.5) D1(-119.5,189.5) D3(-119.5,193.5) D5(-119.5,197.5) D7(-119.5,201.5) D9(-119.5,205.5) D11(-119.5,209.5) E2(-117.5,191.5) E4(-117.5,195.5) E6(-117.5,199.5) E8(-117.5,203.5) E10(-117.5,207.5) E12(-117.5,211.5) F1(-115.5,189.5) F3(-115.5,193.5) F5(-115.5,197.5) F7(-115.5,201.5) F9(-115.5,205.5) F11(-115.5,209.5) G2(-113.5,191.5) G4(-113.5,195.5) G6(-113.5,199.5) G8(-113.5,203.5) G10(-113.5,207.5) G12(-113.5,211.5) H1(-111.5,189.5) H3(-111.5,193.5) H5(-111.5,197.5) H7(-111.5,201.5) H9(-111.5,205.5) H11(-111.5,209.5) I2(-109.5,191.5) I4(-109.5,195.5) I6(-109.5,199.5) I8(-109.5,203.5) I10(-109.5,207.5) I12(-109.5,211.5) J1(-107.5,189.5) J3(-107.5,193.5) J5(-107.5,197.5) J7(-107.5,201.5) J9(-107.5,205.5) J11(-107.5,209.5) K2(-105.5,191.5) K4(-105.5,195.5) K6(-105.5,199.5) K8(-105.5,203.5) K10(-105.5,207.5) K12(-105.5,211.5) L1(-103.5,189.5) L3(-103.5,193.5) L5(-103.5,197.5) L7(-103.5,201.5) L9(-103.5,205.5) L11(-103.5,209.5) M2(-101.5,191.5) M4(-101.5,195.5) M6(-101.5,199.5) M8(-101.5,203.5) M10(-101.5,207.5) M12(-101.5,211.5) N2(-99.5,191.5) N4(-99.5,195.5) N6(-99.5,199.5) N8(-99.5,203.5) N10(-99.5,207.5) N12(-99.5,211.5) O1(-97.5,189.5) O3(-97.5,193.5) O5(-97.5,197.5) O7(-97.5,201.5) O9(-97.5,205.5) O11(-97.5,209.5) P2(-95.5,191.5) P4(-95.5,195.5) P6(-95.5,199.5) P8(-95.5,203.5) P10(-95.5,207.5) P12(-95.5,211.5) Q1(-93.5,189.5) Q3(-93.5,193.5) Q5(-93.5,197.5) Q7(-93.5,201.5) Q9(-93.5,205.5) Q11(-93.5,209.5) R2(-91.5,191.5) R4(-91.5,195.5) R6(-91.5,199.5) R8(-91.5,203.5) R10(-91.5,207.5) R12(-91.5,211.5) S1(-89.5,189.5) S3(-89.5,193.5) S5(-89.5,197.5) S7(-89.5,201.5) S9(-89.5,205.5) S11(-89.5,209.5) T2(-87.5,191.5) T4(-87.5,195.5) T6(-87.5,199.5) T8(-87.5,203.5) T10(-87.5,207.5) T12(-87.5,211.5) U1(-85.5,189.5) U3(-85.5,193.5) U5(-85.5,197.5) U7(-85.5,201.5) U9(-85.5,205.5) U11(-85.5,209.5) V2(-83.5,191.5) V4(-83.5,195.5) V6(-83.5,199.5) V8(-83.5,203.5) V10(-83.5,207.5) V12(-83.5,211.5) W1(-81.5,189.5) W3(-81.5,193.5) W5(-81.5,197.5) W7(-81.5,201.5) W9(-81.5,205.5) W11(-81.5,209.5) X2(-79.5,191.5) X4(-79.5,195.5) X6(-79.5,199.5) X8(-79.5,203.5) X10(-79.5,207.5) X12(-79.5,211.5) Y1(-77.5,189.5) Y3(-77.5,193.5) Y5(-77.5,197.5) Y7(-77.5,201.5) Y9(-77.5,205.5) Y11(-77.5,209.5) Z2(-75.5,191.5) Z4(-75.5,195.5) Z6(-75.5,199.5) Z8(-75.5,203.5) Z10(-75.5,207.5) Z12(-75.5,211.5)
PG_3680_HDRF3_LPC_P5
  rect 0.864x0.864 hole 0.356: A1(82.5,189.5) A3(82.5,193.5) A5(82.5,197.5) A7(82.5,201.5) A9(82.5,205.5) A11(82.5,209.5) B2(84.5,191.5) B4(84.5,195.5) B6(84.5,199.5) B8(84.5,203.5) B10(84.5,207.5) B12(84.5,211.5) C1(86.5,189.5) C3(86.5,193.5) C5(86.5,197.5) C7(86.5,201.5) C9(86.5,205.5) C11(86.5,209.5) D2(88.5,191.5) D4(88.5,195.5) D6(88.5,199.5) D8(88.5,203.5) D10(88.5,207.5) D12(88.5,211.5) E1(90.5,189.5) E3(90.5,193.5) E5(90.5,197.5) E7(90.5,201.5) E9(90.5,205.5) E11(90.5,209.5) F2(92.5,191.5) F4(92.5,195.5) F6(92.5,199.5) F8(92.5,203.5) F10(92.5,207.5) F12(92.5,211.5) G1(94.5,189.5) G3(94.5,193.5) G5(94.5,197.5) G7(94.5,201.5) G9(94.5,205.5) G11(94.5,209.5) H2(96.5,191.5) H4(96.5,195.5) H6(96.5,199.5) H8(96.5,203.5) H10(96.5,207.5) H12(96.5,211.5) I1(98.5,189.5) I3(98.5,193.5) I5(98.5,197.5) I7(98.5,201.5) I9(98.5,205.5) I11(98.5,209.5) J2(100.5,191.5) J4(100.5,195.5) J6(100.5,199.5) J8(100.5,203.5) J10(100.5,207.5) J12(100.5,211.5) K1(102.5,189.5) K3(102.5,193.5) K5(102.5,197.5) K7(102.5,201.5) K9(102.5,205.5) K11(102.5,209.5) L2(104.5,191.5) L4(104.5,195.5) L6(104.5,199.5) L8(104.5,203.5) L10(104.5,207.5) L12(104.5,211.5) M1(106.5,189.5) M3(106.5,193.5) M5(106.5,197.5) M7(106.5,201.5) M9(106.5,205.5) M11(106.5,209.5) N1(108.5,189.5) N3(108.5,193.5) N5(108.5,197.5) N7(108.5,201.5) N9(108.5,205.5) N11(108.5,209.5) O2(110.5,191.5) O4(110.5,195.5) O6(110.5,199.5) O8(110.5,203.5) O10(110.5,207.5) O12(110.5,211.5) P1(112.5,189.5) P3(112.5,193.5) P5(112.5,197.5) P7(112.5,201.5) P9(112.5,205.5) P11(112.5,209.5) Q2(114.5,191.5) Q4(114.5,195.5) Q6(114.5,199.5) Q8(114.5,203.5) Q10(114.5,207.5) Q12(114.5,211.5) R1(116.5,189.5) R3(116.5,193.5) R5(116.5,197.5) R7(116.5,201.5) R9(116.5,205.5) R11(116.5,209.5) S2(118.5,191.5) S4(118.5,195.5) S6(118.5,199.5) S8(118.5,203.5) S10(118.5,207.5) S12(118.5,211.5) T1(120.5,189.5) T3(120.5,193.5) T5(120.5,197.5) T7(120.5,201.5) T9(120.5,205.5) T11(120.5,209.5) U2(122.5,191.5) U4(122.5,195.5) U6(122.5,199.5) U8(122.5,203.5) U10(122.5,207.5) U12(122.5,211.5) V1(124.5,189.5) V3(124.5,193.5) V5(124.5,197.5) V7(124.5,201.5) V9(124.5,205.5) V11(124.5,209.5) W2(126.5,191.5) W4(126.5,195.5) W6(126.5,199.5) W8(126.5,203.5) W10(126.5,207.5) W12(126.5,211.5) X1(128.5,189.5) X3(128.5,193.5) X5(128.5,197.5) X7(128.5,201.5) X9(128.5,205.5) X11(128.5,209.5) Y2(130.5,191.5) Y4(130.5,195.5) Y6(130.5,199.5) Y8(130.5,203.5) Y10(130.5,207.5) Y12(130.5,211.5) Z1(132.5,189.5) Z3(132.5,193.5) Z5(132.5,197.5) Z7(132.5,201.5) Z9(132.5,205.5) Z11(132.5,209.5)
  round 0.864 hole 0.356: A2(82.5,191.5) A4(82.5,195.5) A6(82.5,199.5) A8(82.5,203.5) A10(82.5,207.5) A12(82.5,211.5) B1(84.5,189.5) B3(84.5,193.5) B5(84.5,197.5) B7(84.5,201.5) B9(84.5,205.5) B11(84.5,209.5) C2(86.5,191.5) C4(86.5,195.5) C6(86.5,199.5) C8(86.5,203.5) C10(86.5,207.5) C12(86.5,211.5) D1(88.5,189.5) D3(88.5,193.5) D5(88.5,197.5) D7(88.5,201.5) D9(88.5,205.5) D11(88.5,209.5) E2(90.5,191.5) E4(90.5,195.5) E6(90.5,199.5) E8(90.5,203.5) E10(90.5,207.5) E12(90.5,211.5) F1(92.5,189.5) F3(92.5,193.5) F5(92.5,197.5) F7(92.5,201.5) F9(92.5,205.5) F11(92.5,209.5) G2(94.5,191.5) G4(94.5,195.5) G6(94.5,199.5) G8(94.5,203.5) G10(94.5,207.5) G12(94.5,211.5) H1(96.5,189.5) H3(96.5,193.5) H5(96.5,197.5) H7(96.5,201.5) H9(96.5,205.5) H11(96.5,209.5) I2(98.5,191.5) I4(98.5,195.5) I6(98.5,199.5) I8(98.5,203.5) I10(98.5,207.5) I12(98.5,211.5) J1(100.5,189.5) J3(100.5,193.5) J5(100.5,197.5) J7(100.5,201.5) J9(100.5,205.5) J11(100.5,209.5) K2(102.5,191.5) K4(102.5,195.5) K6(102.5,199.5) K8(102.5,203.5) K10(102.5,207.5) K12(102.5,211.5) L1(104.5,189.5) L3(104.5,193.5) L5(104.5,197.5) L7(104.5,201.5) L9(104.5,205.5) L11(104.5,209.5) M2(106.5,191.5) M4(106.5,195.5) M6(106.5,199.5) M8(106.5,203.5) M10(106.5,207.5) M12(106.5,211.5) N2(108.5,191.5) N4(108.5,195.5) N6(108.5,199.5) N8(108.5,203.5) N10(108.5,207.5) N12(108.5,211.5) O1(110.5,189.5) O3(110.5,193.5) O5(110.5,197.5) O7(110.5,201.5) O9(110.5,205.5) O11(110.5,209.5) P2(112.5,191.5) P4(112.5,195.5) P6(112.5,199.5) P8(112.5,203.5) P10(112.5,207.5) P12(112.5,211.5) Q1(114.5,189.5) Q3(114.5,193.5) Q5(114.5,197.5) Q7(114.5,201.5) Q9(114.5,205.5) Q11(114.5,209.5) R2(116.5,191.5) R4(116.5,195.5) R6(116.5,199.5) R8(116.5,203.5) R10(116.5,207.5) R12(116.5,211.5) S1(118.5,189.5) S3(118.5,193.5) S5(118.5,197.5) S7(118.5,201.5) S9(118.5,205.5) S11(118.5,209.5) T2(120.5,191.5) T4(120.5,195.5) T6(120.5,199.5) T8(120.5,203.5) T10(120.5,207.5) T12(120.5,211.5) U1(122.5,189.5) U3(122.5,193.5) U5(122.5,197.5) U7(122.5,201.5) U9(122.5,205.5) U11(122.5,209.5) V2(124.5,191.5) V4(124.5,195.5) V6(124.5,199.5) V8(124.5,203.5) V10(124.5,207.5) V12(124.5,211.5) W1(126.5,189.5) W3(126.5,193.5) W5(126.5,197.5) W7(126.5,201.5) W9(126.5,205.5) W11(126.5,209.5) X2(128.5,191.5) X4(128.5,195.5) X6(128.5,199.5) X8(128.5,203.5) X10(128.5,207.5) X12(128.5,211.5) Y1(130.5,189.5) Y3(130.5,193.5) Y5(130.5,197.5) Y7(130.5,201.5) Y9(130.5,205.5) Y11(130.5,209.5) Z2(132.5,191.5) Z4(132.5,195.5) Z6(132.5,199.5) Z8(132.5,203.5) Z10(132.5,207.5) Z12(132.5,211.5)
PG_3680_HDRF3_LPC_P8
  rect 0.864x0.864 hole 0.356: A1(-125.5,-211.5) A3(-125.5,-207.5) A5(-125.5,-203.5) A7(-125.5,-199.5) A9(-125.5,-195.5) A11(-125.5,-191.5) B2(-123.5,-209.5) B4(-123.5,-205.5) B6(-123.5,-201.5) B8(-123.5,-197.5) B10(-123.5,-193.5) B12(-123.5,-189.5) C1(-121.5,-211.5) C3(-121.5,-207.5) C5(-121.5,-203.5) C7(-121.5,-199.5) C9(-121.5,-195.5) C11(-121.5,-191.5) D2(-119.5,-209.5) D4(-119.5,-205.5) D6(-119.5,-201.5) D8(-119.5,-197.5) D10(-119.5,-193.5) D12(-119.5,-189.5) E1(-117.5,-211.5) E3(-117.5,-207.5) E5(-117.5,-203.5) E7(-117.5,-199.5) E9(-117.5,-195.5) E11(-117.5,-191.5) F2(-115.5,-209.5) F4(-115.5,-205.5) F6(-115.5,-201.5) F8(-115.5,-197.5) F10(-115.5,-193.5) F12(-115.5,-189.5) G1(-113.5,-211.5) G3(-113.5,-207.5) G5(-113.5,-203.5) G7(-113.5,-199.5) G9(-113.5,-195.5) G11(-113.5,-191.5) H2(-111.5,-209.5) H4(-111.5,-205.5) H6(-111.5,-201.5) H8(-111.5,-197.5) H10(-111.5,-193.5) H12(-111.5,-189.5) I1(-109.5,-211.5) I3(-109.5,-207.5) I5(-109.5,-203.5) I7(-109.5,-199.5) I9(-109.5,-195.5) I11(-109.5,-191.5) J2(-107.5,-209.5) J4(-107.5,-205.5) J6(-107.5,-201.5) J8(-107.5,-197.5) J10(-107.5,-193.5) J12(-107.5,-189.5) K1(-105.5,-211.5) K3(-105.5,-207.5) K5(-105.5,-203.5) K7(-105.5,-199.5) K9(-105.5,-195.5) K11(-105.5,-191.5) L2(-103.5,-209.5) L4(-103.5,-205.5) L6(-103.5,-201.5) L8(-103.5,-197.5) L10(-103.5,-193.5) L12(-103.5,-189.5) M1(-101.5,-211.5) M3(-101.5,-207.5) M5(-101.5,-203.5) M7(-101.5,-199.5) M9(-101.5,-195.5) M11(-101.5,-191.5) N1(-99.5,-211.5) N3(-99.5,-207.5) N5(-99.5,-203.5) N7(-99.5,-199.5) N9(-99.5,-195.5) N11(-99.5,-191.5) O2(-97.5,-209.5) O4(-97.5,-205.5) O6(-97.5,-201.5) O8(-97.5,-197.5) O10(-97.5,-193.5) O12(-97.5,-189.5) P1(-95.5,-211.5) P3(-95.5,-207.5) P5(-95.5,-203.5) P7(-95.5,-199.5) P9(-95.5,-195.5) P11(-95.5,-191.5) Q2(-93.5,-209.5) Q4(-93.5,-205.5) Q6(-93.5,-201.5) Q8(-93.5,-197.5) Q10(-93.5,-193.5) Q12(-93.5,-189.5) R1(-91.5,-211.5) R3(-91.5,-207.5) R5(-91.5,-203.5) R7(-91.5,-199.5) R9(-91.5,-195.5) R11(-91.5,-191.5) S2(-89.5,-209.5) S4(-89.5,-205.5) S6(-89.5,-201.5) S8(-89.5,-197.5) S10(-89.5,-193.5) S12(-89.5,-189.5) T1(-87.5,-211.5) T3(-87.5,-207.5) T5(-87.5,-203.5) T7(-87.5,-199.5) T9(-87.5,-195.5) T11(-87.5,-191.5) U2(-85.5,-209.5) U4(-85.5,-205.5) U6(-85.5,-201.5) U8(-85.5,-197.5) U10(-85.5,-193.5) U12(-85.5,-189.5) V1(-83.5,-211.5) V3(-83.5,-207.5) V5(-83.5,-203.5) V7(-83.5,-199.5) V9(-83.5,-195.5) V11(-83.5,-191.5) W2(-81.5,-209.5) W4(-81.5,-205.5) W6(-81.5,-201.5) W8(-81.5,-197.5) W10(-81.5,-193.5) W12(-81.5,-189.5) X1(-79.5,-211.5) X3(-79.5,-207.5) X5(-79.5,-203.5) X7(-79.5,-199.5) X9(-79.5,-195.5) X11(-79.5,-191.5) Y2(-77.5,-209.5) Y4(-77.5,-205.5) Y6(-77.5,-201.5) Y8(-77.5,-197.5) Y10(-77.5,-193.5) Y12(-77.5,-189.5) Z1(-75.5,-211.5) Z3(-75.5,-207.5) Z5(-75.5,-203.5) Z7(-75.5,-199.5) Z9(-75.5,-195.5) Z11(-75.5,-191.5)
  round 0.864 hole 0.356: A2(-125.5,-209.5) A4(-125.5,-205.5) A6(-125.5,-201.5) A8(-125.5,-197.5) A10(-125.5,-193.5) A12(-125.5,-189.5) B1(-123.5,-211.5) B3(-123.5,-207.5) B5(-123.5,-203.5) B7(-123.5,-199.5) B9(-123.5,-195.5) B11(-123.5,-191.5) C2(-121.5,-209.5) C4(-121.5,-205.5) C6(-121.5,-201.5) C8(-121.5,-197.5) C10(-121.5,-193.5) C12(-121.5,-189.5) D1(-119.5,-211.5) D3(-119.5,-207.5) D5(-119.5,-203.5) D7(-119.5,-199.5) D9(-119.5,-195.5) D11(-119.5,-191.5) E2(-117.5,-209.5) E4(-117.5,-205.5) E6(-117.5,-201.5) E8(-117.5,-197.5) E10(-117.5,-193.5) E12(-117.5,-189.5) F1(-115.5,-211.5) F3(-115.5,-207.5) F5(-115.5,-203.5) F7(-115.5,-199.5) F9(-115.5,-195.5) F11(-115.5,-191.5) G2(-113.5,-209.5) G4(-113.5,-205.5) G6(-113.5,-201.5) G8(-113.5,-197.5) G10(-113.5,-193.5) G12(-113.5,-189.5) H1(-111.5,-211.5) H3(-111.5,-207.5) H5(-111.5,-203.5) H7(-111.5,-199.5) H9(-111.5,-195.5) H11(-111.5,-191.5) I2(-109.5,-209.5) I4(-109.5,-205.5) I6(-109.5,-201.5) I8(-109.5,-197.5) I10(-109.5,-193.5) I12(-109.5,-189.5) J1(-107.5,-211.5) J3(-107.5,-207.5) J5(-107.5,-203.5) J7(-107.5,-199.5) J9(-107.5,-195.5) J11(-107.5,-191.5) K2(-105.5,-209.5) K4(-105.5,-205.5) K6(-105.5,-201.5) K8(-105.5,-197.5) K10(-105.5,-193.5) K12(-105.5,-189.5) L1(-103.5,-211.5) L3(-103.5,-207.5) L5(-103.5,-203.5) L7(-103.5,-199.5) L9(-103.5,-195.5) L11(-103.5,-191.5) M2(-101.5,-209.5) M4(-101.5,-205.5) M6(-101.5,-201.5) M8(-101.5,-197.5) M10(-101.5,-193.5) M12(-101.5,-189.5) N2(-99.5,-209.5) N4(-99.5,-205.5) N6(-99.5,-201.5) N8(-99.5,-197.5) N10(-99.5,-193.5) N12(-99.5,-189.5) O1(-97.5,-211.5) O3(-97.5,-207.5) O5(-97.5,-203.5) O7(-97.5,-199.5) O9(-97.5,-195.5) O11(-97.5,-191.5) P2(-95.5,-209.5) P4(-95.5,-205.5) P6(-95.5,-201.5) P8(-95.5,-197.5) P10(-95.5,-193.5) P12(-95.5,-189.5) Q1(-93.5,-211.5) Q3(-93.5,-207.5) Q5(-93.5,-203.5) Q7(-93.5,-199.5) Q9(-93.5,-195.5) Q11(-93.5,-191.5) R2(-91.5,-209.5) R4(-91.5,-205.5) R6(-91.5,-201.5) R8(-91.5,-197.5) R10(-91.5,-193.5) R12(-91.5,-189.5) S1(-89.5,-211.5) S3(-89.5,-207.5) S5(-89.5,-203.5) S7(-89.5,-199.5) S9(-89.5,-195.5) S11(-89.5,-191.5) T2(-87.5,-209.5) T4(-87.5,-205.5) T6(-87.5,-201.5) T8(-87.5,-197.5) T10(-87.5,-193.5) T12(-87.5,-189.5) U1(-85.5,-211.5) U3(-85.5,-207.5) U5(-85.5,-203.5) U7(-85.5,-199.5) U9(-85.5,-195.5) U11(-85.5,-191.5) V2(-83.5,-209.5) V4(-83.5,-205.5) V6(-83.5,-201.5) V8(-83.5,-197.5) V10(-83.5,-193.5) V12(-83.5,-189.5) W1(-81.5,-211.5) W3(-81.5,-207.5) W5(-81.5,-203.5) W7(-81.5,-199.5) W9(-81.5,-195.5) W11(-81.5,-191.5) X2(-79.5,-209.5) X4(-79.5,-205.5) X6(-79.5,-201.5) X8(-79.5,-197.5) X10(-79.5,-193.5) X12(-79.5,-189.5) Y1(-77.5,-211.5) Y3(-77.5,-207.5) Y5(-77.5,-203.5) Y7(-77.5,-199.5) Y9(-77.5,-195.5) Y11(-77.5,-191.5) Z2(-75.5,-209.5) Z4(-75.5,-205.5) Z6(-75.5,-201.5) Z8(-75.5,-197.5) Z10(-75.5,-193.5) Z12(-75.5,-189.5)
PG_3680_HDRF3_LPC_P10
  rect 0.864x0.864 hole 0.356: A1(82.5,-211.5) A3(82.5,-207.5) A5(82.5,-203.5) A7(82.5,-199.5) A9(82.5,-195.5) A11(82.5,-191.5) B2(84.5,-209.5) B4(84.5,-205.5) B6(84.5,-201.5) B8(84.5,-197.5) B10(84.5,-193.5) B12(84.5,-189.5) C1(86.5,-211.5) C3(86.5,-207.5) C5(86.5,-203.5) C7(86.5,-199.5) C9(86.5,-195.5) C11(86.5,-191.5) D2(88.5,-209.5) D4(88.5,-205.5) D6(88.5,-201.5) D8(88.5,-197.5) D10(88.5,-193.5) D12(88.5,-189.5) E1(90.5,-211.5) E3(90.5,-207.5) E5(90.5,-203.5) E7(90.5,-199.5) E9(90.5,-195.5) E11(90.5,-191.5) F2(92.5,-209.5) F4(92.5,-205.5) F6(92.5,-201.5) F8(92.5,-197.5) F10(92.5,-193.5) F12(92.5,-189.5) G1(94.5,-211.5) G3(94.5,-207.5) G5(94.5,-203.5) G7(94.5,-199.5) G9(94.5,-195.5) G11(94.5,-191.5) H2(96.5,-209.5) H4(96.5,-205.5) H6(96.5,-201.5) H8(96.5,-197.5) H10(96.5,-193.5) H12(96.5,-189.5) I1(98.5,-211.5) I3(98.5,-207.5) I5(98.5,-203.5) I7(98.5,-199.5) I9(98.5,-195.5) I11(98.5,-191.5) J2(100.5,-209.5) J4(100.5,-205.5) J6(100.5,-201.5) J8(100.5,-197.5) J10(100.5,-193.5) J12(100.5,-189.5) K1(102.5,-211.5) K3(102.5,-207.5) K5(102.5,-203.5) K7(102.5,-199.5) K9(102.5,-195.5) K11(102.5,-191.5) L2(104.5,-209.5) L4(104.5,-205.5) L6(104.5,-201.5) L8(104.5,-197.5) L10(104.5,-193.5) L12(104.5,-189.5) M1(106.5,-211.5) M3(106.5,-207.5) M5(106.5,-203.5) M7(106.5,-199.5) M9(106.5,-195.5) M11(106.5,-191.5) N1(108.5,-211.5) N3(108.5,-207.5) N5(108.5,-203.5) N7(108.5,-199.5) N9(108.5,-195.5) N11(108.5,-191.5) O2(110.5,-209.5) O4(110.5,-205.5) O6(110.5,-201.5) O8(110.5,-197.5) O10(110.5,-193.5) O12(110.5,-189.5) P1(112.5,-211.5) P3(112.5,-207.5) P5(112.5,-203.5) P7(112.5,-199.5) P9(112.5,-195.5) P11(112.5,-191.5) Q2(114.5,-209.5) Q4(114.5,-205.5) Q6(114.5,-201.5) Q8(114.5,-197.5) Q10(114.5,-193.5) Q12(114.5,-189.5) R1(116.5,-211.5) R3(116.5,-207.5) R5(116.5,-203.5) R7(116.5,-199.5) R9(116.5,-195.5) R11(116.5,-191.5) S2(118.5,-209.5) S4(118.5,-205.5) S6(118.5,-201.5) S8(118.5,-197.5) S10(118.5,-193.5) S12(118.5,-189.5) T1(120.5,-211.5) T3(120.5,-207.5) T5(120.5,-203.5) T7(120.5,-199.5) T9(120.5,-195.5) T11(120.5,-191.5) U2(122.5,-209.5) U4(122.5,-205.5) U6(122.5,-201.5) U8(122.5,-197.5) U10(122.5,-193.5) U12(122.5,-189.5) V1(124.5,-211.5) V3(124.5,-207.5) V5(124.5,-203.5) V7(124.5,-199.5) V9(124.5,-195.5) V11(124.5,-191.5) W2(126.5,-209.5) W4(126.5,-205.5) W6(126.5,-201.5) W8(126.5,-197.5) W10(126.5,-193.5) W12(126.5,-189.5) X1(128.5,-211.5) X3(128.5,-207.5) X5(128.5,-203.5) X7(128.5,-199.5) X9(128.5,-195.5) X11(128.5,-191.5) Y2(130.5,-209.5) Y4(130.5,-205.5) Y6(130.5,-201.5) Y8(130.5,-197.5) Y10(130.5,-193.5) Y12(130.5,-189.5) Z1(132.5,-211.5) Z3(132.5,-207.5) Z5(132.5,-203.5) Z7(132.5,-199.5) Z9(132.5,-195.5) Z11(132.5,-191.5)
  round 0.864 hole 0.356: A2(82.5,-209.5) A4(82.5,-205.5) A6(82.5,-201.5) A8(82.5,-197.5) A10(82.5,-193.5) A12(82.5,-189.5) B1(84.5,-211.5) B3(84.5,-207.5) B5(84.5,-203.5) B7(84.5,-199.5) B9(84.5,-195.5) B11(84.5,-191.5) C2(86.5,-209.5) C4(86.5,-205.5) C6(86.5,-201.5) C8(86.5,-197.5) C10(86.5,-193.5) C12(86.5,-189.5) D1(88.5,-211.5) D3(88.5,-207.5) D5(88.5,-203.5) D7(88.5,-199.5) D9(88.5,-195.5) D11(88.5,-191.5) E2(90.5,-209.5) E4(90.5,-205.5) E6(90.5,-201.5) E8(90.5,-197.5) E10(90.5,-193.5) E12(90.5,-189.5) F1(92.5,-211.5) F3(92.5,-207.5) F5(92.5,-203.5) F7(92.5,-199.5) F9(92.5,-195.5) F11(92.5,-191.5) G2(94.5,-209.5) G4(94.5,-205.5) G6(94.5,-201.5) G8(94.5,-197.5) G10(94.5,-193.5) G12(94.5,-189.5) H1(96.5,-211.5) H3(96.5,-207.5) H5(96.5,-203.5) H7(96.5,-199.5) H9(96.5,-195.5) H11(96.5,-191.5) I2(98.5,-209.5) I4(98.5,-205.5) I6(98.5,-201.5) I8(98.5,-197.5) I10(98.5,-193.5) I12(98.5,-189.5) J1(100.5,-211.5) J3(100.5,-207.5) J5(100.5,-203.5) J7(100.5,-199.5) J9(100.5,-195.5) J11(100.5,-191.5) K2(102.5,-209.5) K4(102.5,-205.5) K6(102.5,-201.5) K8(102.5,-197.5) K10(102.5,-193.5) K12(102.5,-189.5) L1(104.5,-211.5) L3(104.5,-207.5) L5(104.5,-203.5) L7(104.5,-199.5) L9(104.5,-195.5) L11(104.5,-191.5) M2(106.5,-209.5) M4(106.5,-205.5) M6(106.5,-201.5) M8(106.5,-197.5) M10(106.5,-193.5) M12(106.5,-189.5) N2(108.5,-209.5) N4(108.5,-205.5) N6(108.5,-201.5) N8(108.5,-197.5) N10(108.5,-193.5) N12(108.5,-189.5) O1(110.5,-211.5) O3(110.5,-207.5) O5(110.5,-203.5) O7(110.5,-199.5) O9(110.5,-195.5) O11(110.5,-191.5) P2(112.5,-209.5) P4(112.5,-205.5) P6(112.5,-201.5) P8(112.5,-197.5) P10(112.5,-193.5) P12(112.5,-189.5) Q1(114.5,-211.5) Q3(114.5,-207.5) Q5(114.5,-203.5) Q7(114.5,-199.5) Q9(114.5,-195.5) Q11(114.5,-191.5) R2(116.5,-209.5) R4(116.5,-205.5) R6(116.5,-201.5) R8(116.5,-197.5) R10(116.5,-193.5) R12(116.5,-189.5) S1(118.5,-211.5) S3(118.5,-207.5) S5(118.5,-203.5) S7(118.5,-199.5) S9(118.5,-195.5) S11(118.5,-191.5) T2(120.5,-209.5) T4(120.5,-205.5) T6(120.5,-201.5) T8(120.5,-197.5) T10(120.5,-193.5) T12(120.5,-189.5) U1(122.5,-211.5) U3(122.5,-207.5) U5(122.5,-203.5) U7(122.5,-199.5) U9(122.5,-195.5) U11(122.5,-191.5) V2(124.5,-209.5) V4(124.5,-205.5) V6(124.5,-201.5) V8(124.5,-197.5) V10(124.5,-193.5) V12(124.5,-189.5) W1(126.5,-211.5) W3(126.5,-207.5) W5(126.5,-203.5) W7(126.5,-199.5) W9(126.5,-195.5) W11(126.5,-191.5) X2(128.5,-209.5) X4(128.5,-205.5) X6(128.5,-201.5) X8(128.5,-197.5) X10(128.5,-193.5) X12(128.5,-189.5) Y1(130.5,-211.5) Y3(130.5,-207.5) Y5(130.5,-203.5) Y7(130.5,-199.5) Y9(130.5,-195.5) Y11(130.5,-191.5) Z2(132.5,-209.5) Z4(132.5,-205.5) Z6(132.5,-201.5) Z8(132.5,-197.5) Z10(132.5,-193.5) Z12(132.5,-189.5)
PG_3680_SYS_P9
  rect 0.864x0.864 hole 0.356: A1(-3.5,-211.5) A6(-3.5,-201.5) A11(-3.5,-191.5) B1(-1.5,-211.5) B6(-1.5,-201.5) B11(-1.5,-191.5) C1(0.5,-211.5) C2(0.5,-209.5) C3(0.5,-207.5) C4(0.5,-205.5) C5(0.5,-203.5) C6(0.5,-201.5) C7(0.5,-199.5) C9(0.5,-195.5) C11(0.5,-191.5) D1(2.5,-211.5) D2(2.5,-209.5) D3(2.5,-207.5) D4(2.5,-205.5) D6(2.5,-201.5) D11(2.5,-191.5) D12(2.5,-189.5) E1(4.5,-211.5) E3(4.5,-207.5) E5(4.5,-203.5) E7(4.5,-199.5) E9(4.5,-195.5) E11(4.5,-191.5) F1(6.5,-211.5) F3(6.5,-207.5) F5(6.5,-203.5) F7(6.5,-199.5) F9(6.5,-195.5) F11(6.5,-191.5) G1(8.5,-211.5) G3(8.5,-207.5) G5(8.5,-203.5) G7(8.5,-199.5) G9(8.5,-195.5) G11(8.5,-191.5) H1(10.5,-211.5) H3(10.5,-207.5) H5(10.5,-203.5) H7(10.5,-199.5) H9(10.5,-195.5) H11(10.5,-191.5)
  round 0.864 hole 0.356: A2(-3.5,-209.5) A3(-3.5,-207.5) A4(-3.5,-205.5) A5(-3.5,-203.5) A7(-3.5,-199.5) A8(-3.5,-197.5) A9(-3.5,-195.5) A10(-3.5,-193.5) A12(-3.5,-189.5) B2(-1.5,-209.5) B3(-1.5,-207.5) B4(-1.5,-205.5) B5(-1.5,-203.5) B7(-1.5,-199.5) B8(-1.5,-197.5) B9(-1.5,-195.5) B10(-1.5,-193.5) B12(-1.5,-189.5) C8(0.5,-197.5) C10(0.5,-193.5) C12(0.5,-189.5) D5(2.5,-203.5) D7(2.5,-199.5) D8(2.5,-197.5) D9(2.5,-195.5) D10(2.5,-193.5) E2(4.5,-209.5) E4(4.5,-205.5) E6(4.5,-201.5) E8(4.5,-197.5) E10(4.5,-193.5) E12(4.5,-189.5) F2(6.5,-209.5) F4(6.5,-205.5) F6(6.5,-201.5) F8(6.5,-197.5) F10(6.5,-193.5) F12(6.5,-189.5) G2(8.5,-209.5) G4(8.5,-205.5) G6(8.5,-201.5) G8(8.5,-197.5) G10(8.5,-193.5) G12(8.5,-189.5) H2(10.5,-209.5) H4(10.5,-205.5) H6(10.5,-201.5) H8(10.5,-197.5) H10(10.5,-193.5) H12(10.5,-189.5)
PROTECTOR_75X35MM
  round 0.508 hole 3.2 unplated: (-33.02,-12.42) (-33.02,12.42) (33.02,-6.32) (33.02,12.42)
R0201
  rect 0.305x0.356 smd: 1(-0.3,0) 2(0.3,0)
R0402
  custom 0.15x0.15 smd: 1(-0.5,0) 2(0.5,0)
R0603
  rect 0.889x0.889 smd: 1(-0.85,0) 2(0.85,0)
RC02W_27MM
  round 1.854 hole 1.346: 1(-11.5,0) 2(11.5,0)
RF_SW_GW2159_6P
  custom 0.037x0.037 smd: 1(-0.463,0.35) 3(-0.463,-0.35) 4(0.463,-0.35) 5(0.463,0) 6(0.463,0.35)
  custom 0.181x0.181 smd: 2(0,0)
RL_NECUA2_12V_V2
  rect 1.626x1.626 hole 1.041: 1(3.6,1.6)
  round 1.626 hole 1.041: 2(0.4,1.6) 3(-1.8,1.6) 4(-4,1.6) 5(-4,-1.6) 6(-1.8,-1.6) 7(0.4,-1.6) 8(3.6,-1.6)
RL_RF303_12V_V2
  round 1.397 hole 1.041: 1(1.493,-2.055) 2(2.416,-0.785) 3(2.416,0.785) 4(1.493,2.055) 6(-1.493,2.055) 7(-2.416,0.785) 8(-2.416,-0.785) 9(-1.493,-2.055)
SC70_5P
  rect 0.406x0.762 smd: 1(-0.65,-0.95) 2(0,-0.95) 3(0.65,-0.95) 4(0.65,0.95) 5(-0.65,0.95)
SK_QFN100P_0P35MM_MJC_L8730A
  round 0.508 hole 1.626 unplated: (-17,17) (-17,-17) (17,17) (17,-17)
  rect 1.2x0.25 smd: 1(-6,4.2) 2(-6,3.85) 3(-6,3.5) 4(-6,3.15) 5(-6,2.8) 6(-6,2.45) 7(-6,2.1) 8(-6,1.75) 9(-6,1.4) 10(-6,1.05) 11(-6,0.7) 12(-6,0.35) 13(-6,0) 14(-6,-0.35) 15(-6,-0.7) 16(-6,-1.05) 17(-6,-1.4) 18(-6,-1.75) 19(-6,-2.1) 20(-6,-2.45) 21(-6,-2.8) 22(-6,-3.15) 23(-6,-3.5) 24(-6,-3.85) 25(-6,-4.2) 51(6,-4.2) 52(6,-3.85) 53(6,-3.5) 54(6,-3.15) 55(6,-2.8) 56(6,-2.45) 57(6,-2.1) 58(6,-1.75) 59(6,-1.4) 60(6,-1.05) 61(6,-0.7) 62(6,-0.35) 63(6,0) 64(6,0.35) 65(6,0.7) 66(6,1.05) 67(6,1.4) 68(6,1.75) 69(6,2.1) 70(6,2.45) 71(6,2.8) 72(6,3.15) 73(6,3.5) 74(6,3.85) 75(6,4.2)
  rect 0.25x1.2 smd: 26(-4.2,-6) 27(-3.85,-6) 28(-3.5,-6) 29(-3.15,-6) 30(-2.8,-6) 31(-2.45,-6) 32(-2.1,-6) 33(-1.75,-6) 34(-1.4,-6) 35(-1.05,-6) 36(-0.7,-6) 37(-0.35,-6) 38(0,-6) 39(0.35,-6) 40(0.7,-6) 41(1.05,-6) 42(1.4,-6) 43(1.75,-6) 44(2.1,-6) 45(2.45,-6) 46(2.8,-6) 47(3.15,-6) 48(3.5,-6) 49(3.85,-6) 50(4.2,-6) 76(4.2,6) 77(3.85,6) 78(3.5,6) 79(3.15,6) 80(2.8,6) 81(2.45,6) 82(2.1,6) 83(1.75,6) 84(1.4,6) 85(1.05,6) 86(0.7,6) 87(0.35,6) 88(0,6) 89(-0.35,6) 90(-0.7,6) 91(-1.05,6) 92(-1.4,6) 93(-1.75,6) 94(-2.1,6) 95(-2.45,6) 96(-2.8,6) 97(-3.15,6) 98(-3.5,6) 99(-3.85,6) 100(-4.2,6)
  rect 7x7 smd: EP(0,0)
  round 0.61 hole 0.305: G1(-3,3) G2(-2,3) G3(-1,3) G4(0,3) G5(1,3) G6(2,3) G7(3,3) G8(-3,2) G9(3,2) G10(-3,1) G11(-1,1) G12(0,1) G13(1,1) G14(3,1) G15(-3,0) G16(-1,0) G17(0,0) G18(1,0) G19(3,0) G20(-3,-1) G21(-1,-1) G22(0,-1) G23(1,-1) G24(3,-1) G25(-3,-2) G26(3,-2) G27(-3,-3) G28(-2,-3) G29(-1,-3) G30(0,-3) G31(1,-3) G32(2,-3) G33(3,-3)
  round 6.096 hole 4.293: NUT1(-12.7,12.7) NUT2(-12.7,-12.7) NUT3(12.7,-12.7) NUT4(12.7,12.7)
SK_SO8_1P27MM_LOTES
  rect 0.508x5.08 smd: 1(-1.91,-5.3) 2(-0.64,-5.3) 3(0.63,-5.3) 4(1.9,-5.3) 5(1.91,5.3) 6(0.64,5.3) 7(-0.63,5.3) 8(-1.9,5.3)
SLOT_NPTH_SQ15X15MM
  round 0.5 hole 15 unplated: (0,0)
  round 0.61 hole 0.305: G1(-8.5,8.5) G2(-7.5,8.5) G3(-6.5,8.5) G4(-5.5,8.5) G5(-4.5,8.5) G6(-3.5,8.5) G7(-2.5,8.5) G8(-1.5,8.5) G9(-0.5,8.5) G10(0.5,8.5) G11(1.5,8.5) G12(2.5,8.5) G13(3.5,8.5) G14(4.5,8.5) G15(5.5,8.5) G16(6.5,8.5) G17(7.5,8.5) G18(8.5,8.5) G19(8.5,7.5) G20(8.5,6.5) G21(8.5,5.5) G22(8.5,4.5) G23(8.5,3.5) G24(8.5,2.5) G25(8.5,1.5) G26(8.5,0.5) G27(8.5,-0.5) G28(8.5,-1.5) G29(8.5,-2.5) G30(8.5,-3.5) G31(8.5,-4.5) G32(8.5,-5.5) G33(8.5,-6.5) G34(8.5,-7.5) G35(8.5,-8.5) G36(7.5,-8.5) G37(6.5,-8.5) G38(5.5,-8.5) G39(4.5,-8.5) G40(3.5,-8.5) G41(2.5,-8.5) G42(1.5,-8.5) G43(0.5,-8.5) G44(-0.5,-8.5) G45(-1.5,-8.5) G46(-2.5,-8.5) G47(-3.5,-8.5) G48(-4.5,-8.5) G49(-5.5,-8.5) G50(-6.5,-8.5) G51(-7.5,-8.5) G52(-8.5,-8.5) G53(-8.5,-7.5) G54(-8.5,-6.5) G55(-8.5,-5.5) G56(-8.5,-4.5) G57(-8.5,-3.5) G58(-8.5,-2.5) G59(-8.5,-1.5) G60(-8.5,-0.5) G61(-8.5,0.5) G62(-8.5,1.5) G63(-8.5,2.5) G64(-8.5,3.5) G65(-8.5,4.5) G66(-8.5,5.5) G67(-8.5,6.5) G68(-8.5,7.5)
SO8_206X127MM
  rect 1.905x1.143 smd: 1(-2.616,2.095) 4(-2.616,-2.095) 5(2.616,-2.095) 8(2.616,2.095)
  rect 1.905x0.762 smd: 2(-2.616,0.635) 3(-2.616,-0.635) 6(2.616,-0.635) 7(2.616,0.635)
SO8_206X127MM_G
  rect 1.905x1.143 smd: 1(-2.616,2.095) 4(-2.616,-2.095) 5(2.616,-2.095) 8(2.616,2.095)
  rect 1.905x0.762 smd: 2(-2.616,0.635) 3(-2.616,-0.635) 6(2.616,-0.635) 7(2.616,0.635)
  rect 2.413x3.302 smd: G1(0,0)
SOCKET_CODE
  round 0.051 smd: 1(0,0)
SW_5P_UTP0030B
  rect 3.556x3.556 hole 1.905: 1(-4.7,0)
  round 3.556 hole 1.905: 2(0,0) 3(4.7,0) 4(-6.605,9.53) 5(6.605,9.53)
SW_DIPX4P_2P54MM_ETD
  round 1.626 hole 1.041: 1(-3.81,3.81) 2(-1.27,3.81) 3(1.27,3.81) 4(3.81,3.81) 5(3.81,-3.81) 6(-3.81,-3.81)
SW_DIPX8_16P_H5MM
  rect 1.626x1.626 hole 1.041: 1(-8.89,-3.81)
  round 1.626 hole 1.041: 2(-6.35,-3.81) 3(-3.81,-3.81) 4(-1.27,-3.81) 5(1.27,-3.81) 6(3.81,-3.81) 7(6.35,-3.81) 8(8.89,-3.81) 9(8.89,3.81) 10(6.35,3.81) 11(3.81,3.81) 12(1.27,3.81) 13(-1.27,3.81) 14(-3.81,3.81) 15(-6.35,3.81) 16(-8.89,3.81)
