# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VDD5_ATX: length 10
  BOTTOM w0.254: CB641.1 v2(34.78,391.8)
  BOTTOM w0.277: v2(205.73,105.76) 204.66,105.76 CB657.2 204.46,105.12 v2(205.1,104.48) ; v2(470.36,105.76) 469.29,105.76 CB702.2 469.09,105.12 v2(469.73,104.48) ; v2(333.98,105.76) 332.91,105.76 CB672.2 332.71,105.12 v2(333.34,104.48)
  vias: v2(30.2,386.09) v2(30.2,382.91) v2(34.17,385.07) v2(34.17,383.29) v2(34.77,389.26)
VDD12_ATX: length 0.7
  BOTTOM w0.254: CB647.1 v2(33.19,374.02)
  vias: v2(30.2,367.04) v2(30.2,363.86) v2(33.92,371.74) v2(33.92,369.96) v2(34.17,366.02) v2(34.17,364.24)
VDD33_ATX: length 0.7
  BOTTOM w0.254: CB634.1 v2(22.81,339.1)
  vias: v2(26.52,339.1) v2(27.19,345.07) v2(27.19,343.29)
CAL_SPI_CK0: length 20.7
  BOTTOM w0.277: v2(369.92,148.82) 369.3,149.44 U8.4 ; v2(369.92,118.34) 369.3,118.96 U16.4 ; v2(354.68,118.34) 354.06,118.96 U15.4 ; U10.4 338.82,134.2 v2(339.44,133.58) ; v2(354.68,148.82) 354.06,149.44 U6.4 ; U13.4 323.58,118.96 v2(324.2,118.34) ; U11.4 369.3,134.2 v2(369.92,133.58) ; U9.4 354.06,134.2 v2(354.68,133.58) ; v2(339.44,118.34) 338.82,118.96 U14.4 ; v2(324.2,148.82) 323.58,149.44 U7.4 ; U5.4 338.82,149.44 v2(339.44,148.82) ; U12.4 323.58,134.2 v2(324.2,133.58)
CAL_SPI_DIN0: length 1.5
  BOTTOM w0.277: U7.3 v2(324.2,150.09)
CAL_SPI_DO0: length 2
  BOTTOM w0.277: v2(369.92,117.07) 368.68,118.31 U16.5
CAL_SPI_SL0: length 20.7
  BOTTOM w0.277: v2(369.92,136.12) 369.3,135.5 U11.2 ; v2(324.2,151.36) 323.58,150.74 U7.2 ; U9.2 354.06,135.5 v2(354.68,136.12) ; v2(369.92,151.36) 369.3,150.74 U8.2 ; U13.2 323.58,120.26 v2(324.2,120.88) ; U14.2 338.82,120.26 v2(339.44,120.88) ; v2(339.44,151.36) 338.82,150.74 U5.2 ; U12.2 323.58,135.5 v2(324.2,136.12) ; v2(339.44,136.12) 338.82,135.5 U10.2 ; v2(369.92,120.88) 369.3,120.26 U16.2 ; v2(354.68,120.88) 354.06,120.26 U15.2 ; v2(354.68,151.36) 354.06,150.74 U6.2
DPS_GND:
  vias: v2(154.91,395.12) v2(157.57,69.7) v2(165.07,395.12) v2(167.73,69.7) v2(372.25,395.12) v2(382.41,395.12) v2(392.57,395.12) v2(402.73,395.12) v2(536.62,395.12) v2(536.87,69.7) v2(546.78,395.12) v2(547.03,69.7)
IDCE1:
  vias: v2(380.94,74.26)
IDDI:
  vias: v2(375.71,70.07)
IDDO:
  vias: v2(380.94,72.8)
IDSK:
  vias: v2(375.71,71.53)
LB_GND: length 84.5
  BOTTOM w0.356: v2(321.66,115.8) 321.04,116.42 U13.7 ; v2(336.9,146.28) 336.28,146.9 U5.7 ; v2(321.66,131.04) 321.04,131.66 U12.7 ; U14.13 v2(331.82,119.61) ; U10.10 334.33,132.28 v2(333.09,131.04) ; U11.10 364.81,132.28 v2(363.57,131.04) ; U8.10 364.81,147.52 v2(363.57,146.28) ; U8.7 366.76,146.9 v2(367.38,146.28) ; U12.13 v2(316.58,134.85) ; U6.7 351.52,146.9 v2(352.14,146.28) ; U13.10 319.09,117.04 v2(317.85,115.8) ; v2(333.09,153.9) 334.33,152.66 U5.16 ; U16.13 v2(362.3,119.61) ; U10.13 v2(331.82,134.85) ; v2(352.14,115.8) 351.52,116.42 U15.7 ; U14.10 334.33,117.04 v2(333.09,115.8) ; v2(348.33,153.9) 349.57,152.66 U6.16 ; v2(363.57,123.42) 364.81,122.18 U16.16 ; v2(348.33,115.8) 349.57,117.04 U15.10 ; v2(363.57,115.8) 364.81,117.04 U16.10 ; v2(317.85,138.66) 319.09,137.42 U12.16 ; U14.16 334.33,122.18 v2(333.09,123.42) ; v2(317.85,123.42) 319.09,122.18 U13.16 ; v2(348.33,146.28) 349.57,147.52 U6.10 ; U7.13 v2(316.58,150.09) ; v2(336.9,115.8) 336.28,116.42 U14.7 ; U13.13 v2(316.58,119.61) ; U12.10 319.09,132.28 v2(317.85,131.04) ; U5.10 334.33,147.52 v2(333.09,146.28) ; v2(336.9,131.04) 336.28,131.66 U10.7 ; U15.16 349.57,122.18 v2(348.33,123.42) ; U11.16 364.81,137.42 v2(363.57,138.66) ; v2(352.14,131.04) 351.52,131.66 U9.7 ; v2(367.38,131.04) 366.76,131.66 U11.7 ; U9.13 v2(347.06,134.85) ; v2(321.66,146.28) 321.04,146.9 U7.7 ; v2(333.09,138.66) 334.33,137.42 U10.16 ; U9.16 349.57,137.42 v2(348.33,138.66) ; U7.16 319.09,152.66 v2(317.85,153.9) ; v2(363.57,153.9) 364.81,152.66 U8.16 ; U16.7 366.76,116.42 v2(367.38,115.8) ; U15.13 v2(347.06,119.61) ; U8.13 v2(362.3,150.09) ; v2(317.85,146.28) 319.09,147.52 U7.10 ; v2(348.33,131.04) 349.57,132.28 U9.10 ; U6.13 v2(347.06,150.09) ; U11.13 v2(362.3,134.85)
  vias: v2(262.04,74.07) v2(273.09,69.87) v2(273.39,73.23) v2(298.97,146.56) v2(298.97,139.6) v2(298.97,132.87) v2(298.97,124.94) v2(319.12,151.36) v2(319.12,148.82) v2(319.12,136.12) v2(319.12,133.58) v2(319.12,120.88) v2(319.12,118.34) v2(319.37,70.87) v2(319.54,142.47) v2(319.54,127.23) v2(320.39,150.09) v2(320.39,134.85) v2(320.39,119.61) v2(321.66,151.36) v2(321.66,148.82) v2(321.66,136.12) v2(321.66,133.58) v2(321.66,120.88) v2(321.66,118.34) v2(322.36,73.07) v2(322.66,69.17) v2(334.36,151.36) v2(334.36,148.82) v2(334.36,136.12) v2(334.36,133.58) v2(334.36,120.88) v2(334.36,118.34) v2(334.78,142.47) v2(334.78,127.23) v2(335.63,150.09) v2(335.63,134.85) v2(335.63,119.61) v2(335.89,73.46) v2(336.46,69.49) v2(336.9,151.36) v2(336.9,148.82) v2(336.9,136.12) v2(336.9,133.58) v2(336.9,120.88) v2(336.9,118.34) v2(340.71,69.91) v2(345.84,70.46) v2(346.14,73.07) v2(349.6,151.36) v2(349.6,148.82) v2(349.6,136.12) v2(349.6,133.58) v2(349.6,120.88) v2(349.6,118.34) v2(350.02,142.47) v2(350.02,127.23) v2(350.33,69.04) v2(350.87,150.09) v2(350.87,134.85) v2(350.87,119.61) v2(352.14,151.36) v2(352.14,148.82) v2(352.14,136.12) v2(352.14,133.58) v2(352.14,120.88) v2(352.14,118.34) v2(353.74,69.49) v2(354.31,73.46) v2(363.65,76.38) v2(363.83,69.49) v2(364.4,73.46) v2(364.84,151.36) v2(364.84,148.82) v2(364.84,136.12) v2(364.84,133.58) v2(364.84,120.88) v2(364.84,118.34) v2(365.26,142.47) v2(365.26,127.23) v2(366.11,150.09) v2(366.11,134.85) v2(366.11,119.61) v2(367.38,151.36) v2(367.38,148.82) v2(367.38,136.12) v2(367.38,133.58) v2(367.38,120.88) v2(367.38,118.34) v2(375.83,146.76) v2(375.83,138.84) v2(375.83,132.1) v2(375.83,125.15) v2(380.94,70.07) v2(389.42,73.91)
S0_1_AOUT_LN: length 4.6
  BOTTOM w0.152: R67.1 R68.1 R45.1 226.13,175.86 K10.4
S0_1_AOUT_LP: length 4.6
  BOTTOM w0.152: K10.5 226.13,179.28 R75.1 R69.1 R70.1
S0_1_AOUT_RN: length 4.6
  BOTTOM w0.152: K14.4 226.13,168.6 R47.1 R64.1 R63.1
S0_1_AOUT_RP: length 4.6
  BOTTOM w0.152: K14.5 226.13,172.02 R74.1 R65.1 R66.1
S0_1_SPI_CLK: length 6.2
  BOTTOM w0.277: U3.6 241.04,187.93 240.35,188.62 239.55,188.62 v2(238.41,189.76)
S0_1_SPI_CS: length 3.2
  BOTTOM w0.277: U3.1 v2(243.59,171.34)
S0_1_SPI_DATA0: length 6.1
  BOTTOM w0.277: U3.5 239.77,187.7 239.49,187.98 238.91,187.98 v2(237.14,189.76)
S0_1_SPI_DATA1: length 3.2
  BOTTOM w0.277: U3.2 v2(242.32,171.34)
S0_1_SPI_DATA2: length 5.6
  TOP w0.277: R18.2 R16.2 v2(241.05,171.34)
  BOTTOM w0.277: v2(241.05,171.34) U3.3
S0_1_SPI_DATA3: length 6.5
  TOP w0.277: R12.1 v2(240.95,189.76)
  BOTTOM w0.277: U3.7 242.31,187.82 240.95,189.19 v2(240.95,189.76)
S0_1_VDD09:
  vias: v1(263.96,197.09) v1(281.19,215.76) v1(284.32,215.77) v1(290.14,215.76) v1(291.21,215.76) v1(297.43,212.38) v1(297.43,210.27) v1(298.6,212.38) v1(301.67,201.38)
S0_1_VDD18_A: length 6.5
  TOP w0.61: K26.2 307.74,175.14 303.91,175.14 R50.1
S0_1_VDD18_D:
  vias: v1(301.67,206.84) v1(301.67,204.64) v1(301.67,203.52) v1(302.96,206.84) v2(287.84,233.09)
S0_2_AOUT_LN:
  vias: v2(222.84,176.86)
S0_2_AOUT_LP:
  vias: v2(222.84,178.28)
S0_2_AOUT_RN:
  vias: v2(222.84,169.6)
S0_2_AOUT_RP:
  vias: v2(222.84,171.02)
S0_2_VDD18_A: length 0.9
  BOTTOM w0.508: BD20.1 v1(275.79,206.99)
  vias: v1(274.76,206.99) v1(284.37,201.66) v1(284.37,200.62) v1(296.19,196.37) v2(303.65,173.88)
S0_ATX_VD0V9:
  vias: v2(243.7,197.1) v2(243.7,195.32)
S0_ATX_VD33: length 0.9
  BOTTOM w0.254: BD33.1 v2(279.76,87.35)
  vias: v2(282.56,88.62) v2(282.56,86.06) v2(282.56,83.49)
S0_AVCC_DRV: length 6.1
  TOP w0.249: SITE0.53 295.06,201.5 295.89,200.67
  TOP w0.381: C110.1 298.86,200.25 298.48,199.86 296.82,199.86 296.44,200.24 C75.1 295.89,200.67
  vias: v1(299.06,200.67) v2(276.15,234.23)
S0_CHIP_EN_1: length 2
  BOTTOM w0.277: R34.2 SW5.1
S0_DPS_F001:
  vias: v2(253.52,168.2) v2(253.52,166.42)
S0_DPS_F002:
  vias: v2(311.45,171.07) v2(312.94,168.65) v2(312.94,166.87)
S0_DPS_F004:
  vias: v2(261.74,171.71) v2(263.52,171.71)
S0_DPS_F006:
  vias: v2(296.84,174.69) v2(296.84,173.67) v2(296.84,172.12) v2(296.84,171.11) v2(296.84,169.53) v2(296.84,168.51)
S0_GPIO5_CH: length 5.2
  TOP w0.249: 295.93,205.51 295.39,206.05 SITE0.66
  TOP w0.277: 295.93,205.51 298.41,205.51 v1(299.06,206.16)
S0_HSDM: length 3.1
  TOP w0.249: SITE0.79 291.45,212.22
  TOP w0.305: v1(292.94,213.16) 292.39,213.16 291.45,212.22
S0_HSDP: length 2.1
  TOP w0.249: 291.92,211.89 291.8,211.77 SITE0.78
  TOP w0.305: 291.92,211.89 292.17,212.14 v1(292.94,212.14)
S0_LPC_024: length 3.4
  TOP w0.249: 295.28,207.32 295.06,207.1 SITE0.69
  TOP w0.277: 295.28,207.32 v1(295.49,207.53)
  BOTTOM w0.277: R35.1 J4.2
S0_LPC_025: length 3.5
  TOP w0.249: SITE0.71 293.51,207.8 293.26,208.05
  TOP w0.277: v1(293.05,208.25) 293.26,208.05 293.26,208.05
  BOTTOM w0.277: R34.1 J4.1
S0_LPC_041: length 5.7
  TOP w0.249: SITE0.68 296.66,206.75
  TOP w0.277: 296.66,206.75 297.1,206.75 v1(297.69,206.16)
  BOTTOM w0.277: R36.1 J4.3
S0_LPC_042: length 0.9
  TOP w0.249: SITE0.50 292.5,199.17 292.68,199.35
  TOP w0.277: 292.68,199.35 v1(293.2,199.35)
S0_LPC_044: length 3.9
  TOP w0.249: SITE0.58 293.46,203.25
  TOP w0.277: v1(292.55,202.94) 293.15,202.94 293.46,203.25
  BOTTOM w0.277: R39.1 J4.5
S0_LPC_046: length 2.1
  TOP w0.249: SITE0.67 296.07,206.4 296.18,206.3
  TOP w0.277: 296.18,206.3 v1(296.31,206.16)
S0_LPC_047: length 3.5
  TOP w0.249: SITE0.18 283.44,203.25
  TOP w0.277: 283.44,203.25 v1(283.64,203.46)
  BOTTOM w0.277: R41.1 J4.7
S0_LPC_049: length 5.2
  TOP w0.249: SITE0.8 281.07,206.75
  TOP w0.277: 281.07,206.75 280.58,207.24 278.14,207.24 v1(277.58,206.68)
S0_LPC_050: length 2.4
  TOP w0.249: SITE0.7 281.46,207.1 281.07,207.49
  TOP w0.277: 281.07,207.49 280.76,207.8 v1(280.2,207.8)
S0_LPC_051: length 2
  TOP w0.249: 292.36,199.94 292.15,199.73 SITE0.49
  TOP w0.277: v1(293.2,200.2) 292.63,200.2 292.36,199.94
S0_LPC_052: length 2.4
  TOP w0.249: 291.95,198 291.8,198.15 SITE0.48
  TOP w0.277: v1(293.2,197.97) 293.06,197.84 292.12,197.84 291.95,198
S0_LPC_053: length 7.2
  TOP w0.249: SITE0.57 295.46,202.9 295.69,202.68
  TOP w0.277: 295.69,202.68 298.32,202.68 v1(299.06,203.42)
  BOTTOM w0.277: R37.1 J4.4
S0_LPC_055: length 2.4
  TOP w0.249: SITE0.10 280.83,206.05
  TOP w0.277: 280.83,206.05 v1(280.2,206.68)
S0_LPC_058: length 4.4
  TOP w0.249: SITE0.17 283.06,203.6 283.31,203.85
  TOP w0.277: 283.31,203.85 283.47,204.01 284.19,204.01 v1(284.37,203.83)
  BOTTOM w0.277: R40.1 J4.6
S0_LX_AUD: length 6.2
  TOP w0.249: 283.79,211 SITE0.100
  TOP w0.864: 283.47,211 283.79,211
  TOP w1.016: 283.33,215.38 281.99,214.04 281.99,212.48 283.47,211
S0_LX_DCORE: length 2.2
  TOP w0.249: SITE0.3 280.97,208.5
  TOP w0.508: v1(280.2,208.63) v1(280.74,208.63) 280.85,208.63 280.97,208.5
S0_LX_MEM: length 1.9
  TOP w0.249: 295.1,209.46 294.84,209.2 SITE0.75
  TOP w0.508: 295.1,209.46 v1(295.1,209.85) v1(295.1,210.48)
S0_MIPITX_CKN: length 1.3
  TOP w0.249: 290.52,211.89 290.4,211.77 SITE0.82
  TOP w0.277: 290.52,211.89 v1(290.77,212.14)
S0_MIPITX_CKP: length 2.8
  TOP w0.249: SITE0.83 290.05,212.11
  TOP w0.277: 290.05,212.11 290.05,212.79 v1(290.77,213.51)
S0_MIPITX_DATAN_0: length 1.2
  TOP w0.249: SITE0.85 289.35,212.09
  TOP w0.277: 289.35,212.09 v1(289.4,212.14)
S0_MIPITX_DATAN_1: length 2.3
  TOP w0.249: SITE0.80 291.1,210.21 291.28,210.03
  TOP w0.277: v1(290.83,208.99) 291.28,209.44 291.28,210.03
S0_MIPITX_DATAP_0: length 2.8
  TOP w0.249: 288.83,212.19 288.83,211.93 289,211.75 SITE0.86
  TOP w0.277: v1(289.4,213.51) 288.83,212.94 288.83,212.19
S0_MIPITX_DATAP_1: length 1.2
  TOP w0.249: SITE0.81 290.75,210.04 290.68,209.97
  TOP w0.277: 290.68,209.97 v1(290.58,209.86)
S0_PA2: length 2.1
  TOP w0.249: SITE0.5 284.09,207.8
  TOP w0.277: 284.09,207.8 v1(284.34,207.55)
S0_PA3: length 1.4
  TOP w0.249: 283.44,207.35 283.34,207.45 SITE0.6
  TOP w0.277: 283.44,207.35 v1(283.61,207.17)
S0_PA9_CH: length 4
  TOP w0.249: SITE0.12 280.85,205.35 280.67,205.52
  TOP w0.277: 280.67,205.52 280.53,205.66 279.85,205.66 v1(278.83,206.68)
S0_PA10_CH: length 2.1
  TOP w0.249: SITE0.13 280.27,205
  TOP w0.277: 280.27,205 v1(280.2,204.93)
S0_PA13: length 3.7
  TOP w0.249: 279.82,204.5 280.02,204.3 SITE0.15
  TOP w0.277: 279.82,204.5 279.39,204.93 v1(278.83,204.93)
S0_PA13_UART_RX: length 14
  BOTTOM w0.305: K6.2 281.96,97.99 281.96,94.21 R27.1
S0_PA13_UART_RX_1: length 2.1
  BOTTOM w0.305: R27.2 273.29,88.62 J2.3
S0_PA14: length 5.3
  TOP w0.249: SITE0.16 279.61,203.95 279.21,204.34
  TOP w0.277: 279.21,204.34 278.45,204.34 277.86,204.93 v1(277.46,204.93)
S0_PA14_UART_TX: length 10.1
  BOTTOM w0.305: R28.1 278.48,93.27 278.48,97.71 K6.7
S0_PA14_UART_TX_1: length 2.1
  BOTTOM w0.305: J2.4 273.29,91.16 R28.2
S0_PA15_1: length 2
  BOTTOM w0.277: R40.2 SW5.6
S0_PA16_1: length 2
  BOTTOM w0.277: R41.2 SW5.7
S0_PA20: length 2.2
  TOP w0.152: SITE0.45 290.75,199.93 291.02,200.2 291.02,200.94 v1(291.15,201.07)
S0_PA21: length 1.6
  TOP w0.152: v1(291.58,200.41) 291.58,200.23 291.1,199.75 SITE0.46
S0_PA22: length 2.2
  TOP w0.152: v1(290.01,201.07) 289.86,200.91 289.86,199.9 290.05,199.7 SITE0.43
S0_PA23: length 1.4
  TOP w0.152: v1(290.44,200.41) 290.4,200.37 SITE0.44
S0_PA24: length 1.2
  TOP w0.152: v1(289.06,197.95) 289.35,198.25 SITE0.41
S0_PA25: length 1.2
  TOP w0.152: SITE0.42 289.7,198.25 v1(290,197.95)
S0_PA28: length 2.2
  TOP w0.152: SITE0.39 288.65,200.85 v1(288.87,201.07)
S0_PA29: length 1.5
  TOP w0.152: SITE0.40 289,200.11 v1(289.3,200.41)
S0_PB3: length 2.2
  TOP w0.152: SITE0.52 293.55,201.15 293.29,201.41 v1(292.25,201.41)
S0_PB3_AOUT_LP_2:
  vias: v2(221.67,178.28)
S0_PB4: length 1.4
  TOP w0.152: SITE0.51 v1(292.88,200.8)
S0_PB4_AOUT_LN_2:
  vias: v2(221.67,176.86)
S0_PB5: length 3.8
  TOP w0.152: SITE0.54 295.44,201.85 295.89,201.4 297.04,201.4 v1(297.69,202.05)
S0_PB5_AOUT_RP_2:
  vias: v2(221.67,171.02)
S0_PB6: length 2.1
  TOP w0.152: SITE0.55 296.16,202.2 v1(296.31,202.05)
S0_PB6_AOUT_RN_2:
  vias: v2(221.67,169.6)
S0_PB10_1: length 2
  BOTTOM w0.277: R37.2 SW5.4
S0_PB11_1: length 2
  BOTTOM w0.277: R39.2 SW5.5
S0_PB21_1: length 2
  BOTTOM w0.277: R36.2 SW5.3
S0_PB22_1: length 2
  BOTTOM w0.277: R35.2 SW5.2
S0_PB23: length 4.3
  TOP w0.249: 296.01,207.83 295.7,208.15 SITE0.72
  TOP w0.277: 296.01,207.83 v1(296.31,207.53)
  BOTTOM w0.277: R57.1 K4.3
S0_PB23_1:
  vias: v2(203.61,190.98)
S0_PB23_SICK:
  vias: v2(197.47,196.65)
S0_PB23_SICK_1: length 1.9
  BOTTOM w0.277: J1.3 R20.2
S0_PB24: length 4.2
  TOP w0.249: SITE0.73 295.91,208.5 296.09,208.68
  TOP w0.277: 296.09,208.68 v1(296.31,208.9)
  BOTTOM w0.277: K4.6 R58.1
S0_PB24_1:
  vias: v2(203.61,198.24)
S0_PB24_SIDD:
  vias: v2(197.47,199.19)
S0_PB24_SIDD_1: length 1.9
  BOTTOM w0.277: J1.4 R21.2
S0_PB25: length 4.7
  TOP w0.249: SITE0.96 285.5,212.17
  TOP w0.277: 285.5,212.17 285.5,213.04 v1(285.03,213.51)
  BOTTOM w0.277: K8.3 R59.1
S0_PB25_1:
  vias: v2(203.61,182.57)
S0_PB25_I2C_SCL:
  vias: v2(191.24,196.65)
S0_PB25_I2C_SCL_1: length 1.9
  BOTTOM w0.277: J3.3 R31.2
S0_PB26: length 4.1
  TOP w0.249: 284.95,209.63 284.95,210.01 285.15,210.2 SITE0.97
  TOP w0.277: 284.95,209.63 v1(284.95,208.97)
  BOTTOM w0.277: K8.6 R60.1
S0_PB26_1:
  vias: v2(203.61,189.84)
S0_PB26_I2C_SDA:
  vias: v2(191.24,199.19)
S0_PB26_I2C_SDA_1: length 1.9
  BOTTOM w0.277: J3.4 R32.2
S0_RF_A: length 2.9
  TOP w0.277: SMP3.1 C15.1 D3.1 C13.1
S0_RF_G: length 5.9
  TOP w0.277: SMP2.1 C8.1 D2.1 C7.1
S0_RFIN_A: length 3.5
  TOP w0.249: SITE0.29 285.15,198.14 arc(285.2,197.91) v1(285.33,197.71)
  BOTTOM w0.277: R9.1 C16.2 284.8,196.44 arc(284.94,197.13) v1(285.33,197.71)
S0_RFIN_G: length 4.2
  TOP w0.249: SITE0.31 v1(285.85,197.18)
  BOTTOM w0.277: v1(285.85,197.18) 286.05,196.98 arc(286.44,196.4) C9.2 R5.1
S0_RFIO_A: length 3.3
  TOP w0.249: 284.8,197.46 SITE0.28
  TOP w0.277: R6.1 C11.2 284.8,197.46
S0_RFIO_BT: length 3.5
  TOP w0.249: SITE0.37 287.95,198.35 arc(287.98,198.21) 288.06,198.09
  TOP w0.277: 288.06,198.09 289.37,196.77 R1.1
S0_RFIO_G: length 4.1
  TOP w0.249: SITE0.32 286.2,198.25 arc(286.24,197.84) 286.36,197.46
  TOP w0.277: R2.1 C4.2 286.78,196.85 arc(286.54,197.13) 286.36,197.46
S0_RREF_MEM: length 7.2
  TOP w0.249: 295.42,204.16 295.21,203.95 SITE0.60
  TOP w0.277: 295.42,204.16 298.43,204.16 300.01,205.74 v1(300.73,205.74)
S0_SPI_CLK:
  vias: v2(238.41,190.76)
S0_SPI_CLK/PB28: length 4.3
  TOP w0.249: SITE0.90 287.6,212.64 287.47,212.78
  TOP w0.277: v1(287.77,214.77) 287.77,214.5 287.09,213.82 287.09,213.16 287.47,212.78
S0_SPI_CS:
  vias: v2(243.59,170.34)
S0_SPI_CS/PC0: length 1.3
  TOP w0.249: 285.75,209.92 285.85,210.03 SITE0.95
  TOP w0.277: 285.75,209.92 v1(285.65,209.83)
S0_SPI_D0/PB29: length 2.9
  TOP w0.249: 287.15,212.33 287.25,212.23 SITE0.91
  TOP w0.277: v1(286.4,213.51) 286.4,213.08 287.15,212.33
S0_SPI_D1/PB31: length 2.2
  TOP w0.249: SITE0.94 286.2,209.65
  TOP w0.277: 286.2,209.65 286.2,209.26 v1(285.9,208.96)
S0_SPI_D2/PB30: length 1.5
  TOP w0.249: 286.79,211.93 286.9,211.82 SITE0.92
  TOP w0.277: 286.79,211.93 286.58,212.14 v1(286.4,212.14)
S0_SPI_D3/PB27: length 2.6
  TOP w0.249: SITE0.89 287.95,212.9
  TOP w0.277: 287.95,212.9 287.95,213.33 v1(287.77,213.51)
S0_SPI_DATA0:
  vias: v2(237.14,190.76)
S0_SPI_DATA1:
  vias: v2(242.32,170.34)
S0_SPI_DATA2:
  vias: v2(239.78,170.34)
S0_SPI_DATA3:
  vias: v2(240.95,190.76)
S0_U1_VC1: length 0.7
  TOP w0.152: U1.4 288.47,191.43
  TOP w0.277: 288.47,191.43 v1(287.84,191.43)
S0_U2_VC1: length 0.7
  TOP w0.152: U2.4 286.16,187.42
  TOP w0.277: 286.16,187.42 v1(285.53,187.42)
S0_VA09_MIPI: length 1.2
  TOP w0.249: SITE0.84 289.7,210.24
  TOP w0.254: 289.7,210.24 289.7,209.87
  TOP w0.381: 289.7,209.87 v1(289.67,209.84)
  vias: v1(291.21,214.77)
S0_VA09_PLL: length 1.3
  TOP w0.249: SITE0.11 283.3,205.7
  TOP w0.381: 283.3,205.7 v1(283.5,205.5)
  vias: v1(281.19,214.77)
S0_VA09_USB: length 1.3
  TOP w0.249: SITE0.77 292.15,210.09
  TOP w0.381: 292.15,210.09 v1(292.41,209.84)
  vias: v1(296.31,212.38)
S0_VA13_AFE: length 2.3
  TOP w0.249: 280.89,203.4 281.39,202.9 SITE0.19
  TOP w0.381: 280.89,203.4 v1(280.2,203.4)
  vias: v1(275.79,205.15)
S0_VA13_SYN: length 2.2
  TOP w0.249: SITE0.23 280.4,201.5 280.29,201.39
  TOP w0.381: 280.29,201.39 v1(280.2,201.29)
  vias: v1(283.33,201.66)
S0_VA33_SYN: length 5.9
  TOP w0.249: 280.53,200.61 281.08,201.15 SITE0.24
  TOP w0.381: 280.53,200.61 v1(280.2,200.61)
  BOTTOM w0.381: 280.02,200.61 v1(280.2,200.61)
  BOTTOM w0.508: 280.02,200.61 279.51,200.1 279.51,199.38 278.95,198.82 BD13.2
S0_VA33_XTAL: length 7.1
  TOP w0.249: 280.74,202.74 280.93,202.55 SITE0.20
  TOP w0.381: 280.74,202.74 v1(280.2,202.74)
  BOTTOM w0.381: 279.83,202.74 v1(280.2,202.74)
  BOTTOM w0.508: BD5.2 279.15,205.67 279.51,205.32 279.51,203.06 279.83,202.74
S0_VD09_CORE1: length 1.4
  TOP w0.249: SITE0.56 293.42,202.55 v1(293.06,202.19)
  vias: v1(300.73,201.38)
S0_VD09_CORE2: length 1.6
  TOP w0.249: 293.25,205.5 293.39,205.35 SITE0.64
  TOP w0.381: 293.25,205.5 293.06,205.68 v1(293.06,205.91)
  vias: v1(296.31,210.27)
S0_VD09_CORE3: length 1.2
  TOP w0.249: 288.71,209.95 288.65,210.01 SITE0.87
  TOP w0.381: 288.71,209.95 v1(288.82,209.84)
  vias: v1(290.14,214.77)
S0_VD09_CORE4: length 4.7
  TOP w0.249: SITE0.98 284.8,212.02
  TOP w0.508: 284.8,212.02 284.8,212.37 v1(283.66,213.51)
  BOTTOM w0.508: R79.2 284.6,214.35 283.76,213.51 v1(283.66,213.51)
S0_VD13_FE: length 1.5
  TOP w0.249: SITE0.36 287.6,200.12 287.43,200.29
  TOP w0.381: 287.43,200.29 v1(287.36,200.36)
  vias: v1(295.25,196.37)
S0_VD13_RF: length 2.5
  TOP w0.249: SITE0.25 281.44,200.8 280.56,199.92
  TOP w0.381: 280.56,199.92 v1(280.2,199.92)
  vias: v1(283.33,200.62)
S0_VD33_ALL: length 0.8
  BOTTOM w0.508: BD5.1 276.67,205.49 v1(276.67,204.93)
  vias: v1(273.79,198.83) v1(274.76,205.15) v1(274.85,198.83) v1(276.81,208.92) v1(276.89,198.83) v1(277.29,211.59) v1(280.01,195.04) v1(280.15,215.76) v1(281.83,193.44) v1(282.24,215.76) v1(282.77,191.38) v1(286.81,215.76) v1(289.07,215.76) v1(294.32,214.77) v1(296.19,197.57) v1(296.19,194.23) v1(297.32,198.66) v1(297.32,197.57) v1(297.43,211.34) v1(298.6,211.34) v1(301.67,202.45) v2(246.28,190.76)
S0_VD33_CM_BT: length 1
  TOP w0.249: SITE0.35 287.25,198.12
  TOP w0.381: 287.25,198.12 v1(287.25,198.01)
  vias: v1(295.25,195.29) v1(295.25,194.23)
S0_VD33_EX_FLASH: length 9
  TOP w0.508: BD32.2 246.22,189.76 v2(245.01,189.76) v2(243.74,189.76) v2(242.46,189.76)
  BOTTOM w0.508: v2(242.46,189.76) 242.46,189.23 243.58,188.1 U3.8
  vias: v2(239.68,190.76) v2(241.05,170.34) v2(246.28,189.76)
S0_VD33_IO0: length 10.2
  TOP w0.249: SITE0.9 283.45,206.4
  TOP w0.381: 283.45,206.4 v1(283.5,206.35)
  BOTTOM w0.508: BD7.2 282.24,212.95 282.92,212.27 282.92,206.93 v1(283.5,206.35)
S0_VD33_IO2: length 7.2
  TOP w0.249: SITE0.59 295.63,203.6 295.81,203.42
  TOP w0.381: 295.81,203.42 v1(296.31,203.42)
  BOTTOM w0.381: 296.31,202.99 v1(296.31,203.42)
  BOTTOM w0.508: BD9.2 298.53,202.45 298.25,202.73 296.57,202.73 296.31,202.99
S0_VD33_IO3: length 7.8
  TOP w0.249: SITE0.70 293.1,207.45
  TOP w0.381: 293.1,207.45 v1(293.05,207.4)
  BOTTOM w0.508: v1(293.05,207.4) 293.4,207.4 294.07,208.07 294.07,210.55 294.85,211.34 BD11.2
S0_VD33_IO6: length 6.8
  TOP w0.249: 288.13,210.08 288.3,210.25 SITE0.88
  TOP w0.381: 288.13,210.08 v1(287.88,209.83)
  BOTTOM w0.508: v1(287.88,209.83) 288.59,210.54 288.59,214.28 BD12.2
S0_VD33_SPS_AUD: length 2.7
  TOP w0.249: SITE0.1 282.3,209.41
  TOP w0.508: 282.3,209.41 282.3,209.56 281.79,210.08 v1(280.2,210.08)
  vias: v1(276.63,210.92)
S0_VD33_SPS_DCORE: length 6.3
  TOP w0.249: SITE0.2 281.56,208.85 281.25,209.17
  TOP w0.381: 281.07,209.35 281.25,209.17 ; 278.38,208.5 C112.1 278.83,208.51 279.08,208.77
  TOP w0.508: C111.1 277.33,208.5 278.38,208.5 ; 281.07,209.35 279.66,209.35 279.08,208.77
  vias: v1(276.81,207.99)
S0_VD33_SPS_MEM: length 4.7
  TOP w0.249: 292.65,211 SITE0.76
  TOP w0.381: 293.76,213.77 C126.1 293.63,214.29
  TOP w0.508: v1(293.38,214.77) 293.63,214.52 293.63,214.29 ; 292.65,211 293,211 293.76,211.76 293.76,213.77
S0_VD33PA_A: length 7.2
  TOP w0.249: SITE0.27 284.45,198.2 284.07,197.82
  TOP w0.381: 282.62,196.39 C100.1 283.05,196.59
  TOP w0.508: v1(282.77,193.44) 281.99,194.22 281.99,195.76 282.62,196.39 ; 284.07,197.82 283.05,196.79 283.05,196.59
S0_VD33PA_BT: length 10.4
  TOP w0.249: SITE0.38 288.3,200.15 288.18,200.28
  TOP w0.381: 288.18,200.28 v1(288.09,200.36)
  BOTTOM w0.508: v1(288.09,200.36) 288.71,199.74 291.81,199.74 292.9,198.66 C83.1 BD18.2
S0_VD33PA_G: length 10
  TOP w0.249: v1(285.76,200.36) 285.76,200.24 286.12,199.87 286.38,199.87 286.55,199.7 SITE0.33
  BOTTOM w0.508: BD15.2 C76.1 280.95,196.73 283.66,199.44 285.18,199.44 285.76,200.02 v1(285.76,200.36)
S0_VD33PAD_A: length 10.2
  TOP w0.249: 283.95,199 SITE0.26
  TOP w0.381: 280.89,192.27 C98.1 281.27,192.08
  TOP w0.508: 281.27,192.08 281.54,192.08 281.83,191.79 v1(281.83,191.38) ; 280.89,192.27 280.89,196.53 283.36,199 283.95,199
S0_VD33PAD_G: length 1.5
  TOP w0.249: v1(286.58,200.36) 286.9,200.03 SITE0.34
  vias: v1(275.79,198.83) v1(275.79,197.76)
S0_VD1833_IO1: length 13
  TOP w0.249: SITE0.14 283.26,204.65
  TOP w0.381: 283.26,204.65 v1(283.5,204.65)
  BOTTOM w0.508: BD3.2 280.15,211.62 281.5,210.28 281.5,206.2 283.05,204.65 v1(283.5,204.65)
S0_VD1833_SDIO: length 7.9
  TOP w0.249: 286.68,210.08 286.55,210.22 SITE0.93
  TOP w0.381: 286.68,210.08 v1(286.94,209.83)
  BOTTOM w0.508: BD29.2 C118.1 285.72,211.04 v1(286.94,209.83)
S0_VD_MEM0: length 9.6
  TOP w0.249: SITE0.61 293.57,204.3 293.06,203.79
  TOP w0.381: 293.06,203.79 v1(293.06,203.7)
  BOTTOM w0.508: R81.2 299.97,203.52 299.38,204.11 295.23,204.11 294.82,203.7 v1(293.06,203.7)
S0_VD_MEM1: length 10
  TOP w0.249: SITE0.62 293.36,204.65
  TOP w0.254: 293.36,204.65 293.22,204.65 293.11,204.54
  TOP w0.381: 293.11,204.54 v1(293.05,204.49)
  BOTTOM w0.508: R82.2 300.73,206.85 295.41,206.85 v1(293.05,204.49)
S0_VD_MEM2: length 7.4
  TOP w0.249: 295.94,204.79 295.03,205.7 SITE0.65
  TOP w0.381: 295.94,204.79 v1(296.31,204.79)
  BOTTOM w0.381: 296.55,205.02 v1(296.31,204.79)
  BOTTOM w0.508: 296.55,205.02 296.94,205.41 299.48,205.41 300.25,204.64 R83.2
S0_VDD09: length 2
  BOTTOM w0.277: K22.5 R48.1
S0_VDD18_A: length 6.1
  BOTTOM w0.508: R55.1 K25.5 S0_VDD18_A.1
S0_VDD18_D: length 2.3
  BOTTOM w0.508: R53.1 K28.5
  vias: v2(226.55,190.87)
S0_VDD33: length 2.2
  TOP w0.152: U1.6 289.3,191.43 ; U2.6 286.99,187.42
  TOP w0.277: 289.3,191.43 v1(289.94,191.43) ; 286.99,187.42 v1(287.63,187.42)
  BOTTOM w0.254: BD33.2 v2(279.76,84.71)
  vias: v2(191.24,191.57) v2(197.47,191.57) v2(261.96,83.12) v2(270.6,128.74) v2(276.36,83.54) v2(278.67,85.56)
S0_VDD33_J1: length 1.9
  BOTTOM w0.277: J1.1 R19.2
S0_VDD33_J2: length 2.1
  BOTTOM w0.305: R24.2 273.29,83.54 J2.1
S0_VDD33_J3: length 1.9
  BOTTOM w0.277: J3.1 R30.2
S0_VREF_DRAM: length 1.9
  TOP w0.249: SITE0.63 292.79,205 292.73,205.06
  TOP w0.381: 292.73,205.06 v1(292.55,205.25)
S0_XI: length 8.5
  TOP w0.249: 278.07,201.85 SITE0.22
  TOP w0.277: Y1.1 C25.2 277.3,201.85 278.07,201.85
S0_XO: length 8.5
  TOP w0.249: SITE0.21 278.56,202.2
  TOP w0.254: 278.56,202.2 278.37,202.39
  TOP w0.277: 278.37,202.39 277.85,202.91 C23.2 276.07,202.91 275.81,203.17 274.58,203.17 Y1.3
S1_1_AOUT_LN: length 4.6
  BOTTOM w0.152: UNK1K10.4 226.13,210.15 UNK1R45.1 UNK1R68.1 UNK1R67.1
S1_1_AOUT_LP: length 4.6
  BOTTOM w0.152: UNK1K10.5 226.13,213.57 UNK1R75.1 UNK1R69.1 UNK1R70.1
S1_1_AOUT_RN: length 4.6
  BOTTOM w0.152: UNK1R63.1 UNK1R64.1 UNK1R47.1 226.13,202.89 UNK1K14.4
S1_1_AOUT_RP: length 4.6
  BOTTOM w0.152: UNK1K14.5 226.13,206.31 UNK1R74.1 UNK1R65.1 UNK1R66.1
S1_1_SPI_CLK: length 6.2
  BOTTOM w0.277: v2(238.41,224.05) 239.55,222.91 240.35,222.91 241.04,222.22 UNK1U3.6
S1_1_SPI_CS: length 3.2
  BOTTOM w0.277: UNK1U3.1 v2(243.59,205.63)
S1_1_SPI_DATA0: length 6.1
  BOTTOM w0.277: UNK1U3.5 239.77,221.99 239.49,222.27 238.91,222.27 v2(237.14,224.05)
S1_1_SPI_DATA1: length 3.2
  BOTTOM w0.277: UNK1U3.2 v2(242.32,205.63)
S1_1_SPI_DATA2: length 5.6
  TOP w0.277: UNK1R18.2 UNK1R16.2 v2(241.05,205.63)
  BOTTOM w0.277: v2(241.05,205.63) UNK1U3.3
S1_1_SPI_DATA3: length 6.5
  TOP w0.277: UNK1R12.1 v2(240.95,224.05)
  BOTTOM w0.277: v2(240.95,224.05) 240.95,223.48 242.31,222.11 UNK1U3.7
S1_1_VDD09:
  vias: v1(303.96,197.09) v1(321.19,215.76) v1(324.32,215.77) v1(330.14,215.76) v1(331.21,215.76) v1(337.43,212.38) v1(337.43,210.27) v1(338.6,212.38) v1(341.67,201.38)
S1_1_VDD18_A: length 6.5
  TOP w0.61: UNK1K26.2 347.74,175.14 343.91,175.14 UNK1R50.1
S1_1_VDD18_D:
  vias: v1(341.67,206.84) v1(341.67,204.64) v1(341.67,203.52) v1(342.96,206.84) v2(327.84,233.09)
S1_2_AOUT_LN:
  vias: v2(222.84,211.15)
S1_2_AOUT_LP:
  vias: v2(222.84,212.57)
S1_2_AOUT_RN:
  vias: v2(222.84,203.89)
S1_2_AOUT_RP:
  vias: v2(222.84,205.31)
S1_2_VDD18_A: length 0.9
  BOTTOM w0.508: UNK1BD20.1 v1(315.79,206.99)
  vias: v1(314.76,206.99) v1(324.37,201.66) v1(324.37,200.62) v1(336.19,196.37) v2(343.65,173.88)
S1_ATX_VD0V9:
  vias: v2(243.7,231.39) v2(243.7,229.61)
S1_ATX_VD33: length 0.9
  BOTTOM w0.254: UNK1BD33.1 v2(320.27,87.35)
  vias: v2(323.07,88.62) v2(323.07,86.06) v2(323.07,83.49)
S1_AVCC_DRV: length 6.1
  TOP w0.249: SITE1.53 335.06,201.5 335.89,200.67
  TOP w0.381: 335.89,200.67 UNK1C75.1 336.44,200.24 336.82,199.86 338.48,199.86 338.86,200.25 UNK1C110.1
  vias: v1(339.06,200.67) v2(316.15,234.23)
S1_CHIP_EN_1: length 2
  BOTTOM w0.277: UNK1R34.2 UNK1SW5.1
S1_DPS_F001:
  vias: v2(260.8,231.25) v2(262.58,231.25)
S1_DPS_F002:
  vias: v2(348.41,171.07) v2(349.51,168.65) v2(349.51,166.87)
S1_DPS_F004:
  vias: v2(265.43,231.25) v2(267.2,231.25)
S1_DPS_F006:
  vias: v2(336.84,174.69) v2(336.84,173.67) v2(336.84,172.12) v2(336.84,171.11) v2(336.84,169.53) v2(336.84,168.51)
S1_HSDM: length 3.1
  TOP w0.249: SITE1.79 331.45,212.22
  TOP w0.305: 331.45,212.22 332.39,213.16 v1(332.94,213.16)
S1_HSDP: length 2.1
  TOP w0.249: SITE1.78 331.8,211.77 331.92,211.89
  TOP w0.305: 331.92,211.89 332.17,212.14 v1(332.94,212.14)
S1_LPC_024: length 3.4
  TOP w0.249: 335.28,207.32 335.06,207.1 SITE1.69
  TOP w0.277: 335.28,207.32 v1(335.49,207.53)
  BOTTOM w0.277: UNK1R35.1 UNK1J4.2
S1_LPC_025: length 3.5
  TOP w0.249: 333.26,208.05 333.51,207.8 SITE1.71
  TOP w0.277: 333.26,208.05 333.26,208.05 v1(333.05,208.25)
  BOTTOM w0.277: UNK1R34.1 UNK1J4.1
S1_LPC_041: length 5.7
  TOP w0.249: SITE1.68 336.66,206.75
  TOP w0.277: 336.66,206.75 337.1,206.75 v1(337.69,206.16)
  BOTTOM w0.277: UNK1R36.1 UNK1J4.3
S1_LPC_042: length 0.9
  TOP w0.249: 332.68,199.35 332.5,199.17 SITE1.50
  TOP w0.277: 332.68,199.35 v1(333.2,199.35)
S1_LPC_044: length 3.9
  TOP w0.249: SITE1.58 333.46,203.25
  TOP w0.277: v1(332.55,202.94) 333.15,202.94 333.46,203.25
  BOTTOM w0.277: UNK1R39.1 UNK1J4.5
S1_LPC_046: length 2.1
  TOP w0.249: SITE1.67 336.07,206.4 336.18,206.3
  TOP w0.277: 336.18,206.3 v1(336.31,206.16)
S1_LPC_047: length 3.5
  TOP w0.249: SITE1.18 323.44,203.25
  TOP w0.277: 323.44,203.25 v1(323.64,203.46)
  BOTTOM w0.277: UNK1R41.1 UNK1J4.7
S1_LPC_049: length 5.2
  TOP w0.249: SITE1.8 321.07,206.75
  TOP w0.277: 321.07,206.75 320.58,207.24 318.14,207.24 v1(317.58,206.68)
S1_LPC_050: length 2.4
  TOP w0.249: 321.07,207.49 321.46,207.1 SITE1.7
  TOP w0.277: 321.07,207.49 320.76,207.8 v1(320.2,207.8)
S1_LPC_051: length 2
  TOP w0.249: 332.36,199.94 332.15,199.73 SITE1.49
  TOP w0.277: 332.36,199.94 332.63,200.2 v1(333.2,200.2)
S1_LPC_052: length 2.4
  TOP w0.249: SITE1.48 331.8,198.15 331.95,198
  TOP w0.277: 331.95,198 332.12,197.84 333.06,197.84 v1(333.2,197.97)
S1_LPC_053: length 7.2
  TOP w0.249: SITE1.57 335.46,202.9 335.69,202.68
  TOP w0.277: v1(339.06,203.42) 338.32,202.68 335.69,202.68
  BOTTOM w0.277: UNK1R37.1 UNK1J4.4
S1_LPC_055: length 2.4
  TOP w0.249: SITE1.10 320.83,206.05
  TOP w0.277: 320.83,206.05 v1(320.2,206.68)
S1_LPC_058: length 4.4
  TOP w0.249: SITE1.17 323.06,203.6 323.31,203.85
  TOP w0.277: 323.31,203.85 323.47,204.01 324.19,204.01 v1(324.37,203.83)
  BOTTOM w0.277: UNK1R40.1 UNK1J4.6
S1_LPC_060: length 5.2
  TOP w0.249: 335.93,205.51 335.39,206.05 SITE1.66
  TOP w0.277: v1(339.06,206.16) 338.41,205.51 335.93,205.51
S1_LX_AUD: length 6.2
  TOP w0.249: 323.78,211 SITE1.100
  TOP w0.864: 323.47,211 323.78,211
  TOP w1.016: 323.33,215.38 321.99,214.04 321.99,212.48 323.47,211
S1_LX_DCORE: length 2.2
  TOP w0.249: SITE1.3 320.97,208.5
  TOP w0.508: v1(320.2,208.63) v1(320.74,208.63) 320.85,208.63 320.97,208.5
S1_LX_MEM: length 1.9
  TOP w0.249: 335.1,209.46 334.84,209.2 SITE1.75
  TOP w0.508: 335.1,209.46 v1(335.1,209.85) v1(335.1,210.48)
S1_MIPITX_CKN: length 1.3
  TOP w0.249: 330.52,211.89 330.4,211.77 SITE1.82
  TOP w0.277: 330.52,211.89 v1(330.77,212.14)
S1_MIPITX_CKP: length 2.8
  TOP w0.249: SITE1.83 330.05,212.11
  TOP w0.277: 330.05,212.11 330.05,212.79 v1(330.77,213.51)
S1_MIPITX_DATAN_0: length 1.2
  TOP w0.249: SITE1.85 329.35,212.09
  TOP w0.277: 329.35,212.09 v1(329.4,212.14)
S1_MIPITX_DATAN_1: length 2.3
  TOP w0.249: SITE1.80 331.1,210.21 331.28,210.03
  TOP w0.277: v1(330.83,208.99) 331.28,209.44 331.28,210.03
S1_MIPITX_DATAP_0: length 2.8
  TOP w0.249: 328.83,212.19 328.83,211.93 329,211.75 SITE1.86
  TOP w0.277: 328.83,212.19 328.83,212.94 v1(329.4,213.51)
S1_MIPITX_DATAP_1: length 1.2
  TOP w0.249: SITE1.81 330.75,210.04 330.68,209.97
  TOP w0.277: 330.68,209.97 v1(330.58,209.86)
S1_PA2: length 2.1
  TOP w0.249: SITE1.5 324.09,207.8
  TOP w0.277: 324.09,207.8 v1(324.34,207.55)
S1_PA3: length 1.4
  TOP w0.249: SITE1.6 323.34,207.45 323.44,207.35
  TOP w0.277: 323.44,207.35 v1(323.61,207.17)
S1_PA9_CH: length 4
  TOP w0.249: 320.67,205.52 320.85,205.35 SITE1.12
  TOP w0.277: v1(318.83,206.68) 319.85,205.66 320.53,205.66 320.67,205.52
S1_PA10_CH: length 2.1
  TOP w0.249: SITE1.13 320.27,205
  TOP w0.277: 320.27,205 v1(320.2,204.93)
S1_PA13: length 3.7
  TOP w0.249: SITE1.15 320.02,204.3 319.82,204.5
  TOP w0.277: v1(318.83,204.93) 319.39,204.93 319.82,204.5
S1_PA13_UART_RX: length 14
  BOTTOM w0.305: UNK1K6.2 322.42,97.94 322.42,94.17 UNK1R27.1
S1_PA13_UART_RX_1: length 2.1
  BOTTOM w0.305: UNK1J2.3 315.85,88.6 UNK1R27.2
S1_PA14: length 5.3
  TOP w0.249: SITE1.16 319.61,203.95 319.21,204.34
  TOP w0.277: 319.21,204.34 318.45,204.34 317.86,204.93 v1(317.46,204.93)
S1_PA14_UART_TX: length 10.1
  BOTTOM w0.305: UNK1K6.7 318.91,97.64 318.91,93.2 UNK1R28.1
S1_PA14_UART_TX_1: length 2.1
  BOTTOM w0.305: UNK1R28.2 315.85,91.14 UNK1J2.4
S1_PA15_1: length 2
  BOTTOM w0.277: UNK1R40.2 UNK1SW5.6
S1_PA16_1: length 2
  BOTTOM w0.277: UNK1R41.2 UNK1SW5.7
S1_PA20: length 2.2
  TOP w0.152: v1(331.15,201.07) 331.02,200.94 331.02,200.2 330.75,199.93 SITE1.45
S1_PA21: length 1.6
  TOP w0.152: SITE1.46 331.1,199.75 331.58,200.23 v1(331.58,200.41)
S1_PA22: length 2.2
  TOP w0.152: v1(330.01,201.07) 329.86,200.91 329.86,199.9 330.05,199.7 SITE1.43
S1_PA23: length 1.4
  TOP w0.152: v1(330.44,200.41) 330.4,200.37 SITE1.44
S1_PA24: length 1.2
  TOP w0.152: v1(329.06,197.95) 329.35,198.25 SITE1.41
S1_PA25: length 1.2
  TOP w0.152: SITE1.42 329.7,198.25 v1(330,197.95)
S1_PA28: length 2.2
  TOP w0.152: v1(328.86,201.07) 328.65,200.85 SITE1.39
S1_PA29: length 1.5
  TOP w0.152: SITE1.40 329,200.11 v1(329.3,200.41)
S1_PB3: length 2.2
  TOP w0.152: v1(332.25,201.41) 333.29,201.41 333.55,201.15 SITE1.52
S1_PB3_AOUT_LP_2:
  vias: v2(221.67,212.57)
S1_PB4: length 1.4
  TOP w0.152: SITE1.51 v1(332.88,200.8)
S1_PB4_AOUT_LN_2:
  vias: v2(221.67,211.15)
S1_PB5: length 3.8
  TOP w0.152: SITE1.54 335.44,201.85 335.89,201.4 337.04,201.4 v1(337.69,202.05)
S1_PB5_AOUT_RP_2:
  vias: v2(221.67,205.31)
S1_PB6: length 2.1
  TOP w0.152: v1(336.31,202.05) 336.16,202.2 SITE1.55
S1_PB6_AOUT_RN_2:
  vias: v2(221.67,203.89)
S1_PB10_1: length 2
  BOTTOM w0.277: UNK1R37.2 UNK1SW5.4
S1_PB11_1: length 2
  BOTTOM w0.277: UNK1R39.2 207.97,131.66
S1_PB21_1: length 2
  BOTTOM w0.277: UNK1R36.2 UNK1SW5.3
S1_PB22_1: length 2
  BOTTOM w0.277: UNK1R35.2 200.35,131.66
S1_PB23: length 4.3
  TOP w0.249: SITE1.72 335.7,208.15 336.01,207.83
  TOP w0.277: 336.01,207.83 v1(336.31,207.53)
  BOTTOM w0.277: UNK1R57.1 UNK1K4.3
S1_PB23_1:
  vias: v2(203.61,225.27)
S1_PB23_SICK:
  vias: v2(197.47,230.94)
S1_PB23_SICK_1: length 1.9
  BOTTOM w0.277: UNK1J1.3 UNK1R20.2
S1_PB24: length 4.2
  TOP w0.249: 336.09,208.68 335.91,208.5 SITE1.73
  TOP w0.277: 336.09,208.68 v1(336.31,208.9)
  BOTTOM w0.277: UNK1K4.6 UNK1R58.1
S1_PB24_1:
  vias: v2(203.61,232.53)
S1_PB24_SIDD:
  vias: v2(197.47,233.48)
S1_PB24_SIDD_1: length 1.9
  BOTTOM w0.277: UNK1J1.4 UNK1R21.2
S1_PB25: length 4.7
  TOP w0.249: SITE1.96 325.5,212.17
  TOP w0.277: 325.5,212.17 325.5,213.04 v1(325.03,213.51)
  BOTTOM w0.277: UNK1K8.3 UNK1R59.1
S1_PB25_1:
  vias: v2(203.61,216.86)
S1_PB25_I2C_SCL:
  vias: v2(191.24,230.94)
S1_PB25_I2C_SCL_1: length 1.9
  BOTTOM w0.277: UNK1J3.3 UNK1R31.2
S1_PB26: length 4.1
  TOP w0.249: 324.95,209.63 324.95,210.01 325.15,210.2 SITE1.97
  TOP w0.277: 324.95,209.63 v1(324.95,208.97)
  BOTTOM w0.277: UNK1K8.6 UNK1R60.1
S1_PB26_1:
  vias: v2(203.61,224.13)
S1_PB26_I2C_SDA:
  vias: v2(191.24,233.48)
S1_PB26_I2C_SDA_1: length 1.9
  BOTTOM w0.277: UNK1J3.4 UNK1R32.2
S1_RF_A: length 2.9
  TOP w0.277: UNK1C13.1 UNK1D3.1 UNK1C15.1 UNK1SMP3.1
S1_RF_G: length 5.9
  TOP w0.277: UNK1SMP2.1 UNK1C8.1 UNK1D2.1 UNK1C6.1
S1_RFIN_A: length 3.5
  TOP w0.249: SITE1.29 325.15,198.14 arc(325.2,197.91) v1(325.33,197.71)
  BOTTOM w0.277: UNK1R9.1 UNK1C16.2 324.8,196.44 arc(324.94,197.13) v1(325.33,197.71)
S1_RFIN_G: length 4.2
  TOP w0.249: SITE1.31 v1(325.85,197.18)
  BOTTOM w0.277: UNK1R5.1 UNK1C9.2 arc(326.44,196.4) 326.05,196.98 v1(325.85,197.18)
S1_RFIO_A: length 3.3
  TOP w0.249: 324.8,197.46 SITE1.28
  TOP w0.277: 324.8,197.46 UNK1C11.2 UNK1R6.1
S1_RFIO_BT: length 3.5
  TOP w0.249: SITE1.37 327.95,198.35 arc(327.98,198.21) 328.06,198.09
  TOP w0.277: 328.06,198.09 329.37,196.77 UNK1R1.1
S1_RFIO_G: length 4.1
  TOP w0.249: SITE1.32 326.2,198.25 arc(326.24,197.84) 326.36,197.46
  TOP w0.277: UNK1R2.1 UNK1C4.2 326.78,196.85 arc(326.54,197.13) 326.36,197.46
S1_RREF_MEM: length 7.2
  TOP w0.249: SITE1.60 335.21,203.95 335.42,204.16
  TOP w0.277: 335.42,204.16 338.43,204.16 340.01,205.74 v1(340.73,205.74)
S1_SPI_CLK:
  vias: v2(238.41,225.05)
S1_SPI_CLK/PB28: length 4.3
  TOP w0.249: SITE1.90 327.6,212.64 327.47,212.78
  TOP w0.277: v1(327.77,214.77) 327.77,214.5 327.09,213.82 327.09,213.16 327.47,212.78
S1_SPI_CS:
  vias: v2(243.59,204.63)
S1_SPI_CS/PC0: length 1.3
  TOP w0.249: SITE1.95 325.85,210.03 325.75,209.92
  TOP w0.277: 325.75,209.92 v1(325.65,209.83)
S1_SPI_D0/PB29: length 2.9
  TOP w0.249: SITE1.91 327.25,212.23 327.15,212.33
  TOP w0.277: v1(326.4,213.51) 326.4,213.08 327.15,212.33
S1_SPI_D1/PB31: length 2.2
  TOP w0.249: SITE1.94 326.2,209.65
  TOP w0.277: 326.2,209.65 326.2,209.26 v1(325.9,208.96)
S1_SPI_D2/PB30: length 1.5
  TOP w0.249: 326.79,211.93 326.9,211.82 SITE1.92
  TOP w0.277: 326.79,211.93 326.58,212.14 v1(326.4,212.14)
S1_SPI_D3/PB27: length 2.6
  TOP w0.249: SITE1.89 327.95,212.9
  TOP w0.277: v1(327.77,213.51) 327.95,213.33 327.95,212.9
S1_SPI_DATA0:
  vias: v2(237.14,225.05)
S1_SPI_DATA1:
  vias: v2(242.32,204.63)
S1_SPI_DATA2:
  vias: v2(239.78,204.63)
S1_SPI_DATA3:
  vias: v2(240.95,225.05)
S1_U1_VC1: length 0.7
  TOP w0.152: UNK1U1.4 328.47,191.43
  TOP w0.277: 328.47,191.43 v1(327.84,191.43)
S1_U2_VC1: length 0.7
  TOP w0.152: UNK1U2.4 326.16,187.42
  TOP w0.277: 326.16,187.42 v1(325.53,187.42)
S1_VA09_MIPI: length 1.2
  TOP w0.249: SITE1.84 329.7,210.24
  TOP w0.254: 329.7,210.24 329.7,209.87
  TOP w0.381: 329.7,209.87 v1(329.67,209.84)
  vias: v1(331.21,214.77)
S1_VA09_PLL: length 1.3
  TOP w0.249: SITE1.11 323.3,205.7
  TOP w0.381: 323.3,205.7 v1(323.5,205.5)
  vias: v1(321.19,214.77)
S1_VA09_USB: length 1.3
  TOP w0.249: SITE1.77 332.15,210.09
  TOP w0.381: 332.15,210.09 v1(332.4,209.84)
  vias: v1(336.31,212.38)
S1_VA13_AFE: length 2.3
  TOP w0.249: SITE1.19 321.39,202.9 320.89,203.4
  TOP w0.381: 320.89,203.4 v1(320.2,203.4)
  vias: v1(315.79,205.15)
S1_VA13_SYN: length 2.2
  TOP w0.249: 320.29,201.39 320.4,201.5 SITE1.23
  TOP w0.381: 320.29,201.39 v1(320.2,201.29)
  vias: v1(323.33,201.66)
S1_VA33_SYN: length 5.9
  TOP w0.249: SITE1.24 321.08,201.15 320.53,200.61
  TOP w0.381: 320.53,200.61 v1(320.2,200.61)
  BOTTOM w0.381: 320.02,200.61 v1(320.2,200.61)
  BOTTOM w0.508: 320.02,200.61 319.51,200.1 319.51,199.38 318.95,198.82 UNK1BD13.2
S1_VA33_XTAL: length 7.1
  TOP w0.249: 320.74,202.74 320.93,202.55 SITE1.20
  TOP w0.381: 320.74,202.74 v1(320.2,202.74)
  BOTTOM w0.381: 319.83,202.74 v1(320.2,202.74)
  BOTTOM w0.508: UNK1BD5.2 319.15,205.67 319.51,205.32 319.51,203.06 319.83,202.74
S1_VD09_CORE1: length 1.4
  TOP w0.249: SITE1.56 333.42,202.55 v1(333.06,202.19)
  vias: v1(340.73,201.38)
S1_VD09_CORE2: length 1.6
  TOP w0.249: 333.25,205.5 333.39,205.35 SITE1.64
  TOP w0.381: 333.25,205.5 333.06,205.68 v1(333.06,205.91)
  vias: v1(336.31,210.27)
S1_VD09_CORE3: length 1.2
  TOP w0.249: SITE1.87 328.65,210.01 328.71,209.95
  TOP w0.381: 328.71,209.95 v1(328.82,209.84)
  vias: v1(330.14,214.77)
S1_VD09_CORE4: length 4.7
  TOP w0.249: SITE1.98 324.8,212.02
  TOP w0.508: v1(323.66,213.51) 324.8,212.37 324.8,212.02
  BOTTOM w0.508: v1(323.66,213.51) 323.76,213.51 324.6,214.35 UNK1R79.2
S1_VD13_FE: length 1.5
  TOP w0.249: 327.43,200.29 327.6,200.12 SITE1.36
  TOP w0.381: 327.43,200.29 v1(327.36,200.36)
  vias: v1(335.25,196.37)
S1_VD13_RF: length 2.5
  TOP w0.249: SITE1.25 321.44,200.8 320.56,199.92
  TOP w0.381: 320.56,199.92 v1(320.2,199.92)
  vias: v1(323.33,200.62)
S1_VD33_ALL: length 0.8
  BOTTOM w0.508: v1(316.67,204.93) 316.67,205.49 UNK1BD5.1
  vias: v1(313.79,198.83) v1(314.76,205.15) v1(314.85,198.83) v1(316.81,208.92) v1(316.89,198.83) v1(317.29,211.59) v1(320.01,195.04) v1(320.15,215.76) v1(321.83,193.44) v1(322.24,215.76) v1(322.77,191.38) v1(326.81,215.76) v1(329.07,215.76) v1(334.32,214.77) v1(336.19,197.57) v1(336.19,194.23) v1(337.32,198.66) v1(337.32,197.57) v1(337.43,211.34) v1(338.6,211.34) v1(341.67,202.45) v2(246.28,225.05)
S1_VD33_CM_BT: length 1
  TOP w0.249: SITE1.35 327.25,198.12
  TOP w0.381: 327.25,198.12 v1(327.25,198.01)
  vias: v1(335.25,195.29) v1(335.25,194.23)
S1_VD33_EX_FLASH: length 9
  TOP w0.508: UNK1BD32.2 246.22,224.05 v2(245.01,224.05) v2(243.74,224.05) v2(242.46,224.05)
  BOTTOM w0.508: UNK1U3.8 243.58,222.39 242.46,223.52 v2(242.46,224.05)
  vias: v2(239.68,225.05) v2(241.05,204.63) v2(246.28,224.05)
S1_VD33_IO0: length 10.2
  TOP w0.249: SITE1.9 323.45,206.4
  TOP w0.381: 323.45,206.4 v1(323.5,206.35)
  BOTTOM w0.508: UNK1BD7.2 322.24,212.95 322.92,212.27 322.92,206.93 v1(323.5,206.35)
S1_VD33_IO2: length 7.2
  TOP w0.249: SITE1.59 335.63,203.6 335.81,203.42
  TOP w0.381: 335.81,203.42 v1(336.31,203.42)
  BOTTOM w0.381: 336.31,202.99 v1(336.31,203.42)
  BOTTOM w0.508: 336.31,202.99 336.57,202.73 338.25,202.73 338.53,202.45 UNK1BD9.2
S1_VD33_IO3: length 7.8
  TOP w0.249: SITE1.70 333.1,207.45
  TOP w0.381: 333.1,207.45 v1(333.05,207.4)
  BOTTOM w0.508: UNK1BD11.2 334.85,211.34 334.07,210.55 334.07,208.07 333.4,207.4 v1(333.05,207.4)
S1_VD33_IO6: length 6.8
  TOP w0.249: SITE1.88 328.3,210.25 328.13,210.08
  TOP w0.381: 328.13,210.08 v1(327.88,209.83)
  BOTTOM w0.508: v1(327.88,209.83) 328.59,210.54 328.59,214.28 UNK1BD12.2
S1_VD33_SPS_AUD: length 2.7
  TOP w0.249: SITE1.1 322.3,209.41
  TOP w0.508: 322.3,209.41 322.3,209.56 321.79,210.08 v1(320.2,210.08)
  vias: v1(316.63,210.92)
S1_VD33_SPS_DCORE: length 6.3
  TOP w0.249: 321.24,209.17 321.56,208.85 SITE1.2
  TOP w0.381: 318.38,208.5 UNK1C112.1 318.83,208.51 319.08,208.77 ; 321.07,209.35 321.24,209.17
  TOP w0.508: v1(316.81,207.98) 317.33,208.5 318.38,208.5 ; 321.07,209.35 319.66,209.35 319.08,208.77
S1_VD33_SPS_MEM: length 4.7
  TOP w0.249: 332.65,211 SITE1.76
  TOP w0.381: 333.63,214.29 UNK1C126.1 333.76,213.77
  TOP w0.508: v1(333.38,214.77) 333.63,214.52 333.63,214.29 ; 333.76,213.77 333.76,211.76 333,211 332.65,211
S1_VD33PA_A: length 7.2
  TOP w0.249: 324.07,197.82 324.45,198.2 SITE1.27
  TOP w0.381: 322.62,196.39 UNK1C100.1 323.05,196.59
  TOP w0.508: 322.62,196.39 321.99,195.76 321.99,194.22 v1(322.77,193.44) ; 323.05,196.59 323.05,196.79 324.07,197.82
S1_VD33PA_BT: length 10.4
  TOP w0.249: SITE1.38 328.3,200.15 328.18,200.28
  TOP w0.381: 328.18,200.28 v1(328.09,200.36)
  BOTTOM w0.508: v1(328.09,200.36) 328.71,199.74 331.81,199.74 332.9,198.66 UNK1C83.1 UNK1BD18.2
S1_VD33PA_G: length 10
  TOP w0.249: SITE1.33 326.55,199.7 326.38,199.87 326.12,199.87 325.76,200.24 v1(325.76,200.36)
  BOTTOM w0.508: v1(325.76,200.36) 325.76,200.02 325.18,199.44 323.66,199.44 320.95,196.73 UNK1C76.1 UNK1BD15.2
S1_VD33PAD_A: length 10.2
  TOP w0.249: 323.95,199 SITE1.26
  TOP w0.381: 321.27,192.08 UNK1C98.1 320.89,192.27
  TOP w0.508: 321.27,192.08 321.54,192.08 321.83,191.79 v1(321.83,191.38) ; 323.95,199 323.36,199 320.89,196.53 320.89,192.27
S1_VD33PAD_G: length 1.5
  TOP w0.249: v1(326.58,200.36) 326.9,200.03 SITE1.34
  vias: v1(315.78,198.83) v1(315.78,197.76)
S1_VD1833_IO1: length 13
  TOP w0.249: SITE1.14 323.26,204.65
  TOP w0.381: 323.26,204.65 v1(323.5,204.65)
  BOTTOM w0.508: v1(323.5,204.65) 323.05,204.65 321.5,206.2 321.5,210.28 320.15,211.62 UNK1BD3.2
S1_VD1833_SDIO: length 7.9
  TOP w0.249: 326.68,210.08 326.55,210.22 SITE1.93
  TOP w0.381: 326.68,210.08 v1(326.94,209.83)
  BOTTOM w0.508: v1(326.94,209.83) 325.72,211.04 UNK1C118.1 UNK1BD29.2
S1_VD_MEM0: length 9.6
  TOP w0.249: SITE1.61 333.57,204.3 333.06,203.79
  TOP w0.381: 333.06,203.79 v1(333.06,203.7)
  BOTTOM w0.508: v1(333.06,203.7) 334.82,203.7 335.23,204.11 339.38,204.11 339.97,203.52 UNK1R81.2
S1_VD_MEM1: length 10
  TOP w0.249: SITE1.62 333.36,204.65
  TOP w0.254: 333.36,204.65 333.22,204.65 333.11,204.54
  TOP w0.381: 333.11,204.54 v1(333.05,204.49)
  BOTTOM w0.508: UNK1R82.2 340.73,206.85 335.41,206.85 v1(333.05,204.49)
S1_VD_MEM2: length 7.4
  TOP w0.249: 335.94,204.79 335.03,205.7 SITE1.65
  TOP w0.381: 335.94,204.79 v1(336.31,204.79)
  BOTTOM w0.381: 336.55,205.02 v1(336.31,204.79)
  BOTTOM w0.508: 336.55,205.02 336.94,205.41 339.48,205.41 340.25,204.64 UNK1R83.2
S1_VDD09: length 2
  BOTTOM w0.277: UNK1K22.5 UNK1R48.1
S1_VDD18_A: length 6.1
  BOTTOM w0.508: S1_VDD18_A.1 UNK1K25.5 UNK1R55.1
S1_VDD18_D: length 2.3
  BOTTOM w0.508: UNK1R53.1 UNK1K28.5
  vias: v2(226.55,225.16)
S1_VDD33: length 2.2
  TOP w0.152: UNK1U2.6 326.99,187.42 ; UNK1U1.6 329.3,191.43
  TOP w0.277: 329.3,191.43 v1(329.94,191.43) ; 326.99,187.42 v1(327.63,187.42)
  BOTTOM w0.254: UNK1BD33.2 v2(320.27,84.71)
  vias: v2(191.24,225.86) v2(197.47,225.86) v2(200.72,124.04) v2(302.47,83.12) v2(316.87,83.54) v2(319.18,85.56)
S1_VDD33_J1: length 1.9
  BOTTOM w0.277: UNK1J1.1 UNK1R19.2
S1_VDD33_J2: length 2.1
  BOTTOM w0.305: UNK1J2.1 313.8,83.54 UNK1R24.2
S1_VDD33_J3: length 1.9
  BOTTOM w0.277: UNK1J3.1 UNK1R30.2
S1_VREF_DRAM: length 1.9
  TOP w0.249: SITE1.63 332.79,205 332.73,205.06
  TOP w0.381: 332.73,205.06 v1(332.55,205.25)
S1_XI: length 8.5
  TOP w0.249: 318.07,201.85 SITE1.22
  TOP w0.277: UNK1Y1.1 UNK1C25.2 317.3,201.85 318.07,201.85
S1_XO: length 8.5
  TOP w0.249: SITE1.21 318.56,202.2
  TOP w0.254: 318.56,202.2 318.37,202.39
  TOP w0.277: 318.37,202.39 317.85,202.91 UNK1C23.2 316.07,202.91 315.81,203.17 314.58,203.17 UNK1Y1.3
S2_1_AOUT_LN: length 4.6
  BOTTOM w0.152: UNK2K10.4 470.47,225.56 UNK2R45.1 UNK2R68.1 UNK2R67.1
S2_1_AOUT_LP: length 4.6
  BOTTOM w0.152: UNK2R70.1 UNK2R69.1 UNK2R75.1 470.47,222.14 UNK2K10.5
S2_1_AOUT_RN: length 4.6
  BOTTOM w0.152: UNK2K14.4 470.47,232.82 UNK2R47.1 UNK2R64.1 UNK2R63.1
S2_1_AOUT_RP: length 4.6
  BOTTOM w0.152: UNK2K14.5 470.47,229.4 UNK2R74.1 UNK2R65.1 UNK2R66.1
S2_1_SPI_CLK: length 6.2
  BOTTOM w0.277: UNK2U3.6 455.56,213.49 456.25,212.8 457.05,212.8 v2(458.19,211.66)
S2_1_SPI_CS: length 3.2
  BOTTOM w0.277: UNK2U3.1 v2(453.01,230.08)
S2_1_SPI_DATA0: length 6.1
  BOTTOM w0.277: UNK2U3.5 456.83,213.72 457.11,213.44 457.69,213.44 v2(459.46,211.66)
S2_1_SPI_DATA1: length 3.2
  BOTTOM w0.277: UNK2U3.2 v2(454.28,230.08)
S2_1_SPI_DATA2: length 5.6
  TOP w0.277: UNK2R18.2 UNK2R16.2 v2(455.55,230.08)
  BOTTOM w0.277: UNK2U3.3 v2(455.55,230.08)
S2_1_SPI_DATA3: length 6.5
  TOP w0.277: v2(455.65,211.66) UNK2R12.1
  BOTTOM w0.277: UNK2U3.7 454.29,213.6 455.65,212.23 v2(455.65,211.66)
S2_1_VDD09:
  vias: v1(343.96,197.09) v1(361.19,215.76) v1(364.32,215.77) v1(370.14,215.76) v1(371.2,215.76) v1(377.43,212.38) v1(377.43,210.27) v1(378.6,212.38) v1(381.67,201.38)
S2_1_VDD18_A: length 6.5
  TOP w0.61: UNK2K26.2 387.74,175.14 383.9,175.14 UNK2R50.1
S2_1_VDD18_D:
  vias: v1(381.67,206.84) v1(381.67,204.64) v1(381.67,203.52) v1(382.96,206.84) v2(367.84,233.09)
S2_2_AOUT_LN:
  vias: v2(473.76,224.56)
S2_2_AOUT_LP:
  vias: v2(473.76,223.14)
S2_2_AOUT_RN:
  vias: v2(473.76,231.82)
S2_2_AOUT_RP:
  vias: v2(473.76,230.4)
S2_2_VDD18_A: length 0.9
  BOTTOM w0.508: UNK2BD20.1 v1(355.79,206.99)
  vias: v1(354.76,206.99) v1(364.37,201.66) v1(364.37,200.62) v1(376.19,196.37) v2(383.65,173.88)
S2_ATX_VD0V9:
  vias: v2(452.91,206.1) v2(452.91,204.32)
S2_ATX_VD33: length 0.9
  BOTTOM w0.254: UNK2BD33.1 v2(411.31,87.35)
  vias: v2(414.11,88.62) v2(414.11,86.06) v2(414.11,83.49)
S2_AVCC_DRV: length 6.1
  TOP w0.249: 375.89,200.67 375.06,201.5 SITE2.53
  TOP w0.381: 375.89,200.67 UNK2C75.1 376.44,200.24 376.82,199.86 378.48,199.86 378.86,200.25 UNK2C110.1
  vias: v1(379.06,200.67) v2(356.15,234.23)
S2_CHIP_EN_1: length 2
  BOTTOM w0.305: UNK2R34.2 UNK2SW5.1
S2_DPS_F001:
  vias: v2(432.63,230.87) v2(434.41,230.87)
S2_DPS_F002:
  vias: v2(387.27,171.07) v2(388.12,168.65) v2(388.12,166.87)
S2_DPS_F004:
  vias: v2(420.53,238.23) v2(422.31,238.23)
S2_DPS_F006:
  vias: v2(376.84,174.69) v2(376.84,173.67) v2(376.84,172.12) v2(376.84,171.11) v2(376.84,169.53) v2(376.84,168.51)
S2_HSDM: length 3.1
  TOP w0.249: SITE2.79 371.45,212.22
  TOP w0.305: 371.45,212.22 372.39,213.16 v1(372.94,213.16)
S2_HSDP: length 2.1
  TOP w0.249: 371.92,211.89 371.8,211.77 SITE2.78
  TOP w0.305: 371.92,211.89 372.17,212.14 v1(372.94,212.14)
S2_LPC_024: length 3.4
  TOP w0.249: 375.28,207.32 375.06,207.1 SITE2.69
  TOP w0.277: 375.28,207.32 v1(375.49,207.53)
  BOTTOM w0.305: UNK2R35.1 UNK2J4.2
S2_LPC_025: length 3.5
  TOP w0.249: SITE2.71 373.51,207.8 373.26,208.05
  TOP w0.277: 373.26,208.05 373.26,208.05 v1(373.05,208.25)
  BOTTOM w0.305: UNK2R34.1 UNK2J4.1
S2_LPC_041: length 5.7
  TOP w0.249: SITE2.68 376.66,206.75
  TOP w0.277: v1(377.69,206.16) 377.1,206.75 376.66,206.75
  BOTTOM w0.305: UNK2R36.1 UNK2J4.3
S2_LPC_042: length 0.9
  TOP w0.249: SITE2.50 372.5,199.17 372.68,199.35
  TOP w0.277: 372.68,199.35 v1(373.2,199.35)
S2_LPC_044: length 3.9
  TOP w0.249: SITE2.58 373.46,203.25
  TOP w0.277: v1(372.55,202.94) 373.15,202.94 373.46,203.25
  BOTTOM w0.305: UNK2R39.1 UNK2J4.5
S2_LPC_046: length 2.1
  TOP w0.249: SITE2.67 376.07,206.4 376.18,206.3
  TOP w0.277: 376.18,206.3 v1(376.31,206.16)
S2_LPC_047: length 3.5
  TOP w0.249: SITE2.18 363.44,203.25
  TOP w0.277: 363.44,203.25 v1(363.64,203.46)
  BOTTOM w0.305: UNK2R41.1 UNK2J4.7
S2_LPC_049: length 5.2
  TOP w0.249: SITE2.8 361.07,206.75
  TOP w0.277: v1(357.58,206.68) 358.14,207.24 360.58,207.24 361.07,206.75
S2_LPC_050: length 2.4
  TOP w0.249: SITE2.7 361.46,207.1 361.07,207.49
  TOP w0.277: v1(360.2,207.8) 360.76,207.8 361.07,207.49
S2_LPC_051: length 2
  TOP w0.249: SITE2.49 372.15,199.73 372.36,199.94
  TOP w0.277: v1(373.2,200.2) 372.63,200.2 372.36,199.94
S2_LPC_052: length 2.4
  TOP w0.249: SITE2.48 371.8,198.15 371.95,198
  TOP w0.277: 371.95,198 372.12,197.84 373.06,197.84 v1(373.2,197.97)
S2_LPC_053: length 7.2
  TOP w0.249: 375.69,202.68 375.46,202.9 SITE2.57
  TOP w0.277: 375.69,202.68 378.32,202.68 v1(379.06,203.42)
  BOTTOM w0.305: UNK2R37.1 UNK2J4.4
S2_LPC_055: length 2.4
  TOP w0.249: SITE2.10 360.83,206.05
  TOP w0.277: 360.83,206.05 v1(360.2,206.68)
S2_LPC_058: length 4.4
  TOP w0.249: 363.31,203.85 363.06,203.6 SITE2.17
  TOP w0.277: v1(364.37,203.83) 364.19,204.01 363.47,204.01 363.31,203.85
  BOTTOM w0.305: UNK2R40.1 UNK2J4.6
S2_LPC_060: length 5.2
  TOP w0.249: SITE2.66 375.39,206.05 375.93,205.51
  TOP w0.277: v1(379.06,206.16) 378.41,205.51 375.93,205.51
