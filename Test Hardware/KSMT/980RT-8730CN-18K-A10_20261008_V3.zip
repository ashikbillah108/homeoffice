# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S2_LX_AUD: length 6.2
  TOP w0.249: 363.78,211 SITE2.100
  TOP w0.864: 363.47,211 363.78,211
  TOP w1.016: 363.33,215.38 361.99,214.04 361.99,212.48 363.47,211
S2_LX_DCORE: length 2.2
  TOP w0.249: SITE2.3 360.97,208.5
  TOP w0.508: 360.97,208.5 360.85,208.63 v1(360.74,208.63) v1(360.2,208.63)
S2_LX_MEM: length 1.9
  TOP w0.249: 375.1,209.46 374.84,209.2 SITE2.75
  TOP w0.508: v1(375.1,210.48) v1(375.1,209.85) 375.1,209.46
S2_MIPITX_CKN: length 1.3
  TOP w0.249: SITE2.82 370.4,211.77 370.52,211.89
  TOP w0.277: 370.52,211.89 v1(370.77,212.14)
S2_MIPITX_CKP: length 2.8
  TOP w0.249: SITE2.83 370.05,212.11
  TOP w0.277: 370.05,212.11 370.05,212.79 v1(370.77,213.51)
S2_MIPITX_DATAN_0: length 1.2
  TOP w0.249: SITE2.85 369.35,212.09
  TOP w0.277: 369.35,212.09 v1(369.4,212.14)
S2_MIPITX_DATAN_1: length 2.3
  TOP w0.249: SITE2.80 371.1,210.21 371.28,210.03
  TOP w0.277: v1(370.83,208.99) 371.28,209.44 371.28,210.03
S2_MIPITX_DATAP_0: length 2.8
  TOP w0.249: SITE2.86 369,211.75 368.83,211.93 368.83,212.19
  TOP w0.277: v1(369.4,213.51) 368.83,212.94 368.83,212.19
S2_MIPITX_DATAP_1: length 1.2
  TOP w0.249: 370.68,209.97 370.75,210.04 SITE2.81
  TOP w0.277: 370.68,209.97 v1(370.58,209.86)
S2_PA2: length 2.1
  TOP w0.249: SITE2.5 364.09,207.8
  TOP w0.277: 364.09,207.8 v1(364.34,207.55)
S2_PA3: length 1.4
  TOP w0.249: SITE2.6 363.34,207.45 363.44,207.35
  TOP w0.277: 363.44,207.35 v1(363.61,207.17)
S2_PA9_CH: length 4
  TOP w0.249: SITE2.12 360.85,205.35 360.67,205.52
  TOP w0.277: v1(358.83,206.68) 359.85,205.66 360.53,205.66 360.67,205.52
S2_PA10_CH: length 2.1
  TOP w0.249: SITE2.13 360.27,205
  TOP w0.277: 360.27,205 v1(360.2,204.93)
S2_PA13: length 3.7
  TOP w0.249: SITE2.15 360.02,204.3 359.82,204.5
  TOP w0.277: 359.82,204.5 359.39,204.93 v1(358.83,204.93)
S2_PA13_UART_RX: length 14
  BOTTOM w0.305: UNK2R27.1 413.5,94.22 413.5,97.99 UNK2K6.2
S2_PA13_UART_RX_1: length 2.1
  BOTTOM w0.305: UNK2J2.3 406.89,88.6 UNK2R27.2
S2_PA14: length 5.3
  TOP w0.249: 359.21,204.34 359.61,203.95 SITE2.16
  TOP w0.277: v1(357.46,204.93) 357.86,204.93 358.45,204.34 359.21,204.34
S2_PA14_UART_TX: length 11.1
  BOTTOM w0.305: UNK2K6.7 410.05,97.74 410.05,91.59 409.62,91.16 UNK2R28.1
S2_PA14_UART_TX_1: length 2.1
  BOTTOM w0.305: UNK2J2.4 406.89,91.14 UNK2R28.2
S2_PA15_1: length 2
  BOTTOM w0.305: UNK2R40.2 UNK2SW5.6
S2_PA16_1: length 2
  BOTTOM w0.305: UNK2R41.2 UNK2SW5.7
S2_PA20: length 2.2
  TOP w0.152: SITE2.45 370.75,199.93 371.02,200.2 371.02,200.94 v1(371.15,201.07)
S2_PA21: length 1.6
  TOP w0.152: v1(371.58,200.41) 371.58,200.23 371.1,199.75 SITE2.46
S2_PA22: length 2.2
  TOP w0.152: SITE2.43 370.05,199.7 369.86,199.9 369.86,200.91 v1(370.01,201.07)
S2_PA23: length 1.4
  TOP w0.152: SITE2.44 370.4,200.37 v1(370.44,200.41)
S2_PA24: length 1.2
  TOP w0.152: SITE2.41 369.35,198.25 v1(369.06,197.95)
S2_PA25: length 1.2
  TOP w0.152: SITE2.42 369.7,198.25 v1(370,197.95)
S2_PA28: length 2.2
  TOP w0.152: SITE2.39 368.65,200.85 v1(368.86,201.07)
S2_PA29: length 1.5
  TOP w0.152: SITE2.40 369,200.11 v1(369.3,200.41)
S2_PB3: length 2.2
  TOP w0.152: v1(372.25,201.41) 373.29,201.41 373.55,201.15 SITE2.52
S2_PB3_AOUT_LP_2:
  vias: v2(474.93,223.14)
S2_PB4: length 1.4
  TOP w0.152: SITE2.51 v1(372.88,200.8)
S2_PB4_AOUT_LN_2:
  vias: v2(474.93,224.56)
S2_PB5: length 3.8
  TOP w0.152: SITE2.54 375.44,201.85 375.89,201.4 377.04,201.4 v1(377.69,202.05)
S2_PB5_AOUT_RP_2:
  vias: v2(474.93,230.4)
S2_PB6: length 2.1
  TOP w0.152: v1(376.31,202.05) 376.16,202.2 SITE2.55
S2_PB6_AOUT_RN_2:
  vias: v2(474.93,231.82)
S2_PB10_1: length 2
  BOTTOM w0.305: UNK2R37.2 UNK2SW5.4
S2_PB11_1: length 2
  BOTTOM w0.305: UNK2R39.2 UNK2SW5.5
S2_PB21_1: length 2
  BOTTOM w0.305: UNK2R36.2 UNK2SW5.3
S2_PB22_1: length 2
  BOTTOM w0.305: UNK2R35.2 UNK2SW5.2
S2_PB23: length 4.3
  TOP w0.249: 376.01,207.83 375.7,208.15 SITE2.72
  TOP w0.277: 376.01,207.83 v1(376.31,207.53)
  BOTTOM w0.277: UNK2R57.1 UNK2K4.3
S2_PB23_1:
  vias: v2(492.99,210.44)
S2_PB23_SICK:
  vias: v2(499.13,204.78)
S2_PB23_SICK_1: length 1.9
  BOTTOM w0.277: UNK2J1.3 UNK2R20.2
S2_PB24: length 4.2
  TOP w0.249: 376.09,208.68 375.91,208.5 SITE2.73
  TOP w0.277: 376.09,208.68 v1(376.31,208.9)
  BOTTOM w0.277: UNK2K4.6 UNK2R58.1
S2_PB24_1:
  vias: v2(492.99,203.18)
S2_PB24_SIDD:
  vias: v2(499.13,202.24)
S2_PB24_SIDD_1: length 1.9
  BOTTOM w0.277: UNK2J1.4 UNK2R21.2
S2_PB25: length 4.7
  TOP w0.249: SITE2.96 365.5,212.17
  TOP w0.277: v1(365.03,213.51) 365.5,213.04 365.5,212.17
  BOTTOM w0.277: UNK2K8.3 UNK2R59.1
S2_PB25_1:
  vias: v2(492.99,218.85)
S2_PB25_I2C_SCL:
  vias: v2(505.36,204.78)
S2_PB25_I2C_SCL_1: length 1.9
  BOTTOM w0.277: UNK2J3.3 UNK2R31.2
S2_PB26: length 4.1
  TOP w0.249: SITE2.97 365.15,210.2 364.95,210.01 364.95,209.63
  TOP w0.277: 364.95,209.63 v1(364.95,208.97)
  BOTTOM w0.277: UNK2K8.6 UNK2R60.1
S2_PB26_1:
  vias: v2(492.99,211.58)
S2_PB26_I2C_SDA:
  vias: v2(505.36,202.24)
S2_PB26_I2C_SDA_1: length 1.9
  BOTTOM w0.277: UNK2J3.4 UNK2R32.2
S2_RF_A: length 2.9
  TOP w0.277: UNK2C13.1 UNK2D3.1 UNK2C15.1 UNK2SMP3.1
S2_RF_G: length 5.9
  TOP w0.277: UNK2C7.1 UNK2D2.1 UNK2C8.1 UNK2SMP2.1
S2_RFIN_A: length 3.5
  TOP w0.249: SITE2.29 365.15,198.14 arc(365.2,197.91) v1(365.33,197.71)
  BOTTOM w0.277: UNK2R9.1 UNK2C16.2 364.8,196.44 arc(364.94,197.13) v1(365.33,197.71)
S2_RFIN_G: length 4.2
  TOP w0.249: SITE2.31 v1(365.85,197.18)
  BOTTOM w0.277: UNK2R5.1 UNK2C9.2 arc(366.44,196.4) 366.05,196.98 v1(365.85,197.18)
S2_RFIO_A: length 3.3
  TOP w0.249: 364.8,197.46 SITE2.28
  TOP w0.277: 364.8,197.46 UNK2C11.2 UNK2R6.1
S2_RFIO_BT: length 3.5
  TOP w0.249: SITE2.37 367.95,198.35 arc(367.98,198.21) 368.06,198.09
  TOP w0.277: 368.06,198.09 369.37,196.77 UNK2R1.1
S2_RFIO_G: length 4.1
  TOP w0.249: SITE2.32 366.2,198.25 arc(366.24,197.84) 366.36,197.46
  TOP w0.277: UNK2R2.1 UNK2C4.2 366.78,196.85 arc(366.54,197.13) 366.36,197.46
S2_RREF_MEM: length 7.2
  TOP w0.249: 375.42,204.16 375.21,203.95 SITE2.60
  TOP w0.277: 375.42,204.16 378.43,204.16 380.01,205.74 v1(380.73,205.74)
S2_SPI_CLK:
  vias: v2(458.19,210.66)
S2_SPI_CLK/PB28: length 4.3
  TOP w0.249: SITE2.90 367.6,212.64 367.47,212.78
  TOP w0.277: 367.47,212.78 367.09,213.16 367.09,213.82 367.77,214.5 v1(367.77,214.77)
S2_SPI_CS:
  vias: v2(453.01,231.08)
S2_SPI_CS/PC0: length 1.3
  TOP w0.249: SITE2.95 365.85,210.03 365.75,209.92
  TOP w0.277: 365.75,209.92 v1(365.65,209.83)
S2_SPI_D0/PB29: length 2.9
  TOP w0.249: 367.15,212.33 367.25,212.23 SITE2.91
  TOP w0.277: 367.15,212.33 366.4,213.08 v1(366.4,213.51)
S2_SPI_D1/PB31: length 2.2
  TOP w0.249: SITE2.94 366.2,209.65
  TOP w0.277: v1(365.9,208.96) 366.2,209.26 366.2,209.65
S2_SPI_D2/PB30: length 1.5
  TOP w0.249: 366.79,211.93 366.9,211.82 SITE2.92
  TOP w0.277: v1(366.4,212.14) 366.58,212.14 366.79,211.93
S2_SPI_D3/PB27: length 2.6
  TOP w0.249: SITE2.89 367.95,212.9
  TOP w0.277: 367.95,212.9 367.95,213.33 v1(367.77,213.51)
S2_SPI_DATA0:
  vias: v2(459.46,210.66)
S2_SPI_DATA1:
  vias: v2(454.28,231.08)
S2_SPI_DATA2:
  vias: v2(456.82,231.08)
S2_SPI_DATA3:
  vias: v2(455.65,210.66)
S2_U1_VC1: length 0.7
  TOP w0.152: UNK2U1.4 368.47,191.43
  TOP w0.277: 368.47,191.43 v1(367.84,191.43)
S2_U2_VC1: length 0.7
  TOP w0.152: UNK2U2.4 366.16,187.42
  TOP w0.277: 366.16,187.42 v1(365.53,187.42)
S2_VA09_MIPI: length 1.2
  TOP w0.249: SITE2.84 369.7,210.24
  TOP w0.254: 369.7,210.24 369.7,209.87
  TOP w0.381: 369.7,209.87 v1(369.67,209.84)
  vias: v1(371.2,214.77)
S2_VA09_PLL: length 1.3
  TOP w0.249: SITE2.11 363.3,205.7
  TOP w0.381: 363.3,205.7 v1(363.5,205.5)
  vias: v1(361.19,214.77)
S2_VA09_USB: length 1.3
  TOP w0.249: SITE2.77 372.15,210.09
  TOP w0.381: 372.15,210.09 v1(372.4,209.84)
  vias: v1(376.31,212.38)
S2_VA13_AFE: length 2.3
  TOP w0.249: 360.89,203.4 361.39,202.9 SITE2.19
  TOP w0.381: 360.89,203.4 v1(360.2,203.4)
  vias: v1(355.79,205.15)
S2_VA13_SYN: length 2.2
  TOP w0.249: SITE2.23 360.4,201.5 360.29,201.39
  TOP w0.381: 360.29,201.39 v1(360.2,201.29)
  vias: v1(363.33,201.66)
S2_VA33_SYN: length 5.9
  TOP w0.249: 360.53,200.61 361.08,201.15 SITE2.24
  TOP w0.381: 360.53,200.61 v1(360.2,200.61)
  BOTTOM w0.381: 360.02,200.61 v1(360.2,200.61)
  BOTTOM w0.508: UNK2BD13.2 358.95,198.82 359.51,199.38 359.51,200.1 360.02,200.61
S2_VA33_XTAL: length 7.1
  TOP w0.249: 360.74,202.74 360.93,202.55 SITE2.20
  TOP w0.381: 360.74,202.74 v1(360.2,202.74)
  BOTTOM w0.381: 359.83,202.74 v1(360.2,202.74)
  BOTTOM w0.508: 359.83,202.74 359.51,203.06 359.51,205.32 359.15,205.67 UNK2BD5.2
S2_VD09_CORE1: length 1.4
  TOP w0.249: SITE2.56 373.42,202.55 v1(373.06,202.19)
  vias: v1(380.73,201.38)
S2_VD09_CORE2: length 1.6
  TOP w0.249: SITE2.64 373.39,205.35 373.25,205.5
  TOP w0.381: 373.25,205.5 373.06,205.68 v1(373.06,205.91)
  vias: v1(376.31,210.27)
S2_VD09_CORE3: length 1.2
  TOP w0.249: 368.71,209.95 368.65,210.01 SITE2.87
  TOP w0.381: 368.71,209.95 v1(368.82,209.84)
  vias: v1(370.14,214.77)
S2_VD09_CORE4: length 4.7
  TOP w0.249: SITE2.98 364.8,212.02
  TOP w0.508: 364.8,212.02 364.8,212.37 v1(363.66,213.51)
  BOTTOM w0.508: UNK2R79.2 364.6,214.35 363.76,213.51 v1(363.66,213.51)
S2_VD13_FE: length 1.5
  TOP w0.249: 367.43,200.29 367.6,200.12 SITE2.36
  TOP w0.381: 367.43,200.29 v1(367.36,200.36)
  vias: v1(375.25,196.37)
S2_VD13_RF: length 2.5
  TOP w0.249: 360.56,199.92 361.44,200.8 SITE2.25
  TOP w0.381: 360.56,199.92 v1(360.2,199.92)
  vias: v1(363.33,200.62)
S2_VD33_ALL: length 0.8
  BOTTOM w0.508: UNK2BD5.1 356.67,205.49 v1(356.67,204.93)
  vias: v1(353.79,198.83) v1(354.76,205.15) v1(354.85,198.83) v1(356.81,208.92) v1(356.89,198.83) v1(357.29,211.59) v1(360.01,195.04) v1(360.15,215.76) v1(361.83,193.44) v1(362.23,215.76) v1(362.77,191.38) v1(366.81,215.76) v1(369.07,215.76) v1(374.32,214.77) v1(376.19,197.57) v1(376.19,194.23) v1(377.32,198.66) v1(377.32,197.57) v1(377.43,211.34) v1(378.6,211.34) v1(381.67,202.45) v2(450.32,210.66)
S2_VD33_CM_BT: length 1
  TOP w0.249: SITE2.35 367.25,198.12
  TOP w0.381: 367.25,198.12 v1(367.25,198.01)
  vias: v1(375.25,195.29) v1(375.25,194.23)
S2_VD33_EX_FLASH: length 9
  TOP w0.508: v2(454.14,211.66) v2(452.86,211.66) v2(451.59,211.66) 450.38,211.66 UNK2BD32.2
  BOTTOM w0.508: v2(454.14,211.66) 454.14,212.19 453.02,213.32 UNK2U3.8
  vias: v2(450.32,211.66) v2(455.55,231.08) v2(456.92,210.66)
S2_VD33_IO0: length 10.2
  TOP w0.249: SITE2.9 363.45,206.4
  TOP w0.381: 363.45,206.4 v1(363.5,206.35)
  BOTTOM w0.508: UNK2BD7.2 362.23,212.95 362.92,212.27 362.92,206.93 v1(363.5,206.35)
S2_VD33_IO2: length 7.2
  TOP w0.249: SITE2.59 375.63,203.6 375.81,203.42
  TOP w0.381: 375.81,203.42 v1(376.31,203.42)
  BOTTOM w0.381: 376.31,202.99 v1(376.31,203.42)
  BOTTOM w0.508: UNK2BD9.2 378.53,202.45 378.25,202.73 376.57,202.73 376.31,202.99
S2_VD33_IO3: length 7.8
  TOP w0.249: SITE2.70 373.1,207.45
  TOP w0.381: 373.1,207.45 v1(373.05,207.4)
  BOTTOM w0.508: v1(373.05,207.4) 373.4,207.4 374.07,208.07 374.07,210.55 374.85,211.34 UNK2BD11.2
S2_VD33_IO6: length 6.8
  TOP w0.249: 368.13,210.08 368.3,210.25 SITE2.88
  TOP w0.381: 368.13,210.08 v1(367.88,209.83)
  BOTTOM w0.508: v1(367.88,209.83) 368.59,210.54 368.59,214.28 UNK2BD12.2
S2_VD33_SPS_AUD: length 2.7
  TOP w0.249: SITE2.1 362.3,209.41
  TOP w0.508: 362.3,209.41 362.3,209.56 361.79,210.08 v1(360.2,210.08)
  vias: v1(356.63,210.92)
S2_VD33_SPS_DCORE: length 6.3
  TOP w0.249: SITE2.2 361.56,208.85 361.24,209.17
  TOP w0.381: 361.07,209.35 361.24,209.17 ; 358.37,208.5 UNK2C112.1 358.83,208.51 359.08,208.77
  TOP w0.508: 358.37,208.5 357.33,208.5 v1(356.81,207.98) ; 361.07,209.35 359.66,209.35 359.08,208.77
S2_VD33_SPS_MEM: length 4.7
  TOP w0.249: 372.65,211 SITE2.76
  TOP w0.381: 373.63,214.29 UNK2C126.1 373.76,213.77
  TOP w0.508: v1(373.38,214.77) 373.63,214.52 373.63,214.29 ; 373.76,213.77 373.76,211.76 373,211 372.65,211
S2_VD33PA_A: length 7.2
  TOP w0.249: SITE2.27 364.45,198.2 364.07,197.82
  TOP w0.381: 362.62,196.39 UNK2C100.1 363.05,196.59
  TOP w0.508: 364.07,197.82 363.05,196.79 363.05,196.59 ; 362.62,196.39 361.99,195.76 361.99,194.22 v1(362.77,193.44)
S2_VD33PA_BT: length 10.4
  TOP w0.249: 368.18,200.28 368.3,200.15 SITE2.38
  TOP w0.381: 368.18,200.28 v1(368.09,200.36)
  BOTTOM w0.508: v1(368.09,200.36) 368.71,199.74 371.81,199.74 372.9,198.66 UNK2C83.1 UNK2BD18.2
S2_VD33PA_G: length 10
  TOP w0.249: SITE2.33 366.55,199.7 366.38,199.87 366.12,199.87 365.76,200.24 v1(365.76,200.36)
  BOTTOM w0.508: UNK2BD15.2 UNK2C76.1 360.95,196.73 363.66,199.44 365.18,199.44 365.76,200.02 v1(365.76,200.36)
S2_VD33PAD_A: length 10.2
  TOP w0.249: 363.95,199 SITE2.26
  TOP w0.381: 361.27,192.08 UNK2C98.1 360.89,192.27
  TOP w0.508: 360.89,192.27 360.89,196.53 363.36,199 363.95,199 ; 361.27,192.08 361.54,192.08 361.83,191.79 v1(361.83,191.38)
S2_VD33PAD_G: length 1.5
  TOP w0.249: v1(366.58,200.36) 366.9,200.03 SITE2.34
  vias: v1(355.78,198.83) v1(355.78,197.76)
S2_VD1833_IO1: length 13
  TOP w0.249: SITE2.14 363.26,204.65
  TOP w0.381: 363.26,204.65 v1(363.5,204.65)
  BOTTOM w0.508: UNK2BD3.2 360.15,211.62 361.5,210.28 361.5,206.2 363.05,204.65 v1(363.5,204.65)
S2_VD1833_SDIO: length 7.9
  TOP w0.249: SITE2.93 366.55,210.22 366.68,210.08
  TOP w0.381: 366.68,210.08 v1(366.94,209.83)
  BOTTOM w0.508: UNK2BD29.2 UNK2C118.1 365.72,211.04 v1(366.94,209.83)
S2_VD_MEM0: length 9.6
  TOP w0.249: SITE2.61 373.57,204.3 373.06,203.79
  TOP w0.381: 373.06,203.79 v1(373.06,203.7)
  BOTTOM w0.508: v1(373.06,203.7) 374.82,203.7 375.23,204.11 379.38,204.11 379.97,203.52 UNK2R81.2
S2_VD_MEM1: length 10
  TOP w0.249: SITE2.62 373.36,204.65
  TOP w0.254: 373.11,204.54 373.22,204.65 373.36,204.65
  TOP w0.381: 373.11,204.54 v1(373.05,204.49)
  BOTTOM w0.508: UNK2R82.2 380.73,206.85 375.41,206.85 v1(373.05,204.49)
S2_VD_MEM2: length 7.4
  TOP w0.249: 375.94,204.79 375.03,205.7 SITE2.65
  TOP w0.381: 375.94,204.79 v1(376.31,204.79)
  BOTTOM w0.381: 376.55,205.02 v1(376.31,204.79)
  BOTTOM w0.508: UNK2R83.2 380.25,204.64 379.48,205.41 376.94,205.41 376.55,205.02
S2_VDD09: length 2
  BOTTOM w0.277: UNK2K22.5 UNK2R48.1
S2_VDD18_A: length 6.1
  BOTTOM w0.508: S2_VDD18_A.1 UNK2K25.5 UNK2R55.1
S2_VDD18_D: length 2.3
  BOTTOM w0.508: UNK2R53.1 UNK2K28.5
  vias: v2(470.05,210.55)
S2_VDD33: length 2.2
  TOP w0.152: UNK2U1.6 369.3,191.43 ; UNK2U2.6 366.99,187.42
  TOP w0.277: 369.3,191.43 v1(369.94,191.43) ; 366.99,187.42 v1(367.63,187.42)
  BOTTOM w0.254: UNK2BD33.2 v2(411.31,84.71)
  vias: v2(393.5,83.12) v2(407.91,83.54) v2(410.22,85.56) v2(485.58,128.87) v2(499.13,209.86) v2(505.36,209.86)
S2_VDD33_J1: length 1.9
  BOTTOM w0.277: UNK2J1.1 UNK2R19.2
S2_VDD33_J2: length 2.1
  BOTTOM w0.305: UNK2J2.1 404.83,83.54 UNK2R24.2
S2_VDD33_J3: length 1.9
  BOTTOM w0.277: UNK2J3.1 UNK2R30.2
S2_VREF_DRAM: length 1.9
  TOP w0.249: SITE2.63 372.79,205 372.73,205.06
  TOP w0.381: 372.73,205.06 v1(372.55,205.25)
S2_XI: length 8.5
  TOP w0.249: 358.07,201.85 SITE2.22
  TOP w0.277: 358.07,201.85 357.3,201.85 UNK2C25.2 UNK2Y1.1
S2_XO: length 8.5
  TOP w0.249: SITE2.21 358.56,202.2
  TOP w0.254: 358.56,202.2 358.37,202.39
  TOP w0.277: 358.37,202.39 357.85,202.91 UNK2C23.2 356.07,202.91 355.81,203.17 354.58,203.17 UNK2Y1.3
S3_1_AOUT_LN: length 4.6
  BOTTOM w0.152: UNK3R67.1 UNK3R68.1 UNK3R45.1 470.47,191.27 UNK3K10.4
S3_1_AOUT_LP: length 4.6
  BOTTOM w0.152: UNK3R70.1 UNK3R69.1 UNK3R75.1 470.47,187.85 UNK3K10.5
S3_1_AOUT_RN: length 4.6
  BOTTOM w0.152: UNK3K14.4 470.47,198.53 UNK3R47.1 UNK3R64.1 UNK3R63.1
S3_1_AOUT_RP: length 4.6
  BOTTOM w0.152: UNK3R66.1 UNK3R65.1 UNK3R74.1 470.47,195.11 UNK3K14.5
S3_1_SPI_CLK: length 6.2
  BOTTOM w0.277: UNK3U3.6 455.56,179.2 456.25,178.51 457.05,178.51 v2(458.19,177.37)
S3_1_SPI_CS: length 3.2
  BOTTOM w0.277: UNK3U3.1 v2(453.01,195.79)
S3_1_SPI_DATA0: length 6.1
  BOTTOM w0.277: UNK3U3.5 456.83,179.43 457.11,179.15 457.69,179.15 v2(459.46,177.37)
S3_1_SPI_DATA1: length 3.2
  BOTTOM w0.277: UNK3U3.2 v2(454.28,195.79)
S3_1_SPI_DATA2: length 5.6
  TOP w0.277: v2(455.55,195.79) UNK3R16.2 UNK3R18.2
  BOTTOM w0.277: UNK3U3.3 v2(455.55,195.79)
S3_1_SPI_DATA3: length 6.5
  TOP w0.277: v2(455.65,177.37) UNK3R12.1
  BOTTOM w0.277: v2(455.65,177.37) 455.65,177.94 454.29,179.31 UNK3U3.7
S3_1_VDD09:
  vias: v1(383.96,197.09) v1(401.19,215.76) v1(404.32,215.77) v1(410.14,215.76) v1(411.2,215.76) v1(417.43,212.38) v1(417.43,210.27) v1(418.6,212.38) v1(421.67,201.38)
S3_1_VDD18_A: length 6.5
  TOP w0.61: UNK3K26.2 427.74,175.14 423.9,175.14 UNK3R50.1
S3_1_VDD18_D:
  vias: v1(421.67,206.84) v1(421.67,204.64) v1(421.67,203.52) v1(422.96,206.84) v2(407.84,233.09)
S3_2_AOUT_LN:
  vias: v2(473.76,190.27)
S3_2_AOUT_LP:
  vias: v2(473.76,188.85)
S3_2_AOUT_RN:
  vias: v2(473.76,197.53)
S3_2_AOUT_RP:
  vias: v2(473.76,196.11)
S3_2_VDD18_A: length 0.9
  BOTTOM w0.508: UNK3BD20.1 v1(395.79,206.99)
  vias: v1(394.76,206.99) v1(404.37,201.66) v1(404.37,200.62) v1(416.19,196.37) v2(423.65,173.88)
S3_ATX_VD0V9:
  vias: v2(452.91,171.81) v2(452.91,170.03)
S3_ATX_VD33: length 0.9
  BOTTOM w0.254: UNK3BD33.1 v2(449.7,87.35)
  vias: v2(452.5,88.62) v2(452.5,86.06) v2(452.5,83.49)
S3_AVCC_DRV: length 6.1
  TOP w0.249: SITE3.53 415.06,201.5 415.89,200.67
  TOP w0.381: 415.89,200.67 UNK3C75.1 416.44,200.24 416.82,199.86 418.48,199.86 418.86,200.25 UNK3C110.1
  vias: v1(419.06,200.67) v2(396.15,234.23)
S3_CHIP_EN_1: length 2
  BOTTOM w0.305: UNK3R34.2 UNK3SW5.1
S3_DPS_F001:
  vias: v2(421.42,178.74) v2(421.42,176.96)
S3_DPS_F002:
  vias: v2(433.88,171.07) v2(434.86,168.65) v2(434.86,166.87)
S3_DPS_F004:
  vias: v2(435.19,190.37) v2(435.19,188.59)
S3_DPS_F006:
  vias: v2(416.84,174.69) v2(416.84,173.67) v2(416.84,172.12) v2(416.84,171.11) v2(416.84,169.53) v2(416.84,168.51)
S3_HSDM: length 3.1
  TOP w0.249: SITE3.79 411.45,212.22
  TOP w0.305: 411.45,212.22 412.39,213.16 v1(412.94,213.16)
S3_HSDP: length 2.1
  TOP w0.249: SITE3.78 411.8,211.77 411.92,211.89
  TOP w0.305: v1(412.94,212.14) 412.17,212.14 411.92,211.89
S3_LPC_024: length 3.4
  TOP w0.249: 415.28,207.32 415.06,207.1 SITE3.69
  TOP w0.277: 415.28,207.32 v1(415.49,207.53)
  BOTTOM w0.305: UNK3R35.1 UNK3J4.2
S3_LPC_025: length 3.5
  TOP w0.249: 413.26,208.05 413.51,207.8 SITE3.71
  TOP w0.277: 413.26,208.05 413.26,208.05 v1(413.05,208.25)
  BOTTOM w0.305: UNK3R34.1 UNK3J4.1
S3_LPC_041: length 5.7
  TOP w0.249: SITE3.68 416.66,206.75
  TOP w0.277: 416.66,206.75 417.1,206.75 v1(417.69,206.16)
  BOTTOM w0.305: UNK3R36.1 UNK3J4.3
S3_LPC_042: length 0.9
  TOP w0.249: SITE3.50 412.5,199.17 412.68,199.35
  TOP w0.277: 412.68,199.35 v1(413.2,199.35)
S3_LPC_044: length 3.9
  TOP w0.249: SITE3.58 413.46,203.25
  TOP w0.277: v1(412.55,202.94) 413.15,202.94 413.46,203.25
  BOTTOM w0.305: UNK3R39.1 UNK3J4.5
S3_LPC_046: length 2.1
  TOP w0.249: 416.18,206.3 416.07,206.4 SITE3.67
  TOP w0.277: 416.18,206.3 v1(416.31,206.16)
S3_LPC_047: length 3.5
  TOP w0.249: SITE3.18 403.44,203.25
  TOP w0.277: 403.44,203.25 v1(403.64,203.46)
  BOTTOM w0.305: UNK3R41.1 UNK3J4.7
S3_LPC_049: length 5.2
  TOP w0.249: SITE3.8 401.07,206.75
  TOP w0.277: 401.07,206.75 400.58,207.24 398.14,207.24 v1(397.58,206.68)
S3_LPC_050: length 2.4
  TOP w0.249: 401.07,207.49 401.46,207.1 SITE3.7
  TOP w0.277: 401.07,207.49 400.76,207.8 v1(400.2,207.8)
S3_LPC_051: length 2
  TOP w0.249: 412.36,199.94 412.15,199.73 SITE3.49
  TOP w0.277: v1(413.2,200.2) 412.63,200.2 412.36,199.94
S3_LPC_052: length 2.4
  TOP w0.249: SITE3.48 411.8,198.15 411.95,198
  TOP w0.277: v1(413.2,197.97) 413.06,197.84 412.12,197.84 411.95,198
S3_LPC_053: length 7.2
  TOP w0.249: 415.69,202.68 415.46,202.9 SITE3.57
  TOP w0.277: v1(419.06,203.42) 418.32,202.68 415.69,202.68
  BOTTOM w0.305: UNK3R37.1 UNK3J4.4
S3_LPC_055: length 2.4
  TOP w0.249: SITE3.10 400.83,206.05
  TOP w0.277: 400.83,206.05 v1(400.2,206.68)
S3_LPC_058: length 4.4
  TOP w0.249: SITE3.17 403.06,203.6 403.31,203.85
  TOP w0.277: v1(404.37,203.83) 404.19,204.01 403.47,204.01 403.31,203.85
  BOTTOM w0.305: UNK3R40.1 UNK3J4.6
S3_LPC_060: length 5.2
  TOP w0.249: 415.93,205.51 415.39,206.05 SITE3.66
  TOP w0.277: v1(419.06,206.16) 418.41,205.51 415.93,205.51
S3_LX_AUD: length 6.2
  TOP w0.249: 403.78,211 SITE3.100
  TOP w0.864: 403.47,211 403.78,211
  TOP w1.016: 403.47,211 401.99,212.48 401.99,214.04 403.33,215.38
S3_LX_DCORE: length 2.2
  TOP w0.249: SITE3.3 400.97,208.5
  TOP w0.508: 400.97,208.5 400.85,208.63 v1(400.74,208.63) v1(400.2,208.63)
S3_LX_MEM: length 1.9
  TOP w0.249: SITE3.75 414.84,209.2 415.1,209.46
  TOP w0.508: 415.1,209.46 v1(415.1,209.85) v1(415.1,210.48)
S3_MIPITX_CKN: length 1.3
  TOP w0.249: 410.52,211.89 410.4,211.77 SITE3.82
  TOP w0.277: 410.52,211.89 v1(410.77,212.14)
S3_MIPITX_CKP: length 2.8
  TOP w0.249: SITE3.83 410.05,212.11
  TOP w0.277: v1(410.77,213.51) 410.05,212.79 410.05,212.11
S3_MIPITX_DATAN_0: length 1.2
  TOP w0.249: SITE3.85 409.35,212.09
  TOP w0.277: 409.35,212.09 v1(409.4,212.14)
S3_MIPITX_DATAN_1: length 2.3
  TOP w0.249: SITE3.80 411.1,210.21 411.28,210.03
  TOP w0.277: 411.28,210.03 411.28,209.44 v1(410.83,208.99)
S3_MIPITX_DATAP_0: length 2.8
  TOP w0.249: 408.82,212.19 408.82,211.93 409,211.75 SITE3.86
  TOP w0.277: 408.82,212.19 408.82,212.94 v1(409.4,213.51)
S3_MIPITX_DATAP_1: length 1.2
  TOP w0.249: 410.68,209.97 410.75,210.04 SITE3.81
  TOP w0.277: 410.68,209.97 v1(410.58,209.86)
S3_PA2: length 2.1
  TOP w0.249: SITE3.5 404.09,207.8
  TOP w0.277: 404.09,207.8 v1(404.34,207.55)
S3_PA3: length 1.4
  TOP w0.249: 403.44,207.35 403.34,207.45 SITE3.6
  TOP w0.277: 403.44,207.35 v1(403.61,207.17)
S3_PA9_CH: length 4
  TOP w0.249: 400.67,205.52 400.85,205.35 SITE3.12
  TOP w0.277: v1(398.83,206.68) 399.85,205.66 400.53,205.66 400.67,205.52
S3_PA10_CH: length 2.1
  TOP w0.249: SITE3.13 400.27,205
  TOP w0.277: 400.27,205 v1(400.2,204.93)
S3_PA13: length 3.7
  TOP w0.249: 399.82,204.5 400.02,204.3 SITE3.15
  TOP w0.277: 399.82,204.5 399.39,204.93 v1(398.83,204.93)
S3_PA13_UART_RX: length 14
  BOTTOM w0.305: UNK3K6.2 451.93,98.04 451.93,94.26 UNK3R27.1
S3_PA13_UART_RX_1: length 2.1
  BOTTOM w0.305: UNK3J2.3 445.28,88.6 UNK3R27.2
S3_PA14: length 5.3
  TOP w0.249: 399.21,204.34 399.6,203.95 SITE3.16
  TOP w0.277: 399.21,204.34 398.45,204.34 397.86,204.93 v1(397.46,204.93)
S3_PA14_UART_TX: length 10.1
  BOTTOM w0.305: UNK3R28.1 448.4,93.27 448.4,97.71 UNK3K6.7
S3_PA14_UART_TX_1: length 2.1
  BOTTOM w0.305: UNK3R28.2 445.28,91.14 UNK3J2.4
S3_PA15_1: length 2
  BOTTOM w0.305: UNK3R40.2 UNK3SW5.6
S3_PA16_1: length 2
  BOTTOM w0.305: UNK3R41.2 UNK3SW5.7
S3_PA20: length 2.2
  TOP w0.152: v1(411.15,201.07) 411.02,200.94 411.02,200.2 410.75,199.93 SITE3.45
S3_PA21: length 1.6
  TOP w0.152: v1(411.58,200.41) 411.58,200.23 411.1,199.75 SITE3.46
S3_PA22: length 2.2
  TOP w0.152: SITE3.43 410.05,199.7 409.86,199.9 409.86,200.91 v1(410.01,201.07)
S3_PA23: length 1.4
  TOP w0.152: v1(410.44,200.41) 410.4,200.37 SITE3.44
S3_PA24: length 1.2
  TOP w0.152: v1(409.06,197.95) 409.35,198.25 SITE3.41
S3_PA25: length 1.2
  TOP w0.152: SITE3.42 409.7,198.25 v1(410,197.95)
S3_PA28: length 2.2
  TOP w0.152: SITE3.39 408.65,200.85 v1(408.86,201.07)
S3_PA29: length 1.5
  TOP w0.152: v1(409.3,200.41) 409,200.11 SITE3.40
S3_PB3: length 2.2
  TOP w0.152: SITE3.52 413.55,201.15 413.28,201.41 v1(412.25,201.41)
S3_PB3_AOUT_LP_2:
  vias: v2(474.93,188.85)
S3_PB4: length 1.4
  TOP w0.152: SITE3.51 v1(412.88,200.8)
S3_PB4_AOUT_LN_2:
  vias: v2(474.93,190.27)
S3_PB5: length 3.8
  TOP w0.152: SITE3.54 415.44,201.85 415.89,201.4 417.04,201.4 v1(417.69,202.05)
S3_PB5_AOUT_RP_2:
  vias: v2(474.93,196.11)
S3_PB6: length 2.1
  TOP w0.152: SITE3.55 416.16,202.2 v1(416.31,202.05)
S3_PB6_AOUT_RN_2:
  vias: v2(474.93,197.53)
S3_PB10_1: length 2
  BOTTOM w0.305: UNK3R37.2 UNK3SW5.4
S3_PB11_1: length 2
  BOTTOM w0.305: UNK3R39.2 UNK3SW5.5
S3_PB21_1: length 2
  BOTTOM w0.305: UNK3R36.2 UNK3SW5.3
S3_PB22_1: length 2
  BOTTOM w0.305: UNK3R35.2 UNK3SW5.2
S3_PB23: length 4.3
  TOP w0.249: SITE3.72 415.7,208.15 416.01,207.83
  TOP w0.277: 416.01,207.83 v1(416.31,207.53)
  BOTTOM w0.277: UNK3R57.1 UNK3K4.3
S3_PB23_1:
  vias: v2(492.99,176.15)
S3_PB23_SICK:
  vias: v2(499.13,170.49)
S3_PB23_SICK_1: length 1.9
  BOTTOM w0.277: UNK3J1.3 UNK3R20.2
S3_PB24: length 4.2
  TOP w0.249: SITE3.73 415.91,208.5 416.09,208.68
  TOP w0.277: 416.09,208.68 v1(416.31,208.9)
  BOTTOM w0.277: UNK3K4.6 UNK3R58.1
S3_PB24_1:
  vias: v2(492.99,168.89)
S3_PB24_SIDD:
  vias: v2(499.13,167.95)
S3_PB24_SIDD_1: length 1.9
  BOTTOM w0.277: UNK3J1.4 UNK3R21.2
S3_PB25: length 4.7
  TOP w0.249: SITE3.96 405.5,212.17
  TOP w0.277: v1(405.03,213.51) 405.5,213.04 405.5,212.17
  BOTTOM w0.277: UNK3K8.3 UNK3R59.1
S3_PB25_1:
  vias: v2(492.99,184.56)
S3_PB25_I2C_SCL:
  vias: v2(505.36,170.49)
S3_PB25_I2C_SCL_1: length 1.9
  BOTTOM w0.277: UNK3J3.3 UNK3R31.2
S3_PB26: length 4.1
  TOP w0.249: 404.95,209.63 404.95,210.01 405.15,210.2 SITE3.97
  TOP w0.277: 404.95,209.63 v1(404.95,208.97)
  BOTTOM w0.277: UNK3K8.6 UNK3R60.1
S3_PB26_1:
  vias: v2(492.99,177.29)
S3_PB26_I2C_SDA:
  vias: v2(505.36,167.95)
S3_PB26_I2C_SDA_1: length 1.9
  BOTTOM w0.277: UNK3J3.4 UNK3R32.2
S3_RF_A: length 2.9
  TOP w0.277: UNK3SMP3.1 UNK3C15.1 UNK3D3.1 UNK3C14.1
S3_RF_G: length 5.9
  TOP w0.277: UNK3C7.1 UNK3D2.1 UNK3C8.1 UNK3SMP2.1
S3_RFIN_A: length 3.5
  TOP w0.249: SITE3.29 405.15,198.14 arc(405.2,197.91) v1(405.33,197.71)
  BOTTOM w0.277: UNK3R9.1 UNK3C16.2 404.8,196.44 arc(404.94,197.13) v1(405.33,197.71)
S3_RFIN_G: length 4.2
  TOP w0.249: SITE3.31 v1(405.85,197.18)
  BOTTOM w0.277: v1(405.85,197.18) 406.05,196.98 arc(406.44,196.4) UNK3C9.2 UNK3R5.1
S3_RFIO_A: length 3.3
  TOP w0.249: 404.8,197.46 SITE3.28
  TOP w0.277: 404.8,197.46 UNK3C11.2 UNK3R6.1
S3_RFIO_BT: length 3.5
  TOP w0.249: SITE3.37 407.95,198.35 arc(407.98,198.21) 408.06,198.09
  TOP w0.277: 408.06,198.09 409.37,196.77 UNK3R1.1
S3_RFIO_G: length 4.1
  TOP w0.249: SITE3.32 406.2,198.25 arc(406.24,197.84) 406.36,197.46
  TOP w0.277: UNK3R2.1 UNK3C4.2 406.78,196.85 arc(406.54,197.13) 406.36,197.46
S3_RREF_MEM: length 7.2
  TOP w0.249: 415.42,204.16 415.21,203.95 SITE3.60
  TOP w0.277: 415.42,204.16 418.43,204.16 420.01,205.74 v1(420.73,205.74)
S3_SPI_CLK:
  vias: v2(458.19,176.37)
S3_SPI_CLK/PB28: length 4.3
  TOP w0.249: 407.47,212.78 407.6,212.64 SITE3.90
  TOP w0.277: 407.47,212.78 407.09,213.16 407.09,213.82 407.77,214.5 v1(407.77,214.77)
S3_SPI_CS:
  vias: v2(453.01,196.79)
S3_SPI_CS/PC0: length 1.3
  TOP w0.249: 405.75,209.92 405.85,210.03 SITE3.95
  TOP w0.277: 405.75,209.92 v1(405.65,209.83)
S3_SPI_D0/PB29: length 2.9
  TOP w0.249: 407.15,212.33 407.25,212.23 SITE3.91
  TOP w0.277: 407.15,212.33 406.4,213.08 v1(406.4,213.51)
S3_SPI_D1/PB31: length 2.2
  TOP w0.249: SITE3.94 406.2,209.65
  TOP w0.277: 406.2,209.65 406.2,209.26 v1(405.9,208.96)
S3_SPI_D2/PB30: length 1.5
  TOP w0.249: SITE3.92 406.9,211.82 406.79,211.93
  TOP w0.277: v1(406.4,212.14) 406.58,212.14 406.79,211.93
S3_SPI_D3/PB27: length 2.6
  TOP w0.249: SITE3.89 407.95,212.9
  TOP w0.277: v1(407.77,213.51) 407.95,213.33 407.95,212.9
S3_SPI_DATA0:
  vias: v2(459.46,176.37)
S3_SPI_DATA1:
  vias: v2(454.28,196.79)
S3_SPI_DATA2:
  vias: v2(456.82,196.79)
S3_SPI_DATA3:
  vias: v2(455.65,176.37)
S3_U1_VC1: length 0.7
  TOP w0.152: UNK3U1.4 408.47,191.43
  TOP w0.277: 408.47,191.43 v1(407.84,191.43)
S3_U2_VC1: length 0.7
  TOP w0.152: UNK3U2.4 406.16,187.42
  TOP w0.277: 406.16,187.42 v1(405.53,187.42)
S3_VA09_MIPI: length 1.2
  TOP w0.249: SITE3.84 409.7,210.24
  TOP w0.254: 409.7,210.24 409.7,209.87
  TOP w0.381: 409.7,209.87 v1(409.67,209.84)
  vias: v1(411.2,214.77)
S3_VA09_PLL: length 1.3
  TOP w0.249: SITE3.11 403.3,205.7
  TOP w0.381: 403.3,205.7 v1(403.5,205.5)
  vias: v1(401.19,214.77)
S3_VA09_USB: length 1.3
  TOP w0.249: SITE3.77 412.15,210.09
  TOP w0.381: 412.15,210.09 v1(412.4,209.84)
  vias: v1(416.31,212.38)
S3_VA13_AFE: length 2.3
  TOP w0.249: SITE3.19 401.39,202.9 400.89,203.4
  TOP w0.381: 400.89,203.4 v1(400.2,203.4)
  vias: v1(395.79,205.15)
S3_VA13_SYN: length 2.2
  TOP w0.249: 400.29,201.39 400.4,201.5 SITE3.23
  TOP w0.381: 400.29,201.39 v1(400.2,201.29)
  vias: v1(403.33,201.66)
S3_VA33_SYN: length 5.9
  TOP w0.249: 400.53,200.61 401.08,201.15 SITE3.24
  TOP w0.381: 400.53,200.61 v1(400.2,200.61)
  BOTTOM w0.381: 400.02,200.61 v1(400.2,200.61)
  BOTTOM w0.508: 400.02,200.61 399.51,200.1 399.51,199.38 398.95,198.82 UNK3BD13.2
S3_VA33_XTAL: length 7.1
  TOP w0.249: SITE3.20 400.93,202.55 400.74,202.74
  TOP w0.381: 400.74,202.74 v1(400.2,202.74)
  BOTTOM w0.381: 399.83,202.74 v1(400.2,202.74)
  BOTTOM w0.508: UNK3BD5.2 399.15,205.67 399.51,205.32 399.51,203.06 399.83,202.74
S3_VD09_CORE1: length 1.4
  TOP w0.249: v1(413.06,202.19) 413.42,202.55 SITE3.56
  vias: v1(420.73,201.38)
S3_VD09_CORE2: length 1.6
  TOP w0.249: 413.25,205.5 413.39,205.35 SITE3.64
  TOP w0.381: v1(413.06,205.91) 413.06,205.68 413.25,205.5
  vias: v1(416.31,210.27)
S3_VD09_CORE3: length 1.2
  TOP w0.249: SITE3.87 408.65,210.01 408.71,209.95
  TOP w0.381: 408.71,209.95 v1(408.82,209.84)
  vias: v1(410.14,214.77)
S3_VD09_CORE4: length 4.7
  TOP w0.249: SITE3.98 404.8,212.02
  TOP w0.508: 404.8,212.02 404.8,212.37 v1(403.66,213.51)
  BOTTOM w0.508: v1(403.66,213.51) 403.76,213.51 404.6,214.35 UNK3R79.2
S3_VD13_FE: length 1.5
  TOP w0.249: 407.43,200.29 407.6,200.12 SITE3.36
  TOP w0.381: 407.43,200.29 v1(407.36,200.36)
  vias: v1(415.25,196.37)
S3_VD13_RF: length 2.5
  TOP w0.249: SITE3.25 401.44,200.8 400.56,199.92
  TOP w0.381: 400.56,199.92 v1(400.2,199.92)
  vias: v1(403.33,200.62)
S3_VD33_ALL: length 0.8
  BOTTOM w0.508: UNK3BD5.1 396.67,205.49 v1(396.67,204.93)
  vias: v1(393.79,198.83) v1(394.76,205.15) v1(394.85,198.83) v1(396.81,208.92) v1(396.89,198.83) v1(397.29,211.59) v1(400.01,195.04) v1(400.15,215.76) v1(401.83,193.44) v1(402.23,215.76) v1(402.77,191.38) v1(406.81,215.76) v1(409.07,215.76) v1(414.32,214.77) v1(416.19,197.57) v1(416.19,194.23) v1(417.32,198.66) v1(417.32,197.57) v1(417.43,211.34) v1(418.6,211.34) v1(421.67,202.45) v2(450.32,176.37)
S3_VD33_CM_BT: length 1
  TOP w0.249: SITE3.35 407.25,198.12
  TOP w0.381: 407.25,198.12 v1(407.25,198.01)
  vias: v1(415.25,195.29) v1(415.25,194.23)
S3_VD33_EX_FLASH: length 9
  TOP w0.508: UNK3BD32.2 450.38,177.37 v2(451.59,177.37) v2(452.86,177.37) v2(454.14,177.37)
  BOTTOM w0.508: UNK3U3.8 453.02,179.03 454.14,177.9 v2(454.14,177.37)
  vias: v2(450.32,177.37) v2(455.55,196.79) v2(456.92,176.37)
S3_VD33_IO0: length 10.2
  TOP w0.249: SITE3.9 403.45,206.4
  TOP w0.381: 403.45,206.4 v1(403.5,206.35)
  BOTTOM w0.508: UNK3BD7.2 402.23,212.95 402.92,212.27 402.92,206.93 v1(403.5,206.35)
S3_VD33_IO2: length 7.2
  TOP w0.249: 415.81,203.42 415.63,203.6 SITE3.59
  TOP w0.381: 415.81,203.42 v1(416.31,203.42)
  BOTTOM w0.381: 416.31,202.99 v1(416.31,203.42)
  BOTTOM w0.508: UNK3BD9.2 418.53,202.45 418.25,202.73 416.57,202.73 416.31,202.99
S3_VD33_IO3: length 7.8
  TOP w0.249: SITE3.70 413.1,207.45
  TOP w0.381: 413.1,207.45 v1(413.05,207.4)
  BOTTOM w0.508: v1(413.05,207.4) 413.4,207.4 414.07,208.07 414.07,210.55 414.85,211.34 UNK3BD11.2
S3_VD33_IO6: length 6.8
  TOP w0.249: SITE3.88 408.3,210.25 408.13,210.08
  TOP w0.381: 408.13,210.08 v1(407.88,209.83)
  BOTTOM w0.508: v1(407.88,209.83) 408.59,210.54 408.59,214.28 UNK3BD12.2
S3_VD33_SPS_AUD: length 2.7
  TOP w0.249: SITE3.1 402.3,209.41
  TOP w0.508: 402.3,209.41 402.3,209.56 401.79,210.08 v1(400.2,210.08)
  vias: v1(396.63,210.92)
S3_VD33_SPS_DCORE: length 6.3
  TOP w0.249: SITE3.2 401.56,208.85 401.24,209.17
  TOP w0.381: 398.37,208.5 UNK3C112.1 398.83,208.51 399.08,208.77 ; 401.07,209.35 401.24,209.17
  TOP w0.508: 398.37,208.5 397.33,208.5 v1(396.81,207.98) ; 399.08,208.77 399.66,209.35 401.07,209.35
S3_VD33_SPS_MEM: length 4.7
  TOP w0.249: 412.65,211 SITE3.76
  TOP w0.381: 413.76,213.77 UNK3C126.1 413.63,214.29
  TOP w0.508: 413.63,214.29 413.63,214.52 v1(413.38,214.77) ; 413.76,213.77 413.76,211.76 413,211 412.65,211
S3_VD33PA_A: length 7.2
  TOP w0.249: SITE3.27 404.45,198.2 404.07,197.82
  TOP w0.381: 403.05,196.59 UNK3C100.1 402.62,196.39
  TOP w0.508: v1(402.77,193.44) 401.99,194.22 401.99,195.76 402.62,196.39 ; 404.07,197.82 403.05,196.79 403.05,196.59
S3_VD33PA_BT: length 10.4
  TOP w0.249: 408.18,200.28 408.3,200.15 SITE3.38
  TOP w0.381: 408.18,200.28 v1(408.09,200.36)
  BOTTOM w0.508: UNK3BD18.2 UNK3C83.1 412.9,198.66 411.81,199.74 408.71,199.74 v1(408.09,200.36)
S3_VD33PA_G: length 10
  TOP w0.249: v1(405.76,200.36) 405.76,200.24 406.12,199.87 406.38,199.87 406.55,199.7 SITE3.33
  BOTTOM w0.508: v1(405.76,200.36) 405.76,200.02 405.18,199.44 403.66,199.44 400.95,196.73 UNK3C76.1 UNK3BD15.2
S3_VD33PAD_A: length 10.2
  TOP w0.249: 403.95,199 SITE3.26
  TOP w0.381: 400.89,192.27 UNK3C98.1 401.27,192.08
  TOP w0.508: 403.95,199 403.36,199 400.89,196.53 400.89,192.27 ; v1(401.83,191.38) 401.83,191.79 401.54,192.08 401.27,192.08
S3_VD33PAD_G: length 1.5
  TOP w0.249: v1(406.58,200.36) 406.9,200.03 SITE3.34
  vias: v1(395.78,198.83) v1(395.78,197.76)
S3_VD1833_IO1: length 13
  TOP w0.249: SITE3.14 403.26,204.65
  TOP w0.381: 403.26,204.65 v1(403.5,204.65)
  BOTTOM w0.508: UNK3BD3.2 400.15,211.62 401.5,210.28 401.5,206.2 403.05,204.65 v1(403.5,204.65)
S3_VD1833_SDIO: length 7.9
  TOP w0.249: 406.68,210.08 406.55,210.22 SITE3.93
  TOP w0.381: 406.68,210.08 v1(406.94,209.83)
  BOTTOM w0.508: v1(406.94,209.83) 405.72,211.04 UNK3C118.1 UNK3BD29.2
S3_VD_MEM0: length 9.6
  TOP w0.249: 413.06,203.79 413.57,204.3 SITE3.61
  TOP w0.381: 413.06,203.79 v1(413.06,203.7)
  BOTTOM w0.508: UNK3R81.2 419.97,203.52 419.38,204.11 415.23,204.11 414.82,203.7 v1(413.06,203.7)
S3_VD_MEM1: length 10
  TOP w0.249: SITE3.62 413.36,204.65
  TOP w0.254: 413.36,204.65 413.22,204.65 413.11,204.54
  TOP w0.381: 413.11,204.54 v1(413.05,204.49)
  BOTTOM w0.508: v1(413.05,204.49) 415.41,206.85 420.73,206.85 UNK3R82.2
S3_VD_MEM2: length 7.4
  TOP w0.249: 415.94,204.79 415.03,205.7 SITE3.65
  TOP w0.381: 415.94,204.79 v1(416.31,204.79)
  BOTTOM w0.381: 416.55,205.02 v1(416.31,204.79)
  BOTTOM w0.508: UNK3R83.2 420.25,204.64 419.48,205.41 416.94,205.41 416.55,205.02
S3_VDD09: length 2
  BOTTOM w0.277: UNK3K22.5 UNK3R48.1
S3_VDD18_A: length 6.1
  BOTTOM w0.508: UNK3R55.1 UNK3K25.5 S3_VDD18_A.1
S3_VDD18_D: length 2.3
  BOTTOM w0.508: UNK3R53.1 UNK3K28.5
  vias: v2(470.05,176.26)
S3_VDD33: length 3.1
  TOP w0.152: UNK3U1.6 409.3,191.43 ; UNK3U2.6 406.99,187.42
  TOP w0.277: 406.99,187.42 v1(407.63,187.42) ; 409.3,191.43 v1(409.94,191.43)
  BOTTOM w0.254: UNK3BD33.2 v2(449.7,84.71) ; UNK3R24.1 v2(447.15,83.54)
  vias: v2(414.97,128.74) v2(431.89,83.12) v2(448.6,85.56) v2(499.13,175.57) v2(505.36,175.57)
S3_VDD33_J1: length 1.9
  BOTTOM w0.277: UNK3J1.1 UNK3R19.2
S3_VDD33_J2: length 2.1
  BOTTOM w0.305: UNK3J2.1 445.28,83.52 UNK3R24.2
S3_VDD33_J3: length 1.9
  BOTTOM w0.277: UNK3J3.1 UNK3R30.2
S3_VREF_DRAM: length 1.9
  TOP w0.249: 412.73,205.06 412.79,205 SITE3.63
  TOP w0.381: 412.73,205.06 v1(412.55,205.25)
S3_XI: length 8.5
  TOP w0.249: 398.07,201.85 SITE3.22
  TOP w0.277: UNK3Y1.1 UNK3C25.2 397.3,201.85 398.07,201.85
S3_XO: length 8.5
  TOP w0.249: SITE3.21 398.56,202.2
  TOP w0.254: 398.56,202.2 398.37,202.39
  TOP w0.277: 398.37,202.39 397.85,202.91 UNK3C23.2 396.07,202.91 395.81,203.17 394.58,203.17 UNK3Y1.3
S4_1_AOUT_LN: length 4.6
  BOTTOM w0.152: UNK4K10.4 226.13,244.44 UNK4R45.1 UNK4R68.1 UNK4R67.1
S4_1_AOUT_LP: length 4.6
  BOTTOM w0.152: UNK4K10.5 226.13,247.86 UNK4R75.1 UNK4R69.1 UNK4R70.1
S4_1_AOUT_RN: length 4.6
  BOTTOM w0.152: UNK4R63.1 UNK4R64.1 UNK4R47.1 226.13,237.18 UNK4K14.4
S4_1_AOUT_RP: length 4.6
  BOTTOM w0.152: UNK4K14.5 226.13,240.6 UNK4R74.1 UNK4R65.1 UNK4R66.1
S4_1_SPI_CLK: length 6.2
  BOTTOM w0.277: v2(238.41,258.34) 239.55,257.2 240.35,257.2 241.04,256.51 UNK4U3.6
S4_1_SPI_CS: length 3.2
  BOTTOM w0.277: UNK4U3.1 v2(243.59,239.92)
S4_1_SPI_DATA0: length 6.1
  BOTTOM w0.277: v2(237.14,258.34) 238.91,256.56 239.49,256.56 239.77,256.28 UNK4U3.5
S4_1_SPI_DATA1: length 3.2
  BOTTOM w0.277: UNK4U3.2 v2(242.32,239.92)
S4_1_SPI_DATA2: length 5.6
  TOP w0.277: UNK4R18.2 UNK4R16.2 v2(241.05,239.92)
  BOTTOM w0.277: v2(241.05,239.92) UNK4U3.3
S4_1_SPI_DATA3: length 6.5
  TOP w0.277: UNK4R12.1 v2(240.95,258.34)
  BOTTOM w0.277: UNK4U3.7 242.31,256.4 240.95,257.77 v2(240.95,258.34)
S4_1_VDD09:
  vias: v1(263.96,257.09) v1(281.19,275.76) v1(284.32,275.77) v1(290.14,275.76) v1(291.21,275.76) v1(297.43,272.38) v1(297.43,270.27) v1(298.6,272.38) v1(301.67,261.38)
S4_1_VDD18_A: length 6
  TOP w0.61: UNK4K26.2 307.05,296.92 UNK4R50.1
S4_1_VDD18_D:
  vias: v1(301.67,266.84) v1(301.67,264.64) v1(301.67,263.52) v1(302.96,266.84) v2(287.84,293.09)
S4_2_AOUT_LN:
  vias: v2(222.84,245.44)
S4_2_AOUT_LP:
  vias: v2(222.84,246.86)
S4_2_AOUT_RN:
  vias: v2(222.84,238.18)
S4_2_AOUT_RP:
  vias: v2(222.84,239.6)
S4_2_VDD18_A: length 0.9
  BOTTOM w0.508: UNK4BD20.1 v1(275.79,266.99)
  vias: v1(274.76,266.99) v1(284.37,261.66) v1(284.37,260.62) v1(296.19,256.37) v2(306.05,300.63)
S4_ATX_VD0V9:
  vias: v2(243.7,265.68) v2(243.7,263.9)
S4_ATX_VD33: length 0.9
  BOTTOM w0.254: UNK4BD33.1 v2(219.25,377.23)
  vias: v2(216.45,381.09) v2(216.45,378.53) v2(216.45,375.96)
S4_AVCC_DRV: length 6.1
  TOP w0.249: 295.89,260.67 295.06,261.5 SITE4.53
  TOP w0.381: 295.89,260.67 UNK4C75.1 296.44,260.24 296.82,259.86 298.48,259.86 298.86,260.25 UNK4C110.1
  vias: v1(299.06,260.67) v2(276.15,294.23)
S4_CHIP_EN_1: length 2
  BOTTOM w0.277: UNK4R34.2 UNK4SW5.1
S4_DPS_F001:
  vias: v2(265.32,296.84) v2(267.09,296.84)
S4_DPS_F002:
  vias: v2(213.52,229.07) v2(213.52,227.3) v2(215.01,231.61)
S4_DPS_F004:
  vias: v2(265.32,287.58) v2(267.09,287.58)
S4_DPS_F006:
  vias: v2(281.8,300.62) v2(281.8,299.6) v2(281.8,298.05) v2(281.8,297.04) v2(281.8,295.46) v2(281.8,294.45)
S4_HSDM: length 3.1
  TOP w0.249: SITE4.79 291.45,272.22
  TOP w0.305: v1(292.94,273.16) 292.39,273.16 291.45,272.22
S4_HSDP: length 2.1
  TOP w0.249: 291.92,271.89 291.8,271.77 SITE4.78
  TOP w0.305: 291.92,271.89 292.17,272.14 v1(292.94,272.14)
S4_LPC_024: length 3.4
  TOP w0.249: 295.28,267.32 295.06,267.1 SITE4.69
  TOP w0.277: 295.28,267.32 v1(295.49,267.53)
  BOTTOM w0.277: UNK4R35.1 UNK4J4.2
S4_LPC_025: length 3.5
  TOP w0.249: 293.26,268.05 293.51,267.8 SITE4.71
  TOP w0.277: 293.26,268.05 293.26,268.05 v1(293.05,268.25)
  BOTTOM w0.277: UNK4R34.1 UNK4J4.1
S4_LPC_041: length 5.7
  TOP w0.249: SITE4.68 296.66,266.75
  TOP w0.277: 296.66,266.75 297.1,266.75 v1(297.69,266.16)
  BOTTOM w0.277: UNK4R36.1 UNK4J4.3
S4_LPC_042: length 0.9
  TOP w0.249: SITE4.50 292.5,259.17 292.68,259.35
  TOP w0.277: 292.68,259.35 v1(293.2,259.35)
S4_LPC_044: length 3.9
  TOP w0.249: SITE4.58 293.46,263.25
  TOP w0.277: 293.46,263.25 293.15,262.94 v1(292.55,262.94)
  BOTTOM w0.277: UNK4R39.1 UNK4J4.5
S4_LPC_046: length 2.1
  TOP w0.249: 296.18,266.3 296.07,266.4 SITE4.67
  TOP w0.277: 296.18,266.3 v1(296.31,266.16)
S4_LPC_047: length 3.5
  TOP w0.249: SITE4.18 283.44,263.25
  TOP w0.277: 283.44,263.25 v1(283.64,263.46)
  BOTTOM w0.277: UNK4R41.1 UNK4J4.7
S4_LPC_049: length 5.2
  TOP w0.249: SITE4.8 281.07,266.75
  TOP w0.277: 281.07,266.75 280.58,267.24 278.14,267.24 v1(277.58,266.68)
S4_LPC_050: length 2.4
  TOP w0.249: SITE4.7 281.46,267.1 281.07,267.49
  TOP w0.277: v1(280.2,267.8) 280.76,267.8 281.07,267.49
S4_LPC_051: length 2
  TOP w0.249: SITE4.49 292.15,259.73 292.36,259.94
  TOP w0.277: v1(293.2,260.2) 292.63,260.2 292.36,259.94
S4_LPC_052: length 2.4
  TOP w0.249: SITE4.48 291.8,258.15 291.95,258
  TOP w0.277: v1(293.2,257.97) 293.06,257.84 292.12,257.84 291.95,258
S4_LPC_053: length 7.2
  TOP w0.249: 295.69,262.68 295.46,262.9 SITE4.57
  TOP w0.277: 295.69,262.68 298.32,262.68 v1(299.06,263.42)
  BOTTOM w0.277: UNK4R37.1 UNK4J4.4
S4_LPC_055: length 2.4
  TOP w0.249: SITE4.10 280.83,266.05
  TOP w0.277: 280.83,266.05 v1(280.2,266.68)
S4_LPC_058: length 4.4
  TOP w0.249: SITE4.17 283.06,263.6 283.31,263.85
  TOP w0.277: 283.31,263.85 283.47,264.01 284.19,264.01 v1(284.37,263.83)
  BOTTOM w0.277: UNK4R40.1 UNK4J4.6
S4_LPC_060: length 5.2
  TOP w0.249: 295.93,265.51 295.39,266.05 SITE4.66
  TOP w0.277: v1(299.06,266.16) 298.41,265.51 295.93,265.51
S4_LX_AUD: length 6.2
  TOP w0.249: 283.79,271 SITE4.100
  TOP w0.864: 283.47,271 283.79,271
  TOP w1.016: 283.47,271 281.99,272.48 281.99,274.04 283.33,275.38
S4_LX_DCORE: length 2.2
  TOP w0.249: SITE4.3 280.97,268.5
  TOP w0.508: v1(280.2,268.63) v1(280.74,268.63) 280.85,268.63 280.97,268.5
S4_LX_MEM: length 1.9
  TOP w0.249: 295.1,269.46 294.84,269.2 SITE4.75
  TOP w0.508: v1(295.1,270.48) v1(295.1,269.85) 295.1,269.46
S4_MIPITX_CKN: length 1.3
  TOP w0.249: 290.52,271.89 290.4,271.77 SITE4.82
  TOP w0.277: 290.52,271.89 v1(290.77,272.14)
S4_MIPITX_CKP: length 2.8
  TOP w0.249: SITE4.83 290.05,272.11
  TOP w0.277: 290.05,272.11 290.05,272.79 v1(290.77,273.51)
S4_MIPITX_DATAN_0: length 1.2
  TOP w0.249: SITE4.85 289.35,272.09
  TOP w0.277: 289.35,272.09 v1(289.4,272.14)
S4_MIPITX_DATAN_1: length 2.3
  TOP w0.249: 291.28,270.03 291.1,270.21 SITE4.80
  TOP w0.277: v1(290.83,268.98) 291.28,269.44 291.28,270.03
S4_MIPITX_DATAP_0: length 2.8
  TOP w0.249: 288.83,272.19 288.83,271.93 289,271.75 SITE4.86
  TOP w0.277: 288.83,272.19 288.83,272.94 v1(289.4,273.51)
S4_MIPITX_DATAP_1: length 1.2
  TOP w0.249: SITE4.81 290.75,270.04 290.68,269.97
  TOP w0.277: 290.68,269.97 v1(290.58,269.86)
S4_PA2: length 2.1
  TOP w0.249: SITE4.5 284.09,267.8
  TOP w0.277: 284.09,267.8 v1(284.34,267.55)
S4_PA3: length 1.4
  TOP w0.249: 283.44,267.35 283.34,267.45 SITE4.6
  TOP w0.277: 283.44,267.35 v1(283.61,267.17)
S4_PA9_CH: length 4
  TOP w0.249: SITE4.12 280.85,265.35 280.67,265.52
  TOP w0.277: v1(278.83,266.68) 279.85,265.66 280.53,265.66 280.67,265.52
S4_PA10_CH: length 2.1
  TOP w0.249: SITE4.13 280.27,265
  TOP w0.277: 280.27,265 v1(280.2,264.93)
S4_PA13: length 3.7
  TOP w0.249: 279.82,264.5 280.02,264.3 SITE4.15
  TOP w0.277: 279.82,264.5 279.39,264.93 v1(278.83,264.93)
S4_PA13_UART_RX: length 14.6
  BOTTOM w0.277: UNK4K6.2 217.14,366.67 217.14,371.53 221.57,375.96 UNK4R27.1
S4_PA13_UART_RX_1: length 2.1
  BOTTOM w0.277: UNK4R27.2 223.68,375.98 UNK4J2.3
S4_PA14: length 5.3
  TOP w0.249: SITE4.16 279.61,263.95 279.21,264.34
  TOP w0.277: 279.21,264.34 278.45,264.34 277.86,264.93 v1(277.46,264.93)
S4_PA14_UART_TX: length 10.6
  BOTTOM w0.277: UNK4K6.7 220.59,366.92 220.59,372.21 221.8,373.42 UNK4R28.1
S4_PA14_UART_TX_1: length 2.1
  BOTTOM w0.277: UNK4J2.4 223.68,373.44 UNK4R28.2
S4_PA15_1: length 2
  BOTTOM w0.277: UNK4R40.2 UNK4SW5.6
S4_PA16_1: length 2
  BOTTOM w0.277: UNK4R41.2 UNK4SW5.7
S4_PA20: length 2.2
  TOP w0.152: v1(291.15,261.07) 291.02,260.94 291.02,260.2 290.75,259.93 SITE4.45
S4_PA21: length 1.6
  TOP w0.152: SITE4.46 291.1,259.75 291.58,260.23 v1(291.58,260.41)
S4_PA22: length 2.2
  TOP w0.152: v1(290.01,261.07) 289.86,260.91 289.86,259.9 290.05,259.7 SITE4.43
S4_PA23: length 1.4
  TOP w0.152: SITE4.44 290.4,260.37 v1(290.44,260.41)
S4_PA24: length 1.2
  TOP w0.152: SITE4.41 289.35,258.25 v1(289.06,257.95)
S4_PA25: length 1.2
  TOP w0.152: v1(290,257.95) 289.7,258.25 SITE4.42
S4_PA28: length 2.2
  TOP w0.152: v1(288.87,261.07) 288.65,260.85 SITE4.39
S4_PA29: length 1.5
  TOP w0.152: SITE4.40 289,260.11 v1(289.3,260.41)
S4_PB3: length 2.2
  TOP w0.152: SITE4.52 293.55,261.15 293.29,261.41 v1(292.25,261.41)
S4_PB3_AOUT_LP_2:
  vias: v2(221.67,246.86)
S4_PB4: length 1.4
  TOP w0.152: SITE4.51 v1(292.88,260.8)
S4_PB4_AOUT_LN_2:
  vias: v2(221.67,245.44)
S4_PB5: length 3.8
  TOP w0.152: v1(297.69,262.04) 297.04,261.4 295.89,261.4 295.44,261.85 SITE4.54
S4_PB5_AOUT_RP_2:
  vias: v2(221.67,239.6)
S4_PB6: length 2.1
  TOP w0.152: SITE4.55 296.16,262.2 v1(296.31,262.04)
S4_PB6_AOUT_RN_2:
  vias: v2(221.67,238.18)
S4_PB10_1: length 2
  BOTTOM w0.277: UNK4R37.2 UNK4SW5.4
S4_PB11_1: length 2
  BOTTOM w0.277: UNK4R39.2 UNK4SW5.5
S4_PB21_1: length 2
  BOTTOM w0.277: UNK4R36.2 UNK4SW5.3
S4_PB22_1: length 2
  BOTTOM w0.277: UNK4R35.2 UNK4SW5.2
S4_PB23: length 4.3
  TOP w0.249: 296.01,267.83 295.7,268.15 SITE4.72
  TOP w0.277: 296.01,267.83 v1(296.31,267.53)
  BOTTOM w0.277: UNK4R57.1 UNK4K4.3
S4_PB23_1:
  vias: v2(203.61,259.56)
S4_PB23_SICK:
  vias: v2(197.47,265.23)
S4_PB23_SICK_1: length 1.9
  BOTTOM w0.277: UNK4J1.3 UNK4R20.2
S4_PB24: length 4.2
  TOP w0.249: 296.09,268.68 295.91,268.5 SITE4.73
  TOP w0.277: 296.09,268.68 v1(296.31,268.9)
  BOTTOM w0.277: UNK4K4.6 UNK4R58.1
S4_PB24_1:
  vias: v2(203.61,266.82)
S4_PB24_SIDD:
  vias: v2(197.47,267.77)
S4_PB24_SIDD_1: length 1.9
  BOTTOM w0.277: UNK4J1.4 UNK4R21.2
S4_PB25: length 4.7
  TOP w0.249: SITE4.96 285.5,272.17
  TOP w0.277: 285.5,272.17 285.5,273.04 v1(285.03,273.51)
  BOTTOM w0.277: UNK4K8.3 UNK4R59.1
S4_PB25_1:
  vias: v2(203.61,251.15)
S4_PB25_I2C_SCL:
  vias: v2(191.24,265.23)
S4_PB25_I2C_SCL_1: length 1.9
  BOTTOM w0.277: UNK4J3.3 UNK4R31.2
S4_PB26: length 4.1
  TOP w0.249: SITE4.97 285.15,270.2 284.95,270.01 284.95,269.63
  TOP w0.277: 284.95,269.63 v1(284.95,268.96)
  BOTTOM w0.277: UNK4K8.6 UNK4R60.1
S4_PB26_1:
  vias: v2(203.61,258.42)
S4_PB26_I2C_SDA:
  vias: v2(191.24,267.77)
S4_PB26_I2C_SDA_1: length 1.9
  BOTTOM w0.277: UNK4J3.4 UNK4R32.2
S4_RF_A: length 2.9
  TOP w0.277: UNK4SMP3.1 UNK4C15.1 UNK4D3.1 UNK4C14.1
S4_RF_G: length 5.9
  TOP w0.277: UNK4C6.1 UNK4D2.1 UNK4C8.1 UNK4SMP2.1
S4_RFIN_A: length 3.5
  TOP w0.249: SITE4.29 285.15,258.14 arc(285.2,257.91) v1(285.33,257.71)
  BOTTOM w0.277: UNK4R9.1 UNK4C16.2 284.8,256.44 arc(284.94,257.13) v1(285.33,257.71)
S4_RFIN_G: length 4.2
  TOP w0.249: SITE4.31 v1(285.85,257.18)
  BOTTOM w0.277: UNK4R5.1 UNK4C9.2 arc(286.44,256.4) 286.05,256.98 v1(285.85,257.18)
S4_RFIO_A: length 3.3
  TOP w0.249: 284.8,257.46 SITE4.28
  TOP w0.277: 284.8,257.46 UNK4C11.2 UNK4R6.1
S4_RFIO_BT: length 3.5
  TOP w0.249: SITE4.37 287.95,258.35 arc(287.98,258.21) 288.06,258.09
  TOP w0.277: UNK4R1.1 UNK4C1.2 288.06,258.09
S4_RFIO_G: length 4.1
  TOP w0.249: SITE4.32 286.2,258.25 arc(286.24,257.84) 286.36,257.46
  TOP w0.277: UNK4R2.1 UNK4C4.2 286.78,256.85 arc(286.54,257.13) 286.36,257.46
S4_RREF_MEM: length 7.2
  TOP w0.249: 295.42,264.16 295.21,263.95 SITE4.60
  TOP w0.277: v1(300.73,265.74) 300.01,265.74 298.43,264.16 295.42,264.16
S4_SPI_CLK:
  vias: v2(238.41,259.34)
S4_SPI_CLK/PB28: length 4.3
  TOP w0.249: 287.47,272.77 287.6,272.64 SITE4.90
  TOP w0.277: 287.47,272.77 287.09,273.16 287.09,273.82 287.77,274.5 v1(287.77,274.77)
S4_SPI_CS:
  vias: v2(243.59,238.92)
S4_SPI_CS/PC0: length 1.3
  TOP w0.249: 285.75,269.92 285.85,270.03 SITE4.95
  TOP w0.277: 285.75,269.92 v1(285.65,269.83)
S4_SPI_D0/PB29: length 2.9
  TOP w0.249: 287.15,272.33 287.25,272.23 SITE4.91
  TOP w0.277: v1(286.4,273.51) 286.4,273.08 287.15,272.33
S4_SPI_D1/PB31: length 2.2
  TOP w0.249: SITE4.94 286.2,269.65
  TOP w0.277: v1(285.9,268.96) 286.2,269.26 286.2,269.65
S4_SPI_D2/PB30: length 1.5
  TOP w0.249: SITE4.92 286.9,271.82 286.79,271.93
  TOP w0.277: v1(286.4,272.14) 286.58,272.14 286.79,271.93
S4_SPI_D3/PB27: length 2.6
  TOP w0.249: SITE4.89 287.95,272.9
  TOP w0.277: 287.95,272.9 287.95,273.33 v1(287.77,273.51)
S4_SPI_DATA0:
  vias: v2(237.14,259.34)
S4_SPI_DATA1:
  vias: v2(242.32,238.92)
S4_SPI_DATA2:
  vias: v2(239.78,238.92)
S4_SPI_DATA3:
  vias: v2(240.95,259.34)
S4_U1_VC1: length 0.7
  TOP w0.152: UNK4U1.4 288.47,251.43
  TOP w0.277: 288.47,251.43 v1(287.84,251.43)
S4_U2_VC1: length 0.7
  TOP w0.152: UNK4U2.4 286.16,247.42
  TOP w0.277: 286.16,247.42 v1(285.53,247.42)
S4_VA09_MIPI: length 1.2
  TOP w0.249: SITE4.84 289.7,270.23
  TOP w0.254: 289.7,270.23 289.7,269.87
  TOP w0.381: 289.7,269.87 v1(289.67,269.84)
  vias: v1(291.21,274.77)
S4_VA09_PLL: length 1.3
  TOP w0.249: SITE4.11 283.3,265.7
  TOP w0.381: 283.3,265.7 v1(283.5,265.5)
  vias: v1(281.19,274.77)
S4_VA09_USB: length 1.3
  TOP w0.249: SITE4.77 292.15,270.09
  TOP w0.381: 292.15,270.09 v1(292.41,269.84)
  vias: v1(296.31,272.38)
S4_VA13_AFE: length 2.3
  TOP w0.249: 280.89,263.4 281.39,262.9 SITE4.19
  TOP w0.381: 280.89,263.4 v1(280.2,263.4)
  vias: v1(275.79,265.15)
S4_VA13_SYN: length 2.2
  TOP w0.249: SITE4.23 280.4,261.5 280.29,261.39
  TOP w0.381: 280.29,261.39 v1(280.2,261.29)
  vias: v1(283.33,261.66)
S4_VA33_SYN: length 5.9
  TOP w0.249: SITE4.24 281.08,261.15 280.53,260.61
  TOP w0.381: 280.53,260.61 v1(280.2,260.61)
  BOTTOM w0.381: 280.02,260.61 v1(280.2,260.61)
  BOTTOM w0.508: UNK4BD13.2 278.95,258.82 279.51,259.38 279.51,260.1 280.02,260.61
S4_VA33_XTAL: length 7.1
  TOP w0.249: 280.74,262.74 280.93,262.55 SITE4.20
  TOP w0.381: 280.74,262.74 v1(280.2,262.74)
  BOTTOM w0.381: 279.83,262.74 v1(280.2,262.74)
  BOTTOM w0.508: 279.83,262.74 279.51,263.06 279.51,265.32 279.15,265.67 UNK4BD5.2
S4_VD09_CORE1: length 1.4
  TOP w0.249: SITE4.56 293.42,262.55 v1(293.06,262.19)
  vias: v1(300.73,261.38)
S4_VD09_CORE2: length 1.6
  TOP w0.249: 293.25,265.5 293.39,265.35 SITE4.64
  TOP w0.381: v1(293.06,265.91) 293.06,265.68 293.25,265.5
  vias: v1(296.31,270.27)
S4_VD09_CORE3: length 1.2
  TOP w0.249: 288.71,269.95 288.65,270.01 SITE4.87
  TOP w0.381: 288.71,269.95 v1(288.82,269.84)
  vias: v1(290.14,274.77)
S4_VD09_CORE4: length 4.7
  TOP w0.249: SITE4.98 284.8,272.02
  TOP w0.508: 284.8,272.02 284.8,272.37 v1(283.66,273.51)
  BOTTOM w0.508: v1(283.66,273.51) 283.76,273.51 284.6,274.35 UNK4R79.2
S4_VD13_FE: length 1.5
  TOP w0.249: SITE4.36 287.6,260.12 287.43,260.29
  TOP w0.381: 287.43,260.29 v1(287.36,260.36)
  vias: v1(295.25,256.37)
S4_VD13_RF: length 2.5
  TOP w0.249: 280.56,259.92 281.44,260.8 SITE4.25
  TOP w0.381: 280.56,259.92 v1(280.2,259.92)
  vias: v1(283.33,260.62)
S4_VD33_ALL: length 0.8
  BOTTOM w0.508: UNK4BD5.1 276.67,265.49 v1(276.67,264.93)
  vias: v1(273.79,258.83) v1(274.76,265.15) v1(274.85,258.83) v1(276.81,268.92) v1(276.89,258.83) v1(277.29,271.59) v1(280.01,255.04) v1(280.15,275.76) v1(281.83,253.44) v1(282.24,275.76) v1(282.77,251.38) v1(286.81,275.76) v1(289.07,275.76) v1(294.32,274.77) v1(296.19,257.57) v1(296.19,254.23) v1(297.32,258.66) v1(297.32,257.57) v1(297.43,271.34) v1(298.6,271.34) v1(301.67,262.45) v2(246.28,259.34)
