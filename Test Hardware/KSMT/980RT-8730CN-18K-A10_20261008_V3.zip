# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S4_VD33_CM_BT: length 1
  TOP w0.249: SITE4.35 287.25,258.12
  TOP w0.381: 287.25,258.12 v1(287.25,258.01)
  vias: v1(295.25,255.29) v1(295.25,254.23)
S4_VD33_EX_FLASH: length 9
  TOP w0.508: v2(242.46,258.34) v2(243.74,258.34) v2(245.01,258.34) 246.22,258.34 UNK4BD32.2
  BOTTOM w0.508: v2(242.46,258.34) 242.46,257.81 243.58,256.68 UNK4U3.8
  vias: v2(239.68,259.34) v2(241.05,238.92) v2(246.28,258.34)
S4_VD33_IO0: length 10.2
  TOP w0.249: SITE4.9 283.45,266.4
  TOP w0.381: 283.45,266.4 v1(283.5,266.35)
  BOTTOM w0.508: v1(283.5,266.35) 282.92,266.93 282.92,272.27 282.24,272.95 UNK4BD7.2
S4_VD33_IO2: length 7.2
  TOP w0.249: 295.81,263.42 295.63,263.6 SITE4.59
  TOP w0.381: 295.81,263.42 v1(296.31,263.42)
  BOTTOM w0.381: 296.31,262.99 v1(296.31,263.42)
  BOTTOM w0.508: UNK4BD9.2 298.53,262.45 298.25,262.73 296.57,262.73 296.31,262.99
S4_VD33_IO3: length 7.8
  TOP w0.249: SITE4.70 293.1,267.45
  TOP w0.381: 293.1,267.45 v1(293.05,267.4)
  BOTTOM w0.508: v1(293.05,267.4) 293.4,267.4 294.07,268.07 294.07,270.55 294.85,271.34 UNK4BD11.2
S4_VD33_IO6: length 6.8
  TOP w0.249: SITE4.88 288.3,270.25 288.13,270.08
  TOP w0.381: 288.13,270.08 v1(287.88,269.83)
  BOTTOM w0.508: v1(287.88,269.83) 288.59,270.54 288.59,274.28 UNK4BD12.2
S4_VD33_SPS_AUD: length 2.7
  TOP w0.249: SITE4.1 282.3,269.41
  TOP w0.508: v1(280.2,270.08) 281.79,270.08 282.3,269.56 282.3,269.41
  vias: v1(276.63,270.92)
S4_VD33_SPS_DCORE: length 6.3
  TOP w0.249: SITE4.2 281.56,268.85 281.25,269.17
  TOP w0.381: 281.07,269.35 281.25,269.17 ; 278.38,268.5 UNK4C112.1 278.83,268.51 279.08,268.77
  TOP w0.508: 278.38,268.5 277.33,268.5 v1(276.81,267.98) ; 279.08,268.77 279.66,269.35 281.07,269.35
S4_VD33_SPS_MEM: length 4.7
  TOP w0.249: 292.65,271 SITE4.76
  TOP w0.381: 293.63,274.29 UNK4C126.1 293.76,273.77
  TOP w0.508: 293.76,273.77 293.76,271.76 293,271 292.65,271 ; v1(293.38,274.77) 293.63,274.52 293.63,274.29
S4_VD33PA_A: length 7.2
  TOP w0.249: SITE4.27 284.45,258.2 284.07,257.82
  TOP w0.381: 282.62,256.39 UNK4C100.1 283.05,256.59
  TOP w0.508: v1(282.77,253.44) 281.99,254.22 281.99,255.76 282.62,256.39 ; 284.07,257.82 283.05,256.79 283.05,256.59
S4_VD33PA_BT: length 10.4
  TOP w0.249: 288.18,260.28 288.3,260.15 SITE4.38
  TOP w0.381: 288.18,260.28 v1(288.09,260.36)
  BOTTOM w0.508: UNK4BD18.2 UNK4C83.1 292.9,258.66 291.81,259.74 288.71,259.74 v1(288.09,260.36)
S4_VD33PA_G: length 10
  TOP w0.249: SITE4.33 286.55,259.7 286.38,259.87 286.12,259.87 285.76,260.24 v1(285.76,260.36)
  BOTTOM w0.508: v1(285.76,260.36) 285.76,260.02 285.18,259.44 283.66,259.44 280.95,256.73 UNK4C76.1 UNK4BD15.2
S4_VD33PAD_A: length 10.2
  TOP w0.249: 283.95,259 SITE4.26
  TOP w0.381: 281.27,252.08 UNK4C98.1 280.89,252.27
  TOP w0.508: 280.89,252.27 280.89,256.53 283.36,259 283.95,259 ; v1(281.83,251.38) 281.83,251.79 281.54,252.08 281.27,252.08
S4_VD33PAD_G: length 1.5
  TOP w0.249: SITE4.34 286.9,260.03 v1(286.58,260.36)
  vias: v1(275.79,258.83) v1(275.79,257.76)
S4_VD1833_IO1: length 13
  TOP w0.249: SITE4.14 283.26,264.65
  TOP w0.381: 283.26,264.65 v1(283.5,264.65)
  BOTTOM w0.508: UNK4BD3.2 280.15,271.62 281.5,270.28 281.5,266.2 283.05,264.65 v1(283.5,264.65)
S4_VD1833_SDIO: length 7.9
  TOP w0.249: SITE4.93 286.55,270.22 286.68,270.08
  TOP w0.381: 286.68,270.08 v1(286.94,269.83)
  BOTTOM w0.508: UNK4BD29.2 UNK4C118.1 285.72,271.04 v1(286.94,269.83)
S4_VD_MEM0: length 9.6
  TOP w0.249: 293.06,263.79 293.57,264.3 SITE4.61
  TOP w0.381: 293.06,263.79 v1(293.06,263.7)
  BOTTOM w0.508: UNK4R81.2 299.97,263.52 299.38,264.11 295.23,264.11 294.82,263.7 v1(293.06,263.7)
S4_VD_MEM1: length 10
  TOP w0.249: SITE4.62 293.36,264.65
  TOP w0.254: 293.11,264.54 293.22,264.65 293.36,264.65
  TOP w0.381: 293.11,264.54 v1(293.05,264.49)
  BOTTOM w0.508: UNK4R82.2 300.73,266.85 295.41,266.85 v1(293.05,264.49)
S4_VD_MEM2: length 7.4
  TOP w0.249: 295.94,264.79 295.03,265.7 SITE4.65
  TOP w0.381: 295.94,264.79 v1(296.31,264.79)
  BOTTOM w0.381: 296.55,265.02 v1(296.31,264.79)
  BOTTOM w0.508: UNK4R83.2 300.25,264.64 299.48,265.41 296.94,265.41 296.55,265.02
S4_VDD09: length 2
  BOTTOM w0.277: UNK4K22.5 UNK4R48.1
S4_VDD18_A: length 6.1
  BOTTOM w0.508: S4_VDD18_A.1 UNK4K25.5 UNK4R55.1
S4_VDD18_D: length 2.3
  BOTTOM w0.508: UNK4R53.1 UNK4K28.5
  vias: v2(226.55,259.45)
S4_VDD33: length 2.2
  TOP w0.152: UNK4U2.6 286.99,247.42 ; UNK4U1.6 289.3,251.43
  TOP w0.277: 286.99,247.42 v1(287.63,247.42) ; 289.3,251.43 v1(289.94,251.43)
  BOTTOM w0.254: UNK4BD33.2 v2(219.25,379.87)
  vias: v2(191.24,260.15) v2(197.47,260.15) v2(199.85,342.83) v2(220.35,379.02) v2(222.66,381.04) v2(237.06,381.46)
S4_VDD33_J1: length 1.9
  BOTTOM w0.277: UNK4J1.1 UNK4R19.2
S4_VDD33_J2: length 2.1
  BOTTOM w0.277: UNK4R24.2 223.68,381.06 UNK4J2.1
S4_VDD33_J3: length 1.9
  BOTTOM w0.277: UNK4J3.1 UNK4R30.2
S4_VREF_DRAM: length 1.9
  TOP w0.249: 292.73,265.06 292.79,265 SITE4.63
  TOP w0.381: 292.73,265.06 v1(292.55,265.25)
S4_XI: length 8.5
  TOP w0.249: 278.07,261.85 SITE4.22
  TOP w0.277: 274.11,261.14 UNK4C25.2 277.3,261.85 278.07,261.85
S4_XO: length 8.5
  TOP w0.249: SITE4.21 278.56,262.2
  TOP w0.254: 278.56,262.2 278.37,262.39
  TOP w0.277: 278.37,262.39 277.85,262.91 UNK4C23.2 276.07,262.91 275.81,263.17 274.58,263.17 UNK4Y1.3
S5_1_AOUT_LN: length 4.6
  BOTTOM w0.152: UNK5K10.4 226.13,278.73 UNK5R45.1 UNK5R68.1 UNK5R67.1
S5_1_AOUT_LP: length 4.6
  BOTTOM w0.152: UNK5K10.5 226.13,282.15 UNK5R75.1 UNK5R69.1 UNK5R70.1
S5_1_AOUT_RN: length 4.6
  BOTTOM w0.152: UNK5R63.1 UNK5R64.1 UNK5R47.1 226.13,271.47 UNK5K14.4
S5_1_AOUT_RP: length 4.6
  BOTTOM w0.152: UNK5R66.1 UNK5R65.1 UNK5R74.1 226.13,274.89 UNK5K14.5
S5_1_SPI_CLK: length 6.2
  BOTTOM w0.277: v2(238.41,292.63) 239.55,291.49 240.35,291.49 241.04,290.8 UNK5U3.6
S5_1_SPI_CS: length 3.2
  BOTTOM w0.277: UNK5U3.1 v2(243.59,274.21)
S5_1_SPI_DATA0: length 6.1
  BOTTOM w0.277: UNK5U3.5 239.77,290.57 239.49,290.85 238.91,290.85 v2(237.14,292.63)
S5_1_SPI_DATA1: length 3.2
  BOTTOM w0.277: UNK5U3.2 v2(242.32,274.21)
S5_1_SPI_DATA2: length 5.6
  TOP w0.277: UNK5R18.2 UNK5R16.2 v2(241.05,274.21)
  BOTTOM w0.277: v2(241.05,274.21) UNK5U3.3
S5_1_SPI_DATA3: length 6.5
  TOP w0.277: UNK5R12.1 v2(240.95,292.63)
  BOTTOM w0.277: v2(240.95,292.63) 240.95,292.06 242.31,290.69 UNK5U3.7
S5_1_VDD09:
  vias: v1(303.96,257.09) v1(321.19,275.76) v1(324.32,275.77) v1(330.14,275.76) v1(331.21,275.76) v1(337.43,272.38) v1(337.43,270.27) v1(338.6,272.38) v1(341.67,261.38)
S5_1_VDD18_A: length 6
  TOP w0.61: UNK5R50.1 347.05,296.92 UNK5K26.2
S5_1_VDD18_D:
  vias: v1(341.67,266.84) v1(341.67,264.64) v1(341.67,263.52) v1(342.96,266.84) v2(327.84,293.09)
S5_2_AOUT_LN:
  vias: v2(222.84,279.73)
S5_2_AOUT_LP:
  vias: v2(222.84,281.15)
S5_2_AOUT_RN:
  vias: v2(222.84,272.47)
S5_2_AOUT_RP:
  vias: v2(222.84,273.89)
S5_2_VDD18_A: length 0.9
  BOTTOM w0.508: UNK5BD20.1 v1(315.79,266.99)
  vias: v1(314.76,266.99) v1(324.37,261.66) v1(324.37,260.62) v1(336.19,256.37) v2(346.05,300.63)
S5_ATX_VD0V9:
  vias: v2(243.7,299.97) v2(243.7,298.19)
S5_ATX_VD33: length 0.9
  BOTTOM w0.254: UNK5BD33.1 v2(318.82,377.23)
  vias: v2(316.02,381.09) v2(316.02,378.53) v2(316.02,375.96)
S5_AVCC_DRV: length 6.1
  TOP w0.249: SITE5.53 335.06,261.5 335.89,260.67
  TOP w0.381: 335.89,260.67 UNK5C75.1 336.44,260.24 336.82,259.86 338.48,259.86 338.86,260.25 UNK5C110.1
  vias: v1(339.06,260.67) v2(316.15,294.23)
S5_CHIP_EN_1: length 2
  BOTTOM w0.277: UNK5R34.2 UNK5SW5.1
S5_DPS_F001:
  vias: v2(328,296.17) v2(329.78,296.17)
S5_DPS_F002:
  vias: v2(213.52,297.65) v2(213.52,295.88) v2(215.01,300.19)
S5_DPS_F004:
  vias: v2(260.69,296.84) v2(262.47,296.84)
S5_DPS_F006:
  vias: v2(321.8,300.62) v2(321.8,299.6) v2(321.8,298.05) v2(321.8,297.04) v2(321.8,295.46) v2(321.8,294.45)
S5_HSDM: length 3.1
  TOP w0.249: SITE5.79 331.45,272.22
  TOP w0.305: 331.45,272.22 332.39,273.16 v1(332.94,273.16)
S5_HSDP: length 2.1
  TOP w0.249: SITE5.78 331.8,271.77 331.92,271.89
  TOP w0.305: 331.92,271.89 332.17,272.14 v1(332.94,272.14)
S5_LPC_024: length 3.4
  TOP w0.249: SITE5.69 335.06,267.1 335.28,267.32
  TOP w0.277: 335.28,267.32 v1(335.49,267.53)
  BOTTOM w0.277: UNK5R35.1 UNK5J4.2
S5_LPC_025: length 3.5
  TOP w0.249: SITE5.71 333.51,267.8 333.26,268.05
  TOP w0.277: v1(333.05,268.25) 333.26,268.05 333.26,268.05
  BOTTOM w0.277: UNK5R34.1 UNK5J4.1
S5_LPC_041: length 5.7
  TOP w0.249: SITE5.68 336.66,266.75
  TOP w0.277: v1(337.69,266.16) 337.1,266.75 336.66,266.75
  BOTTOM w0.277: UNK5R36.1 UNK5J4.3
S5_LPC_042: length 0.9
  TOP w0.249: SITE5.50 332.5,259.17 332.68,259.35
  TOP w0.277: 332.68,259.35 v1(333.2,259.35)
S5_LPC_044: length 3.9
  TOP w0.249: SITE5.58 333.46,263.25
  TOP w0.277: v1(332.55,262.94) 333.15,262.94 333.46,263.25
  BOTTOM w0.277: UNK5R39.1 UNK5J4.5
S5_LPC_046: length 2.1
  TOP w0.249: SITE5.67 336.07,266.4 336.18,266.3
  TOP w0.277: 336.18,266.3 v1(336.31,266.16)
S5_LPC_047: length 3.5
  TOP w0.249: SITE5.18 323.44,263.25
  TOP w0.277: 323.44,263.25 v1(323.64,263.46)
  BOTTOM w0.277: UNK5R41.1 UNK5J4.7
S5_LPC_049: length 5.2
  TOP w0.249: SITE5.8 321.07,266.75
  TOP w0.277: 321.07,266.75 320.58,267.24 318.14,267.24 v1(317.58,266.68)
S5_LPC_050: length 2.4
  TOP w0.249: 321.07,267.49 321.46,267.1 SITE5.7
  TOP w0.277: 321.07,267.49 320.76,267.8 v1(320.2,267.8)
S5_LPC_051: length 2
  TOP w0.249: SITE5.49 332.15,259.73 332.36,259.94
  TOP w0.277: v1(333.2,260.2) 332.63,260.2 332.36,259.94
S5_LPC_052: length 2.4
  TOP w0.249: SITE5.48 331.8,258.15 331.95,258
  TOP w0.277: 331.95,258 332.12,257.84 333.06,257.84 v1(333.2,257.97)
S5_LPC_053: length 7.2
  TOP w0.249: 335.69,262.68 335.46,262.9 SITE5.57
  TOP w0.277: v1(339.06,263.42) 338.32,262.68 335.69,262.68
  BOTTOM w0.277: UNK5R37.1 UNK5J4.4
S5_LPC_055: length 2.4
  TOP w0.249: SITE5.10 320.83,266.05
  TOP w0.277: 320.83,266.05 v1(320.2,266.68)
S5_LPC_058: length 4.4
  TOP w0.249: SITE5.17 323.06,263.6 323.31,263.85
  TOP w0.277: v1(324.37,263.83) 324.19,264.01 323.47,264.01 323.31,263.85
  BOTTOM w0.277: UNK5R40.1 UNK5J4.6
S5_LPC_060: length 5.2
  TOP w0.249: 335.93,265.51 335.39,266.05 SITE5.66
  TOP w0.277: v1(339.06,266.16) 338.41,265.51 335.93,265.51
S5_LX_AUD: length 6.2
  TOP w0.249: 323.78,271 SITE5.100
  TOP w0.864: 323.47,271 323.78,271
  TOP w1.016: 323.47,271 321.99,272.48 321.99,274.04 323.33,275.38
S5_LX_DCORE: length 2.2
  TOP w0.249: SITE5.3 320.97,268.5
  TOP w0.508: v1(320.2,268.63) v1(320.74,268.63) 320.85,268.63 320.97,268.5
S5_LX_MEM: length 1.9
  TOP w0.249: SITE5.75 334.84,269.2 335.1,269.46
  TOP w0.508: v1(335.1,270.48) v1(335.1,269.85) 335.1,269.46
S5_MIPITX_CKN: length 1.3
  TOP w0.249: 330.52,271.89 330.4,271.77 SITE5.82
  TOP w0.277: 330.52,271.89 v1(330.77,272.14)
S5_MIPITX_CKP: length 2.8
  TOP w0.249: SITE5.83 330.05,272.11
  TOP w0.277: 330.05,272.11 330.05,272.79 v1(330.77,273.51)
S5_MIPITX_DATAN_0: length 1.2
  TOP w0.249: SITE5.85 329.35,272.09
  TOP w0.277: 329.35,272.09 v1(329.4,272.14)
S5_MIPITX_DATAN_1: length 2.3
  TOP w0.249: SITE5.80 331.1,270.21 331.28,270.03
  TOP w0.277: v1(330.83,268.98) 331.28,269.44 331.28,270.03
S5_MIPITX_DATAP_0: length 2.8
  TOP w0.249: SITE5.86 329,271.75 328.83,271.93 328.83,272.19
  TOP w0.277: 328.83,272.19 328.83,272.94 v1(329.4,273.51)
S5_MIPITX_DATAP_1: length 1.2
  TOP w0.249: SITE5.81 330.75,270.04 330.68,269.97
  TOP w0.277: 330.68,269.97 v1(330.58,269.86)
S5_PA2: length 2.1
  TOP w0.249: SITE5.5 324.09,267.8
  TOP w0.277: 324.09,267.8 v1(324.34,267.55)
S5_PA3: length 1.4
  TOP w0.249: 323.44,267.35 323.34,267.45 SITE5.6
  TOP w0.277: 323.44,267.35 v1(323.61,267.17)
S5_PA9_CH: length 4
  TOP w0.249: SITE5.12 320.85,265.35 320.67,265.52
  TOP w0.277: v1(318.83,266.68) 319.85,265.66 320.53,265.66 320.67,265.52
S5_PA10_CH: length 2.1
  TOP w0.249: SITE5.13 320.27,265
  TOP w0.277: 320.27,265 v1(320.2,264.93)
S5_PA13: length 3.7
  TOP w0.249: SITE5.15 320.02,264.3 319.82,264.5
  TOP w0.277: v1(318.83,264.93) 319.39,264.93 319.82,264.5
S5_PA13_UART_RX: length 14.8
  BOTTOM w0.277: UNK5K6.2 316.75,366.72 316.75,371.8 320.91,375.96 UNK5R27.1
S5_PA13_UART_RX_1: length 2.1
  BOTTOM w0.277: UNK5J2.3 325.3,375.96 UNK5R27.2
S5_PA14: length 5.3
  TOP w0.249: 319.21,264.34 319.61,263.95 SITE5.16
  TOP w0.277: 319.21,264.34 318.45,264.34 317.86,264.93 v1(317.46,264.93)
S5_PA14_UART_TX: length 10.8
  BOTTOM w0.277: UNK5R28.1 321.09,373.42 320.46,372.8 320.46,367.23 UNK5K6.7
S5_PA14_UART_TX_1: length 2.1
  BOTTOM w0.277: UNK5R28.2 325.3,373.42 UNK5J2.4
S5_PA15_1: length 2
  BOTTOM w0.277: UNK5R40.2 UNK5SW5.6
S5_PA16_1: length 2
  BOTTOM w0.277: UNK5R41.2 UNK5SW5.7
S5_PA20: length 2.2
  TOP w0.152: v1(331.15,261.07) 331.02,260.94 331.02,260.2 330.75,259.93 SITE5.45
S5_PA21: length 1.6
  TOP w0.152: v1(331.58,260.41) 331.58,260.23 331.1,259.75 SITE5.46
S5_PA22: length 2.2
  TOP w0.152: v1(330.01,261.07) 329.86,260.91 329.86,259.9 330.05,259.7 SITE5.43
S5_PA23: length 1.4
  TOP w0.152: v1(330.44,260.41) 330.4,260.37 SITE5.44
S5_PA24: length 1.2
  TOP w0.152: SITE5.41 329.35,258.25 v1(329.06,257.95)
S5_PA25: length 1.2
  TOP w0.152: v1(330,257.95) 329.7,258.25 SITE5.42
S5_PA28: length 2.2
  TOP w0.152: v1(328.86,261.07) 328.65,260.85 SITE5.39
S5_PA29: length 1.5
  TOP w0.152: v1(329.3,260.41) 329,260.11 SITE5.40
S5_PB3: length 2.2
  TOP w0.152: SITE5.52 333.55,261.15 333.29,261.41 v1(332.25,261.41)
S5_PB3_AOUT_LP_2:
  vias: v2(221.67,281.15)
S5_PB4: length 1.4
  TOP w0.152: SITE5.51 v1(332.88,260.8)
S5_PB4_AOUT_LN_2:
  vias: v2(221.67,279.73)
S5_PB5: length 3.8
  TOP w0.152: SITE5.54 335.44,261.85 335.89,261.4 337.04,261.4 v1(337.69,262.04)
S5_PB5_AOUT_RP_2:
  vias: v2(221.67,273.89)
S5_PB6: length 2.1
  TOP w0.152: SITE5.55 336.16,262.2 v1(336.31,262.04)
S5_PB6_AOUT_RN_2:
  vias: v2(221.67,272.47)
S5_PB10_1: length 2
  BOTTOM w0.277: UNK5R37.2 UNK5SW5.4
S5_PB11_1: length 2
  BOTTOM w0.277: UNK5R39.2 UNK5SW5.5
S5_PB21_1: length 2
  BOTTOM w0.277: UNK5R36.2 UNK5SW5.3
S5_PB22_1: length 2
  BOTTOM w0.277: UNK5R35.2 UNK5SW5.2
S5_PB23: length 4.3
  TOP w0.249: 336.01,267.83 335.7,268.15 SITE5.72
  TOP w0.277: 336.01,267.83 v1(336.31,267.53)
  BOTTOM w0.277: UNK5R57.1 UNK5K4.3
S5_PB23_1:
  vias: v2(203.61,293.85)
S5_PB23_SICK:
  vias: v2(197.47,299.52)
S5_PB23_SICK_1: length 1.9
  BOTTOM w0.277: UNK5J1.3 UNK5R20.2
S5_PB24: length 4.2
  TOP w0.249: SITE5.73 335.91,268.5 336.09,268.68
  TOP w0.277: 336.09,268.68 v1(336.31,268.9)
  BOTTOM w0.277: UNK5K4.6 UNK5R58.1
S5_PB24_1:
  vias: v2(203.61,301.11)
S5_PB24_SIDD:
  vias: v2(197.47,302.06)
S5_PB24_SIDD_1: length 1.9
  BOTTOM w0.277: UNK5J1.4 UNK5R21.2
S5_PB25: length 4.7
  TOP w0.249: SITE5.96 325.5,272.17
  TOP w0.277: v1(325.03,273.51) 325.5,273.04 325.5,272.17
  BOTTOM w0.277: UNK5K8.3 UNK5R59.1
S5_PB25_1:
  vias: v2(203.61,285.44)
S5_PB25_I2C_SCL:
  vias: v2(191.24,299.52)
S5_PB25_I2C_SCL_1: length 1.9
  BOTTOM w0.277: UNK5J3.3 UNK5R31.2
S5_PB26: length 4.1
  TOP w0.249: SITE5.97 325.15,270.2 324.95,270.01 324.95,269.63
  TOP w0.277: 324.95,269.63 v1(324.95,268.96)
  BOTTOM w0.277: UNK5K8.6 UNK5R60.1
S5_PB26_1:
  vias: v2(203.61,292.71)
S5_PB26_I2C_SDA:
  vias: v2(191.24,302.06)
S5_PB26_I2C_SDA_1: length 1.9
  BOTTOM w0.277: UNK5J3.4 UNK5R32.2
S5_RF_A: length 2.9
  TOP w0.277: UNK5C13.1 UNK5D3.1 UNK5C15.1 UNK5SMP3.1
S5_RF_G: length 5.9
  TOP w0.277: UNK5C6.1 UNK5D2.1 UNK5C8.1 UNK5SMP2.1
S5_RFIN_A: length 3.5
  TOP w0.249: SITE5.29 325.15,258.14 arc(325.2,257.91) v1(325.33,257.71)
  BOTTOM w0.277: UNK5R9.1 UNK5C16.2 324.8,256.44 arc(324.94,257.13) v1(325.33,257.71)
S5_RFIN_G: length 4.2
  TOP w0.249: SITE5.31 v1(325.85,257.18)
  BOTTOM w0.277: v1(325.85,257.18) 326.05,256.98 arc(326.44,256.4) UNK5C9.2 UNK5R5.1
S5_RFIO_A: length 3.3
  TOP w0.249: 324.8,257.46 SITE5.28
  TOP w0.277: 324.8,257.46 UNK5C11.2 UNK5R6.1
S5_RFIO_BT: length 3.5
  TOP w0.249: SITE5.37 327.95,258.35 arc(327.98,258.21) 328.06,258.09
  TOP w0.277: 328.06,258.09 UNK5C1.2 UNK5R1.1
S5_RFIO_G: length 4.1
  TOP w0.249: SITE5.32 326.2,258.25 arc(326.24,257.84) 326.36,257.46
  TOP w0.277: UNK5R2.1 UNK5C4.2 326.78,256.85 arc(326.54,257.13) 326.36,257.46
S5_RREF_MEM: length 7.2
  TOP w0.249: SITE5.60 335.21,263.95 335.42,264.16
  TOP w0.277: 335.42,264.16 338.43,264.16 340.01,265.74 v1(340.73,265.74)
S5_SPI_CLK:
  vias: v2(238.41,293.63)
S5_SPI_CLK/PB28: length 4.3
  TOP w0.249: SITE5.90 327.6,272.64 327.47,272.77
  TOP w0.277: 327.47,272.77 327.09,273.16 327.09,273.82 327.77,274.5 v1(327.77,274.77)
S5_SPI_CS:
  vias: v2(243.59,273.21)
S5_SPI_CS/PC0: length 1.3
  TOP w0.249: SITE5.95 325.85,270.03 325.75,269.92
  TOP w0.277: 325.75,269.92 v1(325.65,269.83)
S5_SPI_D0/PB29: length 2.9
  TOP w0.249: 327.15,272.33 327.25,272.23 SITE5.91
  TOP w0.277: v1(326.4,273.51) 326.4,273.08 327.15,272.33
S5_SPI_D1/PB31: length 2.2
  TOP w0.249: SITE5.94 326.2,269.65
  TOP w0.277: 326.2,269.65 326.2,269.26 v1(325.9,268.96)
S5_SPI_D2/PB30: length 1.5
  TOP w0.249: 326.79,271.93 326.9,271.82 SITE5.92
  TOP w0.277: 326.79,271.93 326.58,272.14 v1(326.4,272.14)
S5_SPI_D3/PB27: length 2.6
  TOP w0.249: SITE5.89 327.95,272.9
  TOP w0.277: v1(327.77,273.51) 327.95,273.33 327.95,272.9
S5_SPI_DATA0:
  vias: v2(237.14,293.63)
S5_SPI_DATA1:
  vias: v2(242.32,273.21)
S5_SPI_DATA2:
  vias: v2(239.78,273.21)
S5_SPI_DATA3:
  vias: v2(240.95,293.63)
S5_U1_VC1: length 0.7
  TOP w0.152: UNK5U1.4 328.47,251.43
  TOP w0.277: 328.47,251.43 v1(327.84,251.43)
S5_U2_VC1: length 0.7
  TOP w0.152: UNK5U2.4 326.16,247.42
  TOP w0.277: 326.16,247.42 v1(325.53,247.42)
S5_VA09_MIPI: length 1.2
  TOP w0.249: SITE5.84 329.7,270.23
  TOP w0.254: 329.7,270.23 329.7,269.87
  TOP w0.381: 329.7,269.87 v1(329.67,269.84)
  vias: v1(331.21,274.77)
S5_VA09_PLL: length 1.3
  TOP w0.249: SITE5.11 323.3,265.7
  TOP w0.381: 323.3,265.7 v1(323.5,265.5)
  vias: v1(321.19,274.77)
S5_VA09_USB: length 1.3
  TOP w0.249: SITE5.77 332.15,270.09
  TOP w0.381: 332.15,270.09 v1(332.4,269.84)
  vias: v1(336.31,272.38)
S5_VA13_AFE: length 2.3
  TOP w0.249: SITE5.19 321.39,262.9 320.89,263.4
  TOP w0.381: 320.89,263.4 v1(320.2,263.4)
  vias: v1(315.79,265.15)
S5_VA13_SYN: length 2.2
  TOP w0.249: SITE5.23 320.4,261.5 320.29,261.39
  TOP w0.381: 320.29,261.39 v1(320.2,261.29)
  vias: v1(323.33,261.66)
S5_VA33_SYN: length 5.9
  TOP w0.249: 320.53,260.61 321.08,261.15 SITE5.24
  TOP w0.381: 320.53,260.61 v1(320.2,260.61)
  BOTTOM w0.381: 320.02,260.61 v1(320.2,260.61)
  BOTTOM w0.508: 320.02,260.61 319.51,260.1 319.51,259.38 318.95,258.82 UNK5BD13.2
S5_VA33_XTAL: length 7.1
  TOP w0.249: SITE5.20 320.93,262.55 320.74,262.74
  TOP w0.381: 320.74,262.74 v1(320.2,262.74)
  BOTTOM w0.381: 319.83,262.74 v1(320.2,262.74)
  BOTTOM w0.508: 319.83,262.74 319.51,263.06 319.51,265.32 319.15,265.67 UNK5BD5.2
S5_VD09_CORE1: length 1.4
  TOP w0.249: v1(333.06,262.19) 333.42,262.55 SITE5.56
  vias: v1(340.73,261.38)
S5_VD09_CORE2: length 1.6
  TOP w0.249: 333.25,265.5 333.39,265.35 SITE5.64
  TOP w0.381: 333.25,265.5 333.06,265.68 v1(333.06,265.91)
  vias: v1(336.31,270.27)
S5_VD09_CORE3: length 1.2
  TOP w0.249: 328.71,269.95 328.65,270.01 SITE5.87
  TOP w0.381: 328.71,269.95 v1(328.82,269.84)
  vias: v1(330.14,274.77)
S5_VD09_CORE4: length 4.7
  TOP w0.249: SITE5.98 324.8,272.02
  TOP w0.508: 324.8,272.02 324.8,272.37 v1(323.66,273.51)
  BOTTOM w0.508: UNK5R79.2 324.6,274.35 323.76,273.51 v1(323.66,273.51)
S5_VD13_FE: length 1.5
  TOP w0.249: 327.43,260.29 327.6,260.12 SITE5.36
  TOP w0.381: 327.43,260.29 v1(327.36,260.36)
  vias: v1(335.25,256.37)
S5_VD13_RF: length 2.5
  TOP w0.249: 320.56,259.92 321.44,260.8 SITE5.25
  TOP w0.381: 320.56,259.92 v1(320.2,259.92)
  vias: v1(323.33,260.62)
S5_VD33_ALL: length 0.8
  BOTTOM w0.508: UNK5BD5.1 316.67,265.49 v1(316.67,264.93)
  vias: v1(313.79,258.83) v1(314.76,265.15) v1(314.85,258.83) v1(316.81,268.92) v1(316.89,258.83) v1(317.29,271.59) v1(320.01,255.04) v1(320.15,275.76) v1(321.83,253.44) v1(322.24,275.76) v1(322.77,251.38) v1(326.81,275.76) v1(329.07,275.76) v1(334.32,274.77) v1(336.19,257.57) v1(336.19,254.23) v1(337.32,258.66) v1(337.32,257.57) v1(337.43,271.34) v1(338.6,271.34) v1(341.67,262.45) v2(246.28,293.63)
S5_VD33_CM_BT: length 1
  TOP w0.249: SITE5.35 327.25,258.12
  TOP w0.381: 327.25,258.12 v1(327.25,258.01)
  vias: v1(335.25,255.29) v1(335.25,254.23)
S5_VD33_EX_FLASH: length 9
  TOP w0.508: v2(242.46,292.63) v2(243.74,292.63) v2(245.01,292.63) 246.22,292.63 UNK5BD32.2
  BOTTOM w0.508: v2(242.46,292.63) 242.46,292.1 243.58,290.97 UNK5U3.8
  vias: v2(239.68,293.63) v2(241.05,273.21) v2(246.28,292.63)
S5_VD33_IO0: length 10.2
  TOP w0.249: SITE5.9 323.45,266.4
  TOP w0.381: 323.45,266.4 v1(323.5,266.35)
  BOTTOM w0.508: v1(323.5,266.35) 322.92,266.93 322.92,272.27 322.24,272.95 UNK5BD7.2
S5_VD33_IO2: length 7.2
  TOP w0.249: SITE5.59 335.63,263.6 335.81,263.42
  TOP w0.381: 335.81,263.42 v1(336.31,263.42)
  BOTTOM w0.381: 336.31,262.99 v1(336.31,263.42)
  BOTTOM w0.508: 336.31,262.99 336.57,262.73 338.25,262.73 338.53,262.45 UNK5BD9.2
S5_VD33_IO3: length 7.8
  TOP w0.249: SITE5.70 333.1,267.45
  TOP w0.381: 333.1,267.45 v1(333.05,267.4)
  BOTTOM w0.508: v1(333.05,267.4) 333.4,267.4 334.07,268.07 334.07,270.55 334.85,271.34 UNK5BD11.2
S5_VD33_IO6: length 6.8
  TOP w0.249: SITE5.88 328.3,270.25 328.13,270.08
  TOP w0.381: 328.13,270.08 v1(327.88,269.83)
  BOTTOM w0.508: UNK5BD12.2 328.59,274.28 328.59,270.54 v1(327.88,269.83)
S5_VD33_SPS_AUD: length 2.7
  TOP w0.249: SITE5.1 322.3,269.41
  TOP w0.508: v1(320.2,270.08) 321.79,270.08 322.3,269.56 322.3,269.41
  vias: v1(316.63,270.92)
S5_VD33_SPS_DCORE: length 6.3
  TOP w0.249: SITE5.2 321.56,268.85 321.24,269.17
  TOP w0.381: 321.07,269.35 321.24,269.17 ; 319.08,268.77 318.83,268.51 UNK5C112.1 318.38,268.5
  TOP w0.508: 318.38,268.5 317.33,268.5 v1(316.81,267.98) ; 319.08,268.77 319.66,269.35 321.07,269.35
S5_VD33_SPS_MEM: length 4.7
  TOP w0.249: 332.65,271 SITE5.76
  TOP w0.381: 333.76,273.77 UNK5C126.1 333.63,274.29
  TOP w0.508: 333.76,273.77 333.76,271.76 333,271 332.65,271 ; v1(333.38,274.77) 333.63,274.52 333.63,274.29
S5_VD33PA_A: length 7.2
  TOP w0.249: SITE5.27 324.45,258.2 324.07,257.82
  TOP w0.381: 323.05,256.59 UNK5C100.1 322.62,256.39
  TOP w0.508: v1(322.77,253.44) 321.99,254.22 321.99,255.76 322.62,256.39 ; 324.07,257.82 323.05,256.79 323.05,256.59
S5_VD33PA_BT: length 10.4
  TOP w0.249: 328.18,260.28 328.3,260.15 SITE5.38
  TOP w0.381: 328.18,260.28 v1(328.09,260.36)
  BOTTOM w0.508: v1(328.09,260.36) 328.71,259.74 331.81,259.74 332.9,258.66 UNK5C83.1 UNK5BD18.2
S5_VD33PA_G: length 10
  TOP w0.249: SITE5.33 326.55,259.7 326.38,259.87 326.12,259.87 325.76,260.24 v1(325.76,260.36)
  BOTTOM w0.508: UNK5BD15.2 UNK5C76.1 320.95,256.73 323.66,259.44 325.18,259.44 325.76,260.02 v1(325.76,260.36)
S5_VD33PAD_A: length 10.2
  TOP w0.249: 323.95,259 SITE5.26
  TOP w0.381: 321.27,252.08 UNK5C98.1 320.89,252.27
  TOP w0.508: v1(321.83,251.38) 321.83,251.79 321.54,252.08 321.27,252.08 ; 320.89,252.27 320.89,256.53 323.36,259 323.95,259
S5_VD33PAD_G: length 1.5
  TOP w0.249: SITE5.34 326.9,260.03 v1(326.58,260.36)
  vias: v1(315.78,258.83) v1(315.78,257.76)
S5_VD1833_IO1: length 13
  TOP w0.249: SITE5.14 323.26,264.65
  TOP w0.381: 323.26,264.65 v1(323.5,264.65)
  BOTTOM w0.508: v1(323.5,264.65) 323.05,264.65 321.5,266.2 321.5,270.28 320.15,271.62 UNK5BD3.2
S5_VD1833_SDIO: length 7.9
  TOP w0.249: 326.68,270.08 326.55,270.22 SITE5.93
  TOP w0.381: 326.68,270.08 v1(326.94,269.83)
  BOTTOM w0.508: UNK5BD29.2 UNK5C118.1 325.72,271.04 v1(326.94,269.83)
S5_VD_MEM0: length 9.6
  TOP w0.249: SITE5.61 333.57,264.3 333.06,263.79
  TOP w0.381: 333.06,263.79 v1(333.06,263.7)
  BOTTOM w0.508: v1(333.06,263.7) 334.82,263.7 335.23,264.11 339.38,264.11 339.97,263.52 UNK5R81.2
S5_VD_MEM1: length 10
  TOP w0.249: SITE5.62 333.36,264.65
  TOP w0.254: 333.36,264.65 333.22,264.65 333.11,264.54
  TOP w0.381: 333.11,264.54 v1(333.05,264.49)
  BOTTOM w0.508: v1(333.05,264.49) 335.41,266.85 340.73,266.85 UNK5R82.2
S5_VD_MEM2: length 7.4
  TOP w0.249: SITE5.65 335.03,265.7 335.94,264.79
  TOP w0.381: 335.94,264.79 v1(336.31,264.79)
  BOTTOM w0.381: 336.55,265.02 v1(336.31,264.79)
  BOTTOM w0.508: UNK5R83.2 340.25,264.64 339.48,265.41 336.94,265.41 336.55,265.02
S5_VDD09: length 2
  BOTTOM w0.277: UNK5K22.5 UNK5R48.1
S5_VDD18_A: length 6.1
  BOTTOM w0.508: S5_VDD18_A.1 UNK5K25.5 UNK5R55.1
S5_VDD18_D: length 2.3
  BOTTOM w0.508: UNK5R53.1 UNK5K28.5
  vias: v2(226.55,293.74)
S5_VDD33: length 2.2
  TOP w0.152: UNK5U1.6 329.3,251.43 ; UNK5U2.6 326.99,247.42
  TOP w0.277: 326.99,247.42 v1(327.63,247.42) ; 329.3,251.43 v1(329.94,251.43)
  BOTTOM w0.254: UNK5BD33.2 v2(318.82,379.87)
  vias: v2(191.24,294.44) v2(197.47,294.44) v2(307.41,343.09) v2(319.91,379.02) v2(322.22,381.04) v2(336.63,381.46)
S5_VDD33_J1: length 1.9
  BOTTOM w0.277: UNK5J1.1 UNK5R19.2
S5_VDD33_J2: length 2.1
  BOTTOM w0.277: UNK5J2.1 325.3,381.04 UNK5R24.2
S5_VDD33_J3: length 1.9
  BOTTOM w0.277: UNK5J3.1 UNK5R30.2
S5_VREF_DRAM: length 1.9
  TOP w0.249: SITE5.63 332.79,265 332.73,265.06
  TOP w0.381: 332.73,265.06 v1(332.55,265.25)
S5_XI: length 8.5
  TOP w0.249: 318.07,261.85 SITE5.22
  TOP w0.277: 314.11,261.14 UNK5C25.2 317.3,261.85 318.07,261.85
S5_XO: length 8.5
  TOP w0.249: SITE5.21 318.56,262.2
  TOP w0.254: 318.56,262.2 318.37,262.39
  TOP w0.277: UNK5Y1.3 314.58,263.17 315.81,263.17 316.07,262.91 UNK5C23.2 317.85,262.91 318.37,262.39
S6_1_AOUT_LN: length 4.6
  BOTTOM w0.152: UNK6R67.1 UNK6R68.1 UNK6R45.1 470.47,294.14 UNK6K10.4
S6_1_AOUT_LP: length 4.6
  BOTTOM w0.152: UNK6K10.5 470.47,290.72 UNK6R75.1 UNK6R69.1 UNK6R70.1
S6_1_AOUT_RN: length 4.6
  BOTTOM w0.152: UNK6K14.4 470.47,301.4 UNK6R47.1 UNK6R64.1 UNK6R63.1
S6_1_AOUT_RP: length 4.6
  BOTTOM w0.152: UNK6R66.1 UNK6R65.1 UNK6R74.1 470.47,297.98 UNK6K14.5
S6_1_SPI_CLK: length 6.2
  BOTTOM w0.277: v2(458.19,280.24) 457.05,281.38 456.25,281.38 455.56,282.07 UNK6U3.6
S6_1_SPI_CS: length 3.2
  BOTTOM w0.277: UNK6U3.1 v2(453.01,298.66)
S6_1_SPI_DATA0: length 6.1
  BOTTOM w0.277: UNK6U3.5 456.83,282.3 457.11,282.02 457.69,282.02 v2(459.46,280.24)
S6_1_SPI_DATA1: length 3.2
  BOTTOM w0.277: UNK6U3.2 v2(454.28,298.66)
S6_1_SPI_DATA2: length 5.6
  TOP w0.277: UNK6R18.2 UNK6R16.2 v2(455.55,298.66)
  BOTTOM w0.277: UNK6U3.3 v2(455.55,298.66)
S6_1_SPI_DATA3: length 6.5
  TOP w0.277: v2(455.65,280.24) UNK6R12.1
  BOTTOM w0.277: v2(455.65,280.24) 455.65,280.81 454.29,282.18 UNK6U3.7
S6_1_VDD09:
  vias: v1(343.96,257.09) v1(361.19,275.76) v1(364.32,275.77) v1(370.14,275.76) v1(371.2,275.76) v1(377.43,272.38) v1(377.43,270.27) v1(378.6,272.38) v1(381.67,261.38)
S6_1_VDD18_A: length 6
  TOP w0.61: UNK6R50.1 387.05,296.92 UNK6K26.2
S6_1_VDD18_D:
  vias: v1(381.67,266.84) v1(381.67,264.64) v1(381.67,263.52) v1(382.96,266.84) v2(367.84,293.09)
S6_2_AOUT_LN:
  vias: v2(473.76,293.14)
S6_2_AOUT_LP:
  vias: v2(473.76,291.72)
S6_2_AOUT_RN:
  vias: v2(473.76,300.4)
S6_2_AOUT_RP:
  vias: v2(473.76,298.98)
S6_2_VDD18_A: length 0.9
  BOTTOM w0.508: UNK6BD20.1 v1(355.79,266.99)
  vias: v1(354.76,266.99) v1(364.37,261.66) v1(364.37,260.62) v1(376.19,256.37) v2(386.05,300.63)
S6_ATX_VD0V9:
  vias: v2(452.91,274.68) v2(452.91,272.9)
S6_ATX_VD33: length 0.9
  BOTTOM w0.254: UNK6BD33.1 v2(463.48,377.23)
  vias: v2(460.68,381.09) v2(460.68,378.53) v2(460.68,375.96)
S6_AVCC_DRV: length 6.1
  TOP w0.249: SITE6.53 375.06,261.5 375.89,260.67
  TOP w0.381: 375.89,260.67 UNK6C75.1 376.44,260.24 376.82,259.86 378.48,259.86 378.86,260.25 UNK6C110.1
  vias: v1(379.06,260.67) v2(356.15,294.23)
S6_CHIP_EN_1: length 2
  BOTTOM w0.277: UNK6R34.2 UNK6SW5.1
S6_DPS_F001:
  vias: v2(384.3,303.34) v2(384.3,301.56)
S6_DPS_F002:
  vias: v2(482.47,243.81) v2(484.09,241.28) v2(484.09,239.5)
S6_DPS_F004:
  vias: v2(392.44,296.45) v2(394.22,296.45)
S6_DPS_F006:
  vias: v2(361.81,300.62) v2(361.81,299.6) v2(361.81,298.05) v2(361.81,297.04) v2(361.81,295.46) v2(361.81,294.45)
S6_HSDM: length 3.1
  TOP w0.249: SITE6.79 371.45,272.22
  TOP w0.305: v1(372.94,273.16) 372.39,273.16 371.45,272.22
S6_HSDP: length 2.1
  TOP w0.249: 371.92,271.89 371.8,271.77 SITE6.78
  TOP w0.305: 371.92,271.89 372.17,272.14 v1(372.94,272.14)
S6_LPC_024: length 3.4
  TOP w0.249: 375.28,267.32 375.06,267.1 SITE6.69
  TOP w0.277: 375.28,267.32 v1(375.49,267.53)
  BOTTOM w0.277: UNK6R35.1 UNK6J4.2
S6_LPC_025: length 3.5
  TOP w0.249: 373.26,268.05 373.51,267.8 SITE6.71
  TOP w0.277: v1(373.05,268.25) 373.26,268.05 373.26,268.05
  BOTTOM w0.277: UNK6R34.1 UNK6J4.1
S6_LPC_041: length 5.7
  TOP w0.249: SITE6.68 376.66,266.75
  TOP w0.277: 376.66,266.75 377.1,266.75 v1(377.69,266.16)
  BOTTOM w0.277: UNK6R36.1 399.48,330.26
S6_LPC_042: length 0.9
  TOP w0.249: 372.68,259.35 372.5,259.17 SITE6.50
  TOP w0.277: 372.68,259.35 v1(373.2,259.35)
S6_LPC_044: length 3.9
  TOP w0.249: SITE6.58 373.46,263.25
  TOP w0.277: 373.46,263.25 373.15,262.94 v1(372.55,262.94)
  BOTTOM w0.277: UNK6R39.1 UNK6J4.5
S6_LPC_046: length 2.1
  TOP w0.249: 376.18,266.3 376.07,266.4 SITE6.67
  TOP w0.277: 376.18,266.3 v1(376.31,266.16)
S6_LPC_047: length 3.5
  TOP w0.249: SITE6.18 363.44,263.25
  TOP w0.277: 363.44,263.25 v1(363.64,263.46)
  BOTTOM w0.277: UNK6R41.1 UNK6J4.7
S6_LPC_049: length 5.2
  TOP w0.249: SITE6.8 361.07,266.75
  TOP w0.277: 361.07,266.75 360.58,267.24 358.14,267.24 v1(357.58,266.68)
S6_LPC_050: length 2.4
  TOP w0.249: SITE6.7 361.46,267.1 361.07,267.49
  TOP w0.277: 361.07,267.49 360.76,267.8 v1(360.2,267.8)
S6_LPC_051: length 2
  TOP w0.249: SITE6.49 372.15,259.73 372.36,259.94
  TOP w0.277: v1(373.2,260.2) 372.63,260.2 372.36,259.94
S6_LPC_052: length 2.4
  TOP w0.249: SITE6.48 371.8,258.15 371.95,258
  TOP w0.277: v1(373.2,257.97) 373.06,257.84 372.12,257.84 371.95,258
S6_LPC_053: length 7.2
  TOP w0.249: 375.69,262.68 375.46,262.9 SITE6.57
  TOP w0.277: 375.69,262.68 378.32,262.68 v1(379.06,263.42)
  BOTTOM w0.277: UNK6R37.1 396.94,330.26
S6_LPC_055: length 2.4
  TOP w0.249: SITE6.10 360.83,266.05
  TOP w0.277: 360.83,266.05 v1(360.2,266.68)
S6_LPC_058: length 4.4
  TOP w0.249: 363.31,263.85 363.06,263.6 SITE6.17
  TOP w0.277: v1(364.37,263.83) 364.19,264.01 363.47,264.01 363.31,263.85
  BOTTOM w0.277: UNK6R40.1 391.86,330.26
S6_LPC_060: length 5.2
  TOP w0.249: SITE6.66 375.39,266.05 375.93,265.51
  TOP w0.277: v1(379.06,266.16) 378.41,265.51 375.93,265.51
S6_LX_AUD: length 6.2
  TOP w0.249: 363.78,271 SITE6.100
  TOP w0.864: 363.47,271 363.78,271
  TOP w1.016: 363.47,271 361.99,272.48 361.99,274.04 363.33,275.38
S6_LX_DCORE: length 2.2
  TOP w0.249: SITE6.3 360.97,268.5
  TOP w0.508: 360.97,268.5 360.85,268.63 v1(360.74,268.63) v1(360.2,268.63)
S6_LX_MEM: length 1.9
  TOP w0.249: 375.1,269.46 374.84,269.2 SITE6.75
  TOP w0.508: v1(375.1,270.48) v1(375.1,269.85) 375.1,269.46
S6_MIPITX_CKN: length 1.3
  TOP w0.249: SITE6.82 370.4,271.77 370.52,271.89
  TOP w0.277: 370.52,271.89 v1(370.77,272.14)
S6_MIPITX_CKP: length 2.8
  TOP w0.249: SITE6.83 370.05,272.11
  TOP w0.277: 370.05,272.11 370.05,272.79 v1(370.77,273.51)
S6_MIPITX_DATAN_0: length 1.2
  TOP w0.249: SITE6.85 369.35,272.09
  TOP w0.277: 369.35,272.09 v1(369.4,272.14)
S6_MIPITX_DATAN_1: length 2.3
  TOP w0.249: SITE6.80 371.1,270.21 371.28,270.03
  TOP w0.277: 371.28,270.03 371.28,269.44 v1(370.83,268.98)
S6_MIPITX_DATAP_0: length 2.8
  TOP w0.249: SITE6.86 369,271.75 368.83,271.93 368.83,272.19
  TOP w0.277: v1(369.4,273.51) 368.83,272.94 368.83,272.19
S6_MIPITX_DATAP_1: length 1.2
  TOP w0.249: 370.68,269.97 370.75,270.04 SITE6.81
  TOP w0.277: 370.68,269.97 v1(370.58,269.86)
S6_PA2: length 2.1
  TOP w0.249: SITE6.5 364.09,267.8
  TOP w0.277: 364.09,267.8 v1(364.34,267.55)
S6_PA3: length 1.4
  TOP w0.249: SITE6.6 363.34,267.45 363.44,267.35
  TOP w0.277: 363.44,267.35 v1(363.61,267.17)
S6_PA9_CH: length 4
  TOP w0.249: 360.67,265.52 360.85,265.35 SITE6.12
  TOP w0.277: 360.67,265.52 360.53,265.66 359.85,265.66 v1(358.83,266.68)
S6_PA10_CH: length 2.1
  TOP w0.249: SITE6.13 360.27,265
  TOP w0.277: 360.27,265 v1(360.2,264.93)
S6_PA13: length 3.7
  TOP w0.249: SITE6.15 360.02,264.3 359.82,264.5
  TOP w0.277: v1(358.83,264.93) 359.39,264.93 359.82,264.5
S6_PA13_UART_RX: length 14.4
  BOTTOM w0.277: UNK6R27.1 466.15,375.96 461.13,370.94 461.13,366.44 UNK6K6.2
S6_PA13_UART_RX_1: length 2.1
  BOTTOM w0.277: UNK6R27.2 469.95,375.96 UNK6J2.3
S6_PA14: length 5.3
  TOP w0.249: 359.21,264.34 359.61,263.95 SITE6.16
  TOP w0.277: 359.21,264.34 358.45,264.34 357.86,264.93 v1(357.46,264.93)
S6_PA14_UART_TX: length 11.1
  BOTTOM w0.277: UNK6K6.7 464.81,366.92 464.81,372.95 465.29,373.42 UNK6R28.1
S6_PA14_UART_TX_1: length 2.1
  BOTTOM w0.277: UNK6R28.2 469.95,373.42 UNK6J2.4
S6_PA15_1: length 2
  BOTTOM w0.277: UNK6R40.2 UNK6SW5.6
S6_PA16_1: length 2
  BOTTOM w0.277: UNK6R41.2 UNK6SW5.7
S6_PA20: length 2.2
  TOP w0.152: SITE6.45 370.75,259.93 371.02,260.2 371.02,260.94 v1(371.15,261.07)
S6_PA21: length 1.6
  TOP w0.152: SITE6.46 371.1,259.75 371.58,260.23 v1(371.58,260.41)
S6_PA22: length 2.2
  TOP w0.152: SITE6.43 370.05,259.7 369.86,259.9 369.86,260.91 v1(370.01,261.07)
S6_PA23: length 1.4
  TOP w0.152: v1(370.44,260.41) 370.4,260.37 SITE6.44
S6_PA24: length 1.2
  TOP w0.152: SITE6.41 369.35,258.25 v1(369.06,257.95)
S6_PA25: length 1.2
  TOP w0.152: SITE6.42 369.7,258.25 v1(370,257.95)
S6_PA28: length 2.2
  TOP w0.152: v1(368.86,261.07) 368.65,260.85 SITE6.39
S6_PA29: length 1.5
  TOP w0.152: SITE6.40 369,260.11 v1(369.3,260.41)
S6_PB3: length 2.2
  TOP w0.152: v1(372.25,261.41) 373.29,261.41 373.55,261.15 SITE6.52
S6_PB3_AOUT_LP_2:
  vias: v2(474.93,291.72)
S6_PB4: length 1.4
  TOP w0.152: SITE6.51 v1(372.88,260.8)
S6_PB4_AOUT_LN_2:
  vias: v2(474.93,293.14)
S6_PB5: length 3.8
  TOP w0.152: SITE6.54 375.44,261.85 375.89,261.4 377.04,261.4 v1(377.69,262.04)
S6_PB5_AOUT_RP_2:
  vias: v2(474.93,298.98)
S6_PB6: length 2.1
  TOP w0.152: SITE6.55 376.16,262.2 v1(376.31,262.04)
S6_PB6_AOUT_RN_2:
  vias: v2(474.93,300.4)
S6_PB10_1: length 2
  BOTTOM w0.277: UNK6R37.2 396.94,335.34
S6_PB11_1: length 2
  BOTTOM w0.277: UNK6R39.2 UNK6SW5.5
S6_PB21_1: length 2
  BOTTOM w0.277: UNK6R36.2 399.48,335.34
S6_PB22_1: length 2
  BOTTOM w0.277: UNK6R35.2 UNK6SW5.2
S6_PB23: length 4.3
  TOP w0.249: 376.01,267.83 375.7,268.15 SITE6.72
  TOP w0.277: 376.01,267.83 v1(376.31,267.53)
  BOTTOM w0.277: UNK6R57.1 UNK6K4.3
S6_PB23_1:
  vias: v2(492.99,279.02)
S6_PB23_SICK:
  vias: v2(499.13,273.36)
S6_PB23_SICK_1: length 1.9
  BOTTOM w0.277: UNK6J1.3 UNK6R20.2
S6_PB24: length 4.2
  TOP w0.249: SITE6.73 375.91,268.5 376.09,268.68
  TOP w0.277: 376.09,268.68 v1(376.31,268.9)
  BOTTOM w0.277: UNK6K4.6 UNK6R58.1
S6_PB24_1:
  vias: v2(492.99,271.76)
S6_PB24_SIDD:
  vias: v2(499.13,270.82)
S6_PB24_SIDD_1: length 1.9
  BOTTOM w0.277: UNK6J1.4 UNK6R21.2
S6_PB25: length 4.7
  TOP w0.249: SITE6.96 365.5,272.17
  TOP w0.277: v1(365.03,273.51) 365.5,273.04 365.5,272.17
  BOTTOM w0.277: UNK6K8.3 UNK6R59.1
S6_PB25_1:
  vias: v2(492.99,287.43)
S6_PB25_I2C_SCL:
  vias: v2(505.36,273.36)
S6_PB25_I2C_SCL_1: length 1.9
  BOTTOM w0.277: UNK6J3.3 UNK6R31.2
S6_PB26: length 4.1
  TOP w0.249: 364.95,269.63 364.95,270.01 365.15,270.2 SITE6.97
  TOP w0.277: 364.95,269.63 v1(364.95,268.96)
  BOTTOM w0.277: UNK6K8.6 UNK6R60.1
S6_PB26_1:
  vias: v2(492.99,280.16)
S6_PB26_I2C_SDA:
  vias: v2(505.36,270.82)
S6_PB26_I2C_SDA_1: length 1.9
  BOTTOM w0.277: UNK6J3.4 UNK6R32.2
S6_RF_A: length 2.9
  TOP w0.277: UNK6SMP3.1 UNK6C15.1 UNK6D3.1 UNK6C14.1
S6_RF_G: length 5.9
  TOP w0.277: UNK6SMP2.1 UNK6C8.1 UNK6D2.1 UNK6C7.1
S6_RFIN_A: length 3.5
  TOP w0.249: SITE6.29 365.15,258.14 arc(365.2,257.91) v1(365.33,257.71)
  BOTTOM w0.277: UNK6R9.1 UNK6C16.2 364.8,256.44 arc(364.94,257.13) v1(365.33,257.71)
S6_RFIN_G: length 4.2
  TOP w0.249: SITE6.31 v1(365.85,257.18)
  BOTTOM w0.277: v1(365.85,257.18) 366.05,256.98 arc(366.44,256.4) UNK6C9.2 UNK6R5.1
S6_RFIO_A: length 3.3
  TOP w0.249: 364.8,257.46 SITE6.28
  TOP w0.277: 364.8,257.46 UNK6C11.2 UNK6R6.1
S6_RFIO_BT: length 3.5
  TOP w0.249: SITE6.37 367.95,258.35 arc(367.98,258.21) 368.06,258.09
  TOP w0.277: 368.06,258.09 UNK6C1.2 UNK6R1.1
S6_RFIO_G: length 4.1
  TOP w0.249: SITE6.32 366.2,258.25 arc(366.24,257.84) 366.36,257.46
  TOP w0.277: UNK6R2.1 UNK6C4.2 366.78,256.85 arc(366.54,257.13) 366.36,257.46
S6_RREF_MEM: length 7.2
  TOP w0.249: 375.42,264.16 375.21,263.95 SITE6.60
  TOP w0.277: v1(380.73,265.74) 380.01,265.74 378.43,264.16 375.42,264.16
S6_SPI_CLK:
  vias: v2(458.19,279.24)
S6_SPI_CLK/PB28: length 4.3
  TOP w0.249: SITE6.90 367.6,272.64 367.47,272.77
  TOP w0.277: v1(367.77,274.77) 367.77,274.5 367.09,273.82 367.09,273.16 367.47,272.77
S6_SPI_CS:
  vias: v2(453.01,299.66)
S6_SPI_CS/PC0: length 1.3
  TOP w0.249: 365.75,269.92 365.85,270.03 SITE6.95
  TOP w0.277: 365.75,269.92 v1(365.65,269.83)
S6_SPI_D0/PB29: length 2.9
  TOP w0.249: 367.15,272.33 367.25,272.23 SITE6.91
  TOP w0.277: 367.15,272.33 366.4,273.08 v1(366.4,273.51)
S6_SPI_D1/PB31: length 2.2
  TOP w0.249: SITE6.94 366.2,269.65
  TOP w0.277: v1(365.9,268.96) 366.2,269.26 366.2,269.65
S6_SPI_D2/PB30: length 1.5
  TOP w0.249: SITE6.92 366.9,271.82 366.79,271.93
  TOP w0.277: 366.79,271.93 366.58,272.14 v1(366.4,272.14)
S6_SPI_D3/PB27: length 2.6
  TOP w0.249: SITE6.89 367.95,272.9
  TOP w0.277: 367.95,272.9 367.95,273.33 v1(367.77,273.51)
S6_SPI_DATA0:
  vias: v2(459.46,279.24)
S6_SPI_DATA1:
  vias: v2(454.28,299.66)
S6_SPI_DATA2:
  vias: v2(456.82,299.66)
S6_SPI_DATA3:
  vias: v2(455.65,279.24)
S6_U1_VC1: length 0.7
  TOP w0.152: UNK6U1.4 368.47,251.43
  TOP w0.277: 368.47,251.43 v1(367.84,251.43)
S6_U2_VC1: length 0.7
  TOP w0.152: UNK6U2.4 366.16,247.42
  TOP w0.277: 366.16,247.42 v1(365.53,247.42)
S6_VA09_MIPI: length 1.2
  TOP w0.249: SITE6.84 369.7,270.23
  TOP w0.254: 369.7,270.23 369.7,269.87
  TOP w0.381: 369.7,269.87 v1(369.67,269.84)
  vias: v1(371.2,274.77)
S6_VA09_PLL: length 1.3
  TOP w0.249: SITE6.11 363.3,265.7
  TOP w0.381: 363.3,265.7 v1(363.5,265.5)
  vias: v1(361.19,274.77)
S6_VA09_USB: length 1.3
  TOP w0.249: SITE6.77 372.15,270.09
  TOP w0.381: 372.15,270.09 v1(372.4,269.84)
  vias: v1(376.31,272.38)
S6_VA13_AFE: length 2.3
  TOP w0.249: 360.89,263.4 361.39,262.9 SITE6.19
  TOP w0.381: 360.89,263.4 v1(360.2,263.4)
  vias: v1(355.79,265.15)
S6_VA13_SYN: length 2.2
  TOP w0.249: 360.29,261.39 360.4,261.5 SITE6.23
  TOP w0.381: 360.29,261.39 v1(360.2,261.29)
  vias: v1(363.33,261.66)
S6_VA33_SYN: length 5.9
  TOP w0.249: 360.53,260.61 361.08,261.15 SITE6.24
  TOP w0.381: 360.53,260.61 v1(360.2,260.61)
  BOTTOM w0.381: 360.02,260.61 v1(360.2,260.61)
  BOTTOM w0.508: UNK6BD13.2 358.95,258.82 359.51,259.38 359.51,260.1 360.02,260.61
S6_VA33_XTAL: length 7.1
  TOP w0.249: 360.74,262.74 360.93,262.55 SITE6.20
  TOP w0.381: 360.74,262.74 v1(360.2,262.74)
  BOTTOM w0.381: 359.83,262.74 v1(360.2,262.74)
  BOTTOM w0.508: UNK6BD5.2 359.15,265.67 359.51,265.32 359.51,263.06 359.83,262.74
S6_VD09_CORE1: length 1.4
  TOP w0.249: SITE6.56 373.42,262.55 v1(373.06,262.19)
  vias: v1(380.73,261.38)
S6_VD09_CORE2: length 1.6
  TOP w0.249: 373.25,265.5 373.39,265.35 SITE6.64
  TOP w0.381: v1(373.06,265.91) 373.06,265.68 373.25,265.5
  vias: v1(376.31,270.27)
S6_VD09_CORE3: length 1.2
  TOP w0.249: 368.71,269.95 368.65,270.01 SITE6.87
  TOP w0.381: 368.71,269.95 v1(368.82,269.84)
  vias: v1(370.14,274.77)
S6_VD09_CORE4: length 4.7
  TOP w0.249: SITE6.98 364.8,272.02
  TOP w0.508: 364.8,272.02 364.8,272.37 v1(363.66,273.51)
  BOTTOM w0.508: UNK6R79.2 364.6,274.35 363.76,273.51 v1(363.66,273.51)
S6_VD13_FE: length 1.5
  TOP w0.249: SITE6.36 367.6,260.12 367.43,260.29
  TOP w0.381: 367.43,260.29 v1(367.36,260.36)
  vias: v1(375.25,256.37)
S6_VD13_RF: length 2.5
  TOP w0.249: SITE6.25 361.44,260.8 360.56,259.92
  TOP w0.381: 360.56,259.92 v1(360.2,259.92)
  vias: v1(363.33,260.62)
S6_VD33_ALL: length 0.8
  BOTTOM w0.508: UNK6BD5.1 356.67,265.49 v1(356.67,264.93)
  vias: v1(353.79,258.83) v1(354.76,265.15) v1(354.85,258.83) v1(356.81,268.92) v1(356.89,258.83) v1(357.29,271.59) v1(360.01,255.04) v1(360.15,275.76) v1(361.83,253.44) v1(362.23,275.76) v1(362.77,251.38) v1(366.81,275.76) v1(369.07,275.76) v1(374.32,274.77) v1(376.19,257.57) v1(376.19,254.23) v1(377.32,258.66) v1(377.32,257.57) v1(377.43,271.34) v1(378.6,271.34) v1(381.67,262.45) v2(450.32,279.24)
S6_VD33_CM_BT: length 1
  TOP w0.249: SITE6.35 367.25,258.12
  TOP w0.381: 367.25,258.12 v1(367.25,258.01)
  vias: v1(375.25,255.29) v1(375.25,254.23)
S6_VD33_EX_FLASH: length 9
  TOP w0.508: v2(454.14,280.24) v2(452.86,280.24) v2(451.59,280.24) 450.38,280.24 UNK6BD32.2
  BOTTOM w0.508: UNK6U3.8 453.02,281.9 454.14,280.77 v2(454.14,280.24)
  vias: v2(450.32,280.24) v2(455.55,299.66) v2(456.92,279.24)
S6_VD33_IO0: length 10.2
  TOP w0.249: SITE6.9 363.45,266.4
  TOP w0.381: 363.45,266.4 v1(363.5,266.35)
  BOTTOM w0.508: UNK6BD7.2 362.23,272.95 362.92,272.27 362.92,266.93 v1(363.5,266.35)
S6_VD33_IO2: length 7.2
  TOP w0.249: SITE6.59 375.63,263.6 375.81,263.42
  TOP w0.381: 375.81,263.42 v1(376.31,263.42)
  BOTTOM w0.381: 376.31,262.99 v1(376.31,263.42)
  BOTTOM w0.508: 376.31,262.99 376.57,262.73 378.25,262.73 378.53,262.45 UNK6BD9.2
S6_VD33_IO3: length 7.8
  TOP w0.249: SITE6.70 373.1,267.45
  TOP w0.381: 373.1,267.45 v1(373.05,267.4)
  BOTTOM w0.508: v1(373.05,267.4) 373.4,267.4 374.07,268.07 374.07,270.55 374.85,271.34 UNK6BD11.2
S6_VD33_IO6: length 6.8
  TOP w0.249: SITE6.88 368.3,270.25 368.13,270.08
  TOP w0.381: 368.13,270.08 v1(367.88,269.83)
  BOTTOM w0.508: v1(367.88,269.83) 368.59,270.54 368.59,274.28 UNK6BD12.2
S6_VD33_SPS_AUD: length 2.7
  TOP w0.249: SITE6.1 362.3,269.41
  TOP w0.508: 362.3,269.41 362.3,269.56 361.79,270.08 v1(360.2,270.08)
  vias: v1(356.63,270.92)
S6_VD33_SPS_DCORE: length 6.3
  TOP w0.249: 361.24,269.17 361.56,268.85 SITE6.2
  TOP w0.381: 359.08,268.77 358.83,268.51 UNK6C112.1 358.37,268.5 ; 361.07,269.35 361.24,269.17
  TOP w0.508: 359.08,268.77 359.66,269.35 361.07,269.35 ; 358.37,268.5 357.33,268.5 v1(356.81,267.98)
S6_VD33_SPS_MEM: length 4.7
  TOP w0.249: 372.65,271 SITE6.76
  TOP w0.381: 373.63,274.29 UNK6C126.1 373.76,273.77
  TOP w0.508: v1(373.38,274.77) 373.63,274.52 373.63,274.29 ; 372.65,271 373,271 373.76,271.76 373.76,273.77
S6_VD33PA_A: length 7.2
  TOP w0.249: 364.07,257.82 364.45,258.2 SITE6.27
  TOP w0.381: 363.05,256.59 UNK6C100.1 362.62,256.39
  TOP w0.508: v1(362.77,253.44) 361.99,254.22 361.99,255.76 362.62,256.39 ; 363.05,256.59 363.05,256.79 364.07,257.82
S6_VD33PA_BT: length 10.4
  TOP w0.249: 368.18,260.28 368.3,260.15 SITE6.38
  TOP w0.381: 368.18,260.28 v1(368.09,260.36)
  BOTTOM w0.508: UNK6BD18.2 UNK6C83.1 372.9,258.66 371.81,259.74 368.71,259.74 v1(368.09,260.36)
S6_VD33PA_G: length 10
  TOP w0.249: v1(365.76,260.36) 365.76,260.24 366.12,259.87 366.38,259.87 366.55,259.7 SITE6.33
  BOTTOM w0.508: v1(365.76,260.36) 365.76,260.02 365.18,259.44 363.66,259.44 360.95,256.73 UNK6C76.1 UNK6BD15.2
S6_VD33PAD_A: length 10.2
  TOP w0.249: 363.95,259 SITE6.26
  TOP w0.381: 360.89,252.27 UNK6C98.1 361.27,252.08
  TOP w0.508: 363.95,259 363.36,259 360.89,256.53 360.89,252.27 ; v1(361.83,251.38) 361.83,251.79 361.54,252.08 361.27,252.08
S6_VD33PAD_G: length 1.5
  TOP w0.249: v1(366.58,260.36) 366.9,260.03 SITE6.34
  vias: v1(355.78,258.83) v1(355.78,257.76)
S6_VD1833_IO1: length 13
  TOP w0.249: SITE6.14 363.26,264.65
  TOP w0.381: 363.26,264.65 v1(363.5,264.65)
  BOTTOM w0.508: v1(363.5,264.65) 363.05,264.65 361.5,266.2 361.5,270.28 360.15,271.62 UNK6BD3.2
S6_VD1833_SDIO: length 7.9
  TOP w0.249: SITE6.93 366.55,270.22 366.68,270.08
  TOP w0.381: 366.68,270.08 v1(366.94,269.83)
  BOTTOM w0.508: UNK6BD29.2 UNK6C118.1 365.72,271.04 v1(366.94,269.83)
S6_VD_MEM0: length 9.6
  TOP w0.249: SITE6.61 373.57,264.3 373.06,263.79
  TOP w0.381: 373.06,263.79 v1(373.06,263.7)
  BOTTOM w0.508: UNK6R81.2 379.97,263.52 379.38,264.11 375.23,264.11 374.82,263.7 v1(373.06,263.7)
S6_VD_MEM1: length 10
  TOP w0.249: SITE6.62 373.36,264.65
  TOP w0.254: 373.11,264.54 373.22,264.65 373.36,264.65
  TOP w0.381: 373.11,264.54 v1(373.05,264.49)
  BOTTOM w0.508: v1(373.05,264.49) 375.41,266.85 380.73,266.85 UNK6R82.2
S6_VD_MEM2: length 7.4
  TOP w0.249: 375.94,264.79 375.03,265.7 SITE6.65
  TOP w0.381: 375.94,264.79 v1(376.31,264.79)
  BOTTOM w0.381: 376.55,265.02 v1(376.31,264.79)
  BOTTOM w0.508: UNK6R83.2 380.25,264.64 379.48,265.41 376.94,265.41 376.55,265.02
S6_VDD09: length 2
  BOTTOM w0.277: UNK6K22.5 UNK6R48.1
S6_VDD18_A: length 6.1
  BOTTOM w0.508: S6_VDD18_A.1 UNK6K25.5 UNK6R55.1
S6_VDD18_D: length 2.3
  BOTTOM w0.508: UNK6R53.1 UNK6K28.5
  vias: v2(470.05,279.13)
S6_VDD33: length 2.2
  TOP w0.152: UNK6U1.6 369.3,251.43 ; UNK6U2.6 366.99,247.42
  TOP w0.277: 366.99,247.42 v1(367.63,247.42) ; 369.3,251.43 v1(369.94,251.43)
  BOTTOM w0.254: UNK6BD33.2 v2(463.48,379.87)
  vias: v2(464.57,379.02) v2(466.88,381.04) v2(481.28,381.46) v2(499.13,278.44) v2(505.36,278.44)
S6_VDD33_J1: length 1.9
  BOTTOM w0.277: UNK6J1.1 UNK6R19.2
S6_VDD33_J2: length 2.1
  BOTTOM w0.277: UNK6R24.2 469.95,381.04 UNK6J2.1
S6_VDD33_J3: length 1.9
  BOTTOM w0.277: UNK6J3.1 UNK6R30.2
S6_VREF_DRAM: length 1.9
  TOP w0.249: 372.73,265.06 372.79,265 SITE6.63
  TOP w0.381: 372.73,265.06 v1(372.55,265.25)
S6_XI: length 8.5
  TOP w0.249: 358.07,261.85 SITE6.22
  TOP w0.277: 358.07,261.85 357.3,261.85 UNK6C25.2 354.11,261.14
S6_XO: length 8.5
  TOP w0.249: SITE6.21 358.56,262.2
  TOP w0.254: 358.56,262.2 358.37,262.39
  TOP w0.277: 358.37,262.39 357.85,262.91 UNK6C23.2 356.07,262.91 355.81,263.17 354.58,263.17 UNK6Y1.3
S7_1_AOUT_LN: length 4.6
  BOTTOM w0.152: UNK7K10.4 470.47,259.85 UNK7R45.1 UNK7R68.1 UNK7R67.1
S7_1_AOUT_LP: length 4.6
  BOTTOM w0.152: UNK7K10.5 470.47,256.43 UNK7R75.1 UNK7R69.1 UNK7R70.1
S7_1_AOUT_RN: length 4.6
  BOTTOM w0.152: UNK7K14.4 470.47,267.11 UNK7R47.1 UNK7R64.1 UNK7R63.1
S7_1_AOUT_RP: length 4.6
  BOTTOM w0.152: UNK7K14.5 470.47,263.69 UNK7R74.1 UNK7R65.1 UNK7R66.1
S7_1_SPI_CLK: length 6.2
  BOTTOM w0.277: UNK7U3.6 455.56,247.78 456.25,247.09 457.05,247.09 v2(458.19,245.95)
S7_1_SPI_CS: length 3.2
  BOTTOM w0.277: UNK7U3.1 v2(453.01,264.37)
S7_1_SPI_DATA0: length 6.1
  BOTTOM w0.277: v2(459.46,245.95) 457.69,247.73 457.11,247.73 456.83,248.01 UNK7U3.5
S7_1_SPI_DATA1: length 3.2
  BOTTOM w0.277: UNK7U3.2 v2(454.28,264.37)
S7_1_SPI_DATA2: length 5.6
  TOP w0.277: UNK7R18.2 UNK7R16.2 v2(455.55,264.37)
  BOTTOM w0.277: UNK7U3.3 v2(455.55,264.37)
S7_1_SPI_DATA3: length 6.5
  TOP w0.277: v2(455.65,245.95) UNK7R12.1
  BOTTOM w0.277: v2(455.65,245.95) 455.65,246.52 454.29,247.89 UNK7U3.7
S7_1_VDD09:
  vias: v1(383.96,257.09) v1(401.19,275.76) v1(404.32,275.77) v1(410.14,275.76) v1(411.2,275.76) v1(417.43,272.38) v1(417.43,270.27) v1(418.6,272.38) v1(421.67,261.38)
S7_1_VDD18_A: length 6
  TOP w0.61: UNK7R50.1 427.05,296.92 UNK7K26.2
S7_1_VDD18_D:
  vias: v1(421.67,266.84) v1(421.67,264.64) v1(421.67,263.52) v1(422.96,266.84) v2(407.84,293.09)
S7_2_AOUT_LN:
  vias: v2(473.76,258.85)
S7_2_AOUT_LP:
  vias: v2(473.76,257.43)
S7_2_AOUT_RN:
  vias: v2(473.76,266.11)
S7_2_AOUT_RP:
  vias: v2(473.76,264.69)
S7_2_VDD18_A: length 0.9
  BOTTOM w0.508: UNK7BD20.1 v1(395.79,266.99)
  vias: v1(394.76,266.99) v1(404.37,261.66) v1(404.37,260.62) v1(416.19,256.37) v2(426.05,300.63)
S7_ATX_VD0V9:
  vias: v2(452.91,240.39) v2(452.91,238.61)
S7_ATX_VD33: length 0.9
  BOTTOM w0.254: UNK7BD33.1 v2(502.59,377.23)
  vias: v2(499.79,381.09) v2(499.79,378.53) v2(499.79,375.96)
S7_AVCC_DRV: length 6.1
  TOP w0.249: 415.89,260.67 415.06,261.5 SITE7.53
  TOP w0.381: UNK7C110.1 418.86,260.25 418.48,259.86 416.82,259.86 416.44,260.24 UNK7C75.1 415.89,260.67
  vias: v1(419.06,260.67) v2(396.15,294.23)
S7_CHIP_EN_1: length 2
  BOTTOM w0.277: UNK7R34.2 UNK7SW5.1
S7_DPS_F001:
  vias: v2(431.86,294.63) v2(433.64,294.63)
S7_DPS_F002: length 1.8
  BOTTOM w0.203: v2(484.09,170.92) UNK7C94.1 v2(484.09,172.7)
  vias: v2(482.47,175.23)
S7_DPS_F004:
  vias: v2(431.86,283.79) v2(433.64,283.79)
S7_DPS_F006:
  vias: v2(414.12,300.62) v2(414.12,299.6) v2(414.12,298.05) v2(414.12,297.04) v2(414.12,295.46) v2(414.12,294.45)
S7_HSDM: length 3.1
  TOP w0.249: SITE7.79 411.45,272.22
  TOP w0.305: v1(412.94,273.16) 412.39,273.16 411.45,272.22
S7_HSDP: length 2.1
  TOP w0.249: SITE7.78 411.8,271.77 411.92,271.89
  TOP w0.305: 411.92,271.89 412.17,272.14 v1(412.94,272.14)
S7_LPC_024: length 3.4
  TOP w0.249: SITE7.69 415.06,267.1 415.28,267.32
  TOP w0.277: 415.28,267.32 v1(415.49,267.53)
  BOTTOM w0.277: UNK7R35.1 UNK7J4.2
S7_LPC_025: length 3.5
  TOP w0.249: 413.26,268.05 413.51,267.8 SITE7.71
  TOP w0.277: 413.26,268.05 413.26,268.05 v1(413.05,268.25)
  BOTTOM w0.277: UNK7R34.1 UNK7J4.1
S7_LPC_041: length 5.7
  TOP w0.249: SITE7.68 416.66,266.75
  TOP w0.277: v1(417.69,266.16) 417.1,266.75 416.66,266.75
  BOTTOM w0.277: UNK7R36.1 UNK7J4.3
S7_LPC_042: length 0.9
  TOP w0.249: 412.68,259.35 412.5,259.17 SITE7.50
  TOP w0.277: 412.68,259.35 v1(413.2,259.35)
S7_LPC_044: length 3.9
  TOP w0.249: SITE7.58 413.46,263.25
  TOP w0.277: 413.46,263.25 413.15,262.94 v1(412.55,262.94)
  BOTTOM w0.277: UNK7R39.1 UNK7J4.5
S7_LPC_046: length 2.1
  TOP w0.249: 416.18,266.3 416.07,266.4 SITE7.67
  TOP w0.277: 416.18,266.3 v1(416.31,266.16)
S7_LPC_047: length 3.5
  TOP w0.249: SITE7.18 403.44,263.25
  TOP w0.277: 403.44,263.25 v1(403.64,263.46)
  BOTTOM w0.277: UNK7R41.1 UNK7J4.7
S7_LPC_049: length 5.2
  TOP w0.249: SITE7.8 401.07,266.75
  TOP w0.277: v1(397.58,266.68) 398.14,267.24 400.58,267.24 401.07,266.75
S7_LPC_050: length 2.4
  TOP w0.249: 401.07,267.49 401.46,267.1 SITE7.7
  TOP w0.277: 401.07,267.49 400.76,267.8 v1(400.2,267.8)
S7_LPC_051: length 2
  TOP w0.249: SITE7.49 412.15,259.73 412.36,259.94
  TOP w0.277: 412.36,259.94 412.63,260.2 v1(413.2,260.2)
S7_LPC_052: length 2.4
  TOP w0.249: SITE7.48 411.8,258.15 411.95,258
  TOP w0.277: 411.95,258 412.12,257.84 413.06,257.84 v1(413.2,257.97)
S7_LPC_053: length 7.2
  TOP w0.249: SITE7.57 415.46,262.9 415.69,262.68
  TOP w0.277: 415.69,262.68 418.32,262.68 v1(419.06,263.42)
  BOTTOM w0.277: UNK7R37.1 UNK7J4.4
S7_LPC_055: length 2.4
  TOP w0.249: SITE7.10 400.83,266.05
  TOP w0.277: 400.83,266.05 v1(400.2,266.68)
