# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
S7_LPC_058: length 4.4
  TOP w0.249: SITE7.17 403.06,263.6 403.31,263.85
  TOP w0.277: v1(404.37,263.83) 404.19,264.01 403.47,264.01 403.31,263.85
  BOTTOM w0.277: UNK7R40.1 UNK7J4.6
S7_LPC_060: length 5.2
  TOP w0.249: 415.93,265.51 415.39,266.05 SITE7.66
  TOP w0.277: 415.93,265.51 418.41,265.51 v1(419.06,266.16)
S7_LX_AUD: length 6.2
  TOP w0.249: 403.78,271 SITE7.100
  TOP w0.864: 403.47,271 403.78,271
  TOP w1.016: 403.33,275.38 401.99,274.04 401.99,272.48 403.47,271
S7_LX_DCORE: length 2.2
  TOP w0.249: SITE7.3 400.97,268.5
  TOP w0.508: v1(400.2,268.63) v1(400.74,268.63) 400.85,268.63 400.97,268.5
S7_LX_MEM: length 1.9
  TOP w0.249: 415.1,269.46 414.84,269.2 SITE7.75
  TOP w0.508: v1(415.1,270.48) v1(415.1,269.85) 415.1,269.46
S7_MIPITX_CKN: length 1.3
  TOP w0.249: 410.52,271.89 410.4,271.77 SITE7.82
  TOP w0.277: 410.52,271.89 v1(410.77,272.14)
S7_MIPITX_CKP: length 2.8
  TOP w0.249: SITE7.83 410.05,272.11
  TOP w0.277: 410.05,272.11 410.05,272.79 v1(410.77,273.51)
S7_MIPITX_DATAN_0: length 1.2
  TOP w0.249: SITE7.85 409.35,272.09
  TOP w0.277: 409.35,272.09 v1(409.4,272.14)
S7_MIPITX_DATAN_1: length 2.3
  TOP w0.249: 411.28,270.03 411.1,270.21 SITE7.80
  TOP w0.277: v1(410.83,268.98) 411.28,269.44 411.28,270.03
S7_MIPITX_DATAP_0: length 2.8
  TOP w0.249: 408.82,272.19 408.82,271.93 409,271.75 SITE7.86
  TOP w0.277: v1(409.4,273.51) 408.82,272.94 408.82,272.19
S7_MIPITX_DATAP_1: length 1.2
  TOP w0.249: 410.68,269.97 410.75,270.04 SITE7.81
  TOP w0.277: 410.68,269.97 v1(410.58,269.86)
S7_PA2: length 2.1
  TOP w0.249: SITE7.5 404.09,267.8
  TOP w0.277: 404.09,267.8 v1(404.34,267.55)
S7_PA3: length 1.4
  TOP w0.249: 403.44,267.35 403.34,267.45 SITE7.6
  TOP w0.277: 403.44,267.35 v1(403.61,267.17)
S7_PA9_CH: length 4
  TOP w0.249: 400.67,265.52 400.85,265.35 SITE7.12
  TOP w0.277: v1(398.83,266.68) 399.85,265.66 400.53,265.66 400.67,265.52
S7_PA10_CH: length 2.1
  TOP w0.249: SITE7.13 400.27,265
  TOP w0.277: 400.27,265 v1(400.2,264.93)
S7_PA13: length 3.7
  TOP w0.249: 399.82,264.5 400.02,264.3 SITE7.15
  TOP w0.277: v1(398.83,264.93) 399.39,264.93 399.82,264.5
S7_PA13_UART_RX: length 14.7
  BOTTOM w0.277: UNK7R27.1 504.73,375.96 500.42,371.65 500.42,366.62 UNK7K6.2
S7_PA13_UART_RX_1: length 2.1
  BOTTOM w0.277: UNK7R27.2 509.07,375.96 UNK7J2.3
S7_PA14: length 5.3
  TOP w0.249: 399.21,264.34 399.6,263.95 SITE7.16
  TOP w0.277: v1(397.46,264.93) 397.86,264.93 398.45,264.34 399.21,264.34
S7_PA14_UART_TX: length 10.9
  BOTTOM w0.277: UNK7R28.1 504.63,373.42 503.8,372.59 503.8,366.79 UNK7K6.7
S7_PA14_UART_TX_1: length 2.1
  BOTTOM w0.277: UNK7R28.2 509.07,373.42 UNK7J2.4
S7_PA15_1: length 2
  BOTTOM w0.277: UNK7R40.2 UNK7SW5.6
S7_PA16_1: length 2
  BOTTOM w0.277: UNK7R41.2 UNK7SW5.7
S7_PA20: length 2.2
  TOP w0.152: v1(411.15,261.07) 411.02,260.94 411.02,260.2 410.75,259.93 SITE7.45
S7_PA21: length 1.6
  TOP w0.152: SITE7.46 411.1,259.75 411.58,260.23 v1(411.58,260.41)
S7_PA22: length 2.2
  TOP w0.152: SITE7.43 410.05,259.7 409.86,259.9 409.86,260.91 v1(410.01,261.07)
S7_PA23: length 1.4
  TOP w0.152: SITE7.44 410.4,260.37 v1(410.44,260.41)
S7_PA24: length 1.2
  TOP w0.152: v1(409.06,257.95) 409.35,258.25 SITE7.41
S7_PA25: length 1.2
  TOP w0.152: SITE7.42 409.7,258.25 v1(410,257.95)
S7_PA28: length 2.2
  TOP w0.152: SITE7.39 408.65,260.85 v1(408.86,261.07)
S7_PA29: length 1.5
  TOP w0.152: SITE7.40 409,260.11 v1(409.3,260.41)
S7_PB3: length 2.2
  TOP w0.152: v1(412.25,261.41) 413.28,261.41 413.55,261.15 SITE7.52
S7_PB3_AOUT_LP_2:
  vias: v2(474.93,257.43)
S7_PB4: length 1.4
  TOP w0.152: SITE7.51 v1(412.88,260.8)
S7_PB4_AOUT_LN_2:
  vias: v2(474.93,258.85)
S7_PB5: length 3.8
  TOP w0.152: SITE7.54 415.44,261.85 415.89,261.4 417.04,261.4 v1(417.69,262.04)
S7_PB5_AOUT_RP_2:
  vias: v2(474.93,264.69)
S7_PB6: length 2.1
  TOP w0.152: v1(416.31,262.04) 416.16,262.2 SITE7.55
S7_PB6_AOUT_RN_2:
  vias: v2(474.93,266.11)
S7_PB10_1: length 2
  BOTTOM w0.277: UNK7R37.2 UNK7SW5.4
S7_PB11_1: length 2
  BOTTOM w0.277: UNK7R39.2 UNK7SW5.5
S7_PB21_1: length 2
  BOTTOM w0.277: UNK7R36.2 UNK7SW5.3
S7_PB22_1: length 2
  BOTTOM w0.277: UNK7R35.2 UNK7SW5.2
S7_PB23: length 4.3
  TOP w0.249: 416.01,267.83 415.7,268.15 SITE7.72
  TOP w0.277: 416.01,267.83 v1(416.31,267.53)
  BOTTOM w0.277: UNK7R57.1 UNK7K4.3
S7_PB23_1:
  vias: v2(492.99,244.73)
S7_PB23_SICK:
  vias: v2(499.13,239.07)
S7_PB23_SICK_1: length 1.9
  BOTTOM w0.277: UNK7J1.3 UNK7R20.2
S7_PB24: length 4.2
  TOP w0.249: 416.09,268.68 415.91,268.5 SITE7.73
  TOP w0.277: 416.09,268.68 v1(416.31,268.9)
  BOTTOM w0.277: UNK7K4.6 UNK7R58.1
S7_PB24_1:
  vias: v2(492.99,237.47)
S7_PB24_SIDD:
  vias: v2(499.13,236.53)
S7_PB24_SIDD_1: length 1.9
  BOTTOM w0.277: UNK7J1.4 UNK7R21.2
S7_PB25: length 4.7
  TOP w0.249: SITE7.96 405.5,272.17
  TOP w0.277: v1(405.03,273.51) 405.5,273.04 405.5,272.17
  BOTTOM w0.277: UNK7K8.3 UNK7R59.1
S7_PB25_1:
  vias: v2(492.99,253.14)
S7_PB25_I2C_SCL:
  vias: v2(505.36,239.07)
S7_PB25_I2C_SCL_1: length 1.9
  BOTTOM w0.277: UNK7J3.3 UNK7R31.2
S7_PB26: length 4.1
  TOP w0.249: 404.95,269.63 404.95,270.01 405.15,270.2 SITE7.97
  TOP w0.277: 404.95,269.63 v1(404.95,268.96)
  BOTTOM w0.277: UNK7K8.6 UNK7R60.1
S7_PB26_1:
  vias: v2(492.99,245.87)
S7_PB26_I2C_SDA:
  vias: v2(505.36,236.53)
S7_PB26_I2C_SDA_1: length 1.9
  BOTTOM w0.277: UNK7J3.4 UNK7R32.2
S7_RF_A: length 2.9
  TOP w0.277: UNK7SMP3.1 UNK7C15.1 UNK7D3.1 UNK7C14.1
S7_RF_G: length 5.9
  TOP w0.277: UNK7C6.1 UNK7D2.1 UNK7C8.1 UNK7SMP2.1
S7_RFIN_A: length 3.5
  TOP w0.249: SITE7.29 405.15,258.14 arc(405.2,257.91) v1(405.33,257.71)
  BOTTOM w0.277: UNK7R9.1 UNK7C16.2 404.8,256.44 arc(404.94,257.13) v1(405.33,257.71)
S7_RFIN_G: length 4.2
  TOP w0.249: SITE7.31 v1(405.85,257.18)
  BOTTOM w0.277: UNK7R5.1 UNK7C9.2 arc(406.44,256.4) 406.05,256.98 v1(405.85,257.18)
S7_RFIO_A: length 3.3
  TOP w0.249: 404.8,257.46 SITE7.28
  TOP w0.277: UNK7R6.1 UNK7C11.2 404.8,257.46
S7_RFIO_BT: length 3.5
  TOP w0.249: SITE7.37 407.95,258.35 arc(407.98,258.21) 408.06,258.09
  TOP w0.277: 408.06,258.09 UNK7C1.2 UNK7R1.1
S7_RFIO_G: length 4.1
  TOP w0.249: SITE7.32 406.2,258.25 arc(406.24,257.84) 406.36,257.46
  TOP w0.277: UNK7R2.1 UNK7C4.2 406.78,256.85 arc(406.54,257.13) 406.36,257.46
S7_RREF_MEM: length 7.2
  TOP w0.249: SITE7.60 415.21,263.95 415.42,264.16
  TOP w0.277: 415.42,264.16 418.43,264.16 420.01,265.74 v1(420.73,265.74)
S7_SPI_CLK:
  vias: v2(458.19,244.95)
S7_SPI_CLK/PB28: length 4.3
  TOP w0.249: SITE7.90 407.6,272.64 407.47,272.77
  TOP w0.277: 407.47,272.77 407.09,273.16 407.09,273.82 407.77,274.5 v1(407.77,274.77)
S7_SPI_CS:
  vias: v2(453.01,265.37)
S7_SPI_CS/PC0: length 1.3
  TOP w0.249: 405.75,269.92 405.85,270.03 SITE7.95
  TOP w0.277: 405.75,269.92 v1(405.65,269.83)
S7_SPI_D0/PB29: length 2.9
  TOP w0.249: 407.15,272.33 407.25,272.23 SITE7.91
  TOP w0.277: 407.15,272.33 406.4,273.08 v1(406.4,273.51)
S7_SPI_D1/PB31: length 2.2
  TOP w0.249: SITE7.94 406.2,269.65
  TOP w0.277: 406.2,269.65 406.2,269.26 v1(405.9,268.96)
S7_SPI_D2/PB30: length 1.5
  TOP w0.249: 406.79,271.93 406.9,271.82 SITE7.92
  TOP w0.277: v1(406.4,272.14) 406.58,272.14 406.79,271.93
S7_SPI_D3/PB27: length 2.6
  TOP w0.249: SITE7.89 407.95,272.9
  TOP w0.277: v1(407.77,273.51) 407.95,273.33 407.95,272.9
S7_SPI_DATA0:
  vias: v2(459.46,244.95)
S7_SPI_DATA1:
  vias: v2(454.28,265.37)
S7_SPI_DATA2:
  vias: v2(456.82,265.37)
S7_SPI_DATA3:
  vias: v2(455.65,244.95)
S7_U1_VC1: length 0.7
  TOP w0.152: UNK7U1.4 408.47,251.43
  TOP w0.277: 408.47,251.43 v1(407.84,251.43)
S7_U2_VC1: length 0.7
  TOP w0.152: UNK7U2.4 406.16,247.42
  TOP w0.277: 406.16,247.42 v1(405.53,247.42)
S7_VA09_MIPI: length 1.2
  TOP w0.249: SITE7.84 409.7,270.23
  TOP w0.254: 409.7,270.23 409.7,269.87
  TOP w0.381: 409.7,269.87 v1(409.67,269.84)
  vias: v1(411.2,274.77)
S7_VA09_PLL: length 1.3
  TOP w0.249: SITE7.11 403.3,265.7
  TOP w0.381: 403.3,265.7 v1(403.5,265.5)
  vias: v1(401.19,274.77)
S7_VA09_USB: length 1.3
  TOP w0.249: SITE7.77 412.15,270.09
  TOP w0.381: 412.15,270.09 v1(412.4,269.84)
  vias: v1(416.31,272.38)
S7_VA13_AFE: length 2.3
  TOP w0.249: SITE7.19 401.39,262.9 400.89,263.4
  TOP w0.381: 400.89,263.4 v1(400.2,263.4)
  vias: v1(395.79,265.15)
S7_VA13_SYN: length 2.2
  TOP w0.249: 400.29,261.39 400.4,261.5 SITE7.23
  TOP w0.381: 400.29,261.39 v1(400.2,261.29)
  vias: v1(403.33,261.66)
S7_VA33_SYN: length 5.9
  TOP w0.249: 400.53,260.61 401.08,261.15 SITE7.24
  TOP w0.381: 400.53,260.61 v1(400.2,260.61)
  BOTTOM w0.381: 400.02,260.61 v1(400.2,260.61)
  BOTTOM w0.508: UNK7BD13.2 398.95,258.82 399.51,259.38 399.51,260.1 400.02,260.61
S7_VA33_XTAL: length 7.1
  TOP w0.249: SITE7.20 400.93,262.55 400.74,262.74
  TOP w0.381: 400.74,262.74 v1(400.2,262.74)
  BOTTOM w0.381: 399.83,262.74 v1(400.2,262.74)
  BOTTOM w0.508: UNK7BD5.2 399.15,265.67 399.51,265.32 399.51,263.06 399.83,262.74
S7_VD09_CORE1: length 1.4
  TOP w0.249: v1(413.06,262.19) 413.42,262.55 SITE7.56
  vias: v1(420.73,261.38)
S7_VD09_CORE2: length 1.6
  TOP w0.249: 413.25,265.5 413.39,265.35 SITE7.64
  TOP w0.381: 413.25,265.5 413.06,265.68 v1(413.06,265.91)
  vias: v1(416.31,270.27)
S7_VD09_CORE3: length 1.2
  TOP w0.249: SITE7.87 408.65,270.01 408.71,269.95
  TOP w0.381: 408.71,269.95 v1(408.82,269.84)
  vias: v1(410.14,274.77)
S7_VD09_CORE4: length 4.7
  TOP w0.249: SITE7.98 404.8,272.02
  TOP w0.508: 404.8,272.02 404.8,272.37 v1(403.66,273.51)
  BOTTOM w0.508: v1(403.66,273.51) 403.76,273.51 404.6,274.35 UNK7R79.2
S7_VD13_FE: length 1.5
  TOP w0.249: 407.43,260.29 407.6,260.12 SITE7.36
  TOP w0.381: 407.43,260.29 v1(407.36,260.36)
  vias: v1(415.25,256.37)
S7_VD13_RF: length 2.5
  TOP w0.249: 400.56,259.92 401.44,260.8 SITE7.25
  TOP w0.381: 400.56,259.92 v1(400.2,259.92)
  vias: v1(403.33,260.62)
S7_VD33_ALL: length 0.8
  BOTTOM w0.508: UNK7BD5.1 396.67,265.49 v1(396.67,264.93)
  vias: v1(393.79,258.83) v1(394.76,265.15) v1(394.85,258.83) v1(396.81,268.92) v1(396.89,258.83) v1(397.29,271.59) v1(400.01,255.04) v1(400.15,275.76) v1(401.83,253.44) v1(402.23,275.76) v1(402.77,251.38) v1(406.81,275.76) v1(409.07,275.76) v1(414.32,274.77) v1(416.19,257.57) v1(416.19,254.23) v1(417.32,258.66) v1(417.32,257.57) v1(417.43,271.34) v1(418.6,271.34) v1(421.67,262.45) v2(450.32,244.95)
S7_VD33_CM_BT: length 1
  TOP w0.249: SITE7.35 407.25,258.12
  TOP w0.381: 407.25,258.12 v1(407.25,258.01)
  vias: v1(415.25,255.29) v1(415.25,254.23)
S7_VD33_EX_FLASH: length 9
  TOP w0.508: UNK7BD32.2 450.38,245.95 v2(451.59,245.95) v2(452.86,245.95) v2(454.14,245.95)
  BOTTOM w0.508: UNK7U3.8 453.02,247.61 454.14,246.48 v2(454.14,245.95)
  vias: v2(450.32,245.95) v2(455.55,265.37) v2(456.92,244.95)
S7_VD33_IO0: length 10.2
  TOP w0.249: SITE7.9 403.45,266.4
  TOP w0.381: 403.45,266.4 v1(403.5,266.35)
  BOTTOM w0.508: UNK7BD7.2 402.23,272.95 402.92,272.27 402.92,266.93 v1(403.5,266.35)
S7_VD33_IO2: length 7.2
  TOP w0.249: 415.81,263.42 415.63,263.6 SITE7.59
  TOP w0.381: 415.81,263.42 v1(416.31,263.42)
  BOTTOM w0.381: 416.31,262.99 v1(416.31,263.42)
  BOTTOM w0.508: 416.31,262.99 416.57,262.73 418.25,262.73 418.53,262.45 UNK7BD9.2
S7_VD33_IO3: length 7.8
  TOP w0.249: SITE7.70 413.1,267.45
  TOP w0.381: 413.1,267.45 v1(413.05,267.4)
  BOTTOM w0.508: UNK7BD11.2 414.85,271.34 414.07,270.55 414.07,268.07 413.4,267.4 v1(413.05,267.4)
S7_VD33_IO6: length 6.8
  TOP w0.249: SITE7.88 408.3,270.25 408.13,270.08
  TOP w0.381: 408.13,270.08 v1(407.88,269.83)
  BOTTOM w0.508: UNK7BD12.2 408.59,274.28 408.59,270.54 v1(407.88,269.83)
S7_VD33_SPS_AUD: length 2.7
  TOP w0.249: SITE7.1 402.3,269.41
  TOP w0.508: v1(400.2,270.08) 401.79,270.08 402.3,269.56 402.3,269.41
  vias: v1(396.63,270.92)
S7_VD33_SPS_DCORE: length 6.3
  TOP w0.249: 401.24,269.17 401.56,268.85 SITE7.2
  TOP w0.381: 401.07,269.35 401.24,269.17 ; 398.37,268.5 UNK7C112.1 398.83,268.51 399.08,268.77
  TOP w0.508: 401.07,269.35 399.66,269.35 399.08,268.77 ; v1(396.81,267.98) 397.33,268.5 398.37,268.5
S7_VD33_SPS_MEM: length 4.7
  TOP w0.249: 412.65,271 SITE7.76
  TOP w0.381: 413.63,274.29 UNK7C126.1 413.76,273.77
  TOP w0.508: v1(413.38,274.77) 413.63,274.52 413.63,274.29 ; 413.76,273.77 413.76,271.76 413,271 412.65,271
S7_VD33PA_A: length 7.2
  TOP w0.249: 404.07,257.82 404.45,258.2 SITE7.27
  TOP w0.381: 403.05,256.59 UNK7C100.1 402.62,256.39
  TOP w0.508: 404.07,257.82 403.05,256.79 403.05,256.59 ; 402.62,256.39 401.99,255.76 401.99,254.22 v1(402.77,253.44)
S7_VD33PA_BT: length 10.4
  TOP w0.249: SITE7.38 408.3,260.15 408.18,260.28
  TOP w0.381: 408.18,260.28 v1(408.09,260.36)
  BOTTOM w0.508: UNK7BD18.2 UNK7C83.1 412.9,258.66 411.81,259.74 408.71,259.74 v1(408.09,260.36)
S7_VD33PA_G: length 10
  TOP w0.249: SITE7.33 406.55,259.7 406.38,259.87 406.12,259.87 405.76,260.24 v1(405.76,260.36)
  BOTTOM w0.508: UNK7BD15.2 UNK7C76.1 400.95,256.73 403.66,259.44 405.18,259.44 405.76,260.02 v1(405.76,260.36)
S7_VD33PAD_A: length 10.2
  TOP w0.249: 403.95,259 SITE7.26
  TOP w0.381: 401.27,252.08 UNK7C98.1 400.89,252.27
  TOP w0.508: 401.27,252.08 401.54,252.08 401.83,251.79 v1(401.83,251.38) ; 400.89,252.27 400.89,256.53 403.36,259 403.95,259
S7_VD33PAD_G: length 1.5
  TOP w0.249: SITE7.34 406.9,260.03 v1(406.58,260.36)
  vias: v1(395.78,258.83) v1(395.78,257.76)
S7_VD1833_IO1: length 13
  TOP w0.249: SITE7.14 403.26,264.65
  TOP w0.381: 403.26,264.65 v1(403.5,264.65)
  BOTTOM w0.508: v1(403.5,264.65) 403.05,264.65 401.5,266.2 401.5,270.28 400.15,271.62 UNK7BD3.2
S7_VD1833_SDIO: length 7.9
  TOP w0.249: SITE7.93 406.55,270.22 406.68,270.08
  TOP w0.381: 406.68,270.08 v1(406.94,269.83)
  BOTTOM w0.508: UNK7BD29.2 UNK7C118.1 405.72,271.04 v1(406.94,269.83)
S7_VD_MEM0: length 9.6
  TOP w0.249: 413.06,263.79 413.57,264.3 SITE7.61
  TOP w0.381: 413.06,263.79 v1(413.06,263.7)
  BOTTOM w0.508: v1(413.06,263.7) 414.82,263.7 415.23,264.11 419.38,264.11 419.97,263.52 UNK7R81.2
S7_VD_MEM1: length 10
  TOP w0.249: SITE7.62 413.36,264.65
  TOP w0.254: 413.11,264.54 413.22,264.65 413.36,264.65
  TOP w0.381: 413.11,264.54 v1(413.05,264.49)
  BOTTOM w0.508: UNK7R82.2 420.73,266.85 415.41,266.85 v1(413.05,264.49)
S7_VD_MEM2: length 7.4
  TOP w0.249: 415.94,264.79 415.03,265.7 SITE7.65
  TOP w0.381: 415.94,264.79 v1(416.31,264.79)
  BOTTOM w0.381: 416.55,265.02 v1(416.31,264.79)
  BOTTOM w0.508: 416.55,265.02 416.94,265.41 419.48,265.41 420.25,264.64 UNK7R83.2
S7_VDD09: length 2
  BOTTOM w0.277: UNK7K22.5 UNK7R48.1
S7_VDD18_A: length 6.1
  BOTTOM w0.508: UNK7R55.1 UNK7K25.5 S7_VDD18_A.1
S7_VDD18_D: length 2.3
  BOTTOM w0.508: UNK7R53.1 UNK7K28.5
  vias: v2(470.05,244.84)
S7_VDD33: length 2.2
  TOP w0.152: UNK7U2.6 406.99,247.42 ; UNK7U1.6 409.3,251.43
  TOP w0.277: 409.3,251.43 v1(409.94,251.43) ; 406.99,247.42 v1(407.63,247.42)
  BOTTOM w0.254: UNK7BD33.2 v2(502.59,379.87)
  vias: v2(499.13,244.15) v2(503.68,379.02) v2(505.36,244.15) v2(505.99,381.04) v2(520.4,381.46) v2(521.92,342.58)
S7_VDD33_J1: length 1.9
  BOTTOM w0.277: UNK7J1.1 UNK7R19.2
S7_VDD33_J2: length 2.1
  BOTTOM w0.277: UNK7R24.2 509.07,381.04 UNK7J2.1
S7_VDD33_J3: length 1.9
  BOTTOM w0.277: UNK7J3.1 UNK7R30.2
S7_VREF_DRAM: length 1.9
  TOP w0.249: 412.73,265.06 412.79,265 SITE7.63
  TOP w0.381: 412.73,265.06 v1(412.55,265.25)
S7_XI: length 8.5
  TOP w0.249: 398.07,261.85 SITE7.22
  TOP w0.277: 394.11,261.14 UNK7C25.2 397.3,261.85 398.07,261.85
S7_XO: length 8.5
  TOP w0.249: SITE7.21 398.56,262.2
  TOP w0.254: 398.56,262.2 398.37,262.39
  TOP w0.277: 398.37,262.39 397.85,262.91 UNK7C23.2 396.07,262.91 395.81,263.17 394.58,263.17 UNK7Y1.3
SA_DPS_F005: length 0.9
  BOTTOM w0.254: UT1.4 v2(295.96,69.68)
  vias: v2(306.04,76.15) v2(306.24,73.33) v2(306.24,70.28) v2(312.28,76.38) v2(312.28,73.33) v2(312.28,70.28)
SA_IO_TMP235ADC_2:
  vias: v2(292.36,74.78) v2(294,74.78) v2(295.96,74.78)
SC_1_ATX_5V_SRC: length 0.7
  BOTTOM w0.254: CB637.1 v2(27.16,381.01)
  vias: v2(21.6,379.36) v2(21.6,377.58) v2(25.88,377.96) v2(27.41,386.09) v2(27.41,382.91)
SC_1_ATX_12V_SRC: length 0.7
  BOTTOM w0.254: CB638.1 v2(28.43,361.32)
  vias: v2(21.6,359.04) v2(21.6,357.26) v2(27.41,367.04) v2(27.41,363.86) v2(28.21,359.04) v2(28.21,357.26)
SC_ATX_3V3_SRC:
  vias: v2(27.19,352.69) v2(27.19,350.91)
SC_ATX_VD0V9_COM:
  vias: v2(500.97,85.94) v2(501.22,90.67) v2(503,90.67)
SC_ATX_VD0V9_LED:
  vias: v2(495.13,84.8)
SC_ATX_VD0V9_SW: length 5.8
  BOTTOM w0.254: CB703.2 v2(477.72,99.27)
  BOTTOM w0.277: v2(480.52,96.95) 477.62,96.95 477.35,96.67 UB73.3
  vias: v2(486.62,98.6) v2(488.39,98.6)
SC_ATX_VD0V9_VOUT:
  vias: v2(481.66,89.11) v2(486.62,88.6) v2(488.39,88.6) v2(491.32,85.8) v2(493.22,85.8) v2(495.13,85.8) v2(495.51,90.67) v2(497.28,90.67) v2(498.17,85.94)
SC_ATX_VD1V8_COM:
  vias: v2(364.58,85.94) v2(364.84,90.67) v2(366.61,90.67)
SC_ATX_VD1V8_LED:
  vias: v2(358.74,84.8)
SC_ATX_VD1V8_SW: length 5.8
  BOTTOM w0.254: CB673.2 v2(341.34,99.27)
  BOTTOM w0.277: UB71.3 340.96,96.67 341.24,96.95 v2(344.14,96.95)
  vias: v2(350.23,98.6) v2(352.01,98.6)
SC_ATX_VD1V8_VOUT:
  vias: v2(345.27,89.11) v2(350.23,88.6) v2(352.01,88.6) v2(354.93,85.8) v2(356.84,85.8) v2(358.74,85.8) v2(359.12,90.67) v2(360.9,90.67) v2(361.79,85.94)
SC_ATX_VD33_COM:
  vias: v2(236.34,85.94) v2(236.6,90.67) v2(238.37,90.67)
SC_ATX_VD33_LED:
  vias: v2(230.5,84.8)
SC_ATX_VD33_SW: length 5.8
  BOTTOM w0.254: CB658.2 v2(213.1,99.27)
  BOTTOM w0.277: v2(215.89,96.95) 213,96.95 212.72,96.67 UB70.3
  vias: v2(221.99,98.6) v2(223.77,98.6)
SC_ATX_VD33_VOUT:
  vias: v2(217.03,89.11) v2(221.99,88.6) v2(223.77,88.6) v2(226.69,85.8) v2(228.59,85.8) v2(230.5,85.8) v2(230.88,90.67) v2(232.66,90.67) v2(233.55,85.94)
SC_BOOT_U70:
  vias: v2(209.68,99.27) v2(209.99,94.91)
SC_BOOT_U71:
  vias: v2(337.92,99.27) v2(338.23,94.91)
SC_BOOT_U73:
  vias: v2(474.31,99.27) v2(474.62,94.91)
SC_COMP_RC_U70: length 1.5
  BOTTOM w0.508: v2(212.08,85.8) 212.08,87.07 CB651.2
SC_COMP_RC_U71: length 1.5
  BOTTOM w0.508: CB666.2 340.33,87.07 v2(340.33,85.8)
  vias: v2(339.06,85.8)
SC_COMP_RC_U73: length 1.5
  BOTTOM w0.508: CB696.2 476.71,87.07 v2(476.71,85.8)
  vias: v2(475.44,85.8)
SC_COMP_U70: length 4.1
  BOTTOM w0.508: UB70.6 212.72,88.62 213.22,88.12 CB651.1 213.35,87.07 v2(213.35,85.8)
SC_COMP_U71: length 4.1
  BOTTOM w0.508: v2(341.6,85.8) 341.6,87.07 CB666.1 341.46,88.12 340.96,88.62 UB71.6
SC_COMP_U73: length 4.1
  BOTTOM w0.508: UB73.6 477.35,88.62 477.85,88.12 CB696.1 477.98,87.07 v2(477.98,85.8)
SC_EN_U70:
  vias: v2(208.27,95.6) v2(211.45,89.67)
SC_EN_U71:
  vias: v2(336.52,95.6) v2(339.69,89.67)
SC_EN_U73:
  vias: v2(472.9,95.6) v2(476.08,89.67)
SC_FB_U70: length 11.2
  BOTTOM w0.508: UB70.5 215.03,90.52 215.71,90.52 ; UB70.5 214.74,89.11 215.42,89.11 ; UB70.5 214.86,89.67 ; 215.42,89.11 214.86,89.67 ; 215.42,89.11 v2(216.03,89.11) 215.89,89.25 ; 214.86,89.67 215.71,90.52 ; 214.86,89.67 215.05,89.67 ; RB600.1 215.71,90.52 ; RB600.1 215.05,89.67 ; RB600.1 215.89,89.92 ; 215.47,89.67 215.65,89.67 215.89,89.92 ; 215.47,89.67 215.89,89.25 ; 215.47,89.67 215.05,89.67 ; 215.89,89.25 215.89,89.92
SC_FB_U71: length 11.2
  BOTTOM w0.508: 343.95,90.52 343.27,90.52 UB71.5 ; 343.95,90.52 RB607.1 ; 343.95,90.52 343.1,89.67 ; 344.14,89.25 344.14,89.92 ; 344.14,89.25 v2(344.27,89.11) 343.66,89.11 ; 344.14,89.25 343.71,89.67 ; 344.14,89.92 RB607.1 ; 344.14,89.92 343.89,89.67 343.71,89.67 ; UB71.5 343.1,89.67 ; UB71.5 342.98,89.11 343.66,89.11 ; 343.1,89.67 343.29,89.67 ; 343.1,89.67 343.66,89.11 ; 343.29,89.67 343.71,89.67 ; 343.29,89.67 RB607.1
SC_FB_U73: length 11.2
  BOTTOM w0.508: RB621.1 479.67,89.67 ; RB621.1 480.34,90.52 ; RB621.1 480.52,89.92 ; 479.67,89.67 480.1,89.67 ; 479.67,89.67 479.49,89.67 ; 479.49,89.67 480.34,90.52 ; 479.49,89.67 UB73.5 ; 479.49,89.67 480.05,89.11 ; 480.34,90.52 479.65,90.52 UB73.5 ; UB73.5 479.37,89.11 480.05,89.11 ; 480.05,89.11 v2(480.66,89.11) 480.52,89.25 ; 480.1,89.67 480.52,89.25 ; 480.1,89.67 480.28,89.67 480.52,89.92 ; 480.52,89.25 480.52,89.92
SC_HOLD_UB1: length 2.2
  BOTTOM w0.305: UB5.3 RB205.2
  vias: v2(375.71,72.8)
SC_SS_U70: length 2.5
  BOTTOM w0.254: CB650.2 v2(210.7,87.9)
  BOTTOM w0.277: UB70.8 CB650.2
SC_SS_U71: length 2.5
  BOTTOM w0.254: CB665.2 v2(338.94,87.9)
  BOTTOM w0.277: UB71.8 CB665.2
SC_SS_U73: length 2.5
  BOTTOM w0.254: CB695.2 v2(475.33,87.9)
  BOTTOM w0.277: UB73.8 CB695.2
SC_SW_RC_U70: length 1.2
  BOTTOM w0.508: CB659.1 RB598.2
SC_SW_RC_U71: length 1.2
  BOTTOM w0.508: CB674.1 RB605.2
SC_SW_RC_U73: length 1.2
  BOTTOM w0.508: CB704.1 RB619.2
SC_VIN_U70: length 3.5
  BOTTOM w0.277: CB655.1 210.65,96.87 210.85,97.07 CB653.2 UB70.2
  vias: v2(204.21,97.79) v2(205.1,101.69) v2(205.99,97.79) v2(208.27,96.6)
SC_VIN_U71: length 3.5
  BOTTOM w0.277: UB71.2 CB668.2 339.09,97.07 338.89,96.87 CB670.1
  vias: v2(332.45,97.79) v2(333.34,101.69) v2(334.23,97.79) v2(336.52,96.6)
SC_VIN_U73: length 3.5
  BOTTOM w0.277: CB700.1 475.28,96.87 475.48,97.07 CB698.2 UB73.2
  vias: v2(468.84,97.79) v2(469.73,101.69) v2(470.61,97.79) v2(472.9,96.6)
UR_0: length 1.5
  BOTTOM w0.254: U7.18 v2(320.39,153.9)
UR_1: length 1.7
  BOTTOM w0.254: U7.17 319.74,153.28 v2(319.12,153.9)
UR_2: length 2
  BOTTOM w0.254: U7.15 317.82,151.39 v2(316.58,152.63)
UR_3: length 1.7
  BOTTOM w0.254: v2(316.58,151.36) 317.2,150.74 U7.14
UR_4: length 1.7
  BOTTOM w0.254: v2(316.58,148.82) 317.2,149.44 U7.12
UR_5: length 2
  BOTTOM w0.254: U7.11 317.82,148.79 v2(316.58,147.55)
UR_6: length 1.7
  BOTTOM w0.254: U7.9 319.74,146.9 v2(319.12,146.28)
UR_7: length 1.5
  BOTTOM w0.254: U7.8 v2(320.39,146.28)
UR_8: length 1.5
  BOTTOM w0.254: v2(335.63,153.9) U5.18
UR_9: length 1.7
  BOTTOM w0.254: U5.17 334.98,153.28 v2(334.36,153.9)
UR_10: length 2
  BOTTOM w0.254: v2(331.82,152.63) 333.06,151.39 U5.15
UR_11: length 1.7
  BOTTOM w0.254: v2(331.82,151.36) 332.44,150.74 U5.14
UR_12: length 1.7
  BOTTOM w0.254: U5.12 332.44,149.44 v2(331.82,148.82)
UR_13: length 2
  BOTTOM w0.254: v2(331.82,147.55) 333.06,148.79 U5.11
UR_14: length 1.7
  BOTTOM w0.254: U5.9 334.98,146.9 v2(334.36,146.28)
UR_15: length 1.5
  BOTTOM w0.254: v2(335.63,146.28) U5.8
UR_16: length 1.5
  BOTTOM w0.254: U6.18 v2(350.87,153.9)
UR_17: length 1.7
  BOTTOM w0.254: v2(349.6,153.9) 350.22,153.28 U6.17
UR_18: length 2
  BOTTOM w0.254: U6.15 348.3,151.39 v2(347.06,152.63)
UR_19: length 1.7
  BOTTOM w0.254: v2(347.06,151.36) 347.68,150.74 U6.14
UR_20: length 1.7
  BOTTOM w0.254: U6.12 347.68,149.44 v2(347.06,148.82)
UR_21: length 2
  BOTTOM w0.254: v2(347.06,147.55) 348.3,148.79 U6.11
UR_22: length 1.7
  BOTTOM w0.254: v2(349.6,146.28) 350.22,146.9 U6.9
UR_23: length 1.5
  BOTTOM w0.254: U6.8 v2(350.87,146.28)
UR_24: length 1.5
  BOTTOM w0.254: U8.18 v2(366.11,153.9)
UR_25: length 1.7
  BOTTOM w0.254: v2(364.84,153.9) 365.46,153.28 U8.17
UR_26: length 2
  BOTTOM w0.254: v2(362.3,152.63) 363.54,151.39 U8.15
UR_27: length 1.7
  BOTTOM w0.254: U8.14 362.92,150.74 v2(362.3,151.36)
UR_28: length 1.7
  BOTTOM w0.254: v2(362.3,148.82) 362.92,149.44 U8.12
UR_29: length 2
  BOTTOM w0.254: U8.11 363.54,148.79 v2(362.3,147.55)
UR_30: length 1.7
  BOTTOM w0.254: U8.9 365.46,146.9 v2(364.84,146.28)
UR_31: length 1.5
  BOTTOM w0.254: U8.8 v2(366.11,146.28)
UR_32: length 1.5
  BOTTOM w0.254: U11.18 v2(366.11,138.66)
UR_33: length 1.7
  BOTTOM w0.254: U11.17 365.46,138.04 v2(364.84,138.66)
UR_34: length 2
  BOTTOM w0.254: U11.15 363.54,136.15 v2(362.3,137.39)
UR_35: length 1.7
  BOTTOM w0.254: v2(362.3,136.12) 362.92,135.5 U11.14
UR_36: length 1.7
  BOTTOM w0.254: U11.12 362.92,134.2 v2(362.3,133.58)
UR_37: length 2
  BOTTOM w0.254: U11.11 363.54,133.55 v2(362.3,132.31)
UR_38: length 1.7
  BOTTOM w0.254: v2(364.84,131.04) 365.46,131.66 U11.9
UR_39: length 1.5
  BOTTOM w0.254: U11.8 v2(366.11,131.04)
UR_40: length 1.5
  BOTTOM w0.254: U9.18 v2(350.87,138.66)
UR_41: length 1.7
  BOTTOM w0.254: U9.17 350.22,138.04 v2(349.6,138.66)
UR_42: length 2
  BOTTOM w0.254: v2(347.06,137.39) 348.3,136.15 U9.15
UR_43: length 1.7
  BOTTOM w0.254: v2(347.06,136.12) 347.68,135.5 U9.14
UR_44: length 1.7
  BOTTOM w0.254: U9.12 347.68,134.2 v2(347.06,133.58)
UR_45: length 2
  BOTTOM w0.254: v2(347.06,132.31) 348.3,133.55 U9.11
UR_46: length 1.7
  BOTTOM w0.254: v2(349.6,131.04) 350.22,131.66 U9.9
UR_47: length 1.5
  BOTTOM w0.254: U9.8 v2(350.87,131.04)
UR_48: length 1.5
  BOTTOM w0.254: U10.18 v2(335.63,138.66)
UR_49: length 1.7
  BOTTOM w0.254: v2(334.36,138.66) 334.98,138.04 U10.17
UR_50: length 2
  BOTTOM w0.254: U10.15 333.06,136.15 v2(331.82,137.39)
UR_51: length 1.7
  BOTTOM w0.254: v2(331.82,136.12) 332.44,135.5 U10.14
UR_52: length 1.7
  BOTTOM w0.254: U10.12 332.44,134.2 v2(331.82,133.58)
UR_53: length 2
  BOTTOM w0.254: U10.11 333.06,133.55 v2(331.82,132.31)
UR_54: length 1.7
  BOTTOM w0.254: v2(334.36,131.04) 334.98,131.66 U10.9
UR_55: length 1.5
  BOTTOM w0.254: U10.8 v2(335.63,131.04)
UR_56: length 1.5
  BOTTOM w0.254: U12.18 v2(320.39,138.66)
UR_57: length 1.7
  BOTTOM w0.254: U12.17 319.74,138.04 v2(319.12,138.66)
UR_58: length 2
  BOTTOM w0.254: v2(316.58,137.39) 317.82,136.15 U12.15
UR_59: length 1.7
  BOTTOM w0.254: U12.14 317.2,135.5 v2(316.58,136.12)
UR_60: length 1.7
  BOTTOM w0.254: U12.12 317.2,134.2 v2(316.58,133.58)
UR_61: length 2
  BOTTOM w0.254: U12.11 317.82,133.55 v2(316.58,132.31)
UR_62: length 1.7
  BOTTOM w0.254: v2(319.12,131.04) 319.74,131.66 U12.9
UR_63: length 1.5
  BOTTOM w0.254: U12.8 v2(320.39,131.04)
UR_64: length 1.5
  BOTTOM w0.254: U13.18 v2(320.39,123.42)
UR_65: length 1.7
  BOTTOM w0.254: U13.17 319.74,122.8 v2(319.12,123.42)
UR_66: length 2
  BOTTOM w0.254: U13.15 317.82,120.91 v2(316.58,122.15)
UR_67: length 1.7
  BOTTOM w0.254: U13.14 317.2,120.26 v2(316.58,120.88)
UR_68: length 1.7
  BOTTOM w0.254: v2(316.58,118.34) 317.2,118.96 U13.12
UR_69: length 2
  BOTTOM w0.254: U13.11 317.82,118.31 v2(316.58,117.07)
UR_70: length 1.7
  BOTTOM w0.254: U13.9 319.74,116.42 v2(319.12,115.8)
UR_71: length 1.5
  BOTTOM w0.254: U13.8 v2(320.39,115.8)
UR_72: length 1.5
  BOTTOM w0.254: U14.18 v2(335.63,123.42)
UR_73: length 1.7
  BOTTOM w0.254: v2(334.36,123.42) 334.98,122.8 U14.17
UR_74: length 2
  BOTTOM w0.254: v2(331.82,122.15) 333.06,120.91 U14.15
UR_75: length 1.7
  BOTTOM w0.254: v2(331.82,120.88) 332.44,120.26 U14.14
UR_76: length 1.7
  BOTTOM w0.254: v2(331.82,118.34) 332.44,118.96 U14.12
UR_77: length 2
  BOTTOM w0.254: U14.11 333.06,118.31 v2(331.82,117.07)
UR_78: length 1.7
  BOTTOM w0.254: v2(334.36,115.8) 334.98,116.42 U14.9
UR_79: length 1.5
  BOTTOM w0.254: U14.8 v2(335.63,115.8)
UR_80: length 1.5
  BOTTOM w0.254: U15.18 v2(350.87,123.42)
UR_81: length 1.7
  BOTTOM w0.254: U15.17 350.22,122.8 v2(349.6,123.42)
UR_82: length 2
  BOTTOM w0.254: v2(347.06,122.15) 348.3,120.91 U15.15
UR_83: length 1.7
  BOTTOM w0.254: v2(347.06,120.88) 347.68,120.26 U15.14
UR_84: length 1.7
  BOTTOM w0.254: U15.12 347.68,118.96 v2(347.06,118.34)
UR_85: length 2
  BOTTOM w0.254: U15.11 348.3,118.31 v2(347.06,117.07)
UR_86: length 1.7
  BOTTOM w0.254: v2(349.6,115.8) 350.22,116.42 U15.9
UR_87: length 1.5
  BOTTOM w0.254: U15.8 v2(350.87,115.8)
UR_88: length 1.5
  BOTTOM w0.254: U16.18 v2(366.11,123.42)
UR_89: length 1.7
  BOTTOM w0.254: U16.17 365.46,122.8 v2(364.84,123.42)
UR_90: length 2
  BOTTOM w0.254: U16.15 363.54,120.91 v2(362.3,122.15)
UR_91: length 1.7
  BOTTOM w0.254: v2(362.3,120.88) 362.92,120.26 U16.14
UR_92: length 1.7
  BOTTOM w0.254: v2(362.3,118.34) 362.92,118.96 U16.12
UR_93: length 2
  BOTTOM w0.254: v2(362.3,117.07) 363.54,118.31 U16.11
UR_94: length 1.7
  BOTTOM w0.254: U16.9 365.46,116.42 v2(364.84,115.8)
UR_95: length 1.5
  BOTTOM w0.254: U16.8 v2(366.11,115.8)
VN15:
  vias: v2(366.3,73.46) v2(366.88,69.49)
VP5A: length 2.2
  BOTTOM w0.305: UB5.8 v2(373.51,74.26)
  vias: v2(343.19,76.38) v2(343.64,73.07) v2(343.94,70.46) v2(384.14,71.53)
VP5B: length 44.5
  BOTTOM w0.356: U11.19 366.76,138.04 v2(367.38,138.66) ; U10.19 336.28,138.04 v2(336.9,138.66) ; v2(338.17,146.28) 338.17,146.51 U5.6 ; U14.19 336.28,122.8 v2(336.9,123.42) ; v2(352.14,123.42) 351.52,122.8 U15.19 ; v2(321.66,123.42) 321.04,122.8 U13.19 ; U11.6 368.65,131.27 v2(368.65,131.04) ; v2(321.66,138.66) 321.04,138.04 U12.19 ; v2(353.41,131.04) 353.41,131.27 U9.6 ; v2(368.65,115.8) 368.65,116.03 U16.6 ; v2(353.41,146.28) 353.41,146.51 U6.6 ; U7.6 322.93,146.51 v2(322.93,146.28) ; U8.19 366.76,153.28 v2(367.38,153.9) ; U13.6 322.93,116.03 v2(322.93,115.8) ; v2(321.66,153.9) 321.04,153.28 U7.19 ; U5.19 336.28,153.28 v2(336.9,153.9) ; v2(368.65,146.28) 368.65,146.51 U8.6 ; U9.19 351.52,138.04 v2(352.14,138.66) ; U6.19 351.52,153.28 v2(352.14,153.9) ; U14.6 338.17,116.03 v2(338.17,115.8) ; v2(367.38,123.42) 366.76,122.8 U16.19 ; U10.6 338.17,131.27 v2(338.17,131.04) ; U12.6 322.93,131.27 v2(322.93,131.04) ; U15.6 353.41,116.03 v2(353.41,115.8)
  vias: v2(321.24,142.47) v2(321.24,127.23) v2(324.2,153.9) v2(324.2,138.66) v2(324.2,123.42) v2(324.56,69.17) v2(324.86,73.07) v2(325.31,76.38) v2(336.48,142.47) v2(336.48,127.23) v2(339.44,153.9) v2(339.44,138.66) v2(339.44,123.42) v2(351.72,142.47) v2(351.72,127.23) v2(354.68,153.9) v2(354.68,138.66) v2(354.68,123.42) v2(366.96,142.47) v2(366.96,127.23) v2(369.92,153.9) v2(369.92,138.66) v2(369.92,123.42)
VP5B_EN:
  vias: v2(340.71,68.91)
VP12:
  vias: v2(275.29,73.23) v2(275.59,69.87) v2(276.04,76.35)
VP15:
  vias: v2(356.21,73.46) v2(356.78,69.49) v2(356.96,76.38)
VP24:
  vias: v2(333.24,76.38) v2(333.42,69.49) v2(333.99,73.46)
N7344580: length 1.1
  BOTTOM w0.305: CB658.1 v2(210.68,99.27)
N7347819: length 1.1
  BOTTOM w0.305: CB673.1 v2(338.92,99.27)
N7350256: length 1.1
  BOTTOM w0.305: CB703.1 v2(475.31,99.27)
N16079151:
  vias: v2(323.61,76.38)
N16079317:
  vias: v2(344.89,76.38)
N16079993:
  vias: v2(274.34,76.35)
N16083795:
  vias: v2(334.94,76.38)
N16083921:
  vias: v2(355.26,76.38)
N16084055:
  vias: v2(365.35,76.38)
N19745084: length 3.5
  BOTTOM w0.277: U8.5 368.68,148.79 v2(369.92,147.55) ; U11.3 v2(369.92,134.85)
N20743418: length 3.5
  BOTTOM w0.277: v2(339.44,147.55) 338.2,148.79 U5.5 ; U6.3 v2(354.68,150.09)
N20743561: length 2
  BOTTOM w0.277: v2(324.2,152.63) 322.96,151.39 U7.1
N20743722: length 2
  BOTTOM w0.277: v2(339.44,152.63) 338.2,151.39 U5.1
N20743738: length 2
  BOTTOM w0.277: v2(338.17,153.9) 336.93,152.66 U5.20
N20743807: length 2
  BOTTOM w0.277: v2(322.93,153.9) 321.69,152.66 U7.20
N20754919: length 3.5
  BOTTOM w0.277: U8.3 v2(369.92,150.09) ; v2(354.68,147.55) 353.44,148.79 U6.5
N20754925: length 2
  BOTTOM w0.277: U6.1 353.44,151.39 v2(354.68,152.63)
N20754928: length 2
  BOTTOM w0.277: v2(353.41,153.9) 352.17,152.66 U6.20
N20754936: length 3.5
  BOTTOM w0.277: v2(339.44,150.09) U5.3 ; U7.5 322.96,148.79 v2(324.2,147.55)
N20754977: length 2
  BOTTOM w0.277: U8.1 368.68,151.39 v2(369.92,152.63)
N20754980: length 2
  BOTTOM w0.277: v2(368.65,153.9) 367.41,152.66 U8.20
N24979212: length 1.9
  BOTTOM w0.277: R38.1 SW5.10
N24979216: length 1.9
  BOTTOM w0.277: R42.1 SW5.9
N24989047: length 3.5
  TOP w0.152: U1.3 288.47,192.35
  TOP w0.277: v1(287.51,193.08) 287.51,193.04 arc(287.71,192.56) 288.2,192.35 288.47,192.35
  BOTTOM w0.277: R5.2 C10.1 arc(286.62,193.5) 286.76,193.29 arc(287,193.13) 287.28,193.08 v1(287.51,193.08)
N24989128: length 1.9
  TOP w0.152: 288.89,191.13 U1.5
  TOP w0.277: C7.2 289.55,190.47 arc(289.08,190.66) 288.89,191.13
N24989237: length 0.8
  TOP w0.152: 289.3,192.35 U1.1
  TOP w0.277: R4.1 289.3,192.35
N24989519: length 0.7
  TOP w0.277: R3.2 C6.2
N24989550: length 8.6
  TOP w0.152: U2.1 286.99,188.34
  TOP w0.277: 286.99,188.34 287.27,188.34 arc(287.76,188.54) 287.96,189.03 v1(287.96,189.06)
  BOTTOM w0.277: v1(287.96,189.06) 286.31,190.75 arc(285.19,192.43) C19.1 R9.2
N24989582: length 1.9
  TOP w0.152: 286.58,187.12 U2.5
  TOP w0.277: C14.2 285.92,186.46 arc(286.39,186.65) 286.58,187.12
N24989672: length 6.7
  TOP w0.277: R8.2 C12.1 R6.2
N24989686: length 0.7
  TOP w0.277: C13.2 R7.2
N24989857: length 3.1
  BOTTOM w0.508: BD27.2 C24.1 223.26,193.01 K16.4
N24989916: length 3.2
  BOTTOM w0.277: R22.1 K5.6
N24989920: length 3.2
  BOTTOM w0.277: R25.1 K5.4
N24989997: length 0.8
  TOP w0.152: 286.16,188.34 U2.3
  TOP w0.277: R8.1 286.16,188.34
N24990019: length 3.6
  TOP w0.277: R3.1 290.67,192.68 arc(290.61,192.94) 290.47,193.16 C5.1 R2.2
N24990271: length 5.1
  TOP w0.277: 293.34,191.84 292.42,193.43 arc(291.98,194.09) 291.45,194.69 291,195.15 C3.1 R1.2
N24990291: length 2.3
  TOP w0.277: C2.2 D1.1 SMP1.1
N25003725: length 3.2
  BOTTOM w0.277: R23.1 K7.6
N25003728: length 3.2
  BOTTOM w0.277: R26.1 K7.4
N25009119: length 2
  BOTTOM w0.277: K19.4 C39.1
N25009121: length 2
  BOTTOM w0.277: K19.2 C38.2
N25009152: length 2
  BOTTOM w0.277: K19.5 C41.1
N25009154: length 2
  BOTTOM w0.277: K19.7 C40.2
N25019718: length 2.3
  BOTTOM w0.277: R54.1 K28.4
N25019726:
  vias: v1(288.97,220.27) v1(288.98,218.11)
N25019924: length 2
  BOTTOM w0.277: K22.4 R49.1
N25019943:
  vias: v1(266.68,216.76) v1(266.68,214.73)
N25095269: length 2.8
  BOTTOM w0.277: R51.1 276.15,229.96 K25.4
N25095276:
  vias: v1(276.49,226.51) v1(278.79,226.51)
N25103211: length 2.3
  BOTTOM w0.508: BD27.1 R33.2 R29.1
N25107005: length 1.8
  BOTTOM w0.305: R61.1 SW6.6
N25107009: length 1.8
  BOTTOM w0.305: R62.1 SW6.5
N25114262: length 1.4
  BOTTOM w0.152: R74.2 R47.2
N25278384: length 3.5
  BOTTOM w0.277: U12.5 322.96,133.55 v2(324.2,132.31) ; U13.3 v2(324.2,119.61)
N25278501: length 3.5
  BOTTOM w0.277: v2(339.44,132.31) 338.2,133.55 U10.5 ; U12.3 v2(324.2,134.85)
N25278513: length 2
  BOTTOM w0.277: v2(339.44,137.39) 338.2,136.15 U10.1
N25278527: length 2
  BOTTOM w0.277: U10.20 336.93,137.42 v2(338.17,138.66)
N25278533: length 3.5
  BOTTOM w0.277: v2(354.68,132.31) 353.44,133.55 U9.5 ; U10.3 v2(339.44,134.85)
N25278541: length 3.5
  BOTTOM w0.277: U11.5 368.68,133.55 v2(369.92,132.31) ; U9.3 v2(354.68,134.85)
N25278621: length 2
  BOTTOM w0.277: v2(324.2,137.39) 322.96,136.15 U12.1
N25278627: length 2
  BOTTOM w0.277: U12.20 321.69,137.42 v2(322.93,138.66)
N25278841: length 2
  BOTTOM w0.277: v2(369.92,137.39) 368.68,136.15 U11.1
N25278855: length 2
  BOTTOM w0.277: v2(354.68,137.39) 353.44,136.15 U9.1
N25278861: length 2
  BOTTOM w0.277: U9.20 352.17,137.42 v2(353.41,138.66)
N25278867: length 2
  BOTTOM w0.277: v2(368.65,138.66) 367.41,137.42 U11.20
N25280768: length 3.5
  BOTTOM w0.277: U16.3 v2(369.92,119.61) ; v2(354.68,117.07) 353.44,118.31 U15.5
N25280780: length 2
  BOTTOM w0.277: v2(354.68,122.15) 353.44,120.91 U15.1
N25280794: length 2
  BOTTOM w0.277: v2(353.41,123.42) 352.17,122.18 U15.20
N25280800: length 3.5
  BOTTOM w0.277: U14.5 338.2,118.31 v2(339.44,117.07) ; U15.3 v2(354.68,119.61)
N25280808: length 3.5
  BOTTOM w0.277: v2(324.2,117.07) 322.96,118.31 U13.5 ; U14.3 v2(339.44,119.61)
N25280888: length 2
  BOTTOM w0.277: U16.1 368.68,120.91 v2(369.92,122.15)
N25280894: length 2
  BOTTOM w0.277: U16.20 367.41,122.18 v2(368.65,123.42)
N25281108: length 2
  BOTTOM w0.277: v2(324.2,122.15) 322.96,120.91 U13.1
N25281122: length 2
  BOTTOM w0.277: U14.1 338.2,120.91 v2(339.44,122.15)
N25281128: length 2
  BOTTOM w0.277: U14.20 336.93,122.18 v2(338.17,123.42)
N25281134: length 2
  BOTTOM w0.277: v2(322.93,123.42) 321.69,122.18 U13.20
N25614045: length 3.4
  BOTTOM w1.016: R71.1 K30.3
N25614052: length 3.4
  BOTTOM w1.016: R72.1 K31.3
N25614059: length 3.4
  BOTTOM w1.016: R73.1 K32.3
N25867897: length 1.4
  BOTTOM w0.152: R75.2 R45.2
N25938555: length 3.3
  TOP w0.249: SITE0.47 291.45,197.64 291.67,197.42
  TOP w0.277: v1(293.2,197.12) 291.98,197.12 291.67,197.42
N25967988: length 2
  TOP w0.277: K34.4 187.38,175.97 C145.2
N25967991: length 2
  TOP w0.277: C146.2 187.38,179.17 K34.5
N25968094: length 2
  TOP w0.277: C147.2 187.38,168.71 K35.4
N25968096: length 2
  TOP w0.277: K35.5 187.38,171.91 C148.2
N25968164: length 2
  TOP w0.277: C149.2 187.38,184.61 K36.4
N25968166: length 2
  TOP w0.277: K36.5 187.38,187.81 C150.2
N26344713: length 1.3
  BOTTOM w0.305: UT1.3 v2(295.96,73.78)
N27439655: length 3.5
  TOP w0.152: UNK1U1.3 328.47,192.35
  TOP w0.277: 328.47,192.35 328.19,192.35 arc(327.71,192.56) 327.51,193.04 v1(327.51,193.08)
  BOTTOM w0.277: UNK1R5.2 UNK1C10.1 arc(326.62,193.5) 326.76,193.29 arc(327,193.13) 327.28,193.08 v1(327.51,193.08)
N27439661: length 1.9
  TOP w0.152: 328.89,191.13 UNK1U1.5
  TOP w0.277: UNK1C7.2 329.55,190.47 arc(329.08,190.66) 328.89,191.13
N27439664: length 0.8
  TOP w0.152: 329.3,192.35 UNK1U1.1
  TOP w0.277: UNK1R4.1 329.3,192.35
N27439715: length 0.7
  TOP w0.277: UNK1R3.2 UNK1C6.2
N27439724: length 8.6
  TOP w0.152: UNK1U2.1 326.99,188.34
  TOP w0.277: v1(327.96,189.06) 327.96,189.03 arc(327.76,188.54) 327.27,188.34 326.99,188.34
  BOTTOM w0.277: UNK1R9.2 UNK1C19.1 arc(325.19,192.43) 326.31,190.75 v1(327.96,189.06)
N27439731: length 1.9
  TOP w0.152: 326.58,187.12 UNK1U2.5
  TOP w0.277: UNK1C14.2 325.92,186.46 arc(326.39,186.65) 326.58,187.12
N27439738: length 6.7
  TOP w0.277: UNK1R7.1 UNK1C12.1 UNK1R6.2
N27439740: length 0.7
  TOP w0.277: UNK1C13.2 UNK1R7.2
N27439759: length 3.1
  BOTTOM w0.508: UNK1K16.4 223.26,227.3 UNK1C24.1 UNK1BD27.2
N27439769: length 3.2
  BOTTOM w0.277: UNK1R22.1 UNK1K5.6
N27439771: length 3.2
  BOTTOM w0.277: UNK1R25.1 UNK1K5.4
N27439774: length 0.8
  TOP w0.152: 326.16,188.34 UNK1U2.3
  TOP w0.277: UNK1R8.1 326.16,188.34
N27439780: length 3.6
  TOP w0.277: UNK1R4.2 330.67,192.68 arc(330.61,192.94) 330.47,193.16 UNK1C5.1 UNK1R2.2
N27439808: length 5.1
  TOP w0.277: UNK1R1.2 UNK1C3.1 331,195.15 331.45,194.69 arc(331.98,194.09) 332.42,193.43 333.34,191.84
N27439813: length 2.3
  TOP w0.277: UNK1SMP1.1 UNK1D1.1 UNK1C2.2
N27439931: length 3.2
  BOTTOM w0.277: UNK1R23.1 UNK1K7.6
N27439932: length 3.2
  BOTTOM w0.277: UNK1R26.1 UNK1K7.4
N27439937: length 2.3
  BOTTOM w0.508: UNK1BD27.1 UNK1R33.2 UNK1R29.1
N27440064: length 3.3
  TOP w0.249: 331.67,197.42 331.45,197.64 SITE1.47
  TOP w0.277: 331.67,197.42 331.98,197.12 v1(333.2,197.12)
N27443667: length 2
  BOTTOM w0.277: UNK1K19.4 UNK1C39.1
N27443668: length 2
  BOTTOM w0.277: UNK1K19.2 UNK1C38.2
N27443671: length 2
  BOTTOM w0.277: UNK1K19.5 UNK1C41.1
N27443672: length 2
  BOTTOM w0.277: UNK1K19.7 UNK1C40.2
N27443703: length 1.4
  BOTTOM w0.152: UNK1R74.2 UNK1R47.2
N27443785: length 1.4
  BOTTOM w0.152: UNK1R75.2 UNK1R45.2
N27443801: length 2
  TOP w0.277: UNK1C145.2 187.38,210.26 UNK1K34.4
N27443802: length 2
  TOP w0.277: UNK1K34.5 187.38,213.46 UNK1C146.2
N27443809: length 2
  TOP w0.277: UNK1K35.4 187.38,203 UNK1C147.2
N27443810: length 2
  TOP w0.277: UNK1K35.5 187.38,206.2 UNK1C148.2
N27443813: length 2
  TOP w0.277: UNK1K36.4 187.38,218.9 UNK1C149.2
N27443814: length 2
  TOP w0.277: UNK1C150.2 187.38,222.1 UNK1K36.5
N27444943: length 2.3
  BOTTOM w0.277: UNK1R54.1 UNK1K28.4
N27444947:
  vias: v1(328.97,220.27) v1(328.98,218.11)
N27444982: length 2
  BOTTOM w0.277: UNK1K22.4 UNK1R49.1
N27444986:
  vias: v1(306.68,216.76) v1(306.68,214.73)
N27445113: length 2.8
  BOTTOM w0.277: UNK1K25.4 316.15,229.96 UNK1R51.1
N27445115:
  vias: v1(316.49,226.51) v1(318.79,226.51)
N27445221: length 3.4
  BOTTOM w1.016: UNK1R71.1 UNK1K30.3
N27445223: length 3.4
  BOTTOM w1.016: UNK1R72.1 UNK1K31.3
N27445225: length 3.4
  BOTTOM w1.016: UNK1R73.1 UNK1K32.3
N27448585: length 3.5
  TOP w0.152: UNK2U1.3 368.47,192.35
  TOP w0.277: v1(367.51,193.08) 367.51,193.04 arc(367.71,192.56) 368.19,192.35 368.47,192.35
  BOTTOM w0.277: v1(367.51,193.08) 367.28,193.08 arc(367,193.13) 366.76,193.29 arc(366.62,193.5) UNK2C10.1 UNK2R5.2
N27448591: length 1.9
  TOP w0.152: 368.89,191.13 UNK2U1.5
  TOP w0.277: UNK2C7.2 369.55,190.47 arc(369.08,190.66) 368.89,191.13
N27448594: length 0.8
  TOP w0.152: 369.3,192.35 UNK2U1.1
  TOP w0.277: UNK2R4.1 369.3,192.35
N27448645: length 0.7
  TOP w0.277: UNK2R3.2 UNK2C6.2
N27448654: length 8.6
  TOP w0.152: UNK2U2.1 366.99,188.34
  TOP w0.277: 366.99,188.34 367.27,188.34 arc(367.76,188.54) 367.96,189.03 v1(367.96,189.06)
  BOTTOM w0.277: v1(367.96,189.06) 366.31,190.75 arc(365.19,192.43) UNK2C19.1 UNK2R9.2
N27448661: length 1.9
  TOP w0.152: 366.58,187.12 UNK2U2.5
  TOP w0.277: UNK2C14.2 365.92,186.46 arc(366.39,186.65) 366.58,187.12
N27448668: length 6.7
  TOP w0.277: UNK2R8.2 UNK2C12.1 UNK2R6.2
N27448670: length 0.7
  TOP w0.277: UNK2C13.2 UNK2R7.2
N27448689: length 3.1
  BOTTOM w0.508: UNK2BD27.2 UNK2C24.1 473.34,208.41 UNK2K16.4
N27448699: length 3.2
  BOTTOM w0.277: UNK2R22.1 UNK2K5.6
N27448701: length 3.2
  BOTTOM w0.277: UNK2R25.1 UNK2K5.4
N27448704: length 0.8
  TOP w0.152: 366.16,188.34 UNK2U2.3
  TOP w0.277: UNK2R8.1 366.16,188.34
N27448710: length 3.6
  TOP w0.277: UNK2R2.2 UNK2C5.1 370.47,193.16 arc(370.61,192.94) 370.67,192.68 UNK2R3.1
N27448738: length 5.1
  TOP w0.277: UNK2R1.2 UNK2C3.1 371,195.15 371.45,194.69 arc(371.98,194.09) 372.42,193.43 373.34,191.84
N27448743: length 2.3
  TOP w0.277: UNK2C2.2 UNK2D1.1 UNK2SMP1.1
N27448861: length 3.2
  BOTTOM w0.277: UNK2R23.1 UNK2K7.6
N27448862: length 3.2
  BOTTOM w0.277: UNK2R26.1 UNK2K7.4
N27448867: length 2.3
  BOTTOM w0.508: UNK2R29.1 UNK2R33.2 UNK2BD27.1
N27448994: length 3.3
  TOP w0.249: SITE2.47 371.45,197.64 371.67,197.42
  TOP w0.277: v1(373.2,197.12) 371.98,197.12 371.67,197.42
N27452597: length 2
  BOTTOM w0.277: UNK2K19.4 UNK2C39.1
N27452598: length 2
  BOTTOM w0.277: UNK2K19.2 UNK2C38.2
N27452601: length 2
  BOTTOM w0.277: UNK2K19.5 UNK2C41.1
N27452602: length 2
  BOTTOM w0.277: UNK2K19.7 UNK2C40.2
N27452633: length 1.4
  BOTTOM w0.152: UNK2R74.2 UNK2R47.2
N27452715: length 1.4
  BOTTOM w0.152: UNK2R75.2 UNK2R45.2
N27452731: length 2
  TOP w0.277: UNK2K34.4 509.22,225.45 UNK2C145.2
N27452732: length 2
  TOP w0.277: UNK2K34.5 509.22,222.25 UNK2C146.2
N27452739: length 2
  TOP w0.277: UNK2C147.2 509.22,232.71 UNK2K35.4
N27452740: length 2
  TOP w0.277: UNK2K35.5 509.22,229.51 UNK2C148.2
N27452743: length 2
  TOP w0.277: UNK2C149.2 509.22,216.81 UNK2K36.4
N27452744: length 2
  TOP w0.277: UNK2C150.2 509.22,213.62 UNK2K36.5
N27453873: length 2.3
  BOTTOM w0.277: UNK2R54.1 UNK2K28.4
N27453877:
  vias: v1(368.97,220.27) v1(368.98,218.11)
N27453912: length 2
  BOTTOM w0.277: UNK2K22.4 UNK2R49.1
N27453916:
  vias: v1(346.68,216.76) v1(346.68,214.73)
N27454043: length 2.8
  BOTTOM w0.277: UNK2R51.1 356.15,229.96 UNK2K25.4
N27454045:
  vias: v1(356.49,226.51) v1(358.79,226.51)
N27454151: length 3.4
  BOTTOM w1.016: UNK2R71.1 UNK2K30.3
N27454153: length 3.4
  BOTTOM w1.016: UNK2R72.1 UNK2K31.3
N27454155: length 3.4
  BOTTOM w1.016: UNK2R73.1 UNK2K32.3
N27457514: length 3.5
  TOP w0.152: UNK3U1.3 408.47,192.35
  TOP w0.277: 408.47,192.35 408.19,192.35 arc(407.71,192.56) 407.51,193.04 v1(407.51,193.08)
  BOTTOM w0.277: v1(407.51,193.08) 407.28,193.08 arc(407,193.13) 406.76,193.29 arc(406.62,193.5) UNK3C10.1 UNK3R5.2
N27457520: length 1.9
  TOP w0.152: 408.89,191.13 UNK3U1.5
  TOP w0.277: UNK3C7.2 409.55,190.47 arc(409.08,190.66) 408.89,191.13
N27457523: length 0.8
  TOP w0.152: 409.3,192.35 UNK3U1.1
  TOP w0.277: UNK3R4.1 409.3,192.35
N27457574: length 0.7
  TOP w0.277: UNK3R3.2 UNK3C6.2
N27457583: length 8.6
  TOP w0.152: UNK3U2.1 406.99,188.34
  TOP w0.277: 406.99,188.34 407.27,188.34 arc(407.76,188.54) 407.96,189.03 v1(407.96,189.06)
  BOTTOM w0.277: v1(407.96,189.06) 406.31,190.75 arc(405.19,192.43) UNK3C19.1 UNK3R9.2
N27457590: length 1.9
  TOP w0.152: 406.58,187.12 UNK3U2.5
  TOP w0.277: UNK3C14.2 405.92,186.46 arc(406.39,186.65) 406.58,187.12
N27457597: length 6.7
  TOP w0.277: UNK3R6.2 UNK3C12.1 UNK3R7.1
N27457599: length 0.7
  TOP w0.277: UNK3C13.2 UNK3R7.2
N27457618: length 3.1
  BOTTOM w0.508: UNK3K16.4 473.34,174.12 UNK3C24.1 UNK3BD27.2
N27457628: length 3.2
  BOTTOM w0.277: UNK3R22.1 UNK3K5.6
N27457630: length 3.2
  BOTTOM w0.277: UNK3R25.1 UNK3K5.4
N27457633: length 0.8
  TOP w0.152: 406.16,188.34 UNK3U2.3
  TOP w0.277: UNK3R8.1 406.16,188.34
N27457639: length 3.6
  TOP w0.277: UNK3R2.2 UNK3C5.1 410.47,193.16 arc(410.61,192.94) 410.67,192.68 UNK3R3.1
N27457667: length 5.1
  TOP w0.277: 413.34,191.84 412.42,193.43 arc(411.98,194.09) 411.45,194.69 411,195.15 UNK3C3.1 UNK3R1.2
N27457672: length 2.3
  TOP w0.277: UNK3SMP1.1 UNK3D1.1 UNK3C2.2
N27457790: length 3.2
  BOTTOM w0.277: UNK3R23.1 UNK3K7.6
N27457791: length 3.2
  BOTTOM w0.277: UNK3R26.1 UNK3K7.4
N27457796: length 2.3
  BOTTOM w0.508: UNK3R29.1 UNK3R33.2 UNK3BD27.1
N27457923: length 3.3
  TOP w0.249: 411.67,197.42 411.45,197.64 SITE3.47
  TOP w0.277: 411.67,197.42 411.98,197.12 v1(413.2,197.12)
N27461526: length 2
  BOTTOM w0.277: UNK3K19.4 UNK3C39.1
N27461527: length 2
  BOTTOM w0.277: UNK3K19.2 UNK3C38.2
N27461530: length 2
  BOTTOM w0.277: UNK3K19.5 UNK3C41.1
N27461531: length 2
  BOTTOM w0.277: UNK3K19.7 UNK3C40.2
N27461562: length 1.4
  BOTTOM w0.152: UNK3R74.2 UNK3R47.2
N27461644: length 1.4
  BOTTOM w0.152: UNK3R75.2 UNK3R45.2
N27461660: length 2
  TOP w0.277: UNK3K34.4 509.22,191.16 UNK3C145.2
N27461661: length 2
  TOP w0.277: UNK3C146.2 509.22,187.96 UNK3K34.5
N27461668: length 2
  TOP w0.277: UNK3K35.4 509.22,198.42 UNK3C147.2
N27461669: length 2
  TOP w0.277: UNK3C148.2 509.22,195.22 UNK3K35.5
N27461672: length 2
  TOP w0.277: UNK3C149.2 509.22,182.52 UNK3K36.4
N27461673: length 2
  TOP w0.277: UNK3C150.2 509.22,179.33 UNK3K36.5
N27462802: length 2.3
  BOTTOM w0.277: UNK3R54.1 UNK3K28.4
N27462806:
  vias: v1(408.97,220.27) v1(408.98,218.11)
N27462841: length 2
  BOTTOM w0.277: UNK3K22.4 UNK3R49.1
N27462845:
  vias: v1(386.68,216.76) v1(386.68,214.73)
N27462972: length 2.8
  BOTTOM w0.277: UNK3R51.1 396.15,229.96 UNK3K25.4
N27462974:
  vias: v1(396.49,226.51) v1(398.79,226.51)
N27463080: length 3.4
  BOTTOM w1.016: UNK3R71.1 UNK3K30.3
N27463082: length 3.4
  BOTTOM w1.016: UNK3R72.1 UNK3K31.3
N27463084: length 3.4
  BOTTOM w1.016: UNK3R73.1 UNK3K32.3
N27466443: length 3.5
  TOP w0.152: UNK4U1.3 288.47,252.35
  TOP w0.277: 288.47,252.35 288.2,252.35 arc(287.71,252.56) 287.51,253.04 v1(287.51,253.08)
  BOTTOM w0.277: v1(287.51,253.08) 287.28,253.08 arc(287,253.13) 286.76,253.29 arc(286.62,253.5) UNK4C10.1 UNK4R5.2
N27466449: length 1.9
  TOP w0.152: 288.89,251.13 UNK4U1.5
  TOP w0.277: UNK4C7.2 289.55,250.47 arc(289.08,250.66) 288.89,251.13
N27466452: length 0.8
  TOP w0.152: 289.3,252.35 UNK4U1.1
  TOP w0.277: UNK4R4.1 289.3,252.35
N27466503: length 0.7
  TOP w0.277: UNK4R3.2 UNK4C6.2
N27466512: length 8.6
  TOP w0.152: UNK4U2.1 286.99,248.34
  TOP w0.277: v1(287.96,249.06) 287.96,249.03 arc(287.76,248.54) 287.27,248.34 286.99,248.34
  BOTTOM w0.277: UNK4R9.2 UNK4C19.1 arc(285.19,252.43) 286.31,250.75 v1(287.96,249.06)
N27466519: length 1.9
  TOP w0.152: 286.58,247.12 UNK4U2.5
  TOP w0.277: UNK4C14.2 285.92,246.46 arc(286.39,246.65) 286.58,247.12
N27466526: length 6.7
  TOP w0.277: UNK4R6.2 UNK4C12.1 UNK4R8.2
N27466528: length 0.7
  TOP w0.277: UNK4C13.2 UNK4R7.2
N27466547: length 3.1
  BOTTOM w0.508: UNK4K16.4 223.26,261.59 UNK4C24.1 UNK4BD27.2
N27466557: length 3.2
  BOTTOM w0.277: UNK4R22.1 UNK4K5.6
N27466559: length 3.2
  BOTTOM w0.277: UNK4R25.1 UNK4K5.4
N27466562: length 0.8
  TOP w0.152: 286.16,248.34 UNK4U2.3
  TOP w0.277: UNK4R8.1 286.16,248.34
N27466568: length 3.6
  TOP w0.277: UNK4R2.2 UNK4C5.1 290.47,253.16 arc(290.61,252.94) 290.67,252.68 UNK4R4.2
N27466596: length 5.1
  TOP w0.277: UNK4C2.1 292.42,253.43 arc(291.98,254.09) 291.45,254.69 291,255.15 UNK4C3.1 UNK4R1.2
N27466601: length 2.3
  TOP w0.277: UNK4C2.2 UNK4D1.1 UNK4SMP1.1
N27466719: length 3.2
  BOTTOM w0.277: UNK4R23.1 UNK4K7.6
N27466720: length 3.2
  BOTTOM w0.277: UNK4R26.1 UNK4K7.4
N27466725: length 2.3
  BOTTOM w0.508: UNK4BD27.1 UNK4R33.2 UNK4R29.1
N27466852: length 3.3
  TOP w0.249: SITE4.47 291.45,257.64 291.67,257.42
  TOP w0.277: v1(293.2,257.12) 291.98,257.12 291.67,257.42
N27470455: length 2
  BOTTOM w0.277: UNK4K19.4 UNK4C39.1
N27470456: length 2
  BOTTOM w0.277: UNK4K19.2 UNK4C38.2
N27470459: length 2
  BOTTOM w0.277: UNK4K19.5 UNK4C41.1
N27470460: length 2
  BOTTOM w0.277: UNK4K19.7 UNK4C40.2
N27470491: length 1.4
  BOTTOM w0.152: UNK4R74.2 UNK4R47.2
N27470573: length 1.4
  BOTTOM w0.152: UNK4R75.2 UNK4R45.2
N27470589: length 2
  TOP w0.277: UNK4K34.4 187.38,244.55 UNK4C145.2
N27470590: length 2
  TOP w0.277: UNK4C146.2 187.38,247.75 UNK4K34.5
N27470597: length 2
  TOP w0.277: UNK4K35.4 187.38,237.29 UNK4C147.2
N27470598: length 2
  TOP w0.277: UNK4K35.5 187.38,240.49 UNK4C148.2
N27470601: length 2
  TOP w0.277: UNK4C149.2 187.38,253.19 UNK4K36.4
N27470602: length 2
  TOP w0.277: UNK4K36.5 187.38,256.39 UNK4C150.2
N27471731: length 2.3
  BOTTOM w0.277: UNK4R54.1 UNK4K28.4
N27471735:
  vias: v1(288.97,280.27) v1(288.98,278.11)
N27471770: length 2
  BOTTOM w0.277: UNK4K22.4 UNK4R49.1
N27471774:
  vias: v1(266.68,276.76) v1(266.68,274.73)
N27471901: length 2.8
  BOTTOM w0.277: UNK4K25.4 276.15,289.96 UNK4R51.1
N27471903:
  vias: v1(276.49,286.51) v1(278.79,286.51)
N27472009: length 3.4
  BOTTOM w1.016: UNK4R71.1 UNK4K30.3
N27472011: length 3.4
  BOTTOM w1.016: UNK4R72.1 UNK4K31.3
N27472013: length 3.4
  BOTTOM w1.016: UNK4R73.1 UNK4K32.3
N27475373: length 3.5
  TOP w0.152: UNK5U1.3 328.47,252.35
  TOP w0.277: v1(327.51,253.08) 327.51,253.04 arc(327.71,252.56) 328.19,252.35 328.47,252.35
  BOTTOM w0.277: v1(327.51,253.08) 327.28,253.08 arc(327,253.13) 326.76,253.29 arc(326.62,253.5) UNK5C10.1 UNK5R5.2
N27475379: length 1.9
  TOP w0.152: 328.89,251.13 UNK5U1.5
  TOP w0.277: UNK5C7.2 329.55,250.47 arc(329.08,250.66) 328.89,251.13
N27475382: length 0.8
  TOP w0.152: 329.3,252.35 UNK5U1.1
  TOP w0.277: UNK5R4.1 329.3,252.35
N27475433: length 0.7
  TOP w0.277: UNK5R3.2 UNK5C6.2
N27475442: length 8.6
  TOP w0.152: UNK5U2.1 326.99,248.34
  TOP w0.277: 326.99,248.34 327.27,248.34 arc(327.76,248.54) 327.96,249.03 v1(327.96,249.06)
  BOTTOM w0.277: v1(327.96,249.06) 326.31,250.75 arc(325.19,252.43) UNK5C19.1 UNK5R9.2
N27475449: length 1.9
  TOP w0.152: 326.58,247.12 UNK5U2.5
  TOP w0.277: UNK5C14.2 325.92,246.46 arc(326.39,246.65) 326.58,247.12
N27475456: length 6.7
  TOP w0.277: UNK5R6.2 UNK5C12.1 UNK5R8.2
N27475458: length 0.7
  TOP w0.277: UNK5C13.2 UNK5R7.2
N27475477: length 3.1
  BOTTOM w0.508: UNK5K16.4 223.26,295.88 UNK5C24.1 UNK5BD27.2
N27475487: length 3.2
  BOTTOM w0.277: UNK5R22.1 UNK5K5.6
