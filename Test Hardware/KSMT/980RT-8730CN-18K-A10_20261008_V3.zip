# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Nets (continued)
S4_VD09_CORE2: SITE4.64(VD09_CORE2/VD09_MEM1) UNK4C49.1 UNK4R77.2
S4_VD09_CORE3: SITE4.87(VD09_CORE3/VA09_PLL) UNK4C54.1 UNK4R78.2
S4_VD09_CORE4: SITE4.98(VD09_CORE4) UNK4C58.1 UNK4R79.2
S4_VD13_FE: SITE4.36(VD13_FE) UNK4BD19.2 UNK4C85.1
S4_VD13_RF: SITE4.25(VD13_RF) UNK4BD17.2 UNK4C79.1
S4_VD33_ALL: UNK4BD3.1 UNK4BD5.1 UNK4BD7.1 UNK4BD9.1 UNK4BD11.1 UNK4BD12.1 UNK4BD13.1 UNK4BD15.1 UNK4BD18.1 UNK4BD21.1 UNK4BD22.1 UNK4BD23.1 UNK4BD28.1 UNK4BD29.1 UNK4BD30.1 UNK4BD31.1 UNK4BD32.1 UNK4BD36.1 UNK4C67.1 UNK4C96.1 UNK4C101.1 UNK4C122.1 UNK4C129.1 UNK4J5.1 UNK4J6.1 UNK4K23.2 UNK4K23.7
S4_VD33_CM_BT: SITE4.35(VD33_CM_BT) UNK4BD21.2 UNK4C90.1 UNK4C91.1
S4_VD33_EX_FLASH: UNK4BD32.2 UNK4C22.1 UNK4C127.1 UNK4C128.1 UNK4R12.2 UNK4R14.1 UNK4U3.8
S4_VD33_IO0: SITE4.9(VA33_PLL/VD33_IO0) UNK4BD7.2 UNK4C52.1
S4_VD33_IO2: SITE4.59(VD33_IO2/VD33_MEM) UNK4BD9.2 UNK4C56.1
S4_VD33_IO3: SITE4.70(VD33_IO3/VDD_IO4/VA33_USB) UNK4BD11.2 UNK4C59.1
S4_VD33_IO6: SITE4.88(VD33_IO6/VDD33_IO5/VD33_FLASH) UNK4BD12.2 UNK4C61.1
S4_VD33_SPS_AUD: SITE4.1(VD33_SPS_AUD) UNK4BD30.2 UNK4C123.1 UNK4C124.1
S4_VD33_SPS_DCORE: SITE4.2(VD33_SPS_DCORE) UNK4BD28.2 UNK4C111.1 UNK4C112.1
S4_VD33_SPS_MEM: SITE4.76(VD33_SPS_MEM) UNK4BD31.2 UNK4C125.1 UNK4C126.1
S4_VD33PA_A: SITE4.27(VD33PA_A) UNK4BD23.2 UNK4C99.1 UNK4C100.1
S4_VD33PA_BT: SITE4.38(VD33PA_BT) UNK4BD18.2 UNK4C83.1 UNK4C84.1
S4_VD33PA_G: SITE4.33(VD33PA_G) UNK4BD15.2 UNK4C76.1 UNK4C77.1
S4_VD33PAD_A: SITE4.26(VD33PAD_A) UNK4BD22.2 UNK4C97.1 UNK4C98.1
S4_VD33PAD_G: SITE4.34(VD33PAD_G) UNK4BD36.2 UNK4C73.1 UNK4C74.1
S4_VD1833_IO1: SITE4.14(VD1833_IO1) UNK4BD3.2 UNK4C46.1
S4_VD1833_SDIO: SITE4.93(VD1833_SDIO) UNK4BD29.2 UNK4C118.1 UNK4C119.1
S4_VD_MEM0: SITE4.61(VD_MEM0) UNK4C102.1 UNK4R81.2
S4_VD_MEM1: SITE4.62(VD_MEM1) UNK4C105.1 UNK4R82.2
S4_VD_MEM2: SITE4.65(VD_MEM2) UNK4C107.1 UNK4R83.2
S4_VDD09: S4_VDD09.1(TP) UNK4K22.2 UNK4K22.5 UNK4K31.4 UNK4R48.1
S4_VDD09_CH: UNK4K37.4 UNK4ST13.1
S4_VDD18_A: S4_VDD18_A.1(TP) UNK4K25.2 UNK4K25.5 UNK4K26.3 UNK4K32.4 UNK4R55.1
S4_VDD18_D: S4_VDD18_D.1(TP) UNK4K28.2 UNK4K28.5 UNK4K30.4 UNK4R29.2 UNK4R53.1
S4_VDD33: UNK4BD33.2 UNK4C130.1 UNK4R19.1 UNK4R24.1 UNK4R30.1 UNK4R38.2 UNK4R61.2 UNK4U1.6 UNK4U2.6
S4_VDD33_J1: UNK4J1.1 UNK4R19.2
S4_VDD33_J2: UNK4J2.1 UNK4R24.2
S4_VDD33_J3: UNK4J3.1 UNK4R30.2
S4_VREF_DRAM: SITE4.63(VREF_DRAM/NC(PSRAM)) UNK4C153.1 UNK4K16.3
S4_XI: SITE4.22(XI) UNK4C25.2 UNK4Y1.1
S4_XO: SITE4.21(XO) UNK4C23.2 UNK4Y1.3
S5_1_AOUT_LN: UNK5K10.4 UNK5R45.1 UNK5R67.1 UNK5R68.1
S5_1_AOUT_LP: UNK5K10.5 UNK5R69.1 UNK5R70.1 UNK5R75.1
S5_1_AOUT_RN: UNK5K14.4 UNK5R47.1 UNK5R63.1 UNK5R64.1
S5_1_AOUT_RP: UNK5K14.5 UNK5R65.1 UNK5R66.1 UNK5R74.1
S5_1_SPI_CLK: UNK5R15.1 UNK5U3.6
S5_1_SPI_CS: UNK5R10.2 UNK5U3.1
S5_1_SPI_DATA0: UNK5R17.1 UNK5U3.5
S5_1_SPI_DATA1: UNK5R11.2 UNK5U3.2
S5_1_SPI_DATA2: UNK5R14.2 UNK5R16.2 UNK5R18.2 UNK5U3.3
S5_1_SPI_DATA3: UNK5R12.1 UNK5R13.1 UNK5U3.7
S5_1_VDD09: UNK5BD1.1 UNK5BD2.1 UNK5BD37.1 UNK5C60.1 UNK5R48.2 UNK5R76.1 UNK5R77.1 UNK5R78.1 UNK5R79.1 UNK5ST13.2
S5_1_VDD18_A: S5_1V3.1(TP) UNK5K26.2 UNK5K26.5 UNK5R50.1
S5_1_VDD18_D: UNK5C113.2 UNK5R53.2 UNK5R81.1 UNK5R82.1 UNK5R83.1 UNK5ST15.1
S5_2_AOUT_LN: UNK5K12.4 UNK5R68.2
S5_2_AOUT_LP: UNK5K12.5 UNK5R69.2
S5_2_AOUT_RN: UNK5K15.4 UNK5R64.2
S5_2_AOUT_RP: UNK5K15.5 UNK5R65.2
S5_2_VDD18_A: UNK5BD16.1 UNK5BD17.1 UNK5BD19.1 UNK5BD20.1 UNK5C89.1 UNK5R50.2
S5_ATX_VD0V9: ATX_VD0V9.12 UNK5C65.1 UNK5C66.1 UNK5K21.6 UNK5ST3.2
S5_ATX_VD1V8: ATX_VD1V8.12 UNK5J7.1 UNK5J8.1 UNK5J9.1
S5_ATX_VD33: ATX_VD33.12 UNK5BD33.1 UNK5C131.1 UNK5C132.1 UNK5C133.1 UNK5C134.1 UNK5C135.1 UNK5J6.2
S5_AVCC_DRV: SITE5.53(AVCC_DRV) UNK5C75.1 UNK5C110.1 UNK5R55.2 UNK5ST14.1
S5_CHIP_EN_1: UNK5R34.2 UNK5SW5.1
S5_DPS_F001: UNK5C120.1 UNK5C121.1 UNK5J9.2 UNK5K29.6 UNK5ST11.2
S5_DPS_F002: UNK5C92.1 UNK5C93.1 UNK5C94.1 UNK5C95.1 UNK5J8.2 UNK5K26.6 UNK5ST8.2
S5_DPS_F004: UNK5C140.1 UNK5C141.1 UNK5J7.2 UNK5K20.6 UNK5ST12.2
S5_DPS_F006: S5_VD33_ALL1.1(TP) UNK5C68.1 UNK5C69.1 UNK5C70.1 UNK5C71.1 UNK5C72.1 UNK5K23.3 UNK5K23.6 UNK5ST4.2
S5_DPS_GS001: UNK5ST19.1
S5_DPS_GS002: UNK5ST18.1
S5_DPS_GS003-1: UNK5ST16.1
S5_DPS_GS004: UNK5ST17.1
S5_DPS_GS006: UNK5ST5.1
S5_DPS_S001: UNK5ST11.1
S5_DPS_S002: UNK5ST8.1
S5_DPS_S003-1: UNK5ST3.1
S5_DPS_S004: UNK5ST12.1
S5_DPS_S006: UNK5ST4.1
S5_HSDM: SITE5.79(HSDM) UNK5K5.8
S5_HSDP: SITE5.78(HSDP) UNK5K5.2
S5_LPC_001: UNK5K36.7
S5_LPC_002: UNK5K36.2
S5_LPC_003: UNK5K11.2
S5_LPC_005: UNK5K14.2
S5_LPC_006: UNK5K18.4
S5_LPC_007: UNK5K1.4
S5_LPC_008: UNK5K35.2
S5_LPC_009: UNK4K38.6
S5_LPC_010: UNK5K34.7
S5_LPC_012: UNK4K37.6
S5_LPC_013+: UNK5K5.3 UNK5K7.2
S5_LPC_013-: UNK5K5.7 UNK5K7.8
S5_LPC_016: UNK5K2.5
S5_LPC_017: UNK5K35.7
S5_LPC_019: UNK5K12.2
S5_LPC_021: UNK5K1.5
S5_LPC_022: UNK5K15.2
S5_LPC_023: UNK5K3.4
S5_LPC_024: SITE5.69(UART2_TXD/TEST_MODE_SEL/DMIC0_C) UNK5J4.2 UNK5R35.1
S5_LPC_025: SITE5.71(CHIP_EN) UNK5J4.1 UNK5R34.1
S5_LPC_026: UNK5K2.4
S5_LPC_027: UNK5K10.2
S5_LPC_028: UNK5K10.7
S5_LPC_029: UNK5K13.7
S5_LPC_030: UNK5K16.2
S5_LPC_032: UNK5K15.7
S5_LPC_033: UNK5K14.7
S5_LPC_034: UNK5K18.5
S5_LPC_035: UNK5K12.7
S5_LPC_036: UNK5K34.2
S5_LPC_038: UNK5K13.2
S5_LPC_039: UNK5K3.5
S5_LPC_040: UNK5K11.7
S5_LPC_041: SITE5.68(UART2_RXD/BOOT_SEL/DMIC0_DATA/G) UNK5J4.3 UNK5R36.1
S5_LPC_042: SITE5.50(MIC_BIAS2/GPIOC_13/PA[31]) UNK5C18.2
S5_LPC_043: UNK4K33.6
S5_LPC_044: SITE5.58(I2S3_DOUT1/DMIC_DATA2/ICFG1/GPI) UNK5J4.5 UNK5R39.1
S5_LPC_045: UNK5K39.3
S5_LPC_046: SITE5.67(I2S2_DIN3/I2S3_DOUT3/SPK_CLK/SP)
S5_LPC_047: SITE5.18(GPIOB_7/PA[16]/ICFG3/SPI0_CS/UA) UNK5J4.7 UNK5R41.1
S5_LPC_048: UNK5K6.4
S5_LPC_049: SITE5.8(GPIOA_5/PA[5]/TOUCH5/ADC5/UART1)
S5_LPC_050: SITE5.7(GPIOA_4/PA[4]/TOUCH4/ADC4/UART1)
S5_LPC_051: SITE5.49(MIC_BIAS1/GPIOC_12/PA[30]) UNK5C17.2
S5_LPC_052: SITE5.48(AVCC) UNK5C21.1
S5_LPC_053: SITE5.57(I2S3_DOUT0/DMIC_DATA1/ICFG0/BT_) UNK5J4.4 UNK5R37.1
S5_LPC_054: UNK5K6.5
S5_LPC_055: SITE5.10(VBAT_MEAS)
S5_LPC_057: UNK5K9.4
S5_LPC_058: SITE5.17(GPIOB_6/PA[15]/ICFG2/SPI0_CLK/U) UNK5J4.6 UNK5R40.1
S5_LPC_059: UNK5K39.6
S5_LPC_060: SITE5.66(I2S2_DIN2/I2S3_DOUT2/SPK_DATA/S)
S5_LPC_A_015: UNK5K8.4
S5_LPC_A_020: UNK5K8.5
S5_LPC_B_031: UNK5K4.4
S5_LPC_B_037: UNK5K4.5
S5_LX_AUD: SITE5.100(LX_AUD) UNK5K20.3
S5_LX_AUD_CH_1: UNK4K38.7 UNK5K20.4
S5_LX_AUD_CH_2: UNK4K38.5 UNK5ST14.2
S5_LX_DCORE: SITE5.3(LX_DCORE) UNK5K21.3
S5_LX_DCORE_CH: UNK4K37.7 UNK5K21.4
S5_LX_MEM: SITE5.75(LX_MEM) UNK5K29.3
S5_LX_MEM_CH_1: UNK4K33.7 UNK5K29.4
S5_LX_MEM_CH_2: UNK4K33.5 UNK5ST15.2
S5_MIPITX_CKN: SITE5.82(MIPITX_CKN) UNK5K36.6
S5_MIPITX_CKP: SITE5.83(MIPITX_CKP) UNK5K36.3
S5_MIPITX_DATAN_0: SITE5.85(MIPITX_DATAN_0) UNK5K34.6
S5_MIPITX_DATAN_1: SITE5.80(MIPITX_DATAN_1) UNK5K35.6
S5_MIPITX_DATAP_0: SITE5.86(MIPITX_DATAP_0) UNK5K34.3
S5_MIPITX_DATAP_1: SITE5.81(MIPITX_DATAP_1) UNK5K35.3
S5_PA2: SITE5.5(GPIOA_2/PA[2]/TOUCH2/ADC2/UART0) UNK5K18.3
S5_PA3: SITE5.6(GPIOA_3/PA[3]/TOUCH3/ADC3/UART0) UNK5K18.6
S5_PA9_CH: SITE5.12(GPIOB_0/PA[9]) UNK5K39.2
S5_PA10_CH: SITE5.13(GPIOB_1/PA[10]) UNK5K39.7
S5_PA13: SITE5.15(GPIOB_4/PA[13]/SWD_DATA/SPI0_MO) UNK5K6.3
S5_PA13_UART_RX: UNK5K6.2 UNK5R27.1
S5_PA13_UART_RX_1: UNK5J2.3 UNK5R27.2
S5_PA14: SITE5.16(GPIOB_5/PA[14]/SWD_CLK/SPI0_MIS) UNK5K6.6
S5_PA14_UART_TX: UNK5K6.7 UNK5R28.1
S5_PA14_UART_TX_1: UNK5J2.4 UNK5R28.2
S5_PA15_1: UNK5R40.2 UNK5SW5.6
S5_PA16_1: UNK5R41.2 UNK5SW5.7
S5_PA20: SITE5.45(MIC1_P/GPIOC_2/PA[20]) UNK5K15.6
S5_PA21: SITE5.46(MIC1_N/GPIOC_3/PA[21]) UNK5K15.3
S5_PA22: SITE5.43(MIC2_P/GPIOC_4/PA[22]) UNK5K11.6
S5_PA23: SITE5.44(MIC2_N/GPIOC_5/PA[23]) UNK5K11.3
S5_PA24: SITE5.41(MIC3_P/I2C_SDA/GPIOC_6/PA[24]) UNK5K12.6
S5_PA25: SITE5.42(MIC3_N/I2C_SCL/GPIOC_7/PA[25]) UNK5K12.3
S5_PA28: SITE5.39(MIC5_P/ANT_SEL_P/GPIOC_10/PA[28) UNK5K13.6
S5_PA29: SITE5.40(MIC5_N/ANT_SEL_N/GPIOC_11/PA[29) UNK5K13.3
S5_PB3: SITE5.52(AOUT_LP/GPIOC_17/PB[3]) UNK5K10.6
S5_PB3_AOUT_LP_2: UNK5K13.5 UNK5R70.2
S5_PB4: SITE5.51(AOUT_LN/GPIOC_18/PB[4]) UNK5K10.3
S5_PB4_AOUT_LN_2: UNK5K13.4 UNK5R67.2
S5_PB5: SITE5.54(AOUT_RP/GPIOC_19/PB[5]) UNK5K14.6
S5_PB5_AOUT_RP_2: UNK5K11.5 UNK5R66.2
S5_PB6: SITE5.55(AOUT_RN/GPIOC_20/PB[6]) UNK5K14.3
S5_PB6_AOUT_RN_2: UNK5K11.4 UNK5R63.2
S5_PB10_1: UNK5R37.2 UNK5SW5.4
S5_PB11_1: UNK5R39.2 UNK5SW5.5
S5_PB21_1: UNK5R36.2 UNK5SW5.3
S5_PB22_1: UNK5R35.2 UNK5SW5.2
S5_PB23: SITE5.72(UART_LOG_RXD/OTP_BYPASS/GPIOF_2) UNK5C144.2 UNK5K4.3 UNK5R57.1
S5_PB23_1: UNK5R57.2 UNK5SW6.1
S5_PB23_SICK: UNK5K4.2 UNK5R20.1
S5_PB23_SICK_1: UNK5J1.3 UNK5R20.2
S5_PB24: SITE5.73(UART_LOG_TXD/UART_DOWNLOAD/GPIO) UNK5C143.2 UNK5K4.6 UNK5R58.1
S5_PB24_1: UNK5R58.2 UNK5SW6.2
S5_PB24_SIDD: UNK5K4.7 UNK5R21.1
S5_PB24_SIDD_1: UNK5J1.4 UNK5R21.2
S5_PB25: SITE5.96(SPI0_CLK/SWD_CLK/SD_D2/ICFG2/GP) UNK5K8.3 UNK5R59.1
S5_PB25_1: UNK5R59.2 UNK5SW6.3
S5_PB25_I2C_SCL: UNK5K8.2 UNK5R31.1
S5_PB25_I2C_SCL_1: UNK5J3.3 UNK5R31.2
S5_PB26: SITE5.97(SPI0_CS/SWD_DATA/SD_D3/ICFG3/GP) UNK5K8.6 UNK5R60.1
S5_PB26_1: UNK5R60.2 UNK5SW6.4
S5_PB26_I2C_SDA: UNK5K8.7 UNK5R32.1
S5_PB26_I2C_SDA_1: UNK5J3.4 UNK5R32.2
S5_RF_A: UNK5C13.1 UNK5C14.1 UNK5C15.1 UNK5D3.1 UNK5SMP3.1
S5_RF_G: UNK5C6.1 UNK5C7.1 UNK5C8.1 UNK5D2.1 UNK5SMP2.1
S5_RFIN_A: SITE5.29(RFIN_A/GND (<750UM)) UNK5C16.2 UNK5R9.1
S5_RFIN_G: SITE5.31(RFIN_G/GND) UNK5C9.2 UNK5R5.1
S5_RFIO_A: SITE5.28(RFIO_A  (<750UM)) UNK5C11.2 UNK5R6.1
S5_RFIO_BT: SITE5.37(RFIO_BT) UNK5C1.2 UNK5R1.1
S5_RFIO_G: SITE5.32(RFIO_G) UNK5C4.2 UNK5R2.1
S5_RREF_MEM: SITE5.60(RREF_MEM) UNK5K9.3 UNK5R43.1
S5_SPI_CLK: UNK5K1.7 UNK5R15.2
S5_SPI_CLK/PB28: SITE5.90(SPI_FLASH_CLK/SD_CLK/GPIOG_3/PB) UNK5K1.6
S5_SPI_CS: UNK5K3.2 UNK5R10.1
S5_SPI_CS/PC0: SITE5.95(SPI_FLASH_CS/UART1_CTS/SD_CD/GP) UNK5K3.3
S5_SPI_D0/PB29: SITE5.91(SPI_FLASH_DATA0/UART1_RXD/SD_D0) UNK5K1.3
S5_SPI_D1/PB31: SITE5.94(SPI_FLASH_DATA1/UART1_RTS/SD_WP) UNK5K3.6
S5_SPI_D2/PB30: SITE5.92(SPI_FLASH_DATA2/UART1_TXD/SD_D1) UNK5K2.6
S5_SPI_D3/PB27: SITE5.89(SPI_FLASH_DATA3/SD_CMD/GPIOG_2/) UNK5K2.3
S5_SPI_DATA0: UNK5K1.2 UNK5R17.2
S5_SPI_DATA1: UNK5K3.7 UNK5R11.1
S5_SPI_DATA2: UNK5K2.7 UNK5R16.1
S5_SPI_DATA3: UNK5K2.2 UNK5R13.2
S5_U1_VC1: UNK5K39.5 UNK5U1.4
S5_U2_VC1: UNK5K39.4 UNK5U2.4
S5_VA09_MIPI: SITE5.84(VA09_MIPI/VA09_CK/VA09_DA) UNK5BD37.2 UNK5C152.1
S5_VA09_PLL: SITE5.11(VA09_PLL/VD09_CORE0) UNK5BD1.2 UNK5C44.1
S5_VA09_USB: SITE5.77(VA09_USB) UNK5BD2.2 UNK5C45.1
S5_VA13_AFE: SITE5.19(VA13_AFE) UNK5BD20.2 UNK5C88.1
S5_VA13_SYN: SITE5.23(VR13_SYN) UNK5BD16.2 UNK5C78.1
S5_VA33_SYN: SITE5.24(VR33_SYN) UNK5BD13.2 UNK5C64.1
S5_VA33_XTAL: SITE5.20(VA33_XTAL) UNK5BD5.2 UNK5C48.1
S5_VD09_CORE1: SITE5.56(VD09_CORE1/VD09MEM0) UNK5C47.1 UNK5R76.2
S5_VD09_CORE2: SITE5.64(VD09_CORE2/VD09_MEM1) UNK5C49.1 UNK5R77.2
S5_VD09_CORE3: SITE5.87(VD09_CORE3/VA09_PLL) UNK5C54.1 UNK5R78.2
S5_VD09_CORE4: SITE5.98(VD09_CORE4) UNK5C58.1 UNK5R79.2
S5_VD13_FE: SITE5.36(VD13_FE) UNK5BD19.2 UNK5C85.1
S5_VD13_RF: SITE5.25(VD13_RF) UNK5BD17.2 UNK5C79.1
S5_VD33_ALL: UNK5BD3.1 UNK5BD5.1 UNK5BD7.1 UNK5BD9.1 UNK5BD11.1 UNK5BD12.1 UNK5BD13.1 UNK5BD15.1 UNK5BD18.1 UNK5BD21.1 UNK5BD22.1 UNK5BD23.1 UNK5BD28.1 UNK5BD29.1 UNK5BD30.1 UNK5BD31.1 UNK5BD32.1 UNK5BD36.1 UNK5C67.1 UNK5C96.1 UNK5C101.1 UNK5C122.1 UNK5C129.1 UNK5J5.1 UNK5J6.1 UNK5K23.2 UNK5K23.7
S5_VD33_CM_BT: SITE5.35(VD33_CM_BT) UNK5BD21.2 UNK5C90.1 UNK5C91.1
S5_VD33_EX_FLASH: UNK5BD32.2 UNK5C22.1 UNK5C127.1 UNK5C128.1 UNK5R12.2 UNK5R14.1 UNK5U3.8
S5_VD33_IO0: SITE5.9(VA33_PLL/VD33_IO0) UNK5BD7.2 UNK5C52.1
S5_VD33_IO2: SITE5.59(VD33_IO2/VD33_MEM) UNK5BD9.2 UNK5C56.1
S5_VD33_IO3: SITE5.70(VD33_IO3/VDD_IO4/VA33_USB) UNK5BD11.2 UNK5C59.1
S5_VD33_IO6: SITE5.88(VD33_IO6/VDD33_IO5/VD33_FLASH) UNK5BD12.2 UNK5C61.1
S5_VD33_SPS_AUD: SITE5.1(VD33_SPS_AUD) UNK5BD30.2 UNK5C123.1 UNK5C124.1
S5_VD33_SPS_DCORE: SITE5.2(VD33_SPS_DCORE) UNK5BD28.2 UNK5C111.1 UNK5C112.1
S5_VD33_SPS_MEM: SITE5.76(VD33_SPS_MEM) UNK5BD31.2 UNK5C125.1 UNK5C126.1
S5_VD33PA_A: SITE5.27(VD33PA_A) UNK5BD23.2 UNK5C99.1 UNK5C100.1
S5_VD33PA_BT: SITE5.38(VD33PA_BT) UNK5BD18.2 UNK5C83.1 UNK5C84.1
S5_VD33PA_G: SITE5.33(VD33PA_G) UNK5BD15.2 UNK5C76.1 UNK5C77.1
S5_VD33PAD_A: SITE5.26(VD33PAD_A) UNK5BD22.2 UNK5C97.1 UNK5C98.1
S5_VD33PAD_G: SITE5.34(VD33PAD_G) UNK5BD36.2 UNK5C73.1 UNK5C74.1
S5_VD1833_IO1: SITE5.14(VD1833_IO1) UNK5BD3.2 UNK5C46.1
S5_VD1833_SDIO: SITE5.93(VD1833_SDIO) UNK5BD29.2 UNK5C118.1 UNK5C119.1
S5_VD_MEM0: SITE5.61(VD_MEM0) UNK5C102.1 UNK5R81.2
S5_VD_MEM1: SITE5.62(VD_MEM1) UNK5C105.1 UNK5R82.2
S5_VD_MEM2: SITE5.65(VD_MEM2) UNK5C107.1 UNK5R83.2
S5_VDD09: S5_VDD09.1(TP) UNK5K22.2 UNK5K22.5 UNK5K31.4 UNK5R48.1
S5_VDD09_CH: UNK4K37.5 UNK5ST13.1
S5_VDD18_A: S5_VDD18_A.1(TP) UNK5K25.2 UNK5K25.5 UNK5K26.3 UNK5K32.4 UNK5R55.1
S5_VDD18_D: S5_VDD18_D.1(TP) UNK5K28.2 UNK5K28.5 UNK5K30.4 UNK5R29.2 UNK5R53.1
S5_VDD33: UNK5BD33.2 UNK5C130.1 UNK5R19.1 UNK5R24.1 UNK5R30.1 UNK5R38.2 UNK5R61.2 UNK5U1.6 UNK5U2.6
S5_VDD33_J1: UNK5J1.1 UNK5R19.2
S5_VDD33_J2: UNK5J2.1 UNK5R24.2
S5_VDD33_J3: UNK5J3.1 UNK5R30.2
S5_VREF_DRAM: SITE5.63(VREF_DRAM/NC(PSRAM)) UNK5C153.1 UNK5K16.3
S5_XI: SITE5.22(XI) UNK5C25.2 UNK5Y1.1
S5_XO: SITE5.21(XO) UNK5C23.2 UNK5Y1.3
S6_1_AOUT_LN: UNK6K10.4 UNK6R45.1 UNK6R67.1 UNK6R68.1
S6_1_AOUT_LP: UNK6K10.5 UNK6R69.1 UNK6R70.1 UNK6R75.1
S6_1_AOUT_RN: UNK6K14.4 UNK6R47.1 UNK6R63.1 UNK6R64.1
S6_1_AOUT_RP: UNK6K14.5 UNK6R65.1 UNK6R66.1 UNK6R74.1
S6_1_SPI_CLK: UNK6R15.1 UNK6U3.6
S6_1_SPI_CS: UNK6R10.2 UNK6U3.1
S6_1_SPI_DATA0: UNK6R17.1 UNK6U3.5
S6_1_SPI_DATA1: UNK6R11.2 UNK6U3.2
S6_1_SPI_DATA2: UNK6R14.2 UNK6R16.2 UNK6R18.2 UNK6U3.3
S6_1_SPI_DATA3: UNK6R12.1 UNK6R13.1 UNK6U3.7
S6_1_VDD09: UNK6BD1.1 UNK6BD2.1 UNK6BD37.1 UNK6C60.1 UNK6R48.2 UNK6R76.1 UNK6R77.1 UNK6R78.1 UNK6R79.1 UNK6ST13.2
S6_1_VDD18_A: S6_1V3.1(TP) UNK6K26.2 UNK6K26.5 UNK6R50.1
S6_1_VDD18_D: UNK6C113.2 UNK6R53.2 UNK6R81.1 UNK6R82.1 UNK6R83.1 UNK6ST15.1
S6_2_AOUT_LN: UNK6K12.4 UNK6R68.2
S6_2_AOUT_LP: UNK6K12.5 UNK6R69.2
S6_2_AOUT_RN: UNK6K15.4 UNK6R64.2
S6_2_AOUT_RP: UNK6K15.5 UNK6R65.2
S6_2_VDD18_A: UNK6BD16.1 UNK6BD17.1 UNK6BD19.1 UNK6BD20.1 UNK6C89.1 UNK6R50.2
S6_ATX_VD0V9: ATX_VD0V9.14 UNK6C65.1 UNK6C66.1 UNK6K21.6 UNK6ST3.2
S6_ATX_VD1V8: ATX_VD1V8.14 UNK6J7.1 UNK6J8.1 UNK6J9.1
S6_ATX_VD33: ATX_VD33.14 UNK6BD33.1 UNK6C131.1 UNK6C132.1 UNK6C133.1 UNK6C134.1 UNK6C135.1 UNK6J6.2
S6_AVCC_DRV: SITE6.53(AVCC_DRV) UNK6C75.1 UNK6C110.1 UNK6R55.2 UNK6ST14.1
S6_CHIP_EN_1: UNK6R34.2 UNK6SW5.1
S6_DPS_F001: UNK6C120.1 UNK6C121.1 UNK6J9.2 UNK6K29.6 UNK6ST11.2
S6_DPS_F002: UNK6C92.1 UNK6C93.1 UNK6C94.1 UNK6C95.1 UNK6J8.2 UNK6K26.6 UNK6ST8.2
S6_DPS_F004: UNK6C140.1 UNK6C141.1 UNK6J7.2 UNK6K20.6 UNK6ST12.2
S6_DPS_F006: S6_VD33_ALL1.1(TP) UNK6C68.1 UNK6C69.1 UNK6C70.1 UNK6C71.1 UNK6C72.1 UNK6K23.3 UNK6K23.6 UNK6ST4.2
S6_DPS_GS001: UNK6ST19.1
S6_DPS_GS002: UNK6ST18.1
S6_DPS_GS003-1: UNK6ST16.1
S6_DPS_GS004: UNK6ST17.1
S6_DPS_GS006: UNK6ST5.1
S6_DPS_S001: UNK6ST11.1
S6_DPS_S002: UNK6ST8.1
S6_DPS_S003-1: UNK6ST3.1
S6_DPS_S004: UNK6ST12.1
S6_DPS_S006: UNK6ST4.1
S6_HSDM: SITE6.79(HSDM) UNK6K5.8
S6_HSDP: SITE6.78(HSDP) UNK6K5.2
S6_LPC_001: UNK6K36.7
S6_LPC_002: UNK6K36.2
S6_LPC_003: UNK6K11.2
S6_LPC_005: UNK6K14.2
S6_LPC_006: UNK6K18.4
S6_LPC_007: UNK6K1.4
S6_LPC_008: UNK6K35.2
S6_LPC_009: UNK6K38.3
S6_LPC_010: UNK6K34.7
S6_LPC_012: UNK6K37.3
S6_LPC_013+: UNK6K5.3 UNK6K7.2
S6_LPC_013-: UNK6K5.7 UNK6K7.8
S6_LPC_016: UNK6K2.5
S6_LPC_017: UNK6K35.7
S6_LPC_019: UNK6K12.2
S6_LPC_021: UNK6K1.5
S6_LPC_022: UNK6K15.2
S6_LPC_023: UNK6K3.4
S6_LPC_024: SITE6.69(UART2_TXD/TEST_MODE_SEL/DMIC0_C) UNK6J4.2 UNK6R35.1
S6_LPC_025: SITE6.71(CHIP_EN) UNK6J4.1 UNK6R34.1
S6_LPC_026: UNK6K2.4
S6_LPC_027: UNK6K10.2
S6_LPC_028: UNK6K10.7
S6_LPC_029: UNK6K13.7
S6_LPC_030: UNK6K16.2
S6_LPC_032: UNK6K15.7
S6_LPC_033: UNK6K14.7
S6_LPC_034: UNK6K18.5
S6_LPC_035: UNK6K12.7
S6_LPC_036: UNK6K34.2
S6_LPC_038: UNK6K13.2
S6_LPC_039: UNK6K3.5
S6_LPC_040: UNK6K11.7
S6_LPC_041: SITE6.68(UART2_RXD/BOOT_SEL/DMIC0_DATA/G) UNK6J4.3 UNK6R36.1
S6_LPC_042: SITE6.50(MIC_BIAS2/GPIOC_13/PA[31]) UNK6C18.2
S6_LPC_043: UNK6K33.3
S6_LPC_044: SITE6.58(I2S3_DOUT1/DMIC_DATA2/ICFG1/GPI) UNK6J4.5 UNK6R39.1
S6_LPC_045: UNK6K39.3
S6_LPC_046: SITE6.67(I2S2_DIN3/I2S3_DOUT3/SPK_CLK/SP)
S6_LPC_047: SITE6.18(GPIOB_7/PA[16]/ICFG3/SPI0_CS/UA) UNK6J4.7 UNK6R41.1
S6_LPC_048: UNK6K6.4
S6_LPC_049: SITE6.8(GPIOA_5/PA[5]/TOUCH5/ADC5/UART1)
S6_LPC_050: SITE6.7(GPIOA_4/PA[4]/TOUCH4/ADC4/UART1)
S6_LPC_051: SITE6.49(MIC_BIAS1/GPIOC_12/PA[30]) UNK6C17.2
S6_LPC_052: SITE6.48(AVCC) UNK6C21.1
S6_LPC_053: SITE6.57(I2S3_DOUT0/DMIC_DATA1/ICFG0/BT_) UNK6J4.4 UNK6R37.1
S6_LPC_054: UNK6K6.5
S6_LPC_055: SITE6.10(VBAT_MEAS)
S6_LPC_057: UNK6K9.4
S6_LPC_058: SITE6.17(GPIOB_6/PA[15]/ICFG2/SPI0_CLK/U) UNK6J4.6 UNK6R40.1
S6_LPC_059: UNK6K39.6
S6_LPC_060: SITE6.66(I2S2_DIN2/I2S3_DOUT2/SPK_DATA/S)
S6_LPC_A_015: UNK6K8.4
S6_LPC_A_020: UNK6K8.5
S6_LPC_B_031: UNK6K4.4
S6_LPC_B_037: UNK6K4.5
S6_LX_AUD: SITE6.100(LX_AUD) UNK6K20.3
S6_LX_AUD_CH_1: UNK6K20.4 UNK6K38.2
S6_LX_AUD_CH_2: UNK6K38.4 UNK6ST14.2
S6_LX_DCORE: SITE6.3(LX_DCORE) UNK6K21.3
S6_LX_DCORE_CH: UNK6K21.4 UNK6K37.2
S6_LX_MEM: SITE6.75(LX_MEM) UNK6K29.3
S6_LX_MEM_CH_1: UNK6K29.4 UNK6K33.2
S6_LX_MEM_CH_2: UNK6K33.4 UNK6ST15.2
S6_MIPITX_CKN: SITE6.82(MIPITX_CKN) UNK6K36.6
S6_MIPITX_CKP: SITE6.83(MIPITX_CKP) UNK6K36.3
S6_MIPITX_DATAN_0: SITE6.85(MIPITX_DATAN_0) UNK6K34.6
S6_MIPITX_DATAN_1: SITE6.80(MIPITX_DATAN_1) UNK6K35.6
S6_MIPITX_DATAP_0: SITE6.86(MIPITX_DATAP_0) UNK6K34.3
S6_MIPITX_DATAP_1: SITE6.81(MIPITX_DATAP_1) UNK6K35.3
S6_PA2: SITE6.5(GPIOA_2/PA[2]/TOUCH2/ADC2/UART0) UNK6K18.3
S6_PA3: SITE6.6(GPIOA_3/PA[3]/TOUCH3/ADC3/UART0) UNK6K18.6
S6_PA9_CH: SITE6.12(GPIOB_0/PA[9]) UNK6K39.2
S6_PA10_CH: SITE6.13(GPIOB_1/PA[10]) UNK6K39.7
S6_PA13: SITE6.15(GPIOB_4/PA[13]/SWD_DATA/SPI0_MO) UNK6K6.3
S6_PA13_UART_RX: UNK6K6.2 UNK6R27.1
S6_PA13_UART_RX_1: UNK6J2.3 UNK6R27.2
S6_PA14: SITE6.16(GPIOB_5/PA[14]/SWD_CLK/SPI0_MIS) UNK6K6.6
S6_PA14_UART_TX: UNK6K6.7 UNK6R28.1
S6_PA14_UART_TX_1: UNK6J2.4 UNK6R28.2
S6_PA15_1: UNK6R40.2 UNK6SW5.6
S6_PA16_1: UNK6R41.2 UNK6SW5.7
S6_PA20: SITE6.45(MIC1_P/GPIOC_2/PA[20]) UNK6K15.6
S6_PA21: SITE6.46(MIC1_N/GPIOC_3/PA[21]) UNK6K15.3
S6_PA22: SITE6.43(MIC2_P/GPIOC_4/PA[22]) UNK6K11.6
S6_PA23: SITE6.44(MIC2_N/GPIOC_5/PA[23]) UNK6K11.3
S6_PA24: SITE6.41(MIC3_P/I2C_SDA/GPIOC_6/PA[24]) UNK6K12.6
S6_PA25: SITE6.42(MIC3_N/I2C_SCL/GPIOC_7/PA[25]) UNK6K12.3
S6_PA28: SITE6.39(MIC5_P/ANT_SEL_P/GPIOC_10/PA[28) UNK6K13.6
S6_PA29: SITE6.40(MIC5_N/ANT_SEL_N/GPIOC_11/PA[29) UNK6K13.3
S6_PB3: SITE6.52(AOUT_LP/GPIOC_17/PB[3]) UNK6K10.6
S6_PB3_AOUT_LP_2: UNK6K13.5 UNK6R70.2
S6_PB4: SITE6.51(AOUT_LN/GPIOC_18/PB[4]) UNK6K10.3
S6_PB4_AOUT_LN_2: UNK6K13.4 UNK6R67.2
S6_PB5: SITE6.54(AOUT_RP/GPIOC_19/PB[5]) UNK6K14.6
S6_PB5_AOUT_RP_2: UNK6K11.5 UNK6R66.2
S6_PB6: SITE6.55(AOUT_RN/GPIOC_20/PB[6]) UNK6K14.3
S6_PB6_AOUT_RN_2: UNK6K11.4 UNK6R63.2
S6_PB10_1: UNK6R37.2 UNK6SW5.4
S6_PB11_1: UNK6R39.2 UNK6SW5.5
S6_PB21_1: UNK6R36.2 UNK6SW5.3
S6_PB22_1: UNK6R35.2 UNK6SW5.2
S6_PB23: SITE6.72(UART_LOG_RXD/OTP_BYPASS/GPIOF_2) UNK6C144.2 UNK6K4.3 UNK6R57.1
S6_PB23_1: UNK6R57.2 UNK6SW6.1
S6_PB23_SICK: UNK6K4.2 UNK6R20.1
S6_PB23_SICK_1: UNK6J1.3 UNK6R20.2
S6_PB24: SITE6.73(UART_LOG_TXD/UART_DOWNLOAD/GPIO) UNK6C143.2 UNK6K4.6 UNK6R58.1
S6_PB24_1: UNK6R58.2 UNK6SW6.2
S6_PB24_SIDD: UNK6K4.7 UNK6R21.1
S6_PB24_SIDD_1: UNK6J1.4 UNK6R21.2
S6_PB25: SITE6.96(SPI0_CLK/SWD_CLK/SD_D2/ICFG2/GP) UNK6K8.3 UNK6R59.1
S6_PB25_1: UNK6R59.2 UNK6SW6.3
S6_PB25_I2C_SCL: UNK6K8.2 UNK6R31.1
S6_PB25_I2C_SCL_1: UNK6J3.3 UNK6R31.2
S6_PB26: SITE6.97(SPI0_CS/SWD_DATA/SD_D3/ICFG3/GP) UNK6K8.6 UNK6R60.1
S6_PB26_1: UNK6R60.2 UNK6SW6.4
S6_PB26_I2C_SDA: UNK6K8.7 UNK6R32.1
S6_PB26_I2C_SDA_1: UNK6J3.4 UNK6R32.2
S6_RF_A: UNK6C13.1 UNK6C14.1 UNK6C15.1 UNK6D3.1 UNK6SMP3.1
S6_RF_G: UNK6C6.1 UNK6C7.1 UNK6C8.1 UNK6D2.1 UNK6SMP2.1
S6_RFIN_A: SITE6.29(RFIN_A/GND (<750UM)) UNK6C16.2 UNK6R9.1
S6_RFIN_G: SITE6.31(RFIN_G/GND) UNK6C9.2 UNK6R5.1
S6_RFIO_A: SITE6.28(RFIO_A  (<750UM)) UNK6C11.2 UNK6R6.1
S6_RFIO_BT: SITE6.37(RFIO_BT) UNK6C1.2 UNK6R1.1
S6_RFIO_G: SITE6.32(RFIO_G) UNK6C4.2 UNK6R2.1
S6_RREF_MEM: SITE6.60(RREF_MEM) UNK6K9.3 UNK6R43.1
S6_SPI_CLK: UNK6K1.7 UNK6R15.2
S6_SPI_CLK/PB28: SITE6.90(SPI_FLASH_CLK/SD_CLK/GPIOG_3/PB) UNK6K1.6
S6_SPI_CS: UNK6K3.2 UNK6R10.1
S6_SPI_CS/PC0: SITE6.95(SPI_FLASH_CS/UART1_CTS/SD_CD/GP) UNK6K3.3
S6_SPI_D0/PB29: SITE6.91(SPI_FLASH_DATA0/UART1_RXD/SD_D0) UNK6K1.3
S6_SPI_D1/PB31: SITE6.94(SPI_FLASH_DATA1/UART1_RTS/SD_WP) UNK6K3.6
S6_SPI_D2/PB30: SITE6.92(SPI_FLASH_DATA2/UART1_TXD/SD_D1) UNK6K2.6
S6_SPI_D3/PB27: SITE6.89(SPI_FLASH_DATA3/SD_CMD/GPIOG_2/) UNK6K2.3
S6_SPI_DATA0: UNK6K1.2 UNK6R17.2
S6_SPI_DATA1: UNK6K3.7 UNK6R11.1
S6_SPI_DATA2: UNK6K2.7 UNK6R16.1
S6_SPI_DATA3: UNK6K2.2 UNK6R13.2
S6_U1_VC1: UNK6K39.5 UNK6U1.4
S6_U2_VC1: UNK6K39.4 UNK6U2.4
S6_VA09_MIPI: SITE6.84(VA09_MIPI/VA09_CK/VA09_DA) UNK6BD37.2 UNK6C152.1
S6_VA09_PLL: SITE6.11(VA09_PLL/VD09_CORE0) UNK6BD1.2 UNK6C44.1
S6_VA09_USB: SITE6.77(VA09_USB) UNK6BD2.2 UNK6C45.1
S6_VA13_AFE: SITE6.19(VA13_AFE) UNK6BD20.2 UNK6C88.1
S6_VA13_SYN: SITE6.23(VR13_SYN) UNK6BD16.2 UNK6C78.1
S6_VA33_SYN: SITE6.24(VR33_SYN) UNK6BD13.2 UNK6C64.1
S6_VA33_XTAL: SITE6.20(VA33_XTAL) UNK6BD5.2 UNK6C48.1
S6_VD09_CORE1: SITE6.56(VD09_CORE1/VD09MEM0) UNK6C47.1 UNK6R76.2
S6_VD09_CORE2: SITE6.64(VD09_CORE2/VD09_MEM1) UNK6C49.1 UNK6R77.2
S6_VD09_CORE3: SITE6.87(VD09_CORE3/VA09_PLL) UNK6C54.1 UNK6R78.2
S6_VD09_CORE4: SITE6.98(VD09_CORE4) UNK6C58.1 UNK6R79.2
S6_VD13_FE: SITE6.36(VD13_FE) UNK6BD19.2 UNK6C85.1
S6_VD13_RF: SITE6.25(VD13_RF) UNK6BD17.2 UNK6C79.1
S6_VD33_ALL: UNK6BD3.1 UNK6BD5.1 UNK6BD7.1 UNK6BD9.1 UNK6BD11.1 UNK6BD12.1 UNK6BD13.1 UNK6BD15.1 UNK6BD18.1 UNK6BD21.1 UNK6BD22.1 UNK6BD23.1 UNK6BD28.1 UNK6BD29.1 UNK6BD30.1 UNK6BD31.1 UNK6BD32.1 UNK6BD36.1 UNK6C67.1 UNK6C96.1 UNK6C101.1 UNK6C122.1 UNK6C129.1 UNK6J5.1 UNK6J6.1 UNK6K23.2 UNK6K23.7
S6_VD33_CM_BT: SITE6.35(VD33_CM_BT) UNK6BD21.2 UNK6C90.1 UNK6C91.1
S6_VD33_EX_FLASH: UNK6BD32.2 UNK6C22.1 UNK6C127.1 UNK6C128.1 UNK6R12.2 UNK6R14.1 UNK6U3.8
S6_VD33_IO0: SITE6.9(VA33_PLL/VD33_IO0) UNK6BD7.2 UNK6C52.1
S6_VD33_IO2: SITE6.59(VD33_IO2/VD33_MEM) UNK6BD9.2 UNK6C56.1
S6_VD33_IO3: SITE6.70(VD33_IO3/VDD_IO4/VA33_USB) UNK6BD11.2 UNK6C59.1
S6_VD33_IO6: SITE6.88(VD33_IO6/VDD33_IO5/VD33_FLASH) UNK6BD12.2 UNK6C61.1
S6_VD33_SPS_AUD: SITE6.1(VD33_SPS_AUD) UNK6BD30.2 UNK6C123.1 UNK6C124.1
S6_VD33_SPS_DCORE: SITE6.2(VD33_SPS_DCORE) UNK6BD28.2 UNK6C111.1 UNK6C112.1
S6_VD33_SPS_MEM: SITE6.76(VD33_SPS_MEM) UNK6BD31.2 UNK6C125.1 UNK6C126.1
S6_VD33PA_A: SITE6.27(VD33PA_A) UNK6BD23.2 UNK6C99.1 UNK6C100.1
S6_VD33PA_BT: SITE6.38(VD33PA_BT) UNK6BD18.2 UNK6C83.1 UNK6C84.1
S6_VD33PA_G: SITE6.33(VD33PA_G) UNK6BD15.2 UNK6C76.1 UNK6C77.1
S6_VD33PAD_A: SITE6.26(VD33PAD_A) UNK6BD22.2 UNK6C97.1 UNK6C98.1
S6_VD33PAD_G: SITE6.34(VD33PAD_G) UNK6BD36.2 UNK6C73.1 UNK6C74.1
S6_VD1833_IO1: SITE6.14(VD1833_IO1) UNK6BD3.2 UNK6C46.1
S6_VD1833_SDIO: SITE6.93(VD1833_SDIO) UNK6BD29.2 UNK6C118.1 UNK6C119.1
S6_VD_MEM0: SITE6.61(VD_MEM0) UNK6C102.1 UNK6R81.2
S6_VD_MEM1: SITE6.62(VD_MEM1) UNK6C105.1 UNK6R82.2
S6_VD_MEM2: SITE6.65(VD_MEM2) UNK6C107.1 UNK6R83.2
S6_VDD09: S6_VDD09.1(TP) UNK6K22.2 UNK6K22.5 UNK6K31.4 UNK6R48.1
S6_VDD09_CH: UNK6K37.4 UNK6ST13.1
S6_VDD18_A: S6_VDD18_A.1(TP) UNK6K25.2 UNK6K25.5 UNK6K26.3 UNK6K32.4 UNK6R55.1
S6_VDD18_D: S6_VDD18_D.1(TP) UNK6K28.2 UNK6K28.5 UNK6K30.4 UNK6R29.2 UNK6R53.1
S6_VDD33: UNK6BD33.2 UNK6C130.1 UNK6R19.1 UNK6R24.1 UNK6R30.1 UNK6R38.2 UNK6R61.2 UNK6U1.6 UNK6U2.6
S6_VDD33_J1: UNK6J1.1 UNK6R19.2
S6_VDD33_J2: UNK6J2.1 UNK6R24.2
S6_VDD33_J3: UNK6J3.1 UNK6R30.2
S6_VREF_DRAM: SITE6.63(VREF_DRAM/NC(PSRAM)) UNK6C153.1 UNK6K16.3
S6_XI: SITE6.22(XI) UNK6C25.2 UNK6Y1.1
S6_XO: SITE6.21(XO) UNK6C23.2 UNK6Y1.3
S7_1_AOUT_LN: UNK7K10.4 UNK7R45.1 UNK7R67.1 UNK7R68.1
S7_1_AOUT_LP: UNK7K10.5 UNK7R69.1 UNK7R70.1 UNK7R75.1
S7_1_AOUT_RN: UNK7K14.4 UNK7R47.1 UNK7R63.1 UNK7R64.1
S7_1_AOUT_RP: UNK7K14.5 UNK7R65.1 UNK7R66.1 UNK7R74.1
S7_1_SPI_CLK: UNK7R15.1 UNK7U3.6
S7_1_SPI_CS: UNK7R10.2 UNK7U3.1
S7_1_SPI_DATA0: UNK7R17.1 UNK7U3.5
S7_1_SPI_DATA1: UNK7R11.2 UNK7U3.2
S7_1_SPI_DATA2: UNK7R14.2 UNK7R16.2 UNK7R18.2 UNK7U3.3
S7_1_SPI_DATA3: UNK7R12.1 UNK7R13.1 UNK7U3.7
S7_1_VDD09: UNK7BD1.1 UNK7BD2.1 UNK7BD37.1 UNK7C60.1 UNK7R48.2 UNK7R76.1 UNK7R77.1 UNK7R78.1 UNK7R79.1 UNK7ST13.2
S7_1_VDD18_A: S7_1V3.1(TP) UNK7K26.2 UNK7K26.5 UNK7R50.1
S7_1_VDD18_D: UNK7C113.2 UNK7R53.2 UNK7R81.1 UNK7R82.1 UNK7R83.1 UNK7ST15.1
S7_2_AOUT_LN: UNK7K12.4 UNK7R68.2
S7_2_AOUT_LP: UNK7K12.5 UNK7R69.2
S7_2_AOUT_RN: UNK7K15.4 UNK7R64.2
S7_2_AOUT_RP: UNK7K15.5 UNK7R65.2
S7_2_VDD18_A: UNK7BD16.1 UNK7BD17.1 UNK7BD19.1 UNK7BD20.1 UNK7C89.1 UNK7R50.2
S7_ATX_VD0V9: ATX_VD0V9.16 UNK7C65.1 UNK7C66.1 UNK7K21.6 UNK7ST3.2
S7_ATX_VD1V8: ATX_VD1V8.16 UNK7J7.1 UNK7J8.1 UNK7J9.1
S7_ATX_VD33: ATX_VD33.16 UNK7BD33.1 UNK7C131.1 UNK7C132.1 UNK7C133.1 UNK7C134.1 UNK7C135.1 UNK7J6.2
S7_AVCC_DRV: SITE7.53(AVCC_DRV) UNK7C75.1 UNK7C110.1 UNK7R55.2 UNK7ST14.1
S7_AVO_DGS02: P6.C12(12)
S7_AVO_DGS03: P6.C6(6)
S7_CAP06_N: P6.B9(9)
S7_CAP06_NSH: P6.B11(11)
S7_CAP06_P: P6.A10(10)
S7_CAP06_PSH: P6.A8(8)
S7_CAP07_N: P6.B3(3)
S7_CAP07_NSH: P6.B5(5)
S7_CAP07_P: P6.A4(4)
S7_CAP07_PSH: P6.A2(2)
S7_CAP14_N: P6.J9(9)
S7_CAP14_NSH: P6.J11(11)
S7_CAP14_P: P6.I10(10)
S7_CAP14_PSH: P6.I8(8)
S7_CAP15_N: P6.J3(3)
S7_CAP15_NSH: P6.J5(5)
S7_CAP15_P: P6.I4(4)
S7_CAP15_PSH: P6.I2(2)
S7_CHIP_EN_1: UNK7R34.2 UNK7SW5.1
S7_DPS_F001: UNK7C120.1 UNK7C121.1 UNK7J9.2 UNK7K29.6 UNK7ST11.2
S7_DPS_F002: UNK7C92.1 UNK7C93.1 UNK7C94.1 UNK7C95.1 UNK7J8.2 UNK7K26.6 UNK7ST8.2
S7_DPS_F004: UNK7C140.1 UNK7C141.1 UNK7J7.2 UNK7K20.6 UNK7ST12.2
S7_DPS_F006: S7_VD33_ALL1.1(TP) UNK7C68.1 UNK7C69.1 UNK7C70.1 UNK7C71.1 UNK7C72.1 UNK7K23.3 UNK7K23.6 UNK7ST4.2
S7_DPS_GS001: UNK7ST19.1
S7_DPS_GS002: UNK7ST18.1
S7_DPS_GS003-1: UNK7ST16.1
S7_DPS_GS004: UNK7ST17.1
S7_DPS_GS006: UNK7ST5.1
S7_DPS_S001: UNK7ST11.1
S7_DPS_S002: UNK7ST8.1
S7_DPS_S003-1: UNK7ST3.1
S7_DPS_S004: UNK7ST12.1
S7_DPS_S006: UNK7ST4.1
S7_HSDM: SITE7.79(HSDM) UNK7K5.8
S7_HSDP: SITE7.78(HSDP) UNK7K5.2
S7_LPC_001: UNK7K36.7
S7_LPC_002: UNK7K36.2
S7_LPC_003: UNK7K11.2
S7_LPC_005: UNK7K14.2
S7_LPC_006: UNK7K18.4
S7_LPC_007: UNK7K1.4
S7_LPC_008: UNK7K35.2
S7_LPC_009: UNK6K38.6
S7_LPC_010: UNK7K34.7
S7_LPC_012: UNK6K37.6
S7_LPC_013+: UNK7K5.3 UNK7K7.2
S7_LPC_013-: UNK7K5.7 UNK7K7.8
S7_LPC_016: UNK7K2.5
S7_LPC_017: UNK7K35.7
S7_LPC_019: UNK7K12.2
S7_LPC_021: UNK7K1.5
S7_LPC_022: UNK7K15.2
S7_LPC_023: UNK7K3.4
S7_LPC_024: SITE7.69(UART2_TXD/TEST_MODE_SEL/DMIC0_C) UNK7J4.2 UNK7R35.1
S7_LPC_025: SITE7.71(CHIP_EN) UNK7J4.1 UNK7R34.1
S7_LPC_026: UNK7K2.4
S7_LPC_027: UNK7K10.2
S7_LPC_028: UNK7K10.7
S7_LPC_029: UNK7K13.7
S7_LPC_030: UNK7K16.2
S7_LPC_032: UNK7K15.7
S7_LPC_033: UNK7K14.7
S7_LPC_034: UNK7K18.5
S7_LPC_035: UNK7K12.7
S7_LPC_036: UNK7K34.2
S7_LPC_038: UNK7K13.2
S7_LPC_039: UNK7K3.5
S7_LPC_040: UNK7K11.7
S7_LPC_041: SITE7.68(UART2_RXD/BOOT_SEL/DMIC0_DATA/G) UNK7J4.3 UNK7R36.1
S7_LPC_042: SITE7.50(MIC_BIAS2/GPIOC_13/PA[31]) UNK7C18.2
S7_LPC_043: UNK6K33.6
S7_LPC_044: SITE7.58(I2S3_DOUT1/DMIC_DATA2/ICFG1/GPI) UNK7J4.5 UNK7R39.1
S7_LPC_045: UNK7K39.3
S7_LPC_046: SITE7.67(I2S2_DIN3/I2S3_DOUT3/SPK_CLK/SP)
S7_LPC_047: SITE7.18(GPIOB_7/PA[16]/ICFG3/SPI0_CS/UA) UNK7J4.7 UNK7R41.1
S7_LPC_048: UNK7K6.4
S7_LPC_049: SITE7.8(GPIOA_5/PA[5]/TOUCH5/ADC5/UART1)
S7_LPC_050: SITE7.7(GPIOA_4/PA[4]/TOUCH4/ADC4/UART1)
S7_LPC_051: SITE7.49(MIC_BIAS1/GPIOC_12/PA[30]) UNK7C17.2
S7_LPC_052: SITE7.48(AVCC) UNK7C21.1
S7_LPC_053: SITE7.57(I2S3_DOUT0/DMIC_DATA1/ICFG0/BT_) UNK7J4.4 UNK7R37.1
S7_LPC_054: UNK7K6.5
S7_LPC_055: SITE7.10(VBAT_MEAS)
S7_LPC_057: UNK7K9.4
S7_LPC_058: SITE7.17(GPIOB_6/PA[15]/ICFG2/SPI0_CLK/U) UNK7J4.6 UNK7R40.1
S7_LPC_059: UNK7K39.6
S7_LPC_060: SITE7.66(I2S2_DIN2/I2S3_DOUT2/SPK_DATA/S)
S7_LPC_A_015: UNK7K8.4
S7_LPC_A_020: UNK7K8.5
S7_LPC_B_031: UNK7K4.4
S7_LPC_B_037: UNK7K4.5
S7_LX_AUD: SITE7.100(LX_AUD) UNK7K20.3
S7_LX_AUD_CH_1: UNK6K38.7 UNK7K20.4
S7_LX_AUD_CH_2: UNK6K38.5 UNK7ST14.2
S7_LX_DCORE: SITE7.3(LX_DCORE) UNK7K21.3
S7_LX_DCORE_CH: UNK6K37.7 UNK7K21.4
S7_LX_MEM: SITE7.75(LX_MEM) UNK7K29.3
S7_LX_MEM_CH_1: UNK6K33.7 UNK7K29.4
S7_LX_MEM_CH_2: UNK6K33.5 UNK7ST15.2
S7_MIPITX_CKN: SITE7.82(MIPITX_CKN) UNK7K36.6
S7_MIPITX_CKP: SITE7.83(MIPITX_CKP) UNK7K36.3
S7_MIPITX_DATAN_0: SITE7.85(MIPITX_DATAN_0) UNK7K34.6
S7_MIPITX_DATAN_1: SITE7.80(MIPITX_DATAN_1) UNK7K35.6
S7_MIPITX_DATAP_0: SITE7.86(MIPITX_DATAP_0) UNK7K34.3
S7_MIPITX_DATAP_1: SITE7.81(MIPITX_DATAP_1) UNK7K35.3
S7_PA2: SITE7.5(GPIOA_2/PA[2]/TOUCH2/ADC2/UART0) UNK7K18.3
S7_PA3: SITE7.6(GPIOA_3/PA[3]/TOUCH3/ADC3/UART0) UNK7K18.6
S7_PA9_CH: SITE7.12(GPIOB_0/PA[9]) UNK7K39.2
S7_PA10_CH: SITE7.13(GPIOB_1/PA[10]) UNK7K39.7
S7_PA13: SITE7.15(GPIOB_4/PA[13]/SWD_DATA/SPI0_MO) UNK7K6.3
S7_PA13_UART_RX: UNK7K6.2 UNK7R27.1
S7_PA13_UART_RX_1: UNK7J2.3 UNK7R27.2
S7_PA14: SITE7.16(GPIOB_5/PA[14]/SWD_CLK/SPI0_MIS) UNK7K6.6
S7_PA14_UART_TX: UNK7K6.7 UNK7R28.1
S7_PA14_UART_TX_1: UNK7J2.4 UNK7R28.2
S7_PA15_1: UNK7R40.2 UNK7SW5.6
S7_PA16_1: UNK7R41.2 UNK7SW5.7
S7_PA20: SITE7.45(MIC1_P/GPIOC_2/PA[20]) UNK7K15.6
S7_PA21: SITE7.46(MIC1_N/GPIOC_3/PA[21]) UNK7K15.3
S7_PA22: SITE7.43(MIC2_P/GPIOC_4/PA[22]) UNK7K11.6
S7_PA23: SITE7.44(MIC2_N/GPIOC_5/PA[23]) UNK7K11.3
S7_PA24: SITE7.41(MIC3_P/I2C_SDA/GPIOC_6/PA[24]) UNK7K12.6
S7_PA25: SITE7.42(MIC3_N/I2C_SCL/GPIOC_7/PA[25]) UNK7K12.3
S7_PA28: SITE7.39(MIC5_P/ANT_SEL_P/GPIOC_10/PA[28) UNK7K13.6
S7_PA29: SITE7.40(MIC5_N/ANT_SEL_N/GPIOC_11/PA[29) UNK7K13.3
S7_PB3: SITE7.52(AOUT_LP/GPIOC_17/PB[3]) UNK7K10.6
S7_PB3_AOUT_LP_2: UNK7K13.5 UNK7R70.2
S7_PB4: SITE7.51(AOUT_LN/GPIOC_18/PB[4]) UNK7K10.3
S7_PB4_AOUT_LN_2: UNK7K13.4 UNK7R67.2
S7_PB5: SITE7.54(AOUT_RP/GPIOC_19/PB[5]) UNK7K14.6
S7_PB5_AOUT_RP_2: UNK7K11.5 UNK7R66.2
S7_PB6: SITE7.55(AOUT_RN/GPIOC_20/PB[6]) UNK7K14.3
S7_PB6_AOUT_RN_2: UNK7K11.4 UNK7R63.2
S7_PB10_1: UNK7R37.2 UNK7SW5.4
S7_PB11_1: UNK7R39.2 UNK7SW5.5
S7_PB21_1: UNK7R36.2 UNK7SW5.3
S7_PB22_1: UNK7R35.2 UNK7SW5.2
S7_PB23: SITE7.72(UART_LOG_RXD/OTP_BYPASS/GPIOF_2) UNK7C144.2 UNK7K4.3 UNK7R57.1
S7_PB23_1: UNK7R57.2 UNK7SW6.1
S7_PB23_SICK: UNK7K4.2 UNK7R20.1
S7_PB23_SICK_1: UNK7J1.3 UNK7R20.2
S7_PB24: SITE7.73(UART_LOG_TXD/UART_DOWNLOAD/GPIO) UNK7C143.2 UNK7K4.6 UNK7R58.1
S7_PB24_1: UNK7R58.2 UNK7SW6.2
S7_PB24_SIDD: UNK7K4.7 UNK7R21.1
S7_PB24_SIDD_1: UNK7J1.4 UNK7R21.2
S7_PB25: SITE7.96(SPI0_CLK/SWD_CLK/SD_D2/ICFG2/GP) UNK7K8.3 UNK7R59.1
S7_PB25_1: UNK7R59.2 UNK7SW6.3
S7_PB25_I2C_SCL: UNK7K8.2 UNK7R31.1
S7_PB25_I2C_SCL_1: UNK7J3.3 UNK7R31.2
S7_PB26: SITE7.97(SPI0_CS/SWD_DATA/SD_D3/ICFG3/GP) UNK7K8.6 UNK7R60.1
S7_PB26_1: UNK7R60.2 UNK7SW6.4
S7_PB26_I2C_SDA: UNK7K8.7 UNK7R32.1
S7_PB26_I2C_SDA_1: UNK7J3.4 UNK7R32.2
S7_REF08_F: P6.G8(8)
S7_REF08_S: P6.H7(7)
S7_REF09_F: P6.G6(6)
S7_REF09_S: P6.H5(5)
S7_REF10_F: P6.G4(4)
S7_REF10_S: P6.H3(3)
S7_REF11_F: P6.G2(2)
S7_REF11_S: P6.H1(1)
S7_REF12_F: P6.E8(8)
S7_REF12_S: P6.F7(7)
S7_REF13_F: P6.E6(6)
S7_REF13_S: P6.F5(5)
S7_REF14_F: P6.E4(4)
S7_REF14_S: P6.F3(3)
S7_REF15_F: P6.E2(2)
S7_REF15_S: P6.F1(1)
S7_RF_A: UNK7C13.1 UNK7C14.1 UNK7C15.1 UNK7D3.1 UNK7SMP3.1
S7_RF_G: UNK7C6.1 UNK7C7.1 UNK7C8.1 UNK7D2.1 UNK7SMP2.1
S7_RFIN_A: SITE7.29(RFIN_A/GND (<750UM)) UNK7C16.2 UNK7R9.1
S7_RFIN_G: SITE7.31(RFIN_G/GND) UNK7C9.2 UNK7R5.1
S7_RFIO_A: SITE7.28(RFIO_A  (<750UM)) UNK7C11.2 UNK7R6.1
S7_RFIO_BT: SITE7.37(RFIO_BT) UNK7C1.2 UNK7R1.1
S7_RFIO_G: SITE7.32(RFIO_G) UNK7C4.2 UNK7R2.1
S7_RREF_MEM: SITE7.60(RREF_MEM) UNK7K9.3 UNK7R43.1
S7_SPI_CLK: UNK7K1.7 UNK7R15.2
S7_SPI_CLK/PB28: SITE7.90(SPI_FLASH_CLK/SD_CLK/GPIOG_3/PB) UNK7K1.6
S7_SPI_CS: UNK7K3.2 UNK7R10.1
S7_SPI_CS/PC0: SITE7.95(SPI_FLASH_CS/UART1_CTS/SD_CD/GP) UNK7K3.3
S7_SPI_D0/PB29: SITE7.91(SPI_FLASH_DATA0/UART1_RXD/SD_D0) UNK7K1.3
S7_SPI_D1/PB31: SITE7.94(SPI_FLASH_DATA1/UART1_RTS/SD_WP) UNK7K3.6
S7_SPI_D2/PB30: SITE7.92(SPI_FLASH_DATA2/UART1_TXD/SD_D1) UNK7K2.6
S7_SPI_D3/PB27: SITE7.89(SPI_FLASH_DATA3/SD_CMD/GPIOG_2/) UNK7K2.3
S7_SPI_DATA0: UNK7K1.2 UNK7R17.2
S7_SPI_DATA1: UNK7K3.7 UNK7R11.1
S7_SPI_DATA2: UNK7K2.7 UNK7R16.1
S7_SPI_DATA3: UNK7K2.2 UNK7R13.2
S7_SRC02_N: P6.D9(9)
S7_SRC02_NSH: P6.D11(11)
S7_SRC02_P: P6.C10(10)
S7_SRC02_PSH: P6.C8(8)
S7_SRC03_N: P6.D3(3)
S7_SRC03_NSH: P6.D5(5)
S7_SRC03_P: P6.C4(4)
S7_SRC03_PSH: P6.C2(2)
S7_SRC10_N: P6.L9(9)
S7_SRC10_NSH: P6.L11(11)
S7_SRC10_P: P6.K10(10)
S7_SRC10_PSH: P6.K8(8)
S7_SRC11_N: P6.L3(3)
S7_SRC11_NSH: P6.L5(5)
S7_SRC11_P: P6.K4(4)
S7_SRC11_PSH: P6.K2(2)
S7_U1_VC1: UNK7K39.5 UNK7U1.4
S7_U2_VC1: UNK7K39.4 UNK7U2.4
S7_VA09_MIPI: SITE7.84(VA09_MIPI/VA09_CK/VA09_DA) UNK7BD37.2 UNK7C152.1
S7_VA09_PLL: SITE7.11(VA09_PLL/VD09_CORE0) UNK7BD1.2 UNK7C44.1
S7_VA09_USB: SITE7.77(VA09_USB) UNK7BD2.2 UNK7C45.1
S7_VA13_AFE: SITE7.19(VA13_AFE) UNK7BD20.2 UNK7C88.1
S7_VA13_SYN: SITE7.23(VR13_SYN) UNK7BD16.2 UNK7C78.1
S7_VA33_SYN: SITE7.24(VR33_SYN) UNK7BD13.2 UNK7C64.1
S7_VA33_XTAL: SITE7.20(VA33_XTAL) UNK7BD5.2 UNK7C48.1
S7_VD09_CORE1: SITE7.56(VD09_CORE1/VD09MEM0) UNK7C47.1 UNK7R76.2
S7_VD09_CORE2: SITE7.64(VD09_CORE2/VD09_MEM1) UNK7C49.1 UNK7R77.2
S7_VD09_CORE3: SITE7.87(VD09_CORE3/VA09_PLL) UNK7C54.1 UNK7R78.2
S7_VD09_CORE4: SITE7.98(VD09_CORE4) UNK7C58.1 UNK7R79.2
S7_VD13_FE: SITE7.36(VD13_FE) UNK7BD19.2 UNK7C85.1
S7_VD13_RF: SITE7.25(VD13_RF) UNK7BD17.2 UNK7C79.1
S7_VD33_ALL: UNK7BD3.1 UNK7BD5.1 UNK7BD7.1 UNK7BD9.1 UNK7BD11.1 UNK7BD12.1 UNK7BD13.1 UNK7BD15.1 UNK7BD18.1 UNK7BD21.1 UNK7BD22.1 UNK7BD23.1 UNK7BD28.1 UNK7BD29.1 UNK7BD30.1 UNK7BD31.1 UNK7BD32.1 UNK7BD36.1 UNK7C67.1 UNK7C96.1 UNK7C101.1 UNK7C122.1 UNK7C129.1 UNK7J5.1 UNK7J6.1 UNK7K23.2 UNK7K23.7
S7_VD33_CM_BT: SITE7.35(VD33_CM_BT) UNK7BD21.2 UNK7C90.1 UNK7C91.1
S7_VD33_EX_FLASH: UNK7BD32.2 UNK7C22.1 UNK7C127.1 UNK7C128.1 UNK7R12.2 UNK7R14.1 UNK7U3.8
S7_VD33_IO0: SITE7.9(VA33_PLL/VD33_IO0) UNK7BD7.2 UNK7C52.1
S7_VD33_IO2: SITE7.59(VD33_IO2/VD33_MEM) UNK7BD9.2 UNK7C56.1
S7_VD33_IO3: SITE7.70(VD33_IO3/VDD_IO4/VA33_USB) UNK7BD11.2 UNK7C59.1
S7_VD33_IO6: SITE7.88(VD33_IO6/VDD33_IO5/VD33_FLASH) UNK7BD12.2 UNK7C61.1
S7_VD33_SPS_AUD: SITE7.1(VD33_SPS_AUD) UNK7BD30.2 UNK7C123.1 UNK7C124.1
S7_VD33_SPS_DCORE: SITE7.2(VD33_SPS_DCORE) UNK7BD28.2 UNK7C111.1 UNK7C112.1
S7_VD33_SPS_MEM: SITE7.76(VD33_SPS_MEM) UNK7BD31.2 UNK7C125.1 UNK7C126.1
S7_VD33PA_A: SITE7.27(VD33PA_A) UNK7BD23.2 UNK7C99.1 UNK7C100.1
S7_VD33PA_BT: SITE7.38(VD33PA_BT) UNK7BD18.2 UNK7C83.1 UNK7C84.1
S7_VD33PA_G: SITE7.33(VD33PA_G) UNK7BD15.2 UNK7C76.1 UNK7C77.1
S7_VD33PAD_A: SITE7.26(VD33PAD_A) UNK7BD22.2 UNK7C97.1 UNK7C98.1
S7_VD33PAD_G: SITE7.34(VD33PAD_G) UNK7BD36.2 UNK7C73.1 UNK7C74.1
S7_VD1833_IO1: SITE7.14(VD1833_IO1) UNK7BD3.2 UNK7C46.1
S7_VD1833_SDIO: SITE7.93(VD1833_SDIO) UNK7BD29.2 UNK7C118.1 UNK7C119.1
S7_VD_MEM0: SITE7.61(VD_MEM0) UNK7C102.1 UNK7R81.2
S7_VD_MEM1: SITE7.62(VD_MEM1) UNK7C105.1 UNK7R82.2
S7_VD_MEM2: SITE7.65(VD_MEM2) UNK7C107.1 UNK7R83.2
S7_VDD09: S7_VDD09.1(TP) UNK7K22.2 UNK7K22.5 UNK7K31.4 UNK7R48.1
S7_VDD09_CH: UNK6K37.5 UNK7ST13.1
S7_VDD18_A: S7_VDD18_A.1(TP) UNK7K25.2 UNK7K25.5 UNK7K26.3 UNK7K32.4 UNK7R55.1
S7_VDD18_D: S7_VDD18_D.1(TP) UNK7K28.2 UNK7K28.5 UNK7K30.4 UNK7R29.2 UNK7R53.1
S7_VDD33: UNK7BD33.2 UNK7C130.1 UNK7R19.1 UNK7R24.1 UNK7R30.1 UNK7R38.2 UNK7R61.2 UNK7U1.6 UNK7U2.6
S7_VDD33_J1: UNK7J1.1 UNK7R19.2
S7_VDD33_J2: UNK7J2.1 UNK7R24.2
S7_VDD33_J3: UNK7J3.1 UNK7R30.2
S7_VREF_DRAM: SITE7.63(VREF_DRAM/NC(PSRAM)) UNK7C153.1 UNK7K16.3
S7_XI: SITE7.22(XI) UNK7C25.2 UNK7Y1.1
S7_XO: SITE7.21(XO) UNK7C23.2 UNK7Y1.3
S8_AVO_DGS00: P7.X12(12)
S8_AVO_DGS01: P7.X6(6)
S8_AVO_DGS02: P1.P12(12)
S8_AVO_DGS03: P1.P6(6)
S8_AVO_TRIG0: P7.N8(8)
S8_AVO_TRIG1: P7.N6(6)
S8_AVO_TRIG2: P7.N4(4)
S8_AVO_TRIG3: P7.N2(2)
S8_CAP04_N: P7.Y9(9)
S8_CAP04_NSH: P7.Y11(11)
S8_CAP04_P: P7.Z10(10)
S8_CAP04_PSH: P7.Z8(8)
S8_CAP05_N: P7.Y3(3)
S8_CAP05_NSH: P7.Y5(5)
S8_CAP05_P: P7.Z4(4)
S8_CAP05_PSH: P7.Z2(2)
S8_CAP06_N: P1.O9(9)
S8_CAP06_NSH: P1.O11(11)
S8_CAP06_P: P1.N10(10)
S8_CAP06_PSH: P1.N8(8)
S8_CAP07_N: P1.O3(3)
S8_CAP07_NSH: P1.O5(5)
S8_CAP07_P: P1.N4(4)
S8_CAP07_PSH: P1.N2(2)
S8_CAP12_N: P7.Q9(9)
S8_CAP12_NSH: P7.Q11(11)
S8_CAP12_P: P7.R10(10)
S8_CAP12_PSH: P7.R8(8)
S8_CAP13_N: P7.Q3(3)
S8_CAP13_NSH: P7.Q5(5)
S8_CAP13_P: P7.R4(4)
S8_CAP13_PSH: P7.R2(2)
S8_CAP14_N: P1.W9(9)
S8_CAP14_NSH: P1.W11(11)
S8_CAP14_P: P1.V10(10)
S8_CAP14_PSH: P1.V8(8)
S8_CAP15_N: P1.W3(3)
S8_CAP15_NSH: P1.W5(5)
S8_CAP15_P: P1.V4(4)
S8_CAP15_PSH: P1.V2(2)
S8_REF00_F: P7.T8(8)
S8_REF00_S: P7.S7(7)
S8_REF01_F: P7.T6(6)
S8_REF01_S: P7.S5(5)
S8_REF02_F: P7.T4(4)
S8_REF02_S: P7.S3(3)
S8_REF03_F: P7.T2(2)
S8_REF03_S: P7.S1(1)
S8_REF04_F: P7.V8(8)
S8_REF04_S: P7.U7(7)
S8_REF05_F: P7.V6(6)
S8_REF05_S: P7.U5(5)
S8_REF06_F: P7.V4(4)
S8_REF06_S: P7.U3(3)
S8_REF07_F: P7.V2(2)
S8_REF07_S: P7.U1(1)
S8_REF08_F: P1.T8(8)
S8_REF08_S: P1.U7(7)
S8_REF09_F: P1.T6(6)
S8_REF09_S: P1.U5(5)
S8_REF10_F: P1.T4(4)
S8_REF10_S: P1.U3(3)
S8_REF11_F: P1.T2(2)
S8_REF11_S: P1.U1(1)
S8_REF12_F: P1.R8(8)
S8_REF12_S: P1.S7(7)
S8_REF13_F: P1.R6(6)
S8_REF13_S: P1.S5(5)
S8_REF14_F: P1.R4(4)
S8_REF14_S: P1.S3(3)
S8_REF15_F: P1.R2(2)
S8_REF15_S: P1.S1(1)
S8_SRC00_N: P7.W9(9)
S8_SRC00_NSH: P7.W11(11)
S8_SRC00_P: P7.X10(10)
S8_SRC00_PSH: P7.X8(8)
S8_SRC01_N: P7.W3(3)
S8_SRC01_NSH: P7.W5(5)
S8_SRC01_P: P7.X4(4)
S8_SRC01_PSH: P7.X2(2)
S8_SRC02_N: P1.Q9(9)
S8_SRC02_NSH: P1.Q11(11)
S8_SRC02_P: P1.P10(10)
S8_SRC02_PSH: P1.P8(8)
S8_SRC03_N: P1.Q3(3)
S8_SRC03_NSH: P1.Q5(5)
S8_SRC03_P: P1.P4(4)
S8_SRC03_PSH: P1.P2(2)
S8_SRC08_N: P7.O9(9)
S8_SRC08_NSH: P7.O11(11)
S8_SRC08_P: P7.P10(10)
S8_SRC08_PSH: P7.P8(8)
S8_SRC09_N: P7.O3(3)
S8_SRC09_NSH: P7.O5(5)
S8_SRC09_P: P7.P4(4)
S8_SRC09_PSH: P7.P2(2)
S8_SRC10_N: P1.Y9(9)
S8_SRC10_NSH: P1.Y11(11)
S8_SRC10_P: P1.X10(10)
S8_SRC10_PSH: P1.X8(8)
S8_SRC11_N: P1.Y3(3)
S8_SRC11_NSH: P1.Y5(5)
S8_SRC11_P: P1.X4(4)
S8_SRC11_PSH: P1.X2(2)
S9_AVO_DGS00: P11.K12(12)
S9_AVO_DGS01: P11.K6(6)
S9_AVO_TRIG0: P11.A8(8)
S9_AVO_TRIG1: P11.A6(6)
S9_AVO_TRIG2: P11.A4(4)
S9_AVO_TRIG3: P11.A2(2)
S9_CAP04_N: P11.L9(9)
S9_CAP04_NSH: P11.L11(11)
S9_CAP04_P: P11.M10(10)
S9_CAP04_PSH: P11.M8(8)
S9_CAP05_N: P11.L3(3)
S9_CAP05_NSH: P11.L5(5)
S9_CAP05_P: P11.M4(4)
S9_CAP05_PSH: P11.M2(2)
S9_CAP12_N: P11.D9(9)
S9_CAP12_NSH: P11.D11(11)
S9_CAP12_P: P11.E10(10)
S9_CAP12_PSH: P11.E8(8)
S9_CAP13_N: P11.D3(3)
S9_CAP13_NSH: P11.D5(5)
S9_CAP13_P: P11.E4(4)
S9_CAP13_PSH: P11.E2(2)
S9_REF00_F: P11.G8(8)
S9_REF00_S: P11.F7(7)
S9_REF01_F: P11.G6(6)
S9_REF01_S: P11.F5(5)
S9_REF02_F: P11.G4(4)
S9_REF02_S: P11.F3(3)
S9_REF03_F: P11.G2(2)
S9_REF03_S: P11.F1(1)
S9_REF04_F: P11.I8(8)
S9_REF04_S: P11.H7(7)
S9_REF05_F: P11.I6(6)
S9_REF05_S: P11.H5(5)
S9_REF06_F: P11.I4(4)
S9_REF06_S: P11.H3(3)
S9_REF07_F: P11.I2(2)
S9_REF07_S: P11.H1(1)
S9_SRC00_N: P11.J9(9)
S9_SRC00_NSH: P11.J11(11)
S9_SRC00_P: P11.K10(10)
S9_SRC00_PSH: P11.K8(8)
S9_SRC01_N: P11.J3(3)
S9_SRC01_NSH: P11.J5(5)
S9_SRC01_P: P11.K4(4)
S9_SRC01_PSH: P11.K2(2)
S9_SRC08_N: P11.B9(9)
S9_SRC08_NSH: P11.B11(11)
S9_SRC08_P: P11.C10(10)
S9_SRC08_PSH: P11.C8(8)
S9_SRC09_N: P11.B3(3)
S9_SRC09_NSH: P11.B5(5)
S9_SRC09_P: P11.C4(4)
S9_SRC09_PSH: P11.C2(2)
S10_DPS_DGS00: P1.A3(3)
S10_DPS_DGS01: P1.A7(7)
S10_DPS_DGS02: P1.A11(11)
S10_DPS_DGS03: P1.B2(2)
S10_DPS_DGS04: P1.B6(6)
S10_DPS_DGS05: P1.B10(10)
S10_DPS_DGS06: P1.C3(3)
S10_DPS_DGS07: P1.C7(7)
S10_DPS_DGS08: P1.C11(11)
S10_DPS_DGS09: P1.D2(2)
S10_DPS_DGS10: P1.D6(6)
S10_DPS_DGS11: P1.D10(10)
S10_DPS_DGS12: P1.E3(3)
S10_DPS_DGS13: P1.E7(7)
S10_DPS_DGS14: P1.E11(11)
S10_DPS_DGS15: P1.F2(2)
S10_DPS_DGS16: P1.F6(6)
S10_DPS_DGS17: P1.F10(10)
S10_DPS_DGS18: P1.G3(3)
S10_DPS_DGS19: P1.G7(7)
S10_DPS_DGS20: P1.G11(11)
S10_DPS_DGS21: P1.H2(2)
S10_DPS_DGS22: P1.H6(6)
S10_DPS_DGS23: P1.H10(10)
S10_DPS_DGS24: P1.I3(3)
S10_DPS_DGS25: P1.I7(7)
S10_DPS_DGS26: P1.I11(11)
S10_DPS_DGS27: P1.J2(2)
S10_DPS_DGS28: P1.J6(6)
S10_DPS_DGS29: P1.J10(10)
S10_DPS_DGS30: P1.K3(3)
S10_DPS_DGS31: P1.K7(7)
S10_DPS_DGS32: P7.M3(3)
S10_DPS_DGS33: P7.M7(7)
S10_DPS_DGS34: P7.M11(11)
S10_DPS_DGS35: P7.L2(2)
S10_DPS_DGS36: P7.L6(6)
S10_DPS_DGS37: P7.L10(10)
S10_DPS_DGS38: P7.K3(3)
S10_DPS_DGS39: P7.K7(7)
S10_DPS_DGS40: P7.K11(11)
S10_DPS_DGS41: P7.J2(2)
S10_DPS_DGS42: P7.J6(6)
S10_DPS_DGS43: P7.J10(10)
S10_DPS_DGS44: P7.I3(3)
S10_DPS_DGS45: P7.I7(7)
S10_DPS_DGS46: P7.I11(11)
S10_DPS_DGS47: P7.H2(2)
S10_DPS_DGS48: P7.H6(6)
S10_DPS_DGS49: P7.H10(10)
S10_DPS_DGS50: P7.G3(3)
S10_DPS_DGS51: P7.G7(7)
S10_DPS_DGS52: P7.G11(11)
S10_DPS_DGS53: P7.F2(2)
S10_DPS_DGS54: P7.F6(6)
S10_DPS_DGS55: P7.F10(10)
S10_DPS_DGS56: P7.E3(3)
S10_DPS_DGS57: P7.E7(7)
S10_DPS_DGS58: P7.E11(11)
S10_DPS_DGS59: P7.D2(2)
S10_DPS_DGS60: P7.D6(6)
S10_DPS_DGS61: P7.D10(10)
S10_DPS_DGS62: P7.C3(3)
S10_DPS_DGS63: P7.C7(7)
S10_DPS_F00: P1.A2(2)
S10_DPS_F01: P1.A6(6)
S10_DPS_F02: P1.A10(10)
S10_DPS_F03: P1.B1(1)
S10_DPS_F04: P1.B5(5)
S10_DPS_F05: P1.B9(9)
S10_DPS_F06: P1.C2(2)
S10_DPS_F07: P1.C6(6)
S10_DPS_F08: P1.C10(10)
S10_DPS_F09: P1.D1(1)
S10_DPS_F10: P1.D5(5)
S10_DPS_F11: P1.D9(9)
S10_DPS_F12: P1.E2(2)
S10_DPS_F13: P1.E6(6)
S10_DPS_F14: P1.E10(10)
S10_DPS_F15: P1.F1(1)
S10_DPS_F16: P1.F5(5)
S10_DPS_F17: P1.F9(9)
S10_DPS_F18: P1.G2(2)
S10_DPS_F19: P1.G6(6)
S10_DPS_F20: P1.G10(10)
S10_DPS_F21: P1.H1(1)
S10_DPS_F22: P1.H5(5)
S10_DPS_F23: P1.H9(9)
S10_DPS_F24: P1.I2(2)
S10_DPS_F25: P1.I6(6)
S10_DPS_F26: P1.I10(10)
S10_DPS_F27: P1.J1(1)
S10_DPS_F28: P1.J5(5)
S10_DPS_F29: P1.J9(9)
S10_DPS_F30: P1.K2(2)
S10_DPS_F31: P1.K6(6)
S10_DPS_F32: P7.M2(2)
S10_DPS_F33: P7.M6(6)
S10_DPS_F34: P7.M10(10)
S10_DPS_F35: P7.L1(1)
S10_DPS_F36: P7.L5(5)
S10_DPS_F37: P7.L9(9)
S10_DPS_F38: P7.K2(2)
S10_DPS_F39: P7.K6(6)
S10_DPS_F40: P7.K10(10)
S10_DPS_F41: P7.J1(1)
S10_DPS_F42: P7.J5(5)
S10_DPS_F43: P7.J9(9)
S10_DPS_F44: P7.I2(2)
S10_DPS_F45: P7.I6(6)
S10_DPS_F46: P7.I10(10)
S10_DPS_F47: P7.H1(1)
S10_DPS_F48: P7.H5(5)
S10_DPS_F49: P7.H9(9)
S10_DPS_F50: P7.G2(2)
S10_DPS_F51: P7.G6(6)
S10_DPS_F52: P7.G10(10)
S10_DPS_F53: P7.F1(1)
S10_DPS_F54: P7.F5(5)
S10_DPS_F55: P7.F9(9)
S10_DPS_F56: P7.E2(2)
S10_DPS_F57: P7.E6(6)
S10_DPS_F58: P7.E10(10)
S10_DPS_F59: P7.D1(1)
S10_DPS_F60: P7.D5(5)
S10_DPS_F61: P7.D9(9)
S10_DPS_F62: P7.C2(2)
S10_DPS_F63: P7.C6(6)
S10_DPS_S00: P1.A4(4)
S10_DPS_S01: P1.A8(8)
S10_DPS_S02: P1.A12(12)
S10_DPS_S03: P1.B3(3)
S10_DPS_S04: P1.B7(7)
S10_DPS_S05: P1.B11(11)
S10_DPS_S06: P1.C4(4)
S10_DPS_S07: P1.C8(8)
S10_DPS_S08: P1.C12(12)
S10_DPS_S09: P1.D3(3)
S10_DPS_S10: P1.D7(7)
S10_DPS_S11: P1.D11(11)
S10_DPS_S12: P1.E4(4)
S10_DPS_S13: P1.E8(8)
S10_DPS_S14: P1.E12(12)
S10_DPS_S15: P1.F3(3)
S10_DPS_S16: P1.F7(7)
S10_DPS_S17: P1.F11(11)
S10_DPS_S18: P1.G4(4)
S10_DPS_S19: P1.G8(8)
S10_DPS_S20: P1.G12(12)
S10_DPS_S21: P1.H3(3)
S10_DPS_S22: P1.H7(7)
S10_DPS_S23: P1.H11(11)
S10_DPS_S24: P1.I4(4)
S10_DPS_S25: P1.I8(8)
S10_DPS_S26: P1.I12(12)
S10_DPS_S27: P1.J3(3)
S10_DPS_S28: P1.J7(7)
S10_DPS_S29: P1.J11(11)
S10_DPS_S30: P1.K4(4)
S10_DPS_S31: P1.K8(8)
S10_DPS_S32: P7.M4(4)
S10_DPS_S33: P7.M8(8)
S10_DPS_S34: P7.M12(12)
S10_DPS_S35: P7.L3(3)
S10_DPS_S36: P7.L7(7)
S10_DPS_S37: P7.L11(11)
S10_DPS_S38: P7.K4(4)
S10_DPS_S39: P7.K8(8)
S10_DPS_S40: P7.K12(12)
S10_DPS_S41: P7.J3(3)
S10_DPS_S42: P7.J7(7)
S10_DPS_S43: P7.J11(11)
S10_DPS_S44: P7.I4(4)
S10_DPS_S45: P7.I8(8)
S10_DPS_S46: P7.I12(12)
S10_DPS_S47: P7.H3(3)
S10_DPS_S48: P7.H7(7)
S10_DPS_S49: P7.H11(11)
S10_DPS_S50: P7.G4(4)
S10_DPS_S51: P7.G8(8)
S10_DPS_S52: P7.G12(12)
S10_DPS_S53: P7.F3(3)
S10_DPS_S54: P7.F7(7)
S10_DPS_S55: P7.F11(11)
S10_DPS_S56: P7.E4(4)
S10_DPS_S57: P7.E8(8)
S10_DPS_S58: P7.E12(12)
S10_DPS_S59: P7.D3(3)
S10_DPS_S60: P7.D7(7)
S10_DPS_S61: P7.D11(11)
S10_DPS_S62: P7.C4(4)
S10_DPS_S63: P7.C8(8)
S10_DPS_UB0: P7.A4(4)
S10_DPS_UB1: P1.L5(5)
S10_DPS_UB2: P1.M6(6)
S10_DPS_UB3: P1.L7(7)
S10_DPS_UB4: P1.M8(8)
S10_DPS_UB5: P1.L9(9)
S10_DPS_UB6: P1.M10(10)
S10_DPS_UB7: P1.L11(11)
S11_DPS_DGS32: P11.Z3(3)
S11_DPS_DGS33: P11.Z7(7)
S11_DPS_DGS34: P11.Z11(11)
S11_DPS_DGS35: P11.Y2(2)
S11_DPS_DGS36: P11.Y6(6)
S11_DPS_DGS37: P11.Y10(10)
S11_DPS_DGS38: P11.X3(3)
S11_DPS_DGS39: P11.X7(7)
S11_DPS_DGS40: P11.X11(11)
S11_DPS_DGS41: P11.W2(2)
S11_DPS_DGS42: P11.W6(6)
S11_DPS_DGS43: P11.W10(10)
S11_DPS_DGS44: P11.V3(3)
S11_DPS_DGS45: P11.V7(7)
S11_DPS_DGS46: P11.V11(11)
S11_DPS_DGS47: P11.U2(2)
S11_DPS_DGS48: P11.U6(6)
S11_DPS_DGS49: P11.U10(10)
S11_DPS_DGS50: P11.T3(3)
S11_DPS_DGS51: P11.T7(7)
S11_DPS_DGS52: P11.T11(11)
S11_DPS_DGS53: P11.S2(2)
S11_DPS_DGS54: P11.S6(6)
S11_DPS_DGS55: P11.S10(10)
S11_DPS_DGS56: P11.R3(3)
S11_DPS_DGS57: P11.R7(7)
S11_DPS_DGS58: P11.R11(11)
S11_DPS_DGS59: P11.Q2(2)
S11_DPS_DGS60: P11.Q6(6)
S11_DPS_DGS61: P11.Q10(10)
S11_DPS_DGS62: P11.P3(3)
S11_DPS_DGS63: P11.P7(7)
S11_DPS_F32: P11.Z2(2)
S11_DPS_F33: P11.Z6(6)
S11_DPS_F34: P11.Z10(10)
S11_DPS_F35: P11.Y1(1)
S11_DPS_F36: P11.Y5(5)
S11_DPS_F37: P11.Y9(9)
S11_DPS_F38: P11.X2(2)
S11_DPS_F39: P11.X6(6)
S11_DPS_F40: P11.X10(10)
S11_DPS_F41: P11.W1(1)
S11_DPS_F42: P11.W5(5)
S11_DPS_F43: P11.W9(9)
S11_DPS_F44: P11.V2(2)
S11_DPS_F45: P11.V6(6)
S11_DPS_F46: P11.V10(10)
S11_DPS_F47: P11.U1(1)
S11_DPS_F48: P11.U5(5)
S11_DPS_F49: P11.U9(9)
S11_DPS_F50: P11.T2(2)
S11_DPS_F51: P11.T6(6)
S11_DPS_F52: P11.T10(10)
S11_DPS_F53: P11.S1(1)
S11_DPS_F54: P11.S5(5)
S11_DPS_F55: P11.S9(9)
S11_DPS_F56: P11.R2(2)
S11_DPS_F57: P11.R6(6)
S11_DPS_F58: P11.R10(10)
S11_DPS_F59: P11.Q1(1)
S11_DPS_F60: P11.Q5(5)
S11_DPS_F61: P11.Q9(9)
S11_DPS_F62: P11.P2(2)
S11_DPS_F63: P11.P6(6)
S11_DPS_S32: P11.Z4(4)
S11_DPS_S33: P11.Z8(8)
S11_DPS_S34: P11.Z12(12)
S11_DPS_S35: P11.Y3(3)
S11_DPS_S36: P11.Y7(7)
S11_DPS_S37: P11.Y11(11)
S11_DPS_S38: P11.X4(4)
S11_DPS_S39: P11.X8(8)
S11_DPS_S40: P11.X12(12)
S11_DPS_S41: P11.W3(3)
S11_DPS_S42: P11.W7(7)
S11_DPS_S43: P11.W11(11)
S11_DPS_S44: P11.V4(4)
S11_DPS_S45: P11.V8(8)
S11_DPS_S46: P11.V12(12)
S11_DPS_S47: P11.U3(3)
S11_DPS_S48: P11.U7(7)
S11_DPS_S49: P11.U11(11)
S11_DPS_S50: P11.T4(4)
S11_DPS_S51: P11.T8(8)
S11_DPS_S52: P11.T12(12)
S11_DPS_S53: P11.S3(3)
S11_DPS_S54: P11.S7(7)
S11_DPS_S55: P11.S11(11)
S11_DPS_S56: P11.R4(4)
S11_DPS_S57: P11.R8(8)
S11_DPS_S58: P11.R12(12)
S11_DPS_S59: P11.Q3(3)
S11_DPS_S60: P11.Q7(7)
S11_DPS_S61: P11.Q11(11)
S11_DPS_S62: P11.P4(4)
S11_DPS_S63: P11.P8(8)
S11_DPS_UB0: P11.N4(4)
S23_DPS_DGS00: P4.A3(3)
S23_DPS_DGS01: P4.A7(7)
S23_DPS_DGS02: P4.A11(11)
S23_DPS_DGS03: P4.B2(2)
S23_DPS_DGS04: P4.B6(6)
S23_DPS_DGS05: P4.B10(10)
S23_DPS_DGS06: P4.C3(3)
S23_DPS_DGS07: P4.C7(7)
S23_DPS_DGS08: P4.C11(11)
S23_DPS_DGS09: P4.D2(2)
S23_DPS_DGS10: P4.D6(6)
S23_DPS_DGS11: P4.D10(10)
S23_DPS_DGS12: P4.E3(3)
S23_DPS_DGS13: P4.E7(7)
S23_DPS_DGS14: P4.E11(11)
S23_DPS_DGS15: P4.F2(2)
S23_DPS_DGS16: P4.F6(6)
S23_DPS_DGS17: P4.F10(10)
S23_DPS_DGS18: P4.G3(3)
S23_DPS_DGS19: P4.G7(7)
S23_DPS_DGS20: P4.G11(11)
S23_DPS_DGS21: P4.H2(2)
S23_DPS_DGS22: P4.H6(6)
S23_DPS_DGS23: P4.H10(10)
S23_DPS_DGS24: P4.I3(3)
S23_DPS_DGS25: P4.I7(7)
S23_DPS_DGS26: P4.I11(11)
S23_DPS_DGS27: P4.J2(2)
S23_DPS_DGS28: P4.J6(6)
S23_DPS_DGS29: P4.J10(10)
S23_DPS_DGS30: P4.K3(3)
S23_DPS_DGS31: P4.K7(7)
S23_DPS_F00: P4.A2(2)
S23_DPS_F01: P4.A6(6)
S23_DPS_F02: P4.A10(10)
S23_DPS_F03: P4.B1(1)
S23_DPS_F04: P4.B5(5)
S23_DPS_F05: P4.B9(9)
S23_DPS_F06: P4.C2(2)
S23_DPS_F07: P4.C6(6)
S23_DPS_F08: P4.C10(10)
S23_DPS_F09: P4.D1(1)
S23_DPS_F10: P4.D5(5)
S23_DPS_F11: P4.D9(9)
S23_DPS_F12: P4.E2(2)
S23_DPS_F13: P4.E6(6)
S23_DPS_F14: P4.E10(10)
S23_DPS_F15: P4.F1(1)
S23_DPS_F16: P4.F5(5)
S23_DPS_F17: P4.F9(9)
S23_DPS_F18: P4.G2(2)
S23_DPS_F19: P4.G6(6)
S23_DPS_F20: P4.G10(10)
S23_DPS_F21: P4.H1(1)
S23_DPS_F22: P4.H5(5)
S23_DPS_F23: P4.H9(9)
S23_DPS_F24: P4.I2(2)
S23_DPS_F25: P4.I6(6)
S23_DPS_F26: P4.I10(10)
S23_DPS_F27: P4.J1(1)
S23_DPS_F28: P4.J5(5)
S23_DPS_F29: P4.J9(9)
S23_DPS_F30: P4.K2(2)
S23_DPS_F31: P4.K6(6)
S23_DPS_S00: P4.A4(4)
S23_DPS_S01: P4.A8(8)
S23_DPS_S02: P4.A12(12)
S23_DPS_S03: P4.B3(3)
S23_DPS_S04: P4.B7(7)
S23_DPS_S05: P4.B11(11)
S23_DPS_S06: P4.C4(4)
S23_DPS_S07: P4.C8(8)
S23_DPS_S08: P4.C12(12)
S23_DPS_S09: P4.D3(3)
S23_DPS_S10: P4.D7(7)
S23_DPS_S11: P4.D11(11)
S23_DPS_S12: P4.E4(4)
S23_DPS_S13: P4.E8(8)
S23_DPS_S14: P4.E12(12)
S23_DPS_S15: P4.F3(3)
S23_DPS_S16: P4.F7(7)
S23_DPS_S17: P4.F11(11)
S23_DPS_S18: P4.G4(4)
S23_DPS_S19: P4.G8(8)
S23_DPS_S20: P4.G12(12)
S23_DPS_S21: P4.H3(3)
S23_DPS_S22: P4.H7(7)
S23_DPS_S23: P4.H11(11)
S23_DPS_S24: P4.I4(4)
S23_DPS_S25: P4.I8(8)
S23_DPS_S26: P4.I12(12)
S23_DPS_S27: P4.J3(3)
S23_DPS_S28: P4.J7(7)
S23_DPS_S29: P4.J11(11)
S23_DPS_S30: P4.K4(4)
S23_DPS_S31: P4.K8(8)
S24_DPS_DGS00: P6.N3(3)
S24_DPS_DGS01: P6.N7(7)
S24_DPS_DGS02: P6.N11(11)
S24_DPS_DGS03: P6.O2(2)
S24_DPS_DGS04: P6.O6(6)
S24_DPS_DGS05: P6.O10(10)
S24_DPS_DGS06: P6.P3(3)
S24_DPS_DGS07: P6.P7(7)
S24_DPS_DGS08: P6.P11(11)
S24_DPS_DGS09: P6.Q2(2)
S24_DPS_DGS10: P6.Q6(6)
S24_DPS_DGS11: P6.Q10(10)
S24_DPS_DGS12: P6.R3(3)
S24_DPS_DGS13: P6.R7(7)
S24_DPS_DGS14: P6.R11(11)
S24_DPS_DGS15: P6.S2(2)
S24_DPS_DGS16: P6.S6(6)
S24_DPS_DGS17: P6.S10(10)
S24_DPS_DGS18: P6.T3(3)
S24_DPS_DGS19: P6.T7(7)
S24_DPS_DGS20: P6.T11(11)
S24_DPS_DGS21: P6.U2(2)
S24_DPS_DGS22: P6.U6(6)
S24_DPS_DGS23: P6.U10(10)
S24_DPS_DGS24: P6.V3(3)
S24_DPS_DGS25: P6.V7(7)
S24_DPS_DGS26: P6.V11(11)
S24_DPS_DGS27: P6.W2(2)
S24_DPS_DGS28: P6.W6(6)
S24_DPS_DGS29: P6.W10(10)
S24_DPS_DGS30: P6.X3(3)
S24_DPS_DGS31: P6.X7(7)
S24_DPS_F00: P6.N2(2)
S24_DPS_F01: P6.N6(6)
S24_DPS_F02: P6.N10(10)
S24_DPS_F03: P6.O1(1)
S24_DPS_F04: P6.O5(5)
S24_DPS_F05: P6.O9(9)
S24_DPS_F06: P6.P2(2)
S24_DPS_F07: P6.P6(6)
S24_DPS_F08: P6.P10(10)
S24_DPS_F09: P6.Q1(1)
S24_DPS_F10: P6.Q5(5)
S24_DPS_F11: P6.Q9(9)
S24_DPS_F12: P6.R2(2)
S24_DPS_F13: P6.R6(6)
S24_DPS_F14: P6.R10(10)
S24_DPS_F15: P6.S1(1)
S24_DPS_F16: P6.S5(5)
S24_DPS_F17: P6.S9(9)
S24_DPS_F18: P6.T2(2)
S24_DPS_F19: P6.T6(6)
S24_DPS_F20: P6.T10(10)
S24_DPS_F21: P6.U1(1)
S24_DPS_F22: P6.U5(5)
S24_DPS_F23: P6.U9(9)
S24_DPS_F24: P6.V2(2)
S24_DPS_F25: P6.V6(6)
S24_DPS_F26: P6.V10(10)
S24_DPS_F27: P6.W1(1)
S24_DPS_F28: P6.W5(5)
S24_DPS_F29: P6.W9(9)
S24_DPS_F30: P6.X2(2)
S24_DPS_F31: P6.X6(6)
S24_DPS_S00: P6.N4(4)
S24_DPS_S01: P6.N8(8)
S24_DPS_S02: P6.N12(12)
S24_DPS_S03: P6.O3(3)
S24_DPS_S04: P6.O7(7)
S24_DPS_S05: P6.O11(11)
S24_DPS_S06: P6.P4(4)
S24_DPS_S07: P6.P8(8)
S24_DPS_S08: P6.P12(12)
S24_DPS_S09: P6.Q3(3)
S24_DPS_S10: P6.Q7(7)
S24_DPS_S11: P6.Q11(11)
S24_DPS_S12: P6.R4(4)
S24_DPS_S13: P6.R8(8)
S24_DPS_S14: P6.R12(12)
S24_DPS_S15: P6.S3(3)
S24_DPS_S16: P6.S7(7)
S24_DPS_S17: P6.S11(11)
S24_DPS_S18: P6.T4(4)
S24_DPS_S19: P6.T8(8)
S24_DPS_S20: P6.T12(12)
S24_DPS_S21: P6.U3(3)
S24_DPS_S22: P6.U7(7)
S24_DPS_S23: P6.U11(11)
S24_DPS_S24: P6.V4(4)
S24_DPS_S25: P6.V8(8)
S24_DPS_S26: P6.V12(12)
S24_DPS_S27: P6.W3(3)
S24_DPS_S28: P6.W7(7)
S24_DPS_S29: P6.W11(11)
S24_DPS_S30: P6.X4(4)
S24_DPS_S31: P6.X8(8)
S0123_CBIT_001: K7.9(V-) SW1.7 UNK1K7.9 UNK2K7.9 UNK3K7.9
S0123_CBIT_002: K37.8(V-) SW7.2 UNK2K37.8
