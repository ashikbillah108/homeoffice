# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DGND: length 176.4
  TOP w0.249: 285.06,200.23 285.5,199.78 SITE0.30 ; SITE2.4 363.34,208.15 363.51,208.33 ; SITE3.99 404.45,210.03 ; SITE2.99 364.45,210.03 ; SITE0.99 284.45,210.03 ; SITE2.30 365.5,199.78 365.05,200.23 ; 285.06,260.23 285.5,259.78 SITE4.30 ; SITE5.30 325.5,259.78 325.05,260.23 ; SITE2.74 373.19,208.85 373.1,208.94 ; 365.05,260.23 365.5,259.78 SITE6.30 ; 283.51,268.33 283.34,268.15 SITE4.4 ; SITE5.4 323.34,268.15 323.51,268.33 ; SITE5.74 333.19,268.85 333.1,268.94 ; 283.51,208.33 283.34,208.15 SITE0.4 ; SITE3.4 403.34,208.15 403.51,208.33 ; SITE1.4 323.34,208.15 323.51,208.33 ; SITE7.99 404.45,270.03 ; SITE6.99 364.45,270.03 ; SITE4.74 293.19,268.85 293.1,268.94 ; 405.05,200.23 405.5,199.78 SITE3.30 ; SITE7.74 413.19,268.85 413.1,268.94 ; SITE4.99 284.45,270.03 ; SITE1.30 325.5,199.78 325.05,200.23 ; SITE3.74 413.19,208.85 413.1,208.94 ; SITE6.4 363.34,268.15 363.51,268.33 ; 333.1,208.94 333.19,208.85 SITE1.74 ; SITE6.74 373.19,268.85 373.1,268.94 ; SITE1.99 324.45,210.03 ; 405.05,260.23 405.5,259.78 SITE7.30 ; SITE7.4 403.34,268.15 403.51,268.33 ; SITE0.74 293.19,208.85 293.1,208.94 ; SITE5.99 324.45,270.03
  TOP w0.254: UNK3C107.2 417.25,204.79 ; UNK7C56.2 417.25,263.42 ; UNK1C56.2 337.25,203.42 ; UNK6C107.2 377.25,264.79 ; UNK7C107.2 417.25,264.79 ; UNK1C107.2 337.25,204.79 ; UNK7C75.2 417.25,260.67 ; UNK6C75.2 377.25,260.67 ; UNK3C75.2 417.25,200.67 ; UNK3C56.2 417.25,203.42 ; UNK5C56.2 337.25,263.42 ; UNK2C56.2 377.25,203.42 ; UNK2C75.2 377.25,200.67 ; C107.2 297.25,204.79 ; UNK6C56.2 377.25,263.42 ; UNK2C107.2 377.25,204.79 ; UNK4C75.2 297.25,260.67 ; C75.2 297.25,200.67 ; C56.2 297.25,203.42 ; UNK5C75.2 337.25,260.67 ; UNK4C56.2 297.25,263.42 ; UNK4C107.2 297.25,264.79 ; UNK5C107.2 337.25,264.79 ; UNK1C75.2 337.25,200.67
  TOP w0.381: 337.25,264.79 v1(337.69,264.79) ; UNK3C88.2 399.22,203.66 v1(398.83,203.66) ; v1(278.83,199.64) 279.19,199.64 C79.2 ; 364.45,270.03 v1(364.25,269.83) ; v1(278.83,203.66) 279.22,203.66 C88.2 ; v1(278.83,261.01) 279.11,261.29 UNK4C78.2 ; 403.51,208.33 v1(403.61,208.43) ; v1(398.83,260.33) 399.06,260.33 399.34,260.61 UNK7C64.2 ; 325.05,260.23 v1(325.05,260.36) ; 377.25,204.79 v1(377.69,204.79) ; 363.51,208.33 v1(363.61,208.43) ; 365.05,200.23 v1(365.05,200.36) ; UNK5C48.2 319.08,262.74 v1(318.83,263) ; 337.25,204.79 v1(337.69,204.79) ; v1(318.83,199.64) 319.19,199.64 UNK1C79.2 ; v1(398.83,200.33) 399.06,200.33 399.34,200.61 UNK3C64.2 ; 413.1,208.94 v1(413.05,208.99) ; 297.25,203.42 v1(297.69,203.42) ; UNK2C88.2 359.22,203.66 v1(358.83,203.66) ; UNK3C79.2 399.19,199.64 v1(398.83,199.64) ; UNK5C79.2 319.19,259.64 v1(318.83,259.64) ; v1(358.83,260.33) 359.06,260.33 359.34,260.61 UNK6C64.2 ; 297.25,260.67 v1(297.69,260.67) ; UNK2C48.2 359.08,202.74 v1(358.83,203) ; UNK7C79.2 399.19,259.64 v1(398.83,259.64) ; 417.25,203.42 v1(417.69,203.42) ; 363.51,268.33 v1(363.61,268.43) ; 417.25,264.79 v1(417.69,264.79) ; v1(318.83,203) 319.08,202.74 UNK1C48.2 ; v1(278.83,263.66) 279.22,263.66 UNK4C88.2 ; C78.2 279.11,201.29 v1(278.83,201.01) ; v1(358.83,263) 359.08,262.74 UNK6C48.2 ; 297.25,200.67 v1(297.69,200.67) ; 297.25,264.79 v1(297.69,264.79) ; v1(398.83,201.01) 399.11,201.29 UNK3C78.2 ; 333.1,268.94 v1(333.05,268.99) ; 323.51,268.33 v1(323.61,268.43) ; 373.1,208.94 v1(373.05,208.99) ; 405.05,200.23 v1(405.05,200.36) ; 377.25,200.67 v1(377.69,200.67) ; v1(318.83,261.01) 319.11,261.29 UNK5C78.2 ; UNK6C78.2 359.11,261.29 v1(358.83,261.01) ; v1(398.83,203) 399.08,202.74 UNK3C48.2 ; 293.1,208.94 v1(293.05,208.99) ; v1(358.83,200.33) 359.06,200.33 359.34,200.61 UNK2C64.2 ; 377.25,260.67 v1(377.69,260.67) ; v1(278.83,200.33) 279.06,200.33 279.34,200.61 C64.2 ; 404.45,270.03 v1(404.25,269.83) ; 337.25,200.67 v1(337.69,200.67) ; v1(278.83,203) 279.08,202.74 C48.2 ; v1(358.83,263.66) 359.22,263.66 UNK6C88.2 ; 284.45,210.03 v1(284.25,209.83) ; UNK6C79.2 359.19,259.64 v1(358.83,259.64) ; 417.25,200.67 v1(417.69,200.67) ; UNK4C79.2 279.19,259.64 v1(278.83,259.64) ; 377.25,203.42 v1(377.69,203.42) ; 417.25,204.79 v1(417.69,204.79) ; UNK4C64.2 279.34,260.61 279.06,260.33 v1(278.83,260.33) ; 337.25,260.67 v1(337.69,260.67) ; UNK7C48.2 399.08,262.74 v1(398.83,263) ; 417.25,263.42 v1(417.69,263.42) ; 403.51,268.33 v1(403.61,268.43) ; UNK4C48.2 279.08,262.74 v1(278.83,263) ; 285.06,200.23 v1(285.06,200.36) ; 405.05,260.23 v1(405.05,260.36) ; 283.51,208.33 v1(283.61,208.43) ; 377.25,263.42 v1(377.69,263.42) ; 377.25,264.79 v1(377.69,264.79) ; UNK7C78.2 399.11,261.29 v1(398.83,261.01) ; 325.05,200.23 v1(325.05,200.36) ; 283.51,268.33 v1(283.61,268.43) ; 364.45,210.03 v1(364.25,209.83) ; v1(318.83,200.33) 319.06,200.33 319.34,200.61 UNK1C64.2 ; 323.51,208.33 v1(323.61,208.43) ; 293.1,268.94 v1(293.05,268.99) ; 324.45,270.03 v1(324.25,269.83) ; 324.45,210.03 v1(324.25,209.83) ; v1(318.83,263.66) 319.22,263.66 UNK5C88.2 ; v1(398.83,263.66) 399.22,263.66 UNK7C88.2 ; UNK1C88.2 319.22,203.66 v1(318.83,203.66) ; 413.1,268.94 v1(413.05,268.99) ; UNK5C64.2 319.34,260.61 319.06,260.33 v1(318.83,260.33) ; v1(358.83,199.64) 359.19,199.64 UNK2C79.2 ; 297.25,204.79 v1(297.69,204.79) ; 365.05,260.23 v1(365.05,260.36) ; UNK1C78.2 319.11,201.29 v1(318.83,201.01) ; v1(358.83,201.01) 359.11,201.29 UNK2C78.2 ; 373.1,268.94 v1(373.05,268.99) ; 297.25,263.42 v1(297.69,263.42) ; 337.25,203.42 v1(337.69,203.42) ; 333.1,208.94 v1(333.05,208.99) ; 404.45,210.03 v1(404.25,209.83) ; 417.25,260.67 v1(417.69,260.67) ; 284.45,270.03 v1(284.25,269.83) ; 337.25,263.42 v1(337.69,263.42) ; 285.06,260.23 v1(285.06,260.36)
  TOP w0.508: v1(396.6,262.03) 395.21,262.03 UNK7Y1.2 ; UNK4Y1.2 275.21,262.03 v1(276.6,262.03) ; v1(316.6,262.03) 315.21,262.03 UNK5Y1.2 ; v1(396.6,202.03) 395.21,202.03 UNK3Y1.2 ; UNK3Y1.4 392.52,201.92 v1(392.41,201.81) ; v1(352.41,201.81) 352.52,201.92 UNK2Y1.4 ; v1(312.41,261.81) 312.52,261.92 UNK5Y1.4 ; Y1.2 275.21,202.03 v1(276.6,202.03) ; UNK7Y1.4 392.52,261.92 v1(392.41,261.81) ; UNK2Y1.2 355.21,202.03 v1(356.6,202.03) ; UNK6Y1.4 352.52,261.92 v1(352.41,261.81) ; v1(272.41,261.81) 272.52,261.92 UNK4Y1.4 ; UNK6Y1.2 355.21,262.03 v1(356.6,262.03) ; v1(272.41,201.81) 272.52,201.92 Y1.4 ; v1(316.6,202.03) 315.21,202.03 UNK1Y1.2 ; v1(312.41,201.81) 312.52,201.92 UNK1Y1.4
  TOP w0.61: C146.1 187.43,177.57 v2(189.98,177.57) ; C145.1 187.43,174.37 v2(189.98,174.37) ; C147.1 187.43,167.11 v2(189.98,167.11) ; C148.1 187.43,170.31 v2(189.98,170.31)
  BOTTOM w0.203: v2(479.01,172.7) UNK7C94.2 v2(479.01,170.92)
  BOTTOM w0.254: UNK7C153.2 411.54,265.24 SITE7.G19 ; UNK6C153.2 371.54,265.24 SITE6.G19 ; UT1.2 v2(295.31,71.58) ; UNK4C153.2 291.54,265.24 SITE4.G19 ; CB668.1 v2(339.69,98.38) ; UT1.5 v2(294.66,69.68) ; CB634.2 v2(20.79,339.1) ; SITE5.G19 331.54,265.24 UNK5C153.2 ; SITE0.G19 291.54,205.24 C153.2 ; CB657.1 v2(204.46,107.27) ; CB637.2 v2(29.18,381.01) ; CB698.1 v2(476.08,98.38) ; UT1.1 v2(294.66,73.46) ; UNK1C153.2 331.54,205.24 SITE1.G19 ; SITE2.G19 371.54,205.24 UNK2C153.2 ; CB672.1 v2(332.71,107.27) ; CB650.1 v2(208.68,87.9) ; CB695.1 v2(473.3,87.9) ; CB638.2 v2(30.45,361.32) ; CB653.1 v2(211.45,98.38) ; CB647.2 v2(35.21,374.02) ; CB641.2 v2(36.8,391.8) ; CB665.1 v2(336.92,87.9) ; CB702.1 v2(469.09,107.27) ; UNK3C153.2 411.54,205.24 SITE3.G19
  BOTTOM w0.305: v1(407.78,257.45) 407.98,257.64 UNK7C91.2 ; UNK2C91.2 367.98,197.64 v1(367.78,197.45) ; v1(287.78,257.45) 287.98,257.64 UNK4C91.2 ; UNK5C91.2 327.98,257.64 v1(327.78,257.45) ; C91.2 287.98,197.64 v1(287.78,197.45) ; v1(407.78,197.45) 407.98,197.64 UNK3C91.2 ; UNK6C91.2 367.98,257.64 v1(367.78,257.45) ; UNK1C91.2 327.98,197.64 v1(327.78,197.45)
  BOTTOM w0.508: UNK1U3.4 v2(239.78,211.99) ; U3.4 v2(239.78,177.7) ; UNK4U3.4 v2(239.78,246.28) ; v1(422.96,204.64) UNK3C113.1 ; v1(302.96,204.64) C113.1 ; UNK6U3.4 v2(456.82,292.3) ; UNK2U3.4 v2(456.82,223.72) ; v1(422.96,264.64) UNK7C113.1 ; v1(382.96,264.64) UNK6C113.1 ; v1(342.96,264.64) UNK5C113.1 ; v1(302.96,264.64) UNK4C113.1 ; UNK3U3.4 v2(456.82,189.43) ; v1(382.96,204.64) UNK2C113.1 ; UNK5U3.4 v2(239.78,280.57) ; v1(342.96,204.64) UNK1C113.1 ; UNK7U3.4 v2(456.82,258.01)
  vias: v1(267.75,266.99) v1(267.75,206.99) v1(268.58,276.76) v1(268.58,274.73) v1(268.58,216.76) v1(268.58,214.73) v1(268.88,266.99) v1(268.88,206.99) v1(270.03,266.99) v1(270.03,206.99) v1(271.19,257.09) v1(271.19,197.09) v1(272.41,262.91) v1(272.41,202.91) v1(272.79,258.83) v1(272.79,198.83) v1(272.86,260.41) v1(272.86,200.41) v1(273.56,264.04) v1(273.56,204.04) v1(273.76,266.99) v1(273.76,265.15) v1(273.76,206.99) v1(273.76,205.15) v1(273.98,259.88) v1(273.98,199.88) v1(274.8,288.95) v1(274.85,257.76) v1(274.8,228.96) v1(274.85,197.76) v1(274.97,264.04) v1(274.97,204.04) v1(275.92,271.63) v1(275.92,211.63) v1(276.49,284.61) v1(276.49,224.61) v1(276.6,263.91) v1(276.6,260.14) v1(276.6,203.91) v1(276.6,200.14) v1(276.81,266.99) v1(276.81,206.99) v1(277.51,263.76) v1(277.51,203.76) v1(277.77,261.01) v1(277.77,201.01) v1(278.79,284.61) v1(278.83,267.8) v1(278.79,224.61) v1(278.83,207.8) v1(279.34,270.08) v1(279.34,210.08) v1(280.01,256.1) v1(280.01,196.1) v1(280.89,251.38) v1(280.89,191.38) v1(281.83,250.38) v1(281.83,190.38) v1(282.77,252.44) v1(282.77,192.44) v1(283.05,255.69) v1(283.01,249.65) v1(283.05,195.69) v1(283.01,189.65) v1(283.66,274.37) v1(283.66,214.37) v1(284.36,266.35) v1(284.36,265.5) v1(284.36,264.65) v1(284.36,206.35) v1(284.36,205.5) v1(284.36,204.65) v1(285.72,275.76) v1(285.72,215.76) v1(285.76,261.21) v1(285.76,201.21) v1(286.58,261.21) v1(286.58,201.21) v1(286.72,286.38) v1(286.72,226.38) v1(286.94,268.97) v1(286.94,208.97) v1(287.07,280.27) v1(287.08,278.11) v1(287.07,220.27) v1(287.08,218.11) v1(287.36,261.21) v1(287.36,201.21) v1(287.84,287.89) v1(287.84,286.38) v1(287.84,227.89) v1(287.84,226.38) v1(287.88,268.97) v1(287.88,208.97) v1(288.09,261.21) v1(288.09,201.21) v1(288.82,268.99) v1(288.82,208.99) v1(288.95,286.38) v1(288.95,226.38) v1(289.67,268.99) v1(289.67,208.99) v1(292.2,267.4) v1(292.21,265.91) v1(292.2,264.49) v1(292.21,263.7) v1(292.21,262.19) v1(292.2,207.4) v1(292.21,205.91) v1(292.2,204.49) v1(292.21,203.7) v1(292.21,202.19) v1(292.41,268.99) v1(292.41,208.99) v1(292.94,273.89) v1(292.94,213.89) v1(293.38,275.76) v1(293.38,215.76) v1(294.05,260.2) v1(294.05,259.35) v1(294.05,257.97) v1(294.05,257.12) v1(294.1,254.23) v1(294.05,200.2) v1(294.05,199.35) v1(294.05,197.97) v1(294.05,197.12) v1(294.1,194.23) v1(296.19,258.66) v1(296.19,255.29) v1(296.19,198.66) v1(296.19,195.29) v1(296.53,286.38) v1(296.53,226.38) v1(297.65,286.38) v1(297.69,268.9) v1(297.69,267.53) v1(297.65,226.38) v1(297.69,208.9) v1(297.69,207.53) v1(298.32,258.66) v1(298.32,257.57) v1(298.32,198.66) v1(298.32,197.57) v1(298.77,286.38) v1(298.77,226.38) v1(299.6,272.38) v1(299.6,271.34) v1(299.6,212.38) v1(299.6,211.34) v1(300.3,291.43) v1(300.3,286.44) v1(300.3,231.43) v1(300.3,226.44) v1(301.67,265.74) v1(301.67,205.74) v1(307.75,266.99) v1(307.75,206.99) v1(308.58,276.76) v1(308.58,274.73) v1(308.58,216.76) v1(308.58,214.73) v1(308.88,266.99) v1(308.88,206.99) v1(310.03,266.99) v1(310.03,206.99) v1(311.19,257.09) v1(311.19,197.09) v1(312.41,262.91) v1(312.41,202.91) v1(312.79,258.83) v1(312.79,198.83) v1(312.86,260.41) v1(312.86,200.41) v1(313.56,264.04) v1(313.56,204.04) v1(313.76,266.99) v1(313.76,265.15) v1(313.76,206.99) v1(313.76,205.15) v1(313.98,259.88) v1(313.98,199.88) v1(314.8,288.95) v1(314.85,257.76) v1(314.8,228.96) v1(314.85,197.76) v1(314.97,264.04) v1(314.97,204.04) v1(315.92,271.63) v1(315.92,211.63) v1(316.49,284.61) v1(316.49,224.61) v1(316.6,263.91) v1(316.6,260.14) v1(316.6,203.91) v1(316.6,200.14) v1(316.81,266.99) v1(316.81,206.99) v1(317.51,263.76) v1(317.51,203.76) v1(317.77,261.01) v1(317.77,201.01) v1(318.79,284.61) v1(318.83,267.8) v1(318.79,224.61) v1(318.83,207.8) v1(319.34,270.08) v1(319.34,210.08) v1(320.01,256.1) v1(320.01,196.1) v1(320.89,251.38) v1(320.89,191.38) v1(321.83,250.38) v1(321.83,190.38) v1(322.77,252.44) v1(322.77,192.44) v1(323.05,255.69) v1(323.01,249.65) v1(323.05,195.69) v1(323.01,189.65) v1(323.66,274.37) v1(323.66,214.37) v1(324.36,266.35) v1(324.36,265.5) v1(324.36,264.65) v1(324.36,206.35) v1(324.36,205.5) v1(324.36,204.65) v1(325.72,275.76) v1(325.72,215.76) v1(325.76,261.21) v1(325.76,201.21) v1(326.58,261.21) v1(326.58,201.21) v1(326.72,286.38) v1(326.72,226.38) v1(326.94,268.97) v1(326.94,208.97) v1(327.07,280.27) v1(327.08,278.11) v1(327.07,220.27) v1(327.08,218.11) v1(327.36,261.21) v1(327.36,201.21) v1(327.84,287.89) v1(327.84,286.38) v1(327.84,227.89) v1(327.84,226.38) v1(327.88,268.97) v1(327.88,208.97) v1(328.09,261.21) v1(328.09,201.21) v1(328.82,268.99) v1(328.82,208.99) v1(328.95,286.38) v1(328.95,226.38) v1(329.67,268.99) v1(329.67,208.99) v1(332.2,267.4) v1(332.21,265.91) v1(332.2,264.49) v1(332.21,263.7) v1(332.21,262.19) v1(332.2,207.4) v1(332.21,205.91) v1(332.2,204.49) v1(332.21,203.7) v1(332.21,202.19) v1(332.4,268.99) v1(332.4,208.99) v1(332.94,273.89) v1(332.94,213.89) v1(333.38,275.76) v1(333.38,215.76) v1(334.05,260.2) v1(334.05,259.35) v1(334.05,257.97) v1(334.05,257.12) v1(334.1,254.23) v1(334.05,200.2) v1(334.05,199.35) v1(334.05,197.97) v1(334.05,197.12) v1(334.1,194.23) v1(336.19,258.66) v1(336.19,255.29) v1(336.19,198.66) v1(336.19,195.29) v1(336.53,286.38) v1(336.53,226.38) v1(337.65,286.38) v1(337.69,268.9) v1(337.69,267.53) v1(337.65,226.38) v1(337.69,208.9) v1(337.69,207.53) v1(338.32,258.66) v1(338.32,257.57) v1(338.32,198.66) v1(338.32,197.57) v1(338.77,286.38) v1(338.77,226.38) v1(339.6,272.38) v1(339.6,271.34) v1(339.6,212.38) v1(339.6,211.34) v1(340.29,286.44) v1(340.29,231.43) v1(340.29,226.44) v1(341.67,265.74) v1(341.67,205.74) v1(347.75,266.99) v1(347.75,206.99) v1(348.58,276.76) v1(348.58,274.73) v1(348.58,216.76) v1(348.58,214.73) v1(348.88,266.99) v1(348.88,206.99) v1(350.03,266.99) v1(350.03,206.99) v1(351.19,257.09) v1(351.19,197.09) v1(352.41,262.91) v1(352.41,202.91) v1(352.79,258.83) v1(352.79,198.83) v1(352.86,260.41) v1(352.86,200.41) v1(353.56,264.04) v1(353.56,204.04) v1(353.76,266.99) v1(353.76,265.15) v1(353.76,206.99) v1(353.76,205.15) v1(353.98,259.88) v1(353.98,199.88) v1(354.8,288.95) v1(354.85,257.76) v1(354.8,228.96) v1(354.85,197.76) v1(354.97,264.04) v1(354.97,204.04) v1(355.92,271.63) v1(355.92,211.63) v1(356.49,284.61) v1(356.49,224.61) v1(356.6,263.91) v1(356.6,260.14) v1(356.6,203.91) v1(356.6,200.14) v1(356.81,266.99) v1(356.81,206.99) v1(357.51,263.76) v1(357.51,203.76) v1(357.77,261.01) v1(357.77,201.01) v1(358.79,284.61) v1(358.83,267.8) v1(358.79,224.61) v1(358.83,207.8) v1(359.34,270.08) v1(359.34,210.08) v1(360.01,256.1) v1(360.01,196.1) v1(360.89,251.38) v1(360.89,191.38) v1(361.83,250.38) v1(361.83,190.38) v1(362.77,252.44) v1(362.77,192.44) v1(363.05,255.69) v1(363.01,249.65) v1(363.05,195.69) v1(363.01,189.65) v1(363.66,274.37) v1(363.66,214.37) v1(364.36,266.35) v1(364.36,265.5) v1(364.36,264.65) v1(364.36,206.35) v1(364.36,205.5) v1(364.36,204.65) v1(365.72,275.76) v1(365.72,215.76) v1(365.76,261.21) v1(365.76,201.21) v1(366.58,261.21) v1(366.58,201.21) v1(366.72,286.38) v1(366.72,226.38) v1(366.94,268.97) v1(366.94,208.97) v1(367.07,280.27) v1(367.08,278.11) v1(367.07,220.27) v1(367.08,218.11) v1(367.36,261.21) v1(367.36,201.21) v1(367.84,287.89) v1(367.84,286.38) v1(367.84,227.89) v1(367.84,226.38) v1(367.88,268.97) v1(367.88,208.97) v1(368.09,261.21) v1(368.09,201.21) v1(368.82,268.99) v1(368.82,208.99) v1(368.95,286.38) v1(368.95,226.38) v1(369.67,268.99) v1(369.67,208.99) v1(372.2,267.4) v1(372.21,265.91) v1(372.2,264.49) v1(372.21,263.7) v1(372.21,262.19) v1(372.2,207.4) v1(372.21,205.91) v1(372.2,204.49) v1(372.21,203.7) v1(372.21,202.19) v1(372.4,268.99) v1(372.4,208.99) v1(372.94,273.89) v1(372.94,213.89) v1(373.38,275.76) v1(373.38,215.76) v1(374.05,260.2) v1(374.05,259.35) v1(374.05,257.97) v1(374.05,257.12) v1(374.1,254.23) v1(374.05,200.2) v1(374.05,199.35) v1(374.05,197.97) v1(374.05,197.12) v1(374.1,194.23) v1(376.19,258.66) v1(376.19,255.29) v1(376.19,198.66) v1(376.19,195.29) v1(376.53,286.38) v1(376.53,226.38) v1(377.65,286.38) v1(377.69,268.9) v1(377.69,267.53) v1(377.65,226.38) v1(377.69,208.9) v1(377.69,207.53) v1(378.32,258.66) v1(378.32,257.57) v1(378.32,198.66) v1(378.32,197.57) v1(378.77,286.38) v1(378.77,226.38) v1(379.6,272.38) v1(379.6,271.34) v1(379.6,212.38) v1(379.6,211.34) v1(380.29,291.43) v1(380.29,286.44) v1(380.29,231.43) v1(380.29,226.44) v1(381.67,265.74) v1(381.67,205.74) v1(387.75,266.99) v1(387.75,206.99) v1(388.58,276.76) v1(388.58,274.73) v1(388.58,216.76) v1(388.58,214.73) v1(388.88,266.99) v1(388.88,206.99) v1(390.03,266.99) v1(390.03,206.99) v1(391.19,257.09) v1(391.19,197.09) v1(392.41,262.91) v1(392.41,202.91) v1(392.79,258.83) v1(392.79,198.83) v1(392.86,260.41) v1(392.86,200.41) v1(393.56,264.04) v1(393.56,204.04) v1(393.76,266.99) v1(393.76,265.15) v1(393.76,206.99) v1(393.76,205.15) v1(393.98,259.88) v1(393.98,199.88) v1(394.8,288.95) v1(394.85,257.76) v1(394.8,228.96) v1(394.85,197.76) v1(394.97,264.04) v1(394.97,204.04) v1(395.92,271.63) v1(395.92,211.63) v1(396.49,284.61) v1(396.49,224.61) v1(396.6,263.91) v1(396.6,260.14) v1(396.6,203.91) v1(396.6,200.14) v1(396.81,266.99) v1(396.81,206.99) v1(397.51,263.76) v1(397.51,203.76) v1(397.77,261.01) v1(397.77,201.01) v1(398.79,284.61) v1(398.83,267.8) v1(398.79,224.61) v1(398.83,207.8) v1(399.34,270.08) v1(399.34,210.08) v1(400.01,256.1) v1(400.01,196.1) v1(400.89,251.38) v1(400.89,191.38) v1(401.83,250.38) v1(401.83,190.38) v1(402.77,252.44) v1(402.77,192.44) v1(403.05,255.69) v1(403.01,249.65) v1(403.05,195.69) v1(403.01,189.65) v1(403.66,274.37) v1(403.66,214.37) v1(404.36,266.35) v1(404.36,265.5) v1(404.36,264.65) v1(404.36,206.35) v1(404.36,205.5) v1(404.36,204.65) v1(405.72,275.76) v1(405.72,215.76) v1(405.76,261.21) v1(405.76,201.21) v1(406.58,261.21) v1(406.58,201.21) v1(406.72,286.38) v1(406.72,226.38) v1(406.94,268.97) v1(406.94,208.97) v1(407.07,280.27) v1(407.08,278.11) v1(407.07,220.27) v1(407.08,218.11) v1(407.36,261.21) v1(407.36,201.21) v1(407.84,287.89) v1(407.84,286.38) v1(407.84,227.89) v1(407.84,226.38) v1(407.88,268.97) v1(407.88,208.97) v1(408.09,261.21) v1(408.09,201.21) v1(408.82,268.99) v1(408.82,208.99) v1(408.95,286.38) v1(408.95,226.38) v1(409.67,268.99) v1(409.67,208.99) v1(412.2,267.4) v1(412.21,265.91) v1(412.2,264.49) v1(412.21,263.7) v1(412.21,262.19) v1(412.2,207.4) v1(412.21,205.91) v1(412.2,204.49) v1(412.21,203.7) v1(412.21,202.19) v1(412.4,268.99) v1(412.4,208.99) v1(412.94,273.89) v1(412.94,213.89) v1(413.38,275.76) v1(413.38,215.76) v1(414.05,260.2) v1(414.05,259.35) v1(414.05,257.97) v1(414.05,257.12) v1(414.1,254.23) v1(414.05,200.2) v1(414.05,199.35) v1(414.05,197.97) v1(414.05,197.12) v1(414.1,194.23) v1(416.19,258.66) v1(416.19,255.29) v1(416.19,198.66) v1(416.19,195.29) v1(416.53,286.38) v1(416.53,226.38) v1(417.65,286.38) v1(417.69,268.9) v1(417.69,267.53) v1(417.65,226.38) v1(417.69,208.9) v1(417.69,207.53) v1(418.32,258.66) v1(418.32,257.57) v1(418.32,198.66) v1(418.32,197.57) v1(418.77,286.38) v1(418.77,226.38) v1(419.6,272.38) v1(419.6,271.34) v1(419.6,212.38) v1(419.6,211.34) v1(420.29,291.43) v1(420.29,286.44) v1(420.29,231.43) v1(420.29,226.44) v1(421.67,265.74) v1(421.67,205.74) v2(4.55,465.54) v2(4.55,460.46) v2(4.55,455.38) v2(4.55,450.3) v2(4.55,445.22) v2(4.55,440.14) v2(4.55,435.06) v2(4.55,429.98) v2(4.55,424.9) v2(4.55,419.82) v2(4.55,414.74) v2(4.55,409.66) v2(4.55,404.58) v2(4.55,399.5) v2(4.55,394.42) v2(4.55,389.34) v2(4.55,384.26) v2(4.55,379.18) v2(4.55,374.1) v2(4.55,369.02) v2(4.55,363.94) v2(4.55,358.86) v2(4.55,353.78) v2(4.55,348.7) v2(4.55,343.62) v2(4.55,338.54) v2(4.55,333.46) v2(4.55,328.38) v2(4.55,323.3) v2(4.55,145.5) v2(4.55,140.42) v2(4.55,135.34) v2(4.55,130.26) v2(4.55,125.18) v2(4.55,120.1) v2(4.55,115.02) v2(4.55,109.94) v2(4.55,104.86) v2(4.55,99.78) v2(4.55,94.7) v2(4.55,89.62) v2(4.55,84.54) v2(4.55,79.46) v2(4.55,74.38) v2(4.55,69.3) v2(4.55,64.22) v2(4.55,59.14) v2(4.55,54.06) v2(4.55,48.98) v2(4.55,43.9) v2(4.55,38.82) v2(4.55,33.74) v2(4.55,28.66) v2(4.55,23.58) v2(4.55,18.5) v2(4.55,13.42) v2(4.55,8.34) v2(4.55,3.26) v2(9.63,465.54) v2(9.63,460.46) v2(9.63,455.38) v2(9.63,450.3) v2(9.63,445.22) v2(9.63,440.14) v2(9.63,435.06) v2(9.63,429.98) v2(9.63,424.9) v2(9.63,419.82) v2(9.63,414.74) v2(9.63,409.66) v2(9.63,404.58) v2(9.63,399.5) v2(9.63,394.42) v2(9.63,389.34) v2(9.63,384.26) v2(9.63,379.18) v2(9.63,374.1) v2(9.63,369.02) v2(9.63,363.94) v2(9.63,358.86) v2(9.63,353.78) v2(9.63,348.7) v2(9.63,343.62) v2(9.63,338.54) v2(9.63,333.46) v2(9.63,328.38) v2(9.63,323.3) v2(9.63,145.5) v2(9.63,140.42) v2(9.63,135.34) v2(9.63,130.26) v2(9.63,125.18) v2(9.63,120.1) v2(9.63,115.02) v2(9.63,109.94) v2(9.63,104.86) v2(9.63,99.78) v2(9.63,94.7) v2(9.63,89.62) v2(9.63,84.54) v2(9.63,79.46) v2(9.63,74.38) v2(9.63,69.3) v2(9.63,64.22) v2(9.63,59.14) v2(9.63,54.06) v2(9.63,48.98) v2(9.63,43.9) v2(9.63,38.82) v2(9.63,33.74) v2(9.63,28.66) v2(9.63,23.58) v2(9.63,18.5) v2(9.63,13.42) v2(9.63,8.34) v2(9.63,3.26) v2(14.49,379.36) v2(14.49,377.58) v2(14.49,359.04) v2(14.49,357.26) v2(14.71,465.54) v2(14.71,460.46) v2(14.71,409.66) v2(14.71,404.58) v2(14.71,394.42) v2(14.71,389.34) v2(14.71,384.26) v2(14.71,374.1) v2(14.71,369.02) v2(14.71,363.94) v2(14.71,353.78) v2(14.71,348.7) v2(14.71,343.62) v2(14.71,338.54) v2(14.71,328.38) v2(14.71,323.3) v2(14.71,145.5) v2(14.71,140.42) v2(14.71,135.34) v2(14.71,130.26) v2(14.71,125.18) v2(14.71,120.1) v2(14.71,115.02) v2(14.71,109.94) v2(14.71,104.86) v2(14.71,99.78) v2(14.71,94.7) v2(14.71,89.62) v2(14.71,84.54) v2(14.71,79.46) v2(14.71,74.38) v2(14.71,69.3) v2(14.71,64.22) v2(14.71,59.14) v2(14.71,54.06) v2(14.71,48.98) v2(14.71,43.9) v2(14.71,38.82) v2(14.71,33.74) v2(14.71,28.66) v2(14.71,23.58) v2(14.71,18.5) v2(14.71,13.42) v2(14.71,8.34) v2(14.71,3.26) v2(19.79,465.54) v2(19.79,460.46) v2(19.79,409.66) v2(19.79,404.58) v2(19.79,399.5) v2(19.79,394.42) v2(19.79,389.34) v2(19.79,384.26) v2(19.79,379.18) v2(19.79,374.1) v2(19.79,369.02) v2(19.79,363.94) v2(19.79,353.78) v2(19.79,348.7) v2(19.79,343.62) v2(19.79,333.46) v2(19.79,328.38) v2(19.79,323.3) v2(19.79,145.5) v2(19.79,140.42) v2(19.79,135.34) v2(19.79,130.26) v2(19.79,125.18) v2(19.79,120.1) v2(19.79,115.02) v2(19.79,109.94) v2(19.79,104.86) v2(19.79,99.78) v2(19.79,94.7) v2(19.79,89.62) v2(19.79,84.54) v2(19.79,79.46) v2(19.79,74.38) v2(19.79,69.3) v2(19.79,64.22) v2(19.79,59.14) v2(19.79,54.06) v2(19.79,48.98) v2(19.79,43.9) v2(19.79,38.82) v2(19.79,33.74) v2(19.79,28.66) v2(19.79,23.58) v2(19.79,18.5) v2(19.79,13.42) v2(19.79,8.34) v2(19.79,3.26) v2(24.87,465.54) v2(24.87,460.46) v2(24.87,409.66) v2(24.87,404.58) v2(24.87,399.5) v2(24.87,394.42) v2(24.87,389.34) v2(24.87,384.26) v2(24.87,369.02) v2(24.87,363.94) v2(24.87,333.46) v2(24.87,328.38) v2(24.87,323.3) v2(24.87,145.5) v2(24.87,140.42) v2(24.87,135.34) v2(24.87,130.26) v2(24.87,125.18) v2(24.87,120.1) v2(24.87,115.02) v2(24.87,109.94) v2(24.87,104.86) v2(24.87,99.78) v2(24.87,94.7) v2(24.87,89.62) v2(24.87,84.54) v2(24.87,79.46) v2(24.87,74.38) v2(24.87,69.3) v2(24.87,64.22) v2(24.87,59.14) v2(24.87,54.06) v2(24.87,48.98) v2(24.87,43.9) v2(24.87,38.82) v2(24.87,33.74) v2(24.87,28.66) v2(24.87,23.58) v2(24.87,18.5) v2(24.87,13.42) v2(24.87,8.34) v2(24.87,3.26) v2(25.88,374.66) v2(29.82,339.1) v2(29.95,465.54) v2(29.95,460.46) v2(29.95,455.38) v2(29.95,450.3) v2(29.95,429.98) v2(29.95,424.9) v2(29.95,419.82) v2(29.95,414.74) v2(29.95,409.66) v2(29.95,404.58) v2(29.95,399.5) v2(29.95,394.42) v2(29.95,333.46) v2(29.95,328.38) v2(29.95,323.3) v2(29.95,145.5) v2(29.95,140.42) v2(29.95,135.34) v2(29.95,130.26) v2(29.95,125.18) v2(29.95,120.1) v2(29.95,115.02) v2(29.95,109.94) v2(29.95,104.86) v2(29.95,99.78) v2(29.95,94.7) v2(29.95,89.62) v2(29.95,84.54) v2(29.95,79.46) v2(29.95,74.38) v2(29.95,69.3) v2(29.95,64.22) v2(29.95,59.14) v2(29.95,54.06) v2(29.95,48.98) v2(29.95,43.9) v2(29.95,38.82) v2(29.95,33.74) v2(29.95,28.66) v2(29.95,23.58) v2(29.95,18.5) v2(29.95,13.42) v2(29.95,8.34) v2(29.95,3.26) v2(33.29,359.04) v2(33.29,357.26) v2(34.3,352.69) v2(34.3,350.91) v2(34.3,345.07) v2(34.3,343.29) v2(35.03,465.54) v2(35.03,460.46) v2(35.03,455.38) v2(35.03,450.3) v2(35.03,429.98) v2(35.03,424.9) v2(35.03,419.82) v2(35.03,414.74) v2(35.03,409.66) v2(35.03,404.58) v2(35.03,399.5) v2(35.03,394.42) v2(35.03,338.54) v2(35.03,328.38) v2(35.03,323.3) v2(35.03,145.5) v2(35.03,140.42) v2(35.03,135.34) v2(35.03,130.26) v2(35.03,125.18) v2(35.03,120.1) v2(35.03,115.02) v2(35.03,109.94) v2(35.03,104.86) v2(35.03,99.78) v2(35.03,94.7) v2(35.03,89.62) v2(35.03,84.54) v2(35.03,79.46) v2(35.03,74.38) v2(35.03,69.3) v2(35.03,64.22) v2(35.03,59.14) v2(35.03,54.06) v2(35.03,48.98) v2(35.03,43.9) v2(35.03,38.82) v2(35.03,33.74) v2(35.03,28.66) v2(35.03,23.58) v2(35.03,18.5) v2(35.03,13.42) v2(35.03,8.34) v2(35.03,3.26) v2(38.08,389.26) v2(39,371.74) v2(39,369.96) v2(40.11,465.54) v2(40.11,460.46) v2(40.11,455.38) v2(40.11,450.3) v2(40.11,429.98) v2(40.11,424.9) v2(40.11,419.82) v2(40.11,414.74) v2(40.11,409.66) v2(40.11,404.58) v2(40.11,394.42) v2(40.11,379.18) v2(40.11,374.1) v2(40.11,358.86) v2(40.11,353.78) v2(40.11,348.7) v2(40.11,343.62) v2(40.11,338.54) v2(40.11,333.46) v2(40.11,328.38) v2(40.11,323.3) v2(40.11,145.5) v2(40.11,140.42) v2(40.11,135.34) v2(40.11,130.26) v2(40.11,125.18) v2(40.11,120.1) v2(40.11,115.02) v2(40.11,109.94) v2(40.11,104.86) v2(40.11,99.78) v2(40.11,94.7) v2(40.11,89.62) v2(40.11,84.54) v2(40.11,79.46) v2(40.11,74.38) v2(40.11,69.3) v2(40.11,64.22) v2(40.11,59.14) v2(40.11,54.06) v2(40.11,48.98) v2(40.11,43.9) v2(40.11,38.82) v2(40.11,33.74) v2(40.11,28.66) v2(40.11,23.58) v2(40.11,18.5) v2(40.11,13.42) v2(40.11,8.34) v2(40.11,3.26) v2(41.29,385.07) v2(41.29,383.29) v2(41.29,366.02) v2(41.29,364.24) v2(45.19,465.54) v2(45.19,460.46) v2(45.19,455.38) v2(45.19,450.3) v2(45.19,445.22) v2(45.19,440.14) v2(45.19,435.06) v2(45.19,429.98) v2(45.19,424.9) v2(45.19,419.82) v2(45.19,414.74) v2(45.19,409.66) v2(45.19,404.58) v2(45.19,399.5) v2(45.19,394.42) v2(45.19,389.34) v2(45.19,384.26) v2(45.19,379.18) v2(45.19,374.1) v2(45.19,369.02) v2(45.19,363.94) v2(45.19,358.86) v2(45.19,353.78) v2(45.19,348.7) v2(45.19,343.62) v2(45.19,338.54) v2(45.19,333.46) v2(45.19,328.38) v2(45.19,323.3) v2(45.19,145.5) v2(45.19,140.42) v2(45.19,135.34) v2(45.19,130.26) v2(45.19,125.18) v2(45.19,120.1) v2(45.19,115.02) v2(45.19,109.94) v2(45.19,104.86) v2(45.19,99.78) v2(45.19,94.7) v2(45.19,89.62) v2(45.19,84.54) v2(45.19,79.46) v2(45.19,74.38) v2(45.19,69.3) v2(45.19,64.22) v2(45.19,59.14) v2(45.19,54.06) v2(45.19,48.98) v2(45.19,43.9) v2(45.19,38.82) v2(45.19,33.74) v2(45.19,28.66) v2(45.19,23.58) v2(45.19,18.5) v2(45.19,13.42) v2(45.19,8.34) v2(45.19,3.26) v2(121.39,399.5) v2(121.39,394.42) v2(121.39,389.34) v2(121.39,384.26) v2(121.39,379.18) v2(121.39,374.1) v2(121.39,369.02) v2(121.39,363.94) v2(121.39,358.86) v2(121.39,353.78) v2(121.39,348.7) v2(121.39,343.62) v2(121.39,338.54) v2(121.39,333.46) v2(121.39,328.38) v2(121.39,323.3) v2(121.39,318.22) v2(121.39,313.14) v2(121.39,308.06) v2(121.39,302.98) v2(121.39,297.9) v2(121.39,292.82) v2(121.39,287.74) v2(121.39,282.66) v2(121.39,277.58) v2(121.39,272.5) v2(121.39,267.42) v2(121.39,262.34) v2(121.39,257.26) v2(121.39,252.18) v2(121.39,247.1) v2(121.39,242.02) v2(121.39,236.94) v2(121.39,231.86) v2(121.39,226.78) v2(121.39,221.7) v2(121.39,216.62) v2(121.39,211.54) v2(121.39,206.46) v2(121.39,201.38) v2(121.39,196.3) v2(121.39,191.22) v2(121.39,186.14) v2(121.39,181.06) v2(121.39,175.98) v2(121.39,170.9) v2(121.39,165.82) v2(121.39,160.74) v2(121.39,155.66) v2(121.39,150.58) v2(121.39,145.5) v2(121.39,140.42) v2(121.39,135.34) v2(121.39,130.26) v2(121.39,125.18) v2(121.39,120.1) v2(121.39,115.02) v2(121.39,109.94) v2(121.39,104.86) v2(121.39,99.78) v2(121.39,94.7) v2(121.39,89.62) v2(121.39,84.54) v2(121.39,79.46) v2(121.39,74.38) v2(121.39,69.3) v2(126.47,399.5) v2(126.47,394.42) v2(126.47,363.94) v2(126.47,358.86) v2(126.47,353.78) v2(126.47,348.7) v2(126.47,343.62) v2(126.47,338.54) v2(126.47,333.46) v2(126.47,328.38) v2(126.47,323.3) v2(126.47,318.22) v2(126.47,313.14) v2(126.47,308.06) v2(126.47,302.98) v2(126.47,297.9) v2(126.47,292.82) v2(126.47,287.74) v2(126.47,282.66) v2(126.47,277.58) v2(126.47,272.5) v2(126.47,267.42) v2(126.47,262.34) v2(126.47,257.26) v2(126.47,252.18) v2(126.47,247.1) v2(126.47,242.02) v2(126.47,231.86) v2(126.47,226.78) v2(126.47,221.7) v2(126.47,216.62) v2(126.47,211.54) v2(126.47,206.46) v2(126.47,201.38) v2(126.47,196.3) v2(126.47,191.22) v2(126.47,186.14) v2(126.47,181.06) v2(126.47,175.98) v2(126.47,170.9) v2(126.47,165.82) v2(126.47,160.74) v2(126.47,155.66) v2(126.47,150.58) v2(126.47,145.5) v2(126.47,140.42) v2(126.47,135.34) v2(126.47,130.26) v2(126.47,125.18) v2(126.47,120.1) v2(126.47,115.02) v2(126.47,109.94) v2(126.47,104.86) v2(126.47,99.78) v2(126.47,94.7) v2(126.47,89.62) v2(126.47,84.54) v2(126.47,79.46) v2(126.47,74.38) v2(126.47,69.3) v2(131.55,399.5) v2(131.55,394.42) v2(131.55,363.94) v2(131.55,358.86) v2(131.55,353.78) v2(131.55,348.7) v2(131.55,343.62) v2(131.55,338.54) v2(131.55,333.46) v2(131.55,328.38) v2(131.55,323.3) v2(131.55,318.22) v2(131.55,313.14) v2(131.55,308.06) v2(131.55,302.98) v2(131.55,297.9) v2(131.55,292.82) v2(131.55,287.74) v2(131.55,282.66) v2(131.55,277.58) v2(131.55,272.5) v2(131.55,267.42) v2(131.55,262.34) v2(131.55,257.26) v2(131.55,252.18) v2(131.55,247.1) v2(131.55,242.02) v2(131.55,236.94) v2(131.55,231.86) v2(131.55,226.78) v2(131.55,221.7) v2(131.55,216.62) v2(131.55,211.54) v2(131.55,206.46) v2(131.55,201.38) v2(131.55,196.3) v2(131.55,191.22) v2(131.55,186.14) v2(131.55,181.06) v2(131.55,175.98) v2(131.55,170.9) v2(131.55,165.82) v2(131.55,160.74) v2(131.55,155.66) v2(131.55,150.58) v2(131.55,145.5) v2(131.55,140.42) v2(131.55,135.34) v2(131.55,130.26) v2(131.55,125.18) v2(131.55,120.1) v2(131.55,115.02) v2(131.55,109.94) v2(131.55,104.86) v2(131.55,99.78) v2(131.55,94.7) v2(131.55,89.62) v2(131.55,84.54) v2(131.55,79.46) v2(131.55,74.38) v2(131.55,69.3) v2(136.63,399.5) v2(136.63,394.42) v2(136.63,363.94) v2(136.63,358.86) v2(136.63,353.78) v2(136.63,348.7) v2(136.63,343.62) v2(136.63,338.54) v2(136.63,333.46) v2(136.63,328.38) v2(136.63,323.3) v2(136.63,318.22) v2(136.63,313.14) v2(136.63,308.06) v2(136.63,302.98) v2(136.63,297.9) v2(136.63,292.82) v2(136.63,287.74) v2(136.63,282.66) v2(136.63,277.58) v2(136.63,272.5) v2(136.63,267.42) v2(136.63,262.34) v2(136.63,257.26) v2(136.63,252.18) v2(136.63,247.1) v2(136.63,242.02) v2(136.63,236.94) v2(136.63,231.86) v2(136.63,226.78) v2(136.63,221.7) v2(136.63,216.62) v2(136.63,211.54) v2(136.63,206.46) v2(136.63,201.38) v2(136.63,196.3) v2(136.63,191.22) v2(136.63,186.14) v2(136.63,181.06) v2(136.63,175.98) v2(136.63,170.9) v2(136.63,165.82) v2(136.63,160.74) v2(136.63,155.66) v2(136.63,150.58) v2(136.63,145.5) v2(136.63,140.42) v2(136.63,135.34) v2(136.63,130.26) v2(136.63,125.18) v2(136.63,120.1) v2(136.63,115.02) v2(136.63,109.94) v2(136.63,104.86) v2(136.63,99.78) v2(136.63,94.7) v2(136.63,89.62) v2(136.63,84.54) v2(136.63,79.46) v2(136.63,74.38) v2(136.63,69.3) v2(141.71,399.5) v2(141.71,394.42) v2(141.71,363.94) v2(141.71,358.86) v2(141.71,353.78) v2(141.71,348.7) v2(141.71,343.62) v2(141.71,338.54) v2(141.71,333.46) v2(141.71,328.38) v2(141.71,323.3) v2(141.71,318.22) v2(141.71,313.14) v2(141.71,308.06) v2(141.71,302.98) v2(141.71,297.9) v2(141.71,292.82) v2(141.71,287.74) v2(141.71,282.66) v2(141.71,277.58) v2(141.71,272.5) v2(141.71,267.42) v2(141.71,262.34) v2(141.71,257.26) v2(141.71,252.18) v2(141.71,247.1) v2(141.71,242.02) v2(141.71,236.94) v2(141.71,231.86) v2(141.71,226.78) v2(141.71,221.7) v2(141.71,216.62) v2(141.71,211.54) v2(141.71,206.46) v2(141.71,201.38) v2(141.71,196.3) v2(141.71,191.22) v2(141.71,186.14) v2(141.71,181.06) v2(141.71,175.98) v2(141.71,170.9) v2(141.71,165.82) v2(141.71,160.74) v2(141.71,155.66) v2(141.71,150.58) v2(141.71,145.5) v2(141.71,140.42) v2(141.71,135.34) v2(141.71,130.26) v2(141.71,125.18) v2(141.71,120.1) v2(141.71,115.02) v2(141.71,109.94) v2(141.71,104.86) v2(141.71,99.78) v2(141.71,94.7) v2(141.71,89.62) v2(141.71,84.54) v2(141.71,79.46) v2(141.71,69.3) v2(146.79,399.5) v2(146.79,394.42) v2(146.79,363.94) v2(146.79,358.86) v2(146.79,353.78) v2(146.79,348.7) v2(146.79,343.62) v2(146.79,338.54) v2(146.79,333.46) v2(146.79,328.38) v2(146.79,323.3) v2(146.79,318.22) v2(146.79,313.14) v2(146.79,308.06) v2(146.79,302.98) v2(146.79,297.9) v2(146.79,292.82) v2(146.79,287.74) v2(146.79,282.66) v2(146.79,277.58) v2(146.79,272.5) v2(146.79,267.42) v2(146.79,262.34) v2(146.79,257.26) v2(146.79,252.18) v2(146.79,247.1) v2(146.79,242.02) v2(146.79,236.94) v2(146.79,231.86) v2(146.79,226.78) v2(146.79,221.7) v2(146.79,216.62) v2(146.79,211.54) v2(146.79,206.46) v2(146.79,201.38) v2(146.79,196.3) v2(146.79,191.22) v2(146.79,186.14) v2(146.79,181.06) v2(146.79,175.98) v2(146.79,170.9) v2(146.79,165.82) v2(146.79,160.74) v2(146.79,155.66) v2(146.79,150.58) v2(146.79,145.5) v2(146.79,140.42) v2(146.79,135.34) v2(146.79,130.26) v2(146.79,125.18) v2(146.79,120.1) v2(146.79,115.02) v2(146.79,109.94) v2(146.79,104.86) v2(146.79,99.78) v2(146.79,94.7) v2(146.79,89.62) v2(146.79,84.54) v2(146.79,79.46) v2(146.79,74.38) v2(146.79,69.3) v2(151.87,399.5) v2(151.87,384.26) v2(151.87,379.18) v2(151.87,374.1) v2(151.87,369.02) v2(151.87,363.94) v2(151.87,358.86) v2(151.87,353.78) v2(151.87,348.7) v2(151.87,343.62) v2(151.87,338.54) v2(151.87,333.46) v2(151.87,328.38) v2(151.87,323.3) v2(151.87,318.22) v2(151.87,313.14) v2(151.87,302.98) v2(151.87,297.9) v2(151.87,287.74) v2(151.87,282.66) v2(151.87,277.58) v2(151.87,272.5) v2(151.87,267.42) v2(151.87,262.34) v2(151.87,257.26) v2(151.87,252.18) v2(151.87,247.1) v2(151.87,242.02) v2(151.87,236.94) v2(151.87,231.86) v2(151.87,226.78) v2(151.87,221.7) v2(151.87,216.62) v2(151.87,211.54) v2(151.87,206.46) v2(151.87,201.38) v2(151.87,196.3) v2(151.87,191.22) v2(151.87,186.14) v2(151.87,181.06) v2(151.87,175.98) v2(151.87,170.9) v2(151.87,160.74) v2(151.87,155.66) v2(151.87,150.58) v2(151.87,145.5) v2(151.87,140.42) v2(151.87,135.34) v2(151.87,130.26) v2(151.87,125.18) v2(151.87,120.1) v2(151.87,115.02) v2(151.87,109.94) v2(151.87,104.86) v2(151.87,99.78) v2(151.87,94.7) v2(151.87,89.62) v2(151.87,84.54) v2(151.87,79.46) v2(151.87,74.38) v2(151.87,69.3) v2(154.91,393.19) v2(156.95,399.5) v2(156.95,389.34) v2(156.95,384.26) v2(156.95,379.18) v2(156.95,374.1) v2(156.95,369.02) v2(156.95,363.94) v2(156.95,358.86) v2(156.95,353.78) v2(156.95,348.7) v2(156.95,343.62) v2(156.95,338.54) v2(156.95,333.46) v2(156.95,328.38) v2(156.95,323.3) v2(156.95,318.22) v2(156.95,313.14) v2(156.95,308.06) v2(156.95,302.98) v2(156.95,165.82) v2(156.95,160.74) v2(156.95,155.66) v2(156.95,150.58) v2(156.95,145.5) v2(156.95,140.42) v2(156.95,135.34) v2(156.95,130.26) v2(156.95,125.18) v2(156.95,120.1) v2(156.95,115.02) v2(156.95,109.94) v2(156.95,104.86) v2(156.95,99.78) v2(156.95,94.7) v2(156.95,89.62) v2(156.95,84.54) v2(156.95,79.46) v2(157.57,71.63) v2(162.03,399.5) v2(162.03,389.34) v2(162.03,384.26) v2(162.03,379.18) v2(162.03,374.1) v2(162.03,369.02) v2(162.03,363.94) v2(162.03,358.86) v2(162.03,353.78) v2(162.03,348.7) v2(162.03,343.62) v2(162.03,338.54) v2(162.03,333.46) v2(162.03,328.38) v2(162.03,323.3) v2(162.03,318.22) v2(162.03,313.14) v2(162.03,308.06) v2(162.03,302.98) v2(162.03,297.9) v2(162.03,292.82) v2(162.03,287.74) v2(162.03,282.66) v2(162.03,277.58) v2(162.03,272.5) v2(162.03,267.42) v2(162.03,262.34) v2(162.03,257.26) v2(162.03,252.18) v2(162.03,247.1) v2(162.03,242.02) v2(162.03,236.94) v2(162.03,231.86) v2(162.03,226.78) v2(162.03,221.7) v2(162.03,216.62) v2(162.03,211.54) v2(162.03,206.46) v2(162.03,201.38) v2(162.03,196.3) v2(162.03,191.22) v2(162.03,186.14) v2(162.03,181.06) v2(162.03,175.98) v2(162.03,170.9) v2(162.03,165.82) v2(162.03,160.74) v2(162.03,155.66) v2(162.03,150.58) v2(162.03,145.5) v2(162.03,140.42) v2(162.03,135.34) v2(162.03,130.26) v2(162.03,125.18) v2(162.03,120.1) v2(162.03,115.02) v2(162.03,109.94) v2(162.03,104.86) v2(162.03,99.78) v2(162.03,94.7) v2(162.03,89.62) v2(162.03,84.54) v2(162.03,79.46) v2(165.07,393.19) v2(167.11,399.5) v2(167.11,389.34) v2(167.11,384.26) v2(167.11,379.18) v2(167.11,374.1) v2(167.11,369.02) v2(167.11,363.94) v2(167.11,358.86) v2(167.11,353.78) v2(167.11,348.7) v2(167.11,343.62) v2(167.11,338.54) v2(167.11,333.46) v2(167.11,328.38) v2(167.11,323.3) v2(167.11,318.22) v2(167.11,313.14) v2(167.11,308.06) v2(167.11,302.98) v2(167.11,297.9) v2(167.11,292.82) v2(167.11,287.74) v2(167.11,282.66) v2(167.11,277.58) v2(167.11,272.5) v2(167.11,267.42) v2(167.11,262.34) v2(167.11,257.26) v2(167.11,252.18) v2(167.11,247.1) v2(167.11,242.02) v2(167.11,236.94) v2(167.11,231.86) v2(167.11,226.78) v2(167.11,221.7) v2(167.11,216.62) v2(167.11,211.54) v2(167.11,206.46) v2(167.11,201.38) v2(167.11,196.3) v2(167.11,191.22) v2(167.11,186.14) v2(167.11,181.06) v2(167.11,175.98) v2(167.11,170.9) v2(167.11,165.82) v2(167.11,160.74) v2(167.11,155.66) v2(167.11,150.58) v2(167.11,145.5) v2(167.11,140.42) v2(167.11,135.34) v2(167.11,104.86) v2(167.11,99.78) v2(167.11,94.7) v2(167.11,89.62) v2(167.11,84.54) v2(167.11,79.46) v2(167.73,71.63) v2(172.19,399.5) v2(172.19,394.42) v2(172.19,389.34) v2(172.19,384.26) v2(172.19,379.18) v2(172.19,374.1) v2(172.19,369.02) v2(172.19,363.94) v2(172.19,358.86) v2(172.19,353.78) v2(172.19,348.7) v2(172.19,343.62) v2(172.19,338.54) v2(172.19,333.46) v2(172.19,328.38) v2(172.19,323.3) v2(172.19,318.22) v2(172.19,313.14) v2(172.19,308.06) v2(172.19,302.98) v2(172.19,297.9) v2(172.19,292.82) v2(172.19,287.74) v2(172.19,282.66) v2(172.19,277.58) v2(172.19,272.5) v2(172.19,267.42) v2(172.19,262.34) v2(172.19,257.26) v2(172.19,252.18) v2(172.19,247.1) v2(172.19,242.02) v2(172.19,236.94) v2(172.19,231.86) v2(172.19,226.78) v2(172.19,221.7) v2(172.19,216.62) v2(172.19,211.54) v2(172.19,206.46) v2(172.19,201.38) v2(172.19,196.3) v2(172.19,191.22) v2(172.19,186.14) v2(172.19,181.06) v2(172.19,175.98) v2(172.19,170.9) v2(172.19,165.82) v2(172.19,160.74) v2(172.19,155.66) v2(172.19,150.58) v2(172.19,145.5) v2(172.19,140.42) v2(172.19,135.34) v2(172.19,104.86) v2(172.19,99.78) v2(172.19,94.7) v2(172.19,89.62) v2(172.19,84.54) v2(172.19,79.46) v2(172.19,74.38) v2(172.19,69.3) v2(177.27,399.5) v2(177.27,394.42) v2(177.27,389.34) v2(177.27,384.26) v2(177.27,379.18) v2(177.27,374.1) v2(177.27,369.02) v2(177.27,363.94) v2(177.27,358.86) v2(177.27,353.78) v2(177.27,348.7) v2(177.27,343.62) v2(177.27,338.54) v2(177.27,333.46) v2(177.27,328.38) v2(177.27,323.3) v2(177.27,318.22) v2(177.27,313.14) v2(177.27,308.06) v2(177.27,160.74) v2(177.27,155.66) v2(177.27,150.58) v2(177.27,145.5) v2(177.27,140.42) v2(177.27,135.34) v2(177.27,104.86) v2(177.27,99.78) v2(177.27,94.7) v2(177.27,89.62) v2(177.27,84.54) v2(177.27,79.46) v2(177.27,74.38) v2(177.27,69.3) v2(182.35,399.5) v2(182.35,394.42) v2(182.35,389.34) v2(182.35,384.26) v2(182.35,379.18) v2(182.35,374.1) v2(182.35,369.02) v2(182.35,363.94) v2(182.35,358.86) v2(182.35,353.78) v2(182.35,348.7) v2(182.35,323.3) v2(182.35,318.22) v2(182.35,313.14) v2(182.35,308.06) v2(182.35,160.74) v2(182.35,155.66) v2(182.35,150.58) v2(182.35,145.5) v2(182.35,140.42) v2(182.35,135.34) v2(182.35,104.86) v2(182.35,99.78) v2(182.35,94.7) v2(182.35,89.62) v2(182.35,84.54) v2(182.35,79.46) v2(182.35,74.38) v2(182.35,69.3) v2(187.11,289.4) v2(187.11,286.2) v2(187.11,280.77) v2(187.11,277.57) v2(187.11,273.5) v2(187.11,270.3) v2(187.11,255.11) v2(187.11,251.91) v2(187.11,246.48) v2(187.11,243.28) v2(187.11,239.21) v2(187.11,236.01) v2(187.11,220.82) v2(187.11,217.62) v2(187.11,212.19) v2(187.11,208.99) v2(187.11,204.92) v2(187.11,201.72) v2(187.11,186.53) v2(187.11,183.33) v2(187.43,399.5) v2(187.43,394.42) v2(187.43,389.34) v2(187.43,384.26) v2(187.43,379.18) v2(187.43,374.1) v2(187.43,369.02) v2(187.43,363.94) v2(187.43,358.86) v2(187.43,353.78) v2(187.43,348.7) v2(187.43,323.3) v2(187.43,318.22) v2(187.43,313.14) v2(187.43,308.06) v2(187.43,160.74) v2(187.43,155.66) v2(187.43,150.58) v2(187.43,145.5) v2(187.43,140.42) v2(187.43,135.34) v2(187.43,104.86) v2(187.43,99.78) v2(187.43,94.7) v2(187.43,89.62) v2(187.43,84.54) v2(187.43,79.46) v2(187.43,74.38) v2(187.43,69.3) v2(187.89,342.83) v2(192.51,399.5) v2(192.51,394.42) v2(192.51,389.34) v2(192.51,384.26) v2(192.51,379.18) v2(192.51,374.1) v2(192.51,369.02) v2(192.51,363.94) v2(192.51,358.86) v2(192.51,353.78) v2(192.51,348.7) v2(192.51,323.3) v2(192.51,318.22) v2(192.51,313.14) v2(192.51,308.06) v2(192.51,160.74) v2(192.51,155.66) v2(192.51,150.58) v2(192.51,145.5) v2(192.51,140.42) v2(192.51,135.34) v2(192.51,130.26) v2(192.51,125.18) v2(192.51,120.1) v2(192.51,115.02) v2(192.51,109.94) v2(192.51,104.86) v2(192.51,99.78) v2(192.51,94.7) v2(192.51,89.62) v2(192.51,84.54) v2(192.51,79.46) v2(192.51,74.38) v2(192.51,69.3) v2(197.59,399.5) v2(197.59,394.42) v2(197.59,389.34) v2(197.59,384.26) v2(197.59,379.18) v2(197.59,374.1) v2(197.59,369.02) v2(197.59,363.94) v2(197.59,358.86) v2(197.59,353.78) v2(197.59,348.7) v2(197.59,323.3) v2(197.59,318.22) v2(197.59,313.14) v2(197.59,308.06) v2(197.59,160.74) v2(197.59,155.66) v2(197.59,150.58) v2(197.59,145.5) v2(197.59,140.42) v2(197.59,104.86) v2(197.59,99.78) v2(197.59,94.7) v2(197.59,89.62) v2(197.59,84.54) v2(197.59,79.46) v2(197.59,74.38) v2(197.59,69.3) v2(202.67,399.5) v2(202.67,394.42) v2(202.67,389.34) v2(202.67,384.26) v2(202.67,379.18) v2(202.67,374.1) v2(202.67,369.02) v2(202.67,363.94) v2(202.67,358.86) v2(202.67,353.78) v2(202.67,348.7) v2(202.67,323.3) v2(202.67,318.22) v2(202.67,313.14) v2(202.67,308.06) v2(202.67,160.74) v2(202.67,155.66) v2(202.67,150.58) v2(202.67,145.5) v2(202.67,140.42) v2(202.67,84.54) v2(202.67,79.46) v2(202.67,74.38) v2(202.67,69.3) v2(204.21,90.67) v2(205.73,106.76) v2(205.99,90.67) v2(207.75,399.5) v2(207.75,394.42) v2(207.75,389.34) v2(207.75,384.26) v2(207.75,379.18) v2(207.75,374.1) v2(207.75,369.02) v2(207.75,363.94) v2(207.75,358.86) v2(207.75,353.78) v2(207.75,348.7) v2(207.75,323.3) v2(207.75,318.22) v2(207.75,313.14) v2(207.75,308.06) v2(207.75,160.74) v2(207.75,155.66) v2(207.75,150.58) v2(207.75,145.5) v2(207.75,140.42) v2(207.75,84.54) v2(207.75,79.46) v2(207.75,74.38) v2(207.75,69.3) v2(210.18,97.87) v2(210.81,93.05) v2(210.81,91.53) v2(212.08,92.29) v2(212.08,84.8) v2(212.67,124.04) v2(212.83,399.5) v2(212.83,394.42) v2(212.83,389.34) v2(212.83,353.78) v2(212.83,348.7) v2(212.83,343.62) v2(212.83,338.54) v2(212.83,333.46) v2(212.83,328.38) v2(212.83,323.3) v2(212.83,318.22) v2(212.83,313.14) v2(212.83,308.06) v2(212.84,292.71) v2(212.84,285.44) v2(212.84,258.42) v2(212.84,251.15) v2(212.84,224.13) v2(212.84,216.86) v2(212.84,189.84) v2(212.84,182.57) v2(212.83,160.74) v2(212.83,155.66) v2(212.83,150.58) v2(212.83,145.5) v2(212.83,140.42) v2(212.83,104.86) v2(212.83,79.46) v2(212.83,74.38) v2(212.83,69.3) v2(213.15,381.09) v2(213.15,378.53) v2(213.15,375.96) v2(213.35,93.05) v2(213.35,91.53) v2(213.35,84.8) v2(214.18,94.91) v2(215.24,292.71) v2(215.24,285.44) v2(215.24,258.42) v2(215.24,251.15) v2(215.24,224.13) v2(215.24,216.86) v2(215.24,189.84) v2(215.24,182.57) v2(215.89,93.06) v2(215.89,91.52) v2(216.91,300.19) v2(216.91,231.61) v2(217.91,399.5) v2(217.91,394.42) v2(217.91,389.34) v2(217.91,353.78) v2(217.91,348.7) v2(217.91,343.62) v2(217.91,338.54) v2(217.91,333.46) v2(217.91,328.38) v2(217.91,323.3) v2(217.91,318.22) v2(217.91,313.14) v2(217.91,308.06) v2(217.91,160.74) v2(217.91,155.66) v2(217.91,150.58) v2(217.91,145.5) v2(217.91,140.42) v2(217.91,104.86) v2(217.91,79.46) v2(217.91,74.38) v2(217.91,69.3) v2(218.53,297.65) v2(218.53,295.88) v2(218.53,229.07) v2(218.53,227.3) v2(220.35,378.02) v2(220.92,282.88) v2(220.92,270.62) v2(220.92,248.59) v2(220.92,236.33) v2(220.92,214.3) v2(220.92,202.04) v2(220.92,180.01) v2(220.92,167.75) v2(222.99,399.5) v2(222.99,394.42) v2(222.99,389.34) v2(222.99,353.78) v2(222.99,348.7) v2(222.99,343.62) v2(222.99,338.54) v2(222.99,333.46) v2(222.99,328.38) v2(222.99,323.3) v2(222.99,318.22) v2(222.99,313.14) v2(222.99,308.06) v2(222.99,160.74) v2(222.99,155.66) v2(222.99,150.58) v2(222.99,145.5) v2(222.99,140.42) v2(222.99,135.34) v2(222.99,130.26) v2(222.99,125.18) v2(222.99,120.1) v2(222.99,115.02) v2(222.99,109.94) v2(222.99,104.86) v2(222.99,79.46) v2(222.99,74.38) v2(222.99,69.3) v2(224.26,293.82) v2(224.26,259.53) v2(224.26,225.24) v2(224.26,190.95) v2(224.89,282.88) v2(224.89,270.62) v2(224.89,248.59) v2(224.89,236.33) v2(224.89,214.3) v2(224.89,202.04) v2(224.89,180.01) v2(224.89,167.75) v2(225.41,293.74) v2(225.41,259.45) v2(225.41,225.16) v2(225.41,190.87) v2(226.69,84.8) v2(228.07,399.5) v2(228.07,394.42) v2(228.07,389.34) v2(228.07,353.78) v2(228.07,348.7) v2(228.07,343.62) v2(228.07,338.54) v2(228.07,333.46) v2(228.07,328.38) v2(228.07,323.3) v2(228.07,318.22) v2(228.07,313.14) v2(228.07,308.06) v2(228.07,160.74) v2(228.07,155.66) v2(228.07,150.58) v2(228.07,145.5) v2(228.07,140.42) v2(228.07,135.34) v2(228.07,130.26) v2(228.07,125.18) v2(228.07,120.1) v2(228.07,115.02) v2(228.07,109.94) v2(228.07,104.86) v2(228.07,79.46) v2(228.07,74.38) v2(228.07,69.3) v2(228.59,84.8) v2(230.88,97.79) v2(232.66,97.79) v2(233.15,399.5) v2(233.15,394.42) v2(233.15,389.34) v2(233.15,369.02) v2(233.15,363.94) v2(233.15,358.86) v2(233.15,353.78) v2(233.15,348.7) v2(233.15,343.62) v2(233.15,338.54) v2(233.15,333.46) v2(233.15,328.38) v2(233.15,323.3) v2(233.15,318.22) v2(233.15,313.14) v2(233.15,308.06) v2(233.15,160.74) v2(233.15,155.66) v2(233.15,150.58) v2(233.15,145.5) v2(233.15,140.42) v2(233.15,135.34) v2(233.15,130.26) v2(233.15,125.18) v2(233.15,120.1) v2(233.15,115.02) v2(233.15,109.94) v2(233.15,104.86) v2(233.15,79.46) v2(233.15,74.38) v2(233.15,69.3) v2(235.06,381.46) v2(236.6,97.79) v2(238.23,399.5) v2(238.23,394.42) v2(238.23,389.34) v2(238.23,369.02) v2(238.23,363.94) v2(238.23,358.86) v2(238.23,353.78) v2(238.23,348.7) v2(238.23,343.62) v2(238.23,338.54) v2(238.23,333.46) v2(238.23,328.38) v2(238.23,323.3) v2(238.23,318.22) v2(238.23,313.14) v2(238.23,308.06) v2(238.23,160.74) v2(238.23,155.66) v2(238.23,150.58) v2(238.23,145.5) v2(238.23,140.42) v2(238.23,135.34) v2(238.23,130.26) v2(238.23,125.18) v2(238.23,120.1) v2(238.23,115.02) v2(238.23,109.94) v2(238.23,104.86) v2(238.23,79.46) v2(238.23,74.38) v2(238.23,69.3) v2(238.37,97.79) v2(238.69,299.97) v2(238.69,298.19) v2(238.67,273.21) v2(238.69,265.68) v2(238.69,263.9) v2(238.67,238.92) v2(238.69,231.39) v2(238.69,229.61) v2(238.67,204.63) v2(238.69,197.1) v2(238.69,195.32) v2(238.67,170.34) v2(242.46,293.63) v2(242.46,259.34) v2(242.46,225.05) v2(242.46,190.76) v2(243.31,399.5) v2(243.31,394.42) v2(243.31,389.34) v2(243.31,369.02) v2(243.31,363.94) v2(243.31,358.86) v2(243.31,353.78) v2(243.31,348.7) v2(243.31,343.62) v2(243.31,338.54) v2(243.31,333.46) v2(243.31,328.38) v2(243.31,323.3) v2(243.31,318.22) v2(243.31,313.14) v2(243.31,308.06) v2(243.31,160.74) v2(243.31,155.66) v2(243.31,150.58) v2(243.31,145.5) v2(243.31,140.42) v2(243.31,135.34) v2(243.31,130.26) v2(243.31,125.18) v2(243.31,120.1) v2(243.31,115.02) v2(243.31,109.94) v2(243.31,104.86) v2(243.31,79.46) v2(243.31,74.38) v2(243.31,69.3) v2(243.74,293.63) v2(243.74,259.34) v2(243.74,225.05) v2(243.74,190.76) v2(245.01,293.63) v2(245.01,259.34) v2(245.01,225.05) v2(245.01,190.76) v2(248.39,399.5) v2(248.39,394.42) v2(248.39,389.34) v2(248.39,384.26) v2(248.39,379.18) v2(248.39,374.1) v2(248.39,369.02) v2(248.39,363.94) v2(248.39,358.86) v2(248.39,353.78) v2(248.39,348.7) v2(248.39,343.62) v2(248.39,338.54) v2(248.39,333.46) v2(248.39,328.38) v2(248.39,323.3) v2(248.39,318.22) v2(248.39,313.14) v2(248.39,308.06) v2(248.43,300.36) v2(248.43,295.37) v2(248.43,266.07) v2(248.43,261.08) v2(248.43,231.78) v2(248.43,226.79) v2(248.43,197.49) v2(248.43,192.5) v2(248.39,160.74) v2(248.39,155.66) v2(248.39,150.58) v2(248.39,145.5) v2(248.39,140.42) v2(248.39,135.34) v2(248.39,130.26) v2(248.39,125.18) v2(248.39,120.1) v2(248.39,115.02) v2(248.39,109.94) v2(248.39,104.86) v2(248.39,79.46) v2(248.39,74.38) v2(248.39,69.3) v2(253.47,399.5) v2(253.47,394.42) v2(253.47,389.34) v2(253.47,384.26) v2(253.47,379.18) v2(253.47,374.1) v2(253.47,369.02) v2(253.47,363.94) v2(253.47,358.86) v2(253.47,353.78) v2(253.47,348.7) v2(253.47,343.62) v2(253.47,338.54) v2(253.47,333.46) v2(253.47,328.38) v2(253.47,323.3) v2(253.47,318.22) v2(253.47,313.14) v2(253.47,308.06) v2(253.47,160.74) v2(253.47,155.66) v2(253.47,150.58) v2(253.47,145.5) v2(253.47,140.42) v2(253.47,135.34) v2(253.47,130.26) v2(253.47,125.18) v2(253.47,120.1) v2(253.47,115.02) v2(253.47,109.94) v2(253.47,104.86) v2(253.47,99.78) v2(253.47,94.7) v2(253.47,89.62) v2(253.47,84.54) v2(253.47,79.46) v2(253.47,74.38) v2(253.47,69.3) v2(258.55,399.5) v2(258.55,394.42) v2(258.55,389.34) v2(258.55,384.26) v2(258.55,379.18) v2(258.55,374.1) v2(258.55,369.02) v2(258.55,363.94) v2(258.55,328.38) v2(258.55,323.3) v2(258.55,318.22) v2(258.55,313.14) v2(258.52,168.2) v2(258.52,166.42) v2(258.55,160.74) v2(258.55,155.66) v2(258.55,150.58) v2(258.55,145.5) v2(258.55,140.42) v2(258.55,135.34) v2(258.55,130.26) v2(258.55,125.18) v2(258.55,120.1) v2(258.55,115.02) v2(258.55,109.94) v2(258.55,104.86) v2(258.55,99.78) v2(258.55,94.7) v2(258.55,79.46) v2(258.55,74.38) v2(258.55,69.3) v2(260.69,301.84) v2(260.8,226.25) v2(261.74,166.71) v2(261.94,290.88) v2(261.94,285.8) v2(261.94,280.72) v2(261.94,275.64) v2(261.94,255.32) v2(261.94,245.16) v2(261.94,240.08) v2(261.94,235) v2(261.94,219.76) v2(261.94,214.68) v2(261.94,209.6) v2(261.94,204.52) v2(261.94,199.44) v2(261.94,194.36) v2(261.94,189.28) v2(261.94,184.2) v2(261.94,179.12) v2(262.04,72.14) v2(262.47,301.84) v2(262.58,226.25) v2(263.52,166.71) v2(263.63,399.5) v2(263.63,394.42) v2(263.63,389.34) v2(263.63,384.26) v2(263.63,379.18) v2(263.63,374.1) v2(263.63,369.02) v2(263.63,363.94) v2(263.63,328.38) v2(263.63,323.3) v2(263.63,318.22) v2(263.63,313.14) v2(263.63,160.74) v2(263.63,155.66) v2(263.63,150.58) v2(263.63,145.5) v2(263.63,140.42) v2(263.63,135.34) v2(263.63,130.26) v2(263.63,125.18) v2(263.63,120.1) v2(263.63,115.02) v2(263.63,109.94) v2(263.63,104.86) v2(263.63,99.78) v2(263.63,94.7) v2(263.63,79.46) v2(263.63,74.38) v2(263.63,69.3) v2(263.96,83.12) v2(265.32,301.84) v2(265.32,292.59) v2(265.43,226.25) v2(267.02,184.2) v2(267.02,179.12) v2(267.02,174.04) v2(267.02,168.96) v2(267.09,301.84) v2(267.09,292.59) v2(267.2,226.25) v2(268.71,399.5) v2(268.71,394.42) v2(268.71,389.34) v2(268.71,384.26) v2(268.71,379.18) v2(268.71,374.1) v2(268.71,369.02) v2(268.71,363.94) v2(268.71,328.38) v2(268.71,323.3) v2(268.71,318.22) v2(268.71,313.14) v2(268.71,160.74) v2(268.71,155.66) v2(268.71,150.58) v2(268.71,145.5) v2(268.71,109.94) v2(268.71,104.86) v2(268.71,99.78) v2(268.71,94.7) v2(268.71,79.46) v2(268.71,74.38) v2(268.71,69.3) v2(272.1,184.2) v2(272.1,179.12) v2(272.1,174.04) v2(272.1,168.96) v2(273.79,399.5) v2(273.79,394.42) v2(273.79,389.34) v2(273.79,384.26) v2(273.79,379.18) v2(273.79,374.1) v2(273.79,369.02) v2(273.79,363.94) v2(273.79,328.38) v2(273.79,323.3) v2(273.79,318.22) v2(273.79,313.14) v2(273.79,160.74) v2(273.79,155.66) v2(273.79,150.58) v2(273.79,145.5) v2(273.79,109.94) v2(273.79,79.46) v2(277.18,184.2) v2(277.18,179.12) v2(277.18,174.04) v2(277.18,168.96) v2(278.67,86.56) v2(278.87,399.5) v2(278.87,394.42) v2(278.87,389.34) v2(278.87,384.26) v2(278.87,379.18) v2(278.87,374.1) v2(278.87,369.02) v2(278.87,363.94) v2(278.87,328.38) v2(278.87,323.3) v2(278.87,318.22) v2(278.87,313.14) v2(278.87,160.74) v2(278.87,155.66) v2(278.87,150.58) v2(278.87,145.5) v2(278.87,109.94) v2(278.87,79.46) v2(282.26,174.04) v2(282.26,168.96) v2(282.56,128.74) v2(283.95,399.5) v2(283.95,394.42) v2(283.95,389.34) v2(283.95,384.26) v2(283.95,379.18) v2(283.95,374.1) v2(283.95,369.02) v2(283.95,363.94) v2(283.95,328.38) v2(283.95,323.3) v2(283.95,318.22) v2(283.95,313.14) v2(283.95,160.74) v2(283.95,155.66) v2(283.95,150.58) v2(283.95,145.5) v2(283.95,109.94) v2(283.95,79.46) v2(285.1,300.62) v2(285.1,299.6) v2(285.1,298.05) v2(285.1,297.04) v2(285.1,295.46) v2(285.1,294.45) v2(285.86,88.62) v2(285.86,86.06) v2(285.86,83.49) v2(287.34,174.04) v2(287.34,168.96) v2(289.03,399.5) v2(289.03,394.42) v2(289.03,389.34) v2(289.03,384.26) v2(289.03,379.18) v2(289.03,374.1) v2(289.03,369.02) v2(289.03,363.94) v2(289.03,323.3) v2(289.03,318.22) v2(289.03,313.14) v2(289.03,160.74) v2(289.03,155.66) v2(289.03,150.58) v2(289.03,145.5) v2(289.03,109.94) v2(289.03,104.86) v2(289.03,99.78) v2(289.03,94.7) v2(289.03,84.54) v2(289.03,79.46) v2(292.36,75.78) v2(294,76.68) v2(294.11,399.5) v2(294.11,394.42) v2(294.11,389.34) v2(294.11,384.26) v2(294.11,379.18) v2(294.11,374.1) v2(294.11,369.02) v2(294.11,363.94) v2(294.11,323.3) v2(294.11,318.22) v2(294.11,313.14) v2(294.11,160.74) v2(294.11,155.66) v2(294.11,150.58) v2(294.11,145.5) v2(294.11,140.42) v2(294.11,135.34) v2(294.11,130.26) v2(294.11,125.18) v2(294.11,109.94) v2(294.11,104.86) v2(294.11,99.78) v2(294.11,94.7) v2(294.11,89.62) v2(294.11,84.54) v2(294.11,79.46) v2(295.46,343.09) v2(297.04,146.56) v2(297.04,139.6) v2(297.04,132.87) v2(297.04,124.94) v2(299.19,399.5) v2(299.19,394.42) v2(299.19,389.34) v2(299.19,384.26) v2(299.19,379.18) v2(299.19,374.1) v2(299.19,369.02) v2(299.19,363.94) v2(299.19,323.3) v2(299.19,318.22) v2(299.19,313.14) v2(299.19,160.74) v2(299.19,155.66) v2(299.19,150.58) v2(299.19,109.94) v2(299.19,104.86) v2(299.19,99.78) v2(299.19,94.7) v2(299.19,79.46) v2(299.19,74.38) v2(299.19,69.3) v2(300.14,174.69) v2(300.14,173.67) v2(300.14,172.12) v2(300.14,171.11) v2(300.14,169.53) v2(300.14,168.51) v2(302.94,73.33) v2(302.94,70.28) v2(304.27,399.5) v2(304.27,394.42) v2(304.27,389.34) v2(304.27,384.26) v2(304.27,379.18) v2(304.27,374.1) v2(304.27,369.02) v2(304.27,363.94) v2(304.27,323.3) v2(304.27,318.22) v2(304.27,313.14) v2(304.27,160.74) v2(304.27,155.66) v2(304.27,150.58) v2(304.27,145.5) v2(304.27,140.42) v2(304.27,135.34) v2(304.27,130.26) v2(304.27,125.18) v2(304.27,109.94) v2(304.27,104.86) v2(304.27,99.78) v2(304.27,94.7) v2(304.27,79.46) v2(304.34,76.15) v2(304.47,83.12) v2(307.93,168.65) v2(307.93,166.87) v2(309.35,399.5) v2(309.35,394.42) v2(309.35,389.34) v2(309.35,384.26) v2(309.35,379.18) v2(309.35,369.02) v2(309.35,363.94) v2(309.35,323.3) v2(309.35,318.22) v2(309.35,313.14) v2(309.35,160.74) v2(309.35,155.66) v2(309.35,150.58) v2(309.35,145.5) v2(309.35,140.42) v2(309.35,135.34) v2(309.35,130.26) v2(309.35,125.18) v2(309.35,109.94) v2(309.35,104.86) v2(309.35,99.78) v2(309.35,94.7) v2(309.35,79.46) v2(309.55,171.07) v2(312.72,381.09) v2(312.72,378.53) v2(312.72,375.96) v2(314.43,399.5) v2(314.43,394.42) v2(314.43,389.34) v2(314.43,384.26) v2(314.43,323.3) v2(314.43,318.22) v2(314.43,313.14) v2(314.43,160.74) v2(314.43,109.94) v2(314.43,79.46) v2(315.59,76.38) v2(315.59,73.33) v2(315.59,70.28) v2(319.18,86.56) v2(319.37,68.93) v2(319.51,399.5) v2(319.51,394.42) v2(319.51,389.34) v2(319.51,384.26) v2(319.51,358.86) v2(319.51,353.78) v2(319.51,348.7) v2(319.51,343.62) v2(319.51,338.54) v2(319.51,333.46) v2(319.51,328.38) v2(319.51,323.3) v2(319.51,318.22) v2(319.51,313.14) v2(319.51,160.74) v2(319.51,109.94) v2(319.51,79.46) v2(319.91,378.02) v2(324.59,399.5) v2(324.59,394.42) v2(324.59,389.34) v2(324.59,384.26) v2(324.59,358.86) v2(324.59,353.78) v2(324.59,348.7) v2(324.59,343.62) v2(324.59,338.54) v2(324.59,333.46) v2(324.59,328.38) v2(324.59,323.3) v2(324.59,318.22) v2(324.59,313.14) v2(324.59,160.74) v2(324.59,109.94) v2(324.59,79.46) v2(325.1,300.62) v2(325.1,299.6) v2(325.1,298.05) v2(325.1,297.04) v2(325.1,295.46) v2(325.1,294.45) v2(326.38,88.62) v2(326.38,86.06) v2(326.38,83.49) v2(328,301.18) v2(329.67,399.5) v2(329.67,394.42) v2(329.67,389.34) v2(329.67,384.26) v2(329.67,369.02) v2(329.67,363.94) v2(329.67,358.86) v2(329.67,353.78) v2(329.67,348.7) v2(329.67,343.62) v2(329.67,338.54) v2(329.67,333.46) v2(329.67,328.38) v2(329.67,323.3) v2(329.67,318.22) v2(329.67,313.14) v2(329.67,160.74) v2(329.67,109.94) v2(329.67,104.86) v2(329.67,99.78) v2(329.67,94.7) v2(329.67,89.62) v2(329.67,84.54) v2(329.67,79.46) v2(329.67,74.38) v2(329.78,301.18) v2(331.82,150.09) v2(332.45,90.67) v2(333.06,301.04) v2(333.06,295.96) v2(333.98,106.76) v2(334.23,90.67) v2(334.63,381.46) v2(334.75,399.5) v2(334.75,394.42) v2(334.75,389.34) v2(334.75,369.02) v2(334.75,363.94) v2(334.75,358.86) v2(334.75,353.78) v2(334.75,348.7) v2(334.75,343.62) v2(334.75,338.54) v2(334.75,333.46) v2(334.75,328.38) v2(334.75,323.3) v2(334.75,318.22) v2(334.75,313.14) v2(334.75,160.74) v2(334.75,109.94) v2(334.75,84.54) v2(334.75,79.46) v2(338.14,301.04) v2(338.14,295.96) v2(338.14,179.12) v2(338.42,97.87) v2(339.06,93.05) v2(339.06,91.53) v2(339.06,84.8) v2(339.83,399.5) v2(339.83,394.42) v2(339.83,389.34) v2(339.83,369.02) v2(339.83,363.94) v2(339.83,358.86) v2(339.83,353.78) v2(339.83,348.7) v2(339.83,343.62) v2(339.83,338.54) v2(339.83,333.46) v2(339.83,328.38) v2(339.83,323.3) v2(339.83,318.22) v2(339.83,313.14) v2(339.83,160.74) v2(339.83,109.94) v2(339.83,104.86) v2(339.83,79.46) v2(340.14,174.69) v2(340.14,173.67) v2(340.14,172.12) v2(340.14,171.11) v2(340.14,169.53) v2(340.14,168.51) v2(340.29,291.43) v2(340.33,92.29) v2(340.33,84.8) v2(341.6,93.05) v2(341.6,91.53) v2(341.6,84.8) v2(342.42,94.91) v2(343.22,301.04) v2(343.22,179.12) v2(344.14,93.06) v2(344.14,91.52) v2(344.51,168.65) v2(344.51,166.87) v2(344.91,399.5) v2(344.91,394.42) v2(344.91,389.34) v2(344.91,384.26) v2(344.91,379.18) v2(344.91,374.1) v2(344.91,369.02) v2(344.91,363.94) v2(344.91,358.86) v2(344.91,353.78) v2(344.91,348.7) v2(344.91,343.62) v2(344.91,338.54) v2(344.91,333.46) v2(344.91,328.38) v2(344.91,323.3) v2(344.91,318.22) v2(344.91,313.14) v2(344.91,160.74) v2(344.91,109.94) v2(344.91,104.86) v2(344.91,79.46) v2(346.51,171.07) v2(348.3,301.04) v2(349.99,160.74) v2(350.33,70.97) v2(351.69,399.5) v2(351.69,394.42) v2(351.69,389.34) v2(351.69,384.26) v2(351.69,379.18) v2(351.69,374.1) v2(351.69,369.02) v2(351.69,363.94) v2(351.69,358.86) v2(351.69,353.78) v2(351.69,348.7) v2(351.69,343.62) v2(351.69,338.54) v2(351.69,333.46) v2(351.69,328.38) v2(351.69,323.3) v2(351.69,318.22) v2(351.69,313.14) v2(351.69,109.94) v2(351.69,104.86) v2(351.69,79.46) v2(354.93,84.8) v2(355.07,160.74) v2(356.77,389.34) v2(356.77,384.26) v2(356.77,379.18) v2(356.77,374.1) v2(356.77,369.02) v2(356.77,363.94) v2(356.77,358.86) v2(356.77,353.78) v2(356.77,348.7) v2(356.77,343.62) v2(356.77,338.54) v2(356.77,333.46) v2(356.77,328.38) v2(356.77,323.3) v2(356.77,318.22) v2(356.77,313.14) v2(356.77,109.94) v2(356.77,104.86) v2(356.84,84.8) v2(356.77,79.46) v2(358.46,179.12) v2(358.46,174.04) v2(358.46,168.96) v2(359.12,97.79) v2(360.9,97.79) v2(361.85,399.5) v2(361.85,394.42) v2(361.85,389.34) v2(361.85,384.26) v2(361.85,379.18) v2(361.85,374.1) v2(361.85,369.02) v2(361.85,363.94) v2(361.85,358.86) v2(361.85,353.78) v2(361.85,348.7) v2(361.85,343.62) v2(361.85,338.54) v2(361.85,333.46) v2(361.85,328.38) v2(361.85,323.3) v2(361.85,318.22) v2(361.85,313.14) v2(361.85,109.94) v2(361.85,104.86) v2(361.85,79.46) v2(363.54,174.04) v2(363.54,168.96) v2(364.84,97.79) v2(365.11,300.62) v2(365.11,299.6) v2(365.11,298.05) v2(365.11,297.04) v2(365.11,295.46) v2(365.11,294.45) v2(366.61,97.79) v2(366.93,399.5) v2(366.93,394.42) v2(366.93,389.34) v2(366.93,384.26) v2(366.93,379.18) v2(366.93,374.1) v2(366.93,369.02) v2(366.93,363.94) v2(366.93,358.86) v2(366.93,353.78) v2(366.93,348.7) v2(366.93,343.62) v2(366.93,338.54) v2(366.93,333.46) v2(366.93,328.38) v2(366.93,323.3) v2(366.93,318.22) v2(366.93,313.14) v2(366.93,160.74) v2(366.93,109.94) v2(366.93,104.86) v2(366.93,79.46) v2(372.01,399.5) v2(372.01,389.34) v2(372.01,384.26) v2(372.01,379.18) v2(372.01,374.1) v2(372.01,369.02) v2(372.01,363.94) v2(372.01,358.86) v2(372.01,353.78) v2(372.01,348.7) v2(372.01,343.62) v2(372.01,338.54) v2(372.01,333.46) v2(372.01,328.38) v2(372.01,323.3) v2(372.01,318.22) v2(372.01,313.14) v2(372.01,160.74) v2(372.01,109.94) v2(372.01,104.86) v2(372.01,79.46) v2(372.25,393.19) v2(372.51,74.26) v2(377.09,399.5) v2(377.09,389.34) v2(377.09,384.26) v2(377.09,379.18) v2(377.09,374.1) v2(377.09,369.02) v2(377.09,363.94) v2(377.09,358.86) v2(377.09,353.78) v2(377.09,348.7) v2(377.09,343.62) v2(377.09,338.54) v2(377.09,333.46) v2(377.09,328.38) v2(377.09,323.3) v2(377.09,318.22) v2(377.09,313.14) v2(377.09,160.74) v2(377.09,155.66) v2(377.09,150.58) v2(377.09,120.1) v2(377.09,115.02) v2(377.09,109.94) v2(377.09,104.86) v2(377.09,79.46) v2(377.77,146.76) v2(377.77,138.84) v2(377.77,132.1) v2(377.77,125.15) v2(378.78,179.12) v2(380.14,174.69) v2(380.14,173.67) v2(380.14,172.12) v2(380.14,171.11) v2(380.14,169.53) v2(380.14,168.51) v2(382.17,399.5) v2(382.17,389.34) v2(382.17,384.26) v2(382.17,379.18) v2(382.17,374.1) v2(382.17,369.02) v2(382.17,363.94) v2(382.17,358.86) v2(382.17,353.78) v2(382.17,348.7) v2(382.17,323.3) v2(382.17,318.22) v2(382.17,313.14) v2(382.17,160.74) v2(382.17,155.66) v2(382.17,150.58) v2(382.17,145.5) v2(382.17,140.42) v2(382.17,125.18) v2(382.17,109.94) v2(382.17,104.86) v2(382.17,99.78) v2(382.17,94.7) v2(382.17,89.62) v2(382.17,84.54) v2(382.17,79.46) v2(382.41,393.19) v2(383.12,168.65) v2(383.12,166.87) v2(383.86,179.12) v2(385.37,171.07) v2(387.25,399.5) v2(387.25,389.34) v2(387.25,384.26) v2(387.25,379.18) v2(387.25,374.1) v2(387.25,369.02) v2(387.25,363.94) v2(387.25,358.86) v2(387.25,353.78) v2(387.25,348.7) v2(387.25,323.3) v2(387.25,318.22) v2(387.25,313.14) v2(387.25,160.74) v2(387.25,155.66) v2(387.25,150.58) v2(387.25,145.5) v2(387.25,140.42) v2(387.25,125.18) v2(387.25,109.94) v2(387.25,104.86) v2(387.25,99.78) v2(387.25,94.7) v2(387.25,79.46) v2(387.25,74.38) v2(387.25,69.3) v2(389.31,303.34) v2(389.31,301.56) v2(389.42,71.98) v2(392.33,399.5) v2(392.33,389.34) v2(392.33,384.26) v2(392.33,379.18) v2(392.33,374.1) v2(392.33,369.02) v2(392.33,363.94) v2(392.33,358.86) v2(392.33,353.78) v2(392.33,348.7) v2(392.33,323.3) v2(392.33,318.22) v2(392.33,313.14) v2(392.33,160.74) v2(392.33,155.66) v2(392.33,150.58) v2(392.33,145.5) v2(392.33,140.42) v2(392.33,125.18) v2(392.33,109.94) v2(392.33,104.86) v2(392.33,99.78) v2(392.33,94.7) v2(392.33,79.46) v2(392.33,74.38) v2(392.33,69.3) v2(392.44,301.46) v2(392.57,393.19) v2(394.22,301.46) v2(395.5,83.12) v2(397.41,399.5) v2(397.41,389.34) v2(397.41,384.26) v2(397.41,379.18) v2(397.41,374.1) v2(397.41,369.02) v2(397.41,363.94) v2(397.41,358.86) v2(397.41,353.78) v2(397.41,348.7) v2(397.41,323.3) v2(397.41,318.22) v2(397.41,313.14) v2(397.41,160.74) v2(397.41,155.66) v2(397.41,150.58) v2(397.41,145.5) v2(397.41,140.42) v2(397.41,125.18) v2(397.41,109.94) v2(397.41,104.86) v2(397.41,99.78) v2(397.41,94.7) v2(397.41,79.46) v2(397.41,69.3) v2(399.1,301.04) v2(402.49,399.5) v2(402.49,389.34) v2(402.49,384.26) v2(402.49,379.18) v2(402.49,374.1) v2(402.49,369.02) v2(402.49,363.94) v2(402.49,358.86) v2(402.49,353.78) v2(402.49,348.7) v2(402.49,323.3) v2(402.49,318.22) v2(402.49,313.14) v2(402.49,160.74) v2(402.49,155.66) v2(402.49,150.58) v2(402.49,145.5) v2(402.49,140.42) v2(402.49,125.18) v2(402.49,109.94) v2(402.49,79.46) v2(402.49,74.38) v2(402.49,69.3) v2(402.73,393.19) v2(404.18,301.04) v2(404.18,295.96) v2(407.57,399.5) v2(407.57,394.42) v2(407.57,389.34) v2(407.57,384.26) v2(407.57,379.18) v2(407.57,374.1) v2(407.57,369.02) v2(407.57,363.94) v2(407.57,358.86) v2(407.57,353.78) v2(407.57,348.7) v2(407.57,323.3) v2(407.57,318.22) v2(407.57,313.14) v2(407.57,160.74) v2(407.57,155.66) v2(407.57,150.58) v2(407.57,145.5) v2(407.57,125.18) v2(407.57,109.94) v2(407.57,79.46) v2(407.57,74.38) v2(407.57,69.3) v2(410.22,86.56) v2(412.65,399.5) v2(412.65,394.42) v2(412.65,389.34) v2(412.65,384.26) v2(412.65,379.18) v2(412.65,374.1) v2(412.65,369.02) v2(412.65,363.94) v2(412.65,358.86) v2(412.65,353.78) v2(412.65,348.7) v2(412.65,343.62) v2(412.65,338.54) v2(412.65,333.46) v2(412.65,328.38) v2(412.65,323.3) v2(412.65,318.22) v2(412.65,313.14) v2(412.65,160.74) v2(412.65,155.66) v2(412.65,150.58) v2(412.65,145.5) v2(412.65,125.18) v2(412.65,109.94) v2(412.65,79.46) v2(412.65,74.38) v2(412.65,69.3) v2(416.42,178.74) v2(416.42,176.96) v2(417.42,300.62) v2(417.42,299.6) v2(417.42,298.05) v2(417.42,297.04) v2(417.42,295.46) v2(417.42,294.45) v2(417.41,88.62) v2(417.41,86.06) v2(417.41,83.49) v2(417.73,399.5) v2(417.73,394.42) v2(417.73,389.34) v2(417.73,384.26) v2(417.73,379.18) v2(417.73,374.1) v2(417.73,369.02) v2(417.73,363.94) v2(417.73,328.38) v2(417.73,323.3) v2(417.73,318.22) v2(417.73,313.14) v2(417.73,160.74) v2(417.73,155.66) v2(417.73,150.58) v2(417.73,145.5) v2(417.73,125.18) v2(417.73,109.94) v2(417.73,79.46) v2(417.73,74.38) v2(417.73,69.3) v2(420.14,174.69) v2(420.14,173.67) v2(420.14,172.12) v2(420.14,171.11) v2(420.14,169.53) v2(420.14,168.51) v2(420.53,243.24) v2(422.31,243.24) v2(422.81,399.5) v2(422.81,394.42) v2(422.81,389.34) v2(422.81,384.26) v2(422.81,379.18) v2(422.81,374.1) v2(422.81,369.02) v2(422.81,363.94) v2(422.81,328.38) v2(422.81,323.3) v2(422.81,318.22) v2(422.81,313.14) v2(422.81,160.74) v2(422.81,155.66) v2(422.81,150.58) v2(422.81,145.5) v2(422.81,125.18) v2(422.81,109.94) v2(422.81,104.86) v2(422.81,99.78) v2(422.81,94.7) v2(422.81,89.62) v2(422.81,84.54) v2(422.81,79.46) v2(422.81,74.38) v2(422.81,69.3) v2(424.5,168.96) v2(426.92,128.74) v2(427.89,399.5) v2(427.89,394.42) v2(427.89,389.34) v2(427.89,384.26) v2(427.89,379.18) v2(427.89,374.1) v2(427.89,369.02) v2(427.89,363.94) v2(427.89,328.38) v2(427.89,323.3) v2(427.89,318.22) v2(427.89,313.14) v2(427.89,160.74) v2(427.89,155.66) v2(427.89,150.58) v2(427.89,145.5) v2(427.89,125.18) v2(427.89,109.94) v2(427.89,104.86) v2(427.89,99.78) v2(427.89,94.7) v2(427.89,79.46) v2(427.89,74.38) v2(427.89,69.3) v2(429.85,168.65) v2(429.85,166.87) v2(430.18,190.37) v2(430.18,188.59) v2(431.86,299.63) v2(431.86,278.78) v2(431.98,171.07) v2(432.63,225.87) v2(432.97,399.5) v2(432.97,394.42) v2(432.97,389.34) v2(432.97,384.26) v2(432.97,379.18) v2(432.97,374.1) v2(432.97,369.02) v2(432.97,363.94) v2(432.97,328.38) v2(432.97,323.3) v2(432.97,318.22) v2(432.97,313.14) v2(432.97,160.74) v2(432.97,155.66) v2(432.97,150.58) v2(432.97,145.5) v2(432.97,125.18) v2(432.97,109.94) v2(432.97,104.86) v2(432.97,99.78) v2(432.97,94.7) v2(432.97,79.46) v2(432.97,74.38) v2(432.97,69.3) v2(433.64,299.63) v2(433.64,278.78) v2(433.89,83.12) v2(434.41,225.87) v2(434.66,290.88) v2(434.66,275.64) v2(434.66,270.56) v2(434.66,265.48) v2(434.66,260.4) v2(434.66,255.32) v2(434.66,250.24) v2(434.66,235) v2(434.66,214.68) v2(434.66,209.6) v2(434.66,204.52) v2(434.66,199.44) v2(434.66,194.36) v2(438.05,399.5) v2(438.05,394.42) v2(438.05,389.34) v2(438.05,384.26) v2(438.05,379.18) v2(438.05,374.1) v2(438.05,369.02) v2(438.05,363.94) v2(438.05,328.38) v2(438.05,323.3) v2(438.05,318.22) v2(438.05,313.14) v2(438.05,160.74) v2(438.05,155.66) v2(438.05,150.58) v2(438.05,145.5) v2(438.05,140.42) v2(438.05,135.34) v2(438.05,130.26) v2(438.05,125.18) v2(438.05,120.1) v2(438.05,115.02) v2(438.05,109.94) v2(438.05,104.86) v2(438.05,99.78) v2(438.05,94.7) v2(438.05,79.46) v2(438.05,74.38) v2(438.05,69.3) v2(443.13,399.5) v2(443.13,394.42) v2(443.13,389.34) v2(443.13,384.26) v2(443.13,379.18) v2(443.13,374.1) v2(443.13,369.02) v2(443.13,363.94) v2(443.13,358.86) v2(443.13,353.78) v2(443.13,348.7) v2(443.13,343.62) v2(443.13,338.54) v2(443.13,333.46) v2(443.13,328.38) v2(443.13,323.3) v2(443.13,318.22) v2(443.13,313.14) v2(443.13,308.06) v2(443.13,165.82) v2(443.13,160.74) v2(443.13,155.66) v2(443.13,150.58) v2(443.13,145.5) v2(443.13,140.42) v2(443.13,135.34) v2(443.13,130.26) v2(443.13,125.18) v2(443.13,120.1) v2(443.13,115.02) v2(443.13,109.94) v2(443.13,79.46) v2(443.13,74.38) v2(443.13,69.3) v2(448.21,399.5) v2(448.21,394.42) v2(448.21,389.34) v2(448.21,384.26) v2(448.21,379.18) v2(448.21,374.1) v2(448.21,369.02) v2(448.21,363.94) v2(448.21,358.86) v2(448.21,353.78) v2(448.21,348.7) v2(448.21,343.62) v2(448.21,338.54) v2(448.21,333.46) v2(448.21,328.38) v2(448.21,323.3) v2(448.21,318.22) v2(448.21,313.14) v2(448.21,308.06) v2(448.17,277.5) v2(448.17,272.51) v2(448.17,243.21) v2(448.17,238.22) v2(448.17,208.92) v2(448.17,203.93) v2(448.17,174.63) v2(448.17,169.64) v2(448.21,165.82) v2(448.21,160.74) v2(448.21,155.66) v2(448.21,150.58) v2(448.21,145.5) v2(448.21,140.42) v2(448.21,135.34) v2(448.21,130.26) v2(448.21,125.18) v2(448.21,120.1) v2(448.21,115.02) v2(448.21,109.94) v2(448.21,79.46) v2(448.21,74.38) v2(448.21,69.3) v2(448.6,86.56) v2(451.59,279.24) v2(451.59,244.95) v2(451.59,210.66) v2(451.59,176.37) v2(452.86,279.24) v2(452.86,244.95) v2(452.86,210.66) v2(452.86,176.37) v2(453.29,399.5) v2(453.29,394.42) v2(453.29,389.34) v2(453.29,384.26) v2(453.29,379.18) v2(453.29,369.02) v2(453.29,363.94) v2(453.29,358.86) v2(453.29,353.78) v2(453.29,348.7) v2(453.29,343.62) v2(453.29,338.54) v2(453.29,333.46) v2(453.29,328.38) v2(453.29,323.3) v2(453.29,318.22) v2(453.29,313.14) v2(453.29,308.06) v2(453.29,165.82) v2(453.29,160.74) v2(453.29,155.66) v2(453.29,150.58) v2(453.29,145.5) v2(453.29,140.42) v2(453.29,135.34) v2(453.29,130.26) v2(453.29,125.18) v2(453.29,120.1) v2(453.29,115.02) v2(453.29,109.94) v2(453.29,79.46) v2(453.29,74.38) v2(453.29,69.3) v2(454.14,279.24) v2(454.14,244.95) v2(454.14,210.66) v2(454.14,176.37) v2(455.8,88.62) v2(455.8,86.06) v2(455.8,83.49) v2(457.37,381.09) v2(457.37,378.53) v2(457.37,375.96) v2(457.94,299.66) v2(457.91,274.68) v2(457.91,272.9) v2(457.94,265.37) v2(457.91,240.39) v2(457.91,238.61) v2(457.94,231.08) v2(457.91,206.1) v2(457.91,204.32) v2(457.94,196.79) v2(457.91,171.81) v2(457.91,170.03) v2(458.37,399.5) v2(458.37,394.42) v2(458.37,389.34) v2(458.37,358.86) v2(458.37,353.78) v2(458.37,348.7) v2(458.37,343.62) v2(458.37,338.54) v2(458.37,333.46) v2(458.37,328.38) v2(458.37,323.3) v2(458.37,318.22) v2(458.37,313.14) v2(458.37,308.06) v2(458.37,165.82) v2(458.37,160.74) v2(458.37,155.66) v2(458.37,150.58) v2(458.37,145.5) v2(458.37,140.42) v2(458.37,135.34) v2(458.37,130.26) v2(458.37,125.18) v2(458.37,120.1) v2(458.37,115.02) v2(458.37,109.94) v2(458.37,104.86) v2(458.37,99.78) v2(458.37,94.7) v2(458.37,79.46) v2(458.37,74.38) v2(458.37,69.3) v2(463.45,399.5) v2(463.45,394.42) v2(463.45,389.34) v2(463.45,358.86) v2(463.45,353.78) v2(463.45,348.7) v2(463.45,343.62) v2(463.45,338.54) v2(463.45,333.46) v2(463.45,328.38) v2(463.45,323.3) v2(463.45,318.22) v2(463.45,313.14) v2(463.45,308.06) v2(463.45,165.82) v2(463.45,160.74) v2(463.45,155.66) v2(463.45,150.58) v2(463.45,145.5) v2(463.45,140.42) v2(463.45,135.34) v2(463.45,130.26) v2(463.45,125.18) v2(463.45,120.1) v2(463.45,115.02) v2(463.45,109.94) v2(463.45,104.86) v2(463.45,99.78) v2(463.45,94.7) v2(463.45,89.62) v2(463.45,84.54) v2(463.45,79.46) v2(463.45,74.38) v2(463.45,69.3) v2(464.57,378.02) v2(468.53,399.5) v2(468.53,394.42) v2(468.53,389.34) v2(468.53,358.86) v2(468.53,353.78) v2(468.53,348.7) v2(468.53,343.62) v2(468.53,338.54) v2(468.53,333.46) v2(468.53,328.38) v2(468.53,323.3) v2(468.53,318.22) v2(468.53,313.14) v2(468.53,308.06) v2(468.53,165.82) v2(468.53,160.74) v2(468.53,155.66) v2(468.53,150.58) v2(468.53,145.5) v2(468.53,140.42) v2(468.53,135.34) v2(468.53,130.26) v2(468.53,125.18) v2(468.53,120.1) v2(468.53,115.02) v2(468.53,109.94) v2(468.53,79.46) v2(468.53,74.38) v2(468.53,69.3) v2(468.84,90.67) v2(470.36,106.76) v2(470.61,90.67) v2(471.2,279.13) v2(471.2,244.84) v2(471.2,210.55) v2(471.2,176.26) v2(471.71,302.25) v2(471.71,289.99) v2(471.71,267.96) v2(471.71,255.7) v2(471.71,233.67) v2(471.71,221.41) v2(471.71,199.38) v2(471.71,187.12) v2(472.34,279.05) v2(472.34,244.76) v2(472.34,210.47) v2(472.34,176.18) v2(473.61,399.5) v2(473.61,394.42) v2(473.61,389.34) v2(473.61,369.02) v2(473.61,363.94) v2(473.61,358.86) v2(473.61,353.78) v2(473.61,348.7) v2(473.61,343.62) v2(473.61,338.54) v2(473.61,333.46) v2(473.61,328.38) v2(473.61,323.3) v2(473.61,318.22) v2(473.61,313.14) v2(473.61,308.06) v2(473.61,165.82) v2(473.61,160.74) v2(473.61,155.66) v2(473.61,150.58) v2(473.61,145.5) v2(473.61,140.42) v2(473.61,135.34) v2(473.61,130.26) v2(473.61,125.18) v2(473.61,120.1) v2(473.61,115.02) v2(473.61,109.94) v2(473.61,104.86) v2(473.61,79.46) v2(473.61,74.38) v2(473.61,69.3) v2(474.81,97.87) v2(475.44,93.05) v2(475.44,91.53) v2(475.44,84.8) v2(475.68,302.25) v2(475.68,289.99) v2(475.68,267.96) v2(475.68,255.7) v2(475.68,233.67) v2(475.68,221.41) v2(475.68,199.38) v2(475.68,187.12) v2(476.71,92.29) v2(476.71,84.8) v2(477.98,93.05) v2(477.98,91.53) v2(477.98,84.8) v2(478.69,399.5) v2(478.69,394.42) v2(478.69,389.34) v2(478.69,369.02) v2(478.69,363.94) v2(478.69,358.86) v2(478.69,353.78) v2(478.69,348.7) v2(478.69,343.62) v2(478.69,338.54) v2(478.69,333.46) v2(478.69,328.38) v2(478.69,323.3) v2(478.69,318.22) v2(478.69,313.14) v2(478.69,308.06) v2(478.69,165.82) v2(478.69,160.74) v2(478.69,155.66) v2(478.69,150.58) v2(478.69,145.5) v2(478.69,125.18) v2(478.69,109.94) v2(478.69,104.86) v2(478.69,79.46) v2(478.69,74.38) v2(478.69,69.3) v2(478.81,94.91) v2(479.01,241.28) v2(479.01,239.5) v2(479.28,381.46) v2(480.52,93.06) v2(480.52,91.52) v2(480.57,243.81) v2(480.57,175.23) v2(481.36,287.43) v2(481.36,280.16) v2(481.36,253.14) v2(481.36,245.87) v2(481.36,218.85) v2(481.36,211.58) v2(481.36,184.56) v2(481.36,177.29) v2(483.77,399.5) v2(483.77,394.42) v2(483.77,389.34) v2(483.77,369.02) v2(483.77,363.94) v2(483.77,358.86) v2(483.77,353.78) v2(483.77,348.7) v2(483.77,343.62) v2(483.77,338.54) v2(483.77,333.46) v2(483.77,328.38) v2(483.77,323.3) v2(483.77,318.22) v2(483.77,313.14) v2(483.77,308.06) v2(483.76,287.43) v2(483.76,280.16) v2(483.76,253.14) v2(483.76,245.87) v2(483.76,218.85) v2(483.76,211.58) v2(483.76,184.56) v2(483.76,177.29) v2(483.77,165.82) v2(483.77,160.74) v2(483.77,155.66) v2(483.77,150.58) v2(483.77,145.5) v2(483.77,125.18) v2(483.77,109.94) v2(483.77,104.86) v2(483.77,79.46) v2(483.77,74.38) v2(483.77,69.3) v2(488.85,399.5) v2(488.85,394.42) v2(488.85,389.34) v2(488.85,369.02) v2(488.85,363.94) v2(488.85,358.86) v2(488.85,353.78) v2(488.85,348.7) v2(488.85,343.62) v2(488.85,338.54) v2(488.85,333.46) v2(488.85,328.38) v2(488.85,323.3) v2(488.85,318.22) v2(488.85,313.14) v2(488.85,308.06) v2(488.85,165.82) v2(488.85,160.74) v2(488.85,155.66) v2(488.85,150.58) v2(488.85,145.5) v2(488.85,125.18) v2(488.85,109.94) v2(488.85,104.86) v2(488.85,79.46) v2(488.85,74.38) v2(488.85,69.3) v2(491.32,84.8) v2(493.22,84.8) v2(493.93,399.5) v2(493.93,394.42) v2(493.93,389.34) v2(493.93,369.02) v2(493.93,363.94) v2(493.93,358.86) v2(493.93,353.78) v2(493.93,348.7) v2(493.93,343.62) v2(493.93,338.54) v2(493.93,333.46) v2(493.93,328.38) v2(493.93,323.3) v2(493.93,318.22) v2(493.93,313.14) v2(493.93,308.06) v2(493.93,165.82) v2(493.93,160.74) v2(493.93,155.66) v2(493.93,150.58) v2(493.93,145.5) v2(493.93,125.18) v2(493.93,109.94) v2(493.93,104.86) v2(493.93,79.46) v2(493.93,74.38) v2(493.93,69.3) v2(495.51,97.79) v2(496.49,381.09) v2(496.49,378.53) v2(496.49,375.96) v2(497.28,97.79) v2(497.53,128.87) v2(499.01,399.5) v2(499.01,394.42) v2(499.01,389.34) v2(499.01,353.78) v2(499.01,348.7) v2(499.01,343.62) v2(499.01,338.54) v2(499.01,333.46) v2(499.01,328.38) v2(499.01,323.3) v2(499.01,318.22) v2(499.01,313.14) v2(499.01,308.06) v2(499.01,165.82) v2(499.01,160.74) v2(499.01,155.66) v2(499.01,150.58) v2(499.01,145.5) v2(499.01,125.18) v2(499.01,109.94) v2(499.01,104.86) v2(499.01,79.46) v2(499.01,74.38) v2(499.01,69.3) v2(501.22,97.79) v2(503,97.79) v2(503.68,378.02) v2(504.09,399.5) v2(504.09,394.42) v2(504.09,389.34) v2(504.09,353.78) v2(504.09,348.7) v2(504.09,323.3) v2(504.09,318.22) v2(504.09,313.14) v2(504.09,308.06) v2(504.09,165.82) v2(504.09,160.74) v2(504.09,155.66) v2(504.09,150.58) v2(504.09,145.5) v2(504.09,125.18) v2(504.09,109.94) v2(504.09,104.86) v2(504.09,79.46) v2(504.09,74.38) v2(504.09,69.3) v2(509.17,399.5) v2(509.17,394.42) v2(509.17,389.34) v2(509.17,353.78) v2(509.17,348.7) v2(509.17,323.3) v2(509.17,318.22) v2(509.17,313.14) v2(509.17,308.06) v2(509.17,165.82) v2(509.17,160.74) v2(509.17,155.66) v2(509.17,150.58) v2(509.17,145.5) v2(509.17,140.42) v2(509.17,135.34) v2(509.17,130.26) v2(509.17,125.18) v2(509.17,109.94) v2(509.17,104.86) v2(509.17,79.46) v2(509.17,74.38) v2(509.17,69.3) v2(509.5,302.57) v2(509.5,299.37) v2(509.5,295.3) v2(509.5,292.1) v2(509.5,286.67) v2(509.5,283.47) v2(509.5,268.28) v2(509.5,265.08) v2(509.5,261.01) v2(509.5,257.81) v2(509.5,252.38) v2(509.5,249.18) v2(509.5,233.99) v2(509.5,230.79) v2(509.5,226.72) v2(509.5,223.52) v2(509.5,218.09) v2(509.5,214.89) v2(509.5,199.7) v2(509.5,196.5) v2(509.5,192.43) v2(509.5,189.23) v2(509.5,183.8) v2(509.5,180.6) v2(509.96,342.58) v2(514.25,399.5) v2(514.25,394.42) v2(514.25,389.34) v2(514.25,369.02) v2(514.25,363.94) v2(514.25,358.86) v2(514.25,353.78) v2(514.25,348.7) v2(514.25,323.3) v2(514.25,318.22) v2(514.25,313.14) v2(514.25,308.06) v2(514.25,165.82) v2(514.25,160.74) v2(514.25,155.66) v2(514.25,150.58) v2(514.25,145.5) v2(514.25,140.42) v2(514.25,135.34) v2(514.25,130.26) v2(514.25,125.18) v2(514.25,109.94) v2(514.25,104.86) v2(514.25,99.78) v2(514.25,94.7) v2(514.25,89.62) v2(514.25,84.54) v2(514.25,79.46) v2(514.25,74.38) v2(514.25,69.3) v2(518.4,381.46) v2(519.33,399.5) v2(519.33,394.42) v2(519.33,389.34) v2(519.33,369.02) v2(519.33,363.94) v2(519.33,358.86) v2(519.33,353.78) v2(519.33,348.7) v2(519.33,323.3) v2(519.33,318.22) v2(519.33,313.14) v2(519.33,308.06) v2(519.33,165.82) v2(519.33,160.74) v2(519.33,155.66) v2(519.33,150.58) v2(519.33,145.5) v2(519.33,140.42) v2(519.33,135.34) v2(519.33,130.26) v2(519.33,125.18) v2(519.33,109.94) v2(519.33,104.86) v2(519.33,99.78) v2(519.33,94.7) v2(519.33,89.62) v2(519.33,84.54) v2(519.33,79.46) v2(519.33,74.38) v2(519.33,69.3) v2(524.41,399.5) v2(524.41,394.42) v2(524.41,389.34) v2(524.41,369.02) v2(524.41,363.94) v2(524.41,358.86) v2(524.41,353.78) v2(524.41,348.7) v2(524.41,323.3) v2(524.41,318.22) v2(524.41,313.14) v2(524.41,308.06) v2(524.41,165.82) v2(524.41,160.74) v2(524.41,155.66) v2(524.41,150.58) v2(524.41,145.5) v2(524.41,140.42) v2(524.41,135.34) v2(524.41,130.26) v2(524.41,125.18) v2(524.41,109.94) v2(524.41,104.86) v2(524.41,99.78) v2(524.41,94.7) v2(524.41,89.62) v2(524.41,84.54) v2(524.41,79.46) v2(524.41,74.38) v2(524.41,69.3) v2(529.49,399.5) v2(529.49,394.42) v2(529.49,389.34) v2(529.49,384.26) v2(529.49,379.18) v2(529.49,374.1) v2(529.49,369.02) v2(529.49,363.94) v2(529.49,358.86) v2(529.49,353.78) v2(529.49,348.7) v2(529.49,343.62) v2(529.49,338.54) v2(529.49,333.46) v2(529.49,328.38) v2(529.49,323.3) v2(529.49,318.22) v2(529.49,313.14) v2(529.49,308.06) v2(529.49,165.82) v2(529.49,160.74) v2(529.49,155.66) v2(529.49,150.58) v2(529.49,145.5) v2(529.49,140.42) v2(529.49,135.34) v2(529.49,130.26) v2(529.49,125.18) v2(529.49,120.1) v2(529.49,115.02) v2(529.49,109.94) v2(529.49,104.86) v2(529.49,99.78) v2(529.49,94.7) v2(529.49,89.62) v2(529.49,84.54) v2(529.49,79.46) v2(529.49,74.38) v2(529.49,69.3) v2(534.57,399.5) v2(534.57,394.42) v2(534.57,389.34) v2(534.57,384.26) v2(534.57,379.18) v2(534.57,374.1) v2(534.57,369.02) v2(534.57,363.94) v2(534.57,358.86) v2(534.57,353.78) v2(534.57,348.7) v2(534.57,343.62) v2(534.57,338.54) v2(534.57,333.46) v2(534.57,328.38) v2(534.57,323.3) v2(534.57,318.22) v2(534.57,313.14) v2(534.57,308.06) v2(534.57,165.82) v2(534.57,160.74) v2(534.57,155.66) v2(534.57,150.58) v2(534.57,145.5) v2(534.57,140.42) v2(534.57,135.34) v2(534.57,130.26) v2(534.57,125.18) v2(534.57,120.1) v2(534.57,115.02) v2(534.57,109.94) v2(534.57,104.86) v2(534.57,99.78) v2(534.57,94.7) v2(534.57,89.62) v2(534.57,84.54) v2(534.57,79.46) v2(534.57,74.38) v2(534.57,69.3) v2(536.62,393.19) v2(536.87,71.63) v2(539.65,399.5) v2(539.65,394.42) v2(539.65,389.34) v2(539.65,384.26) v2(539.65,379.18) v2(539.65,374.1) v2(539.65,369.02) v2(539.65,363.94) v2(539.65,358.86) v2(539.65,353.78) v2(539.65,348.7) v2(539.65,343.62) v2(539.65,338.54) v2(539.65,333.46) v2(539.65,328.38) v2(539.65,323.3) v2(539.65,318.22) v2(539.65,313.14) v2(539.65,308.06) v2(539.65,165.82) v2(539.65,160.74) v2(539.65,155.66) v2(539.65,150.58) v2(539.65,145.5) v2(539.65,140.42) v2(539.65,135.34) v2(539.65,130.26) v2(539.65,125.18) v2(539.65,120.1) v2(539.65,115.02) v2(539.65,109.94) v2(539.65,104.86) v2(539.65,99.78) v2(539.65,94.7) v2(539.65,89.62) v2(539.65,84.54) v2(539.65,79.46) v2(539.65,74.38) v2(539.65,69.3) v2(544.73,399.5) v2(544.73,394.42) v2(544.73,389.34) v2(544.73,384.26) v2(544.73,379.18) v2(544.73,374.1) v2(544.73,369.02) v2(544.73,363.94) v2(544.73,358.86) v2(544.73,353.78) v2(544.73,348.7) v2(544.73,343.62) v2(544.73,338.54) v2(544.73,333.46) v2(544.73,328.38) v2(544.73,323.3) v2(544.73,318.22) v2(544.73,313.14) v2(544.73,308.06) v2(544.73,302.98) v2(544.73,297.9) v2(544.73,292.82) v2(544.73,287.74) v2(544.73,282.66) v2(544.73,277.58) v2(544.73,272.5) v2(544.73,267.42) v2(544.73,262.34) v2(544.73,257.26) v2(544.73,252.18) v2(544.73,247.1) v2(544.73,242.02) v2(544.73,236.94) v2(544.73,231.86) v2(544.73,226.78) v2(544.73,221.7) v2(544.73,216.62) v2(544.73,211.54) v2(544.73,206.46) v2(544.73,201.38) v2(544.73,196.3) v2(544.73,191.22) v2(544.73,186.14) v2(544.73,181.06) v2(544.73,175.98) v2(544.73,170.9) v2(544.73,165.82) v2(544.73,160.74) v2(544.73,155.66) v2(544.73,150.58) v2(544.73,145.5) v2(544.73,140.42) v2(544.73,135.34) v2(544.73,130.26) v2(544.73,125.18) v2(544.73,120.1) v2(544.73,115.02) v2(544.73,109.94) v2(544.73,104.86) v2(544.73,99.78) v2(544.73,94.7) v2(544.73,89.62) v2(544.73,84.54) v2(544.73,79.46) v2(544.73,74.38) v2(544.73,69.3) v2(546.78,393.19) v2(547.03,71.63) v2(549.81,399.5) v2(549.81,394.42) v2(549.81,384.26) v2(549.81,379.18) v2(549.81,374.1) v2(549.81,369.02) v2(549.81,363.94) v2(549.81,358.86) v2(549.81,353.78) v2(549.81,348.7) v2(549.81,343.62) v2(549.81,338.54) v2(549.81,333.46) v2(549.81,328.38) v2(549.81,323.3) v2(549.81,318.22) v2(549.81,313.14) v2(549.81,302.98) v2(549.81,297.9) v2(549.81,292.82) v2(549.81,287.74) v2(549.81,282.66) v2(549.81,277.58) v2(549.81,272.5) v2(549.81,267.42) v2(549.81,262.34) v2(549.81,257.26) v2(549.81,252.18) v2(549.81,247.1) v2(549.81,242.02) v2(549.81,236.94) v2(549.81,231.86) v2(549.81,226.78) v2(549.81,221.7) v2(549.81,216.62) v2(549.81,211.54) v2(549.81,206.46) v2(549.81,201.38) v2(549.81,196.3) v2(549.81,191.22) v2(549.81,186.14) v2(549.81,181.06) v2(549.81,175.98) v2(549.81,170.9) v2(549.81,160.74) v2(549.81,155.66) v2(549.81,150.58) v2(549.81,145.5) v2(549.81,140.42) v2(549.81,135.34) v2(549.81,130.26) v2(549.81,125.18) v2(549.81,120.1) v2(549.81,115.02) v2(549.81,109.94) v2(549.81,104.86) v2(549.81,99.78) v2(549.81,94.7) v2(549.81,89.62) v2(549.81,84.54) v2(549.81,74.38) v2(549.81,69.3) v2(554.89,399.5) v2(554.89,394.42) v2(554.89,389.34) v2(554.89,384.26) v2(554.89,379.18) v2(554.89,374.1) v2(554.89,369.02) v2(554.89,363.94) v2(554.89,358.86) v2(554.89,353.78) v2(554.89,348.7) v2(554.89,343.62) v2(554.89,338.54) v2(554.89,333.46) v2(554.89,328.38) v2(554.89,323.3) v2(554.89,318.22) v2(554.89,313.14) v2(554.89,308.06) v2(554.89,302.98) v2(554.89,297.9) v2(554.89,292.82) v2(554.89,287.74) v2(554.89,282.66) v2(554.89,277.58) v2(554.89,272.5) v2(554.89,267.42) v2(554.89,262.34) v2(554.89,257.26) v2(554.89,252.18) v2(554.89,247.1) v2(554.89,242.02) v2(554.89,236.94) v2(554.89,231.86) v2(554.89,226.78) v2(554.89,221.7) v2(554.89,216.62) v2(554.89,211.54) v2(554.89,206.46) v2(554.89,201.38) v2(554.89,196.3) v2(554.89,191.22) v2(554.89,186.14) v2(554.89,181.06) v2(554.89,175.98) v2(554.89,170.9) v2(554.89,165.82) v2(554.89,160.74) v2(554.89,155.66) v2(554.89,150.58) v2(554.89,145.5) v2(554.89,140.42) v2(554.89,135.34) v2(554.89,130.26) v2(554.89,125.18) v2(554.89,120.1) v2(554.89,115.02) v2(554.89,109.94) v2(554.89,104.86) v2(554.89,99.78) v2(554.89,94.7) v2(559.97,399.5) v2(559.97,394.42) v2(559.97,389.34) v2(559.97,384.26) v2(559.97,379.18) v2(559.97,374.1) v2(559.97,369.02) v2(559.97,363.94) v2(559.97,358.86) v2(559.97,353.78) v2(559.97,348.7) v2(559.97,343.62) v2(559.97,338.54) v2(559.97,333.46) v2(559.97,328.38) v2(559.97,323.3) v2(559.97,318.22) v2(559.97,313.14) v2(559.97,308.06) v2(559.97,302.98) v2(559.97,297.9) v2(559.97,292.82) v2(559.97,287.74) v2(559.97,282.66) v2(559.97,277.58) v2(559.97,272.5) v2(559.97,267.42) v2(559.97,262.34) v2(559.97,257.26) v2(559.97,252.18) v2(559.97,247.1) v2(559.97,242.02) v2(559.97,236.94) v2(559.97,231.86) v2(559.97,226.78) v2(559.97,221.7) v2(559.97,216.62) v2(559.97,211.54) v2(559.97,206.46) v2(559.97,201.38) v2(559.97,196.3) v2(559.97,191.22) v2(559.97,186.14) v2(559.97,181.06) v2(559.97,175.98) v2(559.97,170.9) v2(559.97,165.82) v2(559.97,160.74) v2(559.97,155.66) v2(559.97,150.58) v2(559.97,145.5) v2(559.97,140.42) v2(559.97,135.34) v2(559.97,130.26) v2(559.97,125.18) v2(559.97,120.1) v2(559.97,115.02) v2(559.97,109.94) v2(559.97,104.86) v2(559.97,99.78) v2(559.97,94.7) v2(565.05,399.5) v2(565.05,394.42) v2(565.05,389.34) v2(565.05,384.26) v2(565.05,379.18) v2(565.05,374.1) v2(565.05,369.02) v2(565.05,363.94) v2(565.05,358.86) v2(565.05,353.78) v2(565.05,348.7) v2(565.05,343.62) v2(565.05,338.54) v2(565.05,333.46) v2(565.05,328.38) v2(565.05,323.3) v2(565.05,318.22) v2(565.05,313.14) v2(565.05,308.06) v2(565.05,302.98) v2(565.05,297.9) v2(565.05,292.82) v2(565.05,287.74) v2(565.05,282.66) v2(565.05,277.58) v2(565.05,272.5) v2(565.05,267.42) v2(565.05,262.34) v2(565.05,257.26) v2(565.05,252.18) v2(565.05,247.1) v2(565.05,242.02) v2(565.05,236.94) v2(565.05,231.86) v2(565.05,226.78) v2(565.05,221.7) v2(565.05,216.62) v2(565.05,211.54) v2(565.05,206.46) v2(565.05,201.38) v2(565.05,196.3) v2(565.05,191.22) v2(565.05,186.14) v2(565.05,181.06) v2(565.05,175.98) v2(565.05,170.9) v2(565.05,165.82) v2(565.05,160.74) v2(565.05,155.66) v2(565.05,150.58) v2(565.05,145.5) v2(565.05,140.42) v2(565.05,135.34) v2(565.05,130.26) v2(565.05,125.18) v2(565.05,120.1) v2(565.05,115.02) v2(565.05,109.94) v2(565.05,104.86) v2(565.05,99.78) v2(565.05,94.7) v2(570.13,399.5) v2(570.13,394.42) v2(570.13,389.34) v2(570.13,384.26) v2(570.13,379.18) v2(570.13,374.1) v2(570.13,369.02) v2(570.13,363.94) v2(570.13,358.86) v2(570.13,353.78) v2(570.13,348.7) v2(570.13,343.62) v2(570.13,338.54) v2(570.13,333.46) v2(570.13,328.38) v2(570.13,323.3) v2(570.13,318.22) v2(570.13,313.14) v2(570.13,308.06) v2(570.13,302.98) v2(570.13,297.9) v2(570.13,292.82) v2(570.13,287.74) v2(570.13,282.66) v2(570.13,277.58) v2(570.13,272.5) v2(570.13,267.42) v2(570.13,262.34) v2(570.13,257.26) v2(570.13,252.18) v2(570.13,247.1) v2(570.13,242.02) v2(570.13,231.86) v2(570.13,226.78) v2(570.13,221.7) v2(570.13,216.62) v2(570.13,211.54) v2(570.13,206.46) v2(570.13,201.38) v2(570.13,196.3) v2(570.13,191.22) v2(570.13,186.14) v2(570.13,181.06) v2(570.13,175.98) v2(570.13,170.9) v2(570.13,165.82) v2(570.13,160.74) v2(570.13,155.66) v2(570.13,150.58) v2(570.13,145.5) v2(570.13,140.42) v2(570.13,135.34) v2(570.13,130.26) v2(570.13,125.18) v2(570.13,120.1) v2(570.13,115.02) v2(570.13,109.94) v2(570.13,104.86) v2(570.13,99.78) v2(570.13,94.7) v2(575.21,399.5) v2(575.21,394.42) v2(575.21,389.34) v2(575.21,384.26) v2(575.21,379.18) v2(575.21,374.1) v2(575.21,369.02) v2(575.21,363.94) v2(575.21,358.86) v2(575.21,353.78) v2(575.21,348.7) v2(575.21,343.62) v2(575.21,338.54) v2(575.21,333.46) v2(575.21,328.38) v2(575.21,323.3) v2(575.21,318.22) v2(575.21,313.14) v2(575.21,308.06) v2(575.21,302.98) v2(575.21,297.9) v2(575.21,292.82) v2(575.21,287.74) v2(575.21,282.66) v2(575.21,277.58) v2(575.21,272.5) v2(575.21,267.42) v2(575.21,262.34) v2(575.21,257.26) v2(575.21,252.18) v2(575.21,247.1) v2(575.21,242.02) v2(575.21,236.94) v2(575.21,231.86) v2(575.21,226.78) v2(575.21,221.7) v2(575.21,216.62) v2(575.21,211.54) v2(575.21,206.46) v2(575.21,201.38) v2(575.21,196.3) v2(575.21,191.22) v2(575.21,186.14) v2(575.21,181.06) v2(575.21,175.98) v2(575.21,170.9) v2(575.21,165.82) v2(575.21,160.74) v2(575.21,155.66) v2(575.21,150.58) v2(575.21,145.5) v2(575.21,140.42) v2(575.21,135.34) v2(575.21,130.26) v2(575.21,125.18) v2(575.21,120.1) v2(575.21,115.02) v2(575.21,109.94) v2(575.21,104.86) v2(575.21,99.78) v2(575.21,94.7) v3(275.3,259.87) v3(275.3,199.87) v3(315.3,259.87) v3(315.3,199.87) v3(355.3,259.87) v3(355.3,199.87) v3(395.3,259.87) v3(395.3,199.87)
