# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
NOREF#3087  -  []  503.22 267 0 top
NOREF#3088  -  []  348.3 225 0 top
NOREF#3089  -  []  488.59 225.45 0 top
NOREF#3090  -  []  511.9 177.08 90 top
NOREF#3091  -  []  326.37 296.27 90 top
NOREF#3092  -  []  508.74 203.81 90 top
NOREF#3093  -  []  443.55 288.49 90 top
NOREF#3094  -  []  458.44 241.1 90 top
NOREF#3095  -  []  251.53 171.14 0 top
NOREF#3096  -  []  493.99 232.71 0 top
NOREF#3097  -  []  331.07 196.08 90 top
NOREF#3098  -  []  369.66 195.8 90 top
NOREF#3099  -  []  276.89 198.83 0 top
NOREF#3100  -  []  414.11 83.49 0 top
NOREF#3101  -  []  364.2 194.4 0 top
NOREF#3102  -  []  334.73 170.29 0 top
NOREF#3103  -  []  416.38 177.85 0 top
NOREF#3104  -  []  310.61 377.23 0 top
NOREF#3105  -  []  498.77 364.96 90 top
NOREF#3106  -  []  184.98 335.21 0 top
NOREF#3107  -  []  414.67 251.62 90 top
NOREF#3108  -  []  413.32 257.12 0 top
NOREF#3109  -  []  329.82 186.49 0 top
NOREF#3110  -  []  369.3 251.32 90 top
NOREF#3111  -  []  328.29 251.82 0 top
NOREF#3112  -  []  400.3 177 90 top
NOREF#3113  -  []  335.29 178.14 0 top
NOREF#3114  -  []  334.43 201.87 90 top
NOREF#3115  -  []  497.31 246.5 90 top
NOREF#3116  -  []  291.05 216.46 90 top
NOREF#3117  -  []  286.35 247.8 0 top
NOREF#3118  -  []  182.03 217.26 90 top
NOREF#3119  -  []  280.37 269.76 0 top
NOREF#3120  -  []  488.59 195.22 90 top
NOREF#3121  -  []  359.7 296.22 0 top
NOREF#3122  -  []  293.23 207.72 0 top
NOREF#3123  -  []  256.93 185.16 90 top
NOREF#3124  -  []  25.88 374.66 90 top
NOREF#3125  -  []  360.8 260 0 top
NOREF#3126  -  []  403.34 273.34 0 top
NOREF#3127  -  []  346.14 176.74 0 top
NOREF#3128  -  []  494.38 382.36 0 top
NOREF#3129  -  []  416.24 199.17 0 top
NOREF#3130  -  []  284.1 199 0 top
NOREF#3131  -  []  294.3 208.85 90 top
NOREF#3132  -  []  410.18 297.54 90 top
NOREF#3133  -  []  361.21 192.38 0 top
NOREF#3134  -  []  406.3 207 0 top
NOREF#3135  -  []  351.3 188 90 top
NOREF#3136  -  []  281.57 200.33 90 top
NOREF#3137  -  []  329.34 186.99 0 top
NOREF#3138  -  []  497.31 296.69 90 top
NOREF#3139  -  []  273.33 201.92 0 top
NOREF#3140  -  []  459.1 360.96 90 top
NOREF#3141  -  []  284.75 218.11 90 top
NOREF#3142  -  []  411.14 245.99 90 top
NOREF#3143  -  []  329.42 194.63 0 top
NOREF#3144  -  []  208.01 261.59 90 top
NOREF#3145  -  []  364.48 186.16 0 top
NOREF#3146  -  []  289.3 251.32 90 top
NOREF#3147  -  []  468.93 276.99 0 top
NOREF#3148  -  []  365.92 286.51 0 top
NOREF#3149  -  []  488.59 273.79 90 top
NOREF#3150  -  []  57.77 1.56 90 top
NOREF#3151  -  []  389.57 300.22 0 top
NOREF#3152  -  []  290.35 296.27 90 top
NOREF#3153  -  []  247.68 279.62 0 top
NOREF#3154  -  []  363.33 265.18 0 top
NOREF#3155  -  []  340.53 264.49 0 top
NOREF#3156  -  []  22.4 340.62 0 top
NOREF#3157  -  []  369.35 270.01 0 top
NOREF#3158  -  []  401.57 199.65 90 top
NOREF#3159  -  []  403.63 266.35 0 top
NOREF#3160  -  []  414.58 228.89 0 top
NOREF#3161  -  []  453.02 284.89 90 top
NOREF#3162  -  []  289.7 176.75 0 top
NOREF#3163  -  []  457.37 378.53 0 top
NOREF#3164  -  []  409.31 251.29 90 top
NOREF#3165  -  []  268.88 268.98 0 top
NOREF#3166  -  []  414.3 268.85 90 top
NOREF#3167  -  []  319.47 201.29 0 top
NOREF#3168  -  []  256.93 246.73 90 top
NOREF#3169  -  []  395.5 287.55 0 top
NOREF#3170  -  []  316.1 226.51 0 top
NOREF#3171  -  []  400.3 237 90 top
NOREF#3172  -  []  284.75 228.96 90 top
NOREF#3173  -  []  226.93 172.91 90 top
NOREF#3174  -  []  324.48 195.99 0 top
NOREF#3175  -  []  514.57 282.63 90 top
NOREF#3176  -  []  221.62 286.08 0 top
NOREF#3177  -  []  412.33 262.19 0 top
NOREF#3178  -  []  500.02 195.22 90 top
NOREF#3179  -  []  287.68 200.19 0 top
NOREF#3180  -  []  368.07 253.43 90 top
NOREF#3181  -  []  290.07 185.6 0 top
NOREF#3182  -  []  374.22 260.52 0 top
NOREF#3183  -  []  408.76 209.36 90 top
NOREF#3184  -  []  432.64 175.94 90 top
NOREF#3185  -  []  366.65 77.1 90 top
NOREF#3186  -  []  208.01 193.01 90 top
NOREF#3187  -  []  208.01 168.71 90 top
NOREF#3188  -  []  412.33 264.49 0 top
NOREF#3189  -  []  410.35 190.17 0 top
NOREF#3190  -  []  445.07 298.86 0 top
NOREF#3191  -  []  196.58 168.71 90 top
NOREF#3192  -  []  500.02 213.62 90 top
NOREF#3193  -  []  439.67 284.84 0 top
NOREF#3194  -  []  182.03 271.22 90 top
NOREF#3195  -  []  514.57 218.45 90 top
NOREF#3196  -  []  355.6 217.7 0 top
NOREF#3197  -  []  380.87 276.46 90 top
NOREF#3198  -  []  325.7 196.69 0 top
NOREF#3199  -  []  501.06 374.69 90 top
NOREF#3200  -  []  324.48 255.99 0 top
NOREF#3201  -  []  407.59 196.03 0 top
NOREF#3202  -  []  404.53 264.54 90 top
NOREF#3203  -  []  324.8 185.52 0 top
NOREF#3204  -  []  364.75 282.51 90 top
NOREF#3205  -  []  320.35 208.16 90 top
NOREF#3206  -  []  573.05 71.46 90 top
NOREF#3207  -  []  505.42 251.1 0 top
NOREF#3208  -  []  269.3 186 90 top
NOREF#3209  -  []  416.14 203.74 0 top
NOREF#3210  -  []  408.67 195.4 90 top
NOREF#3211  -  []  299.2 167.5 90 top
NOREF#3212  -  []  296.14 205.11 0 top
NOREF#3213  -  []  414.73 170.29 0 top
NOREF#3214  -  []  375.71 74.26 0 top
NOREF#3215  -  []  182.03 259.79 0 top
NOREF#3216  -  []  263.3 220 0 top
NOREF#3217  -  []  287.93 184.02 90 top
NOREF#3218  -  []  404.1 199 90 top
NOREF#3219  -  []  318.05 120.91 0 top
NOREF#3220  -  []  326.29 238.5 90 top
NOREF#3221  -  []  321.57 269.12 90 top
NOREF#3222  -  []  292.17 184.64 90 top
NOREF#3223  -  []  406.33 255.34 90 top
NOREF#3224  -  []  323.63 266.35 0 top
NOREF#3225  -  []  191.18 210.26 0 top
NOREF#3226  -  []  325.1 194.08 0 top
NOREF#3227  -  []  370.76 195.38 0 top
NOREF#3228  -  []  290.07 250.47 0 top
NOREF#3229  -  []  371.55 189.53 90 top
NOREF#3230  -  []  508.74 186.56 90 top
NOREF#3231  -  []  200.41 227.3 0 top
NOREF#3232  -  []  276.89 198.83 0 top
NOREF#3233  -  []  395.1 262.13 90 top
NOREF#3234  -  []  284.53 204.54 90 top
NOREF#3235  -  []  493.65 85.95 0 top
NOREF#3236  -  []  204.81 237.29 0 top
NOREF#3237  -  []  432.75 294.59 90 top
NOREF#3238  -  []  280.46 87.33 0 top
NOREF#3239  -  []  288.1 199.55 90 top
NOREF#3240  -  []  393.3 180 90 top
NOREF#3241  -  []  404.8 208.5 0 top
NOREF#3242  -  []  405.97 193.75 0 top
NOREF#3243  -  []  324.75 222.51 90 top
NOREF#3244  -  []  501.06 379.82 90 top
NOREF#3245  -  []  214.04 218.9 0 top
NOREF#3246  -  []  322.9 209.33 0 top
NOREF#3247  -  []  293.36 250.09 0 top
NOREF#3248  -  []  504.06 127.18 90 top
NOREF#3249  -  []  294.43 207.08 90 top
NOREF#3250  -  []  366.87 194.07 0 top
NOREF#3251  -  []  355.66 83.32 0 top
NOREF#3252  -  []  477.74 199.82 0 top
NOREF#3253  -  []  323.33 266.03 0 top
NOREF#3254  -  []  327 247.28 90 top
NOREF#3255  -  []  188.31 225.86 90 top
NOREF#3256  -  []  187.33 277.44 0 top
NOREF#3257  -  []  366.29 172.14 90 top
NOREF#3258  -  []  404.53 203.69 90 top
NOREF#3259  -  []  194.53 294.44 90 top
NOREF#3260  -  []  293.03 256.8 0 top
NOREF#3261  -  []  175.18 216.72 90 top
NOREF#3262  -  []  323.98 198.4 90 top
NOREF#3263  -  []  372.38 258.4 0 top
NOREF#3264  -  []  279.69 296.22 0 top
NOREF#3265  -  []  283.33 266.03 0 top
NOREF#3266  -  []  429.08 90.74 0 top
NOREF#3267  -  []  322.41 191.74 90 top
NOREF#3268  -  []  324.53 265.39 90 top
NOREF#3269  -  []  282.92 93.57 90 top
NOREF#3270  -  []  439.67 250.55 0 top
NOREF#3271  -  []  333.89 75.38 0 top
NOREF#3272  -  []  288.09 255.99 0 top
NOREF#3273  -  []  413.93 273.57 0 top
NOREF#3274  -  []  413.47 252.26 0 top
NOREF#3275  -  []  213.49 296.77 0 top
NOREF#3276  -  []  359.47 262.74 0 top
NOREF#3277  -  []  225.47 227.3 0 top
NOREF#3278  -  []  155.68 242.33 0 top
NOREF#3279  -  []  482.91 186.56 90 top
NOREF#3280  -  []  284.08 269.88 0 top
NOREF#3281  -  []  290.3 263 90 top
NOREF#3282  -  []  477.16 213.62 90 top
NOREF#3283  -  []  466.31 192.56 0 top
NOREF#3284  -  []  457.07 87.35 90 top
NOREF#3285  -  []  374.03 294.52 90 top
NOREF#3286  -  []  411.05 276.46 90 top
NOREF#3287  -  []  407.56 210 0 top
NOREF#3288  -  []  485.88 246.5 90 top
NOREF#3289  -  []  424.89 93.18 0 top
NOREF#3290  -  []  232.25 373.84 90 top
NOREF#3291  -  []  230.64 278.84 0 top
NOREF#3292  -  []  317.13 99.62 90 top
NOREF#3293  -  []  200.41 218.9 0 top
NOREF#3294  -  []  388.3 225 0 top
NOREF#3295  -  []  439.67 185.78 90 top
NOREF#3296  -  []  373.02 256.8 0 top
NOREF#3297  -  []  326.3 194.08 90 top
NOREF#3298  -  []  170.58 224.7 0 top
NOREF#3299  -  []  370.07 250.47 0 top
NOREF#3300  -  []  311.56 177.54 0 top
NOREF#3301  -  []  277.3 276 0 top
NOREF#3302  -  []  189.51 258.63 90 top
NOREF#3303  -  []  359.35 288.95 0 top
NOREF#3304  -  []  341.05 295.32 0 top
NOREF#3305  -  []  154.8 446.5 0 top
NOREF#3306  -  []  471.13 285.39 0 top
NOREF#3307  -  []  459.82 184.38 90 top
NOREF#3308  -  []  328.07 253.43 90 top
NOREF#3309  -  []  373.93 213.57 0 top
NOREF#3310  -  []  285.1 254.72 0 top
NOREF#3311  -  []  389.34 176.74 0 top
NOREF#3312  -  []  324.8 196.37 0 top
NOREF#3313  -  []  370.9 202.85 90 top
NOREF#3314  -  []  404.1 199 0 top
NOREF#3315  -  []  405.1 194.08 0 top
NOREF#3316  -  []  328.66 191.82 0 top
NOREF#3317  -  []  466.31 302.69 0 top
NOREF#3318  -  []  349.18 200.49 90 top
NOREF#3319  -  []  451.12 215.91 0 top
NOREF#3320  -  []  179.95 273.6 90 top
NOREF#3321  -  []  196.58 184.61 90 top
NOREF#3322  -  []  391.54 243.1 0 top
NOREF#3323  -  []  221.09 260.19 90 top
NOREF#3324  -  []  412.33 267.4 0 top
NOREF#3325  -  []  408.53 227.49 0 top
NOREF#3326  -  []  256.93 239.72 90 top
NOREF#3327  -  []  198.76 217.5 0 top
NOREF#3328  -  []  312.28 261.88 0 top
NOREF#3329  -  []  364.8 256.37 0 top
NOREF#3330  -  []  33.6 373.7 90 top
NOREF#3331  -  []  291.8 201.5 90 top
NOREF#3332  -  []  386.14 176.74 0 top
NOREF#3333  -  []  359.47 259.92 0 top
NOREF#3334  -  []  221.09 183.21 90 top
NOREF#3335  -  []  280.3 233 0 top
NOREF#3336  -  []  334.33 117.27 90 top
NOREF#3337  -  []  289.29 195.34 90 top
NOREF#3338  -  []  411.05 216.46 90 top
NOREF#3339  -  []  401.57 260.33 90 top
NOREF#3340  -  []  369.31 191.57 90 top
NOREF#3341  -  []  235.49 235.89 90 top
NOREF#3342  -  []  412.7 190.29 0 top
NOREF#3343  -  []  468.16 294.03 0 top
NOREF#3344  -  []  508.74 169.52 90 top
NOREF#3345  -  []  28.84 361 90 top
NOREF#3346  -  []  453.25 176.83 90 top
NOREF#3347  -  []  399.15 208.8 0 top
NOREF#3348  -  []  548.8 23.5 90 top
NOREF#3349  -  []  192.73 189.52 0 top
NOREF#3350  -  []  338.53 86.94 90 top
NOREF#3351  -  []  204.81 278.84 0 top
NOREF#3352  -  []  226.24 244.55 0 top
NOREF#3353  -  []  360.35 268.16 90 top
NOREF#3354  -  []  188.98 237.29 0 top
NOREF#3355  -  []  193.38 218.9 0 top
NOREF#3356  -  []  516.65 259.6 0 top
NOREF#3357  -  []  366.38 293.68 90 top
NOREF#3358  -  []  323.35 176.74 0 top
NOREF#3359  -  []  406.4 227.56 90 top
NOREF#3360  -  []  307.51 69.01 90 top
NOREF#3361  -  []  410.67 250.47 90 top
NOREF#3362  -  []  364.8 208.5 0 top
NOREF#3363  -  []  416.48 293.69 90 top
NOREF#3364  -  []  323.33 264.33 0 top
NOREF#3365  -  []  406.9 267.17 0 top
NOREF#3366  -  []  247.68 286.63 0 top
NOREF#3367  -  []  369.71 195.72 90 top
NOREF#3368  -  []  188.98 210.26 0 top
NOREF#3369  -  []  326.9 255.41 90 top
NOREF#3370  -  []  399.47 259.92 0 top
NOREF#3371  -  []  397.9 177.54 0 top
NOREF#3372  -  []  403.33 205.18 0 top
NOREF#3373  -  []  373.23 207.72 0 top
NOREF#3374  -  []  508.74 272.39 90 top
NOREF#3375  -  []  392.28 261.88 0 top
NOREF#3376  -  []  366.99 187.3 90 top
NOREF#3377  -  []  348.3 185 90 top
NOREF#3378  -  []  194.53 191.57 90 top
NOREF#3379  -  []  521.42 236.35 0 top
NOREF#3380  -  []  373.32 197.12 0 top
NOREF#3381  -  []  409.67 209.11 90 top
NOREF#3382  -  []  356.16 262.17 90 top
NOREF#3383  -  []  336.84 171.61 0 top
NOREF#3384  -  []  277.82 350.14 0 top
NOREF#3385  -  []  473.57 382.58 90 top
NOREF#3386  -  []  408.07 253.43 90 top
NOREF#3387  -  []  315.26 169.66 0 top
NOREF#3388  -  []  324.8 196.37 0 top
NOREF#3389  -  []  292.33 264.49 0 top
NOREF#3390  -  []  333.23 204.81 0 top
NOREF#3391  -  []  310.61 382.36 0 top
NOREF#3392  -  []  268.3 285 0 top
NOREF#3393  -  []  348.3 245 90 top
NOREF#3394  -  []  404.1 259 90 top
NOREF#3395  -  []  439.67 181.97 0 top
NOREF#3396  -  []  439.67 220.07 90 top
NOREF#3397  -  []  208.01 237.29 90 top
NOREF#3398  -  []  365.98 247.8 0 top
NOREF#3399  -  []  334.58 228.89 0 top
NOREF#3400  -  []  334.73 170.29 0 top
NOREF#3401  -  []  509.5 245.66 0 top
NOREF#3402  -  []  230.87 184.61 90 top
NOREF#3403  -  []  215.59 109.62 90 top
NOREF#3404  -  []  369.31 251.29 90 top
NOREF#3405  -  []  334.22 196.16 90 top
NOREF#3406  -  []  271.19 76.18 0 top
NOREF#3407  -  []  407.82 209.36 90 top
NOREF#3408  -  []  216.24 278.84 0 top
NOREF#3409  -  []  412.38 288.89 0 top
NOREF#3410  -  []  466.31 268.4 0 top
NOREF#3411  -  []  324.8 246.46 0 top
NOREF#3412  -  []  281.57 198.96 90 top
NOREF#3413  -  []  289.3 191.52 90 top
NOREF#3414  -  []  283.37 256.69 0 top
NOREF#3415  -  []  313 369.19 0 top
NOREF#3416  -  []  323.98 259.6 90 top
NOREF#3417  -  []  208.01 287.48 90 top
NOREF#3418  -  []  503.22 285.39 0 top
NOREF#3419  -  []  517.92 284.82 0 top
NOREF#3420  -  []  323.63 206.35 0 top
NOREF#3421  -  []  324.75 280.31 90 top
NOREF#3422  -  []  366.8 187.3 90 top
NOREF#3423  -  []  480.36 267 0 top
NOREF#3424  -  []  363.61 122.11 0 top
NOREF#3425  -  []  219.44 184.61 90 top
NOREF#3426  -  []  194.53 225.86 90 top
NOREF#3427  -  []  416.84 169.02 0 top
NOREF#3428  -  []  348.53 150.74 90 top
NOREF#3429  -  []  179.95 176.78 0 top
NOREF#3430  -  []  198.23 174.57 90 top
NOREF#3431  -  []  325.1 254.72 0 top
NOREF#3432  -  []  175.18 245.08 0 top
NOREF#3433  -  []  306.14 243.1 0 top
NOREF#3434  -  []  272.8 424.5 90 top
NOREF#3435  -  []  465.96 225.45 0 top
NOREF#3436  -  []  363.01 146.99 90 top
NOREF#3437  -  []  477.74 286.79 0 top
NOREF#3438  -  []  290.55 209.37 90 top
NOREF#3439  -  []  503.27 177.08 0 top
NOREF#3440  -  []  472.56 173.41 0 top
NOREF#3441  -  []  330.76 255.38 0 top
NOREF#3442  -  []  333.32 257.12 0 top
NOREF#3443  -  []  364.1 199 0 top
NOREF#3444  -  []  462.76 229.51 90 top
NOREF#3445  -  []  245.98 232.4 0 top
NOREF#3446  -  []  249.33 219.45 0 top
NOREF#3447  -  []  209.16 90.26 90 top
NOREF#3448  -  []  326.23 187.42 0 top
NOREF#3449  -  []  332.53 137.95 0 top
NOREF#3450  -  []  182.03 299.48 90 top
NOREF#3451  -  []  320.3 177 90 top
NOREF#3452  -  []  198.23 251.79 90 top
NOREF#3453  -  []  368.88 259.55 90 top
NOREF#3454  -  []  293.36 190.09 0 top
NOREF#3455  -  []  179.95 239.31 90 top
NOREF#3456  -  []  279.69 298.81 0 top
NOREF#3457  -  []  197.81 117.24 0 top
NOREF#3458  -  []  465.73 285.39 0 top
NOREF#3459  -  []  265.55 167.94 90 top
NOREF#3460  -  []  209.66 235.89 90 top
NOREF#3461  -  []  265.98 203.69 0 top
NOREF#3462  -  []  249.33 171.14 0 top
NOREF#3463  -  []  364.53 204.54 90 top
NOREF#3464  -  []  465.73 174.12 0 top
NOREF#3465  -  []  399.52 103.62 0 top
NOREF#3466  -  []  247.68 183.76 0 top
NOREF#3467  -  []  193.38 175.97 0 top
NOREF#3468  -  []  329.71 255.72 90 top
NOREF#3469  -  []  280.37 200.29 0 top
NOREF#3470  -  []  291.07 256.08 90 top
NOREF#3471  -  []  202.61 210.26 0 top
NOREF#3472  -  []  210.19 243.15 0 top
NOREF#3473  -  []  260.3 197 90 top
NOREF#3474  -  []  182.03 196.61 90 top
NOREF#3475  -  []  458.33 203.94 90 top
NOREF#3476  -  []  360.37 263.08 0 top
NOREF#3477  -  []  478.8 45.5 0 top
NOREF#3478  -  []  317.89 137.35 0 top
NOREF#3479  -  []  493.99 276.99 0 top
NOREF#3480  -  []  477.16 256.54 90 top
NOREF#3481  -  []  170.58 247.56 0 top
NOREF#3482  -  []  332.53 131.75 90 top
NOREF#3483  -  []  374.58 300.72 90 top
NOREF#3484  -  []  512.69 382.58 90 top
NOREF#3485  -  []  400.37 200.97 0 top
NOREF#3486  -  []  313.33 261.92 0 top
NOREF#3487  -  []  209.66 270.18 90 top
NOREF#3488  -  []  374.43 261.87 90 top
NOREF#3489  -  []  365.35 67.46 90 top
NOREF#3490  -  []  243.59 174.51 90 top
NOREF#3491  -  []  367.69 294.51 90 top
NOREF#3492  -  []  374.22 196.16 90 top
NOREF#3493  -  []  412.01 296.22 0 top
NOREF#3494  -  []  331.05 216.46 90 top
NOREF#3495  -  []  410.9 202.85 90 top
NOREF#3496  -  []  466.31 226.85 0 top
NOREF#3497  -  []  287.68 260.19 0 top
NOREF#3498  -  []  336.14 265.11 0 top
NOREF#3499  -  []  57.77 1.56 90 top
NOREF#3500  -  []  491.79 301.29 0 top
NOREF#3501  -  []  182.03 265.19 90 top
NOREF#3502  -  []  408.51 196.36 0 top
NOREF#3503  -  []  321.57 202.44 90 top
NOREF#3504  -  []  417.78 288.89 90 top
NOREF#3505  -  []  355.6 277.7 0 top
NOREF#3506  -  []  294.57 220.31 90 top
NOREF#3507  -  []  221.09 270.18 90 top
NOREF#3508  -  []  285.13 255.99 0 top
NOREF#3509  -  []  468.16 267 0 top
NOREF#3510  -  []  366.29 178.5 90 top
NOREF#3511  -  []  204.8 23.5 90 top
NOREF#3512  -  []  332.17 184.64 90 top
NOREF#3513  -  []  223.27 184.61 0 top
NOREF#3514  -  []  346.68 304.88 0 top
NOREF#3515  -  []  462.76 256.54 90 top
NOREF#3516  -  []  315.1 262.13 90 top
NOREF#3517  -  []  394.08 200.75 0 top
NOREF#3518  -  []  493.99 251.1 0 top
NOREF#3519  -  []  194.53 260.15 90 top
NOREF#3520  -  []  284.2 254.4 0 top
NOREF#3521  -  []  414.57 278.11 90 top
NOREF#3522  -  []  335.42 199.03 90 top
NOREF#3523  -  []  364.53 203.69 90 top
NOREF#3524  -  []  225.47 253.19 0 top
NOREF#3525  -  []  349.3 223 0 top
NOREF#3526  -  []  285.3 202 0 top
NOREF#3527  -  []  466.31 278.39 0 top
NOREF#3528  -  []  450.62 169.02 0 top
NOREF#3529  -  []  508.3 202.24 90 top
NOREF#3530  -  []  280.37 262.42 0 top
NOREF#3531  -  []  409.11 251.32 90 top
NOREF#3532  -  []  274.3 279 0 top
NOREF#3533  -  []  324.1 259 0 top
NOREF#3534  -  []  401.55 228.96 0 top
NOREF#3535  -  []  326.37 298.84 90 top
NOREF#3536  -  []  324.5 184.96 0 top
NOREF#3537  -  []  363.63 266.35 0 top
NOREF#3538  -  []  462.76 259.74 0 top
NOREF#3539  -  []  330.67 190.47 90 top
NOREF#3540  -  []  318.05 120.26 90 top
NOREF#3541  -  []  360.37 260.97 0 top
NOREF#3542  -  []  328.89 191.89 0 top
NOREF#3543  -  []  202.61 271.58 0 top
NOREF#3544  -  []  319.15 268.8 0 top
NOREF#3545  -  []  200.41 278.84 0 top
NOREF#3546  -  []  221.09 243.15 90 top
NOREF#3547  -  []  364.81 117.27 90 top
NOREF#3548  -  []  372.72 205.56 0 top
NOREF#3549  -  []  279.47 202.74 0 top
NOREF#3550  -  []  355.26 67.46 90 top
NOREF#3551  -  []  325.76 260.49 90 top
NOREF#3552  -  []  505.92 279.6 0 top
NOREF#3553  -  []  264.61 227.48 90 top
NOREF#3554  -  []  412.19 192 90 top
NOREF#3555  -  []  284.54 272.7 90 top
NOREF#3556  -  []  412.17 184.64 90 top
NOREF#3557  -  []  179.95 205.02 90 top
NOREF#3558  -  []  343.25 295.32 0 top
NOREF#3559  -  []  331.8 261.5 90 top
NOREF#3560  -  []  406.99 187.5 90 top
NOREF#3561  -  []  325.13 248.64 0 top
NOREF#3562  -  []  428.6 169.03 0 top
NOREF#3563  -  []  410.07 185.6 0 top
NOREF#3564  -  []  404.25 177.55 0 top
NOREF#3565  -  []  294.22 260.52 0 top
NOREF#3566  -  []  57.77 1.56 90 top
NOREF#3567  -  []  50.8 465 0 top
NOREF#3568  -  []  370.97 190.15 0 top
NOREF#3569  -  []  364.81 147.75 90 top
NOREF#3570  -  []  214.04 203 0 top
NOREF#3571  -  []  493.99 182.52 0 top
NOREF#3572  -  []  294.3 200.8 90 top
NOREF#3573  -  []  315.32 298.68 90 top
NOREF#3574  -  []  338.94 322.78 90 top
NOREF#3575  -  []  287.44 74.78 0 top
NOREF#3576  -  []  326.58 187.42 0 top
NOREF#3577  -  []  511.37 255.93 0 top
NOREF#3578  -  []  331.8 201.5 90 top
NOREF#3579  -  []  410.18 295.34 90 top
NOREF#3580  -  []  406.99 247.3 90 top
NOREF#3581  -  []  209.66 217.5 90 top
NOREF#3582  -  []  406.9 196.05 90 top
NOREF#3583  -  []  414.57 220.31 90 top
NOREF#3584  -  []  349.57 152.43 0 top
NOREF#3585  -  []  404.75 220.31 90 top
NOREF#3586  -  []  477.16 263.8 90 top
NOREF#3587  -  []  286.37 293.68 90 top
NOREF#3588  -  []  406.58 200.49 90 top
NOREF#3589  -  []  409.3 191.32 90 top
NOREF#3590  -  []  400.8 200 0 top
NOREF#3591  -  []  511.37 210.21 0 top
NOREF#3592  -  []  479.01 240.39 0 top
NOREF#3593  -  []  458.44 172.52 90 top
NOREF#3594  -  []  307.28 83.12 90 top
NOREF#3595  -  []  389.3 246 90 top
NOREF#3596  -  []  324.75 228.96 90 top
NOREF#3597  -  []  348.53 133.55 90 top
NOREF#3598  -  []  36.22 372.45 0 top
NOREF#3599  -  []  227.67 295.88 0 top
NOREF#3600  -  []  262.45 291.36 0 top
NOREF#3601  -  []  404.53 205.39 90 top
NOREF#3602  -  []  251.19 165.4 0 top
NOREF#3603  -  []  477.74 252.5 0 top
NOREF#3604  -  []  400.21 171.34 90 top
NOREF#3605  -  []  510.1 257.08 0 top
NOREF#3606  -  []  318.83 267.9 90 top
NOREF#3607  -  []  321.57 262.44 90 top
NOREF#3608  -  []  325.98 247.8 0 top
NOREF#3609  -  []  357.27 85.95 0 top
NOREF#3610  -  []  498.77 361.76 0 top
NOREF#3611  -  []  324.2 194.4 0 top
NOREF#3612  -  []  324.8 268.5 0 top
NOREF#3613  -  []  411.8 201.5 90 top
NOREF#3614  -  []  280.37 260.97 0 top
NOREF#3615  -  []  313.3 290 0 top
NOREF#3616  -  []  326.3 207 0 top
NOREF#3617  -  []  452.91 170.92 0 top
NOREF#3618  -  []  286.37 296.27 90 top
NOREF#3619  -  []  366.9 207.17 0 top
NOREF#3620  -  []  408.17 99.62 90 top
NOREF#3621  -  []  282.3 209.2 0 top
NOREF#3622  -  []  372.4 269.11 90 top
NOREF#3623  -  []  204.81 203 0 top
NOREF#3624  -  []  235.49 167.31 90 top
NOREF#3625  -  []  468.93 242.7 0 top
NOREF#3626  -  []  365.1 194.72 0 top
NOREF#3627  -  []  366.25 255.33 0 top
NOREF#3628  -  []  275.6 217.7 0 top
NOREF#3629  -  []  282.93 136.36 0 top
NOREF#3630  -  []  517.92 239.1 0 top
NOREF#3631  -  []  521.42 196.56 90 top
NOREF#3632  -  []  454.13 245.15 90 top
NOREF#3633  -  []  375.29 184.5 0 top
NOREF#3634  -  []  477.82 241.66 0 top
NOREF#3635  -  []  374.22 197.01 90 top
NOREF#3636  -  []  288.54 191.43 0 top
NOREF#3637  -  []  355.1 202.13 90 top
NOREF#3638  -  []  408.67 255.4 90 top
NOREF#3639  -  []  50.8 5 0 top
NOREF#3640  -  []  482.91 228.11 90 top
NOREF#3641  -  []  374.57 220.31 90 top
NOREF#3642  -  []  474.62 89.67 90 top
NOREF#3643  -  []  337.4 90.26 90 top
NOREF#3644  -  []  166.06 118.51 0 top
NOREF#3645  -  []  421.84 176.58 90 top
NOREF#3646  -  []  428.65 295.32 90 top
NOREF#3647  -  []  196.58 237.29 90 top
NOREF#3648  -  []  327.88 269.1 90 top
NOREF#3649  -  []  169.4 132.93 0 top
NOREF#3650  -  []  249.33 274.01 0 top
NOREF#3651  -  []  287.47 256.04 0 top
NOREF#3652  -  []  198.76 174.57 0 top
NOREF#3653  -  []  453.25 280.34 0 top
NOREF#3654  -  []  368.1 199.55 90 top
NOREF#3655  -  []  292.41 269.11 90 top
NOREF#3656  -  []  323.63 205.5 0 top
NOREF#3657  -  []  361.57 260.33 90 top
NOREF#3658  -  []  261.69 227.1 90 top
NOREF#3659  -  []  409.82 246.49 0 top
NOREF#3660  -  []  198.76 191.61 0 top
NOREF#3661  -  []  406.13 185.02 0 top
NOREF#3662  -  []  289.42 194.63 0 top
NOREF#3663  -  []  392.28 201.89 0 top
NOREF#3664  -  []  383.3 250 90 top
NOREF#3665  -  []  320.37 260.97 0 top
NOREF#3666  -  []  346.14 243.1 0 top
NOREF#3667  -  []  275.1 202.13 90 top
NOREF#3668  -  []  169.4 118.51 0 top
NOREF#3669  -  []  324.8 186.46 90 top
NOREF#3670  -  []  330.62 253.99 90 top
NOREF#3671  -  []  368.28 257.05 90 top
NOREF#3672  -  []  343.3 220 0 top
NOREF#3673  -  []  251.53 178.15 0 top
NOREF#3674  -  []  372.4 209.11 90 top
NOREF#3675  -  []  287.36 260.49 90 top
NOREF#3676  -  []  414.73 170.29 0 top
NOREF#3677  -  []  640.8 0 90 top
NOREF#3678  -  []  315.58 81.48 90 top
NOREF#3679  -  []  188.98 287.48 0 top
NOREF#3680  -  []  310.3 293.92 90 top
NOREF#3681  -  []  312.28 70.28 0 top
NOREF#3682  -  []  284.53 264.54 90 top
NOREF#3683  -  []  262.45 300.61 0 top
NOREF#3684  -  []  348.37 132.35 90 top
NOREF#3685  -  []  175.18 233.65 0 top
NOREF#3686  -  []  459.82 294.26 90 top
NOREF#3687  -  []  335.86 359.03 90 top
NOREF#3688  -  []  406.58 247.88 0 top
NOREF#3689  -  []  408.3 205 90 top
NOREF#3690  -  []  405.7 196.05 0 top
NOREF#3691  -  []  292.09 210.01 0 top
NOREF#3692  -  []  282.9 209.33 0 top
NOREF#3693  -  []  329.3 251.32 90 top
NOREF#3694  -  []  353.3 240 90 top
NOREF#3695  -  []  196.33 189.52 90 top
NOREF#3696  -  []  288.89 251.43 0 top
NOREF#3697  -  []  331.52 254.76 90 top
NOREF#3698  -  []  334.57 222.51 90 top
NOREF#3699  -  []  313.33 201.92 0 top
NOREF#3700  -  []  360.37 199.6 0 top
NOREF#3701  -  []  373.92 264.92 90 top
NOREF#3702  -  []  376.14 263.74 0 top
NOREF#3703  -  []  448.2 360.96 0 top
NOREF#3704  -  []  395.6 192.3 90 top
NOREF#3705  -  []  421.41 170.34 90 top
NOREF#3706  -  []  415.29 184.5 0 top
NOREF#3707  -  []  315 364.96 90 top
NOREF#3708  -  []  290.18 228.89 0 top
NOREF#3709  -  []  228.44 244.55 0 top
NOREF#3710  -  []  503.22 198.42 0 top
NOREF#3711  -  []  286.99 187.5 90 top
NOREF#3712  -  []  516.65 236.74 0 top
NOREF#3713  -  []  285.1 194.72 0 top
NOREF#3714  -  []  286.8 247.3 90 top
NOREF#3715  -  []  204.8 424.5 90 top
NOREF#3716  -  []  294.43 261.87 90 top
NOREF#3717  -  []  472.56 241.99 0 top
NOREF#3718  -  []  364.5 244.96 0 top
NOREF#3719  -  []  351.3 222 0 top
NOREF#3720  -  []  383.81 307.25 0 top
NOREF#3721  -  []  247.68 272.61 0 top
NOREF#3722  -  []  251.53 281.02 0 top
NOREF#3723  -  []  187.33 201.6 0 top
NOREF#3724  -  []  495.27 169.9 90 top
NOREF#3725  -  []  193.38 210.26 0 top
NOREF#3726  -  []  514.57 172.73 90 top
NOREF#3727  -  []  406.58 260.49 90 top
NOREF#3728  -  []  190.11 223.81 90 top
NOREF#3729  -  []  179.95 233.93 0 top
NOREF#3730  -  []  480.36 208.41 0 top
NOREF#3731  -  []  285.98 247.8 0 top
NOREF#3732  -  []  410.67 251.75 90 top
NOREF#3733  -  []  202.8 446.5 0 top
NOREF#3734  -  []  324.1 95.22 90 top
NOREF#3735  -  []  439.67 213.06 90 top
NOREF#3736  -  []  477.16 205.21 90 top
NOREF#3737  -  []  370.07 252.35 0 top
NOREF#3738  -  []  451.65 240.77 0 top
NOREF#3739  -  []  468.16 232.71 0 top
NOREF#3740  -  []  315.6 192.3 90 top
NOREF#3741  -  []  330.99 252.65 0 top
NOREF#3742  -  []  265.03 267.58 0 top
NOREF#3743  -  []  256.93 178.15 90 top
NOREF#3744  -  []  503.22 301.29 0 top
NOREF#3745  -  []  405.68 255.34 90 top
NOREF#3746  -  []  276.1 226.51 0 top
NOREF#3747  -  []  351.52 152.43 0 top
NOREF#3748  -  []  368.46 256.44 0 top
NOREF#3749  -  []  294.58 228.89 0 top
NOREF#3750  -  []  288.66 191.82 0 top
NOREF#3751  -  []  409.34 246.99 0 top
NOREF#3752  -  []  324.2 254.4 0 top
NOREF#3753  -  []  226.24 210.26 0 top
NOREF#3754  -  []  333.13 117.11 90 top
NOREF#3755  -  []  328.95 256.35 0 top
NOREF#3756  -  []  477.16 251.1 0 top
NOREF#3757  -  []  33.6 374.9 0 top
NOREF#3758  -  []  281.57 259.65 90 top
NOREF#3759  -  []  264.08 138.05 0 top
NOREF#3760  -  []  330.97 190.15 0 top
NOREF#3761  -  []  445.07 250.55 0 top
NOREF#3762  -  []  412.08 210.01 0 top
NOREF#3763  -  []  404.5 246.78 0 top
NOREF#3764  -  []  292.38 198.4 0 top
NOREF#3765  -  []  182.03 219.47 90 top
NOREF#3766  -  []  300.81 266.84 90 top
NOREF#3767  -  []  293.3 257.5 90 top
NOREF#3768  -  []  288.41 200.19 0 top
NOREF#3769  -  []  514.57 214.05 90 top
NOREF#3770  -  []  308.65 295.32 90 top
NOREF#3771  -  []  399.47 263.4 0 top
NOREF#3772  -  []  373.32 260.2 0 top
NOREF#3773  -  []  333.23 266.23 0 top
NOREF#3774  -  []  334.43 265.59 90 top
NOREF#3775  -  []  286.9 207.72 0 top
NOREF#3776  -  []  353.3 230 0 top
NOREF#3777  -  []  442.87 230.28 0 top
NOREF#3778  -  []  399.47 261.29 0 top
NOREF#3779  -  []  403.37 196.69 0 top
NOREF#3780  -  []  418.02 335.54 0 top
NOREF#3781  -  []  521.42 173.7 90 top
NOREF#3782  -  []  389.18 260.49 90 top
NOREF#3783  -  []  329.3 191.32 90 top
NOREF#3784  -  []  281.57 202.44 90 top
NOREF#3785  -  []  359.47 261.29 0 top
NOREF#3786  -  []  407.45 254.68 90 top
NOREF#3787  -  []  209.16 96.1 0 top
NOREF#3788  -  []  330.4 93.57 90 top
NOREF#3789  -  []  365.7 246.14 90 top
NOREF#3790  -  []  50.8 465 0 top
NOREF#3791  -  []  415.13 97.42 90 top
NOREF#3792  -  []  321.7 209.33 0 top
NOREF#3793  -  []  285.3 202 0 top
NOREF#3794  -  []  292.33 262.19 0 top
NOREF#3795  -  []  401.53 303.74 0 top
NOREF#3796  -  []  322.3 209.2 0 top
NOREF#3797  -  []  208.01 218.9 90 top
NOREF#3798  -  []  55.8 0 90 top
NOREF#3799  -  []  293.3 197.5 90 top
NOREF#3800  -  []  393.33 296.41 90 top
NOREF#3801  -  []  268.3 245 90 top
NOREF#3802  -  []  326.23 247.42 0 top
NOREF#3803  -  []  292.7 190.29 0 top
NOREF#3804  -  []  366.23 187.42 0 top
NOREF#3805  -  []  414.3 260.8 90 top
NOREF#3806  -  []  412.38 198.4 0 top
NOREF#3807  -  []  371.52 194.76 90 top
NOREF#3808  -  []  184.98 335.21 90 top
NOREF#3809  -  []  336.44 264.79 0 top
NOREF#3810  -  []  412.08 270.01 0 top
NOREF#3811  -  []  297.34 203.1 90 top
NOREF#3812  -  []  286.25 255.33 0 top
NOREF#3813  -  []  502.07 275.9 90 top
NOREF#3814  -  []  226.24 237.29 0 top
NOREF#3815  -  []  451.65 275.06 0 top
NOREF#3816  -  []  328.51 196.36 0 top
NOREF#3817  -  []  293.33 257.97 0 top
NOREF#3818  -  []  330.07 185.6 0 top
NOREF#3819  -  []  281.8 294.95 0 top
NOREF#3820  -  []  330.07 190.47 0 top
NOREF#3821  -  []  368.09 200.49 90 top
NOREF#3822  -  []  254.96 93.18 0 top
NOREF#3823  -  []  279.47 199.92 0 top
NOREF#3824  -  []  209.66 225.9 90 top
NOREF#3825  -  []  417.34 203.1 90 top
NOREF#3826  -  []  188.31 225.86 90 top
NOREF#3827  -  []  325.13 255.99 0 top
NOREF#3828  -  []  409.87 256.73 0 top
NOREF#3829  -  []  260.73 174.04 0 top
NOREF#3830  -  []  511.9 211.37 90 top
NOREF#3831  -  []  469.97 378.52 90 top
NOREF#3832  -  []  386.14 183.1 0 top
NOREF#3833  -  []  315.6 277.7 0 top
NOREF#3834  -  []  332.38 288.89 0 top
NOREF#3835  -  []  326.52 382.58 0 top
NOREF#3836  -  []  477.16 191.16 0 top
NOREF#3837  -  []  364.1 259 0 top
NOREF#3838  -  []  346.14 179.9 90 top
NOREF#3839  -  []  410.97 250.15 0 top
NOREF#3840  -  []  216.24 237.29 0 top
NOREF#3841  -  []  439.74 282.3 90 top
NOREF#3842  -  []  507.05 334.96 90 top
NOREF#3843  -  []  406.23 247.42 0 top
NOREF#3844  -  []  308.88 208.98 0 top
NOREF#3845  -  []  331.14 245.99 90 top
NOREF#3846  -  []  411.07 256.08 90 top
NOREF#3847  -  []  413.23 262.51 0 top
NOREF#3848  -  []  280.3 177 90 top
NOREF#3849  -  []  453.02 250.6 90 top
NOREF#3850  -  []  224.59 167.31 0 top
NOREF#3851  -  []  317.29 122.71 0 top
NOREF#3852  -  []  415.13 212.93 90 top
NOREF#3853  -  []  52.77 6.56 0 top
NOREF#3854  -  []  260.3 213 0 top
NOREF#3855  -  []  368.29 251.82 0 top
NOREF#3856  -  []  211.84 237.29 0 top
NOREF#3857  -  []  409.31 191.29 90 top
NOREF#3858  -  []  283.59 95.22 90 top
NOREF#3859  -  []  409.35 270.01 0 top
NOREF#3860  -  []  521.42 259.21 0 top
NOREF#3861  -  []  258.24 169.41 0 top
NOREF#3862  -  []  286.4 227.56 90 top
NOREF#3863  -  []  320.89 191.48 90 top
NOREF#3864  -  []  324.8 248.34 0 top
NOREF#3865  -  []  401.57 259.65 90 top
NOREF#3866  -  []  334.43 207.08 90 top
NOREF#3867  -  []  520.17 289.43 90 top
NOREF#3868  -  []  256.93 219.45 90 top
NOREF#3869  -  []  423.75 179.75 0 top
NOREF#3870  -  []  471.13 242.7 0 top
NOREF#3871  -  []  289.77 192.68 0 top
NOREF#3872  -  []  369.29 255.34 90 top
NOREF#3873  -  []  164.15 -41.86 90 top
NOREF#3874  -  []  330.99 192.65 0 top
NOREF#3875  -  []  293.23 204.81 0 top
NOREF#3876  -  []  325.1 254.08 0 top
NOREF#3877  -  []  290.07 190.47 0 top
NOREF#3878  -  []  175.18 279.37 0 top
NOREF#3879  -  []  482.91 193.82 90 top
NOREF#3880  -  []  300.3 213 0 top
NOREF#3881  -  []  280.37 260.29 0 top
NOREF#3882  -  []  286.58 247.42 0 top
NOREF#3883  -  []  249.33 185.16 0 top
NOREF#3884  -  []  253.73 212.44 0 top
NOREF#3885  -  []  520.17 228.11 90 top
NOREF#3886  -  []  408.44 138.05 0 top
NOREF#3887  -  []  288.76 209.36 90 top
NOREF#3888  -  []  204.81 295.88 0 top
NOREF#3889  -  []  57.77 1.56 90 top
NOREF#3890  -  []  320.8 200 0 top
NOREF#3891  -  []  336.28 137.19 0 top
NOREF#3892  -  []  259.98 302.34 90 top
NOREF#3893  -  []  285.7 188.02 0 top
NOREF#3894  -  []  281.57 199.65 90 top
NOREF#3895  -  []  409.29 255.34 90 top
NOREF#3896  -  []  330.35 250.17 0 top
NOREF#3897  -  []  333.02 257.65 0 top
NOREF#3898  -  []  322.31 75.65 0 top
NOREF#3899  -  []  374.3 200.8 90 top
NOREF#3900  -  []  359.47 202.74 0 top
NOREF#3901  -  []  449.82 277.69 0 top
NOREF#3902  -  []  428.82 190.38 0 top
NOREF#3903  -  []  368.3 205 0 top
NOREF#3904  -  []  222.88 88.56 90 top
NOREF#3905  -  []  365.1 254.72 0 top
NOREF#3906  -  []  221.09 286.08 90 top
NOREF#3907  -  []  283.34 273.34 0 top
NOREF#3908  -  []  297.34 200.35 90 top
NOREF#3909  -  []  370.3 206.6 90 top
NOREF#3910  -  []  182.03 179.78 0 top
NOREF#3911  -  []  316.1 286.51 0 top
NOREF#3912  -  []  332.71 105.96 90 top
NOREF#3913  -  []  344.8 45.5 0 top
NOREF#3914  -  []  493.99 267 0 top
NOREF#3915  -  []  188.31 260.15 90 top
NOREF#3916  -  []  466.31 183.92 0 top
NOREF#3917  -  []  281.7 209.32 0 top
NOREF#3918  -  []  334.58 288.89 0 top
NOREF#3919  -  []  404.97 102.82 0 top
NOREF#3920  -  []  474.92 86.94 90 top
NOREF#3921  -  []  179.95 222.5 0 top
NOREF#3922  -  []  333.36 250.09 0 top
NOREF#3923  -  []  505.42 182.52 0 top
NOREF#3924  -  []  332.33 267.4 0 top
NOREF#3925  -  []  428.82 231.68 0 top
NOREF#3926  -  []  224.59 201.6 0 top
NOREF#3927  -  []  343.3 190 90 top
NOREF#3928  -  []  309.18 200.49 90 top
NOREF#3929  -  []  365.76 200.49 90 top
NOREF#3930  -  []  340.93 98.31 90 top
NOREF#3931  -  []  276.62 95.22 90 top
NOREF#3932  -  []  253.73 246.73 0 top
NOREF#3933  -  []  293.33 199.35 0 top
NOREF#3934  -  []  399.35 228.96 0 top
NOREF#3935  -  []  497.31 203.81 90 top
NOREF#3936  -  []  468.93 174.12 0 top
NOREF#3937  -  []  290.97 250.15 0 top
NOREF#3938  -  []  181.48 190.41 90 top
NOREF#3939  -  []  391.3 282 0 top
NOREF#3940  -  []  289.35 270.01 0 top
NOREF#3941  -  []  328.95 196.35 0 top
NOREF#3942  -  []  324.1 97.42 90 top
NOREF#3943  -  []  416.84 174.18 0 top
NOREF#3944  -  []  406.94 269.1 90 top
NOREF#3945  -  []  417.66 242.01 0 top
NOREF#3946  -  []  500.45 128.87 90 top
NOREF#3947  -  []  505.67 279.95 90 top
NOREF#3948  -  []  212.68 98.31 90 top
NOREF#3949  -  []  332.39 106.86 0 top
NOREF#3950  -  []  340.03 99.27 0 top
NOREF#3951  -  []  266.31 227.1 90 top
NOREF#3952  -  []  515.59 373.84 90 top
NOREF#3953  -  []  253.73 253.74 0 top
NOREF#3954  -  []  368.51 196.36 0 top
NOREF#3955  -  []  508.74 262.4 90 top
NOREF#3956  -  []  209.09 87.58 0 top
NOREF#3957  -  []  214.04 184.61 0 top
NOREF#3958  -  []  235.49 243.15 90 top
NOREF#3959  -  []  368.66 191.82 0 top
NOREF#3960  -  []  364.2 194.4 0 top
NOREF#3961  -  []  488.59 282.2 90 top
NOREF#3962  -  []  366.9 267.17 0 top
NOREF#3963  -  []  308.88 268.98 0 top
NOREF#3964  -  []  188.98 278.84 0 top
NOREF#3965  -  []  453.52 97.42 90 top
NOREF#3966  -  []  182.03 168.35 90 top
NOREF#3967  -  []  256.93 171.14 90 top
NOREF#3968  -  []  333.32 259.35 0 top
NOREF#3969  -  []  319.47 261.29 0 top
NOREF#3970  -  []  411.52 254.76 90 top
NOREF#3971  -  []  482.56 191.16 0 top
NOREF#3972  -  []  516.65 299.27 90 top
NOREF#3973  -  []  210.19 174.57 0 top
NOREF#3974  -  []  320.37 199.6 0 top
NOREF#3975  -  []  361.81 294.95 0 top
NOREF#3976  -  []  322.31 73.45 90 top
NOREF#3977  -  []  202.61 184.61 0 top
NOREF#3978  -  []  324.8 244.64 0 top
NOREF#3979  -  []  403.33 206.03 0 top
NOREF#3980  -  []  477.16 198.42 0 top
NOREF#3981  -  []  311.3 222 0 top
NOREF#3982  -  []  374.22 259.67 0 top
NOREF#3983  -  []  365.97 253.75 0 top
NOREF#3984  -  []  200.41 261.59 0 top
NOREF#3985  -  []  414.12 297.54 0 top
NOREF#3986  -  []  404.81 83.52 90 top
NOREF#3987  -  []  155.68 299.48 0 top
NOREF#3988  -  []  319.47 200.61 0 top
NOREF#3989  -  []  269.13 288.82 90 top
NOREF#3990  -  []  414.43 203.38 90 top
NOREF#3991  -  []  451.91 261.14 0 top
NOREF#3992  -  []  368.82 269.11 90 top
NOREF#3993  -  []  412.4 269.11 90 top
NOREF#3994  -  []  367.68 200.19 0 top
NOREF#3995  -  []  339.69 89.67 0 top
NOREF#3996  -  []  395.6 277.7 0 top
NOREF#3997  -  []  294.73 175.45 0 top
NOREF#3998  -  []  462.76 298.09 90 top
NOREF#3999  -  []  403.63 205.5 0 top
NOREF#4000  -  []  366.57 255.72 0 top
NOREF#4001  -  []  268.75 79.79 0 top
NOREF#4002  -  []  514.57 294.06 90 top
NOREF#4003  -  []  361.55 285.71 0 top
NOREF#4004  -  []  511.37 244.5 0 top
NOREF#4005  -  []  259.15 90.74 0 top
NOREF#4006  -  []  406.33 195.34 90 top
NOREF#4007  -  []  494.38 379.8 0 top
NOREF#4008  -  []  404.2 254.4 0 top
NOREF#4009  -  []  295.42 199.88 90 top
NOREF#4010  -  []  198.23 243.15 90 top
NOREF#4011  -  []  251.53 185.16 0 top
NOREF#4012  -  []  369.71 255.72 90 top
NOREF#4013  -  []  405.7 184.32 90 top
NOREF#4014  -  []  228.44 168.71 0 top
NOREF#4015  -  []  364.5 246.78 0 top
NOREF#4016  -  []  404.75 278.11 90 top
NOREF#4017  -  []  333.03 213.89 0 top
NOREF#4018  -  []  457.37 381.09 0 top
NOREF#4019  -  []  288.08 195.55 0 top
NOREF#4020  -  []  251.53 239.72 0 top
NOREF#4021  -  []  366.9 247.37 90 top
NOREF#4022  -  []  284.5 186.78 0 top
NOREF#4023  -  []  366.38 296.27 90 top
NOREF#4024  -  []  514.57 225.48 90 top
NOREF#4025  -  []  369.34 186.99 0 top
NOREF#4026  -  []  196.58 244.55 90 top
NOREF#4027  -  []  182.03 248.36 90 top
NOREF#4028  -  []  376.8 199 90 top
NOREF#4029  -  []  285.7 186.14 90 top
NOREF#4030  -  []  426.14 179.9 90 top
NOREF#4031  -  []  321.41 360.96 90 top
NOREF#4032  -  []  52.77 405.06 0 top
NOREF#4033  -  []  287.13 84.79 90 top
NOREF#4034  -  []  440.89 80.68 90 top
NOREF#4035  -  []  325.7 188.02 0 top
NOREF#4036  -  []  439.67 223.27 0 top
NOREF#4037  -  []  280.8 200 0 top
NOREF#4038  -  []  284.53 203.69 90 top
NOREF#4039  -  []  442 82 0 top
NOREF#4040  -  []  285.7 184.32 90 top
NOREF#4041  -  []  364.75 278.11 90 top
NOREF#4042  -  []  359.47 84.5 90 top
NOREF#4043  -  []  339.69 290.04 90 top
NOREF#4044  -  []  356.1 286.51 0 top
NOREF#4045  -  []  288.09 195.99 0 top
NOREF#4046  -  []  294.67 251.62 90 top
NOREF#4047  -  []  411.52 194.76 90 top
NOREF#4048  -  []  364.1 259 90 top
NOREF#4049  -  []  444.87 103.62 0 top
NOREF#4050  -  []  198.23 235.89 90 top
NOREF#4051  -  []  286.3 267 0 top
NOREF#4052  -  []  286.9 260.19 0 top
NOREF#4053  -  []  488.59 170.92 90 top
NOREF#4054  -  []  55.8 0 90 top
NOREF#4055  -  []  328.46 256.44 0 top
NOREF#4056  -  []  453.52 99.62 90 top
NOREF#4057  -  []  399.47 210.08 0 top
NOREF#4058  -  []  287.69 294.51 90 top
NOREF#4059  -  []  366.3 207 0 top
NOREF#4060  -  []  364.57 196.05 90 top
NOREF#4061  -  []  287.08 257.69 0 top
NOREF#4062  -  []  498.77 367.16 90 top
NOREF#4063  -  []  155.68 288.05 0 top
NOREF#4064  -  []  514.57 207.02 90 top
NOREF#4065  -  []  408.56 254.22 0 top
NOREF#4066  -  []  146.75 421.44 0 top
NOREF#4067  -  []  406.82 187.81 90 top
NOREF#4068  -  []  213.15 378.53 0 top
NOREF#4069  -  []  399.47 262.74 0 top
NOREF#4070  -  []  497.31 255.14 90 top
NOREF#4071  -  []  337.63 87.9 0 top
NOREF#4072  -  []  372.08 270.01 0 top
NOREF#4073  -  []  303.3 220 0 top
NOREF#4074  -  []  505.42 267 0 top
NOREF#4075  -  []  235.49 201.6 90 top
NOREF#4076  -  []  332.08 210.01 0 top
NOREF#4077  -  []  182.03 168.35 0 top
NOREF#4078  -  []  320.97 87.33 0 top
NOREF#4079  -  []  230.87 261.59 90 top
NOREF#4080  -  []  644.99 467.74 0 top
NOREF#4081  -  []  193.38 244.55 0 top
NOREF#4082  -  []  442.87 216.26 0 top
NOREF#4083  -  []  415.42 199.88 90 top
NOREF#4084  -  []  415.13 95.22 90 top
NOREF#4085  -  []  181.48 270.42 90 top
NOREF#4086  -  []  527.4 396.4 0 top
NOREF#4087  -  []  312.28 201.89 0 top
NOREF#4088  -  []  300.3 197 90 top
NOREF#4089  -  []  410.18 228.89 0 top
NOREF#4090  -  []  459.65 364.96 90 top
NOREF#4091  -  []  376.84 174.18 0 top
NOREF#4092  -  []  489.17 261.14 0 top
NOREF#4093  -  []  343.3 250 90 top
NOREF#4094  -  []  279.69 301.38 0 top
NOREF#4095  -  []  186.51 189.52 0 top
NOREF#4096  -  []  50.8 5 0 top
NOREF#4097  -  []  334.73 175.45 0 top
NOREF#4098  -  []  334.22 260.52 0 top
NOREF#4099  -  []  273.42 102.82 0 top
NOREF#4100  -  []  179.95 291.08 0 top
NOREF#4101  -  []  225.75 373.44 90 top
NOREF#4102  -  []  412.9 171.35 90 top
NOREF#4103  -  []  466.61 361.76 0 top
NOREF#4104  -  []  318.02 79.81 0 top
NOREF#4105  -  []  407.88 269.1 90 top
NOREF#4106  -  []  290.62 193.99 90 top
NOREF#4107  -  []  202.61 168.71 0 top
NOREF#4108  -  []  274.08 200.75 90 top
NOREF#4109  -  []  462.76 290.83 90 top
NOREF#4110  -  []  179.95 193.59 90 top
NOREF#4111  -  []  411.8 261.5 90 top
NOREF#4112  -  []  193.33 224.34 0 top
NOREF#4113  -  []  480.36 191.16 0 top
NOREF#4114  -  []  376.44 204.79 0 top
NOREF#4115  -  []  274.94 103.62 0 top
NOREF#4116  -  []  283.33 206.03 0 top
NOREF#4117  -  []  198.23 167.31 90 top
NOREF#4118  -  []  252.26 168.58 0 top
NOREF#4119  -  []  375.42 259.03 90 top
NOREF#4120  -  []  374.5 249.29 90 top
NOREF#4121  -  []  382.13 69.24 90 top
NOREF#4122  -  []  216.24 253.19 0 top
NOREF#4123  -  []  415.16 179.12 0 top
NOREF#4124  -  []  488.59 242.7 0 top
NOREF#4125  -  []  406.33 187.99 90 top
NOREF#4126  -  []  325.68 245.52 90 top
NOREF#4127  -  []  365.3 207 90 top
NOREF#4128  -  []  373.23 267.72 0 top
NOREF#4129  -  []  488.59 198.42 0 top
NOREF#4130  -  []  416.44 200.67 0 top
NOREF#4131  -  []  284.75 280.31 90 top
NOREF#4132  -  []  327.93 244.02 90 top
NOREF#4133  -  []  240.95 292.53 0 top
NOREF#4134  -  []  209.99 89.67 0 top
NOREF#4135  -  []  262.63 167.56 90 top
NOREF#4136  -  []  399.15 268.8 0 top
NOREF#4137  -  []  293.33 200.2 0 top
NOREF#4138  -  []  291.82 205.24 0 top
NOREF#4139  -  []  421.42 238.2 90 top
NOREF#4140  -  []  487.32 360.96 0 top
NOREF#4141  -  []  373.32 197.97 0 top
NOREF#4142  -  []  376.8 259 90 top
NOREF#4143  -  []  330.07 192.35 0 top
NOREF#4144  -  []  491.79 242.7 0 top
NOREF#4145  -  []  182.03 228.69 90 top
NOREF#4146  -  []  279.47 270.08 0 top
NOREF#4147  -  []  264.61 293.09 90 top
NOREF#4148  -  []  334.43 205.59 90 top
NOREF#4149  -  []  328.07 193.43 90 top
NOREF#4150  -  []  204.81 227.3 0 top
NOREF#4151  -  []  368.24 295.31 0 top
NOREF#4152  -  []  327.12 359.7 0 top
NOREF#4153  -  []  366.38 298.84 90 top
NOREF#4154  -  []  238.62 196.21 0 top
NOREF#4155  -  []  321.8 297.54 0 top
NOREF#4156  -  []  442.87 284.84 0 top
NOREF#4157  -  []  320.3 237 90 top
NOREF#4158  -  []  373.32 257.12 0 top
NOREF#4159  -  []  310.18 74.6 0 top
NOREF#4160  -  []  313.94 333.78 0 top
NOREF#4161  -  []  505.92 245.31 0 top
NOREF#4162  -  []  294.73 172.88 0 top
NOREF#4163  -  []  311.54 183.1 0 top
NOREF#4164  -  []  335.42 259.88 90 top
NOREF#4165  -  []  327.82 209.36 90 top
NOREF#4166  -  []  301.05 295.32 0 top
NOREF#4167  -  []  521.42 185.13 90 top
NOREF#4168  -  []  202.61 244.55 0 top
NOREF#4169  -  []  514.57 284.82 90 top
NOREF#4170  -  []  288.07 253.43 90 top
NOREF#4171  -  []  366.4 287.55 90 top
NOREF#4172  -  []  214.04 287.48 0 top
NOREF#4173  -  []  293.93 213.57 0 top
NOREF#4174  -  []  328.3 265 0 top
NOREF#4175  -  []  328.1 199.55 90 top
NOREF#4176  -  []  225.47 193.01 0 top
NOREF#4177  -  []  408.82 269.11 90 top
NOREF#4178  -  []  406.29 178.5 90 top
NOREF#4179  -  []  376.84 169.02 0 top
NOREF#4180  -  []  286.33 247.99 90 top
NOREF#4181  -  []  333.3 257.5 90 top
NOREF#4182  -  []  323.05 255.79 90 top
NOREF#4183  -  []  364.1 199 90 top
NOREF#4184  -  []  326.33 255.34 90 top
NOREF#4185  -  []  325.32 373.44 90 top
NOREF#4186  -  []  374.42 207.08 90 top
NOREF#4187  -  []  336.14 205.11 0 top
NOREF#4188  -  []  399.47 260.61 0 top
NOREF#4189  -  []  182.03 242.33 90 top
NOREF#4190  -  []  296.8 199 90 top
NOREF#4191  -  []  409.61 199.55 90 top
NOREF#4192  -  []  210.19 201.6 0 top
NOREF#4193  -  []  389.73 301.18 90 top
NOREF#4194  -  []  294.3 268.85 90 top
NOREF#4195  -  []  462.76 198.42 0 top
NOREF#4196  -  []  285.76 200.49 90 top
NOREF#4197  -  []  390.69 90.74 0 top
NOREF#4198  -  []  441.4 81.48 0 top
NOREF#4199  -  []  466.31 295.43 0 top
NOREF#4200  -  []  413.23 202.51 0 top
NOREF#4201  -  []  640.8 0 90 top
NOREF#4202  -  []  505.42 301.29 0 top
NOREF#4203  -  []  443.2 83.52 90 top
NOREF#4204  -  []  289.34 186.99 0 top
NOREF#4205  -  []  489.17 234.11 0 top
NOREF#4206  -  []  284.8 196.37 0 top
NOREF#4207  -  []  28.17 365.77 0 top
NOREF#4208  -  []  437.18 169.66 0 top
NOREF#4209  -  []  13.59 386.31 0 top
NOREF#4210  -  []  329.13 191.83 90 top
NOREF#4211  -  []  200.41 295.88 0 top
NOREF#4212  -  []  324.2 254.4 0 top
NOREF#4213  -  []  412.01 298.81 0 top
NOREF#4214  -  []  521.42 179.2 0 top
NOREF#4215  -  []  283.33 265.18 0 top
NOREF#4216  -  []  292.55 335.47 0 top
NOREF#4217  -  []  302.19 70.18 90 top
NOREF#4218  -  []  405.7 244.32 90 top
NOREF#4219  -  []  373.23 206.23 0 top
NOREF#4220  -  []  412.17 189.51 90 top
NOREF#4221  -  []  271.47 81.48 0 top
NOREF#4222  -  []  573.55 84.96 90 top
NOREF#4223  -  []  318.05 133.55 90 top
NOREF#4224  -  []  198.23 277.44 90 top
NOREF#4225  -  []  235.49 208.86 90 top
NOREF#4226  -  []  200.41 175.97 0 top
NOREF#4227  -  []  501.06 379.82 90 top
NOREF#4228  -  []  324.8 255.09 90 top
NOREF#4229  -  []  364.2 254.4 0 top
NOREF#4230  -  []  376.14 205.11 0 top
NOREF#4231  -  []  341.41 172.91 90 top
NOREF#4232  -  []  480.8 23.5 90 top
NOREF#4233  -  []  52.77 6.56 0 top
NOREF#4234  -  []  374.43 265.59 90 top
NOREF#4235  -  []  494.28 360.96 0 top
NOREF#4236  -  []  202.61 253.19 0 top
NOREF#4237  -  []  200.41 210.26 0 top
NOREF#4238  -  []  424.34 239.47 90 top
NOREF#4239  -  []  187.33 243.15 0 top
NOREF#4240  -  []  521.42 270.64 0 top
NOREF#4241  -  []  418.69 296.27 90 top
NOREF#4242  -  []  425.16 303.33 0 top
NOREF#4243  -  []  497.31 177.92 90 top
NOREF#4244  -  []  296.44 263.42 0 top
NOREF#4245  -  []  247.68 238.32 0 top
NOREF#4246  -  []  258.61 296.29 0 top
NOREF#4247  -  []  406.9 207.17 0 top
NOREF#4248  -  []  326.55 171.34 90 top
NOREF#4249  -  []  412 89.89 0 top
NOREF#4250  -  []  324.15 165.85 90 top
NOREF#4251  -  []  263.3 250 90 top
NOREF#4252  -  []  365.1 194.08 0 top
NOREF#4253  -  []  52.77 6.56 0 top
NOREF#4254  -  []  400.37 263.08 0 top
NOREF#4255  -  []  374.22 199.67 0 top
NOREF#4256  -  []  505.18 360.96 90 top
NOREF#4257  -  []  273.3 229.77 90 top
NOREF#4258  -  []  362.3 196.5 0 top
NOREF#4259  -  []  529.91 -41.86 90 top
NOREF#4260  -  []  273.3 180 90 top
NOREF#4261  -  []  193.38 237.29 0 top
NOREF#4262  -  []  366.9 200.19 0 top
NOREF#4263  -  []  363.01 122.71 0 top
NOREF#4264  -  []  407.93 184.02 90 top
NOREF#4265  -  []  52.77 405.06 0 top
NOREF#4266  -  []  457.37 378.53 0 top
NOREF#4267  -  []  282.04 71.58 90 top
NOREF#4268  -  []  257.82 300.61 0 top
NOREF#4269  -  []  294.11 69.97 0 top
NOREF#4270  -  []  406.9 256.05 90 top
NOREF#4271  -  []  428.82 183.37 0 top
NOREF#4272  -  []  312.72 378.53 0 top
NOREF#4273  -  []  325.32 378.52 90 top
NOREF#4274  -  []  489.17 268.4 0 top
NOREF#4275  -  []  411.55 249.53 90 top
NOREF#4276  -  []  445.07 195.99 0 top
NOREF#4277  -  []  281.7 209.33 0 top
NOREF#4278  -  []  279.35 288.95 0 top
NOREF#4279  -  []  326.9 207.17 0 top
NOREF#4280  -  []  414.22 196.16 90 top
NOREF#4281  -  []  382.85 246 45 top
NOREF#4282  -  []  430.8 446.5 0 top
NOREF#4283  -  []  401.57 269.12 90 top
NOREF#4284  -  []  358.83 207.9 90 top
NOREF#4285  -  []  227.67 253.19 0 top
NOREF#4286  -  []  187.11 190.05 0 top
NOREF#4287  -  []  280.46 89.89 0 top
NOREF#4288  -  []  374.73 172.88 0 top
NOREF#4289  -  []  520.87 258.12 90 top
NOREF#4290  -  []  509.5 279.95 0 top
NOREF#4291  -  []  191.18 287.48 0 top
NOREF#4292  -  []  286.9 207.17 0 top
NOREF#4293  -  []  175.18 256.51 0 top
NOREF#4294  -  []  329.35 270.01 0 top
NOREF#4295  -  []  279.15 268.8 0 top
NOREF#4296  -  []  300.81 206.84 90 top
NOREF#4297  -  []  348.53 118.31 90 top
NOREF#4298  -  []  332.9 173.55 90 top
NOREF#4299  -  []  498.8 446.5 0 top
NOREF#4300  -  []  242.47 189.96 90 top
NOREF#4301  -  []  497.31 280.79 90 top
NOREF#4302  -  []  346.68 268.98 0 top
NOREF#4303  -  []  212.33 97.33 90 top
NOREF#4304  -  []  406.9 200.19 0 top
NOREF#4305  -  []  373.23 264.81 0 top
NOREF#4306  -  []  384.27 302.45 0 top
NOREF#4307  -  []  297.43 210.27 0 top
NOREF#4308  -  []  228.44 237.29 0 top
NOREF#4309  -  []  317.89 147.59 90 top
NOREF#4310  -  []  253.73 178.15 0 top
NOREF#4311  -  []  406.62 270 0 top
NOREF#4312  -  []  364.48 255.99 0 top
NOREF#4313  -  []  155.68 276.62 0 top
NOREF#4314  -  []  260.3 273 0 top
NOREF#4315  -  []  321.57 261.78 90 top
NOREF#4316  -  []  517.92 296.25 0 top
NOREF#4317  -  []  200.41 244.55 0 top
NOREF#4318  -  []  186.51 223.81 0 top
NOREF#4319  -  []  294.5 189.29 90 top
NOREF#4320  -  []  289.31 191.29 90 top
NOREF#4321  -  []  290.67 250.47 90 top
NOREF#4322  -  []  476.41 99.27 0 top
NOREF#4323  -  []  144.63 371.18 90 top
NOREF#4324  -  []  286.13 185.02 0 top
NOREF#4325  -  []  290.67 191.75 90 top
NOREF#4326  -  []  404.48 246.16 0 top
NOREF#4327  -  []  181.48 247.56 90 top
NOREF#4328  -  []  410.97 252.03 90 top
NOREF#4329  -  []  371.82 205.24 0 top
NOREF#4330  -  []  286.58 187.42 0 top
NOREF#4331  -  []  493.99 216.81 0 top
NOREF#4332  -  []  333.13 122.11 0 top
NOREF#4333  -  []  439.67 195.99 0 top
NOREF#4334  -  []  521.42 207.99 90 top
NOREF#4335  -  []  364.81 152.43 0 top
NOREF#4336  -  []  224.59 208.86 0 top
NOREF#4337  -  []  404.53 263.69 90 top
NOREF#4338  -  []  516.65 264.98 90 top
NOREF#4339  -  []  452.45 210.01 0 top
NOREF#4340  -  []  25.88 365.13 0 top
NOREF#4341  -  []  546.8 45.5 0 top
NOREF#4342  -  []  379.43 287.49 90 top
NOREF#4343  -  []  370.55 209.37 90 top
NOREF#4344  -  []  480.36 232.71 0 top
NOREF#4345  -  []  283.33 264.33 0 top
NOREF#4346  -  []  388.88 268.98 0 top
NOREF#4347  -  []  466.31 252.5 0 top
NOREF#4348  -  []  325.3 207 90 top
NOREF#4349  -  []  370.97 250.15 0 top
NOREF#4350  -  []  374.42 264.17 90 top
NOREF#4351  -  []  264.5 298.07 90 top
NOREF#4352  -  []  418.02 335.54 90 top
NOREF#4353  -  []  295.13 212.93 90 top
NOREF#4354  -  []  24.41 340.37 0 top
NOREF#4355  -  []  285.92 286.51 0 top
NOREF#4356  -  []  368.5 270.01 0 top
NOREF#4357  -  []  284.48 255.99 0 top
NOREF#4358  -  []  363.98 259.6 90 top
NOREF#4359  -  []  324.57 196.05 90 top
NOREF#4360  -  []  363.77 151.39 0 top
NOREF#4361  -  []  216.24 175.97 0 top
NOREF#4362  -  []  55.8 0 90 top
NOREF#4363  -  []  428.93 190.75 0 top
NOREF#4364  -  []  327.29 301.68 90 top
NOREF#4365  -  []  466.31 199.82 0 top
NOREF#4366  -  []  23.09 345.09 90 top
NOREF#4367  -  []  315.6 217.7 0 top
NOREF#4368  -  []  306.14 173.54 90 top
NOREF#4369  -  []  294.43 204.17 90 top
NOREF#4370  -  []  370.99 252.65 0 top
NOREF#4371  -  []  369.7 176.75 0 top
