# Allegro board 038RT-8730CN_1008V3_5.brd (continued)
## Nets (continued)
S0123_CBIT_003: K6.8(V-) SW1.6 UNK1K6.8 UNK2K6.8 UNK3K6.8
S0123_CBIT_004: K2.8(V-) SW1.2 UNK1K2.8 UNK2K2.8 UNK3K2.8
S0123_CBIT_005: K3.8(V-) SW1.3 UNK1K3.8 UNK2K3.8 UNK3K3.8
S0123_CBIT_006: K35.8(V-) SW4.8 UNK1K35.8 UNK2K35.8 UNK3K35.8
S0123_CBIT_007: K33.8(V-) SW4.6 UNK2K33.8
S0123_CBIT_008: K30.8(V-) SW4.3 UNK1K30.8 UNK2K30.8 UNK3K30.8
S0123_CBIT_009: K32.8(V-) SW4.5 UNK1K32.8 UNK2K32.8 UNK3K32.8
S0123_CBIT_010: K31.8(V-) SW4.4 UNK1K31.8 UNK2K31.8 UNK3K31.8
S0123_CBIT_011: K29.8(V-) SW4.2 UNK1K29.8 UNK2K29.8 UNK3K29.8
S0123_CBIT_012: K28.8(V-) SW4.1 UNK1K28.8 UNK2K28.8 UNK3K28.8
S0123_CBIT_013: K8.8(V-) SW1.8 UNK1K8.8 UNK2K8.8 UNK3K8.8
S0123_CBIT_014: K26.8(V-) SW3.8 UNK1K26.8 UNK2K26.8 UNK3K26.8
S0123_CBIT_015: K34.8(V-) SW4.7 UNK1K34.8 UNK2K34.8 UNK3K34.8
S0123_CBIT_016: K16.8(V-) SW2.8 UNK1K16.8 UNK2K16.8 UNK3K16.8
S0123_CBIT_017: K21.8(V-) SW3.4 UNK1K21.8 UNK2K21.8 UNK3K21.8
S0123_CBIT_018: K18.8(V-) SW3.1 UNK1K18.8 UNK2K18.8 UNK3K18.8
S0123_CBIT_019: K22.8(V-) SW3.5 UNK1K22.8 UNK2K22.8 UNK3K22.8
S0123_CBIT_020: K9.8(V-) SW2.1 UNK1K9.8 UNK2K9.8 UNK3K9.8
S0123_CBIT_022: K19.8(V-) SW3.2 UNK1K19.8 UNK2K19.8 UNK3K19.8
S0123_CBIT_023: K23.8(V-) SW3.6 UNK1K23.8 UNK2K23.8 UNK3K23.8
S0123_CBIT_024: K20.8(V-) SW3.3 UNK1K20.8 UNK2K20.8 UNK3K20.8
S0123_CBIT_025: K13.8(V-) SW2.5 UNK1K13.8 UNK2K13.8 UNK3K13.8
S0123_CBIT_026: K14.8(V-) SW2.6 UNK1K14.8 UNK2K14.8 UNK3K14.8
S0123_CBIT_027: K15.8(V-) SW2.7 UNK1K15.8 UNK2K15.8 UNK3K15.8
S0123_CBIT_028: K25.8(V-) SW3.7 UNK1K25.8 UNK2K25.8 UNK3K25.8
S0123_CBIT_029: K10.8(V-) SW2.2 UNK1K10.8 UNK2K10.8 UNK3K10.8
S0123_CBIT_030: K11.8(V-) SW2.3 UNK1K11.8 UNK2K11.8 UNK3K11.8
S0123_CBIT_031: K12.8(V-) SW2.4 UNK1K12.8 UNK2K12.8 UNK3K12.8
S0123_CBIT_032: K39.8(V-) SW7.4 UNK1K39.8 UNK2K39.8 UNK3K39.8
S0123_CBIT_033: K1.8(V-) SW1.1 UNK1K1.8 UNK2K1.8 UNK3K1.8
S0123_CBIT_034: K38.8(V-) SW7.3 UNK2K38.8
S0123_CBIT_035: K5.9(V-) SW1.5 UNK1K5.9 UNK2K5.9 UNK3K5.9
S0123_CBIT_036: K36.8(V-) SW7.1 UNK1K36.8 UNK2K36.8 UNK3K36.8
S0123_CBIT_037: K4.8(V-) SW1.4 UNK1K4.8 UNK2K4.8 UNK3K4.8
S4567_CBIT_001: UNK4K7.9 UNK4SW1.7 UNK5K7.9 UNK6K7.9 UNK7K7.9
S4567_CBIT_002: UNK4K37.8 UNK4SW7.2 UNK6K37.8
S4567_CBIT_003: UNK4K6.8 UNK4SW1.6 UNK5K6.8 UNK6K6.8 UNK7K6.8
S4567_CBIT_004: UNK4K2.8 UNK4SW1.2 UNK5K2.8 UNK6K2.8 UNK7K2.8
S4567_CBIT_005: UNK4K3.8 UNK4SW1.3 UNK5K3.8 UNK6K3.8 UNK7K3.8
S4567_CBIT_006: UNK4K35.8 UNK4SW4.8 UNK5K35.8 UNK6K35.8 UNK7K35.8
S4567_CBIT_007: UNK4K33.8 UNK4SW4.6 UNK6K33.8
S4567_CBIT_008: UNK4K30.8 UNK4SW4.3 UNK5K30.8 UNK6K30.8 UNK7K30.8
S4567_CBIT_009: UNK4K32.8 UNK4SW4.5 UNK5K32.8 UNK6K32.8 UNK7K32.8
S4567_CBIT_010: UNK4K31.8 UNK4SW4.4 UNK5K31.8 UNK6K31.8 UNK7K31.8
S4567_CBIT_011: UNK4K29.8 UNK4SW4.2 UNK5K29.8 UNK6K29.8 UNK7K29.8
S4567_CBIT_012: UNK4K28.8 UNK4SW4.1 UNK5K28.8 UNK6K28.8 UNK7K28.8
S4567_CBIT_013: UNK4K8.8 UNK4SW1.8 UNK5K8.8 UNK6K8.8 UNK7K8.8
S4567_CBIT_014: UNK4K26.8 UNK4SW3.8 UNK5K26.8 UNK6K26.8 UNK7K26.8
S4567_CBIT_015: UNK4K34.8 UNK4SW4.7 UNK5K34.8 UNK6K34.8 UNK7K34.8
S4567_CBIT_016: UNK4K16.8 UNK4SW2.8 UNK5K16.8 UNK6K16.8 UNK7K16.8
S4567_CBIT_017: UNK4K21.8 UNK4SW3.4 UNK5K21.8 UNK6K21.8 UNK7K21.8
S4567_CBIT_018: UNK4K18.8 UNK4SW3.1 UNK5K18.8 UNK6K18.8 UNK7K18.8
S4567_CBIT_019: UNK4K22.8 UNK4SW3.5 UNK5K22.8 UNK6K22.8 UNK7K22.8
S4567_CBIT_020: UNK4K9.8 UNK4SW2.1 UNK5K9.8 UNK6K9.8 UNK7K9.8
S4567_CBIT_022: UNK4K19.8 UNK4SW3.2 UNK5K19.8 UNK6K19.8 UNK7K19.8
S4567_CBIT_023: UNK4K23.8 UNK4SW3.6 UNK5K23.8 UNK6K23.8 UNK7K23.8
S4567_CBIT_024: UNK4K20.8 UNK4SW3.3 UNK5K20.8 UNK6K20.8 UNK7K20.8
S4567_CBIT_025: UNK4K13.8 UNK4SW2.5 UNK5K13.8 UNK6K13.8 UNK7K13.8
S4567_CBIT_026: UNK4K14.8 UNK4SW2.6 UNK5K14.8 UNK6K14.8 UNK7K14.8
S4567_CBIT_027: UNK4K15.8 UNK4SW2.7 UNK5K15.8 UNK6K15.8 UNK7K15.8
S4567_CBIT_028: UNK4K25.8 UNK4SW3.7 UNK5K25.8 UNK6K25.8 UNK7K25.8
S4567_CBIT_029: UNK4K10.8 UNK4SW2.2 UNK5K10.8 UNK6K10.8 UNK7K10.8
S4567_CBIT_030: UNK4K11.8 UNK4SW2.3 UNK5K11.8 UNK6K11.8 UNK7K11.8
S4567_CBIT_031: UNK4K12.8 UNK4SW2.4 UNK5K12.8 UNK6K12.8 UNK7K12.8
S4567_CBIT_032: UNK4K39.8 UNK4SW7.4 UNK5K39.8 UNK6K39.8 UNK7K39.8
S4567_CBIT_033: UNK4K1.8 UNK4SW1.1 UNK5K1.8 UNK6K1.8 UNK7K1.8
S4567_CBIT_034: UNK4K38.8 UNK4SW7.3 UNK6K38.8
S4567_CBIT_035: UNK4K5.9 UNK4SW1.5 UNK5K5.9 UNK6K5.9 UNK7K5.9
S4567_CBIT_036: UNK4K36.8 UNK4SW7.1 UNK5K36.8 UNK6K36.8 UNK7K36.8
S4567_CBIT_037: UNK4K4.8 UNK4SW1.4 UNK5K4.8 UNK6K4.8 UNK7K4.8
SA_CBIT_021: KT1.8(V-) SW7.5
SA_DPS_F005: CT16.1 CT17.1 CT18.1 CT19.1 CT20.1 CT21.1 ST1.2 TEMP_MEASUREMENT.1(TP) UT1.4(VDD)
SA_DPS_GS005: ST2.1
SA_DPS_S005: ST1.1
SA_IO_TMP235ADC_2: CT1.1 CT15.1 KT1.4 RT1.1
SC_1_ATX_5V_SRC: BDB76.1 BDB77.1 CB635.1 CB636.1 CB637.1 FUSEB2.2
SC_1_ATX_12V_SRC: BDB74.1 BDB75.1 CB638.1 CB639.1 CB640.1 FUSEB3.2
SC_ATX_3V3_SRC: CB631.1 FUSEB1.1 JB1.1(+3.3V(1)) JB1.2(+3.3V(2)) JB1.11(+3.3V(3))
SC_ATX_5V_SRC: FUSEB2.1 JB1.4(+5V(1)) JB1.6(+5V(2)) JB1.19(+5V(3)) JB1.20(+5V(4))
SC_ATX_12V_SRC: FUSEB3.1 JB1.10(+12V)
SC_ATX_POWER_ON: JB1.14(POWER_ON) SWB1.2
SC_ATX_VD0V9_COM: ATX_VD0V9.1 ATX_VD0V9.3 ATX_VD0V9.5 ATX_VD0V9.7 ATX_VD0V9.9 ATX_VD0V9.11 ATX_VD0V9.13 ATX_VD0V9.15 BDB87.2 CB709.1
SC_ATX_VD0V9_LED: LDB22.1(A) RB622.2
SC_ATX_VD0V9_SW: CB703.2 LB4.1 RB619.1 UB73.3(SW)
SC_ATX_VD0V9_VOUT: BDB87.1 CB705.1 CB706.1 CB707.1 CB708.1 LB4.2 RB620.2 RB622.1
SC_ATX_VD1V8_COM: ATX_VD1V8.1 ATX_VD1V8.3 ATX_VD1V8.5 ATX_VD1V8.7 ATX_VD1V8.9 ATX_VD1V8.11 ATX_VD1V8.13 ATX_VD1V8.15 BDB83.2 CB679.1
SC_ATX_VD1V8_LED: LDB20.1(A) RB608.2
SC_ATX_VD1V8_SW: CB673.2 LB2.1 RB605.1 UB71.3(SW)
SC_ATX_VD1V8_VOUT: BDB83.1 CB675.1 CB676.1 CB677.1 CB678.1 LB2.2 RB606.2 RB608.1
SC_ATX_VD33_COM: ATX_VD33.1 ATX_VD33.3 ATX_VD33.5 ATX_VD33.7 ATX_VD33.9 ATX_VD33.11 ATX_VD33.13 ATX_VD33.15 BDB81.2 CB664.1
SC_ATX_VD33_LED: LDB19.1(A) RB601.2
SC_ATX_VD33_SW: CB658.2 LB1.1 RB598.1 UB70.3(SW)
SC_ATX_VD33_VOUT: BDB81.1 CB660.1 CB661.1 CB662.1 CB663.1 LB1.2 RB599.2 RB601.1
SC_BOOT_U70: RB597.1 UB70.1(BOOT)
SC_BOOT_U71: RB604.1 UB71.1(BOOT)
SC_BOOT_U73: RB618.1 UB73.1(BOOT)
SC_COMP_RC_U70: CB651.2 RB595.1
SC_COMP_RC_U71: CB666.2 RB623.1 RB624.1
SC_COMP_RC_U73: CB696.2 RB627.1 RB628.1
SC_COMP_U70: CB651.1 CB652.1 UB70.6(COMP)
SC_COMP_U71: CB666.1 CB667.1 UB71.6(COMP)
SC_COMP_U73: CB696.1 CB697.1 UB73.6(COMP)
SC_EN_U70: RB596.2 UB70.7(EN)
SC_EN_U71: RB603.2 UB71.7(EN)
SC_EN_U73: RB617.2 UB73.7(EN)
SC_FB_U70: CB660.2 RB599.1 RB600.1 UB70.5(FB)
SC_FB_U71: CB675.2 RB606.1 RB607.1 UB71.5(FB)
SC_FB_U73: CB705.2 RB620.1 RB621.1 UB73.5(FB)
SC_HOLD_UB1: RB205.2 UB5.3(W\P\) UB5.7(H\O\L\D\)
SC_SS_U70: CB650.2 UB70.8(SS)
SC_SS_U71: CB665.2 UB71.8(SS)
SC_SS_U73: CB695.2 UB73.8(SS)
SC_SW_RC_U70: CB659.1 RB598.2
SC_SW_RC_U71: CB674.1 RB605.2
SC_SW_RC_U73: CB704.1 RB619.2
SC_VIN_U70: BDB80.2 CB653.2 CB654.1 CB655.1 RB596.1 UB70.2(VIN)
SC_VIN_U71: BDB82.2 CB668.2 CB669.1 CB670.1 RB603.1 UB71.2(VIN)
SC_VIN_U73: BDB86.2 CB698.2 CB699.1 CB700.1 RB617.1 UB73.2(VIN)
SYSCLKN: P9.C10(10)
SYSCLKP: P9.C8(8)
TDRIO: P9.C12(12)
UR_0: U7.18(OUT1)
UR_1: U7.17(OUT2)
UR_2: U7.15(OUT3)
UR_3: U7.14(OUT4)
UR_4: U7.12(OUT5)
UR_5: U7.11(OUT6)
UR_6: U7.9(OUT7)
UR_7: U7.8(OUT8)
UR_8: U5.18(OUT1)
UR_9: U5.17(OUT2)
UR_10: U5.15(OUT3)
UR_11: U5.14(OUT4)
UR_12: U5.12(OUT5)
UR_13: U5.11(OUT6)
UR_14: U5.9(OUT7)
UR_15: U5.8(OUT8)
UR_16: U6.18(OUT1)
UR_17: U6.17(OUT2)
UR_18: U6.15(OUT3)
UR_19: U6.14(OUT4)
UR_20: U6.12(OUT5)
UR_21: U6.11(OUT6)
UR_22: U6.9(OUT7)
UR_23: U6.8(OUT8)
UR_24: U8.18(OUT1)
UR_25: U8.17(OUT2)
UR_26: U8.15(OUT3)
UR_27: U8.14(OUT4)
UR_28: U8.12(OUT5)
UR_29: U8.11(OUT6)
UR_30: U8.9(OUT7)
UR_31: U8.8(OUT8)
UR_32: U11.18(OUT1)
UR_33: U11.17(OUT2)
UR_34: U11.15(OUT3)
UR_35: U11.14(OUT4)
UR_36: U11.12(OUT5)
UR_37: U11.11(OUT6)
UR_38: U11.9(OUT7)
UR_39: U11.8(OUT8)
UR_40: U9.18(OUT1)
UR_41: U9.17(OUT2)
UR_42: U9.15(OUT3)
UR_43: U9.14(OUT4)
UR_44: U9.12(OUT5)
UR_45: U9.11(OUT6)
UR_46: U9.9(OUT7)
UR_47: U9.8(OUT8)
UR_48: U10.18(OUT1)
UR_49: U10.17(OUT2)
UR_50: U10.15(OUT3)
UR_51: U10.14(OUT4)
UR_52: U10.12(OUT5)
UR_53: U10.11(OUT6)
UR_54: U10.9(OUT7)
UR_55: U10.8(OUT8)
UR_56: U12.18(OUT1)
UR_57: U12.17(OUT2)
UR_58: U12.15(OUT3)
UR_59: U12.14(OUT4)
UR_60: U12.12(OUT5)
UR_61: U12.11(OUT6)
UR_62: U12.9(OUT7)
UR_63: U12.8(OUT8)
UR_64: U13.18(OUT1)
UR_65: U13.17(OUT2)
UR_66: U13.15(OUT3)
UR_67: U13.14(OUT4)
UR_68: U13.12(OUT5)
UR_69: U13.11(OUT6)
UR_70: U13.9(OUT7)
UR_71: U13.8(OUT8)
UR_72: U14.18(OUT1)
UR_73: U14.17(OUT2)
UR_74: U14.15(OUT3)
UR_75: U14.14(OUT4)
UR_76: U14.12(OUT5)
UR_77: U14.11(OUT6)
UR_78: U14.9(OUT7)
UR_79: U14.8(OUT8)
UR_80: U15.18(OUT1)
UR_81: U15.17(OUT2)
UR_82: U15.15(OUT3)
UR_83: U15.14(OUT4)
UR_84: U15.12(OUT5)
UR_85: U15.11(OUT6)
UR_86: U15.9(OUT7)
UR_87: U15.8(OUT8)
UR_88: U16.18(OUT1)
UR_89: U16.17(OUT2)
UR_90: U16.15(OUT3)
UR_91: U16.14(OUT4)
UR_92: U16.12(OUT5)
UR_93: U16.11(OUT6)
UR_94: U16.9(OUT7)
UR_95: U16.8(OUT8)
VN15: CT12.1 CT13.1 LDB6.2(B) P9.G4(4) P9.H4(4) TP_VN15.1(TP)
VP5A: CT4.1 CT5.1 CT14.1 LRB2.1 P9.E12(12) P9.F12(12) RB205.1 TP_VP5A.1(TP) UB5.8(VCC)
VP5B: C524.1 C525.1 C528.1 C539.1 C540.1 C541.1 C542.1 C543.1 C544.1 C545.1 C546.1 C547.1 C548.1 C549.1 C550.1 C551.1 C552.1 C553.1 C554.1 C555.1 CT2.1 CT3.1 LRB1.1 P9.E8(8) P9.E10(10) P9.F8(8) P9.F10(10) P9.G8(8) P9.G10(10) P9.G12(12) P9.H8(8) P9.H10(10) P9.H12(12) R327.2 R338.2 R342.2 R346.2 R347.2 R348.2 R349.2 R350.2 R351.2 R352.2 R353.2 R354.2 R355.2 R356.2 R357.2 R358.2 R359.2 R360.2 R361.2 R362.2 R363.2 R364.2 R365.2 R366.2 TP_VP5B.1(TP) U5.6(PDCD) U5.19(VS) U6.6(PDCD) U6.19(VS) U7.6(PDCD) U7.19(VS) U8.6(PDCD) U8.19(VS) U9.6(PDCD) U9.19(VS) U10.6(PDCD) U10.19(VS) U11.6(PDCD) U11.19(VS) U12.6(PDCD) U12.19(VS) U13.6(PDCD) U13.19(VS) U14.6(PDCD) U14.19(VS) U15.6(PDCD) U15.19(VS) U16.6(PDCD) U16.19(VS)
VP5B_EN: P9.D5(5) RB8.1
VP12: CT6.1 CT7.1 K1.1(V+) K2.1(V+) K3.1(V+) K4.1(V+) K5.1(V+) K6.1(V+) K7.1(V+) K8.1(V+) K9.1(V+) K10.1(V+) K11.1(V+) K12.1(V+) K13.1(V+) K14.1(V+) K15.1(V+) K16.1(V+) K18.1(V+) K19.1(V+) K20.1(V+) K21.1(V+) K22.1(V+) K23.1(V+) K25.1(V+) K26.1(V+) K28.1(V+) K29.1(V+) K30.1(V+) K31.1(V+) K32.1(V+) K33.1(V+) K34.1(V+) K35.1(V+) K36.1(V+) K37.1(V+) K38.1(V+) K39.1(V+) KT1.1(V+) LRB3.2 P9.E6(6) P9.F6(6) TP_VP12.1(TP) UNK1K1.1 UNK1K2.1 UNK1K3.1 UNK1K4.1 UNK1K5.1 UNK1K6.1 UNK1K7.1 UNK1K8.1 UNK1K9.1 UNK1K10.1 UNK1K11.1 UNK1K12.1 UNK1K13.1 UNK1K14.1 UNK1K15.1 UNK1K16.1 UNK1K18.1 UNK1K19.1 UNK1K20.1 UNK1K21.1 UNK1K22.1 UNK1K23.1 UNK1K25.1 UNK1K26.1 UNK1K28.1 UNK1K29.1 UNK1K30.1 UNK1K31.1 UNK1K32.1 UNK1K34.1 UNK1K35.1 UNK1K36.1 UNK1K39.1 UNK2K1.1 UNK2K2.1 UNK2K3.1 UNK2K4.1 UNK2K5.1 UNK2K6.1 UNK2K7.1 UNK2K8.1 UNK2K9.1 UNK2K10.1 UNK2K11.1 UNK2K12.1 UNK2K13.1 UNK2K14.1 UNK2K15.1 UNK2K16.1 UNK2K18.1 UNK2K19.1 UNK2K20.1 UNK2K21.1 UNK2K22.1 UNK2K23.1 UNK2K25.1 UNK2K26.1 UNK2K28.1 UNK2K29.1 UNK2K30.1 UNK2K31.1 UNK2K32.1 UNK2K33.1 UNK2K34.1 UNK2K35.1 UNK2K36.1 UNK2K37.1 UNK2K38.1 UNK2K39.1 UNK3K1.1 UNK3K2.1 UNK3K3.1 UNK3K4.1 UNK3K5.1 UNK3K6.1 UNK3K7.1 UNK3K8.1 UNK3K9.1 UNK3K10.1 UNK3K11.1 UNK3K12.1 UNK3K13.1 UNK3K14.1 UNK3K15.1 UNK3K16.1 UNK3K18.1 UNK3K19.1 UNK3K20.1 UNK3K21.1 UNK3K22.1 UNK3K23.1 UNK3K25.1 UNK3K26.1 UNK3K28.1 UNK3K29.1 UNK3K30.1 UNK3K31.1 UNK3K32.1 UNK3K34.1 UNK3K35.1 UNK3K36.1 UNK3K39.1 UNK4K1.1 UNK4K2.1 UNK4K3.1 UNK4K4.1 UNK4K5.1 UNK4K6.1 UNK4K7.1 UNK4K8.1 UNK4K9.1 UNK4K10.1 UNK4K11.1 UNK4K12.1 UNK4K13.1 UNK4K14.1 UNK4K15.1 UNK4K16.1 UNK4K18.1 UNK4K19.1 UNK4K20.1 UNK4K21.1 UNK4K22.1 UNK4K23.1 UNK4K25.1 UNK4K26.1 UNK4K28.1 UNK4K29.1 UNK4K30.1 UNK4K31.1 UNK4K32.1 UNK4K33.1 UNK4K34.1 UNK4K35.1 UNK4K36.1 UNK4K37.1 UNK4K38.1 UNK4K39.1 UNK5K1.1 UNK5K2.1 UNK5K3.1 UNK5K4.1 UNK5K5.1 UNK5K6.1 UNK5K7.1 UNK5K8.1 UNK5K9.1 UNK5K10.1 UNK5K11.1 UNK5K12.1 UNK5K13.1 UNK5K14.1 UNK5K15.1 UNK5K16.1 UNK5K18.1 UNK5K19.1 UNK5K20.1 UNK5K21.1 UNK5K22.1 UNK5K23.1 UNK5K25.1 UNK5K26.1 UNK5K28.1 UNK5K29.1 UNK5K30.1 UNK5K31.1 UNK5K32.1 UNK5K34.1 UNK5K35.1 UNK5K36.1 UNK5K39.1 UNK6K1.1 UNK6K2.1 UNK6K3.1 UNK6K4.1 UNK6K5.1 UNK6K6.1 UNK6K7.1 UNK6K8.1 UNK6K9.1 UNK6K10.1 UNK6K11.1 UNK6K12.1 UNK6K13.1 UNK6K14.1 UNK6K15.1 UNK6K16.1 UNK6K18.1 UNK6K19.1 UNK6K20.1 UNK6K21.1 UNK6K22.1 UNK6K23.1 UNK6K25.1 UNK6K26.1 UNK6K28.1 UNK6K29.1 UNK6K30.1 UNK6K31.1 UNK6K32.1 UNK6K33.1 UNK6K34.1 UNK6K35.1 UNK6K36.1 UNK6K37.1 UNK6K38.1 UNK6K39.1 UNK7K1.1 UNK7K2.1 UNK7K3.1 UNK7K4.1 UNK7K5.1 UNK7K6.1 UNK7K7.1 UNK7K8.1 UNK7K9.1 UNK7K10.1 UNK7K11.1 UNK7K12.1 UNK7K13.1 UNK7K14.1 UNK7K15.1 UNK7K16.1 UNK7K18.1 UNK7K19.1 UNK7K20.1 UNK7K21.1 UNK7K22.1 UNK7K23.1 UNK7K25.1 UNK7K26.1 UNK7K28.1 UNK7K29.1 UNK7K30.1 UNK7K31.1 UNK7K32.1 UNK7K34.1 UNK7K35.1 UNK7K36.1 UNK7K39.1 VDD12_ATX.2 VDD12_ATX.4
VP15: CT10.1 CT11.1 LRB5.2 P9.E4(4) P9.F4(4) TP_VP15.1(TP)
VP24: CT8.1 CT9.1 LRB4.2 P9.E2(2) P9.F2(2) TP_VP24.1(TP)
VR24: P9.G2(2) P9.H2(2)
N7344580: CB658.1 RB597.2
N7347819: CB673.1 RB604.2
N7350256: CB703.1 RB618.2
N16079151: LDB1.1(A) LRB1.2
N16079317: LDB2.1(A) LRB2.2
N16079993: LDB3.1(A) LRB3.1
N16083795: LDB4.1(A) LRB4.1
N16083921: LDB5.1(A) LRB5.1
N16084055: LDB6.1(A) LRB6.1
N19745084: U8.5(DOUT) U11.3(DIN)
N20743418: U5.5(DOUT) U6.3(DIN)
N20743561: R327.1 U7.1(R\E\S\E\T\)
N20743722: R346.1 U5.1(R\E\S\E\T\)
N20743738: R338.1 U5.20(F\L\A\G\)
N20743807: R342.1 U7.20(F\L\A\G\)
N20754919: U6.5(DOUT) U8.3(DIN)
N20754925: R347.1 U6.1(R\E\S\E\T\)
N20754928: R365.1 U6.20(F\L\A\G\)
N20754936: U5.3(DIN) U7.5(DOUT)
N20754977: R348.1 U8.1(R\E\S\E\T\)
N20754980: R366.1 U8.20(F\L\A\G\)
N24979212: R38.1 SW5.10
N24979216: R42.1 SW5.9
N24989047: C10.1 R5.2 U1.3(RF2)
N24989128: C7.2 U1.5(ANT)
N24989237: R4.1 U1.1(RF1)
N24989519: C6.2 R3.2
N24989550: C19.1 R9.2 U2.1(RF1)
N24989582: C14.2 U2.5(ANT)
N24989672: C12.1 R6.2 R7.1 R8.2
N24989686: C13.2 R7.2
N24989857: BD27.2 C24.1 K16.4
N24989916: K5.6 R22.1
N24989920: K5.4 R25.1
N24989997: R8.1 U2.3(RF2)
N24990019: C5.1 R2.2 R3.1 R4.2
N24990271: C2.1 C3.1 R1.2
N24990291: C2.2 D1.1(CATHODE_D1) SMP1.1
N25003725: K7.6 R23.1
N25003728: K7.4 R26.1
N25009100: K18.2 K19.3
N25009102: K18.7 K19.6
N25009119: C39.1 K19.4
N25009121: C38.2 K19.2
N25009152: C41.1 K19.5
N25009154: C40.2 K19.7
N25018635: K21.2 L1.1
N25019559: K29.2 L3.1
N25019667: C106.1 C108.1 C109.1 K28.3 L3.2
N25019718: K28.4 R54.1
N25019726: C116.1 C117.1 K28.6 K29.5
N25019871: C53.1 C55.1 C57.1 K22.3 L1.2
N25019924: K22.4 R49.1
N25019943: C62.1 C63.1 K21.5 K22.6
N25095240: K20.2 L4.1
N25095242: C136.1 C137.1 C138.1 K25.3 L4.2
N25095269: K25.4 R51.1
N25095276: C139.1 C142.1 K20.5 K25.6
N25103211: BD27.1 R29.1 R33.2
N25107005: R61.1 SW6.6
N25107009: R62.1 SW6.5
N25114262: R47.2 R74.2
N25278384: U12.5(DOUT) U13.3(DIN)
N25278501: U10.5(DOUT) U12.3(DIN)
N25278513: R355.1 U10.1(R\E\S\E\T\)
N25278527: R350.1 U10.20(F\L\A\G\)
N25278533: U9.5(DOUT) U10.3(DIN)
N25278541: U9.3(DIN) U11.5(DOUT)
N25278621: R356.1 U12.1(R\E\S\E\T\)
N25278627: R349.1 U12.20(F\L\A\G\)
N25278841: R354.1 U11.1(R\E\S\E\T\)
N25278855: R352.1 U9.1(R\E\S\E\T\)
N25278861: R353.1 U9.20(F\L\A\G\)
N25278867: R351.1 U11.20(F\L\A\G\)
N25280768: U15.5(DOUT) U16.3(DIN)
N25280780: R363.1 U15.1(R\E\S\E\T\)
N25280794: R358.1 U15.20(F\L\A\G\)
N25280800: U14.5(DOUT) U15.3(DIN)
N25280808: U13.5(DOUT) U14.3(DIN)
N25280888: R364.1 U16.1(R\E\S\E\T\)
N25280894: R357.1 U16.20(F\L\A\G\)
N25281108: R362.1 U13.1(R\E\S\E\T\)
N25281122: R360.1 U14.1(R\E\S\E\T\)
N25281128: R361.1 U14.20(F\L\A\G\)
N25281134: R359.1 U13.20(F\L\A\G\)
N25614045: K30.3 R71.1
N25614052: K31.3 R72.1
N25614059: K32.3 R73.1
N25867897: R45.2 R75.2
N25938555: C20.1 SITE0.47(VREF_AUDIO)
N25967988: C145.2 K34.4
N25967991: C146.2 K34.5
N25968094: C147.2 K35.4
N25968096: C148.2 K35.5
N25968164: C149.2 K36.4
N25968166: C150.2 K36.5
N26344713: RT1.2 UT1.3(VO)
N27439655: UNK1C10.1 UNK1R5.2 UNK1U1.3
N27439661: UNK1C7.2 UNK1U1.5
N27439664: UNK1R4.1 UNK1U1.1
N27439715: UNK1C6.2 UNK1R3.2
N27439724: UNK1C19.1 UNK1R9.2 UNK1U2.1
N27439731: UNK1C14.2 UNK1U2.5
N27439738: UNK1C12.1 UNK1R6.2 UNK1R7.1 UNK1R8.2
N27439740: UNK1C13.2 UNK1R7.2
N27439759: UNK1BD27.2 UNK1C24.1 UNK1K16.4
N27439769: UNK1K5.6 UNK1R22.1
N27439771: UNK1K5.4 UNK1R25.1
N27439774: UNK1R8.1 UNK1U2.3
N27439780: UNK1C5.1 UNK1R2.2 UNK1R3.1 UNK1R4.2
N27439808: UNK1C2.1 UNK1C3.1 UNK1R1.2
N27439813: UNK1C2.2 UNK1D1.1 UNK1SMP1.1
N27439931: UNK1K7.6 UNK1R23.1
N27439932: UNK1K7.4 UNK1R26.1
N27439937: UNK1BD27.1 UNK1R29.1 UNK1R33.2
N27440064: SITE1.47(VREF_AUDIO) UNK1C20.1
N27443663: UNK1K18.2 UNK1K19.3
N27443664: UNK1K18.7 UNK1K19.6
N27443667: UNK1C39.1 UNK1K19.4
N27443668: UNK1C38.2 UNK1K19.2
N27443671: UNK1C41.1 UNK1K19.5
N27443672: UNK1C40.2 UNK1K19.7
N27443703: UNK1R47.2 UNK1R74.2
N27443785: UNK1R45.2 UNK1R75.2
N27443801: UNK1C145.2 UNK1K34.4
N27443802: UNK1C146.2 UNK1K34.5
N27443809: UNK1C147.2 UNK1K35.4
N27443810: UNK1C148.2 UNK1K35.5
N27443813: UNK1C149.2 UNK1K36.4
N27443814: UNK1C150.2 UNK1K36.5
N27444901: UNK1K21.2 UNK1L1.1
N27444931: UNK1K29.2 UNK1L3.1
N27444932: UNK1C106.1 UNK1C108.1 UNK1C109.1 UNK1K28.3 UNK1L3.2
N27444943: UNK1K28.4 UNK1R54.1
N27444947: UNK1C116.1 UNK1C117.1 UNK1K28.6 UNK1K29.5
N27444970: UNK1C53.1 UNK1C55.1 UNK1C57.1 UNK1K22.3 UNK1L1.2
N27444982: UNK1K22.4 UNK1R49.1
N27444986: UNK1C62.1 UNK1C63.1 UNK1K21.5 UNK1K22.6
N27445101: UNK1K20.2 UNK1L4.1
N27445102: UNK1C136.1 UNK1C137.1 UNK1C138.1 UNK1K25.3 UNK1L4.2
N27445113: UNK1K25.4 UNK1R51.1
N27445115: UNK1C139.1 UNK1C142.1 UNK1K20.5 UNK1K25.6
N27445221: UNK1K30.3 UNK1R71.1
N27445223: UNK1K31.3 UNK1R72.1
N27445225: UNK1K32.3 UNK1R73.1
N27448585: UNK2C10.1 UNK2R5.2 UNK2U1.3
N27448591: UNK2C7.2 UNK2U1.5
N27448594: UNK2R4.1 UNK2U1.1
N27448645: UNK2C6.2 UNK2R3.2
N27448654: UNK2C19.1 UNK2R9.2 UNK2U2.1
N27448661: UNK2C14.2 UNK2U2.5
N27448668: UNK2C12.1 UNK2R6.2 UNK2R7.1 UNK2R8.2
N27448670: UNK2C13.2 UNK2R7.2
N27448689: UNK2BD27.2 UNK2C24.1 UNK2K16.4
N27448699: UNK2K5.6 UNK2R22.1
N27448701: UNK2K5.4 UNK2R25.1
N27448704: UNK2R8.1 UNK2U2.3
N27448710: UNK2C5.1 UNK2R2.2 UNK2R3.1 UNK2R4.2
N27448738: UNK2C2.1 UNK2C3.1 UNK2R1.2
N27448743: UNK2C2.2 UNK2D1.1 UNK2SMP1.1
N27448861: UNK2K7.6 UNK2R23.1
N27448862: UNK2K7.4 UNK2R26.1
N27448867: UNK2BD27.1 UNK2R29.1 UNK2R33.2
N27448994: SITE2.47(VREF_AUDIO) UNK2C20.1
N27452593: UNK2K18.2 UNK2K19.3
N27452594: UNK2K18.7 UNK2K19.6
N27452597: UNK2C39.1 UNK2K19.4
N27452598: UNK2C38.2 UNK2K19.2
N27452601: UNK2C41.1 UNK2K19.5
N27452602: UNK2C40.2 UNK2K19.7
N27452633: UNK2R47.2 UNK2R74.2
N27452715: UNK2R45.2 UNK2R75.2
N27452731: UNK2C145.2 UNK2K34.4
N27452732: UNK2C146.2 UNK2K34.5
N27452739: UNK2C147.2 UNK2K35.4
N27452740: UNK2C148.2 UNK2K35.5
N27452743: UNK2C149.2 UNK2K36.4
N27452744: UNK2C150.2 UNK2K36.5
N27453831: UNK2K21.2 UNK2L1.1
N27453861: UNK2K29.2 UNK2L3.1
N27453862: UNK2C106.1 UNK2C108.1 UNK2C109.1 UNK2K28.3 UNK2L3.2
N27453873: UNK2K28.4 UNK2R54.1
N27453877: UNK2C116.1 UNK2C117.1 UNK2K28.6 UNK2K29.5
N27453900: UNK2C53.1 UNK2C55.1 UNK2C57.1 UNK2K22.3 UNK2L1.2
N27453912: UNK2K22.4 UNK2R49.1
N27453916: UNK2C62.1 UNK2C63.1 UNK2K21.5 UNK2K22.6
N27454031: UNK2K20.2 UNK2L4.1
N27454032: UNK2C136.1 UNK2C137.1 UNK2C138.1 UNK2K25.3 UNK2L4.2
N27454043: UNK2K25.4 UNK2R51.1
N27454045: UNK2C139.1 UNK2C142.1 UNK2K20.5 UNK2K25.6
N27454151: UNK2K30.3 UNK2R71.1
N27454153: UNK2K31.3 UNK2R72.1
N27454155: UNK2K32.3 UNK2R73.1
N27457514: UNK3C10.1 UNK3R5.2 UNK3U1.3
N27457520: UNK3C7.2 UNK3U1.5
N27457523: UNK3R4.1 UNK3U1.1
N27457574: UNK3C6.2 UNK3R3.2
N27457583: UNK3C19.1 UNK3R9.2 UNK3U2.1
N27457590: UNK3C14.2 UNK3U2.5
N27457597: UNK3C12.1 UNK3R6.2 UNK3R7.1 UNK3R8.2
N27457599: UNK3C13.2 UNK3R7.2
N27457618: UNK3BD27.2 UNK3C24.1 UNK3K16.4
N27457628: UNK3K5.6 UNK3R22.1
N27457630: UNK3K5.4 UNK3R25.1
N27457633: UNK3R8.1 UNK3U2.3
N27457639: UNK3C5.1 UNK3R2.2 UNK3R3.1 UNK3R4.2
N27457667: UNK3C2.1 UNK3C3.1 UNK3R1.2
N27457672: UNK3C2.2 UNK3D1.1 UNK3SMP1.1
N27457790: UNK3K7.6 UNK3R23.1
N27457791: UNK3K7.4 UNK3R26.1
N27457796: UNK3BD27.1 UNK3R29.1 UNK3R33.2
N27457923: SITE3.47(VREF_AUDIO) UNK3C20.1
N27461522: UNK3K18.2 UNK3K19.3
N27461523: UNK3K18.7 UNK3K19.6
N27461526: UNK3C39.1 UNK3K19.4
N27461527: UNK3C38.2 UNK3K19.2
N27461530: UNK3C41.1 UNK3K19.5
N27461531: UNK3C40.2 UNK3K19.7
N27461562: UNK3R47.2 UNK3R74.2
N27461644: UNK3R45.2 UNK3R75.2
N27461660: UNK3C145.2 UNK3K34.4
N27461661: UNK3C146.2 UNK3K34.5
N27461668: UNK3C147.2 UNK3K35.4
N27461669: UNK3C148.2 UNK3K35.5
N27461672: UNK3C149.2 UNK3K36.4
N27461673: UNK3C150.2 UNK3K36.5
N27462760: UNK3K21.2 UNK3L1.1
N27462790: UNK3K29.2 UNK3L3.1
N27462791: UNK3C106.1 UNK3C108.1 UNK3C109.1 UNK3K28.3 UNK3L3.2
N27462802: UNK3K28.4 UNK3R54.1
N27462806: UNK3C116.1 UNK3C117.1 UNK3K28.6 UNK3K29.5
N27462829: UNK3C53.1 UNK3C55.1 UNK3C57.1 UNK3K22.3 UNK3L1.2
N27462841: UNK3K22.4 UNK3R49.1
N27462845: UNK3C62.1 UNK3C63.1 UNK3K21.5 UNK3K22.6
N27462960: UNK3K20.2 UNK3L4.1
N27462961: UNK3C136.1 UNK3C137.1 UNK3C138.1 UNK3K25.3 UNK3L4.2
N27462972: UNK3K25.4 UNK3R51.1
N27462974: UNK3C139.1 UNK3C142.1 UNK3K20.5 UNK3K25.6
N27463080: UNK3K30.3 UNK3R71.1
N27463082: UNK3K31.3 UNK3R72.1
N27463084: UNK3K32.3 UNK3R73.1
N27466443: UNK4C10.1 UNK4R5.2 UNK4U1.3
N27466449: UNK4C7.2 UNK4U1.5
N27466452: UNK4R4.1 UNK4U1.1
N27466503: UNK4C6.2 UNK4R3.2
N27466512: UNK4C19.1 UNK4R9.2 UNK4U2.1
N27466519: UNK4C14.2 UNK4U2.5
N27466526: UNK4C12.1 UNK4R6.2 UNK4R7.1 UNK4R8.2
N27466528: UNK4C13.2 UNK4R7.2
N27466547: UNK4BD27.2 UNK4C24.1 UNK4K16.4
N27466557: UNK4K5.6 UNK4R22.1
N27466559: UNK4K5.4 UNK4R25.1
N27466562: UNK4R8.1 UNK4U2.3
N27466568: UNK4C5.1 UNK4R2.2 UNK4R3.1 UNK4R4.2
N27466596: UNK4C2.1 UNK4C3.1 UNK4R1.2
N27466601: UNK4C2.2 UNK4D1.1 UNK4SMP1.1
N27466719: UNK4K7.6 UNK4R23.1
N27466720: UNK4K7.4 UNK4R26.1
N27466725: UNK4BD27.1 UNK4R29.1 UNK4R33.2
N27466852: SITE4.47(VREF_AUDIO) UNK4C20.1
N27470451: UNK4K18.2 UNK4K19.3
N27470452: UNK4K18.7 UNK4K19.6
N27470455: UNK4C39.1 UNK4K19.4
N27470456: UNK4C38.2 UNK4K19.2
N27470459: UNK4C41.1 UNK4K19.5
N27470460: UNK4C40.2 UNK4K19.7
N27470491: UNK4R47.2 UNK4R74.2
N27470573: UNK4R45.2 UNK4R75.2
N27470589: UNK4C145.2 UNK4K34.4
N27470590: UNK4C146.2 UNK4K34.5
N27470597: UNK4C147.2 UNK4K35.4
N27470598: UNK4C148.2 UNK4K35.5
N27470601: UNK4C149.2 UNK4K36.4
N27470602: UNK4C150.2 UNK4K36.5
N27471689: UNK4K21.2 UNK4L1.1
N27471719: UNK4K29.2 UNK4L3.1
N27471720: UNK4C106.1 UNK4C108.1 UNK4C109.1 UNK4K28.3 UNK4L3.2
N27471731: UNK4K28.4 UNK4R54.1
N27471735: UNK4C116.1 UNK4C117.1 UNK4K28.6 UNK4K29.5
N27471758: UNK4C53.1 UNK4C55.1 UNK4C57.1 UNK4K22.3 UNK4L1.2
N27471770: UNK4K22.4 UNK4R49.1
N27471774: UNK4C62.1 UNK4C63.1 UNK4K21.5 UNK4K22.6
N27471889: UNK4K20.2 UNK4L4.1
N27471890: UNK4C136.1 UNK4C137.1 UNK4C138.1 UNK4K25.3 UNK4L4.2
N27471901: UNK4K25.4 UNK4R51.1
N27471903: UNK4C139.1 UNK4C142.1 UNK4K20.5 UNK4K25.6
N27472009: UNK4K30.3 UNK4R71.1
N27472011: UNK4K31.3 UNK4R72.1
N27472013: UNK4K32.3 UNK4R73.1
N27475373: UNK5C10.1 UNK5R5.2 UNK5U1.3
N27475379: UNK5C7.2 UNK5U1.5
N27475382: UNK5R4.1 UNK5U1.1
N27475433: UNK5C6.2 UNK5R3.2
N27475442: UNK5C19.1 UNK5R9.2 UNK5U2.1
N27475449: UNK5C14.2 UNK5U2.5
N27475456: UNK5C12.1 UNK5R6.2 UNK5R7.1 UNK5R8.2
N27475458: UNK5C13.2 UNK5R7.2
N27475477: UNK5BD27.2 UNK5C24.1 UNK5K16.4
N27475487: UNK5K5.6 UNK5R22.1
N27475489: UNK5K5.4 UNK5R25.1
N27475492: UNK5R8.1 UNK5U2.3
N27475498: UNK5C5.1 UNK5R2.2 UNK5R3.1 UNK5R4.2
N27475526: UNK5C2.1 UNK5C3.1 UNK5R1.2
N27475531: UNK5C2.2 UNK5D1.1 UNK5SMP1.1
N27475649: UNK5K7.6 UNK5R23.1
N27475650: UNK5K7.4 UNK5R26.1
N27475655: UNK5BD27.1 UNK5R29.1 UNK5R33.2
N27475782: SITE5.47(VREF_AUDIO) UNK5C20.1
N27479381: UNK5K18.2 UNK5K19.3
N27479382: UNK5K18.7 UNK5K19.6
N27479385: UNK5C39.1 UNK5K19.4
N27479386: UNK5C38.2 UNK5K19.2
N27479389: UNK5C41.1 UNK5K19.5
N27479390: UNK5C40.2 UNK5K19.7
N27479421: UNK5R47.2 UNK5R74.2
N27479503: UNK5R45.2 UNK5R75.2
N27479519: UNK5C145.2 UNK5K34.4
N27479520: UNK5C146.2 UNK5K34.5
N27479527: UNK5C147.2 UNK5K35.4
N27479528: UNK5C148.2 UNK5K35.5
N27479531: UNK5C149.2 UNK5K36.4
N27479532: UNK5C150.2 UNK5K36.5
N27480619: UNK5K21.2 UNK5L1.1
N27480649: UNK5K29.2 UNK5L3.1
N27480650: UNK5C106.1 UNK5C108.1 UNK5C109.1 UNK5K28.3 UNK5L3.2
N27480661: UNK5K28.4 UNK5R54.1
N27480665: UNK5C116.1 UNK5C117.1 UNK5K28.6 UNK5K29.5
N27480688: UNK5C53.1 UNK5C55.1 UNK5C57.1 UNK5K22.3 UNK5L1.2
N27480700: UNK5K22.4 UNK5R49.1
N27480704: UNK5C62.1 UNK5C63.1 UNK5K21.5 UNK5K22.6
N27480819: UNK5K20.2 UNK5L4.1
N27480820: UNK5C136.1 UNK5C137.1 UNK5C138.1 UNK5K25.3 UNK5L4.2
N27480831: UNK5K25.4 UNK5R51.1
N27480833: UNK5C139.1 UNK5C142.1 UNK5K20.5 UNK5K25.6
N27480939: UNK5K30.3 UNK5R71.1
N27480941: UNK5K31.3 UNK5R72.1
N27480943: UNK5K32.3 UNK5R73.1
N27484303: UNK6C10.1 UNK6R5.2 UNK6U1.3
N27484309: UNK6C7.2 UNK6U1.5
N27484312: UNK6R4.1 UNK6U1.1
N27484363: UNK6C6.2 UNK6R3.2
N27484372: UNK6C19.1 UNK6R9.2 UNK6U2.1
N27484379: UNK6C14.2 UNK6U2.5
N27484386: UNK6C12.1 UNK6R6.2 UNK6R7.1 UNK6R8.2
N27484388: UNK6C13.2 UNK6R7.2
N27484407: UNK6BD27.2 UNK6C24.1 UNK6K16.4
N27484417: UNK6K5.6 UNK6R22.1
N27484419: UNK6K5.4 UNK6R25.1
N27484422: UNK6R8.1 UNK6U2.3
N27484428: UNK6C5.1 UNK6R2.2 UNK6R3.1 UNK6R4.2
N27484456: UNK6C2.1 UNK6C3.1 UNK6R1.2
N27484461: UNK6C2.2 UNK6D1.1 UNK6SMP1.1
N27484579: UNK6K7.6 UNK6R23.1
N27484580: UNK6K7.4 UNK6R26.1
N27484585: UNK6BD27.1 UNK6R29.1 UNK6R33.2
N27484712: SITE6.47(VREF_AUDIO) UNK6C20.1
N27488311: UNK6K18.2 UNK6K19.3
N27488312: UNK6K18.7 UNK6K19.6
N27488315: UNK6C39.1 UNK6K19.4
N27488316: UNK6C38.2 UNK6K19.2
N27488319: UNK6C41.1 UNK6K19.5
N27488320: UNK6C40.2 UNK6K19.7
N27488351: UNK6R47.2 UNK6R74.2
N27488433: UNK6R45.2 UNK6R75.2
N27488449: UNK6C145.2 UNK6K34.4
N27488450: UNK6C146.2 UNK6K34.5
N27488457: UNK6C147.2 UNK6K35.4
N27488458: UNK6C148.2 UNK6K35.5
N27488461: UNK6C149.2 UNK6K36.4
N27488462: UNK6C150.2 UNK6K36.5
N27489549: UNK6K21.2 UNK6L1.1
N27489579: UNK6K29.2 UNK6L3.1
N27489580: UNK6C106.1 UNK6C108.1 UNK6C109.1 UNK6K28.3 UNK6L3.2
N27489591: UNK6K28.4 UNK6R54.1
N27489595: UNK6C116.1 UNK6C117.1 UNK6K28.6 UNK6K29.5
N27489618: UNK6C53.1 UNK6C55.1 UNK6C57.1 UNK6K22.3 UNK6L1.2
N27489630: UNK6K22.4 UNK6R49.1
N27489634: UNK6C62.1 UNK6C63.1 UNK6K21.5 UNK6K22.6
N27489749: UNK6K20.2 UNK6L4.1
N27489750: UNK6C136.1 UNK6C137.1 UNK6C138.1 UNK6K25.3 UNK6L4.2
N27489761: UNK6K25.4 UNK6R51.1
N27489763: UNK6C139.1 UNK6C142.1 UNK6K20.5 UNK6K25.6
N27489869: UNK6K30.3 UNK6R71.1
N27489871: UNK6K31.3 UNK6R72.1
N27489873: UNK6K32.3 UNK6R73.1
N27493233: UNK7C10.1 UNK7R5.2 UNK7U1.3
N27493239: UNK7C7.2 UNK7U1.5
N27493242: UNK7R4.1 UNK7U1.1
N27493293: UNK7C6.2 UNK7R3.2
N27493302: UNK7C19.1 UNK7R9.2 UNK7U2.1
N27493309: UNK7C14.2 UNK7U2.5
N27493316: UNK7C12.1 UNK7R6.2 UNK7R7.1 UNK7R8.2
N27493318: UNK7C13.2 UNK7R7.2
N27493337: UNK7BD27.2 UNK7C24.1 UNK7K16.4
N27493347: UNK7K5.6 UNK7R22.1
N27493349: UNK7K5.4 UNK7R25.1
N27493352: UNK7R8.1 UNK7U2.3
N27493358: UNK7C5.1 UNK7R2.2 UNK7R3.1 UNK7R4.2
N27493386: UNK7C2.1 UNK7C3.1 UNK7R1.2
N27493391: UNK7C2.2 UNK7D1.1 UNK7SMP1.1
N27493509: UNK7K7.6 UNK7R23.1
N27493510: UNK7K7.4 UNK7R26.1
N27493515: UNK7BD27.1 UNK7R29.1 UNK7R33.2
N27493642: SITE7.47(VREF_AUDIO) UNK7C20.1
N27497241: UNK7K18.2 UNK7K19.3
N27497242: UNK7K18.7 UNK7K19.6
N27497245: UNK7C39.1 UNK7K19.4
N27497246: UNK7C38.2 UNK7K19.2
N27497249: UNK7C41.1 UNK7K19.5
N27497250: UNK7C40.2 UNK7K19.7
N27497281: UNK7R47.2 UNK7R74.2
N27497363: UNK7R45.2 UNK7R75.2
N27497379: UNK7C145.2 UNK7K34.4
N27497380: UNK7C146.2 UNK7K34.5
N27497387: UNK7C147.2 UNK7K35.4
N27497388: UNK7C148.2 UNK7K35.5
N27497391: UNK7C149.2 UNK7K36.4
N27497392: UNK7C150.2 UNK7K36.5
N27498479: UNK7K21.2 UNK7L1.1
N27498509: UNK7K29.2 UNK7L3.1
N27498510: UNK7C106.1 UNK7C108.1 UNK7C109.1 UNK7K28.3 UNK7L3.2
N27498521: UNK7K28.4 UNK7R54.1
N27498525: UNK7C116.1 UNK7C117.1 UNK7K28.6 UNK7K29.5
N27498548: UNK7C53.1 UNK7C55.1 UNK7C57.1 UNK7K22.3 UNK7L1.2
N27498560: UNK7K22.4 UNK7R49.1
N27498564: UNK7C62.1 UNK7C63.1 UNK7K21.5 UNK7K22.6
N27498679: UNK7K20.2 UNK7L4.1
N27498680: UNK7C136.1 UNK7C137.1 UNK7C138.1 UNK7K25.3 UNK7L4.2
N27498691: UNK7K25.4 UNK7R51.1
N27498693: UNK7C139.1 UNK7C142.1 UNK7K20.5 UNK7K25.6
N27498799: UNK7K30.3 UNK7R71.1
N27498801: UNK7K31.3 UNK7R72.1
N27498803: UNK7K32.3 UNK7R73.1
N27678036: UNK1R62.1 UNK1SW6.5
N27678040: UNK1R61.1 UNK1SW6.6
N27678099: UNK1R42.1 UNK1SW5.9
N27678103: UNK1R38.1 UNK1SW5.10
N27679333: UNK2R61.1 UNK2SW6.6
N27679337: UNK2R62.1 UNK2SW6.5
N27679417: UNK2R38.1 UNK2SW5.10
N27679421: UNK2R42.1 UNK2SW5.9
N27681031: UNK3R61.1 UNK3SW6.6
N27681035: UNK3R62.1 UNK3SW6.5
N27681115: UNK3R38.1 UNK3SW5.10
N27681119: UNK3R42.1 UNK3SW5.9
N27683469: UNK4R61.1 UNK4SW6.6
N27683473: UNK4R62.1 UNK4SW6.5
N27683595: UNK4R38.1 UNK4SW5.10
N27683599: UNK4R42.1 UNK4SW5.9
N27685777: UNK5R61.1 UNK5SW6.6
N27685781: UNK5R62.1 UNK5SW6.5
N27685861: UNK5R38.1 UNK5SW5.10
N27685865: UNK5R42.1 UNK5SW5.9
N27688167: UNK6R61.1 UNK6SW6.6
N27688171: UNK6R62.1 UNK6SW6.5
N27688293: UNK6R38.1 UNK6SW5.10
N27688297: UNK6R42.1 UNK6SW5.9
N27691430: UNK7R61.1 UNK7SW6.6
N27691434: UNK7R62.1 UNK7SW6.5
N27691556: UNK7R38.1 UNK7SW5.10
N27691560: UNK7R42.1 UNK7SW5.9

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; FD7 1; FD8 1; FD9 1; FD10 1; FD11 1; FD12 1; FD13 1; FD14 1; FD15 1; FD16 1; JB1 8 9 12 18; K7 3 7; K9 2 5 6 7; K16 5 6 7; K20 7; K21 7; K22 7; K23 4 5; K25 7; K26 4 7; K28 7; K29 7; K30 2 5 6 7; K31 2 5 6 7; K32 2 5 6 7; KT1 5 6 7; LOGO1 1; LOGO2 1; P1 K10 K12 L1 L3 M2 M4 M12 N6 N12 O1 O7 Q1 Q7 R10 R12 S9 S11 T10 T12 U9 U11 V6 V12 W1 W7 X6 X12 Y1 Y7 Z2 Z4 Z6 Z8 Z10 Z12; P2 K10 M4 M12 X10 Z4 Z12; P4 K10 K12 L1 L3 L5 L7 L9 L11 M2 M4 M6 M8 M10 M12 N2 N4 N6 N8 N10 N12 O1 O3 O5 O7 O9 O11 P2 P4 P6 P8 P10 P12 Q1 Q3 Q5 Q7 Q9 Q11 R2 R4 R6 R8 R10 R12 S1 S3 S5 S7 S9 S11 T2 T4 T6 T8 T10 T12 U1 U3 U5 U7 U9 U11 V2 V4 V6 V8 V10 V12 W1 W3 W5 W7 W9 W11 X2 X4 X6 X8 X10 X12 Y1 Y3 Y5 Y7 Y9 Y11 Z2 Z4 Z6 Z8 Z10 Z12; P5 K10 M4 M12 X10 Z4 Z12; P6 A6 A12 B1 B7 D1 D7 E10 E12 F9 F11 G10 G12 H9 H11 I6 I12 J1 J7 K6 K12 L1 L7 M2 M4 M6 M8 M10 M12 X10 X12 Y1 Y3 Y5 Y7 Y9 Y11 Z2 Z4 Z6 Z8 Z10 Z12; P7 A2 A6 A8 A10 A12 B1 B3 B5 B7 B9 B11 C10 C12 N10 N12 O1 O7 P6 P12 Q1 Q7 R6 R12 S9 S11 T10 T12 U9 U11 V10 V12 W1 W7 Y1 Y7 Z6 Z12; P8 C10 P10; P9 A12 B12 G6 H6; P10 C10 P10; P11 A10 A12 B1 B7 C6 C12 D1 D7 E6 E12 F9 F11 G10 G12 H9 H11 I10 I12 J1 J7 L1 L7 M6 M12 N2 N6 N8 N10 N12 O1 O3 O5 O7 O9 O11 P10 P12; PJ07604-1982 1; QFN100-10X10 1; RTL8730EAH 1; SITE0 NUT1 NUT2 NUT3 NUT4; SITE1 NUT1 NUT2 NUT3 NUT4; SITE2 NUT1 NUT2 NUT3 NUT4; SITE3 NUT1 NUT2 NUT3 NUT4; SITE4 NUT1 NUT2 NUT3 NUT4; SITE5 NUT1 NUT2 NUT3 NUT4; SITE6 NUT1 NUT2 NUT3 NUT4; SITE7 NUT1 NUT2 NUT3 NUT4; SW5 8; SW7 6 7 8; SWB1 1 4 5; UNK1K7 3 7; UNK1K9 2 5 6 7; UNK1K16 5 6 7; UNK1K20 7; UNK1K21 7; UNK1K22 7; UNK1K23 4 5; UNK1K25 7; UNK1K26 4 7; UNK1K28 7; UNK1K29 7; UNK1K30 2 5 6 7; UNK1K31 2 5 6 7; UNK1K32 2 5 6 7; UNK1SW5 8; UNK2K7 3 7; UNK2K9 2 5 6 7; UNK2K16 5 6 7; UNK2K20 7; UNK2K21 7; UNK2K22 7; UNK2K23 4 5; UNK2K25 7; UNK2K26 4 7; UNK2K28 7; UNK2K29 7; UNK2K30 2 5 6 7; UNK2K31 2 5 6 7; UNK2K32 2 5 6 7; UNK2SW5 8; UNK3K7 3 7; UNK3K9 2 5 6 7; UNK3K16 5 6 7; UNK3K20 7; UNK3K21 7; UNK3K22 7; UNK3K23 4 5; UNK3K25 7; UNK3K26 4 7; UNK3K28 7; UNK3K29 7; UNK3K30 2 5 6 7; UNK3K31 2 5 6 7; UNK3K32 2 5 6 7; UNK3SW5 8; UNK4K7 3 7; UNK4K9 2 5 6 7; UNK4K16 5 6 7; UNK4K20 7; UNK4K21 7; UNK4K22 7; UNK4K23 4 5; UNK4K25 7; UNK4K26 4 7; UNK4K28 7; UNK4K29 7; UNK4K30 2 5 6 7; UNK4K31 2 5 6 7; UNK4K32 2 5 6 7; UNK4SW5 8; UNK4SW7 5 6 7 8; UNK5K7 3 7; UNK5K9 2 5 6 7; UNK5K16 5 6 7; UNK5K20 7; UNK5K21 7; UNK5K22 7; UNK5K23 4 5; UNK5K25 7; UNK5K26 4 7; UNK5K28 7; UNK5K29 7; UNK5K30 2 5 6 7; UNK5K31 2 5 6 7; UNK5K32 2 5 6 7; UNK5SW5 8; UNK6K7 3 7; UNK6K9 2 5 6 7; UNK6K16 5 6 7; UNK6K20 7; UNK6K21 7; UNK6K22 7; UNK6K23 4 5; UNK6K25 7; UNK6K26 4 7; UNK6K28 7; UNK6K29 7; UNK6K30 2 5 6 7; UNK6K31 2 5 6 7; UNK6K32 2 5 6 7; UNK6SW5 8; UNK7K7 3 7; UNK7K9 2 5 6 7; UNK7K16 5 6 7; UNK7K20 7; UNK7K21 7; UNK7K22 7; UNK7K23 4 5; UNK7K25 7; UNK7K26 4 7; UNK7K28 7; UNK7K29 7; UNK7K30 2 5 6 7; UNK7K31 2 5 6 7; UNK7K32 2 5 6 7; UNK7SW5 8; UNK038RT-8730CN16Q-A100 1; UNK980RT-8730CN-18K- 1

## Via types
v1: diameter 0.406, hole 0.203, TOP to BOTTOM, 3022 vias
v2: diameter 0.61, hole 0.305, TOP to BOTTOM, 5019 vias
v3: diameter 0.457, hole 0.203, TOP to BOTTOM, 24 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
AGND: length 116.2
  TOP w0.152: 286.58,249.19 v1(286.58,247.88) v1(288.37,247.88) ; v1(287.11,251.89) v1(288.89,251.89) 288.89,252.66 arc(288.95,252.96) v1(289.12,253.22) ; v1(366.58,249.19) v1(366.58,247.88) v1(368.37,247.88) ; v1(368.37,187.88) v1(366.58,187.88) v1(366.58,189.19) ; v1(407.11,191.89) v1(408.89,191.89) 408.89,192.66 arc(408.95,192.96) v1(409.12,193.22) ; v1(326.58,249.19) v1(326.58,247.88) v1(328.37,247.88) ; v1(327.11,251.89) v1(328.89,251.89) 328.89,252.66 arc(328.95,252.96) v1(329.12,253.22) ; v1(288.37,187.88) v1(286.58,187.88) 286.58,189.19 ; v1(408.37,187.88) v1(406.58,187.88) v1(406.58,189.19) ; v1(326.58,189.19) v1(326.58,187.88) v1(328.37,187.88) ; v1(406.58,249.19) v1(406.58,247.88) v1(408.37,247.88) ; v1(287.11,191.89) v1(288.89,191.89) 288.89,192.66 arc(288.95,192.96) v1(289.12,193.22) ; v1(327.11,191.89) v1(328.89,191.89) 328.89,192.66 arc(328.95,192.96) v1(329.12,193.22) ; v1(407.11,251.89) v1(408.89,251.89) 408.89,252.66 arc(408.95,252.96) v1(409.12,253.22) ; v1(367.11,251.89) v1(368.89,251.89) 368.89,252.66 arc(368.95,252.96) v1(369.12,253.22) ; v1(367.11,191.89) v1(368.89,191.89) 368.89,192.66 arc(368.95,192.96) v1(369.12,193.22)
  TOP w0.254: UNK3C1.1 408.95,195.95 v1(409.23,195.67) ; UNK3C3.2 411.19,195.84 v1(411.38,196.04) ; v1(325.65,244.57) 325.58,244.64 UNK5C15.2 ; UNK6C4.1 368.04,256.46 v1(368.24,256.66) ; v1(285.38,196.79) 285.4,196.77 C11.1 v1(285.76,196.37) ; v1(325.38,196.79) 325.4,196.77 UNK1C11.1 v1(325.76,196.37) ; v1(408.24,196.66) 408.04,196.46 UNK3C4.1 ; v1(289.81,245.53) 289.88,245.6 UNK4C8.2 ; v1(403.95,193.71) 403.95,194.15 UNK3C12.2 ; v1(289.81,185.53) 289.88,185.6 C8.2 ; v1(411.38,256.04) 411.19,255.84 UNK7C3.2 ; v1(369.81,245.53) 369.88,245.6 UNK6C8.2 ; UNK1C12.2 323.95,194.15 v1(323.95,193.71) ; v1(405.38,196.79) 405.4,196.77 UNK3C11.1 v1(405.76,196.37) ; v1(332.53,189.6) 333.03,190.09 UNK1D1.2 ; UNK4C4.1 288.04,256.46 v1(288.24,256.66) ; UNK4D1.2 293.03,250.09 v1(292.53,249.6) ; C4.1 288.04,196.46 v1(288.24,196.66) ; UNK6C5.2 368.11,254.22 v1(367.98,254.36) ; v1(325.38,256.79) 325.4,256.77 UNK5C11.1 v1(325.76,256.37) ; UNK3D1.2 413.03,190.09 v1(412.53,189.6) ; C3.2 291.19,195.84 v1(291.38,196.04) ; v1(365.76,256.37) UNK6C11.1 365.4,256.77 v1(365.38,256.79) ; v1(323.95,253.71) 323.95,254.15 UNK5C12.2 ; UNK5D1.2 333.03,250.09 v1(332.53,249.6) ; UNK4C1.1 288.95,255.95 v1(289.23,255.67) ; UNK1C4.1 328.04,196.46 v1(328.24,196.66) ; v1(403.95,253.71) 403.95,254.15 UNK7C12.2 ; v1(372.53,249.6) 373.03,250.09 UNK6D1.2 ; v1(405.76,256.37) UNK7C11.1 405.4,256.77 v1(405.38,256.79) ; v1(408.24,256.66) 408.04,256.46 UNK7C4.1 ; UNK2C15.2 365.58,184.64 v1(365.65,184.57) ; v1(371.38,256.04) 371.19,255.84 UNK6C3.2 ; v1(291.38,256.04) 291.19,255.84 UNK4C3.2 ; v1(369.81,185.53) 369.88,185.6 UNK2C8.2 ; v1(369.23,195.67) 368.95,195.95 UNK2C1.1 ; UNK7C1.1 408.95,255.95 v1(409.23,255.67) ; v1(287.98,194.36) 288.11,194.22 C5.2 ; UNK2C12.2 363.95,194.15 v1(363.95,193.71) ; UNK4C12.2 283.95,254.15 v1(283.95,253.71) ; v1(412.53,249.6) 413.03,250.09 UNK7D1.2 ; UNK7C5.2 408.11,254.22 v1(407.98,254.36) ; UNK7C8.2 409.88,245.6 v1(409.81,245.53) ; UNK1C15.2 325.58,184.64 v1(325.65,184.57) ; v1(367.98,194.36) 368.11,194.22 UNK2C5.2 ; v1(285.65,244.57) 285.58,244.64 UNK4C15.2 ; UNK6C1.1 368.95,255.95 v1(369.23,255.67) ; UNK1C1.1 328.95,195.95 v1(329.23,195.67) ; v1(372.53,189.6) 373.03,190.09 UNK2D1.2 ; UNK5C8.2 329.88,245.6 v1(329.81,245.53) ; v1(285.65,184.57) 285.58,184.64 C15.2 ; UNK4C5.2 288.11,254.22 v1(287.98,254.36) ; UNK5C5.2 328.11,254.22 v1(327.98,254.36) ; v1(405.65,244.57) 405.58,244.64 UNK7C15.2 ; UNK1C3.2 331.19,195.84 v1(331.38,196.04) ; UNK5C1.1 328.95,255.95 v1(329.23,255.67) ; v1(289.23,195.67) 288.95,195.95 C1.1 ; UNK1C5.2 328.11,194.22 v1(327.98,194.36) ; UNK3C8.2 409.88,185.6 v1(409.81,185.53) ; v1(405.65,184.57) 405.58,184.64 UNK3C15.2 ; UNK4C11.1 285.4,256.77 v1(285.38,256.79) ; v1(363.95,253.71) 363.95,254.15 UNK6C12.2 ; UNK5C3.2 331.19,255.84 v1(331.38,256.04) ; UNK5C4.1 328.04,256.46 v1(328.24,256.66) ; C12.2 283.95,194.15 v1(283.95,193.71) ; v1(365.38,196.79) 365.4,196.77 UNK2C11.1 v1(365.76,196.37) ; v1(371.38,196.04) 371.19,195.84 UNK2C3.2 ; UNK2C4.1 368.04,196.46 v1(368.24,196.66) ; v1(292.53,189.6) 293.03,190.09 D1.2 ; v1(407.98,194.36) 408.11,194.22 UNK3C5.2 ; UNK6C15.2 365.58,244.64 v1(365.65,244.57) ; UNK1C8.2 329.88,185.6 v1(329.81,185.53)
  BOTTOM w0.254: 365.76,255.74 v1(365.76,256.37) UNK6C11.1 365.4,256.77 v1(365.38,256.79) ; v1(285.38,196.79) 285.4,196.77 C11.1 v1(285.76,196.37) 285.76,195.75 ; v1(325.38,256.79) 325.4,256.77 UNK5C11.1 v1(325.76,256.37) 325.76,255.74 ; v1(365.38,196.79) 365.4,196.77 UNK2C11.1 v1(365.76,196.37) 365.76,195.75 ; UNK2C10.2 365.79,193.75 v1(365.75,193.71) ; v1(285.75,193.71) 285.79,193.75 C10.2 ; UNK1C10.2 325.79,193.75 v1(325.75,193.71) ; UNK2C9.1 367.17,194.74 v1(367.16,194.73) ; v1(327.16,254.73) 327.17,254.74 UNK5C9.1 ; 405.76,195.75 v1(405.76,196.37) UNK3C11.1 405.4,196.77 v1(405.38,196.79) ; UNK3C9.1 407.17,194.74 v1(407.16,194.73) ; 405.76,255.74 v1(405.76,256.37) UNK7C11.1 405.4,256.77 v1(405.38,256.79) ; v1(287.16,194.73) 287.17,194.74 C9.1 ; v1(405.75,193.71) 405.79,193.75 UNK3C10.2 ; UNK4C10.2 285.79,253.75 v1(285.75,253.71) ; v1(367.16,254.73) 367.17,254.74 UNK6C9.1 ; UNK1C9.1 327.17,194.74 v1(327.16,194.73) ; v1(325.38,196.79) 325.4,196.77 UNK1C11.1 v1(325.76,196.37) 325.76,195.75 ; UNK7C10.2 405.79,253.75 v1(405.75,253.71) ; v1(287.16,254.73) 287.17,254.74 UNK4C9.1 ; 285.76,255.74 v1(285.76,256.37) UNK4C11.1 285.4,256.77 v1(285.38,256.79) ; UNK6C10.2 365.79,253.75 v1(365.75,253.71) ; UNK7C9.1 407.17,254.74 v1(407.16,254.73) ; v1(325.75,253.71) 325.79,253.75 UNK5C10.2
  BOTTOM w0.277: UNK4C12.2 283.95,254.65 v1(283.95,254.73) ; UNK5C12.2 323.95,254.65 v1(323.95,254.73) ; UNK6C12.2 363.95,254.65 v1(363.95,254.73) ; UNK3C12.2 403.95,194.65 v1(403.95,194.73) ; v1(283.95,194.73) 283.95,194.65 C12.2 ; UNK1C12.2 323.95,194.65 v1(323.95,194.73) ; UNK2C12.2 363.95,194.65 v1(363.95,194.73) ; v1(403.95,254.73) 403.95,254.65 UNK7C12.2
  vias: v1(281.92,244.57) v1(281.92,243.55) v1(281.92,242.54) v1(281.92,241.52) v1(281.92,240.5) v1(281.92,239.49) v1(281.92,238.47) v1(281.92,184.57) v1(281.92,183.55) v1(281.92,182.54) v1(281.92,181.52) v1(281.92,180.51) v1(281.92,179.49) v1(281.92,178.47) v1(282.93,245.58) v1(282.93,244.57) v1(282.93,243.81) v1(282.93,238.47) v1(282.93,185.59) v1(282.93,184.57) v1(282.93,183.81) v1(282.93,178.47) v1(283.95,252.7) v1(283.95,251.68) v1(283.95,250.6) v1(283.95,249.65) v1(283.95,248.63) v1(283.95,247.62) v1(283.95,246.6) v1(283.95,245.58) v1(283.95,244.57) v1(283.95,243.81) v1(283.95,238.47) v1(283.95,192.7) v1(283.95,191.68) v1(283.95,190.6) v1(283.95,189.65) v1(283.95,188.63) v1(283.95,187.62) v1(283.95,186.6) v1(283.95,185.59) v1(283.95,184.57) v1(283.95,183.81) v1(283.95,178.47) v1(283.96,256.29) v1(283.96,255.74) v1(283.96,196.29) v1(283.96,195.75) v1(284.97,238.47) v1(284.97,178.47) v1(285.74,254.73) v1(285.75,250.01) v1(285.75,249.19) v1(285.65,245.58) v1(285.65,243.81) v1(285.74,194.73) v1(285.75,190.01) v1(285.75,189.19) v1(285.65,185.59) v1(285.65,183.81) v1(285.75,255.74) v1(285.75,195.75) v1(285.98,252.91) v1(285.98,238.47) v1(285.98,192.91) v1(285.98,178.47) v1(286.34,252.23) v1(286.34,192.23) v1(286.58,249.19) v1(286.58,189.19) v1(286.67,245.58) v1(286.67,244.57) v1(286.67,243.81) v1(286.67,185.59) v1(286.67,184.57) v1(286.67,183.81) v1(287,238.47) v1(287,178.47) v1(287.16,253.85) v1(287.16,193.85) v1(287.73,243.5) v1(287.73,242.49) v1(287.73,241.47) v1(287.73,240.45) v1(287.73,239.44) v1(287.73,183.5) v1(287.73,182.49) v1(287.73,181.47) v1(287.73,180.45) v1(287.73,179.44) v1(287.89,250.45) v1(287.89,190.45) v1(288.56,253.83) v1(288.56,193.83) v1(288.68,249.52) v1(288.73,248.73) v1(288.68,189.52) v1(288.73,188.73) v1(288.8,245.53) v1(288.8,244.77) v1(288.8,239.44) v1(288.8,185.53) v1(288.8,184.77) v1(288.8,179.44) v1(289.81,249.52) v1(289.81,248.58) v1(289.81,247.57) v1(289.81,246.55) v1(289.81,244.77) v1(289.81,239.44) v1(289.81,189.52) v1(289.81,188.58) v1(289.81,187.57) v1(289.81,186.55) v1(289.81,184.77) v1(289.81,179.44) v1(290.64,256.93) v1(290.64,196.93) v1(290.83,239.44) v1(290.83,179.44) v1(291.19,253.66) v1(291.19,193.66) v1(291.52,251.63) v1(291.52,250.61) v1(291.52,249.6) v1(291.52,248.58) v1(291.52,247.57) v1(291.52,246.55) v1(291.52,245.53) v1(291.52,244.77) v1(291.52,191.63) v1(291.52,190.61) v1(291.52,189.6) v1(291.52,188.58) v1(291.52,187.57) v1(291.52,186.55) v1(291.52,185.53) v1(291.52,184.77) v1(291.67,252.65) v1(291.67,192.65) v1(291.85,239.44) v1(291.85,179.44) v1(292.22,255.2) v1(292.22,195.2) v1(292.46,251.63) v1(292.46,250.61) v1(292.53,248.58) v1(292.53,247.57) v1(292.53,246.55) v1(292.53,245.53) v1(292.53,244.77) v1(292.46,191.63) v1(292.46,190.61) v1(292.53,188.58) v1(292.53,187.57) v1(292.53,186.55) v1(292.53,185.53) v1(292.53,184.77) v1(292.86,239.44) v1(292.86,179.44) v1(293.01,254.18) v1(293.04,250.61) v1(293.01,194.18) v1(293.04,190.61) v1(293.21,246.28) v1(293.21,186.28) v1(293.55,244.26) v1(293.55,243.25) v1(293.55,242.23) v1(293.55,241.22) v1(293.55,240.2) v1(293.55,184.26) v1(293.55,183.25) v1(293.55,182.23) v1(293.55,181.22) v1(293.55,180.2) v1(293.59,253.17) v1(293.59,193.17) v1(293.69,245.42) v1(293.69,185.42) v1(293.79,249.23) v1(293.79,189.23) v1(294.15,244.63) v1(294.15,184.63) v1(294.58,243.87) v1(294.58,183.87) v1(294.76,251.13) v1(294.76,191.13) v1(295.34,250.12) v1(295.34,190.12) v1(295.62,243.74) v1(295.62,183.74) v1(296.28,250.68) v1(296.28,190.68) v1(296.49,244.25) v1(296.49,184.25) v1(297.09,250.09) v1(297.09,190.09) v1(297.4,244.78) v1(297.4,184.78) v1(297.78,249.36) v1(297.78,189.36) v1(298.34,245.32) v1(298.34,185.32) v1(298.49,248.64) v1(298.49,188.65) v1(298.97,247.78) v1(298.97,187.78) v1(299.28,245.83) v1(299.28,185.83) v1(299.46,246.97) v1(299.46,186.97) v1(321.92,244.57) v1(321.92,243.55) v1(321.92,242.54) v1(321.92,241.52) v1(321.92,240.5) v1(321.92,239.49) v1(321.92,238.47) v1(321.92,184.57) v1(321.92,183.55) v1(321.92,182.54) v1(321.92,181.52) v1(321.92,180.51) v1(321.92,179.49) v1(321.92,178.47) v1(322.93,245.58) v1(322.93,244.57) v1(322.93,243.81) v1(322.93,238.47) v1(322.93,185.59) v1(322.93,184.57) v1(322.93,183.81) v1(322.93,178.47) v1(323.95,252.7) v1(323.95,251.68) v1(323.95,250.6) v1(323.95,249.65) v1(323.95,248.63) v1(323.95,247.62) v1(323.95,246.6) v1(323.95,245.58) v1(323.95,244.57) v1(323.95,243.81) v1(323.95,238.47) v1(323.95,192.7) v1(323.95,191.68) v1(323.95,190.6) v1(323.95,189.65) v1(323.95,188.63) v1(323.95,187.62) v1(323.95,186.6) v1(323.95,185.59) v1(323.95,184.57) v1(323.95,183.81) v1(323.95,178.47) v1(323.96,256.29) v1(323.96,255.74) v1(323.96,196.29) v1(323.96,195.75) v1(324.97,238.47) v1(324.97,178.47) v1(325.74,254.73) v1(325.75,250.01) v1(325.75,249.19) v1(325.65,245.58) v1(325.65,243.81) v1(325.74,194.73) v1(325.75,190.01) v1(325.75,189.19) v1(325.65,185.59) v1(325.65,183.81) v1(325.75,255.74) v1(325.75,195.75) v1(325.98,252.91) v1(325.98,238.47) v1(325.98,192.91) v1(325.98,178.47) v1(326.34,252.23) v1(326.34,192.23) v1(326.67,245.58) v1(326.67,244.57) v1(326.67,243.81) v1(326.67,185.59) v1(326.67,184.57) v1(326.67,183.81) v1(327,238.47) v1(327,178.47) v1(327.16,253.85) v1(327.16,193.85) v1(327.73,243.5) v1(327.73,242.49) v1(327.73,241.47) v1(327.73,240.45) v1(327.73,239.44) v1(327.73,183.5) v1(327.73,182.49) v1(327.73,181.47) v1(327.73,180.45) v1(327.73,179.44) v1(327.89,250.45) v1(327.89,190.45) v1(328.56,253.83) v1(328.56,193.83) v1(328.68,249.52) v1(328.73,248.73) v1(328.68,189.52) v1(328.73,188.73) v1(328.8,245.53) v1(328.8,244.77) v1(328.8,239.44) v1(328.8,185.53) v1(328.8,184.77) v1(328.8,179.44) v1(329.81,249.52) v1(329.81,248.58) v1(329.81,247.57) v1(329.81,246.55) v1(329.81,244.77) v1(329.81,239.44) v1(329.81,189.52) v1(329.81,188.58) v1(329.81,187.57) v1(329.81,186.55) v1(329.81,184.77) v1(329.81,179.44) v1(330.64,256.93) v1(330.64,196.93) v1(330.83,239.44) v1(330.83,179.44) v1(331.19,253.66) v1(331.19,193.66) v1(331.52,251.63) v1(331.52,250.61) v1(331.52,249.6) v1(331.52,248.58) v1(331.52,247.57) v1(331.52,246.55) v1(331.52,245.53) v1(331.52,244.77) v1(331.52,191.63) v1(331.52,190.61) v1(331.52,189.6) v1(331.52,188.58) v1(331.52,187.57) v1(331.52,186.55) v1(331.52,185.53) v1(331.52,184.77) v1(331.67,252.65) v1(331.67,192.65) v1(331.85,239.44) v1(331.85,179.44) v1(332.22,255.2) v1(332.22,195.2) v1(332.46,251.63) v1(332.46,250.61) v1(332.53,248.58) v1(332.53,247.57) v1(332.53,246.55) v1(332.53,245.53) v1(332.53,244.77) v1(332.46,191.63) v1(332.46,190.61) v1(332.53,188.58) v1(332.53,187.57) v1(332.53,186.55) v1(332.53,185.53) v1(332.53,184.77) v1(332.86,239.44) v1(332.86,179.44) v1(333.01,254.18) v1(333.04,250.61) v1(333.01,194.18) v1(333.04,190.61) v1(333.21,246.28) v1(333.21,186.28) v1(333.55,244.26) v1(333.55,243.25) v1(333.55,242.23) v1(333.55,241.22) v1(333.55,240.2) v1(333.55,184.26) v1(333.55,183.25) v1(333.55,182.23) v1(333.55,181.22) v1(333.55,180.2) v1(333.59,253.17) v1(333.59,193.17) v1(333.69,245.42) v1(333.69,185.42) v1(333.79,249.23) v1(333.79,189.23) v1(334.15,244.63) v1(334.15,184.63) v1(334.58,243.87) v1(334.58,183.87) v1(334.76,251.13) v1(334.76,191.13) v1(335.34,250.12) v1(335.34,190.12) v1(335.62,243.74) v1(335.62,183.74) v1(336.28,250.68) v1(336.28,190.68) v1(336.48,244.25) v1(336.48,184.25) v1(337.09,250.09) v1(337.09,190.09) v1(337.4,244.78) v1(337.4,184.78) v1(337.78,249.36) v1(337.78,189.36) v1(338.34,245.32) v1(338.34,185.32) v1(338.49,248.64) v1(338.49,188.65) v1(338.97,247.78) v1(338.97,187.78) v1(339.28,245.83) v1(339.28,185.83) v1(339.46,246.97) v1(339.46,186.97) v1(361.92,244.57) v1(361.92,243.55) v1(361.92,242.54) v1(361.92,241.52) v1(361.92,240.5) v1(361.92,239.49) v1(361.92,238.47) v1(361.92,184.57) v1(361.92,183.55) v1(361.92,182.54) v1(361.92,181.52) v1(361.92,180.51) v1(361.92,179.49) v1(361.92,178.47) v1(362.93,245.58) v1(362.93,244.57) v1(362.93,243.81) v1(362.93,238.47) v1(362.93,185.59) v1(362.93,184.57) v1(362.93,183.81) v1(362.93,178.47) v1(363.95,252.7) v1(363.95,251.68) v1(363.95,250.6) v1(363.95,249.65) v1(363.95,248.63) v1(363.95,247.62) v1(363.95,246.6) v1(363.95,245.58) v1(363.95,244.57) v1(363.95,243.81) v1(363.95,238.47) v1(363.95,192.7) v1(363.95,191.68) v1(363.95,190.6) v1(363.95,189.65) v1(363.95,188.63) v1(363.95,187.62) v1(363.95,186.6) v1(363.95,185.59) v1(363.95,184.57) v1(363.95,183.81) v1(363.95,178.47) v1(363.96,256.29) v1(363.96,255.74) v1(363.96,196.29) v1(363.96,195.75) v1(364.97,238.47) v1(364.97,178.47) v1(365.65,245.58) v1(365.65,243.81) v1(365.65,185.59) v1(365.65,183.81) v1(365.74,254.73) v1(365.75,250.01) v1(365.75,249.19) v1(365.74,194.73) v1(365.75,190.01) v1(365.75,189.19) v1(365.75,255.74) v1(365.75,195.75) v1(365.98,252.91) v1(365.98,238.47) v1(365.98,192.91) v1(365.98,178.47) v1(366.34,252.23) v1(366.34,192.23) v1(366.67,245.58) v1(366.67,244.57) v1(366.67,243.81) v1(366.67,185.59) v1(366.67,184.57) v1(366.67,183.81) v1(367,238.47) v1(367,178.47) v1(367.16,253.85) v1(367.16,193.85) v1(367.73,243.5) v1(367.73,242.49) v1(367.73,241.47) v1(367.73,240.45) v1(367.73,239.44) v1(367.73,183.5) v1(367.73,182.49) v1(367.73,181.47) v1(367.73,180.45) v1(367.73,179.44) v1(367.89,250.45) v1(367.89,190.45) v1(368.56,253.83) v1(368.56,193.83) v1(368.68,249.52) v1(368.73,248.73) v1(368.68,189.52) v1(368.73,188.73) v1(368.8,245.53) v1(368.8,244.77) v1(368.8,239.44) v1(368.8,185.53) v1(368.8,184.77) v1(368.8,179.44) v1(369.81,249.52) v1(369.81,248.58) v1(369.81,247.57) v1(369.81,246.55) v1(369.81,244.77) v1(369.81,239.44) v1(369.81,189.52) v1(369.81,188.58) v1(369.81,187.57) v1(369.81,186.55) v1(369.81,184.77) v1(369.81,179.44) v1(370.64,256.93) v1(370.64,196.93) v1(370.83,239.44) v1(370.83,179.44) v1(371.19,253.66) v1(371.19,193.66) v1(371.52,251.63) v1(371.52,250.61) v1(371.52,249.6) v1(371.52,248.58) v1(371.52,247.57) v1(371.52,246.55) v1(371.52,245.53) v1(371.52,244.77) v1(371.52,191.63) v1(371.52,190.61) v1(371.52,189.6) v1(371.52,188.58) v1(371.52,187.57) v1(371.52,186.55) v1(371.52,185.53) v1(371.52,184.77) v1(371.67,252.65) v1(371.67,192.65) v1(371.85,239.44) v1(371.85,179.44) v1(372.22,255.2) v1(372.22,195.2) v1(372.46,251.63) v1(372.46,250.61) v1(372.53,248.58) v1(372.53,247.57) v1(372.53,246.55) v1(372.53,245.53) v1(372.53,244.77) v1(372.46,191.63) v1(372.46,190.61) v1(372.53,188.58) v1(372.53,187.57) v1(372.53,186.55) v1(372.53,185.53) v1(372.53,184.77) v1(372.86,239.44) v1(372.86,179.44) v1(373.01,254.18) v1(373.04,250.61) v1(373.01,194.18) v1(373.04,190.61) v1(373.21,246.28) v1(373.21,186.28) v1(373.55,244.26) v1(373.55,243.25) v1(373.55,242.23) v1(373.55,241.22) v1(373.55,240.2) v1(373.55,184.26) v1(373.55,183.25) v1(373.55,182.23) v1(373.55,181.22) v1(373.55,180.2) v1(373.59,253.17) v1(373.59,193.17) v1(373.69,245.42) v1(373.69,185.42) v1(373.79,249.23) v1(373.79,189.23) v1(374.15,244.63) v1(374.15,184.63) v1(374.58,243.87) v1(374.58,183.87) v1(374.76,251.13) v1(374.76,191.13) v1(375.34,250.12) v1(375.34,190.12) v1(375.62,243.74) v1(375.62,183.74) v1(376.28,250.68) v1(376.28,190.68) v1(376.48,244.25) v1(376.48,184.25) v1(377.09,250.09) v1(377.09,190.09) v1(377.4,244.78) v1(377.4,184.78) v1(377.78,249.36) v1(377.78,189.36) v1(378.34,245.32) v1(378.34,185.32) v1(378.49,248.64) v1(378.49,188.65) v1(378.97,247.78) v1(378.97,187.78) v1(379.28,245.83) v1(379.28,185.83) v1(379.46,246.97) v1(379.46,186.97) v1(401.92,244.57) v1(401.92,243.55) v1(401.92,242.54) v1(401.92,241.52) v1(401.92,240.5) v1(401.92,239.49) v1(401.92,238.47) v1(401.92,184.57) v1(401.92,183.55) v1(401.92,182.54) v1(401.92,181.52) v1(401.92,180.51) v1(401.92,179.49) v1(401.92,178.47) v1(402.93,245.58) v1(402.93,244.57) v1(402.93,243.81) v1(402.93,238.47) v1(402.93,185.59) v1(402.93,184.57) v1(402.93,183.81) v1(402.93,178.47) v1(403.95,252.7) v1(403.95,251.68) v1(403.95,250.6) v1(403.95,249.65) v1(403.95,248.63) v1(403.95,247.62) v1(403.95,246.6) v1(403.95,245.58) v1(403.95,244.57) v1(403.95,243.81) v1(403.95,238.47) v1(403.95,192.7) v1(403.95,191.68) v1(403.95,190.6) v1(403.95,189.65) v1(403.95,188.63) v1(403.95,187.62) v1(403.95,186.6) v1(403.95,185.59) v1(403.95,184.57) v1(403.95,183.81) v1(403.95,178.47) v1(403.96,256.29) v1(403.96,255.74) v1(403.96,196.29) v1(403.96,195.75) v1(404.97,238.47) v1(404.97,178.47) v1(405.65,245.58) v1(405.65,243.81) v1(405.65,185.59) v1(405.65,183.81) v1(405.74,254.73) v1(405.75,250.01) v1(405.75,249.19) v1(405.74,194.73) v1(405.75,190.01) v1(405.75,189.19) v1(405.75,255.74) v1(405.75,195.75) v1(405.98,252.91) v1(405.98,238.47) v1(405.98,192.91) v1(405.98,178.47) v1(406.34,252.23) v1(406.34,192.23) v1(406.67,245.58) v1(406.67,244.57) v1(406.67,243.81) v1(406.67,185.59) v1(406.67,184.57) v1(406.67,183.81) v1(407,238.47) v1(407,178.47) v1(407.16,253.85) v1(407.16,193.85) v1(407.73,243.5) v1(407.73,242.49) v1(407.73,241.47) v1(407.73,240.45) v1(407.73,239.44) v1(407.73,183.5) v1(407.73,182.49) v1(407.73,181.47) v1(407.73,180.45) v1(407.73,179.44) v1(407.89,250.45) v1(407.89,190.45) v1(408.56,253.83) v1(408.56,193.83) v1(408.68,249.52) v1(408.73,248.73) v1(408.68,189.52) v1(408.73,188.73) v1(408.8,245.53) v1(408.8,244.77) v1(408.8,239.44) v1(408.8,185.53) v1(408.8,184.77) v1(408.8,179.44) v1(409.81,249.52) v1(409.81,248.58) v1(409.81,247.57) v1(409.81,246.55) v1(409.81,244.77) v1(409.81,239.44) v1(409.81,189.52) v1(409.81,188.58) v1(409.81,187.57) v1(409.81,186.55) v1(409.81,184.77) v1(409.81,179.44) v1(410.64,256.93) v1(410.64,196.93) v1(410.83,239.44) v1(410.83,179.44) v1(411.19,253.66) v1(411.19,193.66) v1(411.52,251.63) v1(411.52,250.61) v1(411.52,249.6) v1(411.52,248.58) v1(411.52,247.57) v1(411.52,246.55) v1(411.52,245.53) v1(411.52,244.77) v1(411.52,191.63) v1(411.52,190.61) v1(411.52,189.6) v1(411.52,188.58) v1(411.52,187.57) v1(411.52,186.55) v1(411.52,185.53) v1(411.52,184.77) v1(411.67,252.65) v1(411.67,192.65) v1(411.85,239.44) v1(411.85,179.44) v1(412.22,255.2) v1(412.22,195.2) v1(412.46,251.63) v1(412.46,250.61) v1(412.53,248.58) v1(412.53,247.57) v1(412.53,246.55) v1(412.53,245.53) v1(412.53,244.77) v1(412.46,191.63) v1(412.46,190.61) v1(412.53,188.58) v1(412.53,187.57) v1(412.53,186.55) v1(412.53,185.53) v1(412.53,184.77) v1(412.86,239.44) v1(412.86,179.44) v1(413.01,254.18) v1(413.04,250.61) v1(413.01,194.18) v1(413.04,190.61) v1(413.21,246.28) v1(413.21,186.28) v1(413.55,244.26) v1(413.55,243.25) v1(413.55,242.23) v1(413.55,241.22) v1(413.55,240.2) v1(413.55,184.26) v1(413.55,183.25) v1(413.55,182.23) v1(413.55,181.22) v1(413.55,180.2) v1(413.59,253.17) v1(413.59,193.17) v1(413.69,245.42) v1(413.69,185.42) v1(413.79,249.23) v1(413.79,189.23) v1(414.15,244.63) v1(414.15,184.63) v1(414.58,243.87) v1(414.58,183.87) v1(414.76,251.13) v1(414.76,191.13) v1(415.34,250.12) v1(415.34,190.12) v1(415.62,243.74) v1(415.62,183.74) v1(416.28,250.68) v1(416.28,190.68) v1(416.48,244.25) v1(416.48,184.25) v1(417.09,250.09) v1(417.09,190.09) v1(417.4,244.78) v1(417.4,184.78) v1(417.78,249.36) v1(417.78,189.36) v1(418.34,245.32) v1(418.34,185.32) v1(418.49,248.64) v1(418.49,188.65) v1(418.97,247.78) v1(418.97,187.78) v1(419.28,245.83) v1(419.28,185.83) v1(419.46,246.97) v1(419.46,186.97) v3(290.22,254.68) v3(290.22,194.68) v3(294.17,252.15) v3(294.17,192.15) v3(330.22,254.68) v3(330.22,194.68) v3(334.17,252.15) v3(334.17,192.15) v3(370.22,254.68) v3(370.22,194.68) v3(374.17,252.15) v3(374.17,192.15) v3(410.22,254.68) v3(410.22,194.68) v3(414.17,252.15) v3(414.17,192.15)
