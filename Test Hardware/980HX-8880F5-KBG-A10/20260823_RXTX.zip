# Allegro board 8880F5-0823_RXTX.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D13113: length 833.7
  TOP w0.086: v1(276.24,250.09) 275.8,250.53 270.02,250.53 269.2,249.71 264.06,249.71 263.98,249.63 SITE1.79
  L07_SIGNAL w0.071: v2(212.03,230.74) 212.5,230.27 213.48,230.27 214.36,229.4 214.36,224.07 212.02,221.74 130.68,221.74 129.29,220.34 83.36,220.34 77.08,214.06 77.08,140.32 111.99,105.4 125.3,105.4 130.47,100.23 130.47,54.57 127.24,51.34 120.1,51.34 119.01,52.43 119.01,53.71 D131.13
  L30_SIGNAL w0.071: v2(212.03,230.74) 211.56,230.27 210.76,230.27 210.09,230.94 210.09,239.48 209.33,240.24 167.91,240.24 162.05,234.38 106.72,234.38 105.33,232.99 57.97,232.99 56.9,234.05 56.9,254.83 56,255.73 52.33,255.73 51.62,255.03 51.62,248.07 50.61,247.06 46.83,247.06 45.44,248.44 45.44,260.98 47.38,262.92 210.37,262.92 220.57,252.72 223.91,252.72 225.87,250.76 236.92,250.76 242.41,245.28 259.62,245.28 264.91,250.56 275.77,250.56 v1(276.24,250.09)
D13115: length 833.7
  TOP w0.086: SITE1.80 263.98,250.03 264.06,249.95 269.1,249.95 269.92,250.77 275.78,250.77 v1(276.24,251.23)
  L07_SIGNAL w0.071: v2(212.03,229.6) 212.5,230.07 213.4,230.07 214.16,229.31 214.16,224.16 211.94,221.94 130.6,221.94 129.21,220.54 83.28,220.54 76.88,214.14 76.88,140.24 111.91,105.2 125.21,105.2 130.27,100.15 130.27,54.65 127.16,51.54 120.19,51.54 119.21,52.51 119.21,53.31 120.24,54.34 120.38,54.34 D131.15
  L30_SIGNAL w0.071: v1(276.24,251.23) 275.77,250.76 264.83,250.76 259.54,245.47 242.49,245.47 237,250.96 225.95,250.96 223.99,252.92 220.66,252.92 210.45,263.12 47.3,263.12 45.24,261.06 45.24,248.36 46.74,246.86 50.69,246.86 51.82,247.99 51.82,254.95 52.41,255.54 55.91,255.54 56.7,254.75 56.7,233.97 57.89,232.79 105.41,232.79 106.8,234.18 162.14,234.18 168,240.04 209.25,240.04 209.89,239.39 209.89,230.86 210.67,230.07 211.55,230.07 v2(212.03,229.6)
D13201: length 833.7
  TOP w0.086: SITE1.135 237.68,252.43 237.6,252.35 236.46,252.35 231.86,256.95 228.04,256.95 v1(227.6,257.38)
  L07_SIGNAL w0.071: v2(178.5,258.17) 178.97,257.7 179.25,257.7 179.97,258.42 179.97,260.04 179.16,260.84 175,260.84 168.26,254.1 140.98,254.1 135.02,248.14 84.83,248.14 55.75,219.05 55.75,135.85 78.94,112.65 78.94,34.36 82.81,30.5 87.69,30.5 89.74,32.54 89.74,33.66 89.07,34.33 87.59,34.33 D132.01
  L32_SIGNAL w0.071: v2(178.5,258.17) 178.97,257.7 179.32,257.7 179.59,257.97 179.59,265.41 176.16,268.84 176.16,274.85 170.37,280.64 160.39,280.64 157.09,283.94 67.9,283.94 60.74,291.11 60.74,351.38 69.22,359.86 195.72,359.86 209.48,346.1 209.48,284.58 214.25,279.81 214.25,262.45 219.79,256.91 227.13,256.91 v1(227.6,257.38)
D13202: length 833.7
  TOP w0.086: SITE1.142 237.68,249.63 237.6,249.55 233.04,249.55 231.83,250.76 224.76,250.76 v1(224.31,251.21)
  L07_SIGNAL w0.071: v2(181.67,258.17) 181.2,257.7 180.84,257.7 180.46,257.32 180.46,244.15 172.01,235.7 130.48,235.7 128.78,237.39 78.63,237.39 57.53,216.29 57.53,138.19 80.26,115.46 80.26,47.47 85.33,42.4 90.59,42.4 91.03,41.96 91.03,40.23 D132.02
  L32_SIGNAL w0.071: v1(224.31,251.21) 223.83,250.74 223.37,250.74 222.19,251.92 210.89,251.92 207.99,254.83 207.99,268.92 205.43,271.49 205.43,342.84 193.77,354.5 107.12,354.5 83.02,330.39 83.02,298.44 85.84,295.61 150.29,295.61 156.76,302.07 199.53,302.07 201.7,299.9 201.7,254 197.16,249.47 191.59,249.47 183.36,257.7 182.15,257.7 v2(181.67,258.17)
D13203: length 833.7
  TOP w0.086: v1(227.6,256.24) 228.07,256.71 231.76,256.71 236.36,252.11 237.6,252.11 237.68,252.03 SITE1.136
  L07_SIGNAL w0.071: v2(178.5,257.03) 178.97,257.5 179.33,257.5 180.16,258.34 180.16,260.12 179.25,261.04 174.92,261.04 168.18,254.3 140.9,254.3 134.94,248.34 84.75,248.34 55.55,219.14 55.55,135.77 78.74,112.57 78.74,34.28 82.72,30.3 87.78,30.3 89.94,32.46 89.94,34.06 D132.03
  L32_SIGNAL w0.071: v1(227.6,256.24) 227.13,256.71 219.71,256.71 214.05,262.37 214.05,279.73 209.29,284.49 209.29,346.02 195.64,359.66 69.3,359.66 60.94,351.3 60.94,291.19 67.99,284.14 157.18,284.14 160.48,280.84 170.45,280.84 176.36,274.93 176.36,268.93 179.79,265.49 179.79,257.89 179.4,257.5 178.97,257.5 v2(178.5,257.03)
D13204: length 833.7
  TOP w0.086: SITE1.143 237.68,249.23 237.6,249.31 232.94,249.31 231.73,250.52 224.76,250.52 v1(224.31,250.07)
  L07_SIGNAL w0.071: D132.04 92.47,39.61 92.36,39.61 91.23,40.74 91.23,42.04 90.67,42.6 85.42,42.6 80.46,47.55 80.46,115.54 57.73,138.27 57.73,216.21 78.72,237.2 128.7,237.2 130.4,235.5 172.1,235.5 180.66,244.06 180.66,257.24 180.93,257.5 181.2,257.5 v2(181.67,257.03)
  L32_SIGNAL w0.071: v2(181.67,257.03) 182.15,257.5 183.28,257.5 191.51,249.27 197.25,249.27 201.9,253.92 201.9,299.98 199.61,302.27 156.67,302.27 150.21,295.81 85.92,295.81 83.22,298.52 83.22,330.31 107.21,354.3 193.69,354.3 205.23,342.76 205.23,271.41 207.79,268.84 207.79,254.75 210.81,251.72 222.11,251.72 223.29,250.54 223.83,250.54 v1(224.31,250.07)
D13205: length 833.7
  TOP w0.086: SITE1.137 237.68,251.63 237.6,251.55 235.88,251.55 232.43,255.01 224.75,255.01 v1(224.31,255.45)
  L07_SIGNAL w0.071: v2(164.91,258.17) 165.38,257.7 166.27,257.7 166.93,258.36 166.93,259.9 166.05,260.79 142.38,260.79 131.93,250.34 82.26,250.34 52.78,220.86 52.78,134.44 77.42,109.8 77.42,33.22 81.87,28.76 97.59,28.76 99.95,31.12 99.95,33.53 99.13,34.35 97.73,34.35 D132.05
  L32_SIGNAL w0.071: v2(164.91,258.17) 165.38,257.7 166.4,257.7 168.1,256 178.81,256 180.68,257.87 180.68,282.95 178.65,284.98 79.91,284.98 75.84,289.05 75.84,350.19 84.23,358.57 194.95,358.57 208.36,345.16 208.36,283.57 213,278.93 213,262.04 220.06,254.98 223.83,254.98 v1(224.31,255.45)
D13206: length 833.7
  TOP w0.086: SITE1.140 237.68,250.43 237.6,250.35 233.88,250.35 231.52,252.7 228.04,252.7 v1(227.6,253.14)
  L07_SIGNAL w0.071: D132.06 101.21,40.25 101.21,43.1 101,43.31 86.59,43.31 81.59,48.31 81.59,118.76 60.86,139.49 60.86,213.94 80.55,233.64 178.77,233.64 188.73,243.61 188.73,253.97 190.98,256.21 192.26,256.21 193.75,257.7 194.79,257.7 v2(195.26,258.17)
  L32_SIGNAL w0.071: v2(195.26,258.17) 195.73,257.7 196.49,257.7 196.9,258.11 196.9,277.06 189.97,283.99 189.97,289.22 188.38,290.81 171.26,290.81 170.14,289.69 170.14,287.36 169.43,286.65 159.36,286.65 157.75,288.26 154.24,288.26 152.41,286.44 81.64,286.44 77.9,290.18 77.9,349.68 84.92,356.7 193.71,356.7 207.33,343.08 207.33,273.94 210.6,270.67 210.6,254.63 212.55,252.67 227.13,252.67 v1(227.6,253.14)
D13207: length 833.7
  TOP w0.086: SITE1.138 237.68,251.23 237.6,251.31 235.78,251.31 232.33,254.77 224.76,254.77 v1(224.31,254.31)
  L07_SIGNAL w0.071: D132.07 100.15,34.11 100.15,31.04 97.67,28.56 81.79,28.56 77.22,33.13 77.22,109.72 52.59,134.36 52.59,220.94 82.18,250.54 131.85,250.54 142.29,260.99 166.13,260.99 167.13,259.99 167.13,258.28 166.35,257.5 165.38,257.5 v2(164.91,257.03)
  L32_SIGNAL w0.071: v2(164.91,257.03) 165.38,257.5 166.32,257.5 168.02,255.8 178.9,255.8 180.88,257.78 180.88,283.03 178.74,285.17 80,285.17 76.04,289.13 76.04,350.1 84.31,358.38 194.86,358.38 208.16,345.08 208.16,283.49 212.8,278.85 212.8,261.96 219.98,254.78 223.83,254.78 v1(224.31,254.31)
D13208: length 833.7
  TOP w0.086: v1(227.6,252) 228.06,252.46 231.43,252.46 233.78,250.11 237.6,250.11 237.68,250.03 SITE1.141
  L07_SIGNAL w0.071: v1(195.26,257.03) 194.79,257.5 193.83,257.5 192.35,256.02 191.06,256.02 188.93,253.89 188.93,243.52 178.85,233.44 80.64,233.44 61.05,213.86 61.05,139.57 81.79,118.84 81.79,48.4 86.67,43.51 101.08,43.51 101.41,43.18 101.41,40.7 102.22,39.89 102.35,39.89 D132.08
  L32_SIGNAL w0.071: v1(227.6,252) 227.13,252.47 212.47,252.47 210.4,254.54 210.4,270.59 207.13,273.86 207.13,343 193.62,356.5 85,356.5 78.1,349.6 78.1,290.26 81.72,286.64 152.33,286.64 154.16,288.46 157.83,288.46 159.45,286.85 169.35,286.85 169.94,287.44 169.94,289.77 171.18,291.01 188.46,291.01 190.17,289.3 190.17,284.07 197.1,277.14 197.1,258.02 196.58,257.5 195.73,257.5 v1(195.26,257.03)
D13209: length 833.7
  TOP w0.086: v1(250.93,270.87) 250.46,270.4 250.46,268.18 249.35,267.06 249.35,257.86 249.43,257.78 SITE1.114
  L07_SIGNAL w0.071: D132.09 107.83,34.41 109.75,34.41 110.1,34.06 110.1,30.73 106.53,27.16 80.99,27.16 75.85,32.3 75.85,107.65 50.03,133.46 50.03,223.84 79.91,253.72 131.34,253.72 140.9,263.28 222.21,263.28 232.47,273.53 251.47,273.53 265.55,287.62 269.61,287.62 270.11,287.12 270.11,286.54 v2(269.64,286.07)
  L30_SIGNAL w0.071: v2(269.64,286.07) 270.13,286.55 270.13,287.58 271.35,288.8 271.35,290.5 273.2,292.36 273.2,343.05 272.37,343.89 238.19,343.89 237.51,344.57 237.51,346.35 238.28,347.12 272.46,347.12 273.08,347.75 273.08,348.63 272.45,349.26 210.22,349.26 209.07,348.1 209.07,325.91 212.18,322.8 247.92,322.8 261.29,309.43 261.29,287.17 250.46,276.34 250.46,271.34 v1(250.93,270.87)
D13210: length 833.7
  TOP w0.086: SITE1.116 248.63,257.78 248.55,257.86 248.55,268.77 v1(248.93,269.15)
  L07_SIGNAL w0.071: D132.10 111.16,40.04 111.16,44.19 110.45,44.9 87.41,44.9 82.88,49.44 82.88,123.87 66.74,140.01 66.74,214.95 81.82,230.03 129.12,230.03 130.74,231.65 193.37,231.65 210.52,248.8 227.84,248.8 235,255.96 270.62,255.96 280.57,265.91 280.57,268.75 283.02,271.2 286.45,271.2 286.91,270.74 286.91,269.78 v2(287.38,269.3)
  L30_SIGNAL w0.071: v1(248.93,269.15) 248.46,269.62 248.46,275.58 255.67,282.79 255.67,289.18 260.19,293.7 260.19,305.4 244.61,320.97 201.65,320.97 199.69,322.94 199.69,349.49 201.02,350.83 201.93,350.83 202.72,350.04 202.72,322.86 203.88,321.7 206.34,321.7 207.39,322.75 207.39,349.8 208.1,350.52 274.52,350.52 276.38,348.66 276.38,282.72 281.66,277.43 281.66,266.06 282.77,264.94 286.04,264.94 286.91,265.82 286.91,268.83 v2(287.38,269.3)
D13211: length 833.7
  TOP w0.086: SITE1.115 249.03,257.78 249.11,257.86 249.11,267.16 250.22,268.28 250.22,270.43 v1(249.79,270.87)
  L07_SIGNAL w0.071: v2(270.78,286.07) 270.31,286.54 270.31,287.2 269.7,287.82 265.47,287.82 251.38,273.73 232.38,273.73 222.13,263.48 140.82,263.48 131.26,253.91 79.82,253.91 49.84,223.93 49.84,133.38 75.65,107.56 75.65,32.22 80.91,26.96 106.61,26.96 110.3,30.64 110.3,34.1 D132.11
  L30_SIGNAL w0.071: v2(270.78,286.07) 270.32,286.53 270.32,287.49 271.55,288.72 271.55,290.42 273.4,292.27 273.4,343.14 272.45,344.08 238.27,344.08 237.7,344.65 237.7,346.27 238.36,346.93 272.54,346.93 273.28,347.67 273.28,348.71 272.54,349.45 210.14,349.45 208.87,348.19 208.87,325.83 212.1,322.6 247.84,322.6 261.09,309.35 261.09,287.25 250.26,276.43 250.26,271.34 v1(249.79,270.87)
D13212: length 833.7
  TOP w0.086: v1(247.79,269.15) 248.31,268.63 248.31,257.86 248.23,257.78 SITE1.117
  L07_SIGNAL w0.071: D132.12 112.36,40.04 112.03,40.04 111.35,40.72 111.35,44.27 110.53,45.1 87.5,45.1 83.07,49.52 83.07,123.95 66.93,140.09 66.93,214.87 81.9,229.83 129.2,229.83 130.82,231.45 193.46,231.45 210.6,248.6 227.92,248.6 235.08,255.76 270.7,255.76 280.77,265.82 280.77,268.66 283.11,271 286.37,271 286.71,270.66 286.71,269.78 v2(286.24,269.3)
  L30_SIGNAL w0.071: v2(286.24,269.3) 286.71,268.83 286.71,265.9 285.95,265.14 282.85,265.14 281.86,266.14 281.86,277.52 276.58,282.8 276.58,348.74 274.6,350.72 208.02,350.72 207.19,349.89 207.19,322.83 206.26,321.9 203.96,321.9 202.92,322.94 202.92,350.12 202.01,351.03 200.94,351.03 199.49,349.58 199.49,322.86 201.57,320.78 244.53,320.78 259.99,305.31 259.99,293.78 255.47,289.26 255.47,282.87 248.26,275.66 248.26,269.62 v1(247.79,269.15)
D13213: length 833.7
  TOP w0.086: v1(239.3,270.88) 238.85,270.43 238.85,263.79 243.35,259.29 243.35,257.86 243.43,257.78 SITE1.129
  L07_SIGNAL w0.071: D132.13 118.13,34.27 119.82,34.27 120.47,33.62 120.47,30.71 115.07,25.31 79.76,25.31 73.99,31.07 73.99,106.09 48.05,132.04 48.05,226.78 85.94,264.67 221.19,264.67 244.35,287.83 256.11,287.83 256.9,287.04 256.9,286.54 v2(256.43,286.07)
  L32_SIGNAL w0.071: v1(239.3,270.88) 238.83,271.35 238.83,283.57 239.9,284.64 239.9,299.98 216.23,323.65 216.23,364.36 221.29,369.42 221.29,378.76 224.65,382.12 249.41,382.12 250.53,381 250.53,379.41 249.55,378.44 225.5,378.44 224.37,377.31 224.37,374.82 225.36,373.83 235.35,373.83 236.49,372.69 236.49,369.47 235.53,368.51 224.13,368.51 220.86,365.23 220.86,328.12 241.43,307.55 241.43,293.46 244.07,290.83 253.94,290.83 256.9,287.86 256.9,286.54 v2(256.43,286.07)
D13214: length 833.7
  TOP w0.086: SITE1.81 263.98,250.43 264.06,250.51 267.46,250.51 269.46,252.51 278.8,252.51 v1(279.29,252.02)
  L07_SIGNAL w0.071: v2(198.44,230.74) 197.97,230.27 197.09,230.27 193.22,226.39 106.2,226.39 104.99,225.18 81.1,225.18 73.01,217.1 73.01,138.99 84.16,127.84 84.16,49.97 87.95,46.18 119.58,46.18 122.02,43.75 122.02,40.49 121.47,39.94 121.22,39.94 D132.14
  L30_SIGNAL w0.071: v2(198.44,230.74) 197.98,230.28 197.12,230.28 194.07,233.32 163.11,233.32 159.25,229.47 92.13,229.47 91.1,230.5 52.56,230.5 51.57,231.5 51.57,243.33 50.2,244.7 47.65,244.7 46.39,243.43 46.39,230.24 45.54,229.4 43.71,229.4 42.27,230.84 42.27,263.53 43.39,264.65 162.86,264.65 164.61,266.39 219.73,266.39 229.62,256.5 233.86,256.5 239.76,250.6 255.02,250.6 256.91,252.49 278.82,252.49 v1(279.29,252.02)
D13215: length 833.7
  TOP w0.086: SITE1.130 243.03,257.78 243.11,257.86 243.11,259.19 238.61,263.69 238.61,270.43 v1(238.16,270.88)
  L07_SIGNAL w0.071: D132.15 120.67,34.31 120.67,30.63 115.15,25.11 79.68,25.11 73.79,30.99 73.79,106.01 47.85,131.95 47.85,226.86 85.86,264.87 221.11,264.87 244.27,288.03 256.19,288.03 257.1,287.12 257.1,286.54 v2(257.58,286.07)
  L32_SIGNAL w0.071: v1(238.16,270.88) 238.63,271.35 238.63,283.65 239.7,284.72 239.7,299.9 216.03,323.57 216.03,364.44 221.09,369.5 221.09,378.84 224.56,382.32 249.5,382.32 250.72,381.09 250.72,379.33 249.64,378.24 225.58,378.24 224.56,377.22 224.56,374.91 225.44,374.03 235.43,374.03 236.69,372.77 236.69,369.39 235.61,368.31 224.22,368.31 221.05,365.15 221.05,328.21 241.63,307.63 241.63,293.55 244.15,291.03 254.02,291.03 257.1,287.94 257.1,286.54 v2(257.58,286.07)
D13216: length 833.7
  TOP w0.086: SITE1.82 263.98,250.83 264.06,250.75 267.37,250.75 269.36,252.75 278.88,252.75 v1(279.29,253.16)
  L07_SIGNAL w0.071: D132.16 122.22,40.34 122.22,43.83 119.67,46.38 88.03,46.38 84.36,50.05 84.36,127.92 73.21,139.07 73.21,217.01 81.18,224.98 105.07,224.98 106.28,226.19 193.3,226.19 197.17,230.07 197.97,230.07 v1(198.44,229.6)
  L30_SIGNAL w0.071: v1(198.44,229.6) 197.95,230.08 197.04,230.08 193.99,233.13 163.19,233.13 159.34,229.27 92.05,229.27 91.02,230.3 52.48,230.3 51.37,231.41 51.37,243.25 50.11,244.5 47.74,244.5 46.59,243.35 46.59,230.16 45.62,229.2 43.63,229.2 42.08,230.75 42.08,263.61 43.31,264.84 162.78,264.84 164.53,266.59 219.81,266.59 229.71,256.69 233.95,256.69 239.84,250.8 254.94,250.8 256.83,252.69 278.82,252.69 v1(279.29,253.16)
D30102: length 192.4
  TOP w0.147: SITE4.26 332.23,171.33 332.23,171.32 332.23,154.55 arc(332.21,154.42) 332.13,154.31 330.19,152.37 arc(330.08,152.3) 329.95,152.27 318.28,152.27 arc(317.99,152.21) 317.76,152.05 316.41,150.71 arc(316.25,150.47) 316.2,150.19 316.2,146.19 arc(316.25,145.9) 316.41,145.66 317.47,144.6 arc(317.71,144.44) 317.99,144.39 331.11,144.39 arc(331.25,144.36) 331.36,144.29 333.1,142.54 arc(333.18,142.43) 333.2,142.3 333.2,132.06 arc(333.18,131.93) 333.1,131.82 328.32,127.04 arc(328.21,126.97) 328.08,126.94 308.43,126.94 arc(308.03,126.86) 307.69,126.63 306.96,125.91 arc(306.74,125.57) 306.66,125.17 306.66,97.52 arc(306.75,97.03) 307.03,96.62 307.03,96.62 arc(307.63,96.22) 308.34,96.08 arc(309.04,96.22) 309.63,96.61 arc(309.9,97.01) 309.99,97.48 309.99,121.45 arc(310.05,121.72) 310.2,121.95 arc(310.63,122.24) 311.14,122.34 arc(311.63,122.25) 312.04,121.97 arc(312.18,121.76) 312.23,121.52 312.23,91.55 arc(312.17,91.27) 312.01,91.03 D301.02
D30104: length 192.4
  TOP w0.147: D301.04 312.84,91.02 arc(312.68,91.26) 312.62,91.54 312.62,121.52 arc(312.55,121.92) 312.32,122.25 arc(311.78,122.61) 311.14,122.74 arc(310.48,122.61) 309.92,122.23 arc(309.68,121.88) 309.6,121.45 309.6,97.48 arc(309.53,97.16) 309.35,96.89 arc(308.89,96.58) 308.34,96.47 arc(307.78,96.59) 307.31,96.9 307.31,96.9 arc(307.12,97.18) 307.05,97.52 307.05,125.17 arc(307.1,125.42) 307.24,125.63 307.97,126.35 arc(308.18,126.49) 308.43,126.54 328.08,126.54 arc(328.36,126.6) 328.6,126.76 333.38,131.54 arc(333.54,131.78) 333.6,132.06 333.6,142.3 arc(333.54,142.58) 333.38,142.82 331.64,144.57 arc(331.4,144.73) 331.11,144.79 317.99,144.79 arc(317.86,144.81) 317.75,144.88 316.69,145.94 arc(316.62,146.06) 316.59,146.19 316.59,150.19 arc(316.62,150.32) 316.69,150.43 318.04,151.77 arc(318.15,151.85) 318.28,151.87 329.95,151.87 arc(330.23,151.93) 330.47,152.09 332.41,154.03 arc(332.57,154.27) 332.63,154.55 332.63,171.32 332.63,171.33 SITE4.27
D30106: length 192.4
  TOP w0.147: D301.06 322.18,91.04 arc(322.34,91.28) 322.4,91.57 322.4,95.07 arc(322.32,95.49) 322.08,95.84 arc(321.73,96.07) 321.32,96.15 316.66,96.15 arc(316.17,96.25) 315.76,96.53 315.75,96.53 arc(315.24,97.31) 315.05,98.22 arc(315.23,99.12) 315.74,99.88 arc(316.14,100.15) 316.62,100.24 321.27,100.24 arc(321.4,100.27) 321.51,100.34 322.3,101.13 arc(322.37,101.24) 322.4,101.37 322.4,122.89 arc(322.46,123.17) 322.62,123.41 323.15,123.95 arc(323.39,124.11) 323.67,124.16 324.64,124.16 arc(324.92,124.11) 325.16,123.95 325.83,123.28 arc(325.99,123.04) 326.05,122.75 326.05,95.92 arc(326.1,95.64) 326.26,95.41 arc(326.69,95.11) 327.21,95.01 327.43,95.01 arc(327.96,95.12) 328.4,95.41 arc(328.56,95.65) 328.61,95.93 328.61,123.08 arc(328.67,123.36) 328.83,123.6 335.73,130.5 arc(335.8,130.61) 335.83,130.74 335.83,145.03 arc(335.8,145.16) 335.73,145.27 334.69,146.31 arc(334.58,146.38) 334.45,146.41 319.65,146.41 arc(319.37,146.46) 319.13,146.62 318.65,147.11 arc(318.49,147.35) 318.43,147.63 318.43,148.81 arc(318.49,149.09) 318.65,149.33 318.99,149.67 arc(319.23,149.83) 319.51,149.89 330.73,149.89 arc(330.86,149.91) 330.97,149.99 334.49,153.51 arc(334.56,153.62) 334.59,153.75 334.59,165.93 arc(334.56,166.06) 334.49,166.17 333.65,167.01 arc(333.49,167.25) 333.43,167.53 333.43,171.32 333.43,171.33 SITE4.29
D30108: length 192.4
  TOP w0.147: SITE4.30 333.83,171.33 333.83,171.32 333.83,167.53 arc(333.85,167.4) 333.93,167.29 334.77,166.45 arc(334.93,166.21) 334.99,165.93 334.99,153.75 arc(334.93,153.47) 334.77,153.23 331.25,149.7 arc(331.01,149.55) 330.73,149.49 319.51,149.49 arc(319.38,149.46) 319.27,149.39 318.93,149.05 arc(318.85,148.94) 318.83,148.81 318.83,147.63 arc(318.85,147.5) 318.93,147.39 319.41,146.9 arc(319.52,146.83) 319.65,146.8 334.45,146.8 arc(334.73,146.75) 334.97,146.59 336.01,145.55 arc(336.17,145.31) 336.22,145.03 336.22,130.74 arc(336.17,130.46) 336.01,130.22 329.11,123.32 arc(329.04,123.21) 329.01,123.08 329.01,95.93 arc(328.92,95.5) 328.68,95.13 arc(328.11,94.75) 327.44,94.61 327.21,94.61 arc(326.54,94.75) 325.98,95.13 arc(325.73,95.49) 325.65,95.92 325.65,122.75 arc(325.62,122.88) 325.55,123 324.88,123.67 arc(324.77,123.74) 324.64,123.77 323.67,123.77 arc(323.54,123.74) 323.43,123.67 322.9,123.13 arc(322.82,123.02) 322.8,122.89 322.8,101.37 arc(322.74,101.09) 322.58,100.85 321.79,100.06 arc(321.55,99.9) 321.27,99.85 316.62,99.85 arc(316.3,99.78) 316.02,99.6 arc(315.6,98.97) 315.45,98.22 arc(315.6,97.46) 316.03,96.81 316.04,96.81 arc(316.32,96.62) 316.66,96.55 321.32,96.55 arc(321.88,96.44) 322.36,96.12 arc(322.68,95.64) 322.8,95.07 322.8,91.53 arc(322.85,91.25) 323.01,91.01 D301.08
D30110: length 192.4
  TOP w0.147: SITE4.32 334.63,171.33 334.63,171.32 334.63,169.65 arc(334.69,169.37) 334.85,169.13 338.31,165.66 arc(338.39,165.55) 338.41,165.42 338.41,161.32 arc(338.45,161.12) 338.57,160.94 343.71,155.8 arc(343.95,155.64) 344.23,155.58 352.97,155.58 arc(353.1,155.56) 353.21,155.48 353.54,155.16 arc(353.61,155.04) 353.64,154.91 353.64,154.22 arc(353.62,154.12) 353.56,154.03 353.28,153.75 arc(353.17,153.68) 353.04,153.65 339.37,153.65 arc(339.09,153.6) 338.85,153.44 338.47,153.06 arc(338.31,152.81) 338.25,152.52 338.25,151.88 arc(338.31,151.59) 338.47,151.34 338.84,150.97 arc(339.08,150.81) 339.36,150.76 346.77,150.76 arc(347.04,150.7) 347.27,150.55 347.27,150.55 arc(347.52,150.17) 347.61,149.73 arc(347.52,149.29) 347.28,148.92 347.23,148.87 arc(347,148.72) 346.73,148.67 340.97,148.67 arc(340.69,148.61) 340.45,148.45 338.39,146.4 arc(338.23,146.16) 338.18,145.87 338.18,95.57 arc(338.12,95.28) 337.95,95.03 arc(337.43,94.68) 336.81,94.56 arc(336.26,94.67) 335.8,94.98 arc(335.67,95.17) 335.62,95.4 335.62,123.36 arc(335.54,123.76) 335.32,124.1 335.31,124.1 arc(334.75,124.48) 334.09,124.61 arc(333.41,124.48) 332.84,124.09 arc(332.6,123.73) 332.52,123.31 332.52,91.52 arc(332.46,91.24) 332.3,91 D301.10
D30112: length 192.4
  TOP w0.147: D301.12 333.13,91.05 arc(332.97,91.29) 332.91,91.57 332.91,123.31 arc(332.97,123.58) 333.12,123.81 arc(333.57,124.11) 334.09,124.21 arc(334.6,124.11) 335.03,123.82 arc(335.18,123.61) 335.23,123.36 335.23,95.4 arc(335.3,95.02) 335.52,94.7 arc(336.11,94.3) 336.81,94.16 arc(337.58,94.31) 338.23,94.75 arc(338.49,95.13) 338.57,95.57 338.57,145.87 arc(338.6,146) 338.67,146.11 340.73,148.17 arc(340.84,148.24) 340.97,148.27 346.73,148.27 arc(347.15,148.35) 347.51,148.59 347.56,148.64 arc(347.89,149.14) 348.01,149.73 arc(347.89,150.33) 347.55,150.83 arc(347.2,151.07) 346.77,151.15 339.36,151.15 arc(339.23,151.18) 339.12,151.25 338.76,151.62 arc(338.67,151.74) 338.65,151.88 338.65,152.52 arc(338.67,152.66) 338.76,152.78 339.13,153.16 arc(339.24,153.23) 339.37,153.26 353.04,153.26 arc(353.32,153.31) 353.56,153.47 353.7,153.61 353.84,153.75 arc(353.99,153.97) 354.04,154.22 354.04,154.91 arc(353.98,155.2) 353.82,155.44 353.49,155.76 arc(353.25,155.92) 352.97,155.98 344.23,155.98 arc(344.1,156) 343.99,156.08 338.85,161.22 arc(338.82,161.27) 338.81,161.32 338.81,165.42 arc(338.75,165.71) 338.59,165.94 335.13,169.41 arc(335.05,169.52) 335.03,169.65 335.03,171.32 335.03,171.33 SITE4.33
D30114: length 192.4
  TOP w0.147: D301.14 342.47,91.01 arc(342.63,91.25) 342.69,91.53 342.69,123.33 arc(342.77,123.77) 343.03,124.15 arc(343.62,124.54) 344.32,124.68 344.49,124.68 arc(345.18,124.55) 345.77,124.15 345.77,124.15 arc(346.02,123.79) 346.1,123.35 346.1,94.29 arc(346.13,94.16) 346.2,94.05 346.55,93.71 arc(346.99,93.41) 347.5,93.31 arc(348.02,93.41) 348.46,93.71 348.75,93.99 348.75,94 arc(348.83,94.11) 348.85,94.24 348.85,126.09 arc(348.79,126.41) 348.61,126.68 348.61,126.68 arc(348.34,126.86) 348.02,126.92 342.13,126.92 arc(341.62,127.02) 341.19,127.31 341.19,127.31 arc(340.91,127.74) 340.81,128.25 340.81,141.92 arc(340.86,142.2) 341.02,142.44 341.88,143.3 arc(342.12,143.46) 342.4,143.52 348.48,143.52 arc(348.61,143.55) 348.72,143.62 357.43,152.33 arc(357.67,152.49) 357.95,152.54 360.91,152.54 arc(361.04,152.57) 361.15,152.64 361.66,153.15 arc(361.73,153.27) 361.76,153.4 361.76,156.72 arc(361.73,156.85) 361.66,156.96 360.89,157.73 arc(360.78,157.8) 360.65,157.83 346.49,157.83 arc(346.21,157.89) 345.97,158.05 341.02,162.99 arc(340.86,163.23) 340.81,163.51 340.81,165.84 arc(340.78,165.97) 340.71,166.08 335.83,170.95 335.83,171.32 335.83,171.33 SITE4.35
D30116: length 192.4
  TOP w0.147: SITE4.36 336.23,171.33 336.23,171.32 336.23,171.12 340.99,166.36 arc(341.15,166.12) 341.2,165.84 341.2,163.51 arc(341.23,163.38) 341.3,163.27 346.25,158.33 arc(346.36,158.25) 346.49,158.23 360.65,158.23 arc(360.93,158.17) 361.17,158.01 361.94,157.24 arc(362.1,157) 362.15,156.72 362.15,153.4 arc(362.1,153.11) 361.94,152.87 361.43,152.36 arc(361.19,152.2) 360.91,152.15 357.95,152.15 arc(357.82,152.12) 357.71,152.05 349.01,143.34 arc(348.77,143.18) 348.48,143.12 342.4,143.12 arc(342.27,143.1) 342.16,143.02 341.3,142.16 arc(341.23,142.05) 341.2,141.92 341.2,128.25 arc(341.27,127.89) 341.47,127.59 341.47,127.59 arc(341.77,127.39) 342.13,127.32 348.02,127.32 arc(348.49,127.23) 348.89,126.96 arc(349.15,126.56) 349.25,126.09 349.25,94.24 arc(349.19,93.95) 349.03,93.71 348.74,93.43 arc(348.17,93.05) 347.5,92.91 arc(346.83,93.05) 346.27,93.43 345.92,93.77 arc(345.76,94.01) 345.71,94.29 345.71,123.35 arc(345.65,123.63) 345.49,123.87 345.49,123.87 arc(345.03,124.18) 344.49,124.29 344.32,124.29 arc(343.77,124.18) 343.31,123.87 343.31,123.87 arc(343.14,123.62) 343.08,123.33 343.08,91.56 arc(343.14,91.28) 343.3,91.04 D301.16
D30502: length 192.4
  TOP w0.147: SITE2.26 332.23,231.33 332.23,231.32 332.23,219.76 arc(332.29,219.48) 332.45,219.24 339.52,212.17 arc(340.09,211.79) 340.76,211.66 355.4,211.66 arc(355.46,211.64) 355.51,211.61 363.26,203.86 arc(363.34,203.74) 363.36,203.61 363.36,157.18 arc(363.42,156.9) 363.58,156.66 370.12,150.11 arc(370.2,150) 370.22,149.87 370.22,134.19 arc(370.28,133.9) 370.44,133.66 385.85,118.25 arc(385.92,118.14) 385.95,118.01 385.95,102.48 arc(386,102.2) 386.16,101.96 386.98,101.14 arc(387.22,100.98) 387.5,100.93 393.91,100.93 arc(394.36,100.84) 394.75,100.58 395.1,100.22 arc(395.74,99.27) 395.96,98.15 395.96,98.15 arc(395.79,97.27) 395.29,96.52 394.59,95.82 arc(394.41,95.7) 394.19,95.66 387.9,95.66 arc(387.62,95.6) 387.38,95.44 386.07,94.13 arc(385.91,93.89) 385.85,93.61 385.85,91.52 arc(385.8,91.24) 385.64,91 D305.02
D30504: length 192.4
  TOP w0.147: D305.04 386.47,91.05 arc(386.31,91.29) 386.25,91.57 386.25,93.61 arc(386.28,93.74) 386.35,93.85 387.66,95.16 arc(387.77,95.24) 387.9,95.26 394.19,95.26 arc(394.56,95.34) 394.87,95.54 395.57,96.24 arc(396.15,97.12) 396.36,98.15 396.36,98.15 arc(396.11,99.43) 395.38,100.51 395.03,100.86 arc(394.52,101.2) 393.91,101.32 387.5,101.32 arc(387.37,101.35) 387.26,101.42 386.44,102.24 arc(386.37,102.35) 386.34,102.48 386.34,118.01 arc(386.29,118.29) 386.13,118.53 370.72,133.94 arc(370.64,134.05) 370.62,134.19 370.62,149.87 arc(370.56,150.16) 370.4,150.39 363.86,156.94 arc(363.78,157.05) 363.76,157.18 363.76,203.61 arc(363.7,203.9) 363.54,204.14 355.79,211.89 arc(355.61,212.01) 355.4,212.05 340.76,212.05 arc(340.24,212.16) 339.8,212.45 332.73,219.52 arc(332.65,219.63) 332.63,219.76 332.63,231.32 332.63,231.33 SITE2.27
D30506: length 192.4
  TOP w0.147: D305.06 395.8,91 arc(395.96,91.24) 396.01,91.52 396.01,93.35 arc(396.07,93.64) 396.23,93.88 397.9,95.55 arc(398.14,95.71) 398.42,95.77 403,95.77 arc(403.23,95.81) 403.43,95.95 404.01,96.52 arc(404.38,97.08) 404.51,97.73 404.51,98.2 arc(404.31,99.21) 403.74,100.07 arc(403.24,100.4) 402.65,100.52 398.73,100.52 arc(398.45,100.57) 398.21,100.73 396.16,102.78 arc(396,103.02) 395.94,103.3 395.94,110.85 arc(395.92,110.98) 395.84,111.09 373.28,133.65 arc(373.12,133.89) 373.07,134.17 373.07,150.26 arc(373.04,150.39) 372.97,150.5 365.78,157.69 arc(365.62,157.93) 365.56,158.21 365.56,204.16 arc(365.54,204.29) 365.46,204.4 356.18,213.68 arc(356.07,213.75) 355.94,213.78 341.07,213.78 arc(340.79,213.83) 340.55,213.99 333.65,220.9 arc(333.49,221.14) 333.43,221.42 333.43,231.32 333.43,231.33 SITE2.29
D30508: length 192.4
  TOP w0.147: D305.08 396.63,91.05 arc(396.47,91.29) 396.41,91.58 396.41,93.35 arc(396.44,93.48) 396.51,93.6 398.18,95.27 arc(398.29,95.34) 398.42,95.37 403,95.37 arc(403.39,95.45) 403.71,95.67 404.29,96.24 arc(404.75,96.93) 404.91,97.73 404.91,98.2 arc(404.68,99.36) 404.02,100.35 404.02,100.35 arc(403.39,100.76) 402.65,100.91 398.73,100.91 arc(398.6,100.94) 398.49,101.01 396.44,103.06 arc(396.37,103.17) 396.34,103.3 396.34,110.85 arc(396.28,111.13) 396.12,111.37 373.56,133.93 arc(373.49,134.04) 373.46,134.17 373.46,150.26 arc(373.41,150.54) 373.25,150.78 366.06,157.97 arc(365.98,158.08) 365.96,158.21 365.96,204.16 arc(365.9,204.44) 365.74,204.68 356.46,213.96 arc(356.22,214.12) 355.94,214.17 341.07,214.17 arc(340.94,214.2) 340.83,214.27 333.93,221.18 arc(333.85,221.29) 333.83,221.42 333.83,231.32 333.83,231.33 SITE2.30
D30510: length 192.4
  TOP w0.147: SITE2.32 334.63,231.33 334.63,231.32 334.63,229.76 arc(334.69,229.47) 334.85,229.24 338.3,225.79 arc(338.37,225.67) 338.4,225.54 338.4,219.84 arc(338.45,219.56) 338.61,219.32 342.01,215.92 arc(342.25,215.76) 342.53,215.7 357.87,215.7 arc(358,215.68) 358.11,215.6 367.82,205.89 arc(367.9,205.78) 367.92,205.65 367.92,159.78 arc(367.98,159.49) 368.14,159.26 375.88,151.51 arc(375.95,151.4) 375.98,151.27 375.98,133.97 arc(376.04,133.68) 376.2,133.44 406.02,103.62 arc(406.09,103.51) 406.12,103.38 406.12,101.65 arc(406.17,101.37) 406.33,101.13 407.18,100.28 arc(407.42,100.12) 407.7,100.07 410.32,100.07 arc(410.82,99.97) 411.24,99.69 arc(411.82,98.82) 412.03,97.79 412.03,97.79 arc(411.86,96.94) 411.38,96.22 arc(411.11,96.04) 410.79,95.97 407.86,95.97 arc(407.55,95.91) 407.29,95.74 406.42,94.87 arc(406.25,94.61) 406.19,94.3 406.19,91.53 arc(406.13,91.25) 405.97,91.01 D305.10
D30512: length 192.4
  TOP w0.147: SITE2.33 335.03,231.33 335.03,231.32 335.03,229.76 arc(335.05,229.63) 335.13,229.52 338.58,226.07 arc(338.74,225.83) 338.79,225.54 338.79,219.84 arc(338.82,219.71) 338.89,219.6 342.29,216.2 arc(342.4,216.12) 342.53,216.1 357.87,216.1 arc(358.15,216.04) 358.39,215.88 368.1,206.17 arc(368.26,205.93) 368.32,205.65 368.32,159.78 arc(368.35,159.65) 368.42,159.54 376.16,151.79 arc(376.32,151.56) 376.38,151.27 376.38,133.97 arc(376.4,133.84) 376.48,133.72 406.3,103.9 arc(406.46,103.67) 406.51,103.38 406.51,101.65 arc(406.54,101.52) 406.61,101.41 407.46,100.56 arc(407.57,100.49) 407.7,100.46 410.32,100.46 arc(410.97,100.34) 411.52,99.97 411.52,99.97 arc(412.19,98.97) 412.42,97.79 412.42,97.79 arc(412.22,96.79) 411.66,95.94 arc(411.26,95.67) 410.79,95.58 407.86,95.58 arc(407.7,95.55) 407.57,95.46 406.71,94.59 arc(406.61,94.46) 406.58,94.3 406.58,91.56 arc(406.64,91.28) 406.8,91.04 D305.12
D30514: length 192.4
  TOP w0.147: SITE2.35 335.83,231.33 335.83,231.32 335.83,230.95 340.67,226.11 arc(340.75,226) 340.77,225.87 340.77,220.87 arc(340.83,220.59) 340.99,220.35 343.49,217.85 arc(343.73,217.69) 344.01,217.63 359.3,217.63 arc(359.44,217.61) 359.55,217.53 370.26,206.82 arc(370.33,206.71) 370.36,206.58 370.36,161.11 arc(370.41,160.82) 370.57,160.58 378.75,152.41 arc(378.82,152.3) 378.85,152.17 378.85,133.76 arc(378.9,133.48) 379.06,133.24 385.97,126.33 arc(386.21,126.17) 386.49,126.11 393.9,126.11 arc(394.7,125.95) 395.38,125.5 415.74,105.14 arc(416.2,104.46) 416.36,103.65 416.36,91.54 arc(416.3,91.26) 416.14,91.02 D305.14
D30516: length 192.4
  TOP w0.147: SITE2.36 336.23,231.33 336.23,231.32 336.23,231.12 340.95,226.39 arc(341.11,226.15) 341.17,225.87 341.17,220.87 arc(341.2,220.74) 341.27,220.63 343.77,218.13 arc(343.88,218.05) 344.01,218.03 359.3,218.03 arc(359.59,217.97) 359.83,217.81 370.54,207.1 arc(370.7,206.86) 370.75,206.58 370.75,161.11 arc(370.78,160.98) 370.85,160.86 379.03,152.69 arc(379.19,152.45) 379.24,152.17 379.24,133.76 arc(379.27,133.63) 379.34,133.52 386.25,126.61 arc(386.36,126.54) 386.49,126.51 393.9,126.51 arc(394.86,126.32) 395.66,125.78 416.03,105.42 arc(416.57,104.61) 416.76,103.65 416.76,91.55 arc(416.81,91.27) 416.97,91.03 D305.16
D31702: length 192.4
  TOP w0.147: D317.02 164.7,91.04 arc(164.86,91.27) 164.91,91.56 164.91,95.29 arc(164.89,95.42) 164.81,95.53 164.03,96.32 arc(163.91,96.39) 163.78,96.42 157,96.42 arc(156.71,96.47) 156.47,96.63 155.8,97.31 arc(155.07,98.39) 154.82,99.67 arc(155.13,101.25) 156.03,102.59 156.08,102.64 arc(156.58,102.97) 157.16,103.09 163.5,103.09 arc(163.63,103.11) 163.74,103.19 164.81,104.26 arc(164.89,104.37) 164.91,104.5 164.91,105.59 arc(164.89,105.72) 164.81,105.83 163.8,106.84 arc(163.69,106.91) 163.56,106.94 157.81,106.94 arc(157.52,107) 157.29,107.15 155.37,109.07 arc(155.21,109.31) 155.15,109.59 155.15,125.04 arc(155.21,125.32) 155.37,125.56 156.82,127.02 arc(157.06,127.18) 157.34,127.23 192.08,127.23 arc(192.21,127.26) 192.32,127.33 201.84,136.86 arc(202.08,137.01) 202.36,137.07 223.86,137.07 arc(223.99,137.1) 224.1,137.17 228.16,141.23 arc(228.23,141.34) 228.26,141.47 228.26,147.03 arc(228.31,147.31) 228.47,147.55 232.83,151.91 arc(233.07,152.07) 233.35,152.13 249.77,152.13 arc(249.9,152.15) 250.01,152.23 252.13,154.35 arc(252.21,154.46) 252.23,154.59 252.23,171.32 252.23,171.33 SITE3.26
D31704: length 192.4
  TOP w0.147: D317.04 165.52,91.02 arc(165.36,91.26) 165.31,91.54 165.31,95.29 arc(165.25,95.57) 165.09,95.81 164.31,96.6 arc(164.07,96.76) 163.78,96.81 157,96.81 arc(156.86,96.84) 156.75,96.91 156.08,97.59 arc(155.44,98.54) 155.22,99.67 arc(155.5,101.1) 156.31,102.31 156.36,102.36 arc(156.73,102.61) 157.16,102.69 163.5,102.69 arc(163.78,102.75) 164.02,102.91 165.09,103.98 arc(165.25,104.22) 165.31,104.5 165.31,105.59 arc(165.25,105.87) 165.09,106.11 164.08,107.12 arc(163.84,107.28) 163.56,107.34 157.81,107.34 arc(157.68,107.36) 157.57,107.44 155.65,109.35 arc(155.58,109.46) 155.55,109.59 155.55,125.04 arc(155.58,125.17) 155.65,125.28 157.1,126.73 arc(157.21,126.81) 157.34,126.83 192.08,126.83 arc(192.36,126.89) 192.6,127.05 202.12,136.58 arc(202.23,136.65) 202.36,136.67 223.86,136.67 arc(224.14,136.73) 224.38,136.89 228.44,140.95 arc(228.6,141.18) 228.65,141.47 228.65,147.03 arc(228.68,147.16) 228.75,147.27 233.11,151.63 arc(233.22,151.71) 233.35,151.73 249.77,151.73 arc(250.05,151.79) 250.29,151.95 252.41,154.07 arc(252.57,154.31) 252.63,154.59 252.63,171.32 252.63,171.33 SITE3.27
D31706: length 192.4
  TOP w0.147: SITE3.29 253.43,171.33 253.43,171.32 253.43,167.46 arc(253.49,167.18) 253.65,166.94 254.62,165.97 arc(254.69,165.86) 254.72,165.73 254.72,153.91 arc(254.69,153.78) 254.62,153.67 250.73,149.78 arc(250.62,149.71) 250.49,149.68 234.4,149.68 arc(234.12,149.63) 233.88,149.47 230.88,146.47 arc(230.72,146.23) 230.67,145.95 230.67,140.34 arc(230.64,140.21) 230.57,140.1 225.29,134.82 arc(225.18,134.75) 225.05,134.72 202.88,134.72 arc(202.6,134.67) 202.36,134.51 193.09,125.24 arc(192.98,125.17) 192.85,125.14 159.57,125.14 arc(159.29,125.08) 159.05,124.93 157.66,123.54 arc(157.5,123.3) 157.45,123.02 157.45,111.6 arc(157.5,111.32) 157.66,111.08 159.28,109.46 arc(159.52,109.3) 159.81,109.24 172.43,109.24 arc(172.56,109.22) 172.67,109.14 174.97,106.84 arc(175.04,106.73) 175.07,106.6 175.07,104.63 arc(175.04,104.5) 174.97,104.39 173.61,103.04 arc(173.5,102.96) 173.37,102.94 170.84,102.94 arc(170.14,102.8) 169.55,102.4 169.41,102.26 arc(168.5,100.07) 169.41,97.88 170.08,97.21 arc(170.32,97.05) 170.6,96.99 173.7,96.99 arc(173.83,96.97) 173.95,96.89 174.97,95.87 arc(175.04,95.76) 175.07,95.63 175.07,91.55 arc(175.01,91.27) 174.85,91.03 D317.06
D31708: length 192.4
  TOP w0.147: D317.08 175.68,91.02 arc(175.52,91.26) 175.46,91.54 175.46,95.63 arc(175.41,95.91) 175.25,96.15 174.23,97.17 arc(173.99,97.33) 173.7,97.39 170.6,97.39 arc(170.47,97.41) 170.36,97.49 169.69,98.16 arc(168.9,100.07) 169.69,101.98 169.83,102.12 arc(170.29,102.43) 170.84,102.54 173.37,102.54 arc(173.66,102.6) 173.89,102.76 175.25,104.11 arc(175.41,104.35) 175.46,104.63 175.46,106.6 arc(175.41,106.88) 175.25,107.12 172.95,109.42 arc(172.71,109.58) 172.43,109.64 159.81,109.64 arc(159.67,109.67) 159.56,109.74 157.94,111.36 arc(157.87,111.47) 157.84,111.6 157.84,123.02 arc(157.87,123.15) 157.94,123.26 159.33,124.64 arc(159.44,124.72) 159.57,124.74 192.85,124.74 arc(193.13,124.8) 193.37,124.96 202.64,134.23 arc(202.75,134.3) 202.88,134.33 225.05,134.33 arc(225.33,134.38) 225.57,134.54 230.85,139.82 arc(231.01,140.05) 231.06,140.34 231.06,145.95 arc(231.09,146.08) 231.16,146.19 234.16,149.19 arc(234.27,149.26) 234.4,149.29 250.49,149.29 arc(250.77,149.34) 251.01,149.5 254.9,153.39 arc(255.06,153.63) 255.11,153.91 255.11,165.73 arc(255.06,166.01) 254.9,166.25 253.93,167.22 arc(253.85,167.33) 253.83,167.46 253.83,171.32 253.83,171.33 SITE3.30
D31710: length 192.4
  TOP w0.147: SITE3.32 254.63,171.33 254.63,171.32 254.63,170.21 arc(254.69,169.93) 254.85,169.69 258.03,166.5 arc(258.11,166.39) 258.13,166.26 258.13,153.46 arc(258.11,153.33) 258.03,153.22 252.15,147.34 arc(252.04,147.26) 251.91,147.24 235.58,147.24 arc(235.3,147.18) 235.06,147.02 233.21,145.18 arc(233.06,144.94) 233,144.66 233,138.57 233,138.57 arc(232.78,137.46) 232.15,136.52 228.68,133.05 arc(227.74,132.43) 226.63,132.21 203.78,132.21 arc(203.5,132.15) 203.26,131.99 194.05,122.78 arc(193.94,122.71) 193.81,122.68 161.05,122.68 arc(160.77,122.62) 160.53,122.46 159.94,121.87 arc(159.78,121.63) 159.72,121.35 159.72,112.87 arc(159.78,112.59) 159.94,112.35 160.47,111.81 arc(160.71,111.65) 161,111.59 180.14,111.59 arc(180.27,111.57) 180.38,111.49 185.1,106.78 arc(185.17,106.67) 185.2,106.54 185.2,91.52 arc(185.14,91.24) 184.98,91 D317.10
D31712: length 192.4
  TOP w0.147: D317.12 185.81,91.05 arc(185.65,91.29) 185.6,91.57 185.6,106.54 arc(185.54,106.82) 185.38,107.06 180.66,111.77 arc(180.42,111.93) 180.14,111.99 161,111.99 arc(160.87,112.01) 160.75,112.09 160.22,112.63 arc(160.14,112.74) 160.12,112.87 160.12,121.35 arc(160.14,121.48) 160.22,121.59 160.81,122.18 arc(160.92,122.26) 161.05,122.28 193.81,122.28 arc(194.09,122.34) 194.33,122.5 203.54,131.71 arc(203.65,131.78) 203.78,131.81 226.63,131.81 arc(227.89,132.06) 228.96,132.77 232.43,136.24 arc(233.15,137.31) 233.4,138.57 233.4,144.66 arc(233.42,144.79) 233.5,144.9 235.34,146.74 arc(235.45,146.82) 235.58,146.84 251.91,146.84 arc(252.19,146.9) 252.43,147.06 258.31,152.94 arc(258.47,153.18) 258.53,153.46 258.53,166.26 arc(258.47,166.55) 258.31,166.79 255.13,169.97 arc(255.05,170.08) 255.03,170.21 255.03,171.32 255.03,171.33 SITE3.33
D31714: length 192.4
  TOP w0.147: D317.14 195.14,91 arc(195.3,91.24) 195.36,91.52 195.36,99.55 arc(195.33,99.68) 195.26,99.79 181.22,113.83 arc(181.11,113.9) 180.98,113.93 164.32,113.93 arc(164.03,113.98) 163.79,114.14 163.21,114.72 arc(163.05,114.96) 163,115.24 163,118.79 arc(163.05,119.07) 163.21,119.31 164.03,120.12 arc(164.27,120.28) 164.55,120.34 195.52,120.34 arc(195.65,120.36) 195.76,120.44 205.36,130.04 arc(205.6,130.2) 205.88,130.25 228.64,130.25 arc(229.73,130.47) 230.66,131.09 234.67,135.09 arc(235.28,136.02) 235.5,137.11 235.5,143.23 arc(235.56,143.51) 235.72,143.75 237.01,145.04 arc(237.25,145.2) 237.53,145.26 253.04,145.26 arc(253.17,145.29) 253.28,145.36 260.49,152.56 arc(260.56,152.67) 260.59,152.8 260.59,165.95 arc(260.56,166.08) 260.49,166.19 255.99,170.69 arc(255.87,170.87) 255.83,171.08 255.83,171.32 255.83,171.33 SITE3.35
D31716: length 192.4
  TOP w0.147: D317.16 195.97,91.05 arc(195.81,91.29) 195.75,91.57 195.75,99.55 arc(195.7,99.83) 195.54,100.07 181.5,114.11 arc(181.26,114.27) 180.98,114.32 164.32,114.32 arc(164.18,114.35) 164.07,114.42 163.49,115 arc(163.42,115.11) 163.39,115.24 163.39,118.79 arc(163.42,118.92) 163.49,119.03 164.31,119.84 arc(164.42,119.92) 164.55,119.94 195.52,119.94 arc(195.8,120) 196.04,120.16 205.64,129.76 arc(205.75,129.83) 205.88,129.85 228.64,129.85 arc(229.88,130.1) 230.94,130.81 234.95,134.81 arc(235.65,135.87) 235.9,137.11 235.9,143.23 arc(235.92,143.36) 236,143.47 237.29,144.76 arc(237.4,144.84) 237.53,144.86 253.04,144.86 arc(253.33,144.92) 253.57,145.08 260.77,152.28 arc(260.93,152.52) 260.98,152.8 260.98,165.95 arc(260.93,166.24) 260.77,166.48 256.27,170.97 arc(256.24,171.02) 256.23,171.08 256.23,171.32 256.23,171.33 SITE3.36
D32102: length 192.4
  TOP w0.147: D321.02 238.38,91.06 arc(238.54,91.3) 238.59,91.58 238.59,98.62 arc(238.65,98.9) 238.81,99.14 286.48,146.81 arc(286.55,146.92) 286.58,147.05 286.58,206.14 arc(286.47,206.69) 286.16,207.15 282.19,211.12 arc(281.72,211.43) 281.18,211.54 259.33,211.54 arc(259.04,211.6) 258.81,211.76 252.45,218.11 arc(252.29,218.35) 252.23,218.64 252.23,231.32 252.23,231.33 SITE1.26
D32104: length 192.4
  TOP w0.147: SITE1.27 252.63,231.33 252.63,231.32 252.63,218.64 arc(252.65,218.51) 252.73,218.39 259.09,212.04 arc(259.2,211.96) 259.33,211.94 281.18,211.94 arc(281.88,211.8) 282.47,211.4 286.44,207.43 arc(286.84,206.84) 286.98,206.14 286.98,147.05 arc(286.92,146.77) 286.76,146.53 239.09,98.86 arc(239.01,98.75) 238.99,98.62 238.99,91.52 arc(239.04,91.23) 239.2,91 D321.04
D32106: length 192.4
  TOP w0.147: SITE1.29 253.43,231.33 253.43,231.32 253.43,221.34 arc(253.49,221.06) 253.65,220.82 260.72,213.75 arc(260.95,213.59) 261.24,213.54 282.95,213.54 arc(283.08,213.51) 283.19,213.44 288.87,207.76 arc(288.94,207.65) 288.97,207.52 288.97,146.11 arc(288.94,145.98) 288.87,145.87 248.9,105.91 arc(248.74,105.67) 248.69,105.39 248.69,104.2 arc(248.74,103.92) 248.9,103.68 251.97,100.62 arc(252.4,99.97) 252.55,99.2 252.55,99.08 arc(252.4,98.31) 251.97,97.66 248.95,94.64 arc(248.79,94.4) 248.74,94.12 248.74,91.56 arc(248.68,91.28) 248.52,91.04 D321.06
D32108: length 192.4
  TOP w0.147: SITE1.30 253.83,231.33 253.83,231.32 253.83,221.34 arc(253.85,221.21) 253.93,221.1 261,214.03 arc(261.11,213.96) 261.24,213.93 282.95,213.93 arc(283.23,213.88) 283.47,213.72 289.15,208.04 arc(289.31,207.8) 289.36,207.52 289.36,146.11 arc(289.31,145.83) 289.15,145.59 249.18,105.63 arc(249.11,105.52) 249.08,105.39 249.08,104.2 arc(249.11,104.07) 249.18,103.96 252.25,100.9 arc(252.77,100.12) 252.95,99.2 252.95,99.08 arc(252.77,98.16) 252.25,97.38 249.23,94.36 arc(249.16,94.25) 249.13,94.12 249.13,91.53 arc(249.19,91.25) 249.35,91.01 D321.08
D32110: length 192.4
  TOP w0.147: D321.10 258.65,91.01 arc(258.81,91.25) 258.86,91.53 258.86,94.57 arc(258.92,94.85) 259.08,95.09 260.55,96.56 arc(260.79,96.72) 261.07,96.78 261.8,96.78 arc(262.36,96.89) 262.84,97.21 262.91,97.28 arc(263.23,97.75) 263.34,98.31 263.34,100.27 arc(263.2,100.94) 262.82,101.51 arc(262.25,101.89) 261.58,102.02 260.61,102.02 arc(260.33,102.08) 260.09,102.24 259.08,103.25 arc(258.92,103.49) 258.86,103.77 258.86,111.55 arc(258.92,111.83) 259.08,112.07 291.24,144.23 arc(291.31,144.34) 291.34,144.47 291.34,209.33 arc(291.31,209.46) 291.24,209.57 285.33,215.48 arc(285.22,215.55) 285.09,215.58 262.86,215.58 arc(262.58,215.64) 262.34,215.8 258.45,219.69 arc(258.29,219.93) 258.23,220.21 258.23,225.64 arc(258.2,225.77) 258.13,225.88 254.85,229.16 arc(254.69,229.4) 254.63,229.68 254.63,231.32 254.63,231.33 SITE1.32
D32112: length 192.4
  TOP w0.147: SITE1.33 255.03,231.33 255.03,231.32 255.03,229.68 arc(255.05,229.55) 255.13,229.44 258.41,226.16 arc(258.57,225.92) 258.63,225.64 258.63,220.21 arc(258.65,220.08) 258.73,219.97 262.62,216.08 arc(262.73,216) 262.86,215.98 285.09,215.98 arc(285.37,215.92) 285.61,215.76 291.52,209.85 arc(291.68,209.61) 291.74,209.33 291.74,144.47 arc(291.68,144.19) 291.52,143.95 259.36,111.79 arc(259.29,111.68) 259.26,111.55 259.26,103.77 arc(259.29,103.64) 259.36,103.53 260.37,102.52 arc(260.48,102.45) 260.61,102.42 261.58,102.42 arc(262.41,102.26) 263.1,101.79 arc(263.57,101.09) 263.73,100.27 263.73,98.31 arc(263.59,97.6) 263.19,97 263.12,96.93 arc(262.51,96.52) 261.8,96.38 261.07,96.38 arc(260.94,96.35) 260.83,96.28 259.36,94.81 arc(259.29,94.7) 259.26,94.57 259.26,91.56 arc(259.32,91.28) 259.48,91.04 D321.12
D32114: length 192.4
  TOP w0.147: D321.14 268.82,91.02 arc(268.98,91.26) 269.04,91.55 269.04,94.71 arc(269.1,95) 269.26,95.23 270.17,96.15 arc(270.41,96.31) 270.69,96.37 273.45,96.37 arc(273.58,96.39) 273.69,96.47 274.2,96.97 arc(274.81,97.88) 275.02,98.96 275.02,99.37 arc(274.81,100.45) 274.2,101.36 273.53,102.03 arc(273.42,102.1) 273.29,102.13 271.08,102.13 arc(270.8,102.18) 270.56,102.34 269.26,103.65 arc(269.1,103.89) 269.04,104.17 269.04,118.95 arc(269.1,119.23) 269.26,119.47 293.83,144.04 arc(293.9,144.15) 293.93,144.28 293.93,210.44 arc(293.9,210.57) 293.83,210.68 287.07,217.44 arc(286.96,217.51) 286.83,217.54 264.6,217.54 arc(264.31,217.59) 264.07,217.75 260.94,220.89 arc(260.78,221.13) 260.72,221.41 260.72,225.92 arc(260.7,226.05) 260.62,226.16 256.01,230.77 arc(255.88,230.97) 255.83,231.2 255.83,231.32 255.83,231.33 SITE1.35
D32116: length 192.4
  TOP w0.147: SITE1.36 256.23,231.33 256.23,231.32 256.23,231.2 arc(256.24,231.12) 256.29,231.06 260.9,226.44 arc(261.06,226.2) 261.12,225.92 261.12,221.41 arc(261.14,221.28) 261.22,221.17 264.35,218.03 arc(264.47,217.96) 264.6,217.93 286.83,217.93 arc(287.11,217.88) 287.35,217.72 294.11,210.96 arc(294.27,210.72) 294.32,210.44 294.32,144.28 arc(294.27,144) 294.11,143.76 269.54,119.19 arc(269.46,119.08) 269.44,118.95 269.44,104.17 arc(269.46,104.04) 269.54,103.93 270.84,102.62 arc(270.95,102.55) 271.08,102.52 273.29,102.52 arc(273.57,102.47) 273.81,102.31 274.48,101.64 arc(275.18,100.6) 275.42,99.37 275.42,98.96 arc(275.18,97.73) 274.48,96.69 273.97,96.18 arc(273.73,96.02) 273.45,95.97 270.69,95.97 arc(270.56,95.94) 270.45,95.87 269.54,94.95 arc(269.46,94.84) 269.44,94.71 269.44,91.55 arc(269.49,91.27) 269.65,91.03 D321.16
Net_7: length 1.5
  TOP w0.231: v1(229.4,185.39) 229.91,185.39 ; v1(309.4,245.39) 309.91,245.39 ; v1(309.4,185.39) 309.91,185.39
  vias: v1(223.55,259.7) v1(223.55,257.77) v1(223.55,255.84) v1(223.55,253.92) v1(223.55,251.61) v1(223.55,249.68) v1(223.55,199.7) v1(223.55,197.77) v1(223.55,195.84) v1(223.55,193.92) v1(223.55,191.61) v1(223.55,189.68) v1(224.6,241.56) v1(224.6,239.63) v1(224.64,237.71) v1(224.64,235.78) v1(224.6,181.56) v1(224.6,179.63) v1(224.64,177.71) v1(224.64,175.78) v1(224.7,234) v1(224.7,232.07) v1(224.7,174) v1(224.7,172.07) v1(226.85,257.77) v1(226.85,255.84) v1(226.85,253.53) v1(226.85,251.61) v1(226.85,197.77) v1(226.85,195.84) v1(226.85,193.54) v1(226.85,191.61) v1(227.63,239.65) v1(227.63,237.72) v1(227.65,235.93) v1(227.65,234) v1(227.63,179.65) v1(227.63,177.72) v1(227.65,175.93) v1(227.65,174) v1(227.75,231.32) v1(227.75,229.39) v1(227.75,171.32) v1(227.75,169.39) v1(230.19,241.84) v1(230.19,239.59) v1(230.19,181.84) v1(230.19,179.59) v1(233.79,218.54) v1(233.79,158.54) v1(235.15,217.18) v1(235.15,157.18) v1(235.89,269.91) v1(235.89,209.91) v1(236.8,215.47) v1(236.8,155.47) v1(237.59,219.55) v1(237.59,159.55) v1(237.77,271.64) v1(237.77,211.64) v1(237.82,269.91) v1(237.82,209.91) v1(238.17,214.11) v1(238.17,154.11) v1(238.96,218.18) v1(238.96,158.18) v1(239.69,271.64) v1(239.75,269.91) v1(239.69,211.64) v1(239.75,209.91) v1(241.62,271.64) v1(241.68,269.91) v1(241.62,211.64) v1(241.68,209.91) v1(243.55,271.64) v1(243.55,211.64) v1(243.61,269.91) v1(243.61,209.91) v1(244.15,215.84) v1(244.15,155.84) v1(245.54,271.63) v1(245.54,269.91) v1(245.54,211.63) v1(245.54,209.91) v1(246.08,215.84) v1(246.08,155.84) v1(246.26,217.79) v1(246.26,157.79) v1(247.47,271.63) v1(247.4,269.91) v1(247.47,211.63) v1(247.4,209.91) v1(248.19,217.79) v1(248.19,157.79) v1(248.6,215.85) v1(248.6,155.85) v1(249.33,269.91) v1(249.33,209.91) v1(249.39,271.63) v1(249.39,211.63) v1(250.53,215.85) v1(250.53,155.85) v1(251.32,271.63) v1(251.32,269.91) v1(251.32,211.63) v1(251.32,209.91) v1(253.25,269.91) v1(253.25,209.91) v1(254.53,269.69) v1(254.53,209.69) v1(256.46,269.69) v1(256.46,267.97) v1(256.46,209.69) v1(256.46,207.97) v1(258.39,269.69) v1(258.39,267.97) v1(258.39,209.69) v1(258.39,207.97) v1(260.32,269.69) v1(260.32,267.97) v1(260.32,209.69) v1(260.32,207.97) v1(262.25,269.69) v1(262.25,267.97) v1(262.25,209.69) v1(262.25,207.97) v1(264.18,269.69) v1(264.18,267.97) v1(264.18,209.69) v1(264.18,207.97) v1(266.11,269.69) v1(266.11,267.97) v1(266.11,209.69) v1(266.11,207.97) v1(268.04,269.69) v1(268.04,209.69) v1(277,259.34) v1(277,257.41) v1(277,255.48) v1(277,253.56) v1(277,251.63) v1(277,249.7) v1(277,247.27) v1(277,245.34) v1(277,199.34) v1(277,197.41) v1(277,195.49) v1(277,193.56) v1(277,191.63) v1(277,189.7) v1(277,187.27) v1(277,185.34) v1(280.05,257.41) v1(280.05,255.48) v1(280.05,253.56) v1(280.05,251.63) v1(280.05,249.19) v1(280.05,247.27) v1(280.05,197.41) v1(280.05,195.49) v1(280.05,193.56) v1(280.05,191.63) v1(280.05,189.19) v1(280.05,187.27) v1(303.55,259.7) v1(303.55,257.77) v1(303.55,255.84) v1(303.55,253.92) v1(303.55,251.61) v1(303.55,249.68) v1(303.55,199.7) v1(303.55,197.77) v1(303.55,195.84) v1(303.55,193.92) v1(303.55,191.61) v1(303.55,189.68) v1(304.6,241.56) v1(304.6,239.63) v1(304.64,237.71) v1(304.64,235.78) v1(304.6,181.56) v1(304.6,179.63) v1(304.64,177.71) v1(304.64,175.78) v1(304.7,234) v1(304.7,232.07) v1(304.7,174) v1(304.7,172.07) v1(306.85,257.77) v1(306.85,255.84) v1(306.85,253.53) v1(306.85,251.61) v1(306.85,197.77) v1(306.85,195.84) v1(306.85,193.54) v1(306.85,191.61) v1(307.63,239.65) v1(307.63,237.72) v1(307.65,235.93) v1(307.65,234) v1(307.63,179.65) v1(307.63,177.72) v1(307.65,175.93) v1(307.65,174) v1(307.75,231.32) v1(307.75,229.39) v1(307.75,171.32) v1(307.75,169.39) v1(310.19,241.84) v1(310.19,239.59) v1(310.19,181.84) v1(310.19,179.59) v1(313.79,218.54) v1(313.79,158.54) v1(315.15,217.18) v1(315.15,157.18) v1(315.89,269.91) v1(315.89,209.91) v1(316.8,215.47) v1(316.8,155.47) v1(317.59,219.55) v1(317.59,159.55) v1(317.77,271.64) v1(317.77,211.64) v1(317.82,269.91) v1(317.82,209.91) v1(318.16,214.11) v1(318.16,154.11) v1(318.95,218.18) v1(318.95,158.18) v1(319.69,271.64) v1(319.75,269.91) v1(319.69,211.64) v1(319.75,209.91) v1(321.62,271.64) v1(321.68,269.91) v1(321.62,211.64) v1(321.68,209.91) v1(323.55,271.64) v1(323.55,211.64) v1(323.61,269.91) v1(323.61,209.91) v1(324.15,215.84) v1(324.15,155.84) v1(325.54,271.63) v1(325.54,269.91) v1(325.54,211.63) v1(325.54,209.91) v1(326.08,215.84) v1(326.08,155.84) v1(326.26,217.79) v1(326.26,157.79) v1(327.47,271.63) v1(327.4,269.91) v1(327.47,211.63) v1(327.4,209.91) v1(328.19,217.79) v1(328.19,157.79) v1(328.6,215.85) v1(328.6,155.85) v1(329.33,269.91) v1(329.33,209.91) v1(329.39,271.63) v1(329.39,211.63) v1(330.53,215.85) v1(330.53,155.85) v1(331.32,271.63) v1(331.32,269.91) v1(331.32,211.63) v1(331.32,209.91) v1(333.25,269.91) v1(333.25,209.91) v1(334.53,209.69) v1(334.58,269.75) v1(336.46,269.69) v1(336.46,267.97) v1(336.46,209.69) v1(336.46,207.97) v1(338.39,269.69) v1(338.39,267.97) v1(338.39,209.69) v1(338.39,207.97) v1(340.32,269.69) v1(340.32,267.97) v1(340.32,209.69) v1(340.32,207.97) v1(342.25,269.69) v1(342.25,267.97) v1(342.25,209.69) v1(342.25,207.97) v1(344.18,269.69) v1(344.18,267.97) v1(344.18,209.69) v1(344.18,207.97) v1(346.11,269.69) v1(346.11,267.97) v1(346.11,209.69) v1(346.11,207.97) v1(347.71,154.57) v1(348.04,269.69) v1(348.04,209.69) v1(351.52,154.57) v1(357,259.34) v1(357,257.41) v1(357,255.48) v1(357,253.56) v1(357,251.63) v1(357,249.7) v1(357,247.27) v1(357,245.34) v1(357,199.34) v1(357,197.41) v1(357,195.49) v1(357,193.56) v1(357,191.63) v1(357,189.7) v1(357,187.27) v1(357,185.34) v1(360.05,257.41) v1(360.05,255.48) v1(360.05,253.56) v1(360.05,251.63) v1(360.05,249.19) v1(360.05,247.27) v1(360.05,197.41) v1(360.05,195.49) v1(360.05,193.56) v1(360.05,191.63) v1(360.05,189.19) v1(360.05,187.27)
Net_8: length 0.4
  BOTTOM w0.119: 242.67,241.63 v1(242.87,241.63) ; 242.07,241.63 v1(241.87,241.63)
  vias: v1(233.5,237.74) v1(233.5,235.89) v1(233.5,234.03) v1(233.5,232.05) v1(233.5,177.74) v1(233.5,175.89) v1(233.5,174.03) v1(233.5,172.05) v1(236.49,236.12) v1(236.49,176.12) v1(237.99,234.65) v1(237.99,232.05) v1(237.99,229.95) v1(237.99,174.65) v1(237.99,172.05) v1(237.99,169.95) v1(241.87,248.83) v1(241.87,188.83) v1(241.87,181.63) v1(242.87,248.83) v1(242.87,188.83) v1(242.87,181.63) v1(243.28,237.69) v1(243.28,236.69) v1(243.28,177.69) v1(243.28,176.69) v1(246.67,253.59) v1(246.67,252.59) v1(249.1,235.23) v1(249.1,175.23) v1(252.08,237.69) v1(252.08,236.69) v1(252.08,177.69) v1(252.08,176.69) v1(252.74,253.59) v1(252.74,252.59) v1(253.94,253.59) v1(253.94,252.59) v1(254.48,237.69) v1(254.48,236.69) v1(254.48,177.69) v1(254.48,176.69) v1(257.99,249.47) v1(257.99,243.47) v1(257.99,189.47) v1(257.99,183.47) v1(259,249.47) v1(259,243.47) v1(259,189.47) v1(259,183.47) v1(313.5,237.74) v1(313.5,235.89) v1(313.5,234.03) v1(313.5,232.05) v1(313.5,177.74) v1(313.5,175.89) v1(313.5,174.03) v1(313.5,172.05) v1(316.49,236.12) v1(316.49,176.12) v1(317.99,234.65) v1(317.99,232.05) v1(317.99,229.95) v1(317.99,174.65) v1(317.99,172.05) v1(317.99,169.95) v1(321.87,248.83) v1(321.87,241.63) v1(321.87,188.83) v1(321.87,181.63) v1(322.87,248.83) v1(322.87,241.63) v1(322.87,188.83) v1(322.87,181.63) v1(323.28,237.69) v1(323.28,236.69) v1(323.28,177.69) v1(323.28,176.69) v1(326.67,253.59) v1(326.67,252.59) v1(326.67,193.59) v1(326.67,192.59) v1(329.1,235.23) v1(329.1,175.23) v1(332.08,237.69) v1(332.08,236.69) v1(332.08,177.69) v1(332.08,176.69) v1(332.74,253.59) v1(332.74,252.59) v1(332.74,193.59) v1(332.74,192.59) v1(333.94,253.59) v1(333.94,252.59) v1(333.94,193.59) v1(333.94,192.59) v1(334.48,237.69) v1(334.48,236.69) v1(334.48,177.69) v1(334.48,176.69) v1(337.99,249.47) v1(337.99,243.47) v1(337.99,189.47) v1(337.99,183.47) v1(339,249.47) v1(339,243.47) v1(339,189.47) v1(339,183.47)
