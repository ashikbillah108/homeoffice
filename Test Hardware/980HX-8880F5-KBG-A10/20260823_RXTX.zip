# Allegro board 8880F5-0823_RXTX.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D10202: length 833.7
  TOP w0.086: SITE4.142 317.68,189.63 317.6,189.55 313.04,189.55 311.83,190.76 304.76,190.76 v1(304.31,191.21)
  L05_SIGNAL w0.071: D102.02 311.98,80.84 311.98,81.95 311.69,82.24 303.65,82.24 301.8,84.08 301.8,89.53 306.82,94.55 321.96,94.55 324.41,97.01 330.15,97.01 332.23,99.09 336.1,99.09 336.75,98.44 340.23,98.44 342.92,101.12 367.62,101.12 370.61,104.11 392.79,104.11 394.3,102.6 446.3,102.6 457.23,91.67 457.23,77.94 458.59,76.58 485.1,76.58 486.05,77.53 486.05,78.69 485.24,79.5 458.95,79.5 458.33,80.12 458.33,81.5 458.92,82.09 525.41,82.09 526.45,83.13 526.45,84.37 525.34,85.49 460.38,85.49 459.45,86.41 459.45,88.43 460.1,89.08 523.16,89.08 523.89,89.81 523.89,90.83 523.07,91.65 499.54,91.65 498.62,92.56 498.62,93.9 499.5,94.77 520.17,94.77 521.47,96.07 521.47,98.59 514.59,105.47 419.51,105.47 418.77,104.73 409.13,104.73 407.83,106.03 387.07,106.03 379.07,114.04 351.15,114.04 345.88,119.3 333.73,119.3 326.64,126.4 320.25,126.4 312.19,134.45 308.09,134.45 305.48,137.07 305.48,139.52 306.53,140.58 310.77,140.58 311.01,140.81 311.01,141.07 v1(310.53,141.54)
  L32_SIGNAL w0.071: v1(310.53,141.54) 311.01,142.01 311.01,143.05 305.85,148.21 305.85,152.6 302.67,155.78 302.67,190.15 303.26,190.74 303.83,190.74 v1(304.31,191.21)
D10204: length 833.7
  TOP w0.086: SITE4.143 317.68,189.23 317.6,189.31 312.94,189.31 311.73,190.52 304.76,190.52 v1(304.31,190.07)
  L05_SIGNAL w0.071: D102.04 313.31,80.39 313.24,80.39 312.18,81.45 312.18,82.03 311.78,82.43 303.73,82.43 301.99,84.17 301.99,89.45 306.9,94.36 322.04,94.36 324.5,96.81 330.24,96.81 332.31,98.89 336.01,98.89 336.66,98.24 340.32,98.24 343,100.92 367.71,100.92 370.69,103.91 392.7,103.91 394.22,102.4 446.22,102.4 457.03,91.58 457.03,77.86 458.51,76.38 485.18,76.38 486.25,77.45 486.25,78.77 485.32,79.7 459.04,79.7 458.53,80.21 458.53,81.42 459,81.89 525.49,81.89 526.65,83.05 526.65,84.46 525.42,85.68 460.46,85.68 459.65,86.49 459.65,88.35 460.18,88.88 523.24,88.88 524.09,89.73 524.09,90.91 523.15,91.85 499.62,91.85 498.82,92.64 498.82,93.81 499.58,94.57 520.25,94.57 521.67,95.99 521.67,98.67 514.67,105.66 419.43,105.66 418.69,104.93 409.21,104.93 407.91,106.23 387.16,106.23 379.15,114.23 351.23,114.23 345.97,119.5 333.82,119.5 326.73,126.59 320.33,126.59 312.28,134.65 308.17,134.65 305.67,137.15 305.67,139.44 306.61,140.38 310.85,140.38 311.21,140.73 311.21,141.07 v1(311.68,141.54)
  L32_SIGNAL w0.071: v1(304.31,190.07) 303.83,190.54 303.35,190.54 302.87,190.06 302.87,155.86 306.05,152.68 306.05,148.29 311.21,143.13 311.21,142.01 v1(311.68,141.54)
D10206: length 833.7
  TOP w0.086: v1(307.6,193.14) 308.04,192.7 311.52,192.7 313.87,190.35 317.6,190.35 317.68,190.43 SITE4.140
  L05_SIGNAL w0.071: D102.06 322.15,80.85 322.15,82.76 322.08,82.83 305.56,82.83 303.55,84.84 303.55,88.42 308.33,93.2 335.4,93.2 336.98,94.78 342.52,94.78 343.82,93.48 362.54,93.48 370.8,101.73 442.87,101.73 454.79,89.82 454.79,73.52 458.61,69.71 527.16,69.71 527.89,70.43 527.89,71.06 527.47,71.47 458.9,71.47 457.97,72.39 457.97,73.52 458.61,74.17 527.67,74.17 528.43,74.93 528.43,75.85 527.76,76.53 488.34,76.53 487.43,77.44 487.43,79.1 488.18,79.86 527.12,79.86 527.9,80.64 527.9,95.57 515.99,107.48 418.27,107.48 412.34,113.41 396.57,113.41 392.67,117.31 361.59,117.31 349.75,129.15 349.75,144.04 344.74,149.05 314.68,149.05 312.46,151.27 312.46,152.45 311.01,153.91 311.01,154.66 v1(310.53,155.13)
  L32_SIGNAL w0.071: v1(307.6,193.14) 307.13,192.67 306.36,192.67 305.06,191.37 305.06,184.47 303.64,183.05 303.64,164.86 311.01,157.49 311.01,155.6 v1(310.53,155.13)
D10208: length 833.7
  TOP w0.086: SITE4.141 317.68,190.03 317.6,190.11 313.78,190.11 311.43,192.46 308.06,192.46 v1(307.6,192)
  L05_SIGNAL w0.071: v1(311.68,155.13) 311.21,154.66 311.21,153.99 312.66,152.54 312.66,151.36 314.77,149.25 344.82,149.25 349.95,144.13 349.95,129.24 361.68,117.51 392.75,117.51 396.65,113.61 412.42,113.61 418.35,107.68 516.07,107.68 528.1,95.65 528.1,80.55 527.2,79.66 488.26,79.66 487.63,79.02 487.63,77.52 488.42,76.73 527.84,76.73 528.63,75.94 528.63,74.85 527.75,73.97 458.7,73.97 458.17,73.44 458.17,72.48 458.98,71.67 527.56,71.67 528.08,71.14 528.08,70.35 527.24,69.51 458.52,69.51 454.59,73.44 454.59,89.73 442.79,101.53 370.88,101.53 362.63,93.28 343.74,93.28 342.44,94.58 337.06,94.58 335.48,93 308.41,93 303.75,88.33 303.75,84.92 305.64,83.02 322.16,83.02 322.35,82.84 322.35,81.43 323.26,80.52 323.34,80.52 D102.08
  L32_SIGNAL w0.071: v1(307.6,192) 307.13,192.47 306.44,192.47 305.26,191.28 305.26,184.38 303.83,182.96 303.83,164.94 311.21,157.57 311.21,155.6 v1(311.68,155.13)
D10210: length 833.7
  TOP w0.086: v1(359.29,195.88) 358.81,196.36 349.82,196.36 345.58,192.11 344.06,192.11 343.98,192.03 SITE4.85
  L07_SIGNAL w0.071: D102.10 333.01,81.55 333.01,82.39 333.63,83 348.3,83 353.41,77.89 353.41,44.03 348.57,39.18 290.03,39.18 288.71,37.86 288.71,24.52 291.38,21.85 420.88,21.85 421.57,22.54 421.57,23.4 421.01,23.96 307.17,23.96 306.57,24.56 306.57,25.24 307.12,25.79 351.29,25.79 359.02,33.52 359.02,102.27 346.48,114.82 338.29,114.82 324.72,128.39 324.72,128.77 324.65,128.84 v1(324.25,128.84)
  L30_SIGNAL w0.071: v1(324.25,128.84) 324.72,129.31 324.72,130.02 325.59,130.88 327.71,130.88 337.17,121.42 342.01,121.42 343.71,119.71 394.81,119.71 395.8,118.72 415.6,118.72 429.44,132.56 429.44,190.56 427.07,192.93 412.66,192.93 409.24,189.5 380.1,189.5 377.66,191.95 370.78,191.95 366.37,196.35 359.76,196.35 v1(359.29,195.88)
D10212: length 833.7
  TOP w0.086: SITE4.86 343.98,192.43 344.06,192.35 345.48,192.35 349.73,196.6 358.87,196.6 v1(359.29,197.02)
  L07_SIGNAL w0.071: v1(325.39,128.84) 324.99,128.84 324.92,128.77 324.92,128.47 338.38,115.01 346.56,115.01 359.22,102.36 359.22,33.44 351.38,25.6 307.2,25.6 306.77,25.16 306.77,24.64 307.25,24.16 421.09,24.16 421.77,23.48 421.77,22.45 420.97,21.65 291.3,21.65 288.51,24.44 288.51,37.95 289.95,39.38 348.48,39.38 353.21,44.11 353.21,77.81 348.22,82.8 333.71,82.8 333.21,82.3 333.21,80.81 D102.12
  L30_SIGNAL w0.071: v1(359.29,197.02) 359.76,196.55 366.46,196.55 370.86,192.15 377.74,192.15 380.19,189.7 409.15,189.7 412.58,193.13 427.15,193.13 429.64,190.64 429.64,132.48 415.68,118.53 395.72,118.53 394.73,119.51 343.63,119.51 341.92,121.22 337.09,121.22 327.63,130.68 325.67,130.68 324.92,129.94 324.92,129.31 v1(325.39,128.84)
D10213: length 833.7
  TOP w0.086: SITE4.116 328.63,197.78 328.55,197.86 328.55,208.77 v1(328.93,209.15)
  L07_SIGNAL w0.071: v1(381.15,190.94) 381.62,191.42 381.62,191.82 381.24,192.2 379.62,192.2 378.62,191.2 378.62,156.09 370.3,147.77 370.3,134.68 368.83,133.21 368.83,57.25 377.03,49.04 423.17,49.04 424.4,47.82 424.4,12.66 422.82,11.08 311.74,11.08 311.06,10.41 311.06,9.47 311.6,8.93 420.4,8.93 421.06,8.27 421.06,7.37 419.93,6.24 305.92,6.24 300.8,11.36 286.12,11.36 284.32,13.16 284.32,42.9 286.47,45.05 349.11,45.05 351.28,47.22 351.28,68.07 347.42,71.92 340.9,71.92 340.48,72.34 340.48,74.47 339.98,74.97 339.05,74.97 D102.13
  L30_SIGNAL w0.071: v1(328.93,209.15) 328.46,209.62 328.46,212.66 330.34,214.54 343.09,214.54 344.13,213.51 358.11,213.51 359.65,215.06 374.52,215.06 379.48,210.1 379.48,201.55 381.62,199.41 381.62,191.02 381.55,190.94 v1(381.15,190.94)
D10214: length 833.7
  TOP w0.086: SITE4.83 343.98,191.23 344.06,191.31 346.53,191.31 349.61,194.39 355.8,194.39 v1(356.24,193.95)
  L07_SIGNAL w0.071: v1(324.25,142.43) 324.72,141.96 324.72,141.31 325.98,140.05 325.98,138.61 341.67,122.92 350,122.92 360.59,112.32 360.59,55.33 368.83,47.09 419.96,47.09 422.73,44.33 422.73,18.52 422.04,17.84 385.49,17.84 384.88,17.22 384.88,15.76 385.45,15.19 421.97,15.19 422.73,14.44 422.73,13.4 422.1,12.78 307.66,12.78 299.96,20.47 288.45,20.47 286.18,22.74 286.18,40.66 288.17,42.65 349.55,42.65 352.65,45.75 352.65,77.24 347.44,82.44 342.96,82.44 342.04,81.52 342.04,80.42 D102.14
  L30_SIGNAL w0.071: v1(324.25,142.43) 324.72,141.96 324.72,140.98 325.53,140.17 328.46,140.17 331.92,143.64 344.44,143.64 347.85,140.23 347.85,130.22 352.85,125.22 384.09,125.22 385.18,124.13 396.88,124.13 397.94,123.07 416.57,123.07 428.52,135.03 428.52,189.59 426.43,191.68 412.67,191.68 410.09,189.1 379.69,189.1 377.34,191.45 370.55,191.45 366.32,195.68 362.8,195.68 361.81,194.69 359.32,194.69 357.4,196.62 355.4,196.62 354.77,195.98 354.77,194.95 355.29,194.42 355.77,194.42 v1(356.24,193.95)
D10215: length 833.7
  TOP w0.086: SITE4.117 328.23,197.78 328.31,197.86 328.31,208.63 v1(327.79,209.15)
  L07_SIGNAL w0.071: D102.15 340.68,73.98 340.68,72.42 340.98,72.12 347.51,72.12 351.48,68.15 351.48,47.13 349.2,44.85 286.55,44.85 284.52,42.81 284.52,13.25 286.2,11.56 300.88,11.56 306,6.44 419.85,6.44 420.86,7.45 420.86,8.19 420.32,8.74 311.52,8.74 310.87,9.39 310.87,10.5 311.65,11.28 422.74,11.28 424.2,12.74 424.2,47.74 423.09,48.84 376.95,48.84 368.63,57.17 368.63,133.29 370.1,134.76 370.1,147.85 378.42,156.17 378.42,191.29 379.54,192.4 381.32,192.4 381.82,191.9 381.82,191.42 v1(382.29,190.94)
  L30_SIGNAL w0.071: v1(327.79,209.15) 328.26,209.62 328.26,212.75 330.26,214.74 343.18,214.74 344.21,213.71 358.02,213.71 359.57,215.25 374.61,215.25 379.68,210.18 379.68,201.63 381.82,199.49 381.82,191.02 381.89,190.94 v1(382.29,190.94)
D10216: length 833.7
  TOP w0.086: SITE4.84 343.98,191.63 344.06,191.55 346.43,191.55 349.51,194.63 355.78,194.63 v1(356.24,195.09)
  L07_SIGNAL w0.071: D102.16 344.38,79.8 342.65,79.8 342.24,80.22 342.24,81.44 343.05,82.25 347.36,82.25 352.45,77.15 352.45,45.83 349.46,42.85 288.09,42.85 285.98,40.74 285.98,22.66 288.36,20.27 299.88,20.27 307.57,12.58 422.18,12.58 422.92,13.32 422.92,14.52 422.05,15.39 385.53,15.39 385.08,15.85 385.08,17.14 385.57,17.64 422.12,17.64 422.92,18.44 422.92,44.41 420.04,47.29 368.91,47.29 360.79,55.41 360.79,112.4 350.08,123.11 341.76,123.11 326.18,138.69 326.18,140.13 324.92,141.39 324.92,141.96 v1(325.39,142.43)
  L30_SIGNAL w0.071: v1(325.39,142.43) 324.92,141.96 324.92,141.06 325.61,140.37 328.37,140.37 331.84,143.84 344.52,143.84 348.05,140.31 348.05,130.31 352.93,125.42 384.17,125.42 385.27,124.33 396.96,124.33 398.02,123.27 416.49,123.27 428.32,135.11 428.32,189.51 426.35,191.49 412.75,191.49 410.17,188.9 379.61,188.9 377.26,191.25 370.47,191.25 366.24,195.48 362.88,195.48 361.9,194.49 359.24,194.49 357.31,196.42 355.48,196.42 354.97,195.9 354.97,195.03 355.38,194.62 355.77,194.62 v1(356.24,195.09)
D10301: length 833.7
  TOP w0.086: SITE4.95 337.03,197.78 336.95,197.86 336.95,199.28 341.41,203.74 341.41,206.77 v1(341.86,207.21)
  L05_SIGNAL w0.071: v1(394.35,157.67) 394.83,158.14 394.83,159.41 395.47,160.06 397.42,160.06 398.66,158.82 398.66,147.25 405.2,140.71 405.2,131.06 412.36,123.89 429.78,123.89 457.45,151.56 522.26,151.56 548.08,125.75 548.08,45.97 539.58,37.48 459.94,37.48 436.62,60.79 436.62,83.61 424.8,95.44 378.22,95.44 359.3,76.52 359.3,50.96 352.32,43.97 315.18,43.97 309.46,49.69 309.46,53.76 D103.01
  L32_SIGNAL w0.071: v1(341.86,207.21) 341.38,207.69 341.38,213.27 345.79,217.68 372.38,217.68 374.24,215.82 417.29,215.82 430.69,202.43 430.69,148.86 424.94,143.11 420.96,143.11 419.04,145.03 419.04,152.01 417.59,153.45 400.44,153.45 398.7,155.2 398.7,158.31 396.91,160.09 395.84,160.09 394.83,159.08 394.83,158.14 v1(394.35,157.67)
D10303: length 833.7
  TOP w0.086: SITE4.96 336.63,197.78 336.71,197.86 336.71,199.38 341.17,203.84 341.17,206.75 v1(340.71,207.21)
  L05_SIGNAL w0.071: D103.03 311.33,54.79 310.66,54.79 309.66,53.79 309.66,49.77 315.26,44.17 352.24,44.17 359.11,51.04 359.11,76.61 378.14,95.64 424.88,95.64 436.82,83.7 436.82,60.87 460.02,37.67 539.5,37.67 547.88,46.06 547.88,125.67 522.18,151.37 457.53,151.37 429.86,123.7 412.28,123.7 405,130.97 405,140.63 398.46,147.17 398.46,158.74 397.34,159.86 395.55,159.86 395.03,159.33 395.03,158.14 v1(395.5,157.67)
  L32_SIGNAL w0.071: v1(340.71,207.21) 341.19,207.69 341.19,213.36 345.71,217.88 372.46,217.88 374.32,216.02 417.37,216.02 430.88,202.51 430.88,148.78 425.02,142.91 420.87,142.91 418.84,144.95 418.84,151.93 417.51,153.26 400.36,153.26 398.5,155.12 398.5,158.23 396.83,159.9 395.92,159.9 395.02,159 395.02,158.14 v1(395.5,157.67)
D10305: length 833.7
  TOP w0.086: v1(339.93,208.93) 339.46,208.47 339.46,207.3 338.7,206.53 338.7,204.43 335.75,201.48 335.75,197.86 335.83,197.78 SITE4.98
  L05_SIGNAL w0.071: D103.05 319.16,54.22 319.82,54.22 320.26,53.78 320.26,47.79 321.89,46.16 349.75,46.16 355.25,51.66 355.25,75.86 376.62,97.23 430.32,97.23 443.81,83.74 443.81,61.27 463.47,41.61 540.64,41.61 542.1,43.07 542.1,45.94 541.23,46.81 531.5,46.81 530.41,47.9 530.41,49.69 531.43,50.71 541.47,50.71 542.41,51.65 542.41,127.01 521.76,147.65 457.57,147.65 431.03,121.11 405.11,121.11 392.75,133.47 392.75,144.96 393.65,145.87 394.33,145.87 394.83,145.37 394.83,144.55 v1(394.35,144.08)
  L32_SIGNAL w0.071: v1(339.93,208.93) 339.45,209.4 339.45,212.46 338.49,213.43 338.49,216.25 340.43,218.19 419,218.19 433.21,203.98 433.21,145.78 425.99,138.56 401.79,138.56 400.81,139.53 400.81,145.75 398.21,148.36 397.41,148.36 394.83,145.77 394.83,144.55 v1(394.35,144.08)
D10307: length 833.7
  TOP w0.086: v1(338.78,208.93) 339.22,208.49 339.22,207.4 338.46,206.63 338.46,204.53 335.51,201.58 335.51,197.86 335.43,197.78 SITE4.99
  L05_SIGNAL w0.071: D103.07 320.46,53.76 320.46,47.87 321.97,46.36 349.67,46.36 355.05,51.75 355.05,75.95 376.53,97.43 430.41,97.43 444.01,83.83 444.01,61.35 463.56,41.81 540.55,41.81 541.9,43.15 541.9,45.86 541.15,46.61 531.42,46.61 530.21,47.81 530.21,49.77 531.35,50.91 541.39,50.91 542.21,51.73 542.21,126.92 521.68,147.45 457.66,147.45 431.11,120.91 405.03,120.91 392.55,133.39 392.55,145.04 393.57,146.07 394.41,146.07 395.03,145.45 395.03,144.55 v1(395.5,144.08)
  L32_SIGNAL w0.071: v1(395.5,144.08) 395.02,144.55 395.02,145.69 397.49,148.16 398.12,148.16 400.62,145.67 400.62,139.45 401.7,138.36 426.07,138.36 433.41,145.7 433.41,204.06 419.09,218.39 340.35,218.39 338.29,216.33 338.29,213.35 339.26,212.38 339.26,209.4 v1(338.78,208.93)
D10309: length 833.7
  TOP w0.086: SITE4.133 317.68,193.23 317.6,193.15 316.94,193.15 311.22,198.87 304.75,198.87 v1(304.31,199.31)
  L05_SIGNAL w0.071: v1(390.29,129.1) 390.76,129.57 390.76,130.66 390.3,131.13 389.82,131.13 389.28,130.59 389.28,123.9 391.9,121.28 403.4,121.28 406.84,117.84 433.84,117.84 452.38,136.39 517.69,136.39 533.35,120.72 533.35,56.18 529.42,52.25 467.65,52.25 467.06,51.65 467.06,49.83 467.97,48.92 525.69,48.92 527.03,47.58 527.03,45.52 525.33,43.82 465.55,43.82 448.41,60.96 448.41,86.38 436.22,98.57 374.29,98.57 353.33,77.6 353.33,53.55 347.99,48.22 331.11,48.22 330.14,49.19 330.14,53.4 D103.09
  L32_SIGNAL w0.071: v1(390.29,129.1) 390.76,129.57 390.76,130.53 390.17,131.12 388.18,131.12 387.21,130.15 387.21,128.92 383.29,125 373.6,125 368.29,130.3 348.81,130.3 345.65,133.46 342.24,133.46 340.56,131.78 336.9,131.78 335.6,133.08 330.44,133.08 328,130.64 306.35,130.64 305.4,131.6 305.4,132.87 300.03,138.24 300.03,196.6 302.27,198.84 303.83,198.84 v1(304.31,199.31)
D10310: length 833.7
  TOP w0.086: v1(327.07,210.87) 326.61,210.41 326.61,202.62 326.95,202.28 326.95,197.86 327.03,197.78 SITE4.120
  L07_SIGNAL w0.071: v1(381.15,177.36) 381.62,176.88 381.62,175.99 387.69,169.92 387.69,145.99 381.13,139.42 381.13,133.8 379.95,132.62 379.95,124.34 387.12,117.17 396.39,117.17 397.8,115.77 409.59,115.77 424.2,101.16 473.57,101.16 476.76,97.97 476.76,75.87 472.73,71.85 439.82,71.85 437.33,74.33 437.33,89.88 429.04,98.18 377.29,98.18 369.52,90.41 369.52,58.42 376.33,51.61 422.73,51.61 425.7,48.64 425.7,10.88 419.85,5.02 304.42,5.02 298.87,10.57 283.7,10.57 281.57,12.7 281.57,43.02 285.98,47.43 349.41,47.43 350.43,48.45 350.43,62.06 349.77,62.72 333.63,62.72 333.05,62.14 333.05,60.74 332.59,60.29 332.07,60.29 D103.10
  L30_SIGNAL w0.071: v1(381.15,177.36) 381.62,176.88 381.62,175.67 380.87,174.92 373.86,174.92 371.84,176.94 353.3,176.94 348.43,181.8 346.06,181.8 342.91,184.95 342.91,189.2 340.99,191.13 337.77,191.13 326.6,202.3 326.6,210.4 v1(327.07,210.87)
D10311: length 833.7
  TOP w0.086: SITE4.134 317.68,192.83 317.6,192.91 316.84,192.91 311.12,198.63 304.77,198.63 v1(304.31,198.17)
  L05_SIGNAL w0.071: D103.11 331.76,54.9 331.14,54.9 330.34,54.1 330.34,49.27 331.19,48.42 347.91,48.42 353.13,53.64 353.13,77.68 374.21,98.77 436.31,98.77 448.61,86.47 448.61,61.04 465.63,44.02 525.25,44.02 526.83,45.6 526.83,47.49 525.61,48.72 467.88,48.72 466.86,49.74 466.86,51.74 467.57,52.45 529.33,52.45 533.15,56.27 533.15,120.64 517.61,136.19 452.46,136.19 433.92,117.65 406.75,117.65 403.31,121.09 391.81,121.09 389.09,123.81 389.09,130.67 389.74,131.33 390.38,131.33 390.96,130.74 390.96,129.57 v1(391.43,129.1)
  L32_SIGNAL w0.071: v1(304.31,198.17) 303.83,198.64 302.36,198.64 300.23,196.52 300.23,138.32 305.6,132.96 305.6,131.68 306.44,130.84 327.92,130.84 330.35,133.27 335.69,133.27 336.99,131.98 340.47,131.98 342.16,133.66 345.73,133.66 348.89,130.5 368.38,130.5 373.68,125.2 383.21,125.2 387.01,129.01 387.01,130.24 388.1,131.32 390.25,131.32 390.96,130.61 390.96,129.57 v1(391.43,129.1)
D10312: length 833.7
  TOP w0.086: v1(325.93,210.87) 326.38,210.42 326.38,202.52 326.71,202.19 326.71,197.86 326.63,197.78 SITE4.121
  L07_SIGNAL w0.071: D103.12 333.25,60.45 333.25,62.05 333.72,62.52 349.69,62.52 350.23,61.98 350.23,48.53 349.32,47.63 285.9,47.63 281.37,43.1 281.37,12.62 283.62,10.37 298.79,10.37 304.33,4.83 419.93,4.83 425.9,10.79 425.9,48.72 422.81,51.81 376.41,51.81 369.72,58.5 369.72,90.33 377.37,97.98 428.96,97.98 437.14,89.8 437.14,74.25 439.73,71.65 472.81,71.65 476.96,75.79 476.96,98.05 473.65,101.36 424.28,101.36 409.68,115.96 397.88,115.96 396.47,117.37 387.2,117.37 380.15,124.43 380.15,132.54 381.33,133.72 381.33,139.34 387.89,145.91 387.89,170 381.82,176.07 381.82,176.88 v1(382.29,177.36)
  L30_SIGNAL w0.071: v1(325.93,210.87) 326.4,210.4 326.4,202.22 337.69,190.93 340.91,190.93 342.72,189.12 342.72,184.87 345.98,181.6 348.35,181.6 353.21,176.74 371.76,176.74 373.78,174.72 380.96,174.72 381.82,175.58 381.82,176.88 v1(382.29,177.36)
D10313: length 833.7
  TOP w0.086: SITE4.131 322.63,197.78 322.55,197.86 322.55,198.66 316.97,204.24 316.97,208.69 v1(317.43,209.15)
  L05_SIGNAL w0.071: v1(390.29,142.68) 390.76,143.16 390.76,144.33 390.17,144.91 388.9,144.91 385.56,141.57 385.56,121.13 386.88,119.81 393.85,119.81 397.71,115.95 412.33,115.95 419.25,109.03 517.25,109.03 530.44,95.84 530.44,69.55 528.69,67.8 465.22,67.8 464.07,66.65 464.07,65.41 465.19,64.29 530.37,64.29 531.28,63.38 531.28,62.15 530.48,61.34 462.04,61.34 451.86,71.52 451.86,88.52 440.34,100.04 372.37,100.04 350.56,78.22 350.56,53.83 346.25,49.52 341.46,49.52 340.83,50.15 340.83,53.18 339.29,54.73 338.97,54.73 D103.13
  L32_SIGNAL w0.071: v1(317.43,209.15) 316.95,208.68 316.95,207.81 316.62,207.47 315.5,207.47 313.28,209.69 308.81,209.69 296.71,197.59 296.71,137.11 304.15,129.67 336.17,129.67 340.91,124.93 349.47,124.93 351.58,122.83 391.17,122.83 392.28,123.94 392.28,139.44 390.76,140.95 390.76,142.21 v1(390.29,142.68)
D10314: length 833.7
  TOP w0.086: v1(325.14,209.15) 324.69,208.7 324.69,203.17 326.15,201.71 326.15,197.86 326.23,197.78 SITE4.122
  L07_SIGNAL w0.071: D103.14 341.25,59.31 341.9,59.31 343.13,60.54 343.13,61.77 343.55,62.19 347.17,62.19 349.27,60.1 349.27,52.05 346.22,49 285.56,49 279.91,43.36 279.91,11.36 282.12,9.16 298.2,9.16 303.54,3.82 421.46,3.82 427.35,9.71 427.35,50.16 422.88,54.62 378.06,54.62 371.1,61.59 371.1,90.09 377.94,96.93 425.86,96.93 435.52,87.26 435.52,73.08 438.64,69.96 473.1,69.96 478.65,75.52 478.65,98.26 474.2,102.71 426.74,102.71 410.73,118.72 395.5,118.72 389.38,124.84 389.38,167.34 394.83,172.79 394.83,173.96 v1(394.35,174.43)
  L30_SIGNAL w0.071: v1(394.35,174.43) 394.83,173.96 394.83,173.63 394.39,173.19 329.58,173.19 326.01,176.77 326.01,194.81 324.67,196.15 324.67,208.68 v1(325.14,209.15)
D10315: length 833.7
  TOP w0.086: v1(316.28,209.15) 316.73,208.71 316.73,204.14 322.31,198.56 322.31,197.86 322.23,197.78 SITE4.132
  L05_SIGNAL w0.071: v1(391.43,142.68) 390.96,143.16 390.96,144.41 390.26,145.11 388.82,145.11 385.36,141.66 385.36,121.05 386.79,119.61 393.76,119.61 397.63,115.75 412.25,115.75 419.17,108.83 517.17,108.83 530.24,95.76 530.24,69.64 528.61,68 465.14,68 463.87,66.73 463.87,65.33 465.1,64.09 530.29,64.09 531.09,63.3 531.09,62.23 530.39,61.54 462.12,61.54 452.05,71.61 452.05,88.6 440.42,100.24 372.29,100.24 350.36,78.31 350.36,53.91 346.17,49.72 341.55,49.72 341.03,50.23 341.03,54.01 D103.15
  L32_SIGNAL w0.071: v1(391.43,142.68) 390.96,142.21 390.96,141.04 392.48,139.52 392.48,123.86 391.25,122.63 351.5,122.63 349.39,124.74 340.82,124.74 336.09,129.47 304.07,129.47 296.51,137.03 296.51,197.67 308.73,209.89 313.36,209.89 315.58,207.67 316.53,207.67 316.75,207.89 316.75,208.68 v1(316.28,209.15)
D10316: length 833.7
  TOP w0.086: SITE4.123 325.83,197.78 325.91,197.86 325.91,201.61 324.46,203.07 324.46,208.69 v1(324,209.15)
  L07_SIGNAL w0.071: v1(395.5,174.43) 395.03,173.96 395.03,172.71 389.58,167.26 389.58,124.92 395.58,118.92 410.81,118.92 426.83,102.91 474.28,102.91 478.85,98.34 478.85,75.43 473.18,69.76 438.56,69.76 435.33,72.99 435.33,87.18 425.77,96.73 378.02,96.73 371.29,90.01 371.29,61.67 378.14,54.82 422.97,54.82 427.55,50.24 427.55,9.63 421.54,3.62 303.45,3.62 298.12,8.96 282.03,8.96 279.72,11.28 279.72,43.44 285.47,49.2 346.13,49.2 349.07,52.14 349.07,60.02 347.09,62 343.63,62 343.33,61.69 343.33,60.53 D103.16
  L30_SIGNAL w0.071: v1(324,209.15) 324.47,208.68 324.47,196.07 325.82,194.73 325.82,176.68 329.5,173 394.47,173 395.02,173.55 395.02,173.96 v1(395.5,174.43)
D10409: length 413.5
  TOP w0.086: SITE4.172 317.68,177.63 317.6,177.71 315.46,177.71 314.38,176.63 305.85,176.63 v1(305.39,176.18)
  L03_SIGNAL w0.071: D104.09 329.61,33.61 329.61,28.14 324.32,22.85 283.52,22.85 280.97,20.3 280.97,12.23 284.12,9.08 352.84,9.08 359.98,16.23 359.98,112.07 378.99,131.07 378.99,153.22 380.29,154.51 380.29,170.85 381.82,172.37 381.82,173.71 v1(382.29,174.18)
  L28_SIGNAL w0.071: v1(382.29,174.18) 381.82,173.71 381.82,172.79 381.31,172.28 378.13,172.28 377.03,173.38 356.25,173.38 355.47,174.17 323.36,174.17 320.87,176.65 305.87,176.65 v1(305.39,176.18)
D10410: length 457
  TOP w0.086: SITE4.12 326.63,171.48 326.55,171.4 326.55,163.72 325.23,162.4 325.23,157.05 v1(325.68,156.6)
  L03_SIGNAL w0.071: v1(343.47,131.3) 343.94,131.77 345.27,131.77 350.94,126.1 350.94,53.48 343.17,45.7 335.55,45.7 333.66,43.81 333.66,40.79 332.45,39.57 331.67,39.57 D104.10
  L28_SIGNAL w0.071: v1(343.47,131.3) 343.94,131.77 344.83,131.77 347.05,129.55 347.05,125.25 351.69,120.62 366.6,120.62 367.47,119.75 367.47,118.47 366.73,117.74 352.67,117.74 351.22,119.19 340.68,119.19 338.03,116.54 327.72,116.54 326.93,115.75 326.93,113.53 328.03,112.43 337.92,112.43 339.36,110.99 342.33,110.99 343.14,111.8 350.72,111.8 352.76,113.84 389.44,113.84 391.11,112.17 395.79,112.17 396.86,113.24 416.9,113.24 417.44,112.69 417.44,110.93 416.36,109.85 413.17,109.85 409.23,105.91 393.78,105.91 389.84,109.85 352.17,109.85 350.11,107.78 339.37,107.78 338.04,106.45 336.28,106.45 335.69,107.05 330.2,107.05 327.4,109.85 321.22,109.85 317.73,113.34 317.73,141.39 318.54,142.2 318.54,147.52 325.21,154.2 325.21,156.12 v1(325.68,156.6)
D10411: length 413.5
  TOP w0.086: v1(305.39,177.32) 305.85,176.87 314.29,176.87 315.37,177.95 317.6,177.95 317.68,178.03 SITE4.171
  L03_SIGNAL w0.071: D104.11 331.27,34.09 330.31,34.09 329.81,33.59 329.81,28.05 324.41,22.65 283.6,22.65 281.17,20.22 281.17,12.31 284.2,9.28 352.75,9.28 359.79,16.31 359.79,112.15 378.79,131.15 378.79,153.3 380.09,154.6 380.09,170.93 381.62,172.46 381.62,173.71 v1(381.15,174.18)
  L28_SIGNAL w0.071: v1(381.15,174.18) 381.62,173.71 381.62,172.87 381.23,172.48 378.22,172.48 377.11,173.58 356.34,173.58 355.55,174.37 323.44,174.37 320.96,176.85 305.87,176.85 v1(305.39,177.32)
D10412: length 457
  TOP w0.086: SITE4.11 326.23,171.48 326.31,171.4 326.31,163.82 324.99,162.5 324.99,157.05 v1(324.54,156.6)
  L03_SIGNAL w0.071: D104.12 333.86,39.52 333.86,39.62 333.86,43.73 335.64,45.5 343.25,45.5 351.14,53.39 351.14,126.18 345.35,131.97 343.94,131.97 v1(343.47,132.44)
  L28_SIGNAL w0.071: v1(343.47,132.44) 343.94,131.97 344.91,131.97 347.25,129.63 347.25,125.34 351.77,120.82 366.69,120.82 367.67,119.84 367.67,118.39 366.82,117.54 352.59,117.54 351.14,118.99 340.77,118.99 338.11,116.34 327.8,116.34 327.13,115.67 327.13,113.61 328.11,112.63 338,112.63 339.44,111.19 342.25,111.19 343.06,112 350.63,112 352.67,114.04 389.52,114.04 391.19,112.36 395.71,112.36 396.78,113.43 416.98,113.43 417.64,112.77 417.64,110.84 416.45,109.65 413.25,109.65 409.31,105.71 393.7,105.71 389.76,109.65 352.25,109.65 350.19,107.59 339.45,107.59 338.12,106.26 336.2,106.26 335.61,106.85 330.12,106.85 327.32,109.65 321.14,109.65 317.53,113.26 317.53,141.47 318.34,142.28 318.34,147.61 325.01,154.28 325.01,156.12 v1(324.54,156.6)
D10413: length 457
  TOP w0.086: SITE4.8 325.03,171.48 324.95,171.4 324.95,165.37 319.21,159.63 v1(319.21,158.99)
  L03_SIGNAL w0.071: D104.13 340.18,33.2 340.18,30.69 341.53,29.35 347.51,29.35 355.8,37.64 355.8,117.84 370.92,132.96 370.92,149.32 370.35,149.88 370.35,153.54 370.92,154.11 370.92,195.29 371.41,195.78 372.46,195.78 v1(372.94,195.31)
  L28_SIGNAL w0.071: v1(319.21,158.99) 319.21,159.66 320.49,160.94 320.49,164.79 315.43,169.85 309.32,169.85 304.98,165.51 304.98,161.97 303.65,160.64 287.47,160.64 279.63,168.48 279.63,177.92 278.16,179.39 278.16,206.01 282.3,210.15 285.17,210.15 286.9,211.88 288.21,211.88 290.71,209.38 300.83,209.38 301.86,210.41 301.86,212.22 300.56,213.52 286.19,213.52 285.42,214.29 285.42,215.46 286.04,216.08 299.83,216.08 304.17,211.73 304.17,204.22 311.18,197.21 352.79,197.21 356.39,200.81 360.85,200.81 365.88,195.78 372.46,195.78 v1(372.94,195.31)
D10414: length 457
  TOP w0.086: SITE4.10 325.83,171.48 325.75,171.4 325.75,164.32 323.1,161.66 323.1,160.24 318.42,155.56 v1(318.42,154.92)
  L03_SIGNAL w0.071: v1(357.06,131.3) 357.53,131.77 358.93,131.77 360,130.7 360,127.46 353.29,120.74 353.29,51.08 343.54,41.33 343.54,40.13 343.07,39.66 341.92,39.66 D104.14
  L28_SIGNAL w0.071: v1(357.06,131.3) 357.53,131.77 358.67,131.77 373.02,117.42 391.41,117.42 392.93,118.93 402.26,118.93 403.78,117.42 415.89,117.42 419.97,113.34 419.97,111.09 410.98,102.1 363.51,102.1 362.38,100.96 362.38,98.95 363.54,97.79 404.05,97.79 404.99,96.84 404.99,94.76 403.95,93.72 362.13,93.72 351.74,104.1 334.36,104.1 333.15,105.32 327.28,105.32 326.33,104.36 317.08,104.36 314.61,106.83 314.61,151.78 317.75,154.92 v1(318.42,154.92)
D10415: length 457
  TOP w0.086: SITE4.7 324.63,171.48 324.71,171.4 324.71,165.47 319.04,159.8 v1(318.4,159.8)
  L03_SIGNAL w0.071: v1(372.94,196.45) 372.46,195.98 371.32,195.98 370.72,195.37 370.72,154.19 370.15,153.62 370.15,149.8 370.72,149.23 370.72,133.04 355.6,117.92 355.6,37.72 347.43,29.55 341.61,29.55 340.38,30.78 340.38,33.52 341.33,34.47 341.81,34.47 D104.15
  L28_SIGNAL w0.071: v1(318.4,159.8) 319.07,159.8 320.3,161.03 320.3,164.71 315.35,169.65 309.4,169.65 305.18,165.43 305.18,161.89 303.73,160.44 287.38,160.44 279.43,168.4 279.43,177.84 277.96,179.31 277.96,206.09 282.22,210.35 285.09,210.35 286.82,212.08 288.29,212.08 290.79,209.58 300.74,209.58 301.66,210.49 301.66,212.14 300.47,213.32 286.11,213.32 285.22,214.21 285.22,215.54 285.96,216.28 299.91,216.28 304.37,211.81 304.37,204.3 311.26,197.41 352.71,197.41 356.31,201.01 360.93,201.01 365.96,195.98 372.46,195.98 v1(372.94,196.45)
D10416: length 457
  TOP w0.086: SITE4.9 325.43,171.48 325.51,171.4 325.51,164.41 322.86,161.76 322.86,160.34 318.25,155.73 v1(317.61,155.73)
  L03_SIGNAL w0.071: D104.16 343.74,39.8 343.74,39.9 343.74,41.25 353.48,50.99 353.48,120.66 360.2,127.37 360.2,130.78 359.01,131.97 357.53,131.97 v1(357.06,132.44)
  L28_SIGNAL w0.071: v1(357.06,132.44) 357.53,131.97 358.75,131.97 373.1,117.61 391.33,117.61 392.84,119.13 402.35,119.13 403.86,117.61 415.98,117.61 420.17,113.42 420.17,111.01 411.06,101.9 363.6,101.9 362.57,100.88 362.57,99.03 363.62,97.99 404.13,97.99 405.19,96.92 405.19,94.68 404.03,93.52 362.05,93.52 351.66,103.91 334.28,103.91 333.07,105.12 327.36,105.12 326.41,104.17 317,104.17 314.41,106.75 314.41,151.86 317.61,155.06 v1(317.61,155.73)
D10601: length 833.7
  TOP w0.086: v1(359.29,192.02) 358.8,192.51 349.46,192.51 347.46,190.51 344.06,190.51 343.98,190.43 SITE4.81
  L07_SIGNAL w0.071: D106.01 382.25,74.95 383.63,74.95 384.4,74.18 384.4,73.8 383.32,72.72 379.78,72.72 378.94,73.56 378.94,78.43 380.43,79.92 422.38,79.92 425.97,76.33 425.97,65.76 438.68,53.05 438.68,36.95 440.07,35.57 482,35.57 482.58,36.14 482.58,37.29 481.93,37.93 441.04,37.93 440.71,38.26 440.71,38.67 441.03,38.99 521,38.99 521.67,39.66 521.67,40.41 521.27,40.81 440.96,40.81 440.66,41.11 440.66,41.46 441.03,41.83 521.31,41.83 521.93,42.46 521.93,42.98 521.46,43.45 497.06,43.45 496.75,43.75 496.75,44.15 497,44.41 519.69,44.41 521.79,46.51 521.79,110.67 515.3,117.17 436.43,117.17 415.96,137.64 410,137.64 407.25,140.39 407.25,145.08 407.48,145.31 408.38,145.31 408.54,145.14 408.54,144.55 v1(408.07,144.08)
  L30_SIGNAL w0.071: v1(359.29,192.02) 359.76,192.49 366.48,192.49 373.31,185.66 406.99,185.66 411.46,181.18 411.46,171.91 414.42,168.95 422.08,168.95 425.63,165.4 425.63,154.24 423.35,151.96 408.78,151.96 407.35,150.53 407.35,146.59 408.54,145.4 408.54,144.55 v1(408.07,144.08)
D10602: length 833.7
  TOP w0.086: v1(304.31,195.45) 304.75,195.01 312.43,195.01 315.88,191.55 317.6,191.55 317.68,191.63 SITE4.137
  L05_SIGNAL w0.071: D106.02 384.84,80.04 385.09,80.04 386.2,81.15 386.2,81.76 385.67,82.29 377.68,82.29 375.27,84.69 375.27,88.93 380.5,94.16 422.97,94.16 434.18,82.95 434.18,59 457.8,35.38 544.3,35.38 549.66,40.74 549.66,204.7 545.98,208.38 511.45,208.38 510.83,207.76 510.83,206.3 512.23,204.91 529.9,204.91 530.99,203.82 530.99,202.18 530.16,201.35 453.83,201.35 450.01,197.54 450.01,162.55 451.35,161.22 451.35,146.8 429.71,125.16 413.6,125.16 407.73,131.03 407.73,141.18 405.33,143.57 405.33,156.76 408.29,159.71 408.29,160.37 v1(407.82,160.85)
  L32_SIGNAL w0.071: v1(407.82,160.85) 408.29,160.37 408.29,159.24 407.3,158.25 404.36,158.25 402.79,159.81 402.79,165.45 399.27,168.98 357.85,168.98 348.16,178.67 348.16,185.55 343.35,190.36 311.61,190.36 307.7,194.28 305.98,194.28 305.28,194.98 304.78,194.98 v1(304.31,195.45)
D10603: length 833.7
  TOP w0.086: SITE4.82 343.98,190.83 344.06,190.75 347.37,190.75 349.36,192.75 358.88,192.75 v1(359.29,193.16)
  L07_SIGNAL w0.071: v1(409.21,144.08) 408.74,144.55 408.74,145.23 408.46,145.51 407.4,145.51 407.05,145.16 407.05,140.3 409.92,137.44 415.88,137.44 436.35,116.97 515.21,116.97 521.59,110.59 521.59,46.59 519.6,44.6 496.92,44.6 496.55,44.24 496.55,43.67 496.97,43.25 521.38,43.25 521.73,42.9 521.73,42.54 521.22,42.03 440.95,42.03 440.46,41.55 440.46,41.02 440.88,40.61 521.19,40.61 521.47,40.33 521.47,39.74 520.92,39.19 440.94,39.19 440.51,38.76 440.51,38.18 440.95,37.74 481.84,37.74 482.38,37.2 482.38,36.23 481.91,35.76 440.15,35.76 438.88,37.03 438.88,53.13 426.17,65.84 426.17,76.41 422.46,80.12 380.35,80.12 378.74,78.51 378.74,73.48 379.7,72.52 383.4,72.52 384.6,73.72 384.6,74.72 D106.03
  L30_SIGNAL w0.071: v1(359.29,193.16) 359.76,192.69 366.56,192.69 373.39,185.85 407.07,185.85 411.66,181.26 411.66,171.99 414.5,169.15 422.16,169.15 425.82,165.48 425.82,154.16 423.43,151.76 408.86,151.76 407.55,150.45 407.55,146.67 408.74,145.48 408.74,144.55 v1(409.21,144.08)
D10604: length 833.7
  TOP w0.086: SITE4.138 317.68,191.23 317.6,191.31 315.78,191.31 312.33,194.77 304.76,194.77 v1(304.31,194.31)
  L05_SIGNAL w0.071: v1(408.96,160.85) 408.49,160.37 408.49,159.63 405.53,156.67 405.53,143.65 407.92,141.26 407.92,131.11 413.68,125.35 429.63,125.35 451.15,146.88 451.15,161.14 449.82,162.47 449.82,197.62 453.75,201.55 530.08,201.55 530.79,202.26 530.79,203.74 529.82,204.71 512.14,204.71 510.63,206.22 510.63,207.84 511.37,208.57 546.06,208.57 549.86,204.78 549.86,40.66 544.38,35.18 457.72,35.18 433.98,58.92 433.98,82.87 422.89,93.96 380.59,93.96 375.47,88.84 375.47,84.77 377.76,82.49 385.75,82.49 386.4,81.84 386.4,80.96 D106.04
  L32_SIGNAL w0.071: v1(408.96,160.85) 408.49,160.37 408.49,159.16 407.38,158.05 404.28,158.05 402.6,159.73 402.6,165.37 399.19,168.78 357.77,168.78 347.96,178.59 347.96,185.47 343.27,190.16 311.53,190.16 307.61,194.08 305.89,194.08 305.19,194.78 304.78,194.78 v1(304.31,194.31)
D10605: length 833.7
  TOP w0.086: v1(330.93,210.87) 330.46,210.4 330.46,208.18 329.35,207.06 329.35,197.86 329.43,197.78 SITE4.114
  L07_SIGNAL w0.071: v1(403.5,129.1) 403.97,129.57 403.97,130.17 403.52,130.63 402.62,130.63 401.78,129.78 401.78,127.27 402.89,126.15 424.35,126.15 435.44,115.06 513.67,115.06 520.31,108.42 520.31,49.41 519.53,48.64 465.95,48.64 465.78,48.46 465.78,47.83 466.05,47.56 519.66,47.56 520.12,47.1 520.12,46.24 519.58,45.69 442.09,45.69 441.79,45.4 441.79,44.92 442.21,44.51 495.35,44.51 495.81,44.05 495.81,43.4 495.05,42.65 441.03,42.65 440.22,43.46 440.22,53.14 426.67,66.69 426.67,85.71 420.1,92.27 380.32,92.27 375.37,87.32 375.37,74.38 377.65,72.1 393.3,72.1 394.66,73.47 394.66,74.55 394.04,75.13 392.23,75.13 D106.05
  L30_SIGNAL w0.071: v1(330.93,210.87) 330.46,210.4 330.46,203.29 346.84,186.9 353.69,186.9 359.47,181.12 395.32,181.12 398.7,177.74 398.7,146.26 402.3,142.66 412.68,142.66 414.37,144.35 419.12,144.35 420.76,142.71 420.76,138.95 418.5,136.7 402.67,136.7 400.84,134.86 400.84,127.24 401.62,126.45 403.4,126.45 403.98,127.04 403.98,128.61 v1(403.5,129.1)
D10606: length 833.7
  TOP w0.086: SITE4.135 317.68,192.43 317.6,192.35 316.46,192.35 311.86,196.95 308.04,196.95 v1(307.6,197.38)
  L05_SIGNAL w0.071: D106.06 395.64,80.68 395.79,80.68 396.46,81.36 396.46,82.04 395.72,82.78 379.6,82.78 378.21,84.18 378.21,88.74 382.2,92.73 422.35,92.73 431.52,83.55 431.52,55.04 456.2,30.36 546.14,30.36 553.53,37.76 553.53,206.5 550.28,209.75 494.29,209.75 493.36,208.81 493.36,207.43 494.05,206.74 508.2,206.74 508.7,206.24 508.7,205.07 508.25,204.62 486.54,204.62 485.48,203.57 451.32,203.57 449.08,201.33 449.08,149.33 426.1,126.35 416.34,126.35 414.03,128.67 414.03,145.77 410,149.79 410,171.47 408.29,173.18 408.29,173.96 v1(407.82,174.43)
  L32_SIGNAL w0.071: v1(407.82,174.43) 408.29,173.96 408.29,172.79 407.97,172.47 405.75,172.47 401.56,176.65 362.95,176.65 342.69,196.91 308.07,196.91 v1(307.6,197.38)
D10607: length 833.7
  TOP w0.086: SITE4.115 329.03,197.78 329.11,197.86 329.11,207.16 330.22,208.28 330.22,210.43 v1(329.79,210.87)
  L07_SIGNAL w0.071: v1(404.64,129.1) 404.17,129.57 404.17,130.25 403.6,130.83 402.54,130.83 401.58,129.87 401.58,127.19 402.81,125.96 424.26,125.96 435.36,114.86 513.59,114.86 520.11,108.34 520.11,49.49 519.45,48.83 465.87,48.83 465.58,48.54 465.58,47.75 465.97,47.36 519.58,47.36 519.92,47.02 519.92,46.32 519.5,45.89 442.01,45.89 441.59,45.48 441.59,44.84 442.12,44.31 495.27,44.31 495.61,43.97 495.61,43.49 494.97,42.85 441.11,42.85 440.42,43.54 440.42,53.22 426.86,66.77 426.86,85.79 420.18,92.47 380.24,92.47 375.17,87.4 375.17,74.3 377.57,71.9 393.38,71.9 394.86,73.38 394.86,74.82 D106.07
  L30_SIGNAL w0.071: v1(329.79,210.87) 330.26,210.4 330.26,203.2 346.76,186.7 353.61,186.7 359.39,180.92 395.23,180.92 398.5,177.66 398.5,146.18 402.21,142.47 412.76,142.47 414.45,144.16 419.03,144.16 420.56,142.63 420.56,139.04 418.42,136.9 402.59,136.9 400.64,134.94 400.64,127.15 401.54,126.25 403.48,126.25 404.18,126.95 404.18,128.64 v1(404.64,129.1)
D10608: length 833.7
  TOP w0.086: SITE4.136 317.68,192.03 317.6,192.11 316.36,192.11 311.76,196.71 308.07,196.71 v1(307.6,196.24)
  L05_SIGNAL w0.071: v1(408.96,174.43) 408.49,173.96 408.49,173.26 410.2,171.55 410.2,149.87 414.22,145.85 414.22,128.75 416.42,126.55 426.02,126.55 448.88,149.41 448.88,201.42 451.23,203.77 485.4,203.77 486.45,204.82 508.17,204.82 508.5,205.16 508.5,206.16 508.11,206.54 493.97,206.54 493.16,207.35 493.16,208.9 494.21,209.95 550.36,209.95 553.73,206.58 553.73,37.68 546.22,30.17 456.12,30.17 431.32,54.96 431.32,83.47 422.27,92.53 382.28,92.53 378.41,88.66 378.41,84.26 379.69,82.98 395.8,82.98 396.66,82.12 396.66,80.86 D106.08
  L32_SIGNAL w0.071: v1(408.96,174.43) 408.49,173.96 408.49,172.71 408.05,172.27 405.66,172.27 401.48,176.46 362.86,176.46 342.61,196.71 308.07,196.71 v1(307.6,196.24)
D10609: length 833.7
  TOP w0.086: SITE4.126 324.63,197.78 324.55,197.86 324.55,199.62 320.83,203.34 320.83,208.7 v1(321.28,209.15)
  L07_SIGNAL w0.071: v1(416.71,142.68) 417.18,143.16 417.18,143.61 417.84,144.27 420.1,144.27 443.48,120.89 518.93,120.89 524.86,114.95 524.86,29.86 523.25,28.25 459.28,28.25 458.86,27.83 458.86,27.25 459.29,26.82 518.31,26.82 518.84,26.3 518.84,25.67 518.29,25.12 438.82,25.12 438.4,24.7 438.4,24.2 439.04,23.56 519.18,23.56 519.51,23.23 519.51,22.53 518.79,21.82 439.38,21.82 436.22,24.97 436.22,50.94 424.1,63.06 424.1,68.89 420.97,72.02 404.16,72.02 403.41,72.76 403.41,74.11 D106.09
  L30_SIGNAL w0.071: v1(321.28,209.15) 320.81,208.68 320.81,156.64 325.48,151.97 329.66,151.97 333.56,155.86 359.5,155.86 363.54,151.83 377.21,151.83 388.06,140.97 416.32,140.97 417.18,141.83 417.18,142.21 v1(416.71,142.68)
D10610: length 833.7
  TOP w0.086: SITE4.129 323.43,197.78 323.35,197.86 323.35,199.29 318.85,203.79 318.85,210.43 v1(319.3,210.88)
  L05_SIGNAL w0.071: v1(416.71,129.1) 417.18,128.62 417.18,128.19 417.71,127.67 424.53,127.67 426.94,130.08 426.94,139.47 447.87,160.4 447.87,203.17 451.05,206.35 471.35,206.35 474.13,209.13 491.02,209.13 493.33,211.45 540.68,211.45 541.4,212.16 541.4,213.55 540.72,214.23 534.66,214.23 533.27,215.63 533.27,217.64 534.59,218.96 553.07,218.96 555.91,216.13 555.91,36.08 548.58,28.76 455.62,28.76 429.82,54.56 429.82,76.22 423.02,83.02 407.18,83.02 406.67,82.51 406.67,80.94 405.68,79.95 405.07,79.95 D106.10
  L32_SIGNAL w0.071: v1(319.3,210.88) 318.83,211.35 318.83,212.23 327.12,220.51 346.58,220.51 347.35,219.74 379.05,219.74 380.17,220.86 404.34,220.86 405.89,219.32 419.72,219.32 434.95,204.09 434.95,140.66 428.78,134.49 420.85,134.49 417.18,130.82 417.18,129.57 v1(416.71,129.1)
D10611: length 833.7
  TOP w0.086: v1(320.14,209.15) 320.59,208.7 320.59,203.24 324.31,199.52 324.31,197.86 324.23,197.78 SITE4.127
  L07_SIGNAL w0.071: D106.11 405.35,75.15 404.7,75.15 403.61,74.06 403.61,72.85 404.24,72.22 421.05,72.22 424.3,68.97 424.3,63.14 436.41,51.02 436.41,25.06 439.46,22.01 518.71,22.01 519.31,22.62 519.31,23.15 519.1,23.36 438.96,23.36 438.2,24.12 438.2,24.78 438.74,25.32 518.21,25.32 518.64,25.75 518.64,26.22 518.23,26.63 459.21,26.63 458.66,27.17 458.66,27.91 459.2,28.45 523.16,28.45 524.66,29.95 524.66,114.87 518.85,120.69 443.4,120.69 424.54,139.55 420.02,144.07 417.93,144.07 417.38,143.52 417.38,143.16 v1(417.85,142.68)
  L30_SIGNAL w0.071: v1(417.85,142.68) 417.38,142.21 417.38,141.75 416.4,140.77 387.98,140.77 377.13,151.63 363.45,151.63 359.42,155.67 333.65,155.67 329.75,151.77 325.4,151.77 320.61,156.55 320.61,208.68 v1(320.14,209.15)
D10612: length 833.7
  TOP w0.086: v1(318.16,210.88) 318.61,210.43 318.61,203.69 323.11,199.19 323.11,197.86 323.03,197.78 SITE4.130
  L05_SIGNAL w0.071: v1(417.85,129.1) 417.38,128.62 417.38,128.28 417.79,127.86 424.44,127.86 426.74,130.16 426.74,139.56 447.67,160.49 447.67,203.25 450.97,206.55 471.27,206.55 474.04,209.33 490.93,209.33 493.25,211.65 540.6,211.65 541.2,212.24 541.2,213.47 540.64,214.03 534.58,214.03 533.07,215.54 533.07,217.72 534.51,219.16 553.16,219.16 556.11,216.21 556.11,36 548.66,28.56 455.54,28.56 429.62,54.47 429.62,76.14 422.94,82.82 407.26,82.82 406.87,82.43 406.87,80.86 408.94,78.79 D106.12
  L32_SIGNAL w0.071: v1(417.85,129.1) 417.38,129.57 417.38,130.74 420.93,134.29 428.87,134.29 435.15,140.58 435.15,204.17 419.8,219.52 405.97,219.52 404.43,221.06 380.09,221.06 378.97,219.94 347.44,219.94 346.66,220.71 327.03,220.71 318.63,212.31 318.63,211.35 v1(318.16,210.88)
D10613: length 833.7
  TOP w0.086: SITE4.87 343.98,192.83 344.06,192.91 344.57,192.91 349.88,198.23 355.83,198.23 v1(356.24,197.81)
  L07_SIGNAL w0.071: v1(409.34,220.41) 409.81,220.88 409.81,221.74 410.55,222.48 413.52,222.48 414.2,221.8 414.2,176.28 412.16,174.24 412.16,143.86 437.17,118.85 517.4,118.85 523.09,113.16 523.09,39.72 521.63,38.26 484.67,38.26 484.24,37.83 484.24,36.79 484.64,36.4 522.98,36.4 523.44,35.94 523.44,34.94 522.76,34.25 440.33,34.25 439.8,33.73 439.8,33.08 440.29,32.59 523.18,32.59 523.74,32.02 523.74,31.02 522.44,29.72 439.87,29.72 439.45,29.3 439.45,28.62 439.81,28.27 457.2,28.27 457.78,27.69 457.78,26.6 457.32,26.14 438.63,26.14 437.43,27.34 437.43,51.72 425.18,63.98 425.18,69.12 421.74,72.56 414.08,72.56 413.54,73.1 413.54,74.14 D106.13
  L30_SIGNAL w0.071: v1(356.24,197.81) 356.72,198.28 362.95,198.28 363.85,199.18 376.1,199.18 379.88,195.39 379.88,190.79 380.51,190.16 386.08,190.16 388.83,192.9 388.83,206.13 387.14,207.82 387.14,209.63 389.74,212.23 403.31,212.23 406.57,215.5 406.57,222.52 407.28,223.23 408.72,223.23 409.81,222.14 409.81,220.88 v1(409.34,220.41)
D10614: length 833.7
  TOP w0.086: v1(343.79,208.93) 343.34,208.49 343.34,204.27 337.75,198.68 337.75,197.86 337.83,197.78 SITE4.93
  L05_SIGNAL w0.071: v1(421.53,144.08) 422,143.61 422,142.71 422.81,141.9 424.82,141.9 446,163.08 446,204.38 449.61,207.99 471.17,207.99 473.77,210.58 491.18,210.58 493.99,213.39 529.1,213.39 530.65,214.94 530.65,216.67 529.24,218.07 486.9,218.07 485.82,219.15 485.82,220.39 487.14,221.71 557.42,221.71 559.97,219.16 559.97,33.78 552.22,26.03 454.49,26.03 427.5,53.03 427.5,75.92 420.93,82.48 417.26,82.48 416.86,82.08 416.86,80.99 416.25,80.39 415.67,80.39 D106.14
  L32_SIGNAL w0.071: v1(343.79,208.93) 343.31,209.4 343.31,211.69 347.22,215.59 369.91,215.59 371.28,214.22 415.42,214.22 427.98,201.66 427.98,151.53 422.01,145.55 422.01,144.56 v1(421.53,144.08)
D10615: length 833.7
  TOP w0.086: SITE4.88 343.98,193.23 344.06,193.15 344.47,193.15 349.78,198.47 355.76,198.47 v1(356.24,198.95)
  L07_SIGNAL w0.071: v1(410.48,220.41) 410.01,220.88 410.01,221.66 410.63,222.28 413.44,222.28 414,221.72 414,176.36 411.96,174.32 411.96,143.78 437.08,118.65 517.32,118.65 522.89,113.08 522.89,39.8 521.55,38.46 484.59,38.46 484.04,37.91 484.04,36.71 484.55,36.2 522.9,36.2 523.24,35.86 523.24,35.02 522.67,34.45 440.24,34.45 439.6,33.81 439.6,32.99 440.21,32.39 523.1,32.39 523.55,31.94 523.55,31.11 522.36,29.92 439.79,29.92 439.25,29.38 439.25,28.54 439.72,28.07 457.12,28.07 457.58,27.61 457.58,26.68 457.24,26.34 438.71,26.34 437.63,27.42 437.63,51.8 425.38,64.06 425.38,69.2 421.83,72.75 414.17,72.75 413.73,73.19 413.73,74.48 414.41,75.16 415.52,75.16 D106.15
  L30_SIGNAL w0.071: v1(356.24,198.95) 356.72,198.48 362.87,198.48 363.77,199.37 376.18,199.37 380.08,195.48 380.08,190.87 380.59,190.36 386,190.36 388.63,192.99 388.63,206.05 386.94,207.74 386.94,209.71 389.66,212.43 403.23,212.43 406.38,215.58 406.38,222.61 407.2,223.43 408.8,223.43 410.01,222.22 410.01,220.88 v1(410.48,220.41)
D10616: length 833.7
  TOP w0.086: v1(342.64,208.93) 343.1,208.47 343.1,204.37 337.51,198.78 337.51,197.86 337.43,197.78 SITE4.94
  L05_SIGNAL w0.071: D106.16 417.06,80.78 417.06,80.88 417.06,82 417.34,82.29 420.85,82.29 427.3,75.84 427.3,52.94 454.41,25.83 552.31,25.83 560.17,33.7 560.17,219.24 557.5,221.91 487.06,221.91 485.62,220.47 485.62,219.07 486.82,217.87 529.16,217.87 530.45,216.59 530.45,215.02 529.02,213.59 493.91,213.59 491.1,210.78 473.68,210.78 471.09,208.18 449.53,208.18 445.8,204.46 445.8,163.17 424.74,142.1 422.89,142.1 422.2,142.79 422.2,143.61 v1(422.68,144.08)
  L32_SIGNAL w0.071: v1(422.68,144.08) 422.21,144.55 422.21,145.47 428.18,151.44 428.18,201.75 415.51,214.42 371.37,214.42 369.99,215.79 347.14,215.79 343.12,211.77 343.12,209.4 v1(342.64,208.93)
D10701: length 833.7
  TOP w0.086: SITE4.89 339.43,197.78 339.35,197.86 339.35,198.16 345.32,204.13 345.32,205.52 347.21,207.41 347.21,208.5 v1(347.64,208.93)
  L05_SIGNAL w0.071: v1(409.34,206.82) 409.81,207.29 409.81,208.17 410.39,208.74 414.55,208.74 418.39,212.58 418.39,222.27 441.26,245.14 504.89,245.14 505.43,245.68 505.43,247.03 504.89,247.57 451.47,247.57 450.17,248.87 450.17,251.19 451.56,252.58 566.49,252.58 570.71,248.36 570.71,18.03 561.89,9.21 453.58,9.21 419.73,43.06 386.58,43.06 383.11,46.53 383.11,53.77 D107.01
  L32_SIGNAL w0.071: v1(347.64,208.93) 347.17,209.4 347.17,211.08 347.69,211.59 363.28,211.59 364.3,212.61 405.73,212.61 409.81,208.53 409.81,207.29 v1(409.34,206.82)
D10702: length 833.7
  TOP w0.086: SITE4.124 325.43,197.78 325.35,197.86 325.35,200.75 322.73,203.37 322.73,210.45 v1(323.16,210.88)
  L07_SIGNAL w0.071: v1(394.35,160.85) 394.83,160.37 394.83,159.83 396.4,158.26 396.4,141.72 394.82,140.14 394.82,128.26 395.46,127.62 395.46,122.46 396.38,121.53 413.87,121.53 430.15,105.25 508.56,105.25 517.36,96.45 517.36,68.8 516.71,68.15 448.6,68.15 447.87,67.42 447.87,66.54 448.67,65.75 517.22,65.75 517.61,65.35 517.61,64.46 516.97,63.83 439.51,63.83 438.55,62.87 438.55,61.98 439.68,60.85 504.57,60.85 505.55,59.87 505.55,58.71 504.51,57.66 440.66,57.66 431.19,67.13 431.19,87.99 424.12,95.06 379.04,95.06 371.97,87.99 371.97,67.56 377.65,61.88 385.8,61.88 386.39,61.29 386.39,60.69 385.87,60.17 385.29,60.17 D107.02
  L30_SIGNAL w0.071: v1(323.16,210.88) 322.69,210.41 322.69,192.54 325.23,189.99 325.23,175.17 328.31,172.1 357.67,172.1 360.7,169.06 388.65,169.06 391.47,166.25 391.47,160.04 392.76,158.75 394.29,158.75 394.83,159.29 394.83,160.37 v1(394.35,160.85)
D10703: length 833.7
  TOP w0.086: SITE4.90 339.03,197.78 339.11,197.86 339.11,198.26 345.08,204.23 345.08,205.62 346.97,207.51 346.97,208.46 v1(346.5,208.93)
  L05_SIGNAL w0.071: D107.03 384.65,54.45 384.01,54.45 383.31,53.75 383.31,46.61 386.66,43.26 419.81,43.26 453.66,9.41 561.81,9.41 570.52,18.11 570.52,248.27 566.41,252.38 451.64,252.38 450.37,251.11 450.37,248.95 451.55,247.77 504.97,247.77 505.63,247.11 505.63,245.6 504.97,244.94 441.34,244.94 418.58,222.19 418.58,212.49 414.64,208.55 410.47,208.55 410.01,208.08 410.01,207.29 v1(410.48,206.82)
  L32_SIGNAL w0.071: v1(410.48,206.82) 410.01,207.29 410.01,208.61 405.81,212.81 364.22,212.81 363.2,211.79 347.61,211.79 346.97,211.16 346.97,209.4 v1(346.5,208.93)
D10704: length 833.7
  TOP w0.086: v1(322.02,210.88) 322.49,210.41 322.49,203.28 325.11,200.65 325.11,197.86 325.03,197.78 SITE4.125
  L07_SIGNAL w0.071: v1(395.5,160.85) 395.03,160.37 395.03,159.91 396.6,158.34 396.6,141.64 395.02,140.06 395.02,128.34 395.66,127.7 395.66,122.54 396.47,121.73 413.95,121.73 430.24,105.45 508.64,105.45 517.56,96.53 517.56,68.72 516.79,67.95 448.68,67.95 448.07,67.34 448.07,66.62 448.75,65.95 517.3,65.95 517.81,65.44 517.81,64.38 517.05,63.63 439.59,63.63 438.75,62.79 438.75,62.06 439.77,61.05 504.66,61.05 505.75,59.96 505.75,58.62 504.59,57.46 440.57,57.46 430.99,67.05 430.99,87.91 424.04,94.86 379.12,94.86 372.17,87.9 372.17,67.64 377.73,62.08 385.88,62.08 386.59,61.37 386.59,60.45 D107.04
  L30_SIGNAL w0.071: v1(395.5,160.85) 395.02,160.37 395.02,159.21 394.37,158.55 392.68,158.55 391.27,159.96 391.27,166.16 388.57,168.87 360.62,168.87 357.59,171.9 328.22,171.9 325.03,175.09 325.03,189.91 322.49,192.45 322.49,210.41 v1(322.02,210.88)
D10705: length 833.7
  TOP w0.086: v1(338,207.21) 337.55,206.76 337.55,204.67 334.95,202.07 334.95,197.86 335.03,197.78 SITE4.100
  L05_SIGNAL w0.071: v1(426.4,182.99) 426.87,182.52 431.72,182.52 437.34,188.14 437.34,235.33 442.64,240.63 484.39,240.63 485.02,240 502.91,240 508.12,245.21 550.25,245.21 551.01,245.98 551.01,246.77 550.27,247.51 508.37,247.51 507.74,248.14 507.74,249.16 508.56,249.99 563.9,249.99 568.61,245.28 568.61,19.36 560.18,10.94 455.23,10.94 421.01,45.15 397.59,45.15 393.44,49.3 393.44,53.6 D107.05
  L32_SIGNAL w0.071: v1(338,207.21) 337.53,206.74 337.53,201.61 339.26,199.88 344.12,199.88 350.99,193.01 357.54,193.01 359.63,190.93 360.86,190.93 362.13,192.2 372.95,192.2 374.85,190.29 392.01,190.29 393.71,192 415.23,192 424.72,182.52 425.93,182.52 v1(426.4,182.99)
D10706: length 833.7
  TOP w0.086: v1(356.24,190.09) 355.8,190.53 350.02,190.53 349.2,189.71 344.06,189.71 343.98,189.63 SITE4.79
  L07_SIGNAL w0.071: v1(408.07,157.67) 408.54,157.2 408.54,156.01 398.61,146.07 398.61,125.65 400.48,123.77 414.39,123.77 430.31,107.86 483,107.86 483.68,108.54 483.68,109.37 482.93,110.12 438.26,110.12 437.32,111.06 437.32,112.09 438.32,113.1 511.76,113.1 518.88,105.98 518.88,63.66 516.71,61.49 510.39,61.49 507.29,58.39 507.29,56.67 506.42,55.8 444.13,55.8 443.21,54.88 443.21,53.24 444.13,52.32 518.36,52.32 518.91,51.76 518.91,51.09 518.36,50.53 443.81,50.53 443.01,49.73 443.01,49.17 443.72,48.46 464.16,48.46 464.5,48.12 464.5,47.5 464.02,47.03 442.74,47.03 441.8,47.97 441.8,53.83 428.71,66.93 428.71,87.16 422.24,93.63 379.9,93.63 373.31,87.04 373.31,68.71 379.51,62.51 395.9,62.51 396.52,61.9 396.52,61.19 394.8,59.47 394.75,59.47 D107.06
  L30_SIGNAL w0.071: v1(356.24,190.09) 356.72,190.56 360.96,190.56 364.01,187.51 367.44,187.51 370.8,184.16 400.14,184.16 403.03,181.26 403.03,163.46 406.43,160.06 407.87,160.06 408.54,159.38 408.54,158.14 v1(408.07,157.67)
D10707: length 833.7
  TOP w0.086: v1(336.85,207.21) 337.31,206.76 337.31,204.77 334.71,202.17 334.71,197.86 334.63,197.78 SITE4.101
  L05_SIGNAL w0.071: v1(426.4,181.84) 426.87,182.32 431.8,182.32 437.54,188.05 437.54,235.25 442.72,240.43 484.31,240.43 484.94,239.8 502.99,239.8 508.21,245.01 550.33,245.01 551.21,245.89 551.21,246.85 550.35,247.71 508.45,247.71 507.94,248.22 507.94,249.08 508.65,249.79 563.82,249.79 568.41,245.2 568.41,19.45 560.1,11.14 455.31,11.14 421.1,45.35 397.67,45.35 393.64,49.38 393.64,54.19 393.96,54.51 394.87,54.51 D107.07
  L32_SIGNAL w0.071: v1(336.85,207.21) 337.33,206.74 337.33,201.53 339.18,199.68 344.04,199.68 350.91,192.82 357.46,192.82 359.55,190.73 360.94,190.73 362.21,192 372.87,192 374.77,190.1 392.09,190.1 393.79,191.8 415.15,191.8 424.63,182.32 425.93,182.32 v1(426.4,181.84)
D10708: length 833.7
  TOP w0.086: SITE4.80 343.98,190.03 344.06,189.95 349.1,189.95 349.92,190.77 355.78,190.77 v1(356.24,191.23)
  L07_SIGNAL w0.071: D107.08 396.72,60.48 396.72,61.98 395.98,62.71 379.59,62.71 373.51,68.79 373.51,86.96 379.98,93.43 422.15,93.43 428.51,87.08 428.51,66.85 441.61,53.75 441.61,47.89 442.66,46.83 464.1,46.83 464.69,47.42 464.69,48.2 464.24,48.66 443.8,48.66 443.21,49.25 443.21,49.65 443.9,50.34 518.44,50.34 519.11,51 519.11,51.85 518.44,52.51 444.21,52.51 443.41,53.32 443.41,54.8 444.21,55.6 506.51,55.6 507.49,56.59 507.49,58.31 510.47,61.29 516.8,61.29 519.08,63.57 519.08,106.06 511.84,113.3 438.24,113.3 437.12,112.17 437.12,110.98 438.17,109.93 482.85,109.93 483.49,109.29 483.49,108.62 482.92,108.05 430.39,108.05 414.47,123.97 400.56,123.97 398.81,125.73 398.81,145.99 408.74,155.92 408.74,157.2 v1(409.21,157.67)
  L30_SIGNAL w0.071: v1(409.21,157.67) 408.74,158.14 408.74,159.46 407.95,160.25 406.51,160.25 403.23,163.54 403.23,181.35 400.22,184.35 370.88,184.35 367.52,187.71 364.09,187.71 361.04,190.76 356.72,190.76 v1(356.24,191.23)
