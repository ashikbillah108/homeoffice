# Allegro board 8880F5-0823_RXTX.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D10709: length 833.7
  TOP w0.086: SITE4.102 334.23,197.78 334.15,197.86 334.15,202.58 335.64,204.07 335.64,208.51 v1(336.07,208.93)
  L05_SIGNAL w0.071: D107.09 403.22,53.98 403.22,49.89 405.32,47.79 424.12,47.79 452.17,19.73 499.22,19.73 503.3,15.65 560.45,15.65 566.08,21.28 566.08,239.9 562.64,243.34 509.54,243.34 507.58,241.37 507.58,239.41 509.62,237.37 562.46,237.37 563.16,236.67 563.16,234.81 562.14,233.79 487.98,233.79 484.05,229.86 473.1,229.86 471.62,228.38 443.14,228.38 440.3,225.54 440.3,186.24 432.75,178.69 418.15,178.69 414.33,182.52 413.29,182.52 v1(412.81,182.99)
  L32_SIGNAL w0.071: v1(336.07,208.93) 335.6,208.46 335.6,202.4 338.86,199.14 343.59,199.14 350.37,192.37 357.44,192.37 359.41,190.4 361.14,190.4 362.46,191.71 367.12,191.71 369.32,189.52 404.36,189.52 405.49,188.39 405.49,184.75 407.75,182.5 412.32,182.5 v1(412.81,182.99)
D10710: length 833.7
  TOP w0.086: v1(359.29,187.66) 358.84,188.11 344.06,188.11 343.98,188.03 SITE4.75
  L07_SIGNAL w0.071: D107.10 405.96,60.52 406.02,60.52 406.66,61.16 406.66,62.27 407.11,62.71 423.68,62.71 435.6,50.79 435.6,23.12 448.76,9.96 516.47,9.96 517.55,11.04 517.55,11.93 516.96,12.51 447.42,12.51 445.58,14.35 445.58,15.43 446.86,16.7 522.9,16.7 524.03,17.84 524.03,18.85 523.13,19.75 440.31,19.75 439.81,20.26 439.81,20.8 440.3,21.29 524.96,21.29 525.84,22.17 525.84,22.83 525.36,23.31 520.85,23.31 520.03,24.13 520.03,25.14 521.14,26.25 526.09,26.25 526.96,27.12 526.96,114.55 519.53,121.98 450.77,121.98 444.44,128.31 444.44,152.51 437.85,159.1 422.1,159.1 421.5,159.71 421.5,160.37 v1(421.02,160.85)
  L30_SIGNAL w0.071: v1(359.29,187.66) 359.76,188.13 361.53,188.13 367.79,181.87 397.46,181.87 399.36,179.96 399.36,162.67 405.77,156.26 414.98,156.26 418.3,159.59 418.3,162.16 418.82,162.68 421.07,162.68 421.5,162.24 421.5,161.32 v1(421.02,160.85)
D10711: length 833.7
  TOP w0.086: v1(334.93,208.93) 335.4,208.46 335.4,204.17 333.91,202.68 333.91,197.86 333.83,197.78 SITE4.103
  L05_SIGNAL w0.071: D107.11 404.43,53.91 404.1,53.91 403.42,53.22 403.42,49.97 405.41,47.98 424.2,47.98 452.25,19.93 499.3,19.93 503.38,15.85 560.37,15.85 565.88,21.36 565.88,239.82 562.55,243.14 509.63,243.14 507.78,241.29 507.78,239.49 509.7,237.57 562.54,237.57 563.36,236.75 563.36,234.73 562.23,233.59 488.07,233.59 484.13,229.66 473.18,229.66 471.7,228.18 443.22,228.18 440.5,225.46 440.5,186.16 432.83,178.5 418.07,178.5 414.25,182.32 413.29,182.32 v1(412.81,181.84)
  L32_SIGNAL w0.071: v1(412.81,181.84) 412.36,182.3 407.67,182.3 405.3,184.67 405.3,188.3 404.28,189.32 369.23,189.32 367.04,191.52 362.54,191.52 361.23,190.2 359.33,190.2 357.36,192.17 350.28,192.17 343.51,198.94 338.77,198.94 335.4,202.32 335.4,208.46 v1(334.93,208.93)
D10712: length 833.7
  TOP w0.086: SITE4.76 343.98,188.43 344.06,188.35 358.84,188.35 v1(359.29,188.8)
  L07_SIGNAL w0.071: D107.12 406.86,60.5 406.86,62.18 407.19,62.51 423.6,62.51 435.4,50.71 435.4,23.03 448.68,9.76 516.55,9.76 517.75,10.96 517.75,12.01 517.05,12.71 447.5,12.71 445.78,14.43 445.78,15.35 446.94,16.5 522.98,16.5 524.23,17.75 524.23,18.93 523.21,19.95 440.39,19.95 440,20.34 440,20.72 440.38,21.09 525.04,21.09 526.03,22.09 526.03,22.91 525.44,23.51 520.94,23.51 520.23,24.22 520.23,25.06 521.22,26.05 526.18,26.05 527.16,27.03 527.16,114.63 519.61,122.18 450.85,122.18 444.64,128.4 444.64,152.59 437.93,159.3 422.18,159.3 421.7,159.79 421.7,160.37 v1(422.17,160.85)
  L30_SIGNAL w0.071: v1(422.17,160.85) 421.7,161.31 421.7,162.32 421.15,162.87 418.74,162.87 418.11,162.24 418.11,159.67 414.9,156.46 405.86,156.46 399.56,162.76 399.56,180.05 397.54,182.06 367.87,182.06 361.61,188.33 359.76,188.33 v1(359.29,188.8)
D10713: length 833.7
  TOP w0.086: SITE4.91 338.63,197.78 338.55,197.86 338.55,198.23 344.35,204.04 344.35,205.37 345.28,206.31 345.28,206.78 v1(345.72,207.21)
  L05_SIGNAL w0.071: D107.13 412.79,54.57 412.79,52.34 416.28,48.86 427.4,48.86 453.57,22.69 555.75,22.69 563.83,30.77 563.83,230.64 562.35,232.12 494.86,232.12 493.88,231.13 493.88,228.75 494.44,228.18 546.31,228.18 547.55,226.95 547.55,225.28 546.38,224.11 449.07,224.11 444.09,219.12 444.09,185.63 426.21,167.75 426.21,162.05 423.92,159.76 422.49,159.76 422,159.27 422,158.14 v1(421.53,157.67)
  L32_SIGNAL w0.071: v1(345.72,207.21) 345.24,206.74 345.24,200.23 349.01,196.47 357.38,196.47 360.61,199.7 420.47,199.7 427.29,192.87 427.29,154.49 426.35,153.55 424.45,153.55 422,155.99 422,157.2 v1(421.53,157.67)
D10714: length 594.9
  L07_SIGNAL w0.071: v1(421.02,174.43) 421.43,174.43 421.5,174.36 421.5,172.59 430.97,163.12 437.04,163.12 447.22,152.95 447.22,128.93 453.37,122.77 520.02,122.77 528.49,114.3 528.49,19.86 516.95,8.31 448.15,8.31 434.08,22.38 434.08,49.33 421.27,62.15 416.65,62.15 416.19,61.68 416.19,60.59 D107.14
  L30_SIGNAL w0.071: v1(310.01,131.64) 310.01,135.13 309.6,135.54 307.85,135.54 305.86,137.52 305.86,140.86 307.8,142.79 313.69,142.79 317.71,146.81 339.16,146.81 340.59,148.24 344.46,148.24 350.43,142.28 350.43,140.07 353.41,137.09 355.95,137.09 357.01,138.14 388.53,138.14 401.59,125.08 416.34,125.08 426.91,135.65 426.91,167.62 421.5,173.04 421.5,173.96 v1(421.02,174.43)
D10715: length 833.7
  TOP w0.086: SITE4.92 338.23,197.78 338.31,197.86 338.31,198.33 344.11,204.13 344.11,205.47 345.04,206.4 345.04,206.74 v1(344.57,207.21)
  L05_SIGNAL w0.071: D107.15 415.66,54.98 413.91,54.98 412.99,54.07 412.99,52.42 416.36,49.06 427.49,49.06 453.65,22.89 555.67,22.89 563.63,30.85 563.63,230.56 562.27,231.92 494.95,231.92 494.08,231.05 494.08,228.83 494.52,228.38 546.39,228.38 547.75,227.03 547.75,225.2 546.46,223.91 449.15,223.91 444.29,219.04 444.29,185.54 426.41,167.67 426.41,161.97 424,159.56 422.57,159.56 422.2,159.19 422.2,158.14 v1(422.68,157.67)
  L32_SIGNAL w0.071: v1(422.68,157.67) 422.2,157.2 422.2,156.07 424.53,153.74 426.27,153.74 427.09,154.57 427.09,192.79 420.38,199.5 360.69,199.5 357.46,196.27 348.93,196.27 345.04,200.15 345.04,206.74 v1(344.57,207.21)
D10716: length 594.9
  L07_SIGNAL w0.071: v1(422.17,174.43) 421.77,174.43 421.7,174.36 421.7,172.68 431.05,163.32 437.12,163.32 447.41,153.03 447.41,129.01 453.45,122.97 520.1,122.97 528.69,114.38 528.69,19.77 517.03,8.12 448.07,8.12 433.88,22.3 433.88,49.25 421.19,61.95 416.74,61.95 416.38,61.6 416.38,60.93 417.59,59.73 417.79,59.73 D107.16
  L30_SIGNAL w0.071: v1(422.17,174.43) 421.7,173.96 421.7,173.12 427.11,167.7 427.11,135.57 416.43,124.88 401.51,124.88 388.45,137.94 357.09,137.94 356.03,136.89 353.33,136.89 350.23,139.99 350.23,142.2 344.38,148.05 340.67,148.05 339.24,146.61 317.79,146.61 313.77,142.6 307.88,142.6 306.06,140.78 306.06,137.6 307.93,135.74 309.59,135.74 310.01,136.15 v1(310.01,139.64)
D10801: length 457
  TOP w0.086: v1(314.6,158.8) 315.24,158.8 323.91,167.47 323.91,171.4 323.83,171.48 SITE4.5
  L03_SIGNAL w0.071: D108.01 382.62,33.94 382.97,33.94 383.66,33.26 383.66,30.57 382.76,29.67 376.14,29.67 373.28,32.53 373.28,115.09 385.9,127.71 385.9,187.94 388.06,190.1 388.06,195.35 387.43,195.98 387,195.98 v1(386.52,196.45)
  L28_SIGNAL w0.071: v1(314.6,158.8) 315.27,158.8 315.63,159.16 315.63,159.74 315.21,160.16 313.47,160.16 309.83,156.51 287.7,156.51 275.45,168.76 275.45,208 279.55,212.1 282.14,212.1 283.58,213.54 283.58,215.39 282.91,216.05 269.64,216.05 268.83,216.87 268.83,218.85 269.6,219.62 298.49,219.62 306.01,212.1 310.22,212.1 315.69,206.62 320.92,206.62 326.3,201.24 334.47,201.24 336.87,198.84 352.94,198.84 357.4,203.3 366.51,203.3 370.15,199.66 372.31,199.66 374.51,197.46 383.29,197.46 384.77,195.98 386.05,195.98 v1(386.52,196.45)
D10802: length 457
  TOP w0.086: v1(330.13,156.61) 329.68,157.05 329.68,161.65 328.15,163.18 328.15,171.4 328.23,171.48 SITE4.16
  L03_SIGNAL w0.071: D108.02 384.8,39.36 386.23,39.36 386.56,39.69 386.56,42.8 384.57,44.78 379.53,44.78 375.9,48.41 375.9,112.51 387.7,124.31 387.7,182.71 391.08,186.1 391.08,195.17 390.47,195.78 389.92,195.78 v1(389.45,195.31)
  L28_SIGNAL w0.071: v1(330.13,156.61) 329.66,156.13 329.66,154.83 329.19,154.36 329.19,147.38 338.9,137.67 448.12,137.67 451.38,140.93 451.38,147.41 457.83,153.85 457.83,196.05 456.57,197.3 392.75,197.3 391.23,195.78 389.92,195.78 v1(389.45,195.31)
D10803: length 457
  TOP w0.086: SITE4.6 324.23,171.48 324.15,171.4 324.15,167.37 315.41,158.63 v1(315.41,157.99)
  L03_SIGNAL w0.071: v1(386.52,195.31) 387,195.78 387.34,195.78 387.86,195.26 387.86,190.18 385.7,188.02 385.7,127.8 373.08,115.17 373.08,32.45 376.06,29.47 382.84,29.47 383.86,30.49 383.86,33.34 D108.03
  L28_SIGNAL w0.071: v1(315.41,157.99) 315.41,158.66 315.82,159.08 315.82,159.83 315.3,160.35 313.39,160.35 309.74,156.71 287.78,156.71 275.65,168.84 275.65,207.92 279.64,211.9 282.22,211.9 283.78,213.45 283.78,215.47 282.99,216.25 269.73,216.25 269.02,216.96 269.02,218.76 269.68,219.42 298.41,219.42 305.92,211.9 310.14,211.9 315.61,206.42 320.83,206.42 326.22,201.04 334.39,201.04 336.79,198.64 353.02,198.64 357.48,203.11 366.43,203.11 370.07,199.46 372.22,199.46 374.42,197.26 383.21,197.26 384.69,195.78 386.05,195.78 v1(386.52,195.31)
D10804: length 457
  TOP w0.086: SITE4.15 327.83,171.48 327.91,171.4 327.91,163.08 329.45,161.55 329.45,157.06 v1(328.99,156.61)
  L03_SIGNAL w0.071: D108.04 386.76,39.96 386.76,42.88 384.65,44.98 379.61,44.98 376.1,48.49 376.1,112.43 387.9,124.22 387.9,182.63 391.28,186.01 391.28,195.25 390.55,195.98 389.92,195.98 v1(389.45,196.45)
  L28_SIGNAL w0.071: v1(328.99,156.61) 329.46,156.13 329.46,154.91 328.99,154.44 328.99,147.3 338.82,137.47 448.2,137.47 451.58,140.85 451.58,147.32 458.03,153.77 458.03,196.13 456.65,197.5 392.67,197.5 391.14,195.98 389.92,195.98 v1(389.45,196.45)
D10805: length 413.5
  TOP w0.086: v1(305.46,173.61) 305.91,173.16 315.09,173.16 317.01,175.08 317.01,175.98 317.38,176.35 317.6,176.35 317.68,176.43 SITE4.175
  L03_SIGNAL w0.071: D108.05 392.36,34.36 392.62,34.36 393.84,33.13 393.84,26.23 397.32,22.76 397.32,12.65 398.59,11.37 439.55,11.37 440.92,10.01 440.92,6.25 439.34,4.67 373.83,4.67 370.11,8.39 370.11,116.61 383.73,130.23 383.73,161.54 383.15,162.12 382.21,162.12 381.62,161.53 381.62,161.06 v1(381.15,160.59)
  L28_SIGNAL w0.071: v1(381.15,160.59) 381.62,160.12 381.62,159.16 381.16,158.7 379.86,158.7 378.93,159.63 378.93,164.47 374.8,168.6 355.85,168.6 352.2,172.25 328.12,172.25 326.97,171.1 318.09,171.1 316.06,173.14 305.93,173.14 v1(305.46,173.61)
D10806: length 413.5
  TOP w0.086: SITE4.170 317.68,178.43 317.6,178.5 308.77,178.5 v1(308.38,178.12)
  L03_SIGNAL w0.071: v1(395.5,177.36) 395.03,177.83 395.03,178.83 394.19,179.67 393.08,179.67 389.38,175.97 389.38,120.28 388.52,119.42 388.52,112.35 389.46,111.41 389.46,103.8 390.19,103.07 391.98,103.07 392.66,103.75 392.66,112.52 393.71,113.57 393.71,116.28 392.66,117.33 392.66,145.21 391.96,145.91 391.96,166.44 392.82,167.3 395.46,167.3 396.28,166.48 396.28,141.99 395.33,141.04 395.33,118.21 397.26,116.28 397.26,111.65 396.03,110.42 396.03,100.55 393.32,97.84 387.04,97.84 378.63,89.43 378.63,51.46 380.79,49.3 393.37,49.3 395.77,46.89 395.77,40.17 D108.06
  L28_SIGNAL w0.071: v1(395.5,177.36) 395.03,176.88 395.03,176.41 393.79,175.17 390.99,175.17 387.99,178.17 369.59,178.17 368.26,176.84 361.66,176.84 360.34,178.17 344.11,178.17 343.79,177.84 339.33,177.84 338.59,178.59 308.85,178.59 v1(308.38,178.12)
D10807: length 413.5
  TOP w0.086: v1(305.46,172.46) 305.91,172.92 315.19,172.92 317.25,174.98 317.25,175.88 317.48,176.11 317.6,176.11 317.68,176.03 SITE4.176
  L03_SIGNAL w0.071: D108.07 394.04,33.36 394.04,26.32 397.52,22.84 397.52,12.73 398.68,11.57 439.64,11.57 441.12,10.09 441.12,6.17 439.42,4.48 373.74,4.48 369.91,8.31 369.91,116.69 383.53,130.31 383.53,161.46 383.07,161.92 382.29,161.92 381.82,161.45 381.82,161.06 v1(382.29,160.59)
  L28_SIGNAL w0.071: v1(305.46,172.46) 305.93,172.94 315.98,172.94 318.01,170.9 327.06,170.9 328.2,172.05 352.12,172.05 355.76,168.4 374.72,168.4 378.73,164.39 378.73,159.55 379.78,158.5 381.24,158.5 381.82,159.07 381.82,160.12 v1(382.29,160.59)
D10808: length 413.5
  TOP w0.086: v1(308.38,179.26) 308.9,178.74 317.59,178.74 317.68,178.83 SITE4.169
  L03_SIGNAL w0.071: v1(394.35,177.36) 394.83,177.83 394.83,178.74 394.1,179.47 393.16,179.47 389.58,175.89 389.58,120.2 388.72,119.34 388.72,112.44 389.66,111.49 389.66,103.88 390.27,103.27 391.9,103.27 392.47,103.84 392.47,112.61 393.52,113.66 393.52,116.19 392.47,117.24 392.47,145.12 391.76,145.83 391.76,166.52 392.74,167.5 395.54,167.5 396.48,166.56 396.48,141.91 395.53,140.96 395.53,118.29 397.46,116.36 397.46,111.57 396.23,110.34 396.23,100.47 393.4,97.64 387.12,97.64 378.82,89.35 378.82,51.54 380.87,49.5 393.45,49.5 395.97,46.97 395.97,39.85 396.31,39.52 397.36,39.52 D108.08
  L28_SIGNAL w0.071: v1(308.38,179.26) 308.85,178.79 338.67,178.79 339.41,178.04 343.71,178.04 344.03,178.37 360.42,178.37 361.75,177.04 368.18,177.04 369.5,178.37 388.07,178.37 391.07,175.37 393.71,175.37 394.83,176.49 394.83,176.88 v1(394.35,177.36)
D10809: length 413.5
  TOP w0.086: SITE4.2 322.63,171.48 322.55,171.4 322.55,171.18 322.13,170.76 314.03,170.76 313.52,170.25 308.97,170.25 v1(308.51,169.79)
  L03_SIGNAL w0.071: v1(408.96,190.94) 408.49,190.47 408.49,189.39 410.3,187.58 431.9,187.58 449.17,170.3 449.17,29.94 442.9,23.67 406.76,23.67 403.05,27.38 403.05,33.76 403.05,33.83 D108.09
  L28_SIGNAL w0.071: v1(308.51,169.79) 308.98,170.26 315.7,170.26 317.31,168.66 338.84,168.66 340.58,170.4 352.14,170.4 357.08,165.46 374.5,165.46 376.17,163.79 376.17,160.45 380.09,156.53 409.45,156.53 411.61,158.69 411.61,186.22 408.49,189.33 408.49,190.47 v1(408.96,190.94)
D10810: length 413.5
  TOP w0.086: v1(305.36,180.02) 305.84,180.5 312.15,180.5 313.34,179.31 317.6,179.31 317.68,179.23 SITE4.168
  L03_SIGNAL w0.071: D108.10 405.96,40.2 406.21,40.2 406.52,40.52 406.52,46.07 411.07,50.62 421.15,50.62 423.52,52.98 423.52,91.55 401.14,113.93 401.14,143.74 403.15,145.75 403.15,156.33 401.14,158.34 401.14,190.06 398.26,192.94 395.91,192.94 395.03,192.06 395.03,191.42 395.02,191.42 v1(395.5,190.94)
  L28_SIGNAL w0.071: v1(395.5,190.94) 395.03,190.47 395.03,189.79 394.23,188.99 368.85,188.99 368.03,188.17 362.37,188.17 360.58,189.95 358.91,189.95 357.53,188.57 355.6,188.57 347.79,196.38 310.44,196.38 300.63,206.18 286.89,206.18 286.08,205.38 282.14,205.38 281.08,204.32 281.08,170.72 287.56,164.24 301.79,164.24 303.06,165.51 303.06,182.81 303.84,183.59 307.75,183.59 308.41,182.94 308.41,181.11 307.79,180.49 305.83,180.49 v1(305.36,180.02)
D10811: length 413.5
  TOP w0.086: v1(308.51,170.93) 308.95,170.49 313.42,170.49 313.93,171 322.03,171 322.31,171.28 322.31,171.4 322.23,171.48 SITE4.1
  L03_SIGNAL w0.071: D108.11 405.06,34.22 403.69,34.22 403.25,33.78 403.25,27.46 406.84,23.86 442.82,23.86 448.98,30.02 448.98,170.22 431.81,187.38 410.21,187.38 408.29,189.31 408.29,190.47 v1(407.82,190.94)
  L28_SIGNAL w0.071: v1(308.51,170.93) 308.98,170.46 315.78,170.46 317.39,168.85 338.76,168.85 340.5,170.59 352.23,170.59 357.17,165.65 374.59,165.65 376.37,163.87 376.37,160.53 380.17,156.73 409.37,156.73 411.41,158.77 411.41,186.13 408.29,189.25 408.29,190.47 v1(407.82,190.94)
D10812: length 413.5
  TOP w0.086: SITE4.167 317.68,179.63 317.6,179.55 313.44,179.55 312.25,180.74 305.78,180.74 v1(305.36,181.16)
  L03_SIGNAL w0.071: D108.12 406.72,40.32 406.72,45.99 411.15,50.42 421.24,50.42 423.72,52.9 423.72,91.63 401.34,114.01 401.34,143.66 403.35,145.67 403.35,156.42 401.34,158.42 401.34,190.14 398.34,193.14 395.82,193.14 394.83,192.14 394.83,191.42 v1(394.35,190.94)
  L28_SIGNAL w0.071: v1(394.35,190.94) 394.83,190.47 394.83,189.87 394.15,189.19 368.77,189.19 367.95,188.37 362.45,188.37 360.67,190.15 358.83,190.15 357.45,188.77 355.68,188.77 347.87,196.58 310.52,196.58 300.72,206.38 286.8,206.38 286,205.57 282.06,205.57 280.88,204.4 280.88,170.63 287.47,164.04 301.87,164.04 303.26,165.43 303.26,182.73 303.92,183.4 307.67,183.4 308.21,182.86 308.21,181.2 307.71,180.69 305.83,180.69 v1(305.36,181.16)
D10813: length 413.5
  TOP w0.086: v1(308.4,174.39) 308.85,174.85 314.04,174.85 316.1,176.91 317.6,176.91 317.68,176.83 SITE4.174
  L03_SIGNAL w0.071: v1(408.96,177.36) 408.49,176.88 408.49,176.36 412.08,172.77 442.15,172.77 446.27,168.65 446.27,29.99 445.13,28.85 443.63,28.85 442.14,30.34 442.14,64.25 440.67,65.71 438.76,65.71 437.47,64.43 437.47,29.47 433.91,25.91 417.25,25.91 413.47,29.69 413.47,33.57 D108.13
  L28_SIGNAL w0.071: v1(408.96,177.36) 408.49,176.88 408.49,175.62 407.98,175.12 406.69,175.12 401.91,170.33 368.99,170.33 368.09,169.44 365.95,169.44 365.05,170.33 355.38,170.33 352.69,173.03 317.3,173.03 315.46,174.87 308.87,174.87 v1(308.4,174.39)
D10814: length 457
  TOP w0.086: v1(327.8,158.55) 327.35,159 327.35,171.4 327.43,171.48 SITE4.14
  L03_SIGNAL w0.071: v1(403.03,195.31) 403.51,195.78 404.72,195.78 406.77,193.72 406.77,168.76 411.72,163.82 411.72,116.3 434.25,93.77 434.25,55.01 426.58,47.35 418.69,47.35 416.73,45.38 416.73,40.05 416.32,39.64 415.56,39.64 D108.14
  L28_SIGNAL w0.071: v1(327.8,158.55) 327.33,159.02 327.33,159.27 327.65,159.6 330.83,159.6 337.3,153.12 356.58,153.12 357.88,154.42 373.09,154.42 374.39,153.12 434.59,153.12 438,156.54 438,162.02 439.98,164 442.08,164 444.11,161.97 444.11,142.79 445.59,141.31 448.68,141.31 449.71,142.34 449.71,191.47 447.18,194 402.15,194 401.7,194.45 401.7,195.3 402.17,195.78 402.56,195.78 v1(403.03,195.31)
D10815: length 413.5
  TOP w0.086: v1(308.4,175.54) 308.85,175.08 313.94,175.08 316,177.15 317.6,177.15 317.68,177.23 SITE4.173
  L03_SIGNAL w0.071: v1(407.82,177.36) 408.29,176.88 408.29,176.28 411.99,172.57 442.06,172.57 446.07,168.56 446.07,30.07 445.05,29.04 443.71,29.04 442.33,30.42 442.33,64.33 440.75,65.91 438.68,65.91 437.28,64.51 437.28,29.56 433.83,26.11 417.33,26.11 413.67,29.77 413.67,33.68 414.05,34.06 415.06,34.06 D108.15
  L28_SIGNAL w0.071: v1(407.82,177.36) 408.29,176.88 408.29,175.71 407.9,175.31 406.61,175.31 401.83,170.53 368.9,170.53 368.01,169.63 366.03,169.63 365.13,170.53 355.46,170.53 352.77,173.22 317.39,173.22 315.55,175.06 308.87,175.06 v1(308.4,175.54)
D10816: length 457
  TOP w0.086: SITE4.13 327.03,171.48 327.11,171.4 327.11,159 v1(326.65,158.55)
  L03_SIGNAL w0.071: D108.16 416.92,40.28 416.92,45.3 418.77,47.15 426.66,47.15 434.45,54.93 434.45,93.85 411.91,116.38 411.91,163.9 406.97,168.84 406.97,193.81 404.8,195.98 403.51,195.98 v1(403.03,196.45)
  L28_SIGNAL w0.071: v1(403.03,196.45) 402.56,195.98 402.09,195.98 401.5,195.39 401.5,194.37 402.07,193.8 447.1,193.8 449.51,191.39 449.51,142.42 448.6,141.51 445.67,141.51 444.31,142.87 444.31,162.05 442.16,164.2 439.9,164.2 437.8,162.1 437.8,156.62 434.51,153.32 374.48,153.32 373.18,154.62 357.8,154.62 356.5,153.32 337.39,153.32 330.91,159.8 327.57,159.8 327.13,159.36 327.13,159.02 v1(326.65,158.55)
D10901: length 413.5
  TOP w0.086: SITE2.176 317.68,236.03 317.6,236.11 317.48,236.11 317.25,235.88 317.25,234.98 315.19,232.92 305.91,232.92 v1(305.46,232.46)
  L03_SIGNAL w0.071: v1(383.31,206.31) 382.83,205.84 382.83,205.84 382.83,202.23 384.53,200.52 386.3,200.52 396.77,211 445.87,211 449.68,207.19 468.78,207.19 473.28,211.69 473.28,241.91 481.56,250.2 481.56,313.9 454.87,340.6 421.04,340.6 418.67,338.24 418.67,334.77 419.46,333.98 420.4,333.98 D109.01
  L28_SIGNAL w0.071: v1(383.31,206.31) 382.83,205.84 382.83,204.51 382.36,204.04 381.46,204.04 379.66,205.84 379.66,222.03 378.04,223.64 359.7,223.64 355.84,219.78 344.37,219.78 341.38,222.77 341.38,225.23 334.92,231.69 328.47,231.69 327.72,230.94 317.5,230.94 315.51,232.94 305.93,232.94 v1(305.46,232.46)
D10902: length 413.5
  TOP w0.086: SITE2.168 317.68,239.23 317.6,239.31 313.34,239.31 312.15,240.5 305.84,240.5 v1(305.36,240.02)
  L03_SIGNAL w0.071: D109.02 416.85,327.95 416.85,326.44 417.83,325.47 420.5,325.47 433.47,338.45 453.91,338.45 479.45,312.9 479.45,250.54 467.02,238.11 467.02,232.42 465.09,230.49 465.09,226.27 466.18,225.18 468.61,225.18 469.9,223.89 469.9,214.44 468.92,213.46 443.25,213.46 438.55,218.16 428.5,218.16 423.85,213.51 411.12,213.51 408.33,216.3 408.33,235.19 405.96,237.56 403.64,237.56 403.15,237.07 403.15,236.37 v1(403.63,235.9)
  L28_SIGNAL w0.071: v1(403.63,235.9) 403.15,235.43 403.15,234.71 402.66,234.21 401.67,234.21 400.89,234.99 400.89,237.63 396.13,242.39 387.8,242.39 379.77,234.35 354.63,234.35 346.09,242.89 344.24,242.89 342.39,241.04 338.76,241.04 337.86,241.94 324.05,241.94 323.37,242.62 321.24,242.62 320.69,242.08 313.16,242.08 311.57,240.49 305.83,240.49 v1(305.36,240.02)
D10903: length 413.5
  TOP w0.086: v1(305.46,233.61) 305.91,233.16 315.09,233.16 317.01,235.08 317.01,235.98 317.38,236.35 317.6,236.35 317.68,236.43 SITE2.175
  L03_SIGNAL w0.071: v1(382.16,206.31) 382.63,205.84 382.63,202.14 384.45,200.33 386.38,200.33 396.85,210.8 445.79,210.8 449.59,206.99 468.86,206.99 473.48,211.61 473.48,241.83 481.76,250.12 481.76,313.98 454.95,340.8 420.95,340.8 418.47,338.32 418.47,334.65 D109.03
  L28_SIGNAL w0.071: v1(305.46,233.61) 305.93,233.14 315.59,233.14 317.58,231.14 327.64,231.14 328.39,231.89 335,231.89 341.58,225.31 341.58,222.86 344.46,219.98 355.76,219.98 359.62,223.84 378.13,223.84 379.85,222.11 379.85,205.92 381.54,204.23 382.28,204.23 382.63,204.59 382.63,205.84 v1(382.16,206.31)
D10904: length 413.5
  TOP w0.086: v1(305.36,241.16) 305.78,240.74 312.25,240.74 313.44,239.55 317.6,239.55 317.68,239.63 SITE2.167
  L03_SIGNAL w0.071: D109.04 415.27,328.95 415.62,328.95 416.66,327.92 416.66,326.36 417.75,325.27 420.58,325.27 433.56,338.25 453.83,338.25 479.26,312.82 479.26,250.62 466.83,238.19 466.83,232.5 464.89,230.57 464.89,226.19 466.1,224.99 468.52,224.99 469.7,223.8 469.7,214.52 468.84,213.65 443.33,213.65 438.63,218.36 428.42,218.36 423.77,213.71 411.21,213.71 408.53,216.38 408.53,235.27 406.05,237.75 403.55,237.75 402.95,237.15 402.95,236.37 v1(402.48,235.9)
  L28_SIGNAL w0.071: v1(402.48,235.9) 402.95,235.43 402.95,234.79 402.57,234.41 401.76,234.41 401.09,235.08 401.09,237.71 396.21,242.59 387.72,242.59 379.69,234.55 354.71,234.55 346.17,243.09 344.15,243.09 342.31,241.24 338.85,241.24 337.94,242.14 324.14,242.14 323.45,242.82 321.15,242.82 320.61,242.28 313.07,242.28 311.49,240.69 305.83,240.69 v1(305.36,241.16)
D10905: length 413.5
  TOP w0.086: SITE2.174 317.68,236.83 317.6,236.91 316.1,236.91 314.04,234.85 308.85,234.85 v1(308.4,234.39)
  L03_SIGNAL w0.071: D109.05 410.1,334.12 409.43,334.12 408.32,335.23 408.32,338.98 412.36,343.02 455.7,343.02 484.37,314.36 484.37,214.55 479.72,209.9 474.8,209.9 469.39,204.49 397.13,204.49 396.3,205.33 396.3,206.09 v1(396.77,206.57)
  L28_SIGNAL w0.071: v1(396.77,206.57) 396.29,206.09 396.29,205.15 395.8,204.66 394.66,204.66 393.21,206.1 393.21,209.95 390.37,212.8 382.17,212.8 381.07,213.9 381.07,223.16 374.58,229.65 338.58,229.65 335.35,232.88 318.3,232.88 316.32,234.87 308.87,234.87 v1(308.4,234.39)
D10906: length 413.5
  TOP w0.086: SITE2.170 317.68,238.43 317.6,238.5 308.77,238.5 v1(308.38,238.12)
  L03_SIGNAL w0.071: v1(403.63,222.31) 403.15,222.79 403.15,224.22 399.96,227.41 399.96,237.64 401.82,239.49 407.12,239.49 411.61,235 411.61,223.73 414.81,220.53 443.81,220.53 448.31,225.03 448.31,303.05 451.47,306.21 468,306.21 472.1,310.31 472.1,316.17 465.34,322.93 445.01,322.93 438.86,316.78 438.86,312.13 436.11,309.37 419.87,309.37 406.57,322.66 406.57,327.83 D109.06
  L28_SIGNAL w0.071: v1(403.63,222.31) 403.15,221.84 403.15,219.87 402.09,218.8 400.56,218.8 399.62,219.74 399.62,221 397.82,222.8 395.6,222.8 394.48,221.68 394.48,219.01 392.06,216.6 387.69,216.6 385.91,218.38 385.91,226.91 379.51,233.31 342.93,233.31 337.65,238.59 308.85,238.59 v1(308.38,238.12)
D10907: length 413.5
  TOP w0.086: SITE2.173 317.68,237.23 317.6,237.15 316,237.15 313.94,235.08 308.85,235.08 v1(308.4,235.54)
  L03_SIGNAL w0.071: D109.07 408.12,334.46 408.12,339.06 412.28,343.22 455.79,343.22 484.57,314.44 484.57,214.47 479.8,209.7 474.89,209.7 469.48,204.29 397.05,204.29 396.1,205.24 396.1,206.09 v1(395.62,206.57)
  L28_SIGNAL w0.071: v1(308.4,235.54) 308.87,235.06 316.4,235.06 318.38,233.08 335.43,233.08 338.66,229.85 374.66,229.85 381.27,223.24 381.27,213.98 382.25,213 390.45,213 393.41,210.04 393.41,206.19 394.74,204.86 395.72,204.86 396.1,205.23 396.1,206.09 v1(395.62,206.57)
D10908: length 413.5
  TOP w0.086: SITE2.169 317.68,238.83 317.59,238.74 308.9,238.74 v1(308.38,239.26)
  L03_SIGNAL w0.071: v1(402.48,222.31) 402.95,222.79 402.95,224.13 399.76,227.32 399.76,237.72 401.73,239.69 407.2,239.69 411.81,235.08 411.81,223.81 414.89,220.73 443.73,220.73 448.11,225.11 448.11,303.13 451.39,306.41 467.92,306.41 471.9,310.39 471.9,316.09 465.26,322.73 445.09,322.73 439.06,316.7 439.06,312.04 436.19,309.17 419.78,309.17 406.38,322.58 406.38,328.05 405.27,329.15 404.91,329.15 D109.08
  L28_SIGNAL w0.071: v1(402.48,222.31) 402.95,221.84 402.95,219.95 402,219 400.64,219 399.82,219.82 399.82,221.08 397.9,223 395.52,223 394.28,221.76 394.28,219.1 391.98,216.8 387.78,216.8 386.11,218.46 386.11,226.99 379.59,233.51 343.01,233.51 337.74,238.79 308.85,238.79 v1(308.38,239.26)
D10909: length 457
  TOP w0.086: v1(327.8,218.55) 327.35,218.99 327.35,231.4 327.43,231.48 SITE2.14
  L03_SIGNAL w0.071: v1(390.16,235.65) 389.69,235.18 389.69,234.5 389.3,234.11 387.54,234.11 384.17,237.47 384.17,309.51 373.17,320.51 373.17,339.36 375.91,342.1 395.85,342.1 399.52,338.42 399.52,334.54 D109.09
  L28_SIGNAL w0.071: v1(390.16,235.65) 389.69,235.18 389.69,233.97 388.21,232.49 388.21,219.12 388.81,218.52 391.12,218.52 392.27,219.66 392.27,221.1 395.58,224.41 404.27,224.41 407.15,221.52 407.15,206.24 408.71,204.68 418.95,204.68 422.83,208.57 422.83,233.64 426.21,237.02 444.82,237.02 448.37,233.47 448.37,206.58 444.39,202.6 401.84,202.6 400.84,201.61 379.9,201.61 376.79,204.72 376.79,214.1 375.04,215.85 342.11,215.85 341.05,216.91 337.89,216.91 334.95,219.86 327.93,219.86 327.33,219.25 327.33,219.02 v1(327.8,218.55)
D10910: length 413.5
  TOP w0.086: v1(308.51,229.79) 308.97,230.25 313.52,230.25 314.03,230.76 322.13,230.76 322.55,231.18 322.55,231.4 322.63,231.48 SITE2.2
  L03_SIGNAL w0.071: D109.10 396.75,328.17 396.75,323.17 428.31,291.6 428.31,264.18 430.22,262.28 432.66,262.28 434.14,263.76 434.14,282.24 437.37,285.47 441.52,285.47 444.19,282.8 444.19,227.73 440.32,223.87 427.26,223.87 423.54,227.59 423.54,239.25 419.54,243.25 399.38,243.25 397.48,241.35 397.48,224.06 396.3,222.88 396.3,220.63 v1(396.77,220.15)
  L28_SIGNAL w0.071: v1(308.51,229.79) 308.98,230.26 315.86,230.26 317.77,228.35 335.32,228.35 338.56,225.12 338.56,223.39 343.79,218.16 356.29,218.16 360.54,222.41 377.84,222.41 379.03,221.22 379.03,205.22 381.3,202.95 398.37,202.95 402.84,207.43 402.84,210.8 401.84,211.81 400.79,211.81 398.34,214.26 398.34,216.33 396.3,218.37 396.3,219.68 v1(396.77,220.15)
D10911: length 457
  TOP w0.086: SITE2.13 327.03,231.48 327.11,231.4 327.11,219 v1(326.65,218.55)
  L03_SIGNAL w0.071: D109.11 397.78,334.28 399.1,334.28 399.32,334.5 399.32,338.34 395.76,341.9 375.99,341.9 373.37,339.27 373.37,320.59 384.37,309.59 384.37,237.56 387.62,234.31 389.22,234.31 389.49,234.59 389.49,235.18 v1(389.02,235.65)
  L28_SIGNAL w0.071: v1(326.65,218.55) 327.13,219.02 327.13,219.33 327.85,220.06 335.03,220.06 337.98,217.11 341.14,217.11 342.2,216.05 375.12,216.05 376.99,214.18 376.99,204.8 379.99,201.8 400.76,201.8 401.75,202.8 444.31,202.8 448.17,206.66 448.17,233.38 444.74,236.82 426.29,236.82 423.03,233.56 423.03,208.49 419.03,204.49 408.62,204.49 406.95,206.16 406.95,221.44 404.18,224.21 395.66,224.21 392.46,221.01 392.46,219.58 391.2,218.32 388.73,218.32 388.01,219.03 388.01,232.57 389.49,234.05 389.49,235.18 v1(389.02,235.65)
D10912: length 413.5
  TOP w0.086: v1(308.51,230.93) 308.95,230.49 313.42,230.49 313.93,231 322.03,231 322.31,231.28 322.31,231.4 322.23,231.48 SITE2.1
  L03_SIGNAL w0.071: v1(395.62,220.15) 396.1,220.63 396.1,222.96 397.28,224.14 397.28,241.43 399.3,243.45 419.62,243.45 423.74,239.33 423.74,227.67 427.34,224.07 440.24,224.07 443.99,227.82 443.99,282.72 441.43,285.27 437.46,285.27 434.34,282.16 434.34,263.68 432.74,262.08 430.13,262.08 428.12,264.1 428.12,291.52 396.55,323.08 396.55,328.01 395.67,328.89 395.01,328.89 D109.12
  L28_SIGNAL w0.071: v1(395.62,220.15) 396.1,219.68 396.1,218.29 398.14,216.25 398.14,214.18 400.71,211.61 401.75,211.61 402.65,210.72 402.65,207.51 398.29,203.15 381.38,203.15 379.23,205.3 379.23,221.31 377.92,222.61 360.46,222.61 356.2,218.36 343.87,218.36 338.75,223.48 338.75,225.2 335.4,228.55 317.85,228.55 315.94,230.46 308.98,230.46 v1(308.51,230.93)
D10913: length 457
  TOP w0.086: SITE2.10 325.83,231.48 325.75,231.4 325.75,224.32 323.1,221.66 323.1,220.24 318.42,215.56 v1(318.42,214.92)
  L03_SIGNAL w0.071: D109.13 390.17,333.73 390.17,337.41 386.47,341.12 377.86,341.12 375.56,338.82 375.56,321.68 392.92,304.32 392.92,256.83 392.19,256.1 387.68,256.1 386.71,255.13 386.71,250.95 387.53,250.14 389.18,250.14 389.69,250.65 389.69,251.43 v1(390.16,251.9)
  L28_SIGNAL w0.071: v1(318.42,214.92) 317.75,214.92 316.86,214.03 307.22,214.03 296.75,224.5 296.75,236.72 295.8,237.67 294.73,237.67 294.08,237.02 294.08,223.8 293.48,223.21 290.74,223.21 289.94,224.01 289.94,263.01 289.12,263.83 287.11,263.83 286.35,263.08 286.35,224.01 285.62,223.27 284.2,223.27 283.53,223.94 283.53,263.75 287.74,267.97 299.65,267.97 310.89,256.72 348.37,256.72 356.03,249.06 357.88,249.06 359.24,250.42 364.11,250.42 366.91,247.62 382.5,247.62 386.39,251.51 386.39,252.87 387.55,254.02 389.11,254.02 389.69,253.44 389.69,252.38 v1(390.16,251.9)
D10914: length 457
  TOP w0.086: SITE2.12 326.63,231.48 326.55,231.4 326.55,223.72 325.23,222.4 325.23,217.05 v1(325.68,216.6)
  L03_SIGNAL w0.071: D109.14 387.32,328.9 386.5,328.9 385.15,327.55 385.15,321.84 394.57,312.41 394.57,245.05 389.69,240.16 389.69,238.79 v1(390.16,238.32)
  L28_SIGNAL w0.071: v1(325.68,216.6) 325.21,216.12 325.21,215.2 327.27,213.14 332.06,213.14 333.24,211.95 362.77,211.95 364.34,210.37 371.17,210.37 372.88,208.66 372.88,201.84 375.44,199.28 476.97,199.28 478.97,201.28 483.31,201.28 484.46,202.44 484.46,246.62 474.56,256.52 426.05,256.52 418.51,248.99 418.51,237.77 412.64,231.9 398.72,231.9 394.66,235.96 394.66,239.22 393.57,240.32 390.34,240.32 389.69,239.67 389.69,238.79 v1(390.16,238.32)
D10915: length 457
  TOP w0.086: SITE2.9 325.43,231.48 325.51,231.4 325.51,224.41 322.86,221.76 322.86,220.34 318.25,215.73 v1(317.61,215.73)
  L03_SIGNAL w0.071: D109.15 387.17,333.83 389.65,333.83 389.97,334.16 389.97,337.33 386.39,340.92 377.94,340.92 375.76,338.74 375.76,321.76 393.12,304.4 393.12,256.74 392.28,255.9 387.76,255.9 386.91,255.05 386.91,251.04 387.61,250.33 389.1,250.33 389.49,250.73 389.49,251.43 v1(389.02,251.9)
  L28_SIGNAL w0.071: v1(389.02,251.9) 389.49,252.38 389.49,253.36 389.03,253.82 387.63,253.82 386.59,252.79 386.59,251.43 382.58,247.42 366.83,247.42 364.03,250.22 359.32,250.22 357.96,248.86 355.95,248.86 348.28,256.52 310.81,256.52 299.56,267.77 287.82,267.77 283.73,263.67 283.73,224.02 284.28,223.47 285.54,223.47 286.16,224.09 286.16,263.16 287.02,264.03 289.2,264.03 290.13,263.09 290.13,224.09 290.83,223.4 293.4,223.4 293.88,223.88 293.88,237.1 294.65,237.86 295.88,237.86 296.95,236.8 296.95,224.58 307.3,214.23 316.78,214.23 317.61,215.06 v1(317.61,215.73)
D10916: length 457
  TOP w0.086: SITE2.11 326.23,231.48 326.31,231.4 326.31,223.82 324.99,222.5 324.99,217.05 v1(324.54,216.6)
  L03_SIGNAL w0.071: D109.16 384.95,328.79 384.95,321.75 394.38,312.33 394.38,245.13 389.49,240.25 389.49,238.79 v1(389.02,238.32)
  L28_SIGNAL w0.071: v1(324.54,216.6) 325.01,216.12 325.01,215.12 327.19,212.94 331.97,212.94 333.16,211.75 362.68,211.75 364.26,210.17 371.08,210.17 372.68,208.58 372.68,201.75 375.35,199.08 477.05,199.08 479.05,201.08 483.39,201.08 484.66,202.35 484.66,246.7 474.64,256.72 425.96,256.72 418.31,249.07 418.31,237.85 412.56,232.1 398.8,232.1 394.86,236.04 394.86,239.3 393.65,240.51 390.26,240.51 389.49,239.75 389.49,238.79 v1(389.02,238.32)
D11001: length 833.7
  TOP w0.086: v1(359.29,255.88) 358.81,256.36 349.82,256.36 345.58,252.11 344.06,252.11 343.98,252.03 SITE2.85
  L07_SIGNAL w0.071: v1(402.48,238.32) 402.95,238.79 402.95,239.91 411.18,248.14 411.18,313.81 427.34,329.96 427.34,352.88 421.57,358.65 419.51,358.65 418.52,357.65 418.52,354.4 418.68,354.24 420.46,354.24 D110.01
  L30_SIGNAL w0.071: v1(359.29,255.88) 358.82,256.35 355.87,256.35 354.16,254.64 354.16,241.87 361.51,234.52 447.48,234.52 450.75,237.79 556.55,237.79 570.21,251.45 570.21,375.43 569.61,376.03 567.88,376.03 567.13,375.27 567.13,249.7 556.97,239.54 485.76,239.54 484.79,240.51 450.98,240.51 445.39,234.91 405.47,234.91 402.95,237.43 402.95,237.84 v1(402.48,238.32)
D11002: length 833.7
  TOP w0.086: SITE2.93 337.83,257.78 337.75,257.86 337.75,258.68 343.34,264.27 343.34,268.49 v1(343.79,268.93)
  L07_SIGNAL w0.071: v1(402.48,254.57) 402.95,254.1 402.95,253.8 404.78,251.98 404.78,249.52 402.98,247.72 398.86,247.72 393.72,242.57 393.72,231.88 396.91,228.69 433.77,228.69 444.88,217.59 444.88,162.47 465.03,142.32 547.2,142.32 571.05,166.17 571.05,265.09 537.93,298.21 454.89,298.21 451.19,294.5 451.19,266.27 419.74,234.81 401.18,234.81 398.04,237.95 398.04,242.47 400.51,244.94 404.11,244.94 408.3,249.13 408.3,318.66 417.73,328.1 417.73,337.57 416.65,338.65 416.65,348.07 D110.02
  L32_SIGNAL w0.071: v1(402.48,254.57) 402.95,254.1 402.95,253.32 402.31,252.68 381.51,252.68 380.07,254.12 380.07,258.51 377.03,261.55 356.58,261.55 354.26,259.23 345.64,259.23 343.31,261.56 343.31,268.46 v1(343.79,268.93)
D11003: length 833.7
  TOP w0.086: v1(359.29,257.02) 358.87,256.6 349.73,256.6 345.48,252.35 344.06,252.35 343.98,252.43 SITE2.86
  L07_SIGNAL w0.071: v1(403.63,238.32) 403.15,238.79 403.15,239.83 411.38,248.06 411.38,313.72 427.53,329.88 427.53,352.96 421.65,358.84 419.43,358.84 418.32,357.74 418.32,354.82 D110.03
  L30_SIGNAL w0.071: v1(359.29,257.02) 358.82,256.55 355.79,256.55 353.97,254.73 353.97,241.78 361.43,234.33 447.57,234.33 450.83,237.59 556.63,237.59 570.41,251.37 570.41,375.52 569.7,376.23 567.8,376.23 566.93,375.36 566.93,249.79 556.88,239.74 485.84,239.74 484.88,240.71 450.9,240.71 445.3,235.11 405.56,235.11 403.15,237.51 403.15,237.84 v1(403.63,238.32)
D11004: length 833.7
  TOP w0.086: SITE2.94 337.43,257.78 337.51,257.86 337.51,258.78 343.1,264.37 343.1,268.47 v1(342.64,268.93)
  L07_SIGNAL w0.071: v1(403.63,254.57) 403.15,254.1 403.15,253.88 404.98,252.06 404.98,249.43 403.06,247.52 398.95,247.52 393.92,242.49 393.92,231.96 396.99,228.89 433.86,228.89 445.08,217.67 445.08,162.56 465.12,142.52 547.11,142.52 570.85,166.25 570.85,265.01 537.85,298.01 454.98,298.01 451.39,294.42 451.39,266.18 419.82,234.61 401.09,234.61 397.84,237.87 397.84,242.56 400.43,245.14 404.03,245.14 408.1,249.21 408.1,318.74 417.53,328.18 417.53,337.49 416.46,338.57 416.46,348.08 D110.04
  L32_SIGNAL w0.071: v1(342.64,268.93) 343.12,268.46 343.12,261.48 345.56,259.03 354.34,259.03 356.66,261.35 376.94,261.35 379.87,258.43 379.87,254.04 381.43,252.48 402.4,252.48 403.15,253.23 403.15,254.1 v1(403.63,254.57)
D11005: length 833.7
  TOP w0.086: v1(356.24,253.95) 355.8,254.39 349.61,254.39 346.53,251.31 344.06,251.31 343.98,251.23 SITE2.83
  L07_SIGNAL w0.071: D110.05 408.64,355.9 408.64,359.07 403.22,364.49 382.71,364.49 376.45,358.24 376.45,327.2 397.16,306.5 397.16,257.31 401.33,253.13 402.67,253.13 402.95,252.84 402.95,252.37 402.95,252.37 v1(402.48,251.9)
  L30_SIGNAL w0.071: v1(402.48,251.9) 402.95,251.43 402.95,250.31 403.85,249.41 403.85,241.36 407.88,237.33 443.41,237.33 451.33,245.25 484.62,245.25 486.06,243.81 556.18,243.81 562.96,250.59 562.96,371.6 563.44,372.08 564.99,372.08 565.36,371.72 565.36,250.65 556.77,242.06 450.7,242.06 444.95,236.31 407.53,236.31 404.67,239.17 400.92,239.17 398.24,236.49 363.88,236.49 355.12,245.25 355.12,254.06 355.47,254.42 355.77,254.42 v1(356.24,253.95)
D11006: length 833.7
  TOP w0.086: v1(345.72,267.21) 345.28,266.78 345.28,266.31 344.35,265.37 344.35,264.04 338.55,258.23 338.55,257.86 338.63,257.78 SITE2.91
  L07_SIGNAL w0.071: D110.06 407.18,348.76 407.18,338.21 407.5,337.89 407.5,268.34 405.48,266.31 403.5,266.31 402.95,266.86 402.95,267.69 v1(402.48,268.16)
  L32_SIGNAL w0.071: v1(402.48,268.16) 402.95,268.63 402.95,268.97 403.2,269.22 419.81,269.22 442.3,246.73 442.3,106.49 455.34,93.44 517.17,93.44 526.82,83.79 526.82,37.63 522.18,32.99 456.21,32.99 436.55,52.65 436.55,214.39 426.73,224.21 426.73,256.71 417.54,265.9 386.11,265.9 381.04,270.97 346,270.97 345.24,270.21 345.24,267.69 v1(345.72,267.21)
D11007: length 833.7
  TOP w0.086: v1(356.24,255.09) 355.78,254.63 349.51,254.63 346.43,251.55 344.06,251.55 343.98,251.63 SITE2.84
  L07_SIGNAL w0.071: v1(403.63,251.9) 403.16,252.37 403.15,252.37 403.15,252.92 402.75,253.33 401.42,253.33 397.36,257.39 397.36,306.58 376.65,327.28 376.65,358.15 382.79,364.29 403.13,364.29 408.44,358.99 408.44,355.1 D110.07
  L30_SIGNAL w0.071: v1(356.24,255.09) 355.77,254.62 355.39,254.62 354.92,254.14 354.92,245.17 363.8,236.29 398.33,236.29 401,238.97 404.59,238.97 407.44,236.12 445.04,236.12 450.78,241.86 556.85,241.86 565.56,250.56 565.56,371.8 565.07,372.28 563.36,372.28 562.76,371.69 562.76,250.68 556.1,244.01 486.14,244.01 484.7,245.45 451.25,245.45 443.33,237.53 407.96,237.53 404.05,241.44 404.05,249.5 403.15,250.39 403.15,251.43 v1(403.63,251.9)
D11008: length 833.7
  TOP w0.086: SITE2.92 338.23,257.78 338.31,257.86 338.31,258.33 344.11,264.13 344.11,265.47 345.04,266.4 345.04,266.74 v1(344.57,267.21)
  L07_SIGNAL w0.071: v1(403.63,268.16) 403.15,267.69 403.15,266.94 403.58,266.51 405.39,266.51 407.3,268.42 407.3,337.81 406.98,338.13 406.98,348.63 406.29,349.32 405.06,349.32 D110.08
  L32_SIGNAL w0.071: v1(344.57,267.21) 345.04,267.69 345.04,270.3 345.92,271.17 381.12,271.17 386.19,266.1 417.62,266.1 426.93,256.79 426.93,224.29 436.75,214.47 436.75,52.74 456.29,33.19 522.1,33.19 526.62,37.72 526.62,83.7 517.08,93.24 455.26,93.24 442.1,106.4 442.1,246.65 419.73,269.02 403.28,269.02 403.15,268.89 403.15,268.63 v1(403.63,268.16)
D11009: length 833.7
  TOP w0.086: v1(339.93,268.93) 339.46,268.47 339.46,267.3 338.7,266.53 338.7,264.43 335.75,261.48 335.75,257.86 335.83,257.78 SITE2.98
  L05_SIGNAL w0.071: v1(402.48,270.32) 402.95,270.79 402.95,271.71 402.37,272.3 400.54,272.3 397.87,274.96 397.87,307.62 377.85,327.64 377.85,356.97 382.74,361.85 396.04,361.85 398.89,359 398.89,355.49 D110.09
  L32_SIGNAL w0.071: v1(402.48,270.32) 402.95,270.79 402.95,271.88 402.45,272.39 397.98,272.39 395,269.41 387.65,269.41 380.74,276.32 380.74,302.74 398.59,320.6 445.44,320.6 449.97,316.07 554.07,316.07 558.37,320.38 558.37,343.45 556.84,344.98 500.13,344.98 499.03,346.08 499.03,347.68 500.59,349.23 558.42,349.23 558.95,349.76 558.95,350.88 558.22,351.61 380.48,351.61 376.17,347.31 376.17,302.69 379.83,299.03 379.83,284.91 378,283.07 374.23,283.07 373.33,282.17 373.33,279.43 366.86,272.96 340.65,272.96 339.45,271.76 339.45,269.4 v1(339.93,268.93)
D11010: length 833.7
  TOP w0.086: SITE2.95 337.03,257.78 336.95,257.86 336.95,259.28 341.41,263.74 341.41,266.77 v1(341.86,267.21)
  L07_SIGNAL w0.071: v1(402.48,283.91) 402.95,283.44 402.95,282.76 403.87,281.84 406.05,281.84 406.42,282.21 406.42,317.06 397.47,326.02 397.47,342.17 397,342.64 397,348.74 D110.10
  L32_SIGNAL w0.071: v1(402.48,283.91) 402.95,284.38 402.95,285.03 403.22,285.29 408.33,285.29 410.76,287.72 421.16,287.72 422.75,286.13 428.75,286.13 431.74,289.11 563.31,289.11 573.71,278.71 573.71,108.7 562.84,97.83 463.03,97.83 445.17,115.69 445.17,249.96 425.56,269.57 397.32,269.57 396.65,268.89 384.63,268.89 381.81,271.72 366.74,271.72 366.18,272.28 342.6,272.28 341.38,271.07 341.38,267.69 v1(341.86,267.21)
D11011: length 833.7
  TOP w0.086: v1(338.78,268.93) 339.22,268.49 339.22,267.39 338.46,266.63 338.46,264.53 335.51,261.58 335.51,257.86 335.43,257.78 SITE2.99
  L05_SIGNAL w0.071: D110.11 398.69,355.51 398.69,358.92 395.95,361.65 382.82,361.65 378.05,356.89 378.05,327.72 398.07,307.71 398.07,275.05 400.62,272.49 402.45,272.49 403.15,271.79 403.15,270.79 v1(403.63,270.32)
  L32_SIGNAL w0.071: v1(403.63,270.32) 403.15,270.79 403.15,271.96 402.53,272.59 397.9,272.59 394.92,269.61 387.73,269.61 380.94,276.4 380.94,302.66 398.68,320.4 445.36,320.4 449.88,315.87 554.15,315.87 558.57,320.3 558.57,343.53 556.92,345.18 500.21,345.18 499.23,346.16 499.23,347.6 500.67,349.04 558.5,349.04 559.15,349.68 559.15,350.97 558.3,351.81 380.4,351.81 375.97,347.39 375.97,302.61 379.64,298.95 379.64,284.99 377.91,283.27 374.15,283.27 373.13,282.25 373.13,279.51 366.77,273.15 340.57,273.15 339.26,271.84 339.26,269.4 v1(338.78,268.93)
D11012: length 833.7
  TOP w0.086: SITE2.96 336.63,257.78 336.71,257.86 336.71,259.38 341.17,263.84 341.17,266.75 v1(340.71,267.21)
  L07_SIGNAL w0.071: D110.12 394.88,349.34 396.16,349.34 396.8,348.7 396.8,342.55 397.27,342.09 397.27,325.93 406.22,316.98 406.22,282.29 405.97,282.04 403.96,282.04 403.15,282.84 403.15,283.44 v1(403.63,283.91)
  L32_SIGNAL w0.071: v1(403.63,283.91) 403.15,284.38 403.15,284.94 403.3,285.09 408.41,285.09 410.84,287.52 421.07,287.52 422.67,285.93 428.84,285.93 431.82,288.91 563.23,288.91 573.51,278.63 573.51,108.78 562.76,98.03 463.11,98.03 445.37,115.77 445.37,250.04 425.64,269.77 397.24,269.77 396.56,269.09 384.72,269.09 381.89,271.92 366.83,271.92 366.26,272.48 342.52,272.48 341.19,271.15 341.19,267.69 v1(340.71,267.21)
D11013: length 833.7
  TOP w0.086: v1(304.31,259.31) 304.75,258.87 311.22,258.87 316.94,253.15 317.6,253.15 317.68,253.23 SITE2.133
  L07_SIGNAL w0.071: v1(402.48,286.32) 402.95,286.79 402.95,288.02 402.75,288.22 400.29,288.22 399.6,288.9 399.6,308.25 379.27,328.58 379.27,355.71 383.02,359.45 387.78,359.45 388.56,358.68 388.56,355.32 389.35,354.53 389.69,354.53 D110.13
  L32_SIGNAL w0.071: v1(402.48,286.32) 402.95,286.79 402.95,288.13 403.4,288.57 407.2,288.57 408.99,290.36 431.62,290.36 445.75,304.5 508.89,304.5 515.78,297.61 570.52,297.61 574.49,301.57 574.49,413.97 568.69,419.76 365.62,419.76 356.27,410.42 356.27,288.87 345.5,278.1 312.48,278.1 301.98,267.6 301.98,259.59 302.73,258.84 303.83,258.84 v1(304.31,259.31)
D11014: length 833.7
  TOP w0.086: v1(317.43,269.15) 316.97,268.69 316.97,264.24 322.55,258.66 322.55,257.86 322.63,257.78 SITE2.131
  L07_SIGNAL w0.071: D110.14 387.33,349.23 385.97,349.23 385.55,348.81 385.55,345.86 390.01,341.4 390.01,328.86 400.51,318.36 400.51,299.22 401.24,298.49 402.25,298.49 402.95,299.19 402.95,299.44 v1(402.48,299.91)
  L32_SIGNAL w0.071: v1(317.43,269.15) 316.95,269.62 316.95,273.76 319.35,276.16 364.67,276.16 369.01,280.51 369.01,291.88 360.28,300.61 360.28,377.57 366.18,383.47 566.86,383.47 567.4,382.93 567.4,382.49 566.95,382.04 493.01,382.04 492.49,381.52 492.49,380.1 492.97,379.62 564.41,379.62 566.21,377.82 566.21,320.41 556.04,310.24 407.64,310.24 402.95,305.56 402.95,300.38 v1(402.48,299.91)
D11015: length 833.7
  TOP w0.086: SITE2.134 317.68,252.83 317.6,252.91 316.84,252.91 311.12,258.63 304.77,258.63 v1(304.31,258.17)
  L07_SIGNAL w0.071: v1(403.63,286.32) 403.15,286.79 403.15,288.1 402.83,288.42 400.37,288.42 399.8,288.99 399.8,308.33 379.47,328.66 379.47,355.62 383.1,359.25 387.7,359.25 388.36,358.59 388.36,355.34 D110.15
  L32_SIGNAL w0.071: v1(304.31,258.17) 303.83,258.64 302.65,258.64 301.78,259.51 301.78,267.68 312.39,278.3 345.42,278.3 356.08,288.95 356.08,410.5 365.54,419.96 568.78,419.96 574.69,414.05 574.69,301.49 570.61,297.41 515.7,297.41 508.81,304.3 445.84,304.3 431.7,290.16 409.07,290.16 407.29,288.38 403.48,288.38 403.15,288.05 403.15,286.79 v1(403.63,286.32)
D11016: length 833.7
  TOP w0.086: v1(316.28,269.15) 316.73,268.71 316.73,264.14 322.31,258.56 322.31,257.86 322.23,257.78 SITE2.132
  L07_SIGNAL w0.071: v1(403.63,299.91) 403.15,299.44 403.15,299.11 402.34,298.29 401.15,298.29 400.31,299.14 400.31,318.27 389.81,328.77 389.81,341.32 385.35,345.78 385.35,348.71 D110.16
  L32_SIGNAL w0.071: v1(403.63,299.91) 403.15,300.38 403.15,305.48 407.72,310.04 556.12,310.04 566.4,320.32 566.4,377.91 564.49,379.82 493.05,379.82 492.69,380.18 492.69,381.44 493.09,381.84 567.03,381.84 567.6,382.4 567.6,383.01 566.95,383.66 366.1,383.66 360.08,377.65 360.08,300.53 368.81,291.8 368.81,280.59 364.58,276.36 319.27,276.36 316.75,273.84 316.75,269.62 v1(316.28,269.15)
D11101: length 833.7
  TOP w0.086: v1(359.29,247.66) 358.84,248.11 344.06,248.11 343.98,248.03 SITE2.75
  L07_SIGNAL w0.071: v1(416.45,286.32) 416.92,286.79 416.92,287.45 417.35,287.87 431.96,287.87 442.8,298.71 442.8,362.71 426.1,379.41 419.69,379.41 418.42,378.14 418.42,376.01 419.15,375.28 419.74,375.28 D111.01
  L30_SIGNAL w0.071: v1(416.45,286.32) 416.93,286.8 416.93,287.18 416.08,288.02 416.08,294.44 418.69,297.05 418.69,300.03 417.91,300.81 413.78,300.81 411.82,298.85 411.82,254.33 415.38,250.77 426.06,250.77 442.15,266.86 442.15,340.06 452.66,350.57 477.43,350.57 477.98,351.12 477.98,352.4 477.4,352.98 457.53,352.98 457,353.51 457,354.91 457.81,355.73 547.17,355.73 558.47,344.43 558.47,301.04 556.14,298.71 556.14,254.4 550.92,249.18 470.25,249.18 468.89,250.55 451.12,250.55 442.71,242.14 409.35,242.14 408.07,243.41 408.07,252.3 405.18,255.19 395.96,255.19 394.31,256.84 394.31,264.86 391.81,267.37 382.21,267.37 381.08,266.24 381.08,250.42 378.79,248.13 359.76,248.13 v1(359.29,247.66)
D11102: length 678.6
  L07_SIGNAL w0.071: D111.02 417.58,369.32 417.58,366.3 431.36,352.52 431.36,326.68 419.39,314.72 419.39,299.26 418.64,298.51 417.23,298.51 416.92,298.81 416.92,299.44 v1(416.45,299.91)
  L30_SIGNAL w0.071: v1(388.49,257.11) 388.49,261.45 388.42,261.52 384.28,261.52 383.77,262.03 383.77,265.49 385.23,266.95 391.43,266.95 393.54,264.83 393.54,255.81 395.71,253.65 404.94,253.65 407.65,250.94 407.65,241.6 409.18,240.07 442.37,240.07 450.26,247.95 550.83,247.95 558.49,255.62 558.49,296.97 559.27,297.74 559.27,345.16 547.34,357.09 456.86,357.09 440.69,340.92 440.69,268.45 424.81,252.57 414.64,252.57 412.89,254.31 412.89,272.26 413.88,273.24 413.88,295.03 416.92,298.08 416.92,299.44 v1(416.45,299.91)
D11103: length 833.7
  TOP w0.086: v1(359.29,248.8) 358.84,248.35 344.06,248.35 343.98,248.43 SITE2.76
  L07_SIGNAL w0.071: D111.03 418.23,375.05 418.23,378.22 419.61,379.61 426.19,379.61 443,362.79 443,298.63 432.04,287.68 417.43,287.68 417.12,287.36 417.12,286.79 v1(417.6,286.32)
  L30_SIGNAL w0.071: v1(359.29,248.8) 359.76,248.33 378.7,248.33 380.88,250.5 380.88,266.32 382.12,267.56 391.89,267.56 394.51,264.94 394.51,256.92 396.04,255.39 405.26,255.39 408.27,252.38 408.27,243.5 409.43,242.33 442.63,242.33 451.04,250.74 468.97,250.74 470.33,249.38 550.84,249.38 555.94,254.48 555.94,298.79 558.27,301.12 558.27,344.34 547.09,355.53 457.9,355.53 457.19,354.83 457.19,353.6 457.61,353.18 477.48,353.18 478.18,352.48 478.18,351.03 477.51,350.37 452.74,350.37 442.35,339.98 442.35,266.78 426.15,250.58 415.3,250.58 411.62,254.25 411.62,298.93 413.7,301.01 417.99,301.01 418.89,300.12 418.89,296.97 416.28,294.36 416.28,288.11 417.13,287.26 417.13,286.79 v1(417.6,286.32)
D11104: length 678.6
  L07_SIGNAL w0.071: v1(417.6,299.91) 417.12,299.44 417.12,298.89 417.31,298.71 418.56,298.71 419.19,299.34 419.19,314.8 431.16,326.77 431.16,352.44 417.38,366.22 417.38,369.59 417.05,369.92 414.94,369.92 D111.04
  L30_SIGNAL w0.071: v1(388.49,265.11) 388.49,261.79 388.42,261.72 384.36,261.72 383.97,262.11 383.97,265.41 385.31,266.75 391.34,266.75 393.34,264.75 393.34,255.73 395.62,253.45 404.86,253.45 407.45,250.86 407.45,241.52 409.1,239.87 442.45,239.87 450.34,247.76 550.91,247.76 558.69,255.54 558.69,296.89 559.46,297.66 559.46,345.24 547.42,357.29 456.78,357.29 440.49,341 440.49,268.54 424.73,252.77 414.72,252.77 413.09,254.4 413.09,272.18 414.07,273.16 414.07,294.95 417.12,298 417.12,299.44 v1(417.6,299.91)
D11105: length 833.7
  TOP w0.086: v1(356.24,250.09) 355.8,250.53 350.02,250.53 349.2,249.71 344.06,249.71 343.98,249.63 SITE2.79
  L07_SIGNAL w0.071: v1(416.45,284.16) 416.92,284.63 416.92,285.01 417.39,285.47 432.2,285.47 444.63,297.9 444.63,365.32 427.57,382.38 413,382.38 409.35,378.73 409.35,375.51 D111.05
  L30_SIGNAL w0.071: v1(416.45,284.16) 416.92,284.63 416.92,285.2 417.3,285.57 419.17,285.57 420.13,284.6 420.13,280.43 418.3,278.59 418.3,275.54 413.79,271.02 413.79,254.8 415.08,253.51 420.2,253.51 437.4,270.71 437.4,371 449.59,383.18 551.02,383.18 560.75,373.45 560.75,251.75 553.78,244.78 487.97,244.78 486.5,246.25 450.86,246.25 443.57,238.96 408.84,238.96 406.14,241.66 406.14,250.84 404.25,252.73 401.64,252.73 400.33,251.42 400.33,240.42 397.03,237.12 364.37,237.12 358.26,243.23 358.26,249.56 357.26,250.56 356.72,250.56 v1(356.24,250.09)
D11106: length 833.7
  TOP w0.086: SITE2.116 328.63,257.78 328.55,257.86 328.55,268.77 v1(328.93,269.15)
  L07_SIGNAL w0.071: v1(416.2,268.16) 416.67,267.69 416.67,267.17 415.93,266.43 414.63,266.43 413.99,267.07 413.99,312.11 429.76,327.88 429.76,352.53 418.1,364.2 407.25,364.2 405.94,365.5 405.94,369.38 406.24,369.68 407.78,369.68 D111.06
  L30_SIGNAL w0.071: v1(416.2,268.16) 416.67,268.63 416.67,269.56 417.12,270.01 420.89,270.01 427.99,277.1 427.99,297.73 423.31,302.4 389.65,302.4 385.24,297.99 373.58,297.99 372.07,299.49 372.07,397.82 367.59,402.31 214.24,402.31 210.53,398.59 210.53,367.27 216.27,361.52 269.12,361.52 270.28,362.68 270.28,363.4 269.63,364.05 230.63,364.05 229.99,364.68 229.99,365.72 230.54,366.27 273.87,366.27 279.39,371.79 304.34,371.79 313.73,362.4 313.73,319.36 328.18,304.92 328.18,286.24 329.59,284.83 329.59,279.95 328.46,278.82 328.46,269.62 v1(328.93,269.15)
D11107: length 833.7
  TOP w0.086: SITE2.80 343.98,250.03 344.06,249.95 349.1,249.95 349.92,250.77 355.78,250.77 v1(356.24,251.23)
  L07_SIGNAL w0.071: D111.07 407.88,374.86 407.99,374.86 409.15,376.03 409.15,378.82 412.91,382.58 427.65,382.58 444.83,365.4 444.83,297.82 432.29,285.27 417.47,285.27 417.12,284.92 417.12,284.63 v1(417.6,284.16)
  L30_SIGNAL w0.071: v1(356.24,251.23) 356.72,250.76 357.34,250.76 358.46,249.64 358.46,243.31 364.46,237.32 396.95,237.32 400.13,240.5 400.13,251.5 401.56,252.93 404.33,252.93 406.34,250.92 406.34,241.74 408.93,239.16 443.49,239.16 450.78,246.45 486.58,246.45 488.05,244.98 553.69,244.98 560.55,251.84 560.55,373.37 550.94,382.99 449.67,382.99 437.6,370.92 437.6,270.63 420.28,253.31 415,253.31 413.59,254.72 413.59,271.11 418.1,275.62 418.1,278.68 419.93,280.51 419.93,284.52 419.08,285.37 417.38,285.37 417.12,285.12 417.12,284.64 v1(417.6,284.16)
