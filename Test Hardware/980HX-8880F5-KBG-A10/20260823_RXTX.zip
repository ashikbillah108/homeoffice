# Allegro board 8880F5-0823_RXTX.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D12612: length 457
  TOP w0.086: SITE1.13 247.03,231.48 247.11,231.4 247.11,219 v1(246.65,218.55)
  L03_SIGNAL w0.071: D126.12 39.6,79.78 38.35,79.78 37.48,80.65 37.48,85.29 39.34,87.15 54.21,87.15 61.45,94.39 61.45,117.44 49.94,128.95 49.94,198.03 85.73,233.83 194.82,233.83 196.62,232.02 196.62,230.52 196.37,230.27 195.73,230.27 v1(195.26,230.74)
  L28_SIGNAL w0.071: v1(246.65,218.55) 247.13,218.07 247.13,217.56 246.77,217.2 246.09,217.2 245.71,217.59 243.47,217.59 242.38,216.5 236.74,216.5 235.37,215.13 214.6,215.13 212.49,213.02 167.41,213.02 165.61,214.81 165.61,224.86 167.03,226.28 195.25,226.28 196.93,227.95 196.93,229.52 196.18,230.27 195.73,230.27 v1(195.26,230.74)
D12613: length 457
  TOP w0.086: SITE1.10 245.83,231.48 245.75,231.4 245.75,224.32 243.1,221.66 243.1,220.24 238.42,215.56 v1(238.42,214.92)
  L03_SIGNAL w0.071: v2(178.5,229.6) 178.03,230.07 177.02,230.07 176.17,230.92 174.33,230.92 173.48,230.07 169.14,230.07 165.38,226.32 108.02,226.32 105.31,223.61 87.45,223.61 85.18,221.34 85.18,208.76 66.84,190.42 66.84,84.58 52.15,69.88 47.21,69.88 45.23,71.86 45.23,74.15 D126.13
  L28_SIGNAL w0.071: v1(238.42,214.92) 237.75,214.92 236.09,213.25 215.64,213.25 214.09,211.71 159.06,211.71 157.67,210.31 142.65,210.31 138.15,214.82 138.15,225.21 141.59,228.65 179.3,228.65 179.72,229.07 179.72,229.69 179.34,230.07 178.97,230.07 v2(178.5,229.6)
D12614: length 457
  TOP w0.086: v1(245.68,216.6) 245.23,217.05 245.23,222.4 246.55,223.72 246.55,231.4 246.63,231.48 SITE1.12
  L03_SIGNAL w0.071: v2(164.91,229.6) 165.38,230.07 166.05,230.07 166.4,230.42 166.4,231.75 165.93,232.22 131.47,232.22 128.63,229.38 87.29,229.38 73.92,216.01 73.92,209.06 54.81,189.94 54.81,128.57 64.18,119.21 64.18,94.46 54.19,84.47 48.34,84.47 46.76,82.89 46.76,79.78 D126.14
  L28_SIGNAL w0.071: v1(245.68,216.6) 245.21,216.12 245.21,214.8 242.86,212.46 217.06,212.46 214.63,210.03 159.56,210.03 158.83,209.3 136.36,209.3 131.77,213.89 131.77,230.11 135.49,233.83 165.81,233.83 166.65,233 166.65,230.86 165.85,230.07 165.38,230.07 v2(164.91,229.6)
D12615: length 457
  TOP w0.086: SITE1.9 245.43,231.48 245.51,231.4 245.51,224.41 242.86,221.76 242.86,220.34 238.25,215.73 v1(237.61,215.73)
  L03_SIGNAL w0.071: v2(178.5,230.74) 178.03,230.27 177.1,230.27 176.25,231.12 174.25,231.12 173.4,230.27 169.05,230.27 165.3,226.51 107.94,226.51 105.23,223.81 87.37,223.81 84.98,221.42 84.98,208.84 66.65,190.5 66.65,84.66 52.06,70.08 47.29,70.08 45.43,71.94 45.43,74.01 46.56,75.14 47.2,75.14 D126.15
  L28_SIGNAL w0.071: v2(178.5,230.74) 178.97,230.27 179.42,230.27 179.92,229.77 179.92,228.99 179.38,228.45 141.67,228.45 138.35,225.13 138.35,214.9 142.73,210.51 157.58,210.51 158.98,211.9 214.01,211.9 215.56,213.45 236,213.45 237.61,215.06 v1(237.61,215.73)
D12616: length 457
  TOP w0.086: v1(244.54,216.6) 244.99,217.05 244.99,222.5 246.31,223.82 246.31,231.4 246.23,231.48 SITE1.11
  L03_SIGNAL w0.071: v2(164.91,230.74) 165.38,230.27 165.97,230.27 166.2,230.5 166.2,231.67 165.85,232.02 131.55,232.02 128.71,229.18 87.37,229.18 74.12,215.93 74.12,208.98 55.01,189.86 55.01,128.66 64.37,119.29 64.37,94.37 54.27,84.27 48.42,84.27 46.95,82.8 46.95,80.08 47.2,79.83 49.71,79.83 D126.16
  L28_SIGNAL w0.071: v2(164.91,230.74) 165.38,230.27 165.77,230.27 166.45,230.94 166.45,232.91 165.73,233.63 135.57,233.63 131.97,230.03 131.97,213.97 136.44,209.5 158.74,209.5 159.48,210.23 214.55,210.23 216.97,212.65 242.78,212.65 245.01,214.89 245.01,216.12 v1(244.54,216.6)
D12701: length 833.7
  TOP w0.086: SITE1.102 254.23,257.78 254.15,257.86 254.15,262.58 255.64,264.07 255.64,268.51 v1(256.07,268.93)
  L05_SIGNAL w0.071: D127.01 13.8,54.78 15.83,54.78 16.11,54.5 16.11,51.35 15.18,50.42 12.51,50.42 11.77,51.15 11.77,100.43 25.19,113.85 25.19,274.61 58.54,307.95 151.76,307.95 155.76,311.96 282.35,311.96 293.69,300.61 293.69,295.7 298.59,290.79 320.36,290.79 323.45,287.71 323.45,286.54 v2(322.98,286.07)
  L32_SIGNAL w0.071: v1(256.07,268.93) 255.6,269.4 255.6,282.31 261.38,288.1 261.38,292.97 259.23,295.12 245.01,295.12 243.65,296.49 243.65,309.74 224.91,328.48 224.91,333.22 228.18,336.5 277.8,336.5 280.27,334.03 280.27,298.31 281.38,297.21 281.38,292.46 280.55,291.64 280.55,286.03 282.84,283.74 286.69,283.74 298.12,295.17 316.04,295.17 323.45,287.75 323.45,286.54 v2(322.98,286.07)
D12702: length 833.7
  TOP w0.086: SITE1.89 259.43,257.78 259.35,257.86 259.35,258.16 265.32,264.13 265.32,265.52 267.21,267.41 267.21,268.5 v1(267.64,268.93)
  L05_SIGNAL w0.071: D127.02 16.44,59.62 17.47,59.62 17.77,59.92 17.77,66.96 21.36,70.55 53.22,70.55 54.72,72.05 54.72,99.85 27.08,127.48 27.08,273.23 61.14,307.29 284.04,307.29 291.83,299.5 291.83,295.64 304.72,282.75 308.91,282.75 310.24,284.09 310.24,285.6 v2(309.77,286.07)
  L32_SIGNAL w0.071: v2(309.77,286.07) 310.24,286.54 310.24,287.02 309.88,287.38 308.76,287.38 299.78,278.4 299.78,275.07 298.38,273.67 280.79,273.67 280.45,273.33 280.45,271.95 280.85,271.56 299.4,271.56 299.89,271.07 299.89,270.61 299.42,270.15 280.73,270.15 280.42,269.84 280.42,269.01 280.71,268.72 298.45,268.72 298.82,268.35 298.82,267.65 298.42,267.24 280.78,267.24 280.34,266.81 280.34,266.21 280.79,265.77 297.68,265.77 298.2,265.25 298.2,264.84 297.9,264.54 280.93,264.54 280.64,264.24 280.64,263.65 281.08,263.21 298.16,263.21 298.72,262.65 298.72,261.18 297.85,260.31 282.6,260.31 279.21,263.7 279.21,276.34 274.37,281.18 264.6,281.18 263.48,280.06 263.48,272.17 264.31,271.35 266.35,271.35 267.17,270.52 267.17,269.4 v1(267.64,268.93)
D12703: length 833.7
  TOP w0.086: v1(254.93,268.93) 255.4,268.46 255.4,264.17 253.91,262.68 253.91,257.86 253.83,257.78 SITE1.103
  L05_SIGNAL w0.071: D127.03 16.31,54.41 16.31,51.27 15.26,50.22 12.42,50.22 11.58,51.07 11.58,100.51 24.99,113.93 24.99,274.69 58.46,308.15 151.67,308.15 155.67,312.15 282.43,312.15 293.89,300.7 293.89,295.78 298.68,290.99 320.45,290.99 323.65,287.79 323.65,286.54 v2(324.12,286.07)
  L32_SIGNAL w0.071: v2(324.12,286.07) 323.65,286.54 323.65,287.84 316.12,295.37 298.04,295.37 286.61,283.93 282.93,283.93 280.75,286.11 280.75,291.56 281.58,292.38 281.58,297.29 280.47,298.4 280.47,334.11 277.88,336.7 228.1,336.7 224.71,333.31 224.71,328.39 243.45,309.65 243.45,296.4 244.93,294.92 259.15,294.92 261.19,292.88 261.19,288.19 255.4,282.4 255.4,269.4 v1(254.93,268.93)
D12704: length 833.7
  TOP w0.086: v1(266.5,268.93) 266.97,268.46 266.97,267.51 265.08,265.62 265.08,264.23 259.11,258.26 259.11,257.86 259.03,257.78 SITE1.90
  L05_SIGNAL w0.071: D127.04 17.97,60.77 17.97,66.88 21.44,70.35 53.3,70.35 54.91,71.97 54.91,99.93 27.28,127.57 27.28,273.15 61.23,307.1 283.96,307.1 291.63,299.42 291.63,295.56 304.64,282.55 304.8,282.55 308.99,282.55 310.44,284.01 310.44,285.6 v2(310.92,286.07)
  L32_SIGNAL w0.071: v1(266.5,268.93) 266.97,269.4 266.97,270.44 266.27,271.15 264.22,271.15 263.28,272.09 263.28,280.15 264.51,281.38 274.46,281.38 279.41,276.42 279.41,263.78 282.69,260.5 297.77,260.5 298.52,261.26 298.52,262.57 298.07,263.01 280.99,263.01 280.44,263.57 280.44,264.32 280.85,264.73 297.82,264.73 298,264.92 298,265.17 297.6,265.57 280.7,265.57 280.15,266.13 280.15,266.89 280.69,267.44 298.34,267.44 298.62,267.73 298.62,268.27 298.37,268.52 280.63,268.52 280.22,268.93 280.22,269.92 280.65,270.34 299.34,270.34 299.69,270.69 299.69,270.99 299.31,271.36 280.76,271.36 280.25,271.87 280.25,273.41 280.71,273.87 298.3,273.87 299.58,275.15 299.58,278.48 308.68,287.58 309.96,287.58 310.44,287.1 310.44,286.54 v2(310.92,286.07)
D12705: length 833.7
  TOP w0.086: v1(259.93,268.93) 259.46,268.47 259.46,267.3 258.7,266.53 258.7,264.43 255.75,261.48 255.75,257.86 255.83,257.78 SITE1.98
  L05_SIGNAL w0.071: v2(336.44,286.07) 336.91,286.54 336.91,287.8 331.69,293.03 298.98,293.03 295.52,296.49 295.52,301.24 283.67,313.1 155.28,313.1 151.28,309.1 54.13,309.1 22.41,277.38 22.41,113.34 10.63,101.56 10.63,50.13 12.08,48.67 23.49,48.67 26.63,51.8 26.63,53.58 25.5,54.71 24.03,54.71 D127.05
  L32_SIGNAL w0.071: v1(259.93,268.93) 259.45,269.4 259.45,281.71 264.85,287.11 264.85,293.51 260.22,298.15 249.73,298.15 247.27,300.6 247.27,309.78 242.48,314.58 242.48,316.37 243.63,317.52 274.68,317.52 276.49,315.71 276.49,302.25 274.77,300.53 274.77,293.81 278.11,290.47 278.11,284.48 284.43,278.16 293.81,278.16 295.95,280.3 295.95,289.21 299.25,292.51 314.75,292.51 318,289.26 318,286.98 322.26,282.72 333.3,282.72 334.35,283.77 334.35,287.1 335.5,288.25 336.32,288.25 336.91,287.65 336.91,286.54 v2(336.44,286.07)
D12706: length 833.7
  TOP w0.086: v1(279.29,255.88) 278.81,256.36 269.82,256.36 265.58,252.11 264.06,252.11 263.98,252.03 SITE1.85
  L05_SIGNAL w0.071: D127.06 27.35,60.37 27.35,66.72 29.68,69.05 53.84,69.05 56.48,71.69 56.48,100.9 30.81,126.57 30.81,272.67 63.93,305.79 69.07,305.79 283.39,305.79 288.2,300.98 288.2,285.67 290.42,283.46 295.95,283.46 297.04,284.55 297.04,285.6 v2(296.56,286.07)
  L30_SIGNAL w0.071: v2(296.56,286.07) 297.03,286.54 297.03,287.78 298.79,289.54 298.79,305.84 290.13,314.51 290.13,345.62 289.18,346.57 287.75,346.57 286.79,345.61 286.79,330.14 286.25,329.59 285.04,329.59 284.51,330.12 284.51,360.13 287.55,363.17 299.39,363.17 302.33,360.22 302.33,306.97 304.98,304.32 304.98,288.22 303.82,287.06 303.82,263.81 298.24,258.22 288.45,258.22 286.58,256.35 279.76,256.35 v1(279.29,255.88)
D12707: length 833.7
  TOP w0.086: SITE1.99 255.43,257.78 255.51,257.86 255.51,261.58 258.46,264.53 258.46,266.63 259.23,267.39 259.23,268.49 v1(258.78,268.93)
  L05_SIGNAL w0.071: D127.07 26.82,54.76 26.82,51.72 23.58,48.47 12,48.47 10.43,50.04 10.43,101.64 22.21,113.42 22.21,277.46 54.05,309.3 151.2,309.3 155.2,313.3 283.75,313.3 295.72,301.33 295.72,296.57 299.06,293.23 331.77,293.23 337.11,287.88 337.11,286.54 v2(337.59,286.07)
  L32_SIGNAL w0.071: v2(337.59,286.07) 337.11,286.54 337.11,287.74 336.4,288.45 335.41,288.45 334.15,287.19 334.15,283.85 333.22,282.92 322.34,282.92 318.2,287.07 318.2,289.35 314.83,292.71 299.17,292.71 295.75,289.29 295.75,280.38 293.72,278.35 284.51,278.35 278.31,284.56 278.31,290.55 274.96,293.89 274.96,300.45 276.69,302.17 276.69,315.79 274.76,317.72 243.55,317.72 242.28,316.45 242.28,314.49 247.07,309.7 247.07,300.52 249.64,297.95 260.13,297.95 264.66,293.43 264.66,287.2 259.26,281.8 259.26,269.4 v1(258.78,268.93)
D12708: length 833.7
  TOP w0.086: v1(279.29,257.02) 278.87,256.6 269.73,256.6 265.48,252.35 264.06,252.35 263.98,252.43 SITE1.86
  L05_SIGNAL w0.071: D127.08 29.2,59.7 28.19,59.7 27.55,60.34 27.55,66.64 29.76,68.85 53.92,68.85 56.68,71.61 56.68,100.98 31.01,126.65 31.01,272.59 64.01,305.59 283.31,305.59 288,300.9 288,285.59 290.34,283.26 296.03,283.26 297.23,284.46 297.23,285.6 v2(297.71,286.07)
  L30_SIGNAL w0.071: v1(279.29,257.02) 279.76,256.55 286.5,256.55 288.37,258.42 298.15,258.42 303.63,263.89 303.63,287.14 304.78,288.3 304.78,304.24 302.14,306.88 302.14,360.14 299.3,362.97 287.63,362.97 284.71,360.05 284.71,330.2 285.12,329.79 286.17,329.79 286.6,330.22 286.6,345.69 287.67,346.76 289.26,346.76 290.32,345.7 290.32,314.59 298.99,305.92 298.99,289.46 297.23,287.7 297.23,286.54 v2(297.71,286.07)
D12709: length 833.7
  TOP w0.086: SITE1.83 263.98,251.23 264.06,251.31 266.53,251.31 269.61,254.39 275.8,254.39 v1(276.24,253.95)
  L07_SIGNAL w0.071: v2(296.56,299.66) 297.04,300.13 297.04,302.57 285.2,314.41 154.74,314.41 150.74,310.41 50.51,310.41 20.58,280.48 20.58,113.25 9.32,101.99 9.32,50.48 11.14,48.66 33.64,48.66 35.78,50.79 35.78,53.29 35.06,53.97 34.93,53.97 D127.09
  L30_SIGNAL w0.071: v2(296.56,299.66) 297.04,300.13 297.04,301.53 285.8,312.77 285.8,327.21 285.49,327.51 284.87,327.51 284.53,327.18 284.53,316.09 283.96,315.52 283.05,315.52 282.59,315.98 282.59,360.7 287.18,365.29 300.07,365.29 303.54,361.82 303.54,308.04 307.13,304.45 307.13,287.65 305.94,286.45 305.94,262.95 297.41,254.42 276.72,254.42 v1(276.24,253.95)
D12710: length 833.7
  TOP w0.086: SITE1.120 247.03,257.78 246.95,257.86 246.95,262.28 246.61,262.62 246.61,270.41 v1(247.07,270.87)
  L07_SIGNAL w0.071: D127.10 38,60.86 38,65.04 40.04,67.08 54.66,67.08 57.96,70.38 57.96,102.46 32.39,128.04 32.39,269.03 67.5,304.14 282.84,304.14 286.91,300.08 286.91,283.36 v2(287.38,282.89)
  L30_SIGNAL w0.071: v2(287.38,282.89) 286.91,282.42 286.91,281.8 286.26,281.15 282.47,281.15 280.31,283.31 280.31,290.31 278.22,292.4 278.22,348.26 274.86,351.62 200.21,351.62 197.01,348.41 197.01,323.68 201.73,318.95 243.22,318.95 258.71,303.46 258.71,294.31 253.78,289.37 253.78,282.32 246.6,275.14 246.6,271.34 v1(247.07,270.87)
D12711: length 833.7
  TOP w0.086: SITE1.84 263.98,251.63 264.06,251.55 266.43,251.55 269.51,254.63 275.78,254.63 v1(276.24,255.09)
  L07_SIGNAL w0.071: D127.11 35.97,53.75 35.97,50.71 33.72,48.46 11.06,48.46 9.12,50.4 9.12,102.07 20.38,113.33 20.38,280.56 50.43,310.61 150.66,310.61 154.66,314.61 285.28,314.61 297.24,302.65 297.24,300.13 v2(297.71,299.66)
  L30_SIGNAL w0.071: v2(297.71,299.66) 297.23,300.13 297.23,301.62 285.99,312.86 285.99,327.29 285.57,327.71 284.79,327.71 284.34,327.26 284.34,316.17 283.88,315.71 283.13,315.71 282.78,316.07 282.78,360.61 287.26,365.09 299.99,365.09 303.34,361.74 303.34,307.96 306.93,304.37 306.93,287.73 305.74,286.54 305.74,263.03 297.33,254.62 276.72,254.62 v1(276.24,255.09)
D12712: length 833.7
  TOP w0.086: v1(245.93,270.87) 246.38,270.42 246.38,262.52 246.71,262.19 246.71,257.86 246.63,257.78 SITE1.121
  L07_SIGNAL w0.071: v2(286.24,282.89) 286.71,283.36 286.71,299.99 282.76,303.94 67.58,303.94 32.58,268.95 32.58,128.12 58.16,102.55 58.16,70.3 54.74,66.88 40.13,66.88 38.2,64.96 38.2,59.74 38.41,59.54 39.52,59.54 D127.12
  L30_SIGNAL w0.071: v1(245.93,270.87) 246.4,271.34 246.4,275.23 253.58,282.41 253.58,289.46 258.52,294.39 258.52,303.38 243.14,318.75 201.65,318.75 196.81,323.6 196.81,348.5 200.13,351.82 274.95,351.82 278.42,348.34 278.42,292.48 280.5,290.39 280.5,283.39 282.55,281.35 286.18,281.35 286.71,281.88 286.71,282.42 v2(286.24,282.89)
D12713: length 833.7
  TOP w0.086: SITE1.87 263.98,252.83 264.06,252.91 264.57,252.91 269.88,258.23 275.83,258.23 v1(276.24,257.81)
  L07_SIGNAL w0.071: v2(309.77,299.66) 310.24,300.13 310.24,309.61 298.39,321.46 56.18,321.46 17.58,282.86 17.58,112.19 8.37,102.98 8.37,50.04 10.7,47.71 43,47.71 46.45,51.16 46.45,54.31 46.1,54.66 44.4,54.66 D127.13
  L30_SIGNAL w0.071: v2(309.77,299.66) 310.23,300.11 310.23,304.23 304.96,309.5 304.96,362.38 300.24,367.1 285.78,367.1 281.64,362.97 281.64,314.83 290.07,306.41 290.07,266.5 281.85,258.28 276.72,258.28 v1(276.24,257.81)
D12714: length 833.7
  TOP w0.086: SITE1.131 242.63,257.78 242.55,257.86 242.55,258.66 236.97,264.24 236.97,268.69 v1(237.43,269.15)
  L05_SIGNAL w0.071: v2(283.1,299.66) 283.57,299.18 283.57,298.6 282.78,297.8 276.98,297.8 271.96,302.82 70.73,302.82 35.29,267.38 35.29,127.64 59.46,103.48 59.46,71.46 55,67.01 49.83,67.01 48.35,65.53 48.35,60.22 48.07,59.94 47.24,59.94 D127.14
  L32_SIGNAL w0.071: v2(283.1,299.66) 283.57,300.13 283.57,374.91 280.51,377.97 253.03,377.97 252.21,378.79 252.21,380.57 253.28,381.63 277.14,381.63 277.86,382.36 277.86,383.53 277.21,384.19 220.63,384.19 213.3,376.86 213.3,321.94 236.95,298.29 236.95,269.62 v1(237.43,269.15)
D12715: length 833.7
  TOP w0.086: SITE1.88 263.98,253.23 264.06,253.15 264.47,253.15 269.78,258.47 275.76,258.47 v1(276.24,258.95)
  L07_SIGNAL w0.071: D127.15 46.65,54.27 46.65,51.07 43.08,47.51 10.62,47.51 8.17,49.96 8.17,103.06 17.38,112.27 17.38,282.95 56.09,321.66 298.47,321.66 310.44,309.69 310.44,300.13 v2(310.92,299.66)
  L30_SIGNAL w0.071: v1(276.24,258.95) 276.72,258.48 281.76,258.48 289.87,266.58 289.87,306.33 281.45,314.75 281.45,363.05 285.7,367.3 300.32,367.3 305.16,362.46 305.16,309.58 310.43,304.31 310.43,300.14 v2(310.92,299.66)
D12716: length 833.7
  TOP w0.086: v1(236.28,269.15) 236.73,268.71 236.73,264.14 242.31,258.56 242.31,257.86 242.23,257.78 SITE1.132
  L05_SIGNAL w0.071: D127.16 48.55,60.67 48.55,65.44 49.91,66.81 55.09,66.81 59.65,71.38 59.65,103.56 35.49,127.72 35.49,267.29 70.82,302.62 271.88,302.62 276.89,297.61 282.87,297.61 283.77,298.51 283.77,299.18 v2(284.25,299.66)
  L32_SIGNAL w0.071: v2(284.25,299.66) 283.77,300.13 283.77,374.99 280.59,378.17 253.11,378.17 252.41,378.87 252.41,380.49 253.36,381.44 277.22,381.44 278.06,382.28 278.06,383.61 277.29,384.39 220.54,384.39 213.1,376.94 213.1,321.86 236.75,298.21 236.75,269.62 v1(236.28,269.15)
D12801: length 833.7
  TOP w0.086: v1(258,267.21) 257.55,266.76 257.55,264.67 254.95,262.07 254.95,257.86 255.03,257.78 SITE1.100
  L05_SIGNAL w0.071: v2(322.98,299.66) 323.45,300.13 323.45,304.83 305.57,322.7 62.74,322.7 15.66,275.63 15.66,112.35 7.17,103.87 7.17,32.59 8.72,31.04 13.52,31.04 15.15,32.68 15.15,34.2 14.81,34.55 13.71,34.55 D128.01
  L32_SIGNAL w0.071: v2(322.98,299.66) 323.45,300.13 323.45,301.97 324.14,302.66 324.77,302.66 325.35,302.07 325.35,284.68 324.63,283.95 322.48,283.95 321.18,285.25 321.18,287.69 315.28,293.59 298.63,293.59 293.95,288.91 293.95,287.58 288.42,282.05 282.58,282.05 279.89,284.74 279.89,290.37 278,292.26 278,316.45 275.91,318.54 242.69,318.54 240.71,316.56 240.71,314.54 245.9,309.35 245.9,298.53 248.17,296.25 260.78,296.25 263.11,293.92 263.11,287.53 256.71,281.13 256.71,275.17 257.53,274.36 257.53,267.69 v1(258,267.21)
D12802: length 833.7
  TOP w0.086: SITE1.124 245.43,257.78 245.35,257.86 245.35,260.75 242.73,263.37 242.73,270.45 v1(243.16,270.88)
  L05_SIGNAL w0.071: v2(238.87,299.4) 238.4,299.87 238.4,300.61 237.68,301.33 74.49,301.33 37.42,264.25 37.42,127.77 60.8,104.39 60.8,57.48 49.97,46.64 19.52,46.64 17.52,44.64 17.52,40.38 D128.02
  L30_SIGNAL w0.071: v1(243.16,270.88) 242.69,271.35 242.69,272.65 240.2,275.14 228.79,275.14 228.11,275.81 228.11,286.7 223.4,291.41 217.09,291.41 208.65,282.97 208.65,276.3 203.64,271.29 134.07,271.29 126.51,278.84 113.51,278.84 113.25,279.1 113.25,306.16 117,309.91 154.01,309.91 156.82,312.71 227.49,312.71 234.93,305.28 234.93,299.25 236.42,297.76 237.64,297.76 238.4,298.52 238.4,298.94 v2(238.87,299.4)
D12803: length 833.7
  TOP w0.086: SITE1.101 254.63,257.78 254.71,257.86 254.71,262.17 257.31,264.77 257.31,266.76 v1(256.85,267.21)
  L05_SIGNAL w0.071: D128.03 15.35,33.13 15.35,32.6 13.6,30.85 8.64,30.85 6.97,32.51 6.97,103.95 15.46,112.44 15.46,275.71 62.66,322.9 305.66,322.9 323.65,304.91 323.65,300.13 v2(324.12,299.66)
  L32_SIGNAL w0.071: v1(256.85,267.21) 257.33,267.69 257.33,274.27 256.52,275.08 256.52,281.21 262.92,287.61 262.92,293.83 260.7,296.05 248.09,296.05 245.7,298.45 245.7,309.27 240.51,314.46 240.51,316.65 242.61,318.74 275.99,318.74 278.2,316.53 278.2,292.34 280.09,290.45 280.09,284.82 282.66,282.25 288.34,282.25 293.75,287.66 293.75,288.99 298.55,293.79 315.36,293.79 321.38,287.77 321.38,285.33 322.57,284.15 324.55,284.15 325.15,284.76 325.15,301.99 324.68,302.46 324.22,302.46 323.65,301.89 323.65,300.13 v2(324.12,299.66)
D12804: length 833.7
  TOP w0.086: SITE1.125 245.03,257.78 245.11,257.86 245.11,260.65 242.49,263.28 242.49,270.41 v1(242.02,270.88)
  L05_SIGNAL w0.071: v2(237.72,299.4) 238.2,299.87 238.2,300.52 237.59,301.13 74.58,301.13 37.62,264.17 37.62,127.86 61,104.48 61,57.4 50.05,46.45 19.61,46.45 17.72,44.56 17.72,39.84 18.25,39.31 19.11,39.31 D128.04
  L30_SIGNAL w0.071: v1(242.02,270.88) 242.49,271.35 242.49,272.56 240.12,274.94 228.7,274.94 227.91,275.73 227.91,286.61 223.32,291.21 217.17,291.21 208.85,282.89 208.85,276.22 203.72,271.09 133.98,271.09 126.43,278.64 113.43,278.64 113.06,279.01 113.06,306.24 116.92,310.1 153.93,310.1 156.74,312.91 227.58,312.91 235.13,305.36 235.13,299.33 236.5,297.96 237.56,297.96 238.21,298.6 238.21,298.92 v2(237.72,299.4)
D12805: length 833.7
  TOP w0.086: SITE1.95 257.03,257.78 256.95,257.86 256.95,259.28 261.41,263.74 261.41,266.77 v1(261.86,267.21)
  L05_SIGNAL w0.071: v2(336.44,299.66) 336.91,300.13 336.91,305.55 318.55,323.91 58.45,323.91 13.85,279.31 13.85,112.82 5.98,104.95 5.98,32.03 8.07,29.93 23.01,29.93 25.41,32.33 25.41,33.99 24.68,34.71 23.71,34.71 D128.05
  L32_SIGNAL w0.071: v1(261.86,267.21) 261.38,267.69 261.38,281.57 266.61,286.79 266.61,295.25 262.74,299.12 259.34,299.12 258.54,299.92 258.54,304.57 260.5,306.52 270.58,306.52 271.59,305.51 271.59,288.26 282.52,277.34 293.79,277.34 298.72,282.26 298.72,290.3 299.75,291.33 312,291.33 322.51,280.82 335.09,280.82 340.57,286.3 340.57,301.24 339.51,302.3 337.73,302.3 336.91,301.49 336.91,300.13 v2(336.44,299.66)
D12806: length 833.7
  TOP w0.086: SITE1.126 244.63,257.78 244.55,257.86 244.55,259.62 240.83,263.34 240.83,268.7 v1(241.28,269.15)
  L07_SIGNAL w0.071: v2(256.43,299.66) 256.9,299.18 256.9,298 252.48,293.58 131.38,293.58 127.48,289.68 68.21,289.68 40,261.47 40,129.09 62.09,106.99 62.09,56.11 51.35,45.37 30.67,45.37 28.34,43.04 28.34,40.61 27.1,39.38 26.68,39.38 D128.06
  L30_SIGNAL w0.071: v2(256.43,299.66) 256.9,300.12 256.9,300.88 243.25,314.53 154.52,314.53 152.22,312.24 117.51,312.24 111.21,305.93 111.21,274.68 116.19,269.7 221.33,269.7 225.44,273.81 239.34,273.81 240.81,272.33 240.81,269.62 v1(241.28,269.15)
D12807: length 833.7
  TOP w0.086: SITE1.96 256.63,257.78 256.71,257.86 256.71,259.38 261.17,263.84 261.17,266.75 v1(260.71,267.21)
  L05_SIGNAL w0.071: v2(337.59,299.66) 337.11,300.13 337.11,305.63 318.63,324.11 58.36,324.11 13.65,279.4 13.65,112.9 5.78,105.03 5.78,31.95 7.99,29.74 23.09,29.74 25.6,32.25 25.6,33.22 D128.07
  L32_SIGNAL w0.071: v1(260.71,267.21) 261.19,267.69 261.19,281.65 266.41,286.88 266.41,295.17 262.66,298.92 259.26,298.92 258.34,299.83 258.34,304.65 260.42,306.72 270.66,306.72 271.79,305.59 271.79,288.35 282.6,277.54 293.71,277.54 298.52,282.35 298.52,290.38 299.67,291.53 312.09,291.53 322.6,281.02 335.01,281.02 340.37,286.39 340.37,301.16 339.43,302.11 337.81,302.11 337.11,301.41 337.11,300.13 v2(337.59,299.66)
D12808: length 833.7
  TOP w0.086: v1(240.14,269.15) 240.59,268.7 240.59,263.24 244.31,259.52 244.31,257.86 244.23,257.78 SITE1.127
  L07_SIGNAL w0.071: v2(257.58,299.66) 257.1,299.18 257.1,297.92 252.57,293.38 131.46,293.38 127.56,289.48 68.29,289.48 40.2,261.39 40.2,129.17 62.29,107.08 62.29,56.03 51.43,45.17 30.75,45.17 28.53,42.95 28.53,40.05 D128.08
  L30_SIGNAL w0.071: v2(257.58,299.66) 257.1,300.13 257.1,300.96 243.33,314.73 154.44,314.73 152.14,312.44 117.43,312.44 111.01,306.01 111.01,274.6 116.11,269.5 221.42,269.5 225.53,273.61 239.25,273.61 240.61,272.25 240.61,269.62 v1(240.14,269.15)
D12809: length 833.7
  TOP w0.086: SITE1.91 258.63,257.78 258.55,257.86 258.55,258.23 264.35,264.04 264.35,265.37 265.28,266.31 265.28,266.78 v1(265.72,267.21)
  L05_SIGNAL w0.071: v2(349.9,299.66) 350.38,300.13 350.38,302.41 327.75,325.04 55.33,325.04 11.95,281.66 11.95,113.18 4.55,105.77 4.55,31.06 6.98,28.62 31.98,28.62 35.4,32.05 35.4,34.41 35.21,34.6 33.98,34.6 D128.09
  L32_SIGNAL w0.071: v2(349.9,299.66) 350.38,300.13 350.38,308.57 351.3,309.49 353.62,309.49 354.54,308.58 354.54,288.45 344.95,278.85 319.8,278.85 310.52,288.12 305.08,288.12 303.08,286.12 303.08,283.76 294.24,274.92 281.68,274.92 274.14,282.46 265.1,282.46 262.92,280.28 262.92,272.05 265.24,269.73 265.24,267.69 v1(265.72,267.21)
D12810: length 833.7
  TOP w0.086: v1(224.31,259.31) 224.75,258.87 231.22,258.87 236.94,253.15 237.6,253.15 237.68,253.23 SITE1.133
  L05_SIGNAL w0.071: D128.10 37.72,40.26 37.72,42.71 40.4,45.39 53.39,45.39 63.77,55.77 63.77,108.64 42.5,129.9 42.5,259.06 63.24,279.79 63.25,279.79 68.52,285.06 126.47,285.06 132.44,291.03 269.47,291.03 277.1,283.4 282.4,283.4 283.57,284.57 283.57,285.6 v2(283.1,286.07)
  L32_SIGNAL w0.071: v2(283.1,286.07) 283.57,285.6 283.57,285.13 284.21,284.5 285.47,284.5 287.09,286.11 287.09,376.6 277.68,386 220.12,386 211.46,377.34 211.46,317.39 228.6,300.25 228.6,280.89 226.06,278.35 226.06,259.55 225.35,258.84 224.78,258.84 v1(224.31,259.31)
D12811: length 833.7
  TOP w0.086: v1(264.57,267.21) 265.04,266.74 265.04,266.4 264.11,265.47 264.11,264.13 258.31,258.33 258.31,257.86 258.23,257.78 SITE1.92
  L05_SIGNAL w0.071: v2(351.05,299.66) 350.58,300.13 350.58,302.5 327.84,325.23 55.25,325.23 11.76,281.74 11.76,113.26 4.35,105.85 4.35,30.97 6.9,28.42 32.06,28.42 35.6,31.96 35.6,33.06 D128.11
  L32_SIGNAL w0.071: v2(351.05,299.66) 350.57,300.13 350.57,308.48 351.39,309.3 353.54,309.3 354.34,308.49 354.34,288.53 344.87,279.05 319.88,279.05 310.61,288.32 304.99,288.32 302.88,286.21 302.88,283.84 294.16,275.12 281.76,275.12 274.22,282.66 265.02,282.66 262.72,280.36 262.72,271.97 265.04,269.65 265.04,267.69 v1(264.57,267.21)
D12812: length 833.7
  TOP w0.086: SITE1.134 237.68,252.83 237.6,252.91 236.84,252.91 231.12,258.63 224.77,258.63 v1(224.31,258.17)
  L05_SIGNAL w0.071: D128.12 39.55,39.19 38.26,39.19 37.92,39.53 37.92,42.62 40.49,45.19 53.47,45.19 63.96,55.69 63.96,108.72 42.7,129.98 42.7,258.98 63.32,279.6 63.33,279.6 68.6,284.86 126.55,284.86 132.52,290.83 269.39,290.83 277.02,283.2 282.49,283.2 283.77,284.49 283.77,285.6 v2(284.25,286.07)
  L32_SIGNAL w0.071: v2(284.25,286.07) 283.77,285.6 283.77,285.21 284.29,284.7 285.39,284.7 286.89,286.19 286.89,376.52 277.6,385.8 220.21,385.8 211.66,377.26 211.66,317.47 228.8,300.33 228.8,280.81 226.26,278.27 226.26,259.47 225.43,258.64 224.78,258.64 v1(224.31,258.17)
D12813: length 833.7
  TOP w0.086: SITE1.93 257.83,257.78 257.75,257.86 257.75,258.68 263.34,264.27 263.34,268.49 v1(263.79,268.93)
  L05_SIGNAL w0.071: v2(349.9,286.07) 350.38,286.54 350.38,287.9 351.88,289.4 351.88,303.88 329.75,326.01 53.93,326.01 10.03,282.11 10.03,113.6 3.03,106.6 3.03,30.99 6.6,27.42 41.07,27.42 46.72,33.07 46.72,33.84 46.25,34.31 44.43,34.31 D128.13
  L32_SIGNAL w0.071: v1(263.79,268.93) 263.31,269.4 263.31,270.42 262.18,271.55 262.18,281.02 265.02,283.86 274.06,283.86 281.78,276.14 293.77,276.14 300.96,283.33 300.96,289.17 301.99,290.2 309.96,290.2 317.38,282.79 318.6,282.79 321.4,279.98 336.83,279.98 344.9,288.05 349.82,288.05 350.38,287.5 350.38,286.54 v2(349.9,286.07)
D12814: length 833.7
  TOP w0.086: SITE1.122 246.23,257.78 246.15,257.86 246.15,261.71 244.69,263.17 244.69,268.7 v1(245.14,269.15)
  L05_SIGNAL w0.071: v2(238.87,285.81) 238.4,286.29 238.4,287.05 237.92,287.53 235.31,287.53 227.85,280.06 227.85,273.8 223.01,268.96 85.01,268.96 45.69,229.64 45.69,130.76 65.21,111.24 65.21,52.89 56.29,43.97 48.57,43.97 47.65,43.05 47.65,40.03 D128.14
  L30_SIGNAL w0.071: v1(245.14,269.15) 244.67,269.62 244.67,273.1 239.95,277.82 230.48,277.82 229.78,278.51 229.78,287.92 224.96,292.74 215.6,292.74 207.27,284.4 207.27,276.58 204.11,273.41 200.78,273.41 199.83,274.36 135.35,274.36 129.7,280.01 116.37,280.01 115.14,281.23 115.14,305.07 117.76,307.7 139.15,307.7 139.58,307.26 139.58,305.46 139.05,304.92 121.78,304.92 120.5,303.65 120.5,301.91 121.28,301.12 156.48,301.12 165.93,310.57 226.13,310.57 233.95,302.76 233.95,282.82 235.24,281.53 237.1,281.53 238.4,282.82 238.4,285.34 v2(238.87,285.81)
D12815: length 833.7
  TOP w0.086: SITE1.94 257.43,257.78 257.51,257.86 257.51,258.78 263.1,264.37 263.1,268.47 v1(262.64,268.93)
  L05_SIGNAL w0.071: D128.15 46.91,34.21 46.91,32.99 41.15,27.22 6.52,27.22 2.84,30.91 2.84,106.68 9.84,113.68 9.84,282.2 53.84,326.2 329.84,326.2 352.07,303.96 352.07,289.32 350.58,287.82 350.58,286.54 v2(351.05,286.07)
  L32_SIGNAL w0.071: v1(262.64,268.93) 263.12,269.4 263.12,270.33 261.99,271.46 261.99,281.1 264.94,284.06 274.14,284.06 281.86,276.34 293.69,276.34 300.76,283.41 300.76,289.25 301.91,290.4 310.05,290.4 317.46,282.98 318.68,282.98 321.49,280.18 336.74,280.18 344.81,288.25 349.9,288.25 350.57,287.58 350.57,286.54 v2(351.05,286.07)
D12816: length 833.7
  TOP w0.086: SITE1.123 245.83,257.78 245.91,257.86 245.91,261.61 244.46,263.07 244.46,268.69 v1(244,269.15)
  L05_SIGNAL w0.071: D128.16 48.91,39.99 48.52,39.99 47.85,40.66 47.85,42.97 48.65,43.77 56.37,43.77 65.41,52.81 65.41,111.32 45.89,130.84 45.89,229.56 85.09,268.76 223.09,268.76 228.05,273.71 228.05,279.98 235.39,287.33 237.84,287.33 238.2,286.97 238.2,286.29 v2(237.72,285.81)
  L30_SIGNAL w0.071: v1(244,269.15) 244.47,269.62 244.47,273.02 239.87,277.62 230.39,277.62 229.59,278.42 229.59,287.83 224.88,292.54 215.69,292.54 207.47,284.32 207.47,276.49 204.19,273.21 200.7,273.21 199.75,274.16 135.27,274.16 129.61,279.81 116.28,279.81 114.94,281.15 114.94,305.16 117.68,307.89 139.23,307.89 139.78,307.34 139.78,305.38 139.13,304.73 121.86,304.73 120.7,303.57 120.7,301.99 121.37,301.32 156.4,301.32 165.85,310.77 226.22,310.77 234.15,302.84 234.15,282.9 235.33,281.72 237.02,281.72 238.2,282.91 238.2,285.34 v2(237.72,285.81)
D12901: length 413.5
  TOP w0.086: v1(225.46,173.61) 225.91,173.16 235.09,173.16 237.01,175.08 237.01,175.98 237.38,176.35 237.6,176.35 237.68,176.43 SITE3.175
  L03_SIGNAL w0.071: D129.01 87.74,95.14 89.35,95.14 89.62,94.86 89.62,92.63 87.22,90.23 84.49,90.23 81.33,93.39 81.33,169.51 92.44,180.62 197.15,180.62 200.7,177.07 200.7,176.28 200.08,175.66 199.16,175.66 v1(198.69,176.13)
  L28_SIGNAL w0.071: v1(225.46,173.61) 224.98,173.14 223.77,173.14 222.72,172.09 222.72,170.28 221.85,169.41 213.14,169.41 211.21,171.34 132.19,171.34 131.59,171.94 131.59,173.43 132.04,173.89 171.54,173.89 173.69,171.74 200.18,171.74 201.76,173.32 201.76,174.27 200.38,175.66 199.16,175.66 v1(198.69,176.13)
D12902: length 413.5
  TOP w0.086: v1(228.38,178.12) 228.77,178.5 237.61,178.5 237.68,178.43 SITE3.170
  L03_SIGNAL w0.071: v1(198.69,161.52) 199.16,162 199.44,162 199.91,162.47 199.91,168.58 196.26,172.24 162.48,172.24 161.65,173.07 95.9,173.07 87.16,164.33 87.16,111.42 90.85,107.73 90.85,101.01 D129.02
  L28_SIGNAL w0.071: v1(198.69,161.52) 199.16,162 200.16,162 203.24,158.92 216.51,158.92 225.71,168.12 227.88,168.12 229.82,170.06 229.82,171.64 229.38,172.08 227.61,172.08 226.3,173.39 226.3,174.33 225.62,175.01 224.39,175.01 222.18,177.23 217.51,177.23 213.98,173.7 207.44,173.7 203.45,177.68 196.52,177.68 193.04,181.16 167.13,181.16 163.65,184.64 163.65,195.45 169.63,201.43 213.01,201.43 219.9,194.54 219.9,182.14 223.46,178.59 227.91,178.59 v1(228.38,178.12)
D12903: length 413.5
  TOP w0.086: v1(225.46,172.46) 225.91,172.92 235.19,172.92 237.25,174.98 237.25,175.88 237.48,176.11 237.6,176.11 237.68,176.03 SITE3.176
  L03_SIGNAL w0.071: v1(198.69,174.99) 199.16,175.46 200.16,175.46 200.9,176.2 200.9,177.15 197.23,180.82 92.36,180.82 81.13,169.59 81.13,93.3 84.4,90.03 87.3,90.03 89.82,92.55 89.82,94.9 D129.03
  L28_SIGNAL w0.071: v1(198.69,174.99) 199.16,175.46 200.29,175.46 201.56,174.19 201.56,173.4 200.09,171.94 173.77,171.94 171.62,174.09 131.96,174.09 131.39,173.52 131.39,171.86 132.11,171.14 211.12,171.14 213.05,169.21 221.93,169.21 222.92,170.2 222.92,172.01 223.85,172.94 224.98,172.94 v1(225.46,172.46)
D12904: length 413.5
  TOP w0.086: SITE3.169 237.68,178.83 237.59,178.74 228.9,178.74 v1(228.38,179.26)
  L03_SIGNAL w0.071: v1(198.69,162.67) 199.16,162.2 199.35,162.2 199.71,162.55 199.71,168.5 196.18,172.04 162.4,172.04 161.57,172.87 95.99,172.87 87.36,164.24 87.36,111.5 91.05,107.81 91.05,101.09 91.4,100.73 92.31,100.73 D129.04
  L28_SIGNAL w0.071: v1(198.69,162.67) 199.16,162.2 200.24,162.2 203.32,159.12 216.43,159.12 225.63,168.32 227.8,168.32 229.62,170.14 229.62,171.56 229.3,171.88 227.52,171.88 226.1,173.3 226.1,174.25 225.54,174.82 224.31,174.82 222.1,177.03 217.59,177.03 214.06,173.5 207.35,173.5 203.37,177.49 196.43,177.49 192.96,180.96 167.04,180.96 163.45,184.55 163.45,195.53 169.55,201.63 213.09,201.63 220.1,194.62 220.1,182.23 223.54,178.79 227.49,178.79 227.91,178.79 v1(228.38,179.26)
D12905: length 413.5
  TOP w0.086: SITE3.172 237.68,177.63 237.6,177.71 235.46,177.71 234.38,176.63 225.85,176.63 v1(225.39,176.18)
  L03_SIGNAL w0.071: v1(212.28,174.99) 211.81,175.46 210.61,175.46 203.43,182.64 108.95,182.64 106.98,184.61 91.02,184.61 76.66,170.25 76.66,91.78 81.25,87.19 95.17,87.19 99.39,91.42 99.39,94.69 99.02,95.07 97.97,95.07 D129.05
  L28_SIGNAL w0.071: v1(225.39,176.18) 224.92,176.65 223.64,176.65 222.52,177.77 220.56,177.77 219.7,178.63 219.7,180.12 218.66,181.17 216.8,181.17 215.39,182.58 215.39,194.69 211.11,198.97 169.98,198.97 169.06,198.04 169.06,186.49 171.13,184.42 210.61,184.42 215.24,179.8 215.24,176.44 214.26,175.46 212.75,175.46 v1(212.28,174.99)
D12906: length 413.5
  TOP w0.086: SITE3.174 237.68,176.83 237.6,176.91 236.1,176.91 234.04,174.85 228.85,174.85 v1(228.4,174.39)
  L03_SIGNAL w0.071: v1(181.67,161.52) 182.15,162 182.72,162 183.11,162.39 183.11,164.34 182.31,165.14 112.74,165.14 100.99,153.39 100.99,100.99 D129.06
  L28_SIGNAL w0.071: v1(228.4,174.39) 227.93,174.87 227.29,174.87 226.81,175.35 226.81,176.59 227.34,177.12 228.92,177.12 229.36,177.55 229.36,180.29 228,181.65 228,189.2 225.8,191.4 225.8,202.89 222.41,206.28 119.16,206.28 118.01,205.13 118.01,166.54 118.89,165.66 185,165.66 185.6,165.07 185.6,164.3 183.29,162 182.15,162 v1(181.67,161.52)
D12907: length 413.5
  TOP w0.086: SITE3.171 237.68,178.03 237.6,177.95 235.37,177.95 234.29,176.87 225.85,176.87 v1(225.39,177.32)
  L03_SIGNAL w0.071: v1(212.28,176.13) 211.81,175.66 210.69,175.66 203.51,182.84 109.04,182.84 107.06,184.81 90.94,184.81 76.46,170.34 76.46,91.7 81.17,86.99 95.25,86.99 99.59,91.33 99.59,94.51 D129.07
  L28_SIGNAL w0.071: v1(225.39,177.32) 224.92,176.85 223.72,176.85 222.6,177.97 220.65,177.97 219.9,178.71 219.9,180.2 218.74,181.36 216.88,181.36 215.58,182.66 215.58,194.78 211.19,199.17 169.9,199.17 168.86,198.13 168.86,186.41 171.04,184.23 210.53,184.23 215.04,179.71 215.04,176.52 214.17,175.66 212.75,175.66 v1(212.28,176.13)
D12908: length 413.5
  TOP w0.086: SITE3.173 237.68,177.23 237.6,177.15 236,177.15 233.94,175.08 228.85,175.08 v1(228.4,175.54)
  L03_SIGNAL w0.071: v1(181.67,162.67) 182.15,162.2 182.64,162.2 182.91,162.47 182.91,164.26 182.23,164.94 112.82,164.94 101.19,153.31 101.19,101.06 101.69,100.57 102.63,100.57 D129.08
  L28_SIGNAL w0.071: v1(181.67,162.67) 182.15,162.2 183.21,162.2 185.4,164.38 185.4,164.98 184.92,165.46 118.8,165.46 117.81,166.45 117.81,205.21 119.08,206.48 222.5,206.48 226,202.97 226,191.48 228.19,189.29 228.19,181.73 229.55,180.37 229.55,177.47 229,176.92 227.42,176.92 227.01,176.5 227.01,175.44 227.38,175.06 227.93,175.06 v1(228.4,175.54)
D12909: length 457
  TOP w0.086: SITE3.12 246.63,171.48 246.55,171.4 246.55,163.72 245.23,162.4 245.23,157.05 v1(245.68,156.6)
  L03_SIGNAL w0.071: D129.09 108.77,94.43 108.77,91.4 110.78,89.39 128.28,89.39 132.5,93.61 132.5,138.32 145.35,151.16 177.31,151.16 180.2,148.28 181.2,148.28 v1(181.67,147.81)
  L28_SIGNAL w0.071: v1(181.67,147.81) 182.15,148.28 183.55,148.28 186.79,151.52 204.1,151.52 204.88,152.31 204.88,155.03 203.96,155.95 200.04,155.95 199.73,155.64 153.24,155.64 152.72,156.16 152.72,157.21 153.2,157.69 229.77,157.69 232.06,159.98 235.47,159.98 239.1,163.6 239.1,201.52 240.75,203.17 264.3,203.17 265,202.47 265,162.36 262.53,159.88 244.28,159.88 243.16,158.77 243.16,155.24 243.79,154.6 244.78,154.6 245.21,155.03 245.21,156.12 v1(245.68,156.6)
D12910: length 413.5
  TOP w0.086: v1(228.51,169.79) 228.97,170.25 233.52,170.25 234.03,170.76 242.13,170.76 242.55,171.18 242.55,171.4 242.63,171.48 SITE3.2
  L03_SIGNAL w0.071: D129.10 111.59,101.43 111.59,106.32 113.23,107.96 113.23,157.14 112.86,157.51 111.56,157.51 111.06,157.01 111.06,108.91 110.39,108.25 108.83,108.25 107.9,109.18 107.9,153.05 107.39,153.56 106.62,153.56 105.93,152.88 105.93,107.81 105.34,107.22 104.22,107.22 103.53,107.92 103.53,152.49 109.9,158.86 196.59,158.86 197.58,159.85 197.58,161.18 196.76,162 195.73,162 v1(195.26,161.52)
  L28_SIGNAL w0.071: v1(228.51,169.79) 228.04,170.26 225.32,170.26 214.99,159.94 210.2,159.94 204.61,165.53 198.72,165.53 197.16,163.97 197.16,162.6 196.56,162 195.73,162 v1(195.26,161.52)
D12911: length 457
  TOP w0.086: v1(244.54,156.6) 244.99,157.05 244.99,162.5 246.31,163.82 246.31,171.4 246.23,171.48 SITE3.11
  L03_SIGNAL w0.071: v1(181.67,148.95) 181.2,148.48 180.28,148.48 177.4,151.36 145.27,151.36 132.31,138.4 132.31,93.69 128.2,89.59 110.86,89.59 108.96,91.49 108.96,94.36 109.31,94.71 109.95,94.71 D129.11
  L28_SIGNAL w0.071: v1(181.67,148.95) 182.15,148.48 183.47,148.48 186.71,151.72 204.02,151.72 204.68,152.39 204.68,154.95 203.88,155.76 200.13,155.76 199.81,155.44 153.16,155.44 152.52,156.08 152.52,157.29 153.12,157.89 229.69,157.89 231.97,160.17 235.39,160.17 238.9,163.68 238.9,201.6 240.67,203.37 264.38,203.37 265.2,202.55 265.2,162.27 262.61,159.68 244.36,159.68 243.36,158.68 243.36,155.32 243.88,154.8 244.7,154.8 245.01,155.11 245.01,156.12 v1(244.54,156.6)
D12912: length 413.5
  TOP w0.086: SITE3.1 242.23,171.48 242.31,171.4 242.31,171.28 242.03,171 233.93,171 233.42,170.49 228.95,170.49 v1(228.51,170.93)
  L03_SIGNAL w0.071: v1(195.26,162.67) 195.73,162.2 196.84,162.2 197.78,161.26 197.78,159.77 196.67,158.66 109.98,158.66 103.72,152.41 103.72,108 104.31,107.42 105.26,107.42 105.73,107.89 105.73,152.96 106.53,153.76 107.47,153.76 108.1,153.13 108.1,109.26 108.91,108.45 110.31,108.45 110.86,109 110.86,157.09 111.48,157.71 112.94,157.71 113.43,157.22 113.43,107.88 111.78,106.23 111.78,101.58 D129.12
  L28_SIGNAL w0.071: v1(228.51,170.93) 228.04,170.46 225.24,170.46 214.91,160.13 210.28,160.13 204.69,165.72 198.63,165.72 196.96,164.05 196.96,162.69 196.47,162.2 195.73,162.2 v1(195.26,162.67)
D12913: length 457
  TOP w0.086: SITE3.8 245.03,171.48 244.95,171.4 244.95,165.37 239.21,159.63 v1(239.21,158.99)
  L03_SIGNAL w0.071: v1(198.69,148.06) 198.22,148.53 197.78,148.53 192.7,153.62 140.72,153.62 129.69,142.58 129.69,94.01 126.98,91.3 119.86,91.3 117.99,93.17 117.99,95.37 D129.13
  L28_SIGNAL w0.071: v1(239.21,158.99) 238.54,158.99 238.11,158.56 237.32,158.56 236.69,159.2 236.69,160.57 240.22,164.1 240.22,200.99 241.6,202.37 262.54,202.37 263,201.92 263,201.01 262.61,200.62 241.91,200.62 241.33,200.05 241.33,199.25 241.89,198.69 262.87,198.69 263.34,198.22 263.34,197.07 262.66,196.39 242.79,196.39 241.83,195.44 241.83,194.31 242.39,193.75 262.59,193.75 263.25,193.09 263.25,191.96 262.58,191.28 243.04,191.28 242.47,190.71 242.47,189.99 242.76,189.7 255.88,189.7 256.69,188.89 256.69,187.82 255.87,187 244.91,187 244.21,186.3 244.21,185.21 244.75,184.68 246.69,184.68 247.77,183.6 247.77,181.31 246.95,180.49 242.77,180.49 242.39,180.1 242.39,164.5 240.12,162.24 240.12,158.29 239.24,157.4 237.41,157.4 235.43,159.37 232.97,159.37 230.23,156.63 214.52,156.63 205.59,147.7 201.36,147.7 200.53,148.53 199.16,148.53 v1(198.69,148.06)
D12914: length 413.5
  TOP w0.086: v1(225.36,180.02) 225.84,180.5 232.15,180.5 233.34,179.31 237.6,179.31 237.68,179.23 SITE3.168
  L03_SIGNAL w0.071: D129.14 120.95,100.63 121.22,100.63 122.02,101.43 122.02,145.08 134.32,157.38 210.59,157.38 213.97,160.77 213.97,161.56 213.53,162 212.75,162 v1(212.28,161.52)
  L28_SIGNAL w0.071: v1(212.28,161.52) 212.75,162 213.52,162 214.18,162.66 214.18,165.74 212.18,167.73 130.66,167.73 128.92,169.47 123.38,169.47 122.37,170.49 122.37,195.8 130.85,204.28 215.91,204.28 222.75,197.44 222.75,181.89 224.15,180.49 224.89,180.49 v1(225.36,180.02)
D12915: length 457
  TOP w0.086: v1(238.4,159.8) 239.04,159.8 244.71,165.47 244.71,171.4 244.63,171.48 SITE3.7
  L03_SIGNAL w0.071: D129.15 120.83,95.43 119.25,95.43 118.19,94.37 118.19,93.25 119.94,91.5 126.9,91.5 129.49,94.09 129.49,142.66 140.64,153.81 192.78,153.81 197.86,148.73 198.22,148.73 v1(198.69,149.21)
  L28_SIGNAL w0.071: v1(198.69,149.21) 199.16,148.73 200.61,148.73 201.45,147.9 205.51,147.9 214.44,156.83 230.15,156.83 232.89,159.57 235.51,159.57 237.49,157.6 239.15,157.6 239.93,158.37 239.93,162.32 242.19,164.59 242.19,180.19 242.69,180.69 246.87,180.69 247.57,181.39 247.57,183.51 246.61,184.48 244.67,184.48 244.02,185.13 244.02,186.38 244.83,187.2 255.79,187.2 256.49,187.9 256.49,188.81 255.8,189.5 242.67,189.5 242.27,189.9 242.27,190.8 242.95,191.48 262.49,191.48 263.06,192.04 263.06,193.01 262.51,193.56 242.3,193.56 241.64,194.22 241.64,195.52 242.71,196.59 262.58,196.59 263.14,197.15 263.14,198.14 262.79,198.49 241.81,198.49 241.14,199.16 241.14,200.13 241.83,200.82 262.53,200.82 262.8,201.09 262.8,201.84 262.46,202.17 241.68,202.17 240.42,200.91 240.42,164.02 236.89,160.49 236.89,159.28 237.41,158.76 238.03,158.76 238.4,159.13 v1(238.4,159.8)
D12916: length 413.5
  TOP w0.086: v1(225.36,181.16) 225.78,180.74 232.25,180.74 233.44,179.55 237.6,179.55 237.68,179.63 SITE3.167
  L03_SIGNAL w0.071: v1(212.28,162.67) 212.75,162.2 213.61,162.2 214.17,161.64 214.17,160.68 210.67,157.19 134.4,157.19 122.22,145 122.22,101.3 D129.16
  L28_SIGNAL w0.071: v1(212.28,162.67) 212.75,162.2 213.44,162.2 213.98,162.74 213.98,165.65 212.1,167.54 130.58,167.54 128.84,169.27 123.3,169.27 122.17,170.41 122.17,195.88 130.77,204.48 215.99,204.48 222.95,197.53 222.95,181.97 224.23,180.69 224.89,180.69 v1(225.36,181.16)
D13009: length 457
  TOP w0.086: SITE3.16 248.23,171.48 248.15,171.4 248.15,163.18 249.68,161.65 249.68,157.05 v1(250.13,156.61)
  L03_SIGNAL w0.071: v1(164.91,134.6) 164.44,135.07 148.78,135.07 143.26,129.55 143.26,77.87 132.85,67.46 110.87,67.46 108.85,69.49 108.85,74.03 D130.09
  L28_SIGNAL w0.071: v1(164.91,134.6) 165.38,135.07 166.64,135.07 169.97,131.74 169.97,115.86 174.58,111.25 252.61,111.25 253.42,112.06 253.42,113.15 252.56,114.01 175.87,114.01 174.99,114.89 174.99,116.65 175.62,117.28 251.66,117.28 253.06,118.69 253.06,123.04 251.81,124.29 248.29,124.29 243.83,128.76 243.83,138.3 249.66,144.13 249.66,146.84 250.96,148.14 250.96,150.21 249.66,151.5 249.66,156.13 v1(250.13,156.61)
D13010: length 457
  TOP w0.086: v1(238.42,154.92) 238.42,155.56 243.1,160.24 243.1,161.66 245.75,164.32 245.75,171.4 245.83,171.48 SITE3.10
  L03_SIGNAL w0.071: v1(195.26,147.81) 195.73,148.28 196.05,148.28 196.72,147.61 196.72,146.18 195.01,144.47 144.95,144.47 135.56,135.08 135.56,93.67 130.09,88.2 113.54,88.2 111.61,86.27 111.61,81.13 D130.10
  L28_SIGNAL w0.071: v1(238.42,154.92) 237.75,154.92 237.09,154.26 237.09,153.71 237.96,152.84 239.38,152.84 239.87,152.35 239.87,151.74 239.5,151.37 227.97,151.37 227.49,150.9 227.49,149.57 228.21,148.85 233.32,148.85 233.75,149.29 244.66,149.29 245.32,148.63 245.32,148.09 244.77,147.54 228.61,147.54 228.2,147.13 228.2,146.54 228.45,146.28 237.83,146.28 238.7,145.41 238.7,144.28 238.08,143.66 228.86,143.66 228.04,142.84 228.04,141.5 228.99,140.55 238.61,140.55 239.52,139.64 239.52,138.53 237.07,136.08 231.94,136.08 230.56,134.69 205.8,134.69 202.4,138.09 141.81,138.09 140.83,139.08 140.83,141.24 142.02,142.43 209.75,142.43 210.49,143.17 210.49,144.42 209.55,145.35 197.42,145.35 196.9,145.87 196.9,147.94 196.56,148.28 195.73,148.28 v1(195.26,147.81)
D13011: length 457
  TOP w0.086: SITE3.15 247.83,171.48 247.91,171.4 247.91,163.08 249.45,161.55 249.45,157.06 v1(248.99,156.61)
  L03_SIGNAL w0.071: v1(164.91,135.74) 164.44,135.27 148.7,135.27 143.06,129.63 143.06,77.96 132.77,67.66 110.95,67.66 109.05,69.57 109.05,74.25 109.79,75 110.56,75 D130.11
  L28_SIGNAL w0.071: v1(248.99,156.61) 249.46,156.13 249.46,151.42 250.76,150.12 250.76,148.22 249.46,146.92 249.46,144.22 243.63,138.38 243.63,128.68 248.21,124.1 251.73,124.1 252.87,122.96 252.87,118.77 251.57,117.48 175.54,117.48 174.79,116.73 174.79,114.8 175.79,113.81 252.47,113.81 253.22,113.07 253.22,112.14 252.53,111.45 174.66,111.45 170.17,115.94 170.17,131.82 166.73,135.27 165.38,135.27 v1(164.91,135.74)
D13012: length 457
  TOP w0.086: v1(237.61,155.73) 238.25,155.73 242.86,160.34 242.86,161.76 245.51,164.41 245.51,171.4 245.43,171.48 SITE3.9
  L03_SIGNAL w0.071: v1(195.26,148.95) 195.73,148.48 196.13,148.48 196.92,147.69 196.92,146.1 195.1,144.27 145.04,144.27 135.76,134.99 135.76,93.59 130.17,88 113.62,88 111.8,86.18 111.8,81.24 D130.12
  L28_SIGNAL w0.071: v1(195.26,148.95) 195.73,148.48 196.64,148.48 197.1,148.02 197.1,145.95 197.5,145.55 209.64,145.55 210.68,144.5 210.68,143.08 209.83,142.23 142.1,142.23 141.03,141.15 141.03,139.16 141.89,138.29 202.48,138.29 205.88,134.89 230.48,134.89 231.86,136.28 236.99,136.28 239.32,138.61 239.32,139.56 238.53,140.35 228.91,140.35 227.84,141.42 227.84,142.93 228.78,143.86 238,143.86 238.5,144.37 238.5,145.33 237.74,146.08 228.37,146.08 228,146.45 228,147.21 228.53,147.74 244.68,147.74 245.12,148.18 245.12,148.55 244.58,149.09 233.83,149.09 233.4,148.66 228.13,148.66 227.3,149.49 227.3,150.98 227.88,151.57 239.42,151.57 239.67,151.82 239.67,152.27 239.3,152.64 237.88,152.64 236.89,153.63 236.89,154.34 237.61,155.06 v1(237.61,155.73)
D13013: length 457
  TOP w0.086: v1(247.8,158.55) 247.35,159 247.35,171.4 247.43,171.48 SITE3.14
  L03_SIGNAL w0.071: D130.13 118.93,74.11 118.93,71.28 120.69,69.52 128.8,69.52 140.53,81.26 140.53,130.59 150.58,140.63 171.01,140.63 176.57,135.07 178.03,135.07 v1(178.5,134.6)
  L28_SIGNAL w0.071: v1(178.5,134.6) 178.97,135.07 198.26,135.07 199.22,134.12 199.22,130.93 198.21,129.92 172.89,129.92 171.98,129.01 171.98,127.89 173.18,126.69 194.18,126.69 195.17,125.7 238.68,125.7 239.61,124.77 239.61,123.78 238.94,123.11 173.76,123.11 172.98,122.33 172.98,121.1 173.8,120.28 248.69,120.28 249.36,120.95 249.36,122.51 248.86,123.01 245.56,123.01 241.38,127.18 241.38,139.2 248.24,146.06 248.24,151.68 247.33,152.59 247.33,158.07 v1(247.8,158.55)
D13014: length 457
  TOP w0.086: SITE3.6 244.23,171.48 244.15,171.4 244.15,167.37 235.41,158.63 v1(235.41,157.99)
  L03_SIGNAL w0.071: D130.14 121.78,81.14 121.78,85.45 122.77,86.44 131.57,86.44 138.29,93.15 138.29,133.36 147.33,142.41 201.57,142.41 207.82,136.16 207.82,132.65 203.86,128.69 195.76,128.69 194.77,129.68 154.16,129.68 152.72,128.25 152.72,125.87 154.12,124.48 158.24,124.48 158.84,125.07 195.65,125.07 196.67,126.1 198.95,126.1 199.73,125.32 199.73,121.28 198.6,120.15 163.61,120.15 162.75,121.01 158.29,121.01 157.43,120.15 148.87,120.15 148.12,119.4 148.12,117.88 148.79,117.21 208.99,117.21 212.04,120.26 212.04,136.38 214.39,138.72 214.39,147.85 213.7,148.53 212.75,148.53 v1(212.28,148.06)
  L28_SIGNAL w0.071: v1(212.28,148.06) 212.75,148.53 213.66,148.53 220.92,155.79 232.54,155.79 234.74,157.99 v1(235.41,157.99)
D13015: length 457
  TOP w0.086: SITE3.13 247.03,171.48 247.11,171.4 247.11,159 v1(246.65,158.55)
  L03_SIGNAL w0.071: D130.15 120.1,74.38 119.47,74.38 119.13,74.04 119.13,71.37 120.78,69.72 128.71,69.72 140.34,81.34 140.34,130.67 150.5,140.83 171.09,140.83 176.65,135.27 178.03,135.27 v1(178.5,135.74)
  L28_SIGNAL w0.071: v1(178.5,135.74) 178.97,135.27 198.34,135.27 199.41,134.2 199.41,130.85 198.29,129.73 172.98,129.73 172.18,128.93 172.18,127.97 173.26,126.89 194.26,126.89 195.25,125.9 238.76,125.9 239.81,124.85 239.81,123.7 239.02,122.91 173.85,122.91 173.18,122.25 173.18,121.18 173.88,120.48 248.61,120.48 249.16,121.03 249.16,122.43 248.78,122.81 245.47,122.81 241.19,127.1 241.19,139.28 248.04,146.14 248.04,151.6 247.13,152.51 247.13,158.07 v1(246.65,158.55)
D13016: length 457
  TOP w0.086: SITE3.5 243.83,171.48 243.91,171.4 243.91,167.47 235.24,158.8 v1(234.6,158.8)
  L03_SIGNAL w0.071: D130.16 121.98,81.22 121.98,85.36 122.85,86.24 131.65,86.24 138.49,93.07 138.49,133.28 147.41,142.21 201.49,142.21 207.62,136.08 207.62,132.73 203.78,128.88 195.84,128.88 194.85,129.88 154.07,129.88 152.52,128.33 152.52,125.79 154.04,124.28 158.33,124.28 158.93,124.88 195.73,124.88 196.75,125.9 198.87,125.9 199.53,125.23 199.53,121.37 198.51,120.35 163.69,120.35 162.83,121.21 158.21,121.21 157.35,120.35 148.79,120.35 147.92,119.48 147.92,117.8 148.7,117.02 209.08,117.02 212.24,120.18 212.24,136.29 214.59,138.64 214.59,147.93 213.78,148.73 212.75,148.73 v1(212.28,149.21)
  L28_SIGNAL w0.071: v1(234.6,158.8) 234.6,158.13 232.46,155.99 220.83,155.99 213.58,148.73 212.75,148.73 v1(212.28,149.21)
D13105: length 760.8
  L07_SIGNAL w0.071: v2(178.5,217.02) 178.97,216.55 180.31,216.55 180.85,216.01 180.85,213.36 173.63,206.14 134.75,206.14 131.45,202.83 95.53,202.83 86.12,193.42 86.12,139.94 116.98,109.08 126.8,109.08 133.46,102.41 133.46,53.68 129.04,49.26 101.5,49.26 98.18,52.58 98.18,54.22 D131.05
  L30_SIGNAL w0.071: v1(267.84,280.1) 267.84,276.61 267.43,276.19 258.39,276.19 253.79,271.6 253.79,269.18 252.98,268.37 250.91,268.37 249.38,266.85 249.38,262.52 244.36,257.5 229.93,257.5 219.93,267.5 43.18,267.5 40.55,264.87 40.55,230.48 46.14,224.89 185.95,224.89 187.11,223.73 187.11,221.28 185.84,220.01 182.74,220.01 179.28,216.55 178.97,216.55 v2(178.5,217.02)
D13107: length 760.8
  L07_SIGNAL w0.071: v2(178.5,215.88) 178.97,216.35 180.23,216.35 180.65,215.93 180.65,213.44 173.55,206.34 134.67,206.34 131.36,203.03 95.45,203.03 85.93,193.5 85.93,139.85 116.9,108.88 126.71,108.88 133.26,102.33 133.26,53.76 128.96,49.45 101.58,49.45 98.37,52.66 98.37,53.27 98.88,53.78 99.5,53.78 D131.07
  L30_SIGNAL w0.071: v1(267.84,272.1) 267.84,275.56 267.41,275.99 258.47,275.99 253.99,271.52 253.99,269.1 253.07,268.17 250.99,268.17 249.58,266.76 249.58,262.44 244.44,257.3 229.85,257.3 219.85,267.3 43.26,267.3 40.75,264.79 40.75,230.56 46.22,225.08 186.04,225.08 187.31,223.81 187.31,221.2 185.93,219.81 182.83,219.81 179.36,216.35 178.97,216.35 v2(178.5,215.88)
D13109: length 833.7
  TOP w0.086: v1(279.29,247.66) 278.84,248.11 264.06,248.11 263.98,248.03 SITE1.75
  L07_SIGNAL w0.071: D131.09 108.84,53.72 108.84,51.05 109.55,50.34 128.42,50.34 132.01,53.93 132.01,101.41 126.18,107.24 114.74,107.24 82.22,139.76 82.22,210.09 88.97,216.84 130.14,216.84 132.96,219.66 166.09,219.66 166.73,219.01 166.73,216.98 166.3,216.55 165.38,216.55 v2(164.91,217.02)
  L30_SIGNAL w0.071: v2(164.91,217.02) 164.44,216.56 159.84,216.56 155.31,221.08 107.2,221.08 105.35,222.93 26.87,222.93 25.01,221.07 25.01,219.42 27,217.42 62.17,217.42 63.42,216.18 63.42,213.87 62.13,212.58 23.07,212.58 22.08,211.59 22.08,209.21 23.5,207.78 151.02,207.78 156.52,213.28 202.98,213.28 212.15,222.44 217.97,222.44 229.67,234.14 229.67,236.01 232.46,238.81 253.89,238.81 255.95,240.88 260.58,240.88 261.65,241.94 261.65,244.82 264.95,248.13 278.82,248.13 v1(279.29,247.66)
D13111: length 833.7
  TOP w0.086: SITE1.76 263.98,248.43 264.06,248.35 278.84,248.35 v1(279.29,248.8)
  L07_SIGNAL w0.071: D131.11 109.58,53.7 109.43,53.7 109.04,53.31 109.04,51.13 109.63,50.53 128.34,50.53 131.81,54.01 131.81,101.33 126.1,107.04 114.66,107.04 82.02,139.68 82.02,210.17 88.89,217.04 130.06,217.04 132.88,219.85 166.17,219.85 166.93,219.09 166.93,216.9 166.39,216.35 165.38,216.35 v2(164.91,215.88)
  L30_SIGNAL w0.071: v1(279.29,248.8) 278.82,248.33 264.87,248.33 261.45,244.91 261.45,242.03 260.5,241.08 255.87,241.08 253.8,239.01 232.38,239.01 229.47,236.1 229.47,234.22 217.89,222.64 212.06,222.64 202.9,213.48 156.44,213.48 150.94,207.98 23.59,207.98 22.28,209.29 22.28,211.5 23.16,212.38 62.21,212.38 63.62,213.78 63.62,216.26 62.25,217.62 27.09,217.62 25.21,219.5 25.21,220.99 26.96,222.74 105.27,222.74 107.12,220.89 155.23,220.89 159.76,216.36 164.43,216.36 v2(164.91,215.88)
