# Allegro board 8880F5-0823_RXTX.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
Net_1681: length 3
  BOTTOM w0.119: 192.47,190.12 194.3,190.12 194.78,190.59 195.26,190.59
Net_1682: length 3
  BOTTOM w0.119: 195.26,187.45 194.78,187.45 194.3,187.92 192.47,187.92
Net_2059: length 3
  BOTTOM w0.119: 402.97,139.89 402.97,141.73 402.5,142.2 402.5,142.68
Net_2060: length 3
  BOTTOM w0.119: 405.64,142.68 405.64,142.2 405.17,141.73 405.17,139.89
S1_2AUX+:
  vias: v1(184.65,132.33) v1(184.65,131.06)
S1_2AUX-:
  vias: v1(181.11,131.06) v1(182.11,132.33)
S1_AUX_100DCH002+:
  vias: v1(183.65,132.33)
S1_AUX_100DCH002-:
  vias: v1(181.11,132.33)
S1_AUXCH+: length 24
  TOP w0.203: SITE1.21 250.23,236.2 v2(250.6,236.57)
  BOTTOM w0.203: v2(250.6,236.57) 250.3,236.28 250.3,234.52 247.57,231.79 247.57,217.42
S1_AUXCH-: length 24
  TOP w0.203: v2(249.46,236.57) 249.83,236.2 SITE1.20
  BOTTOM w0.203: v2(249.46,236.57) 249.76,236.28 249.76,234.75 247.03,232.02 247.03,217.42
S1_AVDD11_RX: length 8.4
  TOP w0.231: SITE1.31 254.23,228.29 254.67,227.85
  TOP w0.508: v1(256.77,225.75) 254.67,227.85
  vias: v1(256.77,223.71)
S1_AVDD11_XTAL: length 8.8
  TOP w0.231: SITE1.105 253.03,260.95 252.87,261.11 252.87,261.45
  TOP w0.381: v1(253.72,264.54) 253.72,264.44 252.87,263.59 252.87,261.45
  vias: v1(253.72,266.58)
S1_AVDD18_RX: length 7.7
  TOP w0.231: 251.28,230.01 251.83,230.56 SITE1.25
  TOP w0.508: 251.28,230.01 251.28,228.9 251.06,228.68 v1(251.06,225.75)
  vias: v1(251.06,223.71)
S1_DCH041: length 2.2
  TOP w0.231: SITE1.159 237.43,242.83 v1(237.23,243.03)
S1_DCH042: length 3.7
  TOP w0.231: v1(235.83,243.03) 236.43,242.43 SITE1.160
S1_DCH043: length 5.3
  TOP w0.231: v1(234.44,243.03) 235.44,242.03 SITE1.161
S1_DCH044: length 2.2
  TOP w0.231: SITE1.163 237.43,241.23 v1(237.23,241.03)
S1_DCH045: length 5.4
  TOP w0.231: v1(244.35,239.83) 243.35,240.83 SITE1.164
S1_DCH046: length 3.9
  TOP w0.231: v1(242.95,239.83) 242.35,240.43 SITE1.165
S1_DCH047: length 2.3
  TOP w0.231: SITE1.166 241.36,240.03 v1(241.56,239.83)
S1_DCH048:
  vias: v1(229.05,276.97)
S1_DCH049:
  vias: v1(229.05,271.67)
S1_DPS_F_001:
  vias: v1(182.11,131.06)
S1_DPS_F_002: length 10.1
  TOP w0.119: v1(237.98,223.71) 237.98,223.75
  TOP w0.231: SITE1.3 243.03,230.86 241.72,229.55 240.65,229.55
  TOP w0.508: v1(237.98,225.75) 237.98,226.88 240.65,229.55
  vias: v1(236.32,222.9)
S1_DPS_F_003: length 63.1
  TOP w0.231: SITE1.63 264.9,243.23 265.2,242.93 ; SITE1.37 256.63,231.59 258.57,229.66 259.73,229.66 ; 267.84,245.53 266.94,246.43 SITE1.71 ; 234.63,241.63 SITE1.162 ; SITE1.145 233.08,248.43 232.83,248.18 ; SITE1.17 248.63,229.5 249.28,228.85 ; SITE1.107 252.23,260.11 251.69,260.65 251.69,261.16
  TOP w0.381: v1(251.94,264.54) 251.69,264.28 251.69,261.16
  TOP w0.508: 267.84,245.53 269.46,243.91 v1(271.22,243.91) ; v1(262.36,225.75) 262.36,227.02 259.73,229.66 ; v1(231.44,243.41) 232.59,243.41 234.37,241.63 234.63,241.63 ; v1(231.44,247.93) 232.58,247.93 232.83,248.18 ; v1(271.22,241.37) 268.11,241.37 266.8,242.67 265.45,242.67 265.2,242.93 ; v1(249.28,225.75) 249.28,228.85
  vias: v1(229.4,247.93) v1(229.4,243.41) v1(249.28,223.71) v1(251.54,252.59) v1(251.94,266.58) v1(262.36,223.71) v1(273.27,243.91) v1(273.27,241.37)
S1_DPS_F_006: length 9.8
  TOP w0.231: SITE1.72 267.92,246.83 268.55,246.19
  TOP w0.508: v1(271.22,245.18) 269.56,245.18 268.55,246.19
  BOTTOM w0.119: CC40.1 v1(259,246.67)
  vias: v1(273.27,245.18)
S1_DPS_F_007: length 19.2
  TOP w0.231: SITE1.78 264.15,249.23 264.37,249.01
  TOP w0.254: CD11.1 v1(259.65,264.54) 259.65,264.22 256.23,260.8 SITE1.97
  TOP w0.508: 264.37,249.01 270.31,249.01 270.8,249.5 v1(271.22,249.5)
  BOTTOM w0.119: CC27.1 v1(273.27,249.5)
  vias: v1(259.65,266.58)
S1_DPS_F_009: length 8.8
  TOP w0.231: SITE1.106 252.63,260.53 252.26,260.9 252.26,261.12
  TOP w0.381: v1(252.83,264.54) 252.83,264.39 252.26,263.82 252.26,261.12
  vias: v1(252.83,266.58) v1(253.61,267.66)
S1_DPS_F_010: length 8.6
  TOP w0.231: 251.05,261.13 251.05,260.57 250.63,260.15 SITE1.111
  TOP w0.381: 251.05,261.13 v1(251.05,264.54)
  vias: v1(250.34,253.59) v1(251.05,266.58)
S1_DPS_F_011: length 17.6
  TOP w0.231: 247.64,258.01 247.43,257.79 SITE1.119 ; v1(231.44,253.69) 232.01,253.69 234.87,250.83 SITE1.139
  TOP w0.508: v1(247.57,264.54) 247.64,264.47 247.64,258.01
  vias: v1(229.4,253.69) v1(247.57,266.58)
S1_DPS_F_012: length 8
  TOP w0.231: 232.2,248.83 SITE1.144
  TOP w0.508: 232.2,248.83 231.81,248.83 v1(231.44,249.2)
  vias: v1(229.4,249.2)
S1_ISP00+: length 72.8
  TOP w0.086: SITE1.73 263.98,247.23 264.06,247.31 270.41,247.31 271.56,246.16 275.81,246.16 v1(276.24,245.73)
  L32_SIGNAL w0.071: v1(276.24,245.73) 276.72,246.2 285.9,246.2 288.86,249.16 288.86,256.76 286.57,259.04 282.86,259.04 277.77,264.13 277.77,274.81 276.19,276.39 270.56,276.39 270.04,276.91 v1(270.04,280.1)
S1_ISP00-: length 72.8
  TOP w0.086: SITE1.74 263.98,247.63 264.06,247.55 270.51,247.55 271.66,246.4 275.77,246.4 v1(276.24,246.87)
  L32_SIGNAL w0.071: v1(270.04,272.1) 270.04,276.12 270.12,276.19 276.11,276.19 277.57,274.73 277.57,264.04 282.78,258.84 286.49,258.84 288.66,256.67 288.66,249.24 285.82,246.4 276.72,246.4 v1(276.24,246.87)
S1_ISP14+: length 72.8
  TOP w0.086: v1(252.86,269.15) 252.42,268.71 252.42,267.92 251.76,267.26 250.73,267.26 250.15,266.68 250.15,257.86 250.23,257.78 SITE1.112
  L28_SIGNAL w0.071: v1(265.64,280.1) 265.64,276.46 266.69,275.42 277.44,275.42 278.89,276.87 278.89,280.93 277.73,282.08 259.25,282.08 252.39,275.23 252.39,269.62 v1(252.86,269.15)
S1_ISP14-: length 72.8
  TOP w0.086: v1(251.72,269.15) 252.18,268.69 252.18,268.02 251.66,267.5 250.63,267.5 249.91,266.78 249.91,257.86 249.83,257.78 SITE1.113
  L28_SIGNAL w0.071: v1(265.64,272.1) 265.64,275.15 265.72,275.22 277.52,275.22 279.08,276.78 279.08,281.01 277.81,282.28 259.16,282.28 252.19,275.31 252.19,269.62 v1(251.72,269.15)
S1_ISP_1LOCK:
  vias: v1(229.91,245.39)
S1_M_DPS_F_001: length 45.2
  TOP w0.231: 266.49,243.63 SITE1.64 ; 260.57,230.37 258.54,230.37 257.43,231.49 SITE1.39 ; SITE1.104 253.43,263.21 ; 250.63,230.54 SITE1.22 ; 233.24,247.18 233.7,247.63 SITE1.147
  TOP w0.381: v1(254.61,264.54) 254.61,264.39 253.43,263.21
  TOP w0.508: 260.57,230.37 263.63,227.31 v1(263.63,225.75) ; 266.49,243.63 267.49,243.63 268.48,242.64 v1(271.22,242.64) ; v1(231.44,246.66) 232.72,246.66 233.24,247.18 ; 250.63,230.54 250.38,230.28 250.38,229.17 250.17,228.96 v1(250.17,225.75)
  vias: v1(229.4,246.66) v1(250.17,223.71) v1(254.61,266.58) v1(263.63,223.71) v1(273.27,242.64)
S1_PS9G_DCH001: length 3.7
  TOP w0.231: v1(249.63,229.63) 249.03,230.23 SITE1.18
S1_PS9G_DCH002: length 2.2
  TOP w0.231: SITE1.19 249.43,231.23 v1(249.63,231.03)
S1_PS9G_DCH003: length 2.2
  TOP w0.231: v1(251.23,231.03) 251.43,231.23 SITE1.24
S1_PS9G_DCH004: length 2.2
  TOP w0.231: v1(257.63,235.23) 257.83,235.03 SITE1.40
S1_PS9G_DCH005: length 2.2
  TOP w0.231: SITE1.45 264.23,236.03 v1(264.43,235.83)
S1_PS9G_DCH006: length 3.7
  TOP w0.231: v1(265.83,235.83) 265.23,236.43 SITE1.46
S1_PS9G_DCH007: length 5.3
  TOP w0.231: v1(267.23,235.83) 266.22,236.83 SITE1.47
S1_PS9G_DCH009: length 2.2
  TOP w0.231: v1(264.43,237.43) 264.23,237.63 SITE1.49
S1_PS9G_DCH010: length 3.7
  TOP w0.231: v1(265.83,237.43) 265.23,238.03 SITE1.50
S1_PS9G_DCH011: length 5.3
  TOP w0.231: SITE1.51 266.22,238.43 v1(267.23,237.43)
S1_PS9G_DCH014: length 3.7
  TOP w0.231: SITE1.54 265.23,239.63 v1(265.83,239.03)
S1_PS9G_DCH015: length 5.3
  TOP w0.231: SITE1.55 266.22,240.03 v1(267.23,239.03)
S1_PS9G_DCH022: length 5.3
  TOP w0.231: v1(267.23,245.03) 267.05,245.03 266.05,244.03 SITE1.65
S1_PS9G_DCH023: length 2.5
  TOP w0.231: v1(264.43,245.03) 264.43,244.83 264.03,244.43 SITE1.66
S1_PS9G_DCH027: length 3.9
  TOP w0.231: SITE1.70 264.83,246.03 v1(265.83,245.03)
S1_PS9G_DCH028: length 2.3
  TOP w0.231: v1(260.23,248.46) 260.6,248.83 SITE1.77
S1_PS9G_DCH029: length 2.2
  TOP w0.231: v1(248.03,254.03) 247.83,254.23 SITE1.118
S1_PS9G_DCH030: length 9.2
  TOP w0.231: SITE1.148 237.62,247.23 237.3,246.91 234.16,246.91 232.63,245.39 v1(230.91,245.39)
S1_PS9G_DCH035: length 5.3
  TOP w0.231: SITE1.153 235.44,245.23 v1(234.44,246.23)
S1_PS9G_DCH036: length 2.2
  TOP w0.231: SITE1.154 241.23,244.83 v1(241.43,245.03)
S1_PS9G_DCH037: length 2.2
  TOP w0.231: SITE1.155 237.43,244.43 v1(237.23,244.63)
S1_PS9G_DCH038: length 3.7
  TOP w0.231: SITE1.156 236.43,244.03 v1(235.83,244.63)
S1_PS9G_DCH039: length 5.3
  TOP w0.231: SITE1.157 235.44,243.63 v1(234.44,244.63)
S1_PS9G_DCH040: length 2.2
  TOP w0.231: v1(241.43,243.43) 241.23,243.23 SITE1.158
S1_RLY_001:
  vias: v1(167.7,222.95) v1(201.23,236.67)
S1_RLY_003:
  vias: v1(290.64,288.86) v1(303.84,288.86)
S1_RLY_005:
  vias: v1(330.51,288.86) v1(343.98,288.86)
S1_RLY_007:
  vias: v1(317.05,288.86)
S1_RLY_008:
  vias: v1(263.71,288.86) v1(293.31,280.1)
S1_RLY_016:
  vias: v1(244.8,296.61) v1(250.5,288.86)
S1_RLY_018:
  vias: v1(232.25,276.97)
S1_RLY_021:
  vias: v1(167.7,264.1) v1(277.17,288.86)
S1_RLY_022:
  vias: v1(167.7,236.67) v1(201.23,250.38)
S1_RLY_023:
  vias: v1(184.47,236.67)
S1_RLY_025:
  vias: v1(167.7,250.38) v1(200.98,264.1)
S1_RLY_026:
  vias: v1(184.47,250.38)
S1_RLY_030:
  vias: v1(184.47,264.1)
S1_RLY_043:
  vias: v1(273.24,280.1)
S1_SCAN_DCH008: length 2.2
  TOP w0.231: SITE1.48 260.43,237.23 v1(260.23,237.03)
S1_SCAN_DCH012: length 2.2
  TOP w0.231: v1(260.23,238.63) 260.43,238.83 SITE1.52
S1_SCAN_DCH013: length 2.2
  TOP w0.231: v1(264.43,239.03) 264.23,239.23 SITE1.53
S1_SCAN_DCH016: length 2.2
  TOP w0.231: SITE1.56 260.43,240.43 v1(260.23,240.23)
S1_SCAN_DCH017: length 2.2
  TOP w0.231: v1(264.43,240.63) 264.23,240.83 SITE1.57
S1_SCAN_DCH018: length 3.7
  TOP w0.231: v1(265.83,240.63) 265.23,241.23 SITE1.58
S1_SCAN_DCH019: length 5.3
  TOP w0.231: SITE1.59 266.22,241.63 v1(267.23,240.63)
S1_SCAN_DCH020: length 2.2
  TOP w0.231: SITE1.60 260.43,242.03 v1(260.23,241.83)
S1_SCAN_DCH021: length 2.2
  TOP w0.231: v1(264.43,242.23) 264.23,242.43 SITE1.61
S1_SCAN_DCH024: length 2.2
  TOP w0.231: SITE1.67 260.43,244.83 v1(260.23,244.63)
S1_SCAN_DCH025: length 3.7
  TOP w0.231: v1(258.83,244.63) 259.43,245.23 SITE1.68
S1_SCAN_DCH026: length 5.3
  TOP w0.231: v1(257.44,244.63) 258.44,245.63 SITE1.69
S1_SCAN_DCH031: length 3.7
  TOP w0.231: v1(242.83,247.43) 242.23,246.83 SITE1.149
S1_SCAN_DCH032: length 5.3
  TOP w0.231: v1(244.22,247.43) 243.22,246.43 SITE1.150
S1_SCAN_DCH033: length 2.2
  TOP w0.231: SITE1.151 237.43,246.03 v1(237.23,246.23)
S1_SCAN_DCH034: length 3.7
  TOP w0.231: v1(235.83,246.23) 236.43,245.63 SITE1.152
S1_SPI_CSN: length 25.9
  TOP w0.231: v1(259.23,231.03) 259.03,231.23 SITE1.43
  BOTTOM w0.231: 250.11,219.95 250.61,220.44 252.25,220.44 252.91,221.11 252.91,233.59 253.58,234.25 255.17,234.25 258.4,231.03 v1(259.23,231.03)
S1_SPI_SCK: length 25.3
  TOP w0.231: v1(258.83,235.23) 258.63,235.03 SITE1.42
  BOTTOM w0.231: v1(258.83,235.23) 258.83,233.98 260.53,232.28 260.53,229.11 259.96,228.54 257.9,228.54 257.17,229.27 255.92,229.27 255.03,228.39 255.03,218.48
S1_SPI_SDI: length 27.5
  TOP w0.231: v1(258.83,236.63) 259.43,236.03 SITE1.44
  BOTTOM w0.231: 258.07,218.19 258.07,226.28 258.85,227.06 262.04,227.06 262.6,227.63 262.6,232.86 v1(258.83,236.63)
S1_SPI_SDO: length 29.1
  TOP w0.231: SITE1.41 258.23,236.03 v1(257.63,236.63)
  BOTTOM w0.231: v1(257.63,236.63) 258.83,237.83 261.5,237.83 262.29,237.04 262.29,235.83 264.72,233.4 264.72,218.19
S1_XTAL_IN: length 2.2
  TOP w0.231: v1(251.63,258.23) 251.43,258.03 SITE1.109
  vias: v1(226.85,271.67)
S1_XTAL_OUT: length 3.7
  TOP w0.231: v1(251.63,259.63) 251.03,259.03 SITE1.110
  vias: v1(226.85,276.97)
S2_2AUX+:
  vias: v1(290.31,132.08) v1(290.31,130.81)
S2_2AUX-:
  vias: v1(286.77,130.81) v1(287.77,132.08)
S2_AUX_100DCH002+:
  vias: v1(289.31,132.08)
S2_AUX_100DCH002-:
  vias: v1(286.77,132.08)
S2_AUXCH+: length 32.3
  TOP w0.203: v2(330.6,236.57) 330.23,236.2 SITE2.21
  BOTTOM w0.203: v2(330.6,236.57) 330.3,236.28 330.3,234.52 327.57,231.79 327.57,209.14
S2_AUXCH-: length 32.1
  TOP w0.203: SITE2.20 329.83,236.2 v2(329.46,236.57)
  BOTTOM w0.203: 327.02,209.37 327.02,232.02 329.76,234.75 329.76,236.28 v2(329.46,236.57)
S2_AVDD11_RX: length 8.4
  TOP w0.231: SITE2.31 334.23,228.29 334.67,227.85
  TOP w0.508: v1(336.77,225.75) 334.67,227.85
  vias: v1(336.77,223.71)
S2_AVDD11_XTAL: length 8.8
  TOP w0.231: 332.87,261.45 332.87,261.11 333.03,260.95 SITE2.105
  TOP w0.381: v1(333.72,264.54) 333.72,264.44 332.87,263.59 332.87,261.45
  vias: v1(333.72,266.58)
S2_AVDD18_RX: length 7.7
  TOP w0.231: 331.28,230.01 331.83,230.56 SITE2.25
  TOP w0.508: 331.28,230.01 331.28,228.9 331.06,228.68 v1(331.06,225.75)
  vias: v1(331.06,223.71)
S2_DCH041: length 2.2
  TOP w0.231: v1(317.23,243.03) 317.43,242.83 SITE2.159
S2_DCH042: length 3.7
  TOP w0.231: SITE2.160 316.43,242.43 v1(315.83,243.03)
S2_DCH043: length 5.3
  TOP w0.231: SITE2.161 315.44,242.03 v1(314.43,243.03)
S2_DCH044: length 2.2
  TOP w0.231: v1(317.23,241.03) 317.43,241.23 SITE2.163
S2_DCH045: length 5.4
  TOP w0.231: v1(324.35,239.83) 323.35,240.83 SITE2.164
S2_DCH046: length 3.9
  TOP w0.231: SITE2.165 322.35,240.43 v1(322.95,239.83)
S2_DCH047: length 2.3
  TOP w0.231: v1(321.56,239.83) 321.36,240.03 SITE2.166
S2_DCH048:
  vias: v1(309.05,276.97)
S2_DCH049:
  vias: v1(309.05,271.67)
S2_DPS_F_001:
  vias: v1(287.77,130.81)
S2_DPS_F_002: length 10.1
  TOP w0.231: SITE2.3 323.03,230.86 321.72,229.55 320.65,229.55
  TOP w0.508: 320.65,229.55 317.98,226.88 v1(317.98,225.75)
  vias: v1(316.32,222.9) v1(317.98,223.71)
S2_DPS_F_003: length 63.1
  TOP w0.231: 347.84,245.53 346.94,246.43 SITE2.71 ; 312.83,248.18 313.08,248.43 SITE2.145 ; 345.2,242.93 344.9,243.23 SITE2.63 ; 329.28,228.85 328.63,229.5 SITE2.17 ; SITE2.37 336.63,231.59 338.57,229.66 339.73,229.66 ; SITE2.107 332.23,260.11 331.69,260.65 331.69,261.16 ; 314.63,241.63 SITE2.162
  TOP w0.381: 331.69,261.16 331.69,264.28 v1(331.94,264.54)
  TOP w0.508: v1(351.22,243.91) 349.45,243.91 347.84,245.53 ; 312.83,248.18 312.58,247.93 v1(311.44,247.93) ; v1(329.28,225.75) 329.28,228.85 ; v1(351.22,241.37) 348.11,241.37 346.8,242.67 345.45,242.67 345.2,242.93 ; v1(311.44,243.41) 312.59,243.41 314.37,241.63 314.63,241.63 ; 342.36,225.75 342.36,227.02 339.73,229.66
  vias: v1(309.4,247.93) v1(309.4,243.41) v1(329.28,223.71) v1(331.94,266.58) v1(342.36,223.71) v1(353.27,243.91) v1(353.27,241.37) v1(464.57,235.71)
S2_DPS_F_006: length 9.6
  TOP w0.231: 348.55,246.19 347.92,246.83 SITE2.72
  TOP w0.508: v1(351.22,245.18) 349.56,245.18 348.55,246.19
  vias: v1(339,246.67) v1(353.27,245.18)
S2_DPS_F_007: length 19
  TOP w0.231: v1(339.65,264.54) 339.65,264.13 336.23,260.71 SITE2.97 ; 344.37,249.01 344.15,249.23 SITE2.78
  TOP w0.508: v1(351.22,249.5) 350.8,249.5 350.31,249.01 344.37,249.01
  vias: v1(339.65,266.58) v1(353.27,249.5)
S2_DPS_F_009: length 8.8
  TOP w0.231: 332.26,261.12 332.26,260.9 332.63,260.53 SITE2.106
  TOP w0.381: v1(332.83,264.54) 332.83,264.39 332.26,263.82 332.26,261.12
  vias: v1(332.83,266.58) v1(333.61,267.66)
S2_DPS_F_010: length 8.6
  TOP w0.231: SITE2.111 330.63,260.15 331.05,260.57 331.05,261.13
  TOP w0.381: 331.05,261.13 v1(331.05,264.54)
  vias: v1(330.63,253.59) v1(331.05,266.58)
S2_DPS_F_011: length 17.6
  TOP w0.231: SITE2.139 314.87,250.83 312.01,253.69 v1(311.44,253.69) ; SITE2.119 327.43,257.79 327.64,258.01
  TOP w0.508: v1(327.57,264.54) 327.64,264.47 327.64,258.01
  vias: v1(309.4,253.69) v1(327.57,266.58)
S2_DPS_F_012: length 8
  TOP w0.231: 312.2,248.83 SITE2.144
  TOP w0.508: 312.2,248.83 311.81,248.83 v1(311.44,249.2)
  vias: v1(309.4,249.2)
S2_DPS_F_013:
  vias: v1(452.62,232.41) v1(452.62,224.79) v1(457.25,233.88) v1(474.87,217.23) v1(474.89,204.98) v1(474.99,218.59) v1(475.99,230.78) v1(478.43,217.17) v1(478.43,204.98) v1(478.53,230.78) v1(478.53,218.59) v1(480.97,204.98) v1(481.07,218.59) v1(482.1,241.3) v1(482.1,233.68) v1(483.51,204.98) v1(483.61,218.59) v1(489.86,212.91) v1(490.1,226.67)
S2_ISP00+: length 155.1
  TOP w0.086: v1(356.24,245.73) 355.81,246.16 351.56,246.16 350.41,247.31 344.06,247.31 343.98,247.23 SITE2.73
  L32_SIGNAL w0.071: v1(386.29,257.11) 386.29,260.62 386.21,260.7 381.34,260.7 380.96,260.32 380.96,256.39 383.13,254.22 390.83,254.22 399.45,262.84 418.94,262.84 422.94,258.84 422.94,247.79 420.36,245.21 360.9,245.21 359.91,246.2 356.72,246.2 v1(356.24,245.73)
S2_ISP00-: length 155.1
  TOP w0.086: v1(356.24,246.87) 355.77,246.4 351.66,246.4 350.51,247.55 344.06,247.55 343.98,247.63 SITE2.74
  L32_SIGNAL w0.071: v1(386.29,265.11) 386.29,262.08 385.11,260.9 381.26,260.9 380.76,260.4 380.76,256.31 383.05,254.02 390.91,254.02 399.53,262.64 418.85,262.64 422.74,258.76 422.74,247.87 420.28,245.41 360.99,245.41 359.99,246.4 356.72,246.4 v1(356.24,246.87)
S2_ISP14+: length 155.1
  TOP w0.086: v1(332.86,269.15) 332.42,268.71 332.42,267.92 331.76,267.26 330.73,267.26 330.15,266.68 330.15,257.86 330.23,257.78 SITE2.112
  L28_SIGNAL w0.071: v1(332.86,269.15) 332.39,269.62 332.39,271.2 334.58,273.39 358.16,273.39 359.22,274.46 359.22,276.14 358.06,277.31 329.86,277.31 329.51,277.66 329.51,278.59 329.83,278.91 357.85,278.91 362.5,274.26 362.5,266.62 367.84,261.28 390.11,261.28 390.69,260.7 v1(390.69,257.11)
S2_ISP14-: length 155.1
  TOP w0.086: SITE2.113 329.83,257.78 329.91,257.86 329.91,266.78 330.63,267.5 331.66,267.5 332.18,268.02 332.18,268.69 v1(331.72,269.15)
  L28_SIGNAL w0.071: v1(331.72,269.15) 332.19,269.62 332.19,271.28 334.5,273.59 358.07,273.59 359.02,274.54 359.02,276.06 357.97,277.11 329.77,277.11 329.31,277.57 329.31,278.67 329.75,279.11 357.94,279.11 362.7,274.34 362.7,266.71 367.92,261.48 390.47,261.48 390.69,261.71 v1(390.69,265.11)
S2_M_DPS_F_001: length 45.2
  TOP w0.231: SITE2.39 337.43,231.49 338.54,230.37 340.57,230.37 ; SITE2.104 333.43,263.21 ; 330.63,230.54 SITE2.22 ; 313.24,247.18 313.7,247.63 SITE2.147 ; 346.49,243.63 SITE2.64
  TOP w0.381: v1(334.61,264.54) 334.61,264.39 333.43,263.21
  TOP w0.508: 330.63,230.54 330.38,230.28 330.38,229.17 330.17,228.96 v1(330.17,225.75) ; v1(311.44,246.66) 312.72,246.66 313.24,247.18 ; 346.49,243.63 347.49,243.63 348.48,242.64 v1(351.22,242.64) ; 340.57,230.37 343.63,227.31 v1(343.63,225.75)
  vias: v1(309.4,246.66) v1(330.17,223.71) v1(334.61,266.58) v1(343.63,223.71) v1(353.27,242.64)
S2_PS9G_DCH001: length 3.7
  TOP w0.231: v1(329.63,229.63) 329.03,230.23 SITE2.18
S2_PS9G_DCH002: length 2.2
  TOP w0.231: v1(329.63,231.03) 329.43,231.23 SITE2.19
S2_PS9G_DCH003: length 2.2
  TOP w0.231: SITE2.24 331.43,231.23 v1(331.23,231.03)
S2_PS9G_DCH004: length 2.2
  TOP w0.231: SITE2.40 337.83,235.03 v1(337.63,235.23)
S2_PS9G_DCH005: length 2.2
  TOP w0.231: v1(344.43,235.83) 344.23,236.03 SITE2.45
S2_PS9G_DCH006: length 3.7
  TOP w0.231: v1(345.83,235.83) 345.23,236.43 SITE2.46
S2_PS9G_DCH007: length 5.3
  TOP w0.231: SITE2.47 346.22,236.83 v1(347.22,235.83)
S2_PS9G_DCH009: length 2.2
  TOP w0.231: v1(344.43,237.43) 344.23,237.63 SITE2.49
S2_PS9G_DCH010: length 3.7
  TOP w0.231: SITE2.50 345.23,238.03 v1(345.83,237.43)
S2_PS9G_DCH011: length 5.3
  TOP w0.231: SITE2.51 346.22,238.43 v1(347.22,237.43)
S2_PS9G_DCH014: length 3.7
  TOP w0.231: v1(345.83,239.03) 345.23,239.63 SITE2.54
S2_PS9G_DCH015: length 5.3
  TOP w0.231: SITE2.55 346.22,240.03 v1(347.22,239.03)
S2_PS9G_DCH022: length 5.3
  TOP w0.231: SITE2.65 346.05,244.03 347.05,245.03 v1(347.22,245.03)
S2_PS9G_DCH023: length 2.5
  TOP w0.231: v1(344.43,245.03) 344.43,244.83 344.03,244.43 SITE2.66
S2_PS9G_DCH027: length 3.9
  TOP w0.231: v1(345.83,245.03) 344.83,246.03 SITE2.70
S2_PS9G_DCH028: length 2.3
  TOP w0.231: v1(340.23,248.46) 340.6,248.83 SITE2.77
S2_PS9G_DCH029: length 2.2
  TOP w0.231: SITE2.118 327.83,254.23 v1(328.03,254.03)
S2_PS9G_DCH030: length 9.2
  TOP w0.231: SITE2.148 317.62,247.23 317.3,246.91 314.16,246.91 312.63,245.39 v1(310.91,245.39)
S2_PS9G_DCH035: length 5.3
  TOP w0.231: SITE2.153 315.44,245.23 v1(314.43,246.23)
S2_PS9G_DCH036: length 2.2
  TOP w0.231: v1(321.43,245.03) 321.23,244.83 SITE2.154
S2_PS9G_DCH037: length 2.2
  TOP w0.231: SITE2.155 317.43,244.43 v1(317.23,244.63)
S2_PS9G_DCH038: length 3.7
  TOP w0.231: v1(315.83,244.63) 316.43,244.03 SITE2.156
S2_PS9G_DCH039: length 5.3
  TOP w0.231: SITE2.157 315.44,243.63 v1(314.43,244.63)
S2_PS9G_DCH040: length 2.2
  TOP w0.231: v1(321.43,243.43) 321.23,243.23 SITE2.158
S2_RLY_001:
  vias: v1(410.52,289.12) v1(410.52,273.37)
S2_RLY_003:
  vias: v1(369.63,273.11) v1(396.55,241.11)
S2_RLY_005:
  vias: v1(396.55,273.11) v1(396.55,257.37)
S2_RLY_007:
  vias: v1(383.09,273.11)
S2_RLY_008:
  vias: v1(383.09,289.12) v1(410.27,257.37)
S2_RLY_016:
  vias: v1(369.38,257.11) v1(369.63,289.12)
S2_RLY_018:
  vias: v1(312.25,276.97)
S2_RLY_021:
  vias: v1(369.38,241.11) v1(396.55,289.12)
S2_RLY_022:
  vias: v1(369.38,224.6) v1(383.09,241.11)
S2_RLY_023:
  vias: v1(383.09,224.85)
S2_RLY_025:
  vias: v1(376.23,209.11) v1(396.55,225.11)
S2_RLY_026:
  vias: v1(389.7,209.36)
S2_RLY_030:
  vias: v1(410.52,241.11)
S2_RLY_043:
  vias: v1(383.09,257.11)
S2_SCAN_DCH008: length 2.2
  TOP w0.231: v1(340.23,237.03) 340.43,237.23 SITE2.48
S2_SCAN_DCH012: length 2.2
  TOP w0.231: v1(340.23,238.63) 340.43,238.83 SITE2.52
S2_SCAN_DCH013: length 2.2
  TOP w0.231: v1(344.43,239.03) 344.23,239.23 SITE2.53
S2_SCAN_DCH016: length 2.2
  TOP w0.231: SITE2.56 340.43,240.43 v1(340.23,240.23)
S2_SCAN_DCH017: length 2.2
  TOP w0.231: v1(344.43,240.63) 344.23,240.83 SITE2.57
S2_SCAN_DCH018: length 3.7
  TOP w0.231: SITE2.58 345.23,241.23 v1(345.83,240.63)
S2_SCAN_DCH019: length 5.3
  TOP w0.231: v1(347.22,240.63) 346.22,241.63 SITE2.59
S2_SCAN_DCH020: length 2.2
  TOP w0.231: SITE2.60 340.43,242.03 v1(340.23,241.83)
S2_SCAN_DCH021: length 2.2
  TOP w0.231: SITE2.61 344.23,242.43 v1(344.43,242.23)
S2_SCAN_DCH024: length 2.2
  TOP w0.231: SITE2.67 340.43,244.83 v1(340.23,244.63)
S2_SCAN_DCH025: length 3.7
  TOP w0.231: v1(338.83,244.63) 339.43,245.23 SITE2.68
S2_SCAN_DCH026: length 5.3
  TOP w0.231: v1(337.44,244.63) 338.44,245.63 SITE2.69
S2_SCAN_DCH031: length 3.7
  TOP w0.231: v1(322.83,247.43) 322.23,246.83 SITE2.149
S2_SCAN_DCH032: length 5.3
  TOP w0.231: v1(324.22,247.43) 323.22,246.43 SITE2.150
S2_SCAN_DCH033: length 2.2
  TOP w0.231: SITE2.151 317.43,246.03 v1(317.23,246.23)
S2_SCAN_DCH034: length 3.7
  TOP w0.231: v1(315.83,246.23) 316.43,245.63 SITE2.152
S2_SPI_1_CSN:
  vias: v1(474.99,230.78)
S2_SPI_1_SCK:
  vias: v1(480.07,218.59)
S2_SPI_1_SDI:
  vias: v1(456.19,217.17)
S2_SPI_1_SDO:
  vias: v1(455.94,209.55)
S2_SPI_2_CSN:
  vias: v1(475.87,217.23)
S2_SPI_2_SCK:
  vias: v1(479.97,204.98)
S2_SPI_2_SDI:
  vias: v1(451.62,217.17)
S2_SPI_2_SDO:
  vias: v1(451.87,209.55)
S2_SPI_11_SDI:
  vias: v1(457.19,217.17) v1(477.53,230.78)
S2_SPI_11_SDO:
  vias: v1(456.94,209.55) v1(482.61,218.59)
S2_SPI_22_SDI:
  vias: v1(452.62,217.17) v1(477.43,217.17)
S2_SPI_22_SDO:
  vias: v1(452.87,209.55) v1(482.51,204.98)
S2_SPI_CSN: length 25.9
  TOP w0.231: v1(339.23,231.03) 339.03,231.23 SITE2.43
  BOTTOM w0.231: 330.11,219.95 330.61,220.44 332.25,220.44 332.91,221.11 332.91,233.59 333.57,234.25 335.17,234.25 338.4,231.03 v1(339.23,231.03)
S2_SPI_SCK: length 25.3
  TOP w0.231: SITE2.42 338.63,235.03 v1(338.83,235.23)
  BOTTOM w0.231: v1(338.83,235.23) 338.83,233.98 340.53,232.28 340.53,229.11 339.96,228.54 337.9,228.54 337.17,229.27 335.92,229.27 335.03,228.39 335.03,218.48
S2_SPI_SDI: length 34.1
  TOP w0.231: SITE2.44 339.43,236.03 v1(338.83,236.63)
  BOTTOM w0.231: 338.07,211.53 338.07,226.28 338.85,227.06 342.04,227.06 342.6,227.63 342.6,232.86 v1(338.83,236.63)
S2_SPI_SDO: length 37
  TOP w0.231: SITE2.41 338.23,236.03 v1(337.63,236.63)
  BOTTOM w0.231: 344.72,210.32 344.72,233.4 342.29,235.83 342.29,237.04 341.5,237.83 338.83,237.83 v1(337.63,236.63)
S2_XTAL_IN: length 28.3
  TOP w0.231: SITE2.109 331.43,258.03 v1(331.63,258.23)
  BOTTOM w0.231: 314.98,275.24 318.94,271.27 318.94,267.1 327.82,258.23 v1(331.63,258.23)
  vias: v1(306.85,271.67)
S2_XTAL_OUT: length 26.8
  TOP w0.231: SITE2.110 331.03,259.03 v1(331.63,259.63)
  BOTTOM w0.231: v1(331.63,259.63) 329.83,259.63 322.59,266.87 322.59,271.15 320.8,272.93 320.8,274.36 318.8,276.35
  vias: v1(306.85,276.97)
S3_2AUX+:
  vias: v1(192.78,132.33) v1(192.78,131.06)
S3_2AUX-:
  vias: v1(189.24,131.06) v1(190.24,132.33)
S3_AUX_100DCH002+:
  vias: v1(191.78,132.33)
S3_AUX_100DCH002-:
  vias: v1(189.24,132.33)
S3_AUXCH+: length 32.3
  TOP w0.203: SITE3.21 250.23,176.2 v2(250.6,176.57)
  BOTTOM w0.203: v2(250.6,176.57) 250.3,176.28 250.3,174.52 247.57,171.79 247.57,149.14
S3_AUXCH-: length 32.1
  TOP w0.203: v2(249.46,176.57) 249.83,176.2 SITE3.20
  BOTTOM w0.203: 247.03,149.37 247.03,172.02 249.76,174.75 249.76,176.28 v2(249.46,176.57)
S3_AVDD11_RX: length 8.4
  TOP w0.231: 254.67,167.85 254.23,168.29 SITE3.31
  TOP w0.508: v1(256.77,165.75) 254.67,167.85
  vias: v1(256.77,163.71)
S3_AVDD11_XTAL: length 8.8
  TOP w0.231: 252.87,201.45 252.87,201.11 253.03,200.95 SITE3.105
  TOP w0.381: v1(253.72,204.54) 253.72,204.45 252.87,203.59 252.87,201.45
  vias: v1(253.72,206.58)
S3_AVDD18_RX: length 7.7
  TOP w0.231: 251.28,170.01 251.83,170.56 SITE3.25
  TOP w0.508: v1(251.06,165.75) 251.06,168.68 251.28,168.9 251.28,170.01
  vias: v1(251.06,163.71)
S3_DCH041: length 2.2
  TOP w0.231: SITE3.159 237.43,182.83 v1(237.23,183.03)
S3_DCH042: length 3.7
  TOP w0.231: SITE3.160 236.43,182.43 v1(235.83,183.03)
S3_DCH043: length 5.3
  TOP w0.231: SITE3.161 235.44,182.03 v1(234.44,183.03)
S3_DCH044: length 2.2
  TOP w0.231: SITE3.163 237.43,181.23 v1(237.23,181.03)
S3_DCH045: length 5.4
  TOP w0.231: SITE3.164 243.35,180.83 v1(244.35,179.83)
S3_DCH046: length 3.9
  TOP w0.231: SITE3.165 242.35,180.43 v1(242.95,179.83)
S3_DCH047: length 2.3
  TOP w0.231: SITE3.166 241.36,180.03 v1(241.56,179.83)
S3_DPS_F_001:
  vias: v1(190.24,131.06)
S3_DPS_F_002: length 10.1
  TOP w0.231: SITE3.3 243.03,170.86 241.72,169.55 240.65,169.55
  TOP w0.508: v1(237.98,165.75) 237.98,166.88 240.65,169.55
  vias: v1(236.32,162.9) v1(237.98,163.71)
S3_DPS_F_003: length 63.1
  TOP w0.231: 249.28,168.85 248.63,169.5 SITE3.17 ; 232.83,188.18 233.08,188.43 SITE3.145 ; SITE3.37 256.63,171.59 258.57,169.66 259.73,169.66 ; 265.2,182.93 264.9,183.23 SITE3.63 ; 267.84,185.53 266.94,186.43 SITE3.71 ; 251.69,201.16 251.69,200.65 252.23,200.11 SITE3.107 ; 234.63,181.63 SITE3.162
  TOP w0.381: v1(251.94,204.54) 251.69,204.28 251.69,201.16
  TOP w0.508: v1(249.28,165.75) 249.28,168.85 ; 232.83,188.18 232.58,187.93 v1(231.44,187.93) ; v1(262.36,165.75) 262.36,167.02 259.73,169.66 ; 267.84,185.53 269.46,183.91 v1(271.22,183.91) ; v1(271.22,181.37) 268.11,181.37 266.8,182.68 265.45,182.68 265.2,182.93 ; 234.63,181.63 234.37,181.63 232.59,183.41 v1(231.44,183.41)
  vias: v1(229.4,187.93) v1(229.4,183.41) v1(249.28,163.71) v1(251.94,206.58) v1(262.36,163.71) v1(273.27,183.91) v1(273.27,181.37)
S3_DPS_F_006: length 9.6
  TOP w0.231: SITE3.72 267.92,186.83 268.55,186.19
  TOP w0.508: v1(271.22,185.18) 269.56,185.18 268.55,186.19
  vias: v1(259,186.67) v1(273.27,185.18)
S3_DPS_F_007: length 19
  TOP w0.231: SITE3.78 264.15,189.23 264.37,189.01 ; SITE3.97 256.23,200.71 259.65,204.13 v1(259.65,204.54)
  TOP w0.508: v1(271.22,189.5) 270.8,189.5 270.31,189.01 264.37,189.01
  vias: v1(259.65,206.58) v1(273.27,189.5)
S3_DPS_F_009: length 8.8
  TOP w0.231: SITE3.106 252.63,200.53 252.26,200.9 252.26,201.12
  TOP w0.381: v1(252.83,204.54) 252.83,204.39 252.26,203.82 252.26,201.12
  vias: v1(252.83,206.58) v1(253.61,207.66)
S3_DPS_F_010: length 8.6
  TOP w0.231: 251.05,201.13 251.05,200.57 250.63,200.15 SITE3.111
  TOP w0.381: 251.05,201.13 v1(251.05,204.54)
  vias: v1(251.05,206.58)
S3_DPS_F_011: length 17.6
  TOP w0.231: SITE3.119 247.43,197.79 247.64,198.01 ; SITE3.139 234.87,190.83 232.01,193.69 v1(231.44,193.69)
  TOP w0.508: 247.64,198.01 247.64,204.47 v1(247.57,204.54)
  vias: v1(229.4,193.69) v1(247.57,206.58)
S3_DPS_F_012: length 8
  TOP w0.231: 232.2,188.83 SITE3.144
  TOP w0.508: v1(231.44,189.2) 231.81,188.83 232.2,188.83
  vias: v1(229.4,189.2)
S3_ISP00+: length 486.1
  TOP w0.086: v1(276.24,185.73) 275.81,186.16 271.56,186.16 270.41,187.31 264.06,187.31 263.98,187.23 SITE3.73
  L32_SIGNAL w0.071: v1(276.24,185.73) 275.77,186.2 270.72,186.2 269.06,184.54 269.06,174.94 261.31,167.19 244.19,167.19 236.86,159.86 218.78,159.86 210.5,151.57 200.3,151.57 195.24,146.51 164.25,146.51 162.14,148.63 162.14,163.89 166.09,167.83 168.3,167.83 171.26,170.8 171.26,184.18 170.18,185.27 170.18,196.93 173.12,199.88 201.24,199.88 201.59,199.52 201.59,198.58 201.22,198.21 177.6,198.21 176.88,197.49 176.88,196.96 177.52,196.33 201.75,196.33 202.21,195.87 202.21,195.06 201.75,194.61 174.03,194.61 173.59,194.17 173.59,191.3 174.55,190.34 196.95,190.34 197.47,189.82 197.47,189.02 196.57,188.11 183.03,188.11 182.38,187.46 175.17,187.46 174.76,187.05 174.76,186.34 175.25,185.84 212.41,185.84 213.29,184.95 213.29,182.09 212.12,180.92 175.17,180.92 173.65,179.4 173.65,173.77 175.1,172.32 187.34,172.32 188.28,173.25 188.28,178.26 187.68,178.86 v1(184.47,178.86)
S3_ISP00-: length 486.1
  TOP w0.086: v1(276.24,186.87) 275.77,186.4 271.66,186.4 270.51,187.55 264.06,187.55 263.98,187.63 SITE3.74
  L32_SIGNAL w0.071: v1(276.24,186.87) 275.77,186.4 270.64,186.4 268.86,184.62 268.86,175.02 261.23,167.39 244.11,167.39 236.78,160.06 218.7,160.06 210.42,151.77 200.22,151.77 195.16,146.71 164.33,146.71 162.34,148.71 162.34,163.8 166.17,167.63 168.38,167.63 171.46,170.72 171.46,184.26 170.37,185.35 170.37,196.84 173.21,199.68 201.16,199.68 201.39,199.44 201.39,198.66 201.14,198.4 177.52,198.4 176.69,197.57 176.69,196.88 177.43,196.13 201.67,196.13 202.01,195.79 202.01,195.15 201.67,194.81 173.95,194.81 173.39,194.25 173.39,191.22 174.47,190.14 196.87,190.14 197.28,189.74 197.28,189.1 196.49,188.31 182.95,188.31 182.3,187.66 175.08,187.66 174.56,187.14 174.56,186.26 175.17,185.64 212.32,185.64 213.1,184.87 213.1,182.17 212.04,181.11 175.08,181.11 173.45,179.48 173.45,173.69 175.02,172.12 187.42,172.12 188.47,173.17 188.47,178.49 188.84,178.86 v1(192.47,178.86)
S3_ISP14+: length 486.1
  TOP w0.086: SITE3.112 250.23,197.78 250.15,197.86 250.15,206.68 250.73,207.26 251.76,207.26 252.42,207.92 252.42,208.71 v1(252.86,209.15)
  L28_SIGNAL w0.071: v1(184.47,174.46) 188.48,174.46 188.68,174.26 188.68,173.06 188.17,172.55 183.99,172.55 182.98,173.56 182.98,175.52 179.47,179.03 133.17,179.03 129.97,175.84 129.97,171.21 132.01,169.17 211.8,169.17 215.08,165.89 215.08,161.94 214.06,160.92 211.73,160.92 205.44,167.21 197.96,167.21 196.32,165.57 189.24,165.57 184.44,160.77 163.82,160.77 161.93,162.66 109.7,162.66 106.23,166.13 106.23,202.75 111.66,208.18 214.98,208.18 215.84,209.04 223.87,209.04 225.71,210.88 232.36,210.88 235.72,207.51 251.93,207.51 252.39,207.97 252.39,208.68 v1(252.86,209.15)
S3_ISP14-: length 486.1
  TOP w0.086: SITE3.113 249.83,197.78 249.91,197.86 249.91,206.78 250.63,207.5 251.66,207.5 252.18,208.02 252.18,208.69 v1(251.72,209.15)
  L28_SIGNAL w0.071: v1(192.47,174.46) 189.13,174.46 188.88,174.21 188.88,172.98 188.26,172.35 183.91,172.35 182.78,173.48 182.78,175.44 179.39,178.84 133.25,178.84 130.17,175.76 130.17,171.29 132.09,169.37 211.88,169.37 215.28,165.97 215.28,161.86 214.14,160.72 211.65,160.72 205.35,167.02 198.04,167.02 196.4,165.37 189.33,165.37 184.52,160.57 163.74,160.57 161.84,162.47 109.61,162.47 106.03,166.05 106.03,202.83 111.58,208.38 214.9,208.38 215.76,209.24 223.79,209.24 225.63,211.08 232.44,211.08 235.81,207.71 251.85,207.71 252.19,208.05 252.19,208.68 v1(251.72,209.15)
S3_M_DPS_F_001: length 45.2
  TOP w0.231: 260.57,170.37 258.54,170.37 257.43,171.49 SITE3.39 ; SITE3.104 253.43,203.21 ; 266.49,183.63 SITE3.64 ; 233.24,187.18 233.7,187.63 SITE3.147 ; 250.63,170.54 SITE3.22
  TOP w0.381: 253.43,203.21 254.61,204.39 v1(254.61,204.54)
  TOP w0.508: v1(263.63,165.75) 263.63,167.31 260.57,170.37 ; v1(271.22,182.64) 268.48,182.64 267.49,183.63 266.49,183.63 ; v1(250.17,165.75) 250.17,168.96 250.38,169.17 250.38,170.28 250.63,170.54 ; v1(231.44,186.66) 232.72,186.66 233.24,187.18
  vias: v1(229.4,186.66) v1(250.17,163.71) v1(254.61,206.58) v1(263.63,163.71) v1(273.27,182.64)
S3_PS9G_DCH001: length 3.7
  TOP w0.231: v1(249.63,169.63) 249.03,170.23 SITE3.18
S3_PS9G_DCH002: length 2.2
  TOP w0.231: SITE3.19 249.43,171.23 v1(249.63,171.03)
S3_PS9G_DCH003: length 2.2
  TOP w0.231: v1(251.23,171.03) 251.43,171.23 SITE3.24
S3_PS9G_DCH004: length 2.2
  TOP w0.231: SITE3.40 257.83,175.03 v1(257.63,175.23)
S3_PS9G_DCH005: length 2.2
  TOP w0.231: v1(264.43,175.83) 264.23,176.03 SITE3.45
S3_PS9G_DCH006: length 3.7
  TOP w0.231: v1(265.83,175.83) 265.23,176.43 SITE3.46
S3_PS9G_DCH007: length 5.3
  TOP w0.231: v1(267.23,175.83) 266.22,176.83 SITE3.47
S3_PS9G_DCH009: length 2.2
  TOP w0.231: v1(264.43,177.43) 264.23,177.63 SITE3.49
S3_PS9G_DCH010: length 3.7
  TOP w0.231: v1(265.83,177.43) 265.23,178.03 SITE3.50
S3_PS9G_DCH011: length 5.3
  TOP w0.231: v1(267.23,177.43) 266.22,178.43 SITE3.51
S3_PS9G_DCH014: length 3.7
  TOP w0.231: v1(265.83,179.03) 265.23,179.63 SITE3.54
S3_PS9G_DCH015: length 5.3
  TOP w0.231: v1(267.23,179.03) 266.22,180.03 SITE3.55
S3_PS9G_DCH022: length 5.3
  TOP w0.231: SITE3.65 266.05,184.03 267.05,185.03 v1(267.23,185.03)
S3_PS9G_DCH023: length 2.5
  TOP w0.231: SITE3.66 264.03,184.43 264.43,184.83 v1(264.43,185.03)
S3_PS9G_DCH027: length 3.9
  TOP w0.231: SITE3.70 264.83,186.03 v1(265.83,185.03)
S3_PS9G_DCH028: length 2.3
  TOP w0.231: v1(260.23,188.46) 260.6,188.83 SITE3.77
S3_PS9G_DCH030: length 9.2
  TOP w0.231: v1(230.91,185.39) 232.63,185.39 234.16,186.91 237.3,186.91 237.62,187.23 SITE3.148
S3_PS9G_DCH035: length 5.3
  TOP w0.231: SITE3.153 235.44,185.23 v1(234.44,186.23)
S3_PS9G_DCH036: length 2.2
  TOP w0.231: v1(241.43,185.03) 241.23,184.83 SITE3.154
S3_PS9G_DCH037: length 2.2
  TOP w0.231: v1(237.23,184.63) 237.43,184.43 SITE3.155
S3_PS9G_DCH038: length 3.7
  TOP w0.231: SITE3.156 236.43,184.03 v1(235.83,184.63)
S3_PS9G_DCH039: length 5.3
  TOP w0.231: v1(234.44,184.63) 235.44,183.63 SITE3.157
S3_PS9G_DCH040: length 2.2
  TOP w0.231: v1(241.43,183.43) 241.23,183.23 SITE3.158
S3_RLY_001:
  vias: v1(256.73,140.14) v1(282.9,155.38)
S3_RLY_003:
  vias: v1(167.7,182.06) v1(269.94,143.19)
S3_RLY_005:
  vias: v1(184.47,222.95) v1(201.23,222.95)
S3_RLY_007:
  vias: v1(184.47,209.49)
S3_RLY_008:
  vias: v1(167.7,209.49) v1(184.47,195.52)
S3_RLY_016:
  vias: v1(167.7,195.52) v1(201.23,209.49)
S3_RLY_021:
  vias: v1(167.7,168.6) v1(201.23,195.52)
S3_RLY_022:
  vias: v1(184.47,154.88) v1(201.49,155.13)
S3_RLY_023:
  vias: v1(167.7,141.67)
S3_RLY_025:
  vias: v1(201.49,182.06) v1(201.49,168.6)
S3_RLY_026:
  vias: v1(184.47,168.6)
S3_RLY_030:
  vias: v1(167.7,154.88)
S3_RLY_043:
  vias: v1(184.47,182.06)
S3_SCAN_DCH008: length 2.2
  TOP w0.231: v1(260.23,177.03) 260.43,177.23 SITE3.48
S3_SCAN_DCH012: length 2.2
  TOP w0.231: v1(260.23,178.63) 260.43,178.83 SITE3.52
S3_SCAN_DCH013: length 2.2
  TOP w0.231: SITE3.53 264.23,179.23 v1(264.43,179.03)
S3_SCAN_DCH016: length 2.2
  TOP w0.231: SITE3.56 260.43,180.43 v1(260.23,180.23)
S3_SCAN_DCH017: length 2.2
  TOP w0.231: v1(264.43,180.63) 264.23,180.83 SITE3.57
S3_SCAN_DCH018: length 3.7
  TOP w0.231: SITE3.58 265.23,181.23 v1(265.83,180.63)
S3_SCAN_DCH019: length 5.3
  TOP w0.231: SITE3.59 266.22,181.63 v1(267.23,180.63)
S3_SCAN_DCH020: length 2.2
  TOP w0.231: v1(260.23,181.83) 260.43,182.03 SITE3.60
S3_SCAN_DCH021: length 2.2
  TOP w0.231: v1(264.43,182.23) 264.23,182.43 SITE3.61
S3_SCAN_DCH024: length 2.2
  TOP w0.231: SITE3.67 260.43,184.83 v1(260.23,184.63)
S3_SCAN_DCH025: length 3.7
  TOP w0.231: SITE3.68 259.43,185.23 v1(258.83,184.63)
S3_SCAN_DCH026: length 5.3
  TOP w0.231: v1(257.44,184.63) 258.44,185.63 SITE3.69
S3_SCAN_DCH031: length 3.7
  TOP w0.231: v1(242.83,187.43) 242.23,186.83 SITE3.149
S3_SCAN_DCH032: length 5.3
  TOP w0.231: SITE3.150 243.22,186.43 v1(244.22,187.43)
S3_SCAN_DCH033: length 2.2
  TOP w0.231: SITE3.151 237.43,186.03 v1(237.23,186.23)
S3_SCAN_DCH034: length 3.7
  TOP w0.231: SITE3.152 236.43,185.63 v1(235.83,186.23)
S3_SPI_CSN: length 25.9
  TOP w0.231: v1(259.23,171.03) 259.03,171.23 SITE3.43
  BOTTOM w0.231: 250.11,159.95 250.61,160.44 252.25,160.44 252.91,161.11 252.91,173.59 253.58,174.25 255.17,174.25 258.4,171.03 v1(259.23,171.03)
S3_SPI_SCK: length 25.3
  TOP w0.231: v1(258.83,175.23) 258.63,175.03 SITE3.42
  BOTTOM w0.231: v1(258.83,175.23) 258.83,173.98 260.53,172.28 260.53,169.11 259.96,168.54 257.9,168.54 257.17,169.27 255.92,169.27 255.03,168.39 255.03,158.48
S3_SPI_SDI: length 34.1
  TOP w0.231: v1(258.83,176.63) 259.43,176.03 SITE3.44
  BOTTOM w0.231: 258.07,151.53 258.07,166.28 258.85,167.06 262.04,167.06 262.6,167.63 262.6,172.86 v1(258.83,176.63)
S3_SPI_SDO: length 37
  TOP w0.231: SITE3.41 258.23,176.03 v1(257.63,176.63)
  BOTTOM w0.231: v1(257.63,176.63) 258.83,177.83 261.5,177.83 262.29,177.04 262.29,175.83 264.72,173.4 264.72,150.32
S3_XTAL_OUT: length 3.7
  TOP w0.231: SITE3.110 251.03,199.03 v1(251.63,199.63)
S4_2AUX+:
  vias: v1(300.22,132.08) v1(300.22,130.81)
S4_2AUX-:
  vias: v1(296.68,130.81) v1(297.68,132.08)
S4_AUX_100DCH002+:
  vias: v1(299.22,132.08)
S4_AUX_100DCH002-:
  vias: v1(296.68,132.08)
S4_AUXCH+: length 32.3
  TOP w0.203: SITE4.21 330.23,176.2 v2(330.6,176.57)
  BOTTOM w0.203: 327.57,149.14 327.57,171.79 330.3,174.52 330.3,176.28 v2(330.6,176.57)
S4_AUXCH-: length 32.1
  TOP w0.203: SITE4.20 329.83,176.2 v2(329.46,176.57)
  BOTTOM w0.203: v2(329.46,176.57) 329.76,176.28 329.76,174.75 327.02,172.02 327.02,149.37
S4_AVDD11_RX: length 8.4
  TOP w0.231: 334.67,167.85 334.23,168.29 SITE4.31
  TOP w0.508: v1(336.77,165.75) 334.67,167.85
  vias: v1(336.77,163.71)
S4_AVDD11_XTAL: length 8.8
  TOP w0.231: 332.87,201.45 332.87,201.11 333.03,200.95 SITE4.105
  TOP w0.381: 332.87,201.45 332.87,203.59 333.72,204.45 v1(333.72,204.54)
  vias: v1(333.72,206.58)
S4_AVDD18_RX: length 7.7
  TOP w0.231: SITE4.25 331.83,170.56 331.28,170.01
  TOP w0.508: 331.28,170.01 331.28,168.9 331.06,168.68 v1(331.06,165.75)
  vias: v1(331.06,163.71)
S4_DCH041: length 2.2
  TOP w0.231: v1(317.23,183.03) 317.43,182.83 SITE4.159
S4_DCH042: length 3.7
  TOP w0.231: v1(315.83,183.03) 316.43,182.43 SITE4.160
S4_DCH043: length 5.3
  TOP w0.231: v1(314.43,183.03) 315.44,182.03 SITE4.161
S4_DCH044: length 2.2
  TOP w0.231: v1(317.23,181.03) 317.43,181.23 SITE4.163
S4_DCH045: length 5.4
  TOP w0.231: SITE4.164 323.35,180.83 v1(324.35,179.83)
S4_DCH046: length 3.9
  TOP w0.231: SITE4.165 322.35,180.43 v1(322.95,179.83)
S4_DCH047: length 2.3
  TOP w0.231: SITE4.166 321.36,180.03 v1(321.56,179.83)
S4_DPS_F_001:
  vias: v1(297.68,130.81)
S4_DPS_F_002: length 10.1
  TOP w0.231: 320.65,169.55 321.72,169.55 323.03,170.86 SITE4.3
  TOP w0.508: 320.65,169.55 317.98,166.88 v1(317.98,165.75)
  vias: v1(316.32,162.9) v1(317.98,163.71)
S4_DPS_F_003: length 63.1
  TOP w0.231: 329.28,168.85 328.63,169.5 SITE4.17 ; SITE4.107 332.23,200.11 331.69,200.65 331.69,201.16 ; SITE4.145 313.08,188.43 312.83,188.18 ; 314.63,181.63 SITE4.162 ; SITE4.37 336.63,171.59 338.57,169.66 339.73,169.66 ; 345.2,182.93 344.9,183.23 SITE4.63 ; 347.84,185.53 346.94,186.43 SITE4.71
  TOP w0.381: v1(331.94,204.54) 331.69,204.28 331.69,201.16
  TOP w0.508: 345.2,182.93 345.45,182.68 346.8,182.68 348.11,181.37 v1(351.22,181.37) ; 312.83,188.18 312.58,187.93 v1(311.44,187.93) ; 314.63,181.63 314.37,181.63 312.59,183.41 v1(311.44,183.41) ; v1(329.28,165.75) 329.28,168.85 ; 347.84,185.53 349.45,183.91 v1(351.22,183.91) ; 339.73,169.66 342.36,167.02 v1(342.36,165.75)
  vias: v1(309.4,187.93) v1(309.4,183.41) v1(329.28,163.71) v1(331.94,206.58) v1(342.36,163.71) v1(353.27,183.91) v1(353.27,181.37) v1(464.57,192.28)
S4_DPS_F_006: length 9.6
  TOP w0.231: SITE4.72 347.92,186.83 348.55,186.19
  TOP w0.508: 348.55,186.19 349.56,185.18 v1(351.22,185.18)
  vias: v1(339,186.67) v1(353.27,185.18)
S4_DPS_F_007: length 19
  TOP w0.231: SITE4.97 336.23,200.71 339.65,204.13 v1(339.65,204.54) ; SITE4.78 344.15,189.23 344.37,189.01
  TOP w0.508: 344.37,189.01 350.31,189.01 350.8,189.5 v1(351.22,189.5)
  vias: v1(339.65,206.58) v1(353.27,189.5)
S4_DPS_F_009: length 8.8
  TOP w0.231: 332.26,201.12 332.26,200.9 332.63,200.53 SITE4.106
  TOP w0.381: v1(332.83,204.54) 332.83,204.39 332.26,203.82 332.26,201.12
  vias: v1(332.83,206.58) v1(333.61,207.66)
S4_DPS_F_010: length 8.6
  TOP w0.231: SITE4.111 330.63,200.15 331.05,200.57 331.05,201.13
  TOP w0.381: 331.05,201.13 v1(331.05,204.54)
  vias: v1(330.63,193.59) v1(331.05,206.58)
S4_DPS_F_011: length 17.6
  TOP w0.231: SITE4.119 327.43,197.79 327.64,198.01 ; SITE4.139 314.87,190.83 312.01,193.69 v1(311.44,193.69)
  TOP w0.508: 327.64,198.01 327.64,204.47 v1(327.57,204.54)
  vias: v1(309.4,193.69) v1(327.57,206.58)
S4_DPS_F_012: length 8
  TOP w0.231: 312.2,188.83 SITE4.144
  TOP w0.508: v1(311.44,189.2) 311.81,188.83 312.2,188.83
  vias: v1(309.4,189.2)
S4_DPS_F_013:
  vias: v1(452.62,188.98) v1(452.62,181.36) v1(457.25,190.45) v1(474.87,173.79) v1(474.89,161.55) v1(474.99,175.15) v1(475.99,187.35) v1(478.43,173.74) v1(478.43,161.55) v1(478.53,187.35) v1(478.53,175.15) v1(480.97,161.55) v1(481.07,175.15) v1(482.1,197.87) v1(482.1,190.25) v1(483.51,161.55) v1(483.61,175.15) v1(489.86,169.47) v1(490.1,183.24)
S4_ISP00+: length 238.8
  TOP w0.086: v1(356.24,185.73) 355.81,186.16 351.56,186.16 350.41,187.31 344.06,187.31 343.98,187.23 SITE4.73
  L32_SIGNAL w0.071: v1(307.81,131.64) 307.81,134.65 308.06,134.9 326.6,134.9 333.05,141.35 333.05,146.49 330.95,148.6 330.95,149.82 336.95,155.82 355.51,155.82 356.49,154.84 367.05,154.84 370.77,158.56 385.64,158.56 388.6,161.51 397.95,161.51 402.93,156.53 415.34,156.53 418.41,159.6 418.41,174.14 413.87,178.68 406.65,178.68 400.96,184.37 361.3,184.37 357.16,188.52 355.37,188.52 354.86,188.01 354.86,186.64 355.31,186.2 355.77,186.2 v1(356.24,185.73)
S4_ISP00-: length 238.8
  TOP w0.086: v1(356.24,186.87) 355.77,186.4 351.66,186.4 350.51,187.55 344.06,187.55 343.98,187.63 SITE4.74
  L32_SIGNAL w0.071: v1(307.81,139.64) 307.81,135.31 308.02,135.1 326.52,135.1 332.85,141.43 332.85,146.41 330.75,148.51 330.75,149.9 336.87,156.02 355.59,156.02 356.57,155.04 366.97,155.04 370.68,158.76 385.56,158.76 388.52,161.71 398.03,161.71 403.01,156.73 415.26,156.73 418.21,159.68 418.21,174.06 413.79,178.49 406.57,178.49 400.88,184.18 361.22,184.18 357.08,188.32 355.45,188.32 355.06,187.93 355.06,186.73 355.39,186.4 355.77,186.4 v1(356.24,186.87)
S4_ISP14+: length 238.8
  TOP w0.086: SITE4.112 330.23,197.78 330.15,197.86 330.15,206.68 330.73,207.26 331.76,207.26 332.42,207.92 332.42,208.71 v1(332.86,209.15)
  L28_SIGNAL w0.071: v1(332.86,209.15) 332.39,209.62 332.39,210.02 332.81,210.44 333.48,210.44 333.79,210.13 333.79,209.07 332.34,207.62 316.37,207.62 310.71,213.29 306.57,213.29 298.29,221.56 282.37,221.56 276.69,227.25 276.69,228.17 272.97,231.88 265.51,231.88 261.24,227.6 261.24,215.03 264.85,211.42 268.58,211.42 269.22,210.77 269.22,209.76 265.58,206.11 265.58,193.54 270.17,188.95 270.17,172.2 284.88,157.49 284.88,141.49 290.57,135.81 311.76,135.81 312.21,135.36 v1(312.21,131.64)
S4_ISP14-: length 238.8
  TOP w0.086: SITE4.113 329.83,197.78 329.91,197.86 329.91,206.78 330.63,207.5 331.66,207.5 332.18,208.02 332.18,208.69 v1(331.72,209.15)
  L28_SIGNAL w0.071: v1(331.72,209.15) 332.19,209.62 332.19,210.1 332.73,210.64 333.56,210.64 333.98,210.22 333.98,208.99 332.42,207.42 316.29,207.42 310.63,213.09 306.49,213.09 298.21,221.37 282.29,221.37 276.49,227.17 276.49,228.08 272.89,231.68 265.6,231.68 261.43,227.52 261.43,215.11 264.93,211.62 268.66,211.62 269.42,210.85 269.42,209.68 265.77,206.03 265.77,193.62 270.37,189.03 270.37,172.28 285.08,157.57 285.08,141.57 290.65,136 312.09,136 312.21,136.12 v1(312.21,139.64)
S4_M_DPS_F_001: length 45.2
  TOP w0.231: 346.49,183.63 SITE4.64 ; SITE4.147 313.7,187.63 313.24,187.18 ; 340.57,170.37 338.54,170.37 337.43,171.49 SITE4.39 ; 330.63,170.54 SITE4.22 ; SITE4.104 333.43,203.21
  TOP w0.381: v1(334.61,204.54) 334.61,204.39 333.43,203.21
  TOP w0.508: v1(351.22,182.64) 348.48,182.64 347.49,183.63 346.49,183.63 ; 330.63,170.54 330.38,170.28 330.38,169.17 330.17,168.96 v1(330.17,165.75) ; 313.24,187.18 312.72,186.66 v1(311.44,186.66) ; v1(343.63,165.75) 343.63,167.31 340.57,170.37
  vias: v1(309.4,186.66) v1(330.17,163.71) v1(334.61,206.58) v1(343.63,163.71) v1(353.27,182.64)
S4_PS9G_DCH001: length 3.7
  TOP w0.231: v1(329.63,169.63) 329.03,170.23 SITE4.18
S4_PS9G_DCH002: length 2.2
  TOP w0.231: SITE4.19 329.43,171.23 v1(329.63,171.03)
S4_PS9G_DCH003: length 2.2
  TOP w0.231: SITE4.24 331.43,171.23 v1(331.23,171.03)
S4_PS9G_DCH004: length 2.2
  TOP w0.231: SITE4.40 337.83,175.03 v1(337.63,175.23)
S4_PS9G_DCH005: length 2.2
  TOP w0.231: SITE4.45 344.23,176.03 v1(344.43,175.83)
S4_PS9G_DCH006: length 3.7
  TOP w0.231: SITE4.46 345.23,176.43 v1(345.83,175.83)
S4_PS9G_DCH007: length 5.3
  TOP w0.231: v1(347.22,175.83) 346.22,176.83 SITE4.47
S4_PS9G_DCH009: length 2.2
  TOP w0.231: SITE4.49 344.23,177.63 v1(344.43,177.43)
S4_PS9G_DCH010: length 3.7
  TOP w0.231: SITE4.50 345.23,178.03 v1(345.83,177.43)
S4_PS9G_DCH011: length 5.3
  TOP w0.231: SITE4.51 346.22,178.43 v1(347.22,177.43)
S4_PS9G_DCH014: length 3.7
  TOP w0.231: SITE4.54 345.23,179.63 v1(345.83,179.03)
S4_PS9G_DCH015: length 5.3
  TOP w0.231: v1(347.22,179.03) 346.22,180.03 SITE4.55
S4_PS9G_DCH022: length 5.3
  TOP w0.231: SITE4.65 346.05,184.03 347.05,185.03 v1(347.22,185.03)
S4_PS9G_DCH023: length 2.5
  TOP w0.231: SITE4.66 344.03,184.43 344.43,184.83 v1(344.43,185.03)
S4_PS9G_DCH027: length 3.9
  TOP w0.231: SITE4.70 344.83,186.03 v1(345.83,185.03)
S4_PS9G_DCH028: length 2.3
  TOP w0.231: v1(340.23,188.46) 340.6,188.83 SITE4.77
S4_PS9G_DCH029: length 2.2
  TOP w0.231: v1(328.03,194.03) 327.83,194.23 SITE4.118
S4_PS9G_DCH030: length 9.2
  TOP w0.231: v1(310.91,185.39) 312.63,185.39 314.16,186.91 317.3,186.91 317.62,187.23 SITE4.148
S4_PS9G_DCH035: length 5.3
  TOP w0.231: v1(314.43,186.23) 315.44,185.23 SITE4.153
S4_PS9G_DCH036: length 2.2
  TOP w0.231: SITE4.154 321.23,184.83 v1(321.43,185.03)
S4_PS9G_DCH037: length 2.2
  TOP w0.231: v1(317.23,184.63) 317.43,184.43 SITE4.155
S4_PS9G_DCH038: length 3.7
  TOP w0.231: v1(315.83,184.63) 316.43,184.03 SITE4.156
S4_PS9G_DCH039: length 5.3
  TOP w0.231: v1(314.43,184.63) 315.44,183.63 SITE4.157
S4_PS9G_DCH040: length 2.2
  TOP w0.231: v1(321.43,183.43) 321.23,183.23 SITE4.158
S4_RLY_001:
  vias: v1(402.14,146.88) v1(415.1,163.64)
S4_RLY_003:
  vias: v1(318.32,131.64) v1(403.41,209.61)
S4_RLY_005:
  vias: v1(388.43,146.88) v1(415.6,146.88)
S4_RLY_007:
  vias: v1(415.61,188.92)
S4_RLY_008:
  vias: v1(375.22,180.15) v1(397.57,131.89)
S4_RLY_016:
  vias: v1(388.43,163.64) v1(410.78,131.89)
S4_RLY_021:
  vias: v1(384.36,131.89) v1(401.89,163.64)
S4_RLY_022:
  vias: v1(346.27,138.37) v1(375.73,202.38)
S4_RLY_023:
  vias: v1(392.24,202.38)
S4_RLY_025:
  vias: v1(375.22,163.39) v1(388.43,180.15)
S4_RLY_026:
  vias: v1(401.89,180.15)
S4_RLY_030:
  vias: v1(304.61,144.34)
S4_RLY_043:
  vias: v1(304.61,131.64)
S4_SCAN_DCH008: length 2.2
  TOP w0.231: SITE4.48 340.43,177.23 v1(340.23,177.03)
S4_SCAN_DCH012: length 2.2
  TOP w0.231: SITE4.52 340.43,178.83 v1(340.23,178.63)
S4_SCAN_DCH013: length 2.2
  TOP w0.231: v1(344.43,179.03) 344.23,179.23 SITE4.53
S4_SCAN_DCH016: length 2.2
  TOP w0.231: v1(340.23,180.23) 340.43,180.43 SITE4.56
S4_SCAN_DCH017: length 2.2
  TOP w0.231: SITE4.57 344.23,180.83 v1(344.43,180.63)
S4_SCAN_DCH018: length 3.7
  TOP w0.231: v1(345.83,180.63) 345.23,181.23 SITE4.58
S4_SCAN_DCH019: length 5.3
  TOP w0.231: SITE4.59 346.22,181.63 v1(347.22,180.63)
S4_SCAN_DCH020: length 2.2
  TOP w0.231: v1(340.23,181.83) 340.43,182.03 SITE4.60
S4_SCAN_DCH021: length 2.2
  TOP w0.231: SITE4.61 344.23,182.43 v1(344.43,182.23)
S4_SCAN_DCH024: length 2.2
  TOP w0.231: v1(340.23,184.63) 340.43,184.83 SITE4.67
S4_SCAN_DCH025: length 3.7
  TOP w0.231: v1(338.83,184.63) 339.43,185.23 SITE4.68
S4_SCAN_DCH026: length 5.3
  TOP w0.231: v1(337.44,184.63) 338.44,185.63 SITE4.69
S4_SCAN_DCH031: length 3.7
  TOP w0.231: v1(322.83,187.43) 322.23,186.83 SITE4.149
S4_SCAN_DCH032: length 5.3
  TOP w0.231: v1(324.22,187.43) 323.22,186.43 SITE4.150
S4_SCAN_DCH033: length 2.2
  TOP w0.231: v1(317.23,186.23) 317.43,186.03 SITE4.151
S4_SCAN_DCH034: length 3.7
  TOP w0.231: v1(315.83,186.23) 316.43,185.63 SITE4.152
S4_SPI_1_CSN:
  vias: v1(474.99,187.35)
S4_SPI_1_SCK:
  vias: v1(480.07,175.15)
S4_SPI_1_SDI:
  vias: v1(456.19,173.74)
S4_SPI_1_SDO:
  vias: v1(455.94,166.12)
S4_SPI_2_CSN:
  vias: v1(475.87,173.79)
S4_SPI_2_SCK:
  vias: v1(479.97,161.55)
S4_SPI_2_SDI:
  vias: v1(451.62,173.74)
S4_SPI_2_SDO:
  vias: v1(451.87,166.12)
S4_SPI_11_SDI:
  vias: v1(457.19,173.74) v1(477.53,187.35)
S4_SPI_11_SDO:
  vias: v1(456.94,166.12) v1(482.61,175.15)
S4_SPI_22_SDI:
  vias: v1(452.62,173.74) v1(477.43,173.74)
S4_SPI_22_SDO:
  vias: v1(452.87,166.12) v1(482.51,161.55)
S4_SPI_CSN: length 25.9
  TOP w0.231: SITE4.43 339.03,171.23 v1(339.23,171.03)
  BOTTOM w0.231: v1(339.23,171.03) 338.4,171.03 335.17,174.25 333.57,174.25 332.91,173.59 332.91,161.11 332.25,160.44 330.61,160.44 330.11,159.95
S4_SPI_SCK: length 25.3
  TOP w0.231: SITE4.42 338.63,175.03 v1(338.83,175.23)
  BOTTOM w0.231: 335.03,158.48 335.03,168.39 335.92,169.27 337.17,169.27 337.9,168.54 339.96,168.54 340.53,169.11 340.53,172.28 338.83,173.98 v1(338.83,175.23)
S4_SPI_SDI: length 3.7
  TOP w0.231: SITE4.44 339.43,176.03 v1(338.83,176.63)
S4_SPI_SDO: length 37
  TOP w0.231: SITE4.41 338.23,176.03 v1(337.63,176.63)
  BOTTOM w0.231: 344.72,150.32 344.72,173.4 342.29,175.83 342.29,177.04 341.5,177.83 338.83,177.83 v1(337.63,176.63)
S4_XTAL_IN: length 28.3
  TOP w0.231: SITE4.109 331.43,198.03 v1(331.63,198.23)
  BOTTOM w0.231: 314.98,215.24 318.94,211.27 318.94,207.1 327.82,198.23 v1(331.63,198.23)
S4_XTAL_OUT: length 26.8
  TOP w0.231: SITE4.110 331.03,199.03 v1(331.63,199.63)
  BOTTOM w0.231: v1(331.63,199.63) 329.83,199.63 322.59,206.87 322.59,211.15 320.8,212.93 320.8,214.36 318.8,216.35
