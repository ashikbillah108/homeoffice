# Allegro board 8880F5-0823_RXTX.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D12002: length 833.7
  TOP w0.086: v1(224.31,195.45) 224.75,195.01 232.43,195.01 235.88,191.55 237.6,191.55 237.68,191.63 SITE3.137
  L05_SIGNAL w0.071: v1(164.91,162.67) 164.44,162.2 156.97,162.2 144.93,174.24 144.93,246.27 140.64,250.56 112.67,250.56 111.71,251.52 111.71,252.59 112.57,253.45 133.51,253.45 134.08,254.03 134.08,254.97 133.56,255.49 88.9,255.49 88.48,255.92 88.48,256.5 89.01,257.03 151.34,257.03 154.07,254.29 169.09,254.29 170.07,255.27 170.07,260.56 169.48,261.16 163.67,261.16 162.74,260.23 90.86,260.23 61.3,230.67 61.3,132.62 78.5,115.42 78.5,31.16 86.39,23.26 152.61,23.26 155.7,26.35 155.7,40.8 159.16,44.25 163.92,44.25 164.78,43.4 164.78,40.32 D120.02
  L32_SIGNAL w0.071: v1(164.91,162.67) 165.38,162.2 166.77,162.2 171.92,167.34 171.92,169.15 173.56,170.79 210.94,170.79 216.38,176.23 216.38,190.31 221.05,194.98 223.83,194.98 v1(224.31,195.45)
D12003: length 833.7
  TOP w0.086: v1(266.5,208.93) 266.97,208.46 266.97,207.51 265.08,205.62 265.08,204.23 259.11,198.26 259.11,197.86 259.03,197.78 SITE3.90
  L05_SIGNAL w0.071: v1(164.91,174.99) 165.38,175.46 166.06,175.46 166.25,175.27 166.25,173.99 165.39,173.13 161.17,173.13 153.44,180.87 153.44,204 161.87,212.43 161.87,250.75 164.23,253.12 170.74,253.12 172.36,254.74 172.36,261.37 170.5,263.23 89.27,263.23 57.24,231.2 57.24,131.97 76.06,113.15 76.06,29.14 83.46,21.74 159.33,21.74 162.31,24.73 162.31,33.37 163.08,34.14 163.68,34.14 D120.03
  L32_SIGNAL w0.071: v1(266.5,208.93) 266.97,208.46 266.97,207.67 261.26,201.96 261.26,199.08 263.16,197.19 271.5,197.19 274.67,200.36 279.7,200.36 281.77,198.29 281.77,146 272,136.23 230.5,136.23 228.68,134.4 209.92,134.4 205.01,139.32 177.87,139.32 176.64,140.55 159.47,140.55 153.6,146.41 153.6,170.64 158.42,175.46 164.84,175.46 164.91,175.39 v1(164.91,174.99)
D12004: length 833.7
  TOP w0.086: SITE3.138 237.68,191.23 237.6,191.31 235.78,191.31 232.33,194.77 224.76,194.77 v1(224.31,194.31)
  L05_SIGNAL w0.071: D120.04 165.91,39.83 165.66,39.83 164.98,40.51 164.98,43.48 164,44.45 159.07,44.45 155.5,40.88 155.5,26.43 152.53,23.46 86.47,23.46 78.7,31.24 78.7,115.51 61.5,132.7 61.5,230.58 90.95,260.03 162.82,260.03 163.75,260.96 169.39,260.96 169.87,260.48 169.87,255.35 169.01,254.49 154.15,254.49 151.42,257.22 88.92,257.22 88.28,256.58 88.28,255.83 88.82,255.3 133.47,255.3 133.89,254.88 133.89,254.11 133.42,253.65 112.49,253.65 111.51,252.67 111.51,251.44 112.59,250.36 140.56,250.36 144.73,246.19 144.73,174.16 156.89,162 164.44,162 v1(164.91,161.52)
  L32_SIGNAL w0.071: v1(164.91,161.52) 165.38,162 166.86,162 172.12,167.26 172.12,169.07 173.64,170.59 211.02,170.59 216.57,176.14 216.57,190.23 221.13,194.78 223.83,194.78 v1(224.31,194.31)
D12005: length 833.7
  TOP w0.086: v1(239.3,210.88) 238.85,210.43 238.85,203.79 243.35,199.29 243.35,197.86 243.43,197.78 SITE3.129
  L05_SIGNAL w0.071: v1(164.91,189.59) 165.38,189.12 165.95,189.12 166.55,188.51 166.55,185.89 164.84,184.18 159.73,184.18 158.31,185.6 158.31,202.64 179.84,224.17 179.84,232.57 180.8,233.53 213.5,233.53 216.71,230.32 225,230.32 228.05,233.37 253.35,233.37 255.87,235.89 255.87,262.08 255.08,262.87 240.62,262.87 233.47,270.03 228.61,270.03 225.32,266.74 167.38,266.74 165.48,264.83 86.04,264.83 53.15,231.94 53.15,130.72 74.13,109.74 74.13,28.3 82.08,20.35 169.58,20.35 172.63,23.4 172.63,33.11 D120.05
  L32_SIGNAL w0.071: v1(164.91,189.59) 165.38,189.12 166.7,189.12 169.03,191.45 169.03,198.91 171.78,201.66 214.65,201.66 225.85,212.86 238.15,212.86 238.83,212.18 238.83,211.35 v1(239.3,210.88)
D12006: length 833.7
  TOP w0.086: SITE3.142 237.68,189.63 237.6,189.55 233.04,189.55 231.83,190.76 224.76,190.76 v1(224.31,191.21)
  L05_SIGNAL w0.071: D120.06 174.86,40.24 174.86,44.41 173.24,46.03 157.08,46.03 152.6,41.55 152.6,27.36 150.23,25 87.92,25 80.42,32.5 80.42,118.05 66.12,132.35 66.12,205.74 64.22,207.64 64.22,227.9 90.62,254.3 107.92,254.3 109.05,253.17 109.05,251.29 108,250.24 89.1,250.24 88.54,249.67 88.54,249.08 89,248.62 140.64,248.62 141.55,247.72 141.55,246.95 140.83,246.23 84.35,246.23 83.78,245.66 83.78,245.07 84.27,244.58 142.07,244.58 142.76,243.9 142.76,242.55 141.98,241.78 124.16,241.78 123.81,241.43 123.81,240.69 124.2,240.29 140.09,240.29 141.57,238.81 141.57,162.07 155.16,148.48 164.44,148.48 v1(164.91,148.95)
  L32_SIGNAL w0.071: v1(224.31,191.21) 223.83,190.74 223.24,190.74 220.2,187.7 220.2,170.6 217.11,167.51 180.67,167.51 176.77,163.62 176.77,150.74 175.28,149.25 167.53,149.25 166.77,148.48 165.38,148.48 v1(164.91,148.95)
D12007: length 833.7
  TOP w0.086: SITE3.130 243.03,197.78 243.11,197.86 243.11,199.19 238.61,203.69 238.61,210.43 v1(238.16,210.88)
  L05_SIGNAL w0.071: D120.07 172.83,33.13 172.83,23.31 169.66,20.15 82,20.15 73.93,28.22 73.93,109.66 52.95,130.63 52.95,232.02 85.96,265.03 165.39,265.03 167.3,266.93 225.24,266.93 228.53,270.23 233.55,270.23 240.71,263.07 255.16,263.07 256.07,262.16 256.07,235.8 253.44,233.17 228.13,233.17 225.08,230.12 216.63,230.12 213.42,233.33 180.88,233.33 180.04,232.49 180.04,224.09 158.51,202.55 158.51,185.68 159.81,184.38 164.75,184.38 166.35,185.98 166.35,188.43 165.86,188.92 165.38,188.92 v1(164.91,188.45)
  L32_SIGNAL w0.071: v1(238.16,210.88) 238.63,211.35 238.63,212.1 238.07,212.66 225.93,212.66 214.73,201.46 171.86,201.46 169.23,198.83 169.23,191.37 166.78,188.92 165.38,188.92 v1(164.91,188.45)
D12008: length 833.7
  TOP w0.086: SITE3.143 237.68,189.23 237.6,189.31 232.94,189.31 231.73,190.52 224.76,190.52 v1(224.31,190.07)
  L05_SIGNAL w0.071: v1(164.91,147.81) 164.44,148.28 155.08,148.28 141.37,161.98 141.37,238.73 140.01,240.09 124.12,240.09 123.61,240.61 123.61,241.51 124.08,241.98 141.9,241.98 142.56,242.64 142.56,243.82 141.99,244.39 84.19,244.39 83.59,244.99 83.59,245.75 84.27,246.43 140.74,246.43 141.35,247.03 141.35,247.64 140.56,248.42 88.92,248.42 88.34,249 88.34,249.76 89.02,250.44 107.92,250.44 108.86,251.38 108.86,253.09 107.84,254.1 90.7,254.1 64.42,227.82 64.42,207.72 66.32,205.82 66.32,132.43 80.61,118.14 80.61,32.58 88,25.19 150.15,25.19 152.4,27.44 152.4,41.63 157,46.23 173.32,46.23 175.06,44.49 175.06,40.71 176.16,39.62 176.28,39.62 D120.08
  L32_SIGNAL w0.071: v1(224.31,190.07) 223.83,190.54 223.32,190.54 220.4,187.62 220.4,170.52 217.2,167.31 180.75,167.31 176.97,163.53 176.97,150.66 175.36,149.05 167.62,149.05 166.85,148.28 165.38,148.28 v1(164.91,147.81)
D12009: length 833.7
  TOP w0.086: v1(227.6,193.14) 228.04,192.7 231.52,192.7 233.88,190.35 237.6,190.35 237.68,190.43 SITE3.140
  L05_SIGNAL w0.071: D120.09 182.2,33.7 182.2,29.09 183.78,27.51 202.9,27.51 204.17,28.77 204.17,47.53 200.16,51.53 149,51.53 141.99,44.52 141.99,38.04 138.41,34.46 91.19,34.46 90.39,35.27 90.39,122.31 78.82,133.88 78.82,191.66 80.71,193.55 132.24,193.55 132.79,193 132.79,191.69 131.97,190.87 95.72,190.87 94.31,192.29 81.44,192.29 80.32,191.17 80.32,189.59 80.78,189.14 106.49,189.14 107.16,189.81 130.98,189.81 132.32,188.47 132.32,187.53 131.16,186.37 81.73,186.37 80.92,185.56 80.92,184.4 81.55,183.77 95.95,183.77 96.67,184.49 117.61,184.49 119.54,182.56 131.79,182.56 132.23,182.12 132.23,181.41 131.81,180.99 111.43,180.99 110.24,179.79 110.24,178.4 111.43,177.2 130.99,177.2 132.15,176.04 132.15,153.87 145.53,140.49 170.6,140.49 174.56,144.45 178.51,144.45 180.36,146.3 180.36,147.95 179.83,148.48 178.97,148.48 v1(178.5,148.95)
  L32_SIGNAL w0.071: v1(227.6,193.14) 227.13,192.67 226.62,192.67 226.13,192.18 226.13,168.8 211.64,154.31 197.31,154.31 192.43,149.43 183.83,149.43 183.23,150.03 181.68,150.03 180.14,148.48 178.97,148.48 v1(178.5,148.95)
D12010: length 833.7
  TOP w0.086: v1(263.79,208.93) 263.34,208.49 263.34,204.27 257.75,198.68 257.75,197.86 257.83,197.78 SITE3.93
  L05_SIGNAL w0.071: D120.10 184.93,40.15 184.93,44.07 181.76,47.24 154.11,47.24 148.99,42.13 148.99,29.07 147.35,27.42 88.22,27.42 82.57,33.08 82.57,121.2 70.2,133.56 70.2,204.28 66.71,207.78 66.71,225.42 83.31,242.02 122.29,242.02 122.83,241.48 122.83,240.61 122.38,240.16 85.1,240.16 84.43,239.48 84.43,238.19 85,237.61 138.61,237.61 139.2,237.02 139.2,235.12 138.28,234.2 115.6,234.2 114.73,233.32 114.73,231.03 115.75,230 137.75,230 139.47,228.28 139.47,158.72 151.45,146.74 167.18,146.74 170.72,150.28 170.72,199.25 180.08,208.61 180.08,216.14 180.49,216.55 181.2,216.55 v1(181.67,217.02)
  L32_SIGNAL w0.071: v1(263.79,208.93) 263.31,209.4 263.31,213.14 260.75,215.71 260.75,217.22 257.42,220.55 234.34,220.55 230.43,216.64 221.51,216.64 218.31,219.84 199.35,219.84 197.58,218.06 197.58,216.06 196.49,214.97 184.93,214.97 183.36,216.55 182.15,216.55 v1(181.67,217.02)
D12011: length 833.7
  TOP w0.086: v1(227.6,192) 228.06,192.46 231.43,192.46 233.78,190.11 237.6,190.11 237.68,190.03 SITE3.141
  L05_SIGNAL w0.071: D120.11 184.26,34.4 183.41,34.4 182.4,33.39 182.4,29.17 183.87,27.71 202.82,27.71 203.97,28.86 203.97,47.44 200.08,51.33 149.08,51.33 142.19,44.44 142.19,37.96 138.49,34.26 91.11,34.26 90.19,35.18 90.19,122.23 78.62,133.8 78.62,191.74 80.62,193.74 132.33,193.74 132.99,193.08 132.99,191.61 132.05,190.68 95.64,190.68 94.22,192.09 81.53,192.09 80.52,191.08 80.52,189.67 80.86,189.34 106.41,189.34 107.08,190 131.06,190 132.51,188.55 132.51,187.45 131.24,186.17 81.81,186.17 81.11,185.48 81.11,184.48 81.63,183.96 95.87,183.96 96.59,184.69 117.69,184.69 119.62,182.76 131.87,182.76 132.43,182.2 132.43,181.33 131.89,180.79 111.51,180.79 110.43,179.71 110.43,178.48 111.51,177.4 131.08,177.4 132.35,176.13 132.35,153.95 145.61,140.69 170.52,140.69 174.48,144.65 178.43,144.65 180.16,146.38 180.16,147.87 179.75,148.28 178.97,148.28 v1(178.5,147.81)
  L32_SIGNAL w0.071: v1(227.6,192) 227.13,192.47 226.7,192.47 226.33,192.1 226.33,168.72 211.72,154.11 197.39,154.11 192.51,149.23 183.74,149.23 183.15,149.83 181.77,149.83 180.22,148.28 178.97,148.28 v1(178.5,147.81)
D12012: length 833.7
  TOP w0.086: SITE3.94 257.43,197.78 257.51,197.86 257.51,198.78 263.1,204.37 263.1,208.47 v1(262.64,208.93)
  L05_SIGNAL w0.071: v1(181.67,215.88) 181.2,216.35 180.57,216.35 180.28,216.06 180.28,208.53 170.92,199.17 170.92,150.2 167.26,146.54 151.37,146.54 139.27,158.64 139.27,228.2 137.66,229.81 115.67,229.81 114.53,230.95 114.53,233.4 115.52,234.39 138.2,234.39 139.01,235.2 139.01,236.94 138.52,237.42 84.91,237.42 84.23,238.1 84.23,239.57 85.02,240.36 122.29,240.36 122.63,240.69 122.63,241.4 122.2,241.82 83.39,241.82 66.91,225.33 66.91,207.86 70.4,204.37 70.4,133.65 82.77,121.28 82.77,33.16 88.31,27.62 147.27,27.62 148.8,29.15 148.8,42.21 154.03,47.44 181.85,47.44 185.13,44.15 185.13,40.35 185.81,39.67 186.39,39.67 D120.12
  L32_SIGNAL w0.071: v1(262.64,208.93) 263.12,209.4 263.12,213.06 260.55,215.63 260.55,217.14 257.33,220.36 234.42,220.36 230.51,216.44 221.42,216.44 218.23,219.64 199.43,219.64 197.77,217.98 197.77,215.98 196.57,214.77 184.85,214.77 183.27,216.35 182.15,216.35 v1(181.67,215.88)
D12013: length 833.7
  TOP w0.086: v1(227.6,197.38) 228.04,196.95 231.86,196.95 236.46,192.35 237.6,192.35 237.68,192.43 SITE3.135
  L05_SIGNAL w0.071: v1(178.5,162.67) 178.97,162.2 179.52,162.2 179.91,161.81 179.91,160.47 177.66,158.23 175.66,158.23 174.87,157.44 174.87,148.62 170.16,143.91 166.38,143.91 164.53,142.05 147.5,142.05 134.37,155.18 134.37,195.1 133.23,196.25 78.63,196.25 77.77,197.11 77.77,198.87 78.42,199.52 92.22,199.52 93.4,198.34 100.23,198.34 101.25,199.37 134.75,199.37 135.13,199.75 135.13,200.85 134.78,201.21 77.89,201.21 77.38,201.71 77.38,202.43 77.9,202.94 134.86,202.94 135.15,203.22 135.15,203.75 134.79,204.11 77.33,204.11 76.06,202.84 76.06,134.26 87.68,122.64 87.68,33.8 90.28,31.2 143.13,31.2 145.02,33.09 145.02,44.76 150.63,50.37 197.94,50.37 202.93,45.39 202.93,30.68 201.29,29.04 194,29.04 192.2,30.85 192.2,33.86 D120.13
  L32_SIGNAL w0.071: v1(227.6,197.38) 227.13,196.91 226.48,196.91 225.28,195.71 225.28,185.17 223.22,183.12 223.22,170.34 218.38,165.49 183.28,165.49 179.98,162.2 178.97,162.2 v1(178.5,162.67)
D12014: length 833.7
  TOP w0.086: v1(256.07,208.93) 255.64,208.51 255.64,204.07 254.15,202.58 254.15,197.86 254.23,197.78 SITE3.102
  L05_SIGNAL w0.071: v1(181.67,203.56) 181.2,203.09 180.14,203.09 177.08,200.03 177.08,164.74 172.92,160.58 172.92,149.72 168.31,145.11 149.01,145.11 136.79,157.34 136.79,204.86 134.34,207.31 75.77,207.31 72.44,203.98 72.44,134.59 84.83,122.2 84.83,32.53 88.15,29.22 144.24,29.22 147.68,32.66 147.68,42.4 154.14,48.86 190.82,48.86 194.73,44.95 194.73,39.79 D120.14
  L32_SIGNAL w0.071: v1(181.67,203.56) 181.2,203.09 180.18,203.09 176.92,206.34 162.45,206.34 159.1,203 159.1,189.56 162.87,185.79 167.01,185.79 170.41,182.4 170.41,173.57 168.42,171.58 165.61,171.58 159.73,165.71 159.73,149.11 164.77,144.08 198.32,144.08 203.77,149.52 209.77,149.52 213.29,153.04 230.86,153.04 236.63,147.27 251.59,147.27 253.23,148.91 272.21,148.91 277.98,154.68 277.98,187.55 273.71,191.82 260.15,191.82 255.6,196.37 255.6,208.46 v1(256.07,208.93)
D12015: length 833.7
  TOP w0.086: SITE3.136 237.68,192.03 237.6,192.11 236.36,192.11 231.76,196.71 228.07,196.71 v1(227.6,196.24)
  L05_SIGNAL w0.071: v1(178.5,161.52) 178.97,162 179.44,162 179.71,161.73 179.71,160.56 177.58,158.42 175.57,158.42 174.67,157.52 174.67,148.7 170.07,144.1 166.3,144.1 164.45,142.25 147.58,142.25 134.57,155.26 134.57,195.19 133.32,196.44 78.71,196.44 77.97,197.19 77.97,198.78 78.51,199.32 92.13,199.32 93.31,198.14 100.31,198.14 101.34,199.17 134.83,199.17 135.33,199.67 135.33,200.93 134.86,201.4 77.97,201.4 77.58,201.79 77.58,202.34 77.98,202.74 134.95,202.74 135.35,203.14 135.35,203.84 134.87,204.31 77.25,204.31 75.86,202.92 75.86,134.18 87.48,122.56 87.48,33.72 90.2,31 143.21,31 145.21,33 145.21,44.67 150.72,50.18 197.86,50.18 202.73,45.31 202.73,30.76 201.21,29.24 194.09,29.24 192.39,30.93 192.39,32.98 193.7,34.29 194.31,34.29 D120.15
  L32_SIGNAL w0.071: v1(178.5,161.52) 178.97,162 180.06,162 183.36,165.3 218.46,165.3 223.42,170.26 223.42,183.04 225.48,185.09 225.48,195.63 226.56,196.71 227.13,196.71 v1(227.6,196.24)
D12016: length 833.7
  TOP w0.086: SITE3.103 253.83,197.78 253.91,197.86 253.91,202.68 255.4,204.17 255.4,208.46 v1(254.93,208.93)
  L05_SIGNAL w0.071: D120.16 197.01,39.21 195.86,39.21 194.92,40.14 194.92,45.03 190.9,49.06 154.05,49.06 147.49,42.49 147.49,32.74 144.16,29.42 88.23,29.42 85.03,32.62 85.03,122.28 72.64,134.67 72.64,203.9 75.86,207.11 134.26,207.11 136.59,204.78 136.59,157.26 148.93,144.91 168.4,144.91 173.11,149.63 173.11,160.49 177.28,164.65 177.28,199.94 180.22,202.89 181.2,202.89 v1(181.67,202.42)
  L32_SIGNAL w0.071: v1(181.67,202.42) 181.2,202.89 180.09,202.89 176.84,206.15 162.53,206.15 159.3,202.92 159.3,189.64 162.95,185.99 167.09,185.99 170.61,182.48 170.61,173.49 168.5,171.38 165.69,171.38 159.93,165.62 159.93,149.19 164.85,144.27 198.24,144.27 203.68,149.72 209.69,149.72 213.21,153.24 230.94,153.24 236.71,147.47 251.51,147.47 253.15,149.11 272.13,149.11 277.78,154.77 277.78,187.47 273.63,191.63 260.07,191.63 255.4,196.29 255.4,208.46 v1(254.93,208.93)
D12301: length 833.7
  TOP w0.086: v1(261.86,207.21) 261.41,206.77 261.41,203.74 256.95,199.28 256.95,197.86 257.03,197.78 SITE3.95
  L05_SIGNAL w0.071: v1(212.03,217.02) 212.5,216.55 219.13,216.55 219.8,217.22 219.8,218.79 218.87,219.72 208.21,219.72 204.1,215.61 204.1,142.35 198.78,137.03 198.78,133.53 192.35,127.1 156.77,127.1 155.64,128.23 121.86,128.23 113.12,119.49 113.12,85.25 115.62,82.76 204.46,82.76 205.1,82.12 205.1,80.57 204.52,79.99 113.61,79.99 113.18,79.57 113.18,78.11 113.76,77.53 204.79,77.53 205.56,76.76 205.56,75.39 205.01,74.84 114.15,74.84 113.3,73.99 113.3,73.25 114.27,72.28 200.47,72.28 202.36,70.39 202.36,64.07 217.84,48.59 234.68,48.59 236.63,50.54 236.63,54.47 236.34,54.75 234.81,54.75 D123.01
  L32_SIGNAL w0.071: v1(261.86,207.21) 261.38,207.69 261.38,211.17 258.84,213.71 258.84,214.86 254.14,219.57 241.81,219.57 238.79,216.55 232.02,216.55 230.96,215.5 220.48,215.5 219.43,216.55 212.5,216.55 v1(212.03,217.02)
D12302: length 833.7
  TOP w0.086: SITE3.131 242.63,197.78 242.55,197.86 242.55,198.66 236.97,204.24 236.97,208.69 v1(237.43,209.15)
  L05_SIGNAL w0.071: D123.02 238.66,60.86 238.66,61.97 238.19,62.45 211.97,62.45 207.23,67.19 207.23,87.87 202.41,92.69 115.21,92.69 114.4,93.5 114.4,94.8 115.06,95.45 155.07,95.45 156.41,94.11 197.94,94.11 198.7,94.87 198.7,95.99 197.58,97.11 177.37,97.11 175.31,99.17 158.67,99.17 157.18,97.68 116.5,97.68 115.53,98.64 115.53,99.78 116.4,100.64 150.39,100.64 151.25,101.51 157.64,101.51 158.31,100.84 200.22,100.84 201.39,102.01 201.39,103.64 199.15,105.89 188.05,105.89 187.02,104.86 122.26,104.86 121.49,105.63 121.49,107.19 122.1,107.8 152.76,107.8 153.69,106.87 171.87,106.87 173.53,108.52 199.93,108.52 200.84,109.44 200.84,113.39 197.15,117.07 150.57,117.07 148.63,119.01 148.63,122.26 150.57,124.21 158.14,124.21 159.48,122.87 205.64,122.87 208.31,125.54 208.31,132.07 205.62,134.75 205.62,184.3 210.44,189.12 211.55,189.12 v1(212.03,189.59)
  L32_SIGNAL w0.071: v1(212.03,189.59) 211.55,189.12 211.03,189.12 210.09,190.06 210.09,192.23 214.37,196.51 224.09,196.51 226.56,198.99 235.95,198.99 236.95,199.99 236.95,208.68 v1(237.43,209.15)
D12303: length 833.7
  TOP w0.086: SITE3.96 256.63,197.78 256.71,197.86 256.71,199.38 261.17,203.84 261.17,206.75 v1(260.71,207.21)
  L05_SIGNAL w0.071: v1(212.03,215.88) 212.5,216.35 219.21,216.35 220,217.14 220,218.87 218.95,219.92 208.13,219.92 203.91,215.69 203.91,142.44 198.58,137.11 198.58,133.61 192.27,127.3 156.85,127.3 155.72,128.43 121.78,128.43 112.92,119.58 112.92,85.17 115.53,82.56 204.38,82.56 204.9,82.03 204.9,80.66 204.44,80.19 113.53,80.19 112.99,79.65 112.99,78.02 113.68,77.33 204.71,77.33 205.36,76.67 205.36,75.48 204.92,75.04 114.07,75.04 113.1,74.07 113.1,73.16 114.18,72.08 200.39,72.08 202.16,70.31 202.16,63.99 217.76,48.39 234.77,48.39 236.83,50.46 236.83,53.95 D123.03
  L32_SIGNAL w0.071: v1(260.71,207.21) 261.19,207.69 261.19,211.08 258.64,213.63 258.64,214.78 254.05,219.37 241.9,219.37 238.88,216.35 232.1,216.35 231.04,215.3 220.4,215.3 219.35,216.35 212.5,216.35 v1(212.03,215.88)
D12304: length 833.7
  TOP w0.086: SITE3.132 242.23,197.78 242.31,197.86 242.31,198.56 236.73,204.14 236.73,208.71 v1(236.28,209.15)
  L05_SIGNAL w0.071: D123.04 238.86,60.86 238.86,62.05 238.27,62.65 212.05,62.65 207.43,67.27 207.43,87.95 202.49,92.89 115.3,92.89 114.6,93.58 114.6,94.71 115.14,95.25 154.99,95.25 156.32,93.92 198.02,93.92 198.89,94.79 198.89,96.08 197.66,97.31 177.45,97.31 175.4,99.37 158.58,99.37 157.09,97.88 116.58,97.88 115.73,98.72 115.73,99.7 116.48,100.45 150.47,100.45 151.34,101.31 157.56,101.31 158.22,100.64 200.31,100.64 201.59,101.93 201.59,103.72 199.23,106.09 187.97,106.09 186.94,105.06 122.34,105.06 121.69,105.71 121.69,107.1 122.19,107.6 152.67,107.6 153.61,106.67 171.95,106.67 173.61,108.33 200.01,108.33 201.04,109.35 201.04,113.47 197.24,117.27 150.65,117.27 148.82,119.1 148.82,122.18 150.65,124.01 158.06,124.01 159.4,122.67 205.72,122.67 208.51,125.46 208.51,132.15 205.82,134.83 205.82,184.22 210.53,188.92 211.55,188.92 v1(212.03,188.45)
  L32_SIGNAL w0.071: v1(212.03,188.45) 211.55,188.92 210.95,188.92 209.89,189.98 209.89,192.31 214.29,196.71 224,196.71 226.48,199.18 235.87,199.18 236.75,200.07 236.75,208.68 v1(236.28,209.15)
D12305: length 833.7
  TOP w0.086: v1(279.29,195.88) 278.81,196.36 269.82,196.36 265.58,192.11 264.06,192.11 263.98,192.03 SITE3.85
  L07_SIGNAL w0.071: D123.05 244.87,54.85 246.65,54.85 246.99,54.5 246.99,52.15 244.9,50.07 228.14,50.07 224.31,53.89 224.31,100.65 261.98,138.32 261.98,143.16 263.54,144.73 263.54,145.51 v1(264.01,145.99)
  L30_SIGNAL w0.071: v1(279.29,195.88) 279.76,196.35 287.15,196.35 288.47,195.03 288.47,113.91 283.29,108.73 187.17,108.73 184.03,105.6 172.57,105.6 170.6,107.56 159.02,107.56 157.16,105.7 24.62,105.7 21.58,108.74 21.58,123.16 25.18,126.75 192.9,126.75 194.44,125.21 204.63,125.21 206.59,127.17 264.69,127.17 278.86,141.34 278.86,144.83 277.83,145.86 275.88,145.86 274.54,144.52 274.54,140.81 272.34,138.61 266.44,138.61 264.49,140.56 264.49,143.73 263.55,144.67 263.55,145.53 v1(264.01,145.99)
D12306: length 833.7
  TOP w0.086: v1(276.24,193.95) 275.8,194.39 269.61,194.39 266.53,191.31 264.06,191.31 263.98,191.23 SITE3.83
  L07_SIGNAL w0.071: D123.06 248.38,60.42 248.38,62.19 248.1,62.47 230.03,62.47 226.2,66.3 226.2,98.56 261.82,134.17 263.06,134.17 263.54,133.69 263.54,132.87 v1(264.01,132.4)
  L30_SIGNAL w0.071: v1(276.24,193.95) 276.72,194.42 284.42,194.42 287.11,191.73 287.11,147.61 287.81,146.91 287.81,134.93 285.97,133.09 285.97,114.38 281.74,110.15 262.95,110.15 261.61,111.48 248.03,111.48 246.31,109.77 189.32,109.77 188.06,111.03 184.5,111.03 182.89,109.42 154.26,109.42 152.26,107.42 55.01,107.42 52.56,109.87 42.91,109.87 42.56,109.51 42.56,108.95 43,108.51 48.22,108.51 48.59,108.13 48.59,107.76 48.24,107.42 25.15,107.42 23.93,108.63 23.93,122.76 26.37,125.21 153.15,125.21 153.97,124.38 157.49,124.38 158.17,125.07 193.8,125.07 195.15,123.72 198.59,123.72 199.3,124.43 205.7,124.43 207.62,126.35 266.03,126.35 279.71,140.02 279.71,147.49 277.94,149.26 261.11,149.26 259.65,147.8 259.65,131.08 260.69,130.04 262.93,130.04 263.54,130.64 263.54,131.93 v1(264.01,132.4)
D12307: length 833.7
  TOP w0.086: v1(279.29,197.02) 278.87,196.6 269.73,196.6 265.48,192.35 264.06,192.35 263.98,192.43 SITE3.86
  L07_SIGNAL w0.071: D123.07 247.19,54.15 247.19,52.07 244.99,49.87 228.06,49.87 224.12,53.81 224.12,100.74 261.78,138.4 261.78,143.25 263.34,144.81 263.34,145.51 v1(262.87,145.99)
  L30_SIGNAL w0.071: v1(279.29,197.02) 279.76,196.55 287.23,196.55 288.67,195.11 288.67,113.83 283.38,108.54 187.25,108.54 184.12,105.4 172.48,105.4 170.52,107.36 159.1,107.36 157.24,105.51 24.54,105.51 21.38,108.66 21.38,123.24 25.1,126.95 192.98,126.95 194.53,125.41 204.55,125.41 206.51,127.37 264.61,127.37 278.66,141.42 278.66,144.75 277.75,145.66 275.96,145.66 274.74,144.44 274.74,140.72 272.42,138.41 266.36,138.41 264.29,140.48 264.29,143.65 263.36,144.59 263.36,145.5 v1(262.87,145.99)
D12308: length 833.7
  TOP w0.086: SITE3.84 263.98,191.63 264.06,191.55 266.43,191.55 269.51,194.63 275.78,194.63 v1(276.24,195.09)
  L07_SIGNAL w0.071: D123.08 249.86,60.02 248.81,60.02 248.58,60.25 248.58,62.27 248.18,62.67 230.11,62.67 226.4,66.38 226.4,98.47 261.9,133.97 262.98,133.97 263.34,133.61 263.34,132.87 v1(262.87,132.4)
  L30_SIGNAL w0.071: v1(276.24,195.09) 276.72,194.62 284.5,194.62 287.31,191.81 287.31,147.69 288.01,146.99 288.01,134.85 286.17,133.01 286.17,114.3 281.82,109.95 262.86,109.95 261.53,111.29 248.11,111.29 246.4,109.57 189.24,109.57 187.98,110.83 184.58,110.83 182.97,109.22 154.34,109.22 152.34,107.22 54.93,107.22 52.48,109.67 42.99,109.67 42.76,109.43 42.76,109.04 43.09,108.7 48.3,108.7 48.79,108.21 48.79,107.68 48.33,107.22 25.07,107.22 23.73,108.55 23.73,122.85 26.29,125.4 153.23,125.4 154.06,124.58 157.4,124.58 158.09,125.27 193.88,125.27 195.23,123.92 198.51,123.92 199.22,124.63 205.61,124.63 207.53,126.55 265.95,126.55 279.51,140.1 279.51,147.41 277.86,149.06 261.19,149.06 259.84,147.71 259.84,131.16 260.77,130.23 262.85,130.23 263.34,130.73 263.34,131.93 v1(262.87,132.4)
D12309: length 833.7
  TOP w0.086: v1(276.24,190.09) 275.8,190.53 270.02,190.53 269.2,189.71 264.06,189.71 263.98,189.63 SITE3.79
  L07_SIGNAL w0.071: v1(250.81,129.35) 250.33,128.88 250.33,127.92 222.24,99.82 222.24,51.94 226.52,47.66 254.84,47.66 256.98,49.8 256.98,53.82 256.78,54.02 255.91,54.02 254.05,55.88 D123.09
  L30_SIGNAL w0.071: v1(250.81,129.35) 250.33,129.82 250.33,131.31 247.9,133.73 238.12,133.73 234.48,130.09 206.09,130.09 205.02,129.02 197.72,129.02 196.48,130.26 145.41,130.26 143.59,132.07 143.59,133.02 144.2,133.63 163.56,133.63 164.22,134.29 164.22,134.93 163.63,135.52 143.52,135.52 143.23,135.81 143.23,136.64 143.62,137.03 163.32,137.03 163.9,137.62 163.9,138.28 163.15,139.03 143.73,139.03 143.14,139.62 143.14,140.68 143.38,140.92 206.62,140.92 207.31,141.62 207.31,143.37 206.9,143.79 143.34,143.79 142.95,144.18 142.95,144.54 143.32,144.91 203.53,144.91 204.13,145.51 204.13,146.69 203.38,147.44 200.11,147.44 199.36,146.69 143.25,146.69 143,146.94 143,147.52 143.17,147.69 162.64,147.69 163.04,148.09 163.04,148.69 162.5,149.22 143.84,149.22 143.38,149.69 143.38,150.3 144.49,151.41 165.75,151.41 167.35,149.81 204.74,149.81 217.29,137.26 227.88,137.26 229.65,139.03 252.54,139.03 258.74,145.22 258.74,164.96 263.84,170.06 263.84,189.54 264.86,190.56 275.77,190.56 v1(276.24,190.09)
D12311: length 833.7
  TOP w0.086: SITE3.80 263.98,190.03 264.06,189.95 269.1,189.95 269.92,190.77 275.78,190.77 v1(276.24,191.23)
  L07_SIGNAL w0.071: D123.11 257.18,53.98 257.18,49.72 254.92,47.46 226.44,47.46 222.04,51.86 222.04,99.9 250.14,128 250.14,128.88 v1(249.66,129.35)
  L30_SIGNAL w0.071: v1(276.24,191.23) 275.77,190.76 264.77,190.76 263.64,189.62 263.64,170.14 258.54,165.04 258.54,145.31 252.46,139.23 229.57,139.23 227.8,137.46 217.37,137.46 204.82,150.01 167.43,150.01 165.84,151.6 144.41,151.6 143.18,150.38 143.18,149.6 143.76,149.03 162.42,149.03 162.84,148.61 162.84,148.17 162.56,147.89 143.09,147.89 142.8,147.6 142.8,146.86 143.17,146.49 199.44,146.49 200.2,147.24 203.29,147.24 203.93,146.61 203.93,145.6 203.44,145.11 143.24,145.11 142.75,144.62 142.75,144.1 143.26,143.59 206.82,143.59 207.12,143.29 207.12,141.7 206.53,141.12 143.3,141.12 142.94,140.76 142.94,139.53 143.64,138.83 163.06,138.83 163.71,138.19 163.71,137.7 163.24,137.23 143.54,137.23 143.03,136.72 143.03,135.73 143.44,135.32 163.55,135.32 164.02,134.85 164.02,134.37 163.48,133.83 144.12,133.83 143.39,133.11 143.39,131.99 145.33,130.06 196.4,130.06 197.63,128.82 205.1,128.82 206.17,129.89 234.56,129.89 238.2,133.54 247.82,133.54 250.13,131.22 250.13,129.82 v1(249.66,129.35)
D12313: length 347.6
  L07_SIGNAL w0.071: v1(276.97,144.59) 276.5,144.12 276.5,136.26 274.73,134.49 274.73,107.93 278.99,103.66 278.99,58.62 275.04,54.67 273.49,54.67 271.08,52.25 266.48,52.25 265.68,53.06 265.68,54.36 D123.13
  L30_SIGNAL w0.071: v1(276.97,144.59) 276.5,144.12 276.5,140.56 273.33,137.39 268.79,137.39 266.84,135.43 266.84,131.56 263.39,128.1 196.12,128.1 194.89,129.33 144.57,129.33 141.77,132.13 141.77,150.27 144.22,152.71 166.29,152.71 167.13,151.87 182.39,151.87 188.37,157.86 188.37,176.38 188.09,176.66 v1(184.47,176.66)
D12314: length 833.7
  TOP w0.086: SITE3.75 263.98,188.03 264.06,188.11 278.84,188.11 v1(279.29,187.66)
  L07_SIGNAL w0.071: D123.14 269.01,60.73 269.01,61.93 271.63,64.55 275.48,64.55 277.48,66.55 277.48,102.78 272.28,107.97 272.28,129.23 273.6,130.54 273.6,143.9 271.58,145.92 271.58,158.92 272.89,160.23 275.77,160.23 276.5,159.5 276.5,158.65 v1(276.97,158.18)
  L30_SIGNAL w0.071: v1(276.97,158.18) 276.51,158.64 276.51,159.51 276.98,159.98 277.98,159.98 279.32,158.63 279.32,150.13 281.5,147.96 281.5,138.99 266.83,124.32 207.37,124.32 205.86,122.81 157.94,122.81 157.22,123.53 28.02,123.53 26.41,121.92 26.41,120.73 27.46,119.68 61.22,119.68 62.22,118.68 62.22,117.77 61.19,116.74 29.07,116.74 27.6,115.26 27.6,113.3 29.77,111.13 143.03,111.13 152,120.1 156.83,120.1 159.85,117.09 254.22,117.09 254.99,116.32 263.33,116.32 265.08,118.07 274.4,118.07 283.02,126.69 283.02,136.18 286.39,139.55 286.39,142.48 285.14,143.72 285.14,156.02 277.84,163.33 277.84,187.75 278.21,188.13 278.82,188.13 v1(279.29,187.66)
D12315: length 347.6
  L07_SIGNAL w0.071: D123.15 267.89,54.53 266.96,54.53 265.87,53.45 265.87,53.14 266.57,52.45 270.99,52.45 273.41,54.87 274.95,54.87 278.79,58.71 278.79,103.58 274.53,107.84 274.53,134.57 276.3,136.34 276.3,144.12 v1(275.82,144.59)
  L30_SIGNAL w0.071: v1(275.82,144.59) 276.3,144.12 276.3,140.64 273.24,137.58 268.71,137.58 266.64,135.52 266.64,131.64 263.31,128.3 196.2,128.3 194.98,129.53 144.66,129.53 141.97,132.21 141.97,150.19 144.3,152.52 166.21,152.52 167.05,151.68 182.47,151.68 188.57,157.78 188.57,176.38 188.84,176.66 v1(192.47,176.66)
D12316: length 833.7
  TOP w0.086: v1(279.29,188.8) 278.84,188.35 264.06,188.35 263.98,188.43 SITE3.76
  L07_SIGNAL w0.071: D123.16 270.84,59.36 270.49,59.36 269.2,60.65 269.2,61.85 271.71,64.36 275.56,64.36 277.67,66.47 277.67,102.86 272.48,108.06 272.48,129.14 273.79,130.46 273.79,143.98 271.78,146 271.78,158.83 272.97,160.03 275.69,160.03 276.3,159.42 276.3,158.65 v1(275.82,158.18)
  L30_SIGNAL w0.071: v1(275.82,158.18) 276.31,158.66 276.31,159.59 276.89,160.17 278.06,160.17 279.52,158.71 279.52,150.21 281.7,148.04 281.7,138.91 266.92,124.12 207.45,124.12 205.94,122.62 157.86,122.62 157.14,123.33 28.1,123.33 26.61,121.84 26.61,120.81 27.54,119.88 61.31,119.88 62.42,118.76 62.42,117.69 61.27,116.54 29.16,116.54 27.8,115.18 27.8,113.38 29.85,111.33 142.95,111.33 151.92,120.3 156.92,120.3 159.93,117.28 254.3,117.28 255.07,116.51 263.25,116.51 265,118.26 274.32,118.26 282.82,126.77 282.82,136.27 286.19,139.63 286.19,142.39 284.94,143.64 284.94,155.94 277.64,163.24 277.64,187.83 278.13,188.33 278.82,188.33 v1(279.29,188.8)
D12401: length 833.7
  TOP w0.086: SITE3.100 255.03,197.78 254.95,197.86 254.95,202.07 257.55,204.67 257.55,206.76 v1(258,207.21)
  L05_SIGNAL w0.071: v1(195.26,203.56) 195.73,203.09 196.41,203.09 196.69,203.37 196.69,204.08 196.43,204.34 187.11,204.34 186.04,203.27 186.04,144.55 179.73,138.24 171.45,138.24 169.65,136.44 141.83,136.44 129.5,148.77 129.5,157.87 126.87,160.5 88.32,160.5 83.45,155.63 83.45,138.72 95.48,126.69 95.48,42.35 98.24,39.59 134.74,39.59 138.42,43.28 138.42,48.42 147.23,57.22 202.46,57.22 209.31,50.37 209.31,34.24 217.07,26.48 233.19,26.48 236.52,29.82 236.52,33.28 235.56,34.24 235,34.24 D124.01
  L32_SIGNAL w0.071: v1(195.26,203.56) 194.79,203.09 193.58,203.09 188.15,208.52 162.97,208.52 157.98,203.53 157.98,188.44 166.02,180.4 166.02,173.36 157.35,164.69 157.35,147.81 162.92,142.23 204.38,142.23 214.25,152.1 226.67,152.1 240.07,138.7 272.62,138.7 279.89,145.97 279.89,185.48 280.82,186.41 280.82,193.94 279.71,195.05 278.69,195.05 277.53,196.21 260.34,196.21 257.53,199.02 257.53,206.74 v1(258,207.21)
D12402: length 833.7
  TOP w0.086: v1(224.31,199.31) 224.75,198.87 231.22,198.87 236.94,193.15 237.6,193.15 237.68,193.23 SITE3.133
  L05_SIGNAL w0.071: v1(198.44,189.59) 197.97,189.12 197.12,189.12 196.1,188.09 191.06,188.09 188.85,185.88 188.85,143.8 181.89,136.83 172.07,136.83 168.8,133.57 142.79,133.57 138.83,137.52 90.4,137.52 88.98,138.95 88.98,139.84 89.45,140.31 126.8,140.31 127.79,141.3 127.79,142.39 126.85,143.33 89.55,143.33 88.8,144.09 88.8,144.7 89.43,145.33 126.78,145.33 127.46,146.01 127.46,147.12 126.6,147.98 89.53,147.98 88.62,148.9 88.62,149.86 89.42,150.67 125.45,150.67 126.17,151.39 126.17,152.62 125.42,153.36 89.55,153.36 89.01,153.9 89.01,155.32 89.78,156.09 126.98,156.09 127.67,156.78 127.67,157.91 126.85,158.73 89.42,158.73 86.9,156.22 86.9,137.76 97.75,126.91 97.75,46.4 100.27,43.88 131.37,43.88 147,59.51 201.71,59.51 210.65,50.56 210.65,35.37 218,28.02 229.01,28.02 231.63,30.64 231.63,38.32 235.72,42.41 237.86,42.41 238.57,41.71 238.57,40.45 D124.02
  L32_SIGNAL w0.071: v1(198.44,189.59) 198.91,189.12 200.29,189.12 202.81,191.64 202.81,196.17 205.48,198.84 223.83,198.84 v1(224.31,199.31)
D12403: length 833.7
  TOP w0.086: SITE3.101 254.63,197.78 254.71,197.86 254.71,202.17 257.31,204.77 257.31,206.76 v1(256.85,207.21)
  L05_SIGNAL w0.071: D124.03 236.72,33.52 236.72,29.73 233.27,26.28 216.99,26.28 209.11,34.16 209.11,50.29 202.38,57.03 147.31,57.03 138.62,48.34 138.62,43.19 134.82,39.39 98.16,39.39 95.28,42.27 95.28,126.61 83.25,138.64 83.25,155.71 88.24,160.7 126.95,160.7 129.7,157.95 129.7,148.85 141.91,136.64 169.57,136.64 171.37,138.44 179.65,138.44 185.84,144.63 185.84,203.36 187.03,204.54 196.51,204.54 196.88,204.17 196.88,203.29 196.49,202.89 195.73,202.89 v1(195.26,202.42)
  L32_SIGNAL w0.071: v1(256.85,207.21) 257.33,206.74 257.33,198.94 260.26,196.01 277.44,196.01 278.6,194.85 279.63,194.85 280.62,193.86 280.62,186.49 279.69,185.56 279.69,146.05 272.53,138.89 240.16,138.89 226.75,152.3 214.16,152.3 204.3,142.43 163,142.43 157.54,147.89 157.54,164.61 166.22,173.28 166.22,180.48 158.18,188.52 158.18,203.44 163.06,208.32 188.07,208.32 193.5,202.89 194.79,202.89 v1(195.26,202.42)
D12404: length 833.7
  TOP w0.086: SITE3.134 237.68,192.83 237.6,192.91 236.84,192.91 231.12,198.63 224.77,198.63 v1(224.31,198.17)
  L05_SIGNAL w0.071: D124.04 239.97,39.43 239.55,39.43 238.77,40.21 238.77,41.79 237.94,42.61 235.63,42.61 231.43,38.41 231.43,30.72 228.92,28.21 218.09,28.21 210.85,35.45 210.85,50.64 201.79,59.71 146.92,59.71 131.29,44.08 100.35,44.08 97.95,46.48 97.95,126.99 87.1,137.84 87.1,156.13 89.5,158.54 126.77,158.54 127.47,157.83 127.47,156.86 126.9,156.29 89.7,156.29 88.81,155.4 88.81,153.82 89.47,153.16 125.34,153.16 125.97,152.53 125.97,151.48 125.37,150.87 89.34,150.87 88.42,149.95 88.42,148.81 89.45,147.78 126.52,147.78 127.26,147.04 127.26,146.09 126.69,145.52 89.34,145.52 88.6,144.78 88.6,144.01 89.47,143.13 126.77,143.13 127.6,142.31 127.6,141.38 126.72,140.51 89.37,140.51 88.78,139.92 88.78,138.87 90.32,137.32 138.75,137.32 142.7,133.37 168.88,133.37 172.15,136.64 181.97,136.64 189.05,143.72 189.05,185.8 191.15,187.9 196.18,187.9 197.2,188.92 197.97,188.92 v1(198.44,188.45)
  L32_SIGNAL w0.071: v1(224.31,198.17) 223.83,198.64 205.56,198.64 203.01,196.08 203.01,191.55 200.38,188.92 198.91,188.92 v1(198.44,188.45)
D12405: length 833.7
  TOP w0.086: v1(265.72,207.21) 265.28,206.78 265.28,206.31 264.35,205.37 264.35,204.04 258.55,198.23 258.55,197.86 258.63,197.78 SITE3.91
  L05_SIGNAL w0.071: D124.05 246.32,33.08 247.12,33.08 247.31,32.9 247.31,27.84 244.31,24.84 210.35,24.84 205.84,29.34 205.84,50.49 201.66,54.67 147.26,54.67 139.95,47.36 139.95,39.96 136.82,36.83 93.88,36.83 92.91,37.8 92.91,124.68 81.35,136.25 81.35,179.27 83.34,181.27 102.11,181.27 102.66,180.71 102.66,179.8 102.2,179.34 83.03,179.34 82.51,178.81 82.51,177.31 82.98,176.83 105.51,176.83 106.35,176 106.35,174.99 105.45,174.1 83.46,174.1 82.68,173.32 82.68,172.28 83.27,171.68 106.97,171.68 107.74,172.46 130.08,172.46 130.52,172.01 130.52,170.37 129.58,169.42 107.27,169.42 105.9,170.79 96.86,170.79 95.39,169.32 95.39,167.73 96.6,166.52 129.5,166.52 131.13,164.89 131.13,151.41 144.12,138.41 170.3,138.41 172.23,140.34 176.06,140.34 182.9,147.18 182.9,215.69 186.44,219.23 195.79,219.23 196.32,218.7 196.32,216.78 196.08,216.55 195.73,216.55 v1(195.26,217.02)
  L32_SIGNAL w0.071: v1(195.26,217.02) 195.73,216.55 196.59,216.55 196.87,216.83 196.87,219.04 199.94,222.12 217.87,222.12 221.57,218.41 231.09,218.41 233.94,221.25 260.44,221.25 265.89,215.81 265.89,212.05 265.24,211.41 265.24,207.69 v1(265.72,207.21)
D12406: length 833.7
  TOP w0.086: SITE3.98 255.83,197.78 255.75,197.86 255.75,201.48 258.7,204.43 258.7,206.53 259.46,207.3 259.46,208.47 v1(259.93,208.93)
  L05_SIGNAL w0.071: v1(198.44,217.02) 197.97,216.55 197.58,216.55 197.03,216 197.03,207.43 199.83,204.64 199.83,187.7 196.88,184.76 191.74,184.76 189.89,182.9 189.89,142.7 178.63,131.44 128.86,131.44 125.47,134.83 105.16,134.83 100.38,130.05 100.38,46.18 100.78,45.79 101.55,45.79 102.77,47.01 102.77,125.57 103.83,126.62 104.53,126.62 105.41,125.75 105.41,47.13 106.07,46.46 107.21,46.46 107.9,47.15 107.9,125.81 108.52,126.43 109.59,126.43 110.37,125.65 110.37,47.84 111.29,46.92 127.95,46.92 143.22,62.19 201.37,62.19 217.68,45.88 247.17,45.88 248.63,44.42 248.63,40.35 D124.06
  L32_SIGNAL w0.071: v1(259.93,208.93) 259.45,209.4 259.45,211.36 254.93,215.88 252.06,215.88 251.01,214.83 239.71,214.83 238.43,213.56 210.21,213.56 209.57,212.92 203.46,212.92 199.83,216.55 198.91,216.55 v1(198.44,217.02)
D12407: length 833.7
  TOP w0.086: v1(264.57,207.21) 265.04,206.74 265.04,206.4 264.11,205.47 264.11,204.13 258.31,198.33 258.31,197.86 258.23,197.78 SITE3.92
  L05_SIGNAL w0.071: D124.07 247.51,34.15 247.51,27.76 244.39,24.64 210.26,24.64 205.65,29.26 205.65,50.41 201.58,54.48 147.34,54.48 140.14,47.28 140.14,39.87 136.91,36.63 93.8,36.63 92.72,37.71 92.72,124.6 81.15,136.17 81.15,179.36 83.26,181.47 102.19,181.47 102.86,180.8 102.86,179.72 102.28,179.14 83.12,179.14 82.7,178.73 82.7,177.39 83.06,177.03 105.59,177.03 106.55,176.08 106.55,174.91 105.54,173.9 83.54,173.9 82.88,173.23 82.88,172.36 83.35,171.88 106.89,171.88 107.66,172.65 130.16,172.65 130.72,172.09 130.72,170.29 129.66,169.22 107.18,169.22 105.82,170.59 96.94,170.59 95.59,169.24 95.59,167.81 96.68,166.72 129.58,166.72 131.33,164.98 131.33,151.49 144.21,138.61 170.22,138.61 172.15,140.54 175.98,140.54 182.7,147.26 182.7,215.77 186.36,219.43 195.87,219.43 196.51,218.79 196.51,216.7 196.17,216.35 195.73,216.35 v1(195.26,215.88)
  L32_SIGNAL w0.071: v1(195.26,215.88) 195.73,216.35 196.67,216.35 197.07,216.75 197.07,218.96 200.02,221.92 217.78,221.92 221.49,218.21 231.17,218.21 234.02,221.06 260.36,221.06 265.69,215.73 265.69,212.14 265.04,211.49 265.04,207.69 v1(264.57,207.21)
D12408: length 833.7
  TOP w0.086: SITE3.99 255.43,197.78 255.51,197.86 255.51,201.58 258.46,204.53 258.46,206.63 259.23,207.4 259.23,208.49 v1(258.78,208.93)
  L05_SIGNAL w0.071: v1(198.44,215.88) 197.97,216.35 197.66,216.35 197.23,215.92 197.23,207.51 200.02,204.72 200.02,187.62 196.97,184.56 191.82,184.56 190.09,182.82 190.09,142.62 178.71,131.24 128.78,131.24 125.39,134.64 105.24,134.64 100.58,129.97 100.58,46.27 100.86,45.98 101.47,45.98 102.57,47.09 102.57,125.65 103.75,126.82 104.61,126.82 105.6,125.83 105.6,47.21 106.16,46.65 107.12,46.65 107.7,47.23 107.7,125.9 108.44,126.63 109.67,126.63 110.57,125.74 110.57,47.93 111.38,47.12 127.87,47.12 143.14,62.39 201.45,62.39 217.76,46.08 247.25,46.08 248.83,44.5 248.83,39.89 249.2,39.51 250.05,39.51 D124.08
  L32_SIGNAL w0.071: v1(258.78,208.93) 259.26,209.4 259.26,211.28 254.85,215.68 252.15,215.68 251.09,214.63 239.79,214.63 238.51,213.36 210.29,213.36 209.65,212.72 203.38,212.72 199.74,216.35 198.91,216.35 v1(198.44,215.88)
D12501: length 413.5
  TOP w0.086: v1(228.38,238.12) 228.77,238.5 237.61,238.5 237.68,238.43 SITE1.170
  L03_SIGNAL w0.071: D125.01 14.11,95.11 15.13,95.11 15.7,94.54 15.7,92.61 14.28,91.19 11.61,91.19 9.03,93.76 9.03,194.4 75.2,260.57 195.23,260.57 196.58,259.22 196.58,258.09 197.17,257.5 197.71,257.5 v2(198.18,257.03)
  L28_SIGNAL w0.071: v1(228.38,238.12) 227.91,238.59 227.66,238.59 226.86,239.39 226.86,244.38 225.57,245.67 225.57,259.05 221.28,263.35 199.2,263.35 198.54,262.69 198.54,261.8 199.21,261.12 204.82,261.12 205.44,260.5 205.44,259.48 204.73,258.76 200.96,258.76 199.7,257.5 198.66,257.5 v2(198.18,257.03)
D12502: length 457
  TOP w0.086: v1(235.41,217.99) 235.41,218.63 244.15,227.37 244.15,231.4 244.23,231.48 SITE1.6
  L03_SIGNAL w0.071: v2(212.03,243.31) 212.5,243.78 213.52,243.78 214.2,244.47 214.2,248.17 207.95,254.43 74.02,254.43 16.42,196.83 16.42,100.24 D125.02
  L28_SIGNAL w0.071: v1(235.41,217.99) 235.41,218.66 235.72,218.97 235.72,225.05 236.88,226.21 236.88,231.62 235.23,233.27 235.23,251.26 221.65,264.84 198.02,264.84 195.99,262.81 195.99,254.34 205.56,244.76 209.62,244.76 210.59,243.78 211.55,243.78 v2(212.03,243.31)
D12503: length 413.5
  TOP w0.086: v1(228.38,239.26) 228.9,238.74 237.59,238.74 237.68,238.83 SITE1.169
  L03_SIGNAL w0.071: D125.03 15.9,94.64 15.9,92.53 14.36,90.99 11.53,90.99 8.84,93.68 8.84,194.48 75.12,260.77 195.31,260.77 196.78,259.3 196.78,258.17 197.25,257.7 197.71,257.7 v2(198.18,258.17)
  L28_SIGNAL w0.071: v2(198.18,258.17) 198.66,257.7 199.62,257.7 200.88,258.96 204.64,258.96 205.24,259.56 205.24,260.42 204.73,260.93 199.13,260.93 198.34,261.72 198.34,262.77 199.11,263.54 221.36,263.54 225.77,259.13 225.77,245.75 227.06,244.47 227.06,239.47 227.74,238.79 227.91,238.79 v1(228.38,239.26)
D12504: length 457
  TOP w0.086: v1(234.6,218.8) 235.24,218.8 243.91,227.47 243.91,231.4 243.83,231.48 SITE1.5
  L03_SIGNAL w0.071: D125.04 19.24,100.14 17.07,100.14 16.62,100.6 16.62,196.75 74.1,254.23 207.87,254.23 214.01,248.09 214.01,244.55 213.44,243.98 212.5,243.98 v2(212.03,244.46)
  L28_SIGNAL w0.071: v1(234.6,218.8) 235.27,218.8 235.52,219.05 235.52,225.13 236.68,226.29 236.68,231.54 235.04,233.18 235.04,251.18 221.57,264.65 198.11,264.65 196.18,262.72 196.18,254.42 205.65,244.96 209.7,244.96 210.68,243.98 211.55,243.98 v2(212.03,244.46)
D12505: length 413.5
  TOP w0.086: v1(225.36,240.02) 225.84,240.5 232.15,240.5 233.34,239.31 237.6,239.31 237.68,239.23 SITE1.168
  L03_SIGNAL w0.071: D125.05 24,95.38 24.84,95.38 25.87,94.36 25.87,89.95 23.45,87.53 11.23,87.53 7,91.77 7,197.29 72.44,262.74 204.65,262.74 209.9,257.5 211.3,257.5 v1(211.77,257.03)
  L28_SIGNAL w0.071: v1(225.36,240.02) 224.89,240.49 224.23,240.49 222.61,242.11 222.61,255.82 220.93,257.5 212.24,257.5 v1(211.77,257.03)
D12506: length 457
  TOP w0.086: SITE1.8 245.03,231.48 244.95,231.4 244.95,225.37 239.21,219.63 v1(239.21,218.99)
  L03_SIGNAL w0.071: D125.06 26.69,100.35 26.69,112.08 24.6,114.16 24.6,199.17 78.39,252.96 196.1,252.96 199.85,249.22 199.85,244.28 199.35,243.78 198.91,243.78 v2(198.44,243.31)
  L28_SIGNAL w0.071: v1(239.21,218.99) 239.21,219.66 239.41,219.86 239.41,263.47 232.91,269.97 187.36,269.97 185.18,267.79 185.18,256.36 193.58,247.97 193.58,246.89 196.68,243.78 197.97,243.78 v2(198.44,243.31)
D12507: length 413.5
  TOP w0.086: SITE1.167 237.68,239.63 237.6,239.55 233.44,239.55 232.25,240.74 225.78,240.74 v1(225.36,241.16)
  L03_SIGNAL w0.071: v2(211.77,258.17) 211.3,257.7 209.98,257.7 204.74,262.94 72.36,262.94 6.8,197.38 6.8,91.68 11.15,87.33 23.53,87.33 26.07,89.87 26.07,94.65 D125.07
  L28_SIGNAL w0.071: v1(225.36,241.16) 224.89,240.69 224.31,240.69 222.81,242.19 222.81,255.9 221.01,257.7 212.24,257.7 v2(211.77,258.17)
D12508: length 457
  TOP w0.086: v1(238.4,219.8) 239.04,219.8 244.71,225.47 244.71,231.4 244.63,231.48 SITE1.7
  L03_SIGNAL w0.071: v2(198.44,244.46) 198.91,243.98 199.26,243.98 199.65,244.37 199.65,249.14 196.02,252.77 78.48,252.77 24.8,199.09 24.8,114.24 26.88,112.16 26.88,100.3 27.05,100.13 29.41,100.13 D125.08
  L28_SIGNAL w0.071: v2(198.44,244.46) 197.97,243.98 196.76,243.98 193.78,246.97 193.78,248.05 185.38,256.45 185.38,267.71 187.44,269.77 232.82,269.77 239.21,263.38 239.21,219.94 239.07,219.8 v1(238.4,219.8)
D12509: length 413.5
  TOP w0.086: SITE1.2 242.63,231.48 242.55,231.4 242.55,231.18 242.13,230.76 234.03,230.76 233.52,230.25 228.97,230.25 v1(228.51,229.79)
  L03_SIGNAL w0.071: v2(195.26,243.31) 194.79,243.78 193.68,243.78 192.61,244.86 190.06,244.86 188.99,243.78 185.49,243.78 178.99,237.28 83.88,237.28 45.32,198.73 45.32,129.02 59.27,115.07 59.27,95.31 52.98,89.02 37.07,89.02 35.22,90.88 35.22,94.32 D125.09
  L28_SIGNAL w0.071: v1(228.51,229.79) 228.98,230.26 229.7,230.26 230.51,231.07 230.51,235.79 229.15,237.15 227.35,237.15 226.88,237.61 226.88,238.52 226.31,239.09 224.39,239.09 221.93,241.55 216.08,241.55 215.45,242.19 189.4,242.19 185.86,245.73 185.86,248.35 184.74,249.47 183.79,249.47 181.79,251.47 181.79,252.77 182.48,253.46 183.87,253.46 193.55,243.78 195.19,243.78 195.26,243.71 v2(195.26,243.31)
D12510: length 413.5
  TOP w0.086: SITE1.174 237.68,236.83 237.6,236.91 236.1,236.91 234.04,234.85 228.85,234.85 v1(228.4,234.39)
  L03_SIGNAL w0.071: v2(181.67,243.31) 182.15,243.78 182.42,243.78 182.74,244.1 182.74,246.33 180.03,249.04 79.89,249.04 29.32,198.48 29.32,120.28 36.74,112.86 36.74,100.24 D125.10
  L28_SIGNAL w0.071: v1(228.4,234.39) 227.93,234.87 226.93,234.87 225.95,235.84 225.95,237.7 225.38,238.27 223.86,238.27 222.01,240.13 170.47,240.13 169.55,241.04 169.55,245.93 170.14,246.52 171,246.52 171.56,245.97 171.56,241.95 172.08,241.43 172.77,241.43 173.36,242.02 173.36,244.75 173.86,245.25 174.56,245.25 175.12,244.7 175.12,242.8 175.71,242.22 179.9,242.22 180.47,242.79 180.47,247.12 178.27,249.32 175.17,249.32 174.55,249.95 174.55,252.5 175.03,252.98 178.03,252.98 183.18,247.83 183.18,244.28 182.69,243.78 182.15,243.78 v2(181.67,243.31)
D12511: length 413.5
  TOP w0.086: SITE1.1 242.23,231.48 242.31,231.4 242.31,231.28 242.03,231 233.93,231 233.42,230.49 228.95,230.49 v1(228.51,230.93)
  L03_SIGNAL w0.071: D125.11 36.67,95.09 35.79,95.09 35.41,94.72 35.41,90.96 37.16,89.22 52.9,89.22 59.07,95.39 59.07,114.99 45.13,128.93 45.13,198.81 83.79,237.48 178.9,237.48 185.41,243.98 188.91,243.98 189.98,245.06 192.69,245.06 193.77,243.98 194.79,243.98 v2(195.26,244.46)
  L28_SIGNAL w0.071: v1(228.51,230.93) 228.98,230.46 229.62,230.46 230.31,231.16 230.31,235.71 229.07,236.95 227.26,236.95 226.68,237.53 226.68,238.43 226.22,238.89 224.31,238.89 221.85,241.36 216,241.36 215.36,241.99 189.32,241.99 185.66,245.65 185.66,248.27 184.66,249.27 183.71,249.27 181.6,251.39 181.6,252.86 182.4,253.66 183.96,253.66 193.63,243.98 195.19,243.98 195.26,244.05 v2(195.26,244.46)
D12512: length 413.5
  TOP w0.086: SITE1.173 237.68,237.23 237.6,237.15 236,237.15 233.94,235.08 228.85,235.08 v1(228.4,235.54)
  L03_SIGNAL w0.071: v2(181.67,244.46) 182.15,243.98 182.34,243.98 182.54,244.18 182.54,246.25 179.95,248.84 79.97,248.84 29.52,198.39 29.52,120.36 36.94,112.94 36.94,100.65 37.4,100.19 39.51,100.19 D125.12
  L28_SIGNAL w0.071: v1(228.4,235.54) 227.93,235.06 227.01,235.06 226.14,235.93 226.14,237.79 225.46,238.47 223.95,238.47 222.09,240.32 170.55,240.32 169.75,241.13 169.75,245.85 170.22,246.32 170.92,246.32 171.36,245.88 171.36,241.86 171.99,241.23 172.85,241.23 173.56,241.93 173.56,244.67 173.94,245.06 174.48,245.06 174.92,244.61 174.92,242.72 175.63,242.02 179.98,242.02 180.67,242.71 180.67,247.2 178.35,249.52 175.26,249.52 174.75,250.03 174.75,252.42 175.12,252.78 177.95,252.78 182.98,247.75 182.98,244.36 182.61,243.98 182.15,243.98 v2(181.67,244.46)
D12513: length 413.5
  TOP w0.086: v1(225.39,236.18) 225.85,236.63 234.38,236.63 235.46,237.71 237.6,237.71 237.68,237.63 SITE1.172
  L03_SIGNAL w0.071: v2(178.5,243.31) 178.03,243.78 176.91,243.78 176.12,244.58 171.9,244.58 171.11,243.78 168.94,243.78 166.18,241.03 82.4,241.03 39.76,198.4 39.76,128.48 56.06,112.18 56.06,94.5 51.92,90.35 47.01,90.35 44.61,92.75 44.61,95.09 D125.13
  L28_SIGNAL w0.071: v1(225.39,236.18) 224.92,236.65 223.85,236.65 222.67,237.82 213.7,237.82 212.66,238.86 170.26,238.86 168.64,240.48 168.64,244.06 167.42,245.28 154.64,245.28 153.74,246.18 153.74,248.63 154.47,249.36 164.66,249.36 166.73,247.29 178.03,247.29 179.86,245.46 179.86,244.31 179.34,243.78 178.97,243.78 v2(178.5,243.31)
D12514: length 413.5
  TOP w0.086: SITE1.176 237.68,236.03 237.6,236.11 237.48,236.11 237.25,235.88 237.25,234.98 235.19,232.92 225.91,232.92 v1(225.46,232.46)
  L03_SIGNAL w0.071: D125.14 47.63,100.97 47.63,111.82 34.51,124.94 34.51,198.84 82.1,246.44 164.96,246.44 166.22,245.17 166.22,244.13 165.88,243.78 165.38,243.78 v2(164.91,243.31)
  L28_SIGNAL w0.071: v1(225.46,232.46) 224.98,232.94 224.31,232.94 222.79,234.45 222.79,236.41 222.31,236.89 212.23,236.89 211.14,235.81 134.33,235.81 132.88,237.26 132.88,240.39 134.1,241.61 165.85,241.61 166.34,242.1 166.34,243.16 165.72,243.78 165.38,243.78 v2(164.91,243.31)
D12515: length 413.5
  TOP w0.086: SITE1.171 237.68,238.03 237.6,237.95 235.37,237.95 234.29,236.87 225.85,236.87 v1(225.39,237.32)
  L03_SIGNAL w0.071: D125.15 46.79,95.05 45.43,95.05 44.81,94.43 44.81,92.83 47.09,90.55 51.84,90.55 55.86,94.58 55.86,112.1 39.57,128.39 39.57,198.48 82.31,241.22 166.1,241.22 168.86,243.98 171.03,243.98 171.82,244.77 176.2,244.77 176.99,243.98 178.03,243.98 v2(178.5,244.46)
  L28_SIGNAL w0.071: v1(225.39,237.32) 224.92,236.85 223.93,236.85 222.76,238.02 213.78,238.02 212.74,239.06 170.34,239.06 168.84,240.56 168.84,244.14 167.51,245.48 154.72,245.48 153.93,246.27 153.93,248.55 154.55,249.16 164.57,249.16 166.64,247.09 177.95,247.09 179.66,245.38 179.66,244.39 179.25,243.98 178.97,243.98 v2(178.5,244.46)
D12516: length 413.5
  TOP w0.086: v1(225.46,233.61) 225.91,233.16 235.09,233.16 237.01,235.08 237.01,235.98 237.38,236.35 237.6,236.35 237.68,236.43 SITE1.175
  L03_SIGNAL w0.071: v2(164.91,244.46) 165.38,243.98 165.8,243.98 166.02,244.21 166.02,245.09 164.87,246.24 82.18,246.24 34.71,198.76 34.71,125.02 47.83,111.9 47.83,101.07 48.78,100.11 49.75,100.11 D125.16
  L28_SIGNAL w0.071: v2(164.91,244.46) 165.38,243.98 165.8,243.98 166.54,243.24 166.54,242.02 165.94,241.42 134.18,241.42 133.07,240.31 133.07,237.34 134.41,236 211.06,236 212.15,237.09 222.4,237.09 222.99,236.49 222.99,234.53 224.39,233.14 224.98,233.14 v1(225.46,233.61)
D12609: length 457
  TOP w0.086: v1(250.13,216.61) 249.68,217.05 249.68,221.65 248.15,223.18 248.15,231.4 248.23,231.48 SITE1.16
  L03_SIGNAL w0.071: v1(181.67,229.6) 181.2,230.07 180.65,230.07 180.1,229.52 180.1,226.13 176,222.03 130.95,222.03 129.39,220.47 87.91,220.47 87.2,219.77 87.2,205.39 72.03,190.22 72.03,82.33 58.22,68.51 36.99,68.51 34.96,70.54 34.96,74.26 D126.09
  L28_SIGNAL w0.071: v1(181.67,229.6) 181.2,230.07 180.6,230.07 180.05,230.63 180.05,232.05 181.31,233.32 198.27,233.32 199.44,232.16 199.44,226.71 198.14,225.41 175.87,225.41 173.23,222.78 173.23,216.8 175.19,214.84 212.34,214.84 214.08,216.58 235.33,216.58 236.09,217.34 240.73,217.34 243.1,219.71 248.27,219.71 249.66,218.32 249.66,217.08 v1(250.13,216.61)
D12610: length 457
  TOP w0.086: v1(247.8,218.55) 247.35,218.99 247.35,231.4 247.43,231.48 SITE1.14
  L03_SIGNAL w0.071: D126.10 37.28,80.46 37.28,85.37 39.26,87.35 54.12,87.35 61.25,94.47 61.25,117.36 49.74,128.87 49.74,198.11 85.65,234.02 194.9,234.02 196.82,232.1 196.82,230.44 196.45,230.07 195.73,230.07 v1(195.26,229.6)
  L28_SIGNAL w0.071: v1(195.26,229.6) 195.73,230.07 196.1,230.07 196.73,229.44 196.73,228.04 195.17,226.48 166.95,226.48 165.41,224.94 165.41,214.73 167.32,212.82 212.57,212.82 214.68,214.93 235.45,214.93 236.83,216.3 242.46,216.3 243.55,217.39 245.62,217.39 246.01,217.01 246.85,217.01 247.33,217.48 247.33,218.07 v1(247.8,218.55)
D12611: length 457
  TOP w0.086: SITE1.15 247.83,231.48 247.91,231.4 247.91,223.08 249.45,221.55 249.45,217.06 v1(248.99,216.61)
  L03_SIGNAL w0.071: D126.11 36.87,74.97 35.38,74.97 35.16,74.75 35.16,70.62 37.07,68.71 58.13,68.71 71.84,82.41 71.84,190.3 87.01,205.47 87.01,219.85 87.82,220.67 129.31,220.67 130.87,222.23 175.92,222.23 179.9,226.21 179.9,229.6 180.57,230.27 181.2,230.27 v1(181.67,230.74)
  L28_SIGNAL w0.071: v1(181.67,230.74) 181.2,230.27 180.69,230.27 180.25,230.71 180.25,231.97 181.4,233.12 198.19,233.12 199.24,232.07 199.24,226.8 198.05,225.61 175.79,225.61 173.04,222.86 173.04,216.72 175.11,214.65 212.43,214.65 214.16,216.38 235.42,216.38 236.17,217.14 240.81,217.14 243.18,219.51 248.19,219.51 249.46,218.24 249.46,217.08 v1(248.99,216.61)
