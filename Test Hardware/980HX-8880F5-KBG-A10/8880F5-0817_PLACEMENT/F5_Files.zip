# Allegro board 8880F5-0827_updates.brd (continued)
## Nets (continued)
D11111: D111.11 SITE2.82(AMLCKN) UNK2R14.2
D11112: D111.12 SITE2.123(CML3N) UNK2R68.2
D11113: D111.13 SITE2.124(CML4P) UNK2R69.1
D11114: D111.14 SITE2.87(AML5P) UNK2R19.1
D11115: D111.15 SITE2.125(CML4N) UNK2R70.2
D11116: D111.16 SITE2.88(AML5N) UNK2R20.2
D11201: D112.01 SITE2.98(BML3P) UNK2R29.1
D11202: D112.02 SITE2.91(BML1P) UNK2R23.1
D11203: D112.03 SITE2.99(BML3N) UNK2R30.2
D11204: D112.04 SITE2.92(BML1N) UNK2R24.2
D11205: D112.05 SITE2.93(BML2P) UNK2R25.1
D11206: D112.06 SITE2.140(DML4P) UNK2R63.1
D11207: D112.07 SITE2.94(BML2N) UNK2R26.2
D11208: D112.08 SITE2.141(DML4N) UNK2R64.2
D11209: D112.09 SITE2.137(DML3P) UNK2R43.1
D11210: D112.10 SITE2.95(BMLCKP) UNK2R27.1
D11211: D112.11 SITE2.138(DML3N) UNK2R44.2
D11212: D112.12 SITE2.96(BMLCKN) UNK2R28.2
D11213: D112.13 SITE2.142(DML5P) UNK2R100.1
D11214: D112.14 SITE2.79(AML2P) UNK2R11.1
D11215: D112.15 SITE2.143(DML5N) UNK2R101.2
D11216: D112.16 SITE2.80(AML2N) UNK2R12.2
D11301: D113.01 R11.1 SITE1.79(AML2P)
D11302: D113.02 R17.1 SITE1.85(AML4P)
D11303: D113.03 R12.2 SITE1.80(AML2N)
D11304: D113.04 R18.2 SITE1.86(AML4N)
D11305: D113.05 R13.1 SITE1.81(AMLCKP)
D11306: D113.06 R15.1 SITE1.83(AML3P)
D11307: D113.07 R14.2 SITE1.82(AMLCKN)
D11308: D113.08 R16.2 SITE1.84(AML3N)
D11309: D113.09 R39.1 SITE1.116(CML2P)
D11310: D113.10 R19.1 SITE1.87(AML5P)
D11311: D113.11 R40.2 SITE1.117(CML2N)
D11312: D113.12 R20.2 SITE1.88(AML5N)
D11313: D113.13 R41.1 SITE1.120(CMLCKP)
D11314: D113.14 R37.1 SITE1.114(CML1P)
D11315: D113.15 R42.2 SITE1.121(CMLCKN)
D11316: D113.16 R38.2 SITE1.115(CML1N)
D11401: D114.01 R9.1 SITE1.75(AML1P)
D11402: D114.02 K43.6 R7.1
D11403: D114.03 R10.2 SITE1.76(AML1N)
D11404: D114.04 K43.3 R8.2
D11405: D114.05 R33.1 SITE1.102(BML5P)
D11406: D114.06 R27.1 SITE1.95(BMLCKP)
D11407: D114.07 R34.2 SITE1.103(BML5N)
D11408: D114.08 R28.2 SITE1.96(BMLCKN)
D11409: D114.09
D11410: D114.10 R31.1 SITE1.100(BML4P)
D11411: D114.11
D11412: D114.12 R32.2 SITE1.101(BML4N)
D11413: D114.13 R69.1 SITE1.124(CML4P)
D11414: D114.14 R67.1 SITE1.122(CML3P)
D11415: D114.15 R70.2 SITE1.125(CML4N)
D11416: D114.16 R68.2 SITE1.123(CML3N)
D11501: D115.01 R29.1 SITE1.98(BML3P)
D11502: D115.02 R21.1 SITE1.89(BML0P)
D11503: D115.03 R30.2 SITE1.99(BML3N)
D11504: D115.04 R22.2 SITE1.90(BML0N)
D11505: D115.05 R25.1 SITE1.93(BML2P)
D11506: D115.06 R23.1 SITE1.91(BML1P)
D11507: D115.07 R26.2 SITE1.94(BML2N)
D11508: D115.08 R24.2 SITE1.92(BML1N)
D11509: D115.09
D11510: D115.10
D11511: D115.11
D11512: D115.12
D11513: D115.13
D11514: D115.14
D11515: D115.15
D11516: D115.16
D11601: D116.01 SITE2.133(DML2P) UNK2R77.1
D11602: D116.02 SITE2.131(DML1P) UNK2R75.1
D11603: D116.03 SITE2.134(DML2N) UNK2R78.2
D11604: D116.04 SITE2.132(DML1N) UNK2R76.2
D11605: D116.05 SITE2.129(DML0P) UNK2R73.1
D11606: D116.06 SITE2.100(BML4P) UNK2R31.1
D11607: D116.07 SITE2.130(DML0N) UNK2R74.2
D11608: D116.08 SITE2.101(BML4N) UNK2R32.2
D11609: D116.09 SITE2.89(BML0P) UNK2R21.1
D11610: D116.10 SITE2.135(DMLCKP) UNK2R79.1
D11611: D116.11 SITE2.90(BML0N) UNK2R22.2
D11612: D116.12 SITE2.136(DMLCKN) UNK2R80.2
D11613: D116.13 SITE2.102(BML5P) UNK2R33.1
D11614: D116.14
D11615: D116.15 SITE2.103(BML5N) UNK2R34.2
D11616: D116.16
D11801: D118.01 SITE3.116(CML2P) UNK3R39.1
D11802: D118.02 SITE3.126(CML5P) UNK3R71.1
D11803: D118.03 SITE3.117(CML2N) UNK3R40.2
D11804: D118.04 SITE3.127(CML5N) UNK3R72.2
D11805: D118.05 SITE3.142(DML5P) UNK3R100.1
D11806: D118.06 SITE3.140(DML4P) UNK3R63.1
D11807: D118.07 SITE3.143(DML5N) UNK3R101.2
D11808: D118.08 SITE3.141(DML4N) UNK3R64.2
D11809: D118.09 SITE3.102(BML5P) UNK3R33.1
D11810: D118.10 SITE3.129(DML0P) UNK3R73.1
D11811: D118.11 SITE3.103(BML5N) UNK3R34.2
D11812: D118.12 SITE3.130(DML0N) UNK3R74.2
D11813: D118.13 SITE3.114(CML1P) UNK3R37.1
D11814: D118.14 UNK3K43.6 UNK3R7.1
D11815: D118.15 SITE3.115(CML1N) UNK3R38.2
D11816: D118.16 UNK3K43.3 UNK3R8.2
D11901: D119.01 SITE3.8(ELV1P) UNK3R46.2
D11902: D119.02 SITE3.6(ELV0P) UNK3R103.2
D11903: D119.03 SITE3.7(ELV1N) UNK3R45.1
D11904: D119.04 SITE3.5(ELV0N) UNK3R102.1
D11905: D119.05 SITE3.75(AML1P) UNK3R9.1
D11906: D119.06 SITE3.120(CMLCKP) UNK3R41.1
D11907: D119.07 SITE3.76(AML1N) UNK3R10.2
D11908: D119.08 SITE3.121(CMLCKN) UNK3R42.2
D11909: D119.09 SITE3.122(CML3P) UNK3R67.1
D11910: D119.10 SITE3.124(CML4P) UNK3R69.1
D11911: D119.11 SITE3.123(CML3N) UNK3R68.2
D11912: D119.12 SITE3.125(CML4N) UNK3R70.2
D11913: D119.13 SITE3.10(ELV2P) UNK3R52.2
D11914: D119.14 SITE3.12(ELVCKP) UNK3R54.2
D11915: D119.15 SITE3.9(ELV2N) UNK3R51.1
D11916: D119.16 SITE3.11(ELVCKN) UNK3R53.1
D12001: D120.01 SITE3.2(OLV4P) UNK3R60.2
D12002: D120.02 SITE3.168(OLV0P) UNK3R56.2
D12003: D120.03 SITE3.1(OLV4N) UNK3R59.1
D12004: D120.04 SITE3.167(OLV0N) UNK3R55.1
D12005: D120.05 SITE3.174(OLVCKP) UNK3R62.2
D12006: D120.06 SITE3.170(OLV1P) UNK3R58.2
D12007: D120.07 SITE3.173(OLVCKN) UNK3R61.1
D12008: D120.08 SITE3.169(OLV1N) UNK3R57.1
D12009: D120.09 SITE3.14(ELV3P) UNK3R48.2
D12010: D120.10 SITE3.16(ELV4P) UNK3R50.2
D12011: D120.11 SITE3.13(ELV3N) UNK3R47.1
D12012: D120.12 SITE3.15(ELV4N) UNK3R49.1
D12013: D120.13 SITE3.172(OLV2P) UNK3R105.2
D12014: D120.14 SITE3.176(OLV3P) UNK3R66.2
D12015: D120.15 SITE3.171(OLV2N) UNK3R104.1
D12016: D120.16 SITE3.175(OLV3N) UNK3R65.1
D12201: D122.01 SITE3.81(AMLCKP) UNK3R13.1
D12202: D122.02 SITE3.79(AML2P) UNK3R11.1
D12203: D122.03 SITE3.82(AMLCKN) UNK3R14.2
D12204: D122.04 SITE3.80(AML2N) UNK3R12.2
D12205: D122.05 SITE3.93(BML2P) UNK3R25.1
D12206: D122.06 SITE3.133(DML2P) UNK3R77.1
D12207: D122.07 SITE3.94(BML2N) UNK3R26.2
D12208: D122.08 SITE3.134(DML2N) UNK3R78.2
D12209: D122.09 SITE3.91(BML1P) UNK3R23.1
D12210: D122.10 SITE3.137(DML3P) UNK3R43.1
D12211: D122.11 SITE3.92(BML1N) UNK3R24.2
D12212: D122.12 SITE3.138(DML3N) UNK3R44.2
D12213: D122.13 SITE3.85(AML4P) UNK3R17.1
D12214: D122.14 SITE3.83(AML3P) UNK3R15.1
D12215: D122.15 SITE3.86(AML4N) UNK3R18.2
D12216: D122.16 SITE3.84(AML3N) UNK3R16.2
D12301: D123.01 SITE3.95(BMLCKP) UNK3R27.1
D12302: D123.02 SITE3.100(BML4P) UNK3R31.1
D12303: D123.03 SITE3.96(BMLCKN) UNK3R28.2
D12304: D123.04 SITE3.101(BML4N) UNK3R32.2
D12305: D123.05 SITE3.98(BML3P) UNK3R29.1
D12306: D123.06
D12307: D123.07 SITE3.99(BML3N) UNK3R30.2
D12308: D123.08
D12309: D123.09 SITE3.89(BML0P) UNK3R21.1
D12310: D123.10 SITE3.131(DML1P) UNK3R75.1
D12311: D123.11 SITE3.90(BML0N) UNK3R22.2
D12312: D123.12 SITE3.132(DML1N) UNK3R76.2
D12313: D123.13 SITE3.135(DMLCKP) UNK3R79.1
D12314: D123.14 SITE3.87(AML5P) UNK3R19.1
D12315: D123.15 SITE3.136(DMLCKN) UNK3R80.2
D12316: D123.16 SITE3.88(AML5N) UNK3R20.2
D12401: D124.01
D12402: D124.02
D12403: D124.03
D12404: D124.04
D12405: D124.05
D12406: D124.06
D12407: D124.07
D12408: D124.08
D12409: D124.09
D12410: D124.10
D12411: D124.11
D12412: D124.12
D12413: D124.13
D12414: D124.14
D12415: D124.15
D12416: D124.16
D12501: D125.01
D12502: D125.02
D12503: D125.03
D12504: D125.04
D12505: D125.05
D12506: D125.06
D12507: D125.07
D12508: D125.08
D12509: D125.09
D12510: D125.10
D12511: D125.11
D12512: D125.12
D12513: D125.13
D12514: D125.14
D12515: D125.15
D12516: D125.16
D12601: D126.01
D12602: D126.02
D12603: D126.03
D12604: D126.04
D12605: D126.05
D12606: D126.06
D12607: D126.07
D12608: D126.08
D12609: D126.09
D12610: D126.10
D12611: D126.11
D12612: D126.12
D12613: D126.13
D12614: D126.14
D12615: D126.15
D12616: D126.16
D12701: D127.01
D12702: D127.02
D12703: D127.03
D12704: D127.04
D12705: D127.05
D12706: D127.06
D12707: D127.07
D12708: D127.08
D12709: D127.09
D12710: D127.10
D12711: D127.11
D12712: D127.12
D12713: D127.13
D12714: D127.14
D12715: D127.15
D12716: D127.16
D12801: D128.01
D12802: D128.02
D12803: D128.03
D12804: D128.04
D12805: D128.05
D12806: D128.06
D12807: D128.07
D12808: D128.08
D12809: D128.09
D12810: D128.10
D12811: D128.11
D12812: D128.12
D12813: D128.13
D12814: D128.14
D12815: D128.15
D12816: D128.16
D12901: D129.01 R79.1 SITE1.135(DMLCKP)
D12902: D129.02 R73.1 SITE1.129(DML0P)
D12903: D129.03 R80.2 SITE1.136(DMLCKN)
D12904: D129.04 R74.2 SITE1.130(DML0N)
D12905: D129.05 R43.1 SITE1.137(DML3P)
D12906: D129.06 R77.1 SITE1.133(DML2P)
D12907: D129.07 R44.2 SITE1.138(DML3N)
D12908: D129.08 R78.2 SITE1.134(DML2N)
D12909: D129.09 R63.1 SITE1.140(DML4P)
D12910: D129.10 R75.1 SITE1.131(DML1P)
D12911: D129.11 R64.2 SITE1.141(DML4N)
D12912: D129.12 R76.2 SITE1.132(DML1N)
D12913: D129.13 R100.1 SITE1.142(DML5P)
D12914: D129.14 R71.1 SITE1.126(CML5P)
D12915: D129.15 R101.2 SITE1.143(DML5N)
D12916: D129.16 R72.2 SITE1.127(CML5N)
D13001: D130.01
D13002: D130.02
D13003: D130.03
D13004: D130.04
D13005: D130.05
D13006: D130.06
D13007: D130.07
D13008: D130.08
D13009: D130.09
D13010: D130.10
D13011: D130.11
D13012: D130.12
D13013: D130.13
D13014: D130.14
D13015: D130.15
D13016: D130.16
D13101: D131.01 R50.2 SITE1.16(ELV4P)
D13102: D131.02 R48.2 SITE1.14(ELV3P)
D13103: D131.03 R49.1 SITE1.15(ELV4N)
D13104: D131.04 R47.1 SITE1.13(ELV3N)
D13105: D131.05
D13106: D131.06
D13107: D131.07
D13108: D131.08
D13109: D131.09
D13110: D131.10
D13111: D131.11
D13112: D131.12
D13113: D131.13 R58.2 SITE1.170(OLV1P)
D13114: D131.14 R54.2 SITE1.12(ELVCKP)
D13115: D131.15 R57.1 SITE1.169(OLV1N)
D13116: D131.16 R53.1 SITE1.11(ELVCKN)
D13201: D132.01 R105.2 SITE1.172(OLV2P)
D13202: D132.02 R62.2 SITE1.174(OLVCKP)
D13203: D132.03 R104.1 SITE1.171(OLV2N)
D13204: D132.04 R61.1 SITE1.173(OLVCKN)
D13205: D132.05 R66.2 SITE1.176(OLV3P)
D13206: D132.06 R60.2 SITE1.2(OLV4P)
D13207: D132.07 R65.1 SITE1.175(OLV3N)
D13208: D132.08 R59.1 SITE1.1(OLV4N)
D13209: D132.09 R103.2 SITE1.6(ELV0P)
D13210: D132.10 R56.2 SITE1.168(OLV0P)
D13211: D132.11 R102.1 SITE1.5(ELV0N)
D13212: D132.12 R55.1 SITE1.167(OLV0N)
D13213: D132.13 R46.2 SITE1.8(ELV1P)
D13214: D132.14 R52.2 SITE1.10(ELV2P)
D13215: D132.15 R45.1 SITE1.7(ELV1N)
D13216: D132.16 R51.1 SITE1.9(ELV2N)
D30101: D301.01
D30102: D301.02 SITE4.26(RXD0P)
D30103: D301.03
D30104: D301.04 SITE4.27(RXD0N)
D30105: D301.05
D30106: D301.06 SITE4.29(RXD1P)
D30107: D301.07
D30108: D301.08 SITE4.30(RXD1N)
D30109: D301.09
D30110: D301.10 SITE4.32(RXD2P)
D30111: D301.11
D30112: D301.12 SITE4.33(RXD2N)
D30113: D301.13
D30114: D301.14 SITE4.35(RXD3P)
D30115: D301.15
D30116: D301.16 SITE4.36(RXD3N)
D30201: D302.01
D30202: D302.02
D30203: D302.03
D30204: D302.04
D30205: D302.05
D30206: D302.06
D30207: D302.07
D30208: D302.08
D30209: D302.09
D30210: D302.10
D30211: D302.11
D30212: D302.12
D30213: D302.13
D30214: D302.14
D30215: D302.15
D30216: D302.16
D30501: D305.01
D30502: D305.02 SITE2.26(RXD0P)
D30503: D305.03
D30504: D305.04 SITE2.27(RXD0N)
D30505: D305.05
D30506: D305.06 SITE2.29(RXD1P)
D30507: D305.07
D30508: D305.08 SITE2.30(RXD1N)
D30509: D305.09
D30510: D305.10 SITE2.32(RXD2P)
D30511: D305.11
D30512: D305.12 SITE2.33(RXD2N)
D30513: D305.13
D30514: D305.14 SITE2.35(RXD3P)
D30515: D305.15
D30516: D305.16 SITE2.36(RXD3N)
D30601: D306.01
D30602: D306.02
D30603: D306.03
D30604: D306.04
D30605: D306.05
D30606: D306.06
D30607: D306.07
D30608: D306.08
D30609: D306.09
D30610: D306.10
D30611: D306.11
D30612: D306.12
D30613: D306.13
D30614: D306.14
D30615: D306.15
D30616: D306.16
D31701: D317.01
D31702: D317.02 SITE3.26(RXD0P)
D31703: D317.03
D31704: D317.04 SITE3.27(RXD0N)
D31705: D317.05
D31706: D317.06 SITE3.29(RXD1P)
D31707: D317.07
D31708: D317.08 SITE3.30(RXD1N)
D31709: D317.09
D31710: D317.10 SITE3.32(RXD2P)
D31711: D317.11
D31712: D317.12 SITE3.33(RXD2N)
D31713: D317.13
D31714: D317.14 SITE3.35(RXD3P)
D31715: D317.15
D31716: D317.16 SITE3.36(RXD3N)
D31801: D318.01
D31802: D318.02
D31803: D318.03
D31804: D318.04
D31805: D318.05
D31806: D318.06
D31807: D318.07
D31808: D318.08
D31809: D318.09
D31810: D318.10
D31811: D318.11
D31812: D318.12
D31813: D318.13
D31814: D318.14
D31815: D318.15
D31816: D318.16
D32101: D321.01
D32102: D321.02 SITE1.26(RXD0P)
D32103: D321.03
D32104: D321.04 SITE1.27(RXD0N)
D32105: D321.05
D32106: D321.06 SITE1.29(RXD1P)
D32107: D321.07
D32108: D321.08 SITE1.30(RXD1N)
D32109: D321.09
D32110: D321.10 SITE1.32(RXD2P)
D32111: D321.11
D32112: D321.12 SITE1.33(RXD2N)
D32113: D321.13
D32114: D321.14 SITE1.35(RXD3P)
D32115: D321.15
D32116: D321.16 SITE1.36(RXD3N)
D32201: D322.01
D32202: D322.02
D32203: D322.03
D32204: D322.04
D32205: D322.05
D32206: D322.06
D32207: D322.07
D32208: D322.08
D32209: D322.09
D32210: D322.10
D32211: D322.11
D32212: D322.12
D32213: D322.13
D32214: D322.14
D32215: D322.15
D32216: D322.16
MSDPS1_1F: DPS1.C03
MSDPS1_1GRD: DPS1.B02
MSDPS1_1GS: DPS1.A02
MSDPS1_1S: DPS1.C02
MSDPS1_2F: DPS1.C07
MSDPS1_2GRD: DPS1.B06
MSDPS1_2GS: DPS1.A06
MSDPS1_2S: DPS1.C06
MSDPS1_3F: DPS1.C13
MSDPS1_3GRD: DPS1.B12
MSDPS1_3GS: DPS1.A12
MSDPS1_3S: DPS1.C12
MSDPS1_4F: DPS1.C17
MSDPS1_4GRD: DPS1.B16
MSDPS1_4GS: DPS1.A16
MSDPS1_4S: DPS1.C16
MSDPS1_5F: DPS1.A03
MSDPS1_5GS: DPS1.B01
MSDPS1_5S: DPS1.B03
MSDPS1_6F: DPS1.A07
MSDPS1_6GS: DPS1.B05
MSDPS1_6S: DPS1.B07
MSDPS1_7F: DPS1.A13
MSDPS1_7GS: DPS1.B11
MSDPS1_7S: DPS1.B13
MSDPS1_8F: DPS1.A17
MSDPS1_8GS: DPS1.B15
MSDPS1_8S: DPS1.B17
MSDPS1_TR+: DPS1.A09
MSDPS1_TRVB-: DPS1.B09 SB1.2
MSDPS1_VB+: DPS1.C09
MSDPS2_1F: DPS2.C03
MSDPS2_1GRD: DPS2.B02
MSDPS2_1GS: DPS2.A02
MSDPS2_1S: DPS2.C02
MSDPS2_2F: DPS2.C07
MSDPS2_2GRD: DPS2.B06
MSDPS2_2GS: DPS2.A06
MSDPS2_2S: DPS2.C06
MSDPS2_3F: DPS2.C13
MSDPS2_3GRD: DPS2.B12
MSDPS2_3GS: DPS2.A12
MSDPS2_3S: DPS2.C12
MSDPS2_4F: DPS2.C17
MSDPS2_4GRD: DPS2.B16
MSDPS2_4GS: DPS2.A16
MSDPS2_4S: DPS2.C16
MSDPS2_5F: DPS2.A03
MSDPS2_5GS: DPS2.B01
MSDPS2_5S: DPS2.B03
MSDPS2_6F: DPS2.A07
MSDPS2_6GS: DPS2.B05
MSDPS2_6S: DPS2.B07
MSDPS2_7F: DPS2.A13
MSDPS2_7GS: DPS2.B11
MSDPS2_7S: DPS2.B13
MSDPS2_8F: DPS2.A17
MSDPS2_8GS: DPS2.B15
MSDPS2_8S: DPS2.B17
MSDPS2_TR+: DPS2.A09
MSDPS2_TRVB-: DPS2.B09 SB2.2
MSDPS2_VB+: DPS2.C09
MSDPS3_1F: DPS3.C03
MSDPS3_1GRD: DPS3.B02
MSDPS3_1GS: DPS3.A02
MSDPS3_1S: DPS3.C02
MSDPS3_2F: DPS3.C07
MSDPS3_2GRD: DPS3.B06
MSDPS3_2GS: DPS3.A06
MSDPS3_2S: DPS3.C06
MSDPS3_3F: DPS3.C13
MSDPS3_3GRD: DPS3.B12
MSDPS3_3GS: DPS3.A12
MSDPS3_3S: DPS3.C12
MSDPS3_4F: DPS3.C17
MSDPS3_4GRD: DPS3.B16
MSDPS3_4GS: DPS3.A16
MSDPS3_4S: DPS3.C16
MSDPS3_5F: DPS3.A03
MSDPS3_5GS: DPS3.B01
MSDPS3_5S: DPS3.B03
MSDPS3_6F: DPS3.A07
MSDPS3_6GS: DPS3.B05
MSDPS3_6S: DPS3.B07
MSDPS3_7F: DPS3.A13
MSDPS3_7GS: DPS3.B11
MSDPS3_7S: DPS3.B13
MSDPS3_8F: DPS3.A17
MSDPS3_8GS: DPS3.B15
MSDPS3_8S: DPS3.B17
MSDPS3_TR+: DPS3.A09
MSDPS3_TRVB-: DPS3.B09 SB3.2
MSDPS3_VB+: DPS3.C09
MSDPS8_1F: DPS8.C03
MSDPS8_1GRD: DPS8.B02
MSDPS8_1GS: DPS8.A02
MSDPS8_1S: DPS8.C02
MSDPS8_2F: DPS8.C07
MSDPS8_2GRD: DPS8.B06
MSDPS8_2GS: DPS8.A06
MSDPS8_2S: DPS8.C06
MSDPS8_3F: DPS8.C13
MSDPS8_3GRD: DPS8.B12
MSDPS8_3GS: DPS8.A12
MSDPS8_3S: DPS8.C12
MSDPS8_4F: DPS8.C17
MSDPS8_4GRD: DPS8.B16
MSDPS8_4GS: DPS8.A16
MSDPS8_4S: DPS8.C16
MSDPS8_5F: DPS8.A03
MSDPS8_5GS: DPS8.B01
MSDPS8_5S: DPS8.B03
MSDPS8_6F: DPS8.A07
MSDPS8_6GS: DPS8.B05
MSDPS8_6S: DPS8.B07
MSDPS8_7F: DPS8.A13
MSDPS8_7GS: DPS8.B11
MSDPS8_7S: DPS8.B13
MSDPS8_8F: DPS8.A17
MSDPS8_8GS: DPS8.B15
MSDPS8_8S: DPS8.B17
MSDPS8_TR+: DPS8.A09
MSDPS8_TRVB-: DPS8.B09 SB8.2
MSDPS8_VB+: DPS8.C09
S1_1AUX+: K9.4 R129.1
S1_1AUX-: K9.5 R130.1
S1_1SPI_CSN: K15.5 K19.6
S1_1SPI_SCK: K15.4 K19.3
S1_1SPI_SDI: K14.5 K20.6
S1_1SPI_SDO: K14.4 K20.3
S1_2AUX+: C3.1 R1.2 R3.1 R129.2
S1_2AUX-: C4.1 R2.2 R4.2 R130.2
S1_AUX_100DCH001+: K9.2
S1_AUX_100DCH001-: K9.7
S1_AUX_100DCH002+: C3.2
S1_AUX_100DCH002-: C4.2
S1_AUXCH+: K9.3 K12.3 SITE1.21(AUXCHP)
S1_AUXCH-: K9.6 K12.6 SITE1.20(AUXCHN)
S1_AVDD11_RX: CA9.1 CA10.1 CC13.1 CD9.1 K37.9 SH10.1 SITE1.31(AVDD11_RX) TP_AVDD11_RX.1(TP)
S1_AVDD11_XTAL: CA32.1 CA33.1 CC26.1 CD16.1 K31.4 SH23.1 SITE1.105(AVDD11_XTAL) TP_AVDD11_XTAL.1(TP)
S1_AVDD18_RX: CA7.1 CA8.1 CC11.1 CD8.1 K37.4 SH7.1 SITE1.25(AVDD18_RX) TP_AVDD18_RX.1(TP)
S1_DCH041: SITE1.159(STV2)
S1_DCH042: SITE1.160(STV1)
S1_DCH043: SITE1.161(POL)
S1_DCH044: SITE1.163(TP1)
S1_DCH045: SITE1.164(DC_EN)
S1_DCH046: SITE1.165(H2POL)
S1_DCH047: SITE1.166(SQINV)
S1_DCH048: K18.7
S1_DCH049: K18.2
S1_DPS_F_001: CA19.1 CA20.1 R1.1 R4.1 SH20.1 TP_AUXVCC.1(TP)
S1_DPS_F_002: CA1.1 CA2.1 CC1.1 CC2.1 CD1.1 K34.4 SH1.1 SITE1.3(VDDA_33_LV) TP_VDDA_33_LV.1(TP)
S1_DPS_F_003: CA3.1 CA4.1 CC4.1 CC30.1 CC31.1 CC32.1 CC33.1 CC34.1 CC35.1 CC42.1 CD3.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 K34.9 R85.1 SH3.1 SITE1.17(VDD_IO_33-1) SITE1.37(VDD_IO_33-2) SITE1.63(VDD_IO_33-3) SITE1.71(VDD_IO_33-4) SITE1.107(VDD_IO_33-5) SITE1.145(VDD_IO_33-6) SITE1.162(VDD_IO_33-7) TP_VDD_IO_33.1(TP)
S1_DPS_F_006: CA17.1 CA18.1 CC25.1 CC40.1 CD15.1 K42.4 SH18.1 SITE1.72(VDD_TXREG_33_B) TP_VDD_TXREG_33_B.1(TP)
S1_DPS_F_007: CA11.1 CA12.1 CC15.1 CC16.1 CC27.1 CC28.1 CD10.1 CD11.1 K39.4 SH12.1 SITE1.78(VDDTXPST_11_B-1) SITE1.97(VDDTXPST_11_B-2) TP_VDDTXPST_11_B.1(TP)
S1_DPS_F_009: CA13.1 CA14.1 CC19.1 CC20.1 CD13.1 K40.4 SH14.1 SITE1.106(PLL_M_VDD33) TP_PLL_M_VDD33.1(TP)
S1_DPS_F_010: CA15.1 CA16.1 CC22.1 CC23.1 CD14.1 K40.9 SH16.1 SITE1.111(PLL_TX_VDD33) TP_PLL_TX_VDD33.1(TP)
S1_DPS_F_011: CA35.1 CA36.1 CC17.1 CC29.1 CC37.1 CC38.1 CD12.1 CD24.1 K39.9 SH25.1 SITE1.119(VDDTXPST_11_T-1) SITE1.139(VDDTXPST_11_T-2) TP_VDDTXPST_11_T.1(TP)
S1_DPS_F_012: CA38.1 CA39.1 CC39.1 CC41.1 CD25.1 K42.9 SH27.1 SITE1.144(VDD_TXREG_33_T) TP_VDD_TXREG_33_T.1(TP)
S1_DPS_F_013: C8.1 C9.1 CA30.1 CA31.1 R82.2 R83.1 R84.1 R87.2 R88.2 R89.2 R90.2 R91.2 R92.2 R94.2 R95.2 R96.2 R97.2 R98.2 R99.2 R119.1 R120.1 SH22.1 TP_VCC3V3.1(TP) U1.8(VCC) U2.8(VCC)
S1_DPS_FS_001: SH20.2
S1_DPS_FS_002: SH1.2
S1_DPS_FS_003: SH3.2
S1_DPS_FS_004: SH7.2
S1_DPS_FS_005: SH10.2
S1_DPS_FS_006: SH18.2
S1_DPS_FS_007: SH12.2
S1_DPS_FS_008: SH23.2
S1_DPS_FS_009: SH14.2
S1_DPS_FS_010: SH16.2
S1_DPS_FS_011: SH25.2
S1_DPS_FS_012: SH27.2
S1_DPS_FS_013: SH22.2
S1_DPS_GS_001: SH19.2
S1_DPS_GS_002: SH2.2
S1_DPS_GS_003: SH4.2
S1_DPS_GS_004: SH8.2
S1_DPS_GS_005: SH9.2
S1_DPS_GS_006: SH17.2
S1_DPS_GS_007: SH11.2
S1_DPS_GS_008: SH24.2
S1_DPS_GS_009: SH13.2
S1_DPS_GS_010: SH15.2
S1_DPS_GS_011: SH26.2
S1_DPS_GS_012: SH28.2
S1_DPS_GS_013: SH21.2
S1_ISP00+: K43.7 SITE1.73(AML0P)
S1_ISP00-: K43.2 SITE1.74(AML0N)
S1_ISP14+: K43.5 SITE1.112(CML0P)
S1_ISP14-: K43.4 SITE1.113(CML0N)
S1_ISP_1LOCK: K33.3 R118.2
S1_M_DPS_F_001: CA5.1 CA6.1 CC6.1 CC7.1 CC8.1 CC9.1 CC36.1 CD4.1 CD5.1 CD6.1 CD7.1 CD23.1 K36.4 K36.9 SH5.1 SITE1.22(VDDC_11-1) SITE1.39(VDDC_11-2) SITE1.64(VDDC_11-3) SITE1.104(VDDC_11-4) SITE1.147(VDDC_11-5) TP_VDDC_11.1(TP)
S1_M_DPS_FS_001: SH5.2
S1_M_DPS_GS_001: SH6.2
S1_PS9G_DCH001: SITE1.18(TEST)
S1_PS9G_DCH002: K10.3 S1_RST_N.1 SITE1.19(RESET_N)
S1_PS9G_DCH003: SITE1.24(HPD)
S1_PS9G_DCH004: SITE1.40(AGEN)
S1_PS9G_DCH005: SITE1.45(STV_IN)
S1_PS9G_DCH006: SITE1.46(EIO1)
S1_PS9G_DCH007: SITE1.47(EIO2)
S1_PS9G_DCH009: SITE1.49(PWMI)
S1_PS9G_DCH010: J4.2 K28.3 S1_I2C.1 SITE1.50(I2C_SCL)
S1_PS9G_DCH011: J5.2 K28.6 S1_I2C.2 SITE1.51(I2C_SDA)
S1_PS9G_DCH014: SITE1.54(LED_SPI_SIN_A)
S1_PS9G_DCH015: SITE1.55(LED_SPI_SCLK_A)
S1_PS9G_DCH022: SITE1.65(LED_SPI_SO_A)
S1_PS9G_DCH023: SITE1.66(LED_SPI_SO_B)
S1_PS9G_DCH027: SITE1.70(OSD_SPI_SDO)
S1_PS9G_DCH028: SITE1.77(NC_VDDTX_11_B)
S1_PS9G_DCH029: SITE1.118(NC_VDDTX_11_T)
S1_PS9G_DCH030: R118.1 SITE1.148(ISP_LOCK)
S1_PS9G_DCH035: SITE1.153(CLK6)
S1_PS9G_DCH036: SITE1.154(CLK5)
S1_PS9G_DCH037: SITE1.155(CLK4)
S1_PS9G_DCH038: SITE1.156(CLK3)
S1_PS9G_DCH039: SITE1.157(CLK2)
S1_PS9G_DCH040: SITE1.158(CLK1)
S1_RLY_001: K1.8(V-) K2.8(V-)
S1_RLY_003: K3.8(V-) K4.8(V-)
S1_RLY_005: K5.8(V-) K6.8(V-)
S1_RLY_007: K7.8(V-)
S1_RLY_008: K8.8(V-) K11.8(V-)
S1_RLY_009: K9.8(V-)
S1_RLY_010: K10.8(V-)
S1_RLY_012: K12.8(V-)
S1_RLY_013: K13.8(V-)
S1_RLY_014: K14.8(V-)
S1_RLY_015: K15.8(V-)
S1_RLY_016: K16.8(V-) K17.8(V-)
S1_RLY_018: K18.8(V-)
S1_RLY_019: K19.8(V-)
S1_RLY_020: K20.8(V-)
S1_RLY_021: K21.8(V-) K29.8(V-)
S1_RLY_022: K22.8(V-) K24.8(V-)
S1_RLY_023: K23.8(V-)
S1_RLY_025: K25.8(V-) K27.8(V-)
S1_RLY_026: K26.8(V-)
S1_RLY_028: K28.8(V-)
S1_RLY_030: K30.8(V-)
S1_RLY_031: K31.12(V-)
S1_RLY_033: K33.8(V-)
S1_RLY_034: K34.12(V-)
S1_RLY_036: K36.12(V-)
S1_RLY_037: K37.12(V-)
S1_RLY_039: K39.12(V-)
S1_RLY_040: K40.12(V-)
S1_RLY_042: K42.12(V-)
S1_RLY_043: K43.8(V-)
S1_SCAN_DCH008: SITE1.48(FAIL_FLAG_O)
S1_SCAN_DCH012: SITE1.52(LED_SPI_BLANK_A)
S1_SCAN_DCH013: SITE1.53(LED_SPI_GSCLK_A)
S1_SCAN_DCH016: SITE1.56(LED_SPI_XLAT_A)
S1_SCAN_DCH017: SITE1.57(LED_SPI_BLANK_B)
S1_SCAN_DCH018: SITE1.58(LED_SPI_GSCLK_B)
S1_SCAN_DCH019: SITE1.59(LED_SPI_SIN_B)
S1_SCAN_DCH020: SITE1.60(LED_SPI_SCLK_B)
S1_SCAN_DCH021: SITE1.61(LED_SPI_XLAT_B)
S1_SCAN_DCH024: K13.3 SITE1.67(OSD_SPI_SCK_I2CCLK)
S1_SCAN_DCH025: K13.6 SITE1.68(OSD_SPI_SDI_I2CDAT)
S1_SCAN_DCH026: SITE1.69(OSD_SPI_CSN)
S1_SCAN_DCH031: SITE1.149(OE2)
S1_SCAN_DCH032: SITE1.150(OE1)
S1_SCAN_DCH033: SITE1.151(CLK8)
S1_SCAN_DCH034: SITE1.152(CLK7)
S1_SCAN_DCH050: K15.2
S1_SCAN_DCH051: K15.7
S1_SCAN_DCH052: K14.2
S1_SCAN_DCH053: K14.7
S1_SPI_1_CSN: K19.7 R87.1 U1.1(CS#)
S1_SPI_1_SCK: K19.2 R91.1 U1.6(SCLK)
S1_SPI_1_SDI: K20.7 R127.1
S1_SPI_1_SDO: K20.2 R125.1
S1_SPI_2_CSN: K19.5 R94.1 U2.1(CS#)
S1_SPI_2_SCK: K19.4 R98.1 U2.6(SCLK)
S1_SPI_2_SDI: K20.5 R128.1
S1_SPI_2_SDO: K20.4 R126.1
S1_SPI_11_SDI: R88.1 R127.2 U1.2(SO)
S1_SPI_11_SDO: R92.1 R125.2 U1.5(SI)
S1_SPI_22_SDI: R95.1 R128.2 U2.2(SO)
S1_SPI_22_SDO: R99.1 R126.2 U2.5(SI)
S1_SPI_CSN: K15.6 SITE1.43(SPI_CSN)
S1_SPI_SCK: K15.3 SITE1.42(SPI_SCK)
S1_SPI_SDI: K14.6 SITE1.44(SPI_SDI)
S1_SPI_SDO: K14.3 SITE1.41(SPI_SDO)
S1_XTAL_IN: K18.3 SITE1.109(XTAL_IN) TP_XTAL_IN.1(TP)
S1_XTAL_OUT: K18.6 SITE1.110(XTAL_OUT) TP_XTAL_OUT.1(TP)
S2_1AUX+: UNK2K9.4 UNK2R129.1
S2_1AUX-: UNK2K9.5 UNK2R130.1
S2_1SPI_CSN: UNK2K15.5 UNK2K19.6
S2_1SPI_SCK: UNK2K15.4 UNK2K19.3
S2_1SPI_SDI: UNK2K14.5 UNK2K20.6
S2_1SPI_SDO: UNK2K14.4 UNK2K20.3
S2_2AUX+: UNK2C3.1 UNK2R1.2 UNK2R3.1 UNK2R129.2
S2_2AUX-: UNK2C4.1 UNK2R2.2 UNK2R4.2 UNK2R130.2
S2_AUX_100DCH001+: UNK2K9.2
S2_AUX_100DCH001-: UNK2K9.7
S2_AUX_100DCH002+: UNK2C3.2
S2_AUX_100DCH002-: UNK2C4.2
S2_AUXCH+: SITE2.21(AUXCHP) UNK2K9.3 UNK2K12.3
S2_AUXCH-: SITE2.20(AUXCHN) UNK2K9.6 UNK2K12.6
S2_AVDD11_RX: SITE2.31(AVDD11_RX) UNK2CA9.1 UNK2CA10.1 UNK2CC13.1 UNK2CD9.1 UNK2K37.9 UNK2SH10.1 UNK2TP_AVDD11_RX.1
S2_AVDD11_XTAL: SITE2.105(AVDD11_XTAL) UNK2CA32.1 UNK2CA33.1 UNK2CC26.1 UNK2CD16.1 UNK2K31.4 UNK2SH23.1 UNK2TP_AVDD11_XTAL.1
S2_AVDD18_RX: SITE2.25(AVDD18_RX) UNK2CA7.1 UNK2CA8.1 UNK2CC11.1 UNK2CD8.1 UNK2K37.4 UNK2SH7.1 UNK2TP_AVDD18_RX.1
S2_DCH041: SITE2.159(STV2)
S2_DCH042: SITE2.160(STV1)
S2_DCH043: SITE2.161(POL)
S2_DCH044: SITE2.163(TP1)
S2_DCH045: SITE2.164(DC_EN)
S2_DCH046: SITE2.165(H2POL)
S2_DCH047: SITE2.166(SQINV)
S2_DCH048: UNK2K18.7
S2_DCH049: UNK2K18.2
S2_DPS_F_001: UNK2CA19.1 UNK2CA20.1 UNK2R1.1 UNK2R4.1 UNK2SH20.1 UNK2TP_AUXVCC.1
S2_DPS_F_002: SITE2.3(VDDA_33_LV) UNK2CA1.1 UNK2CA2.1 UNK2CC1.1 UNK2CC2.1 UNK2CD1.1 UNK2K34.4 UNK2SH1.1 UNK2TP_VDDA_33_LV.1
S2_DPS_F_003: SITE2.17(VDD_IO_33-1) SITE2.37(VDD_IO_33-2) SITE2.63(VDD_IO_33-3) SITE2.71(VDD_IO_33-4) SITE2.107(VDD_IO_33-5) SITE2.145(VDD_IO_33-6) SITE2.162(VDD_IO_33-7) UNK2CA3.1 UNK2CA4.1 UNK2CC4.1 UNK2CC30.1 UNK2CC31.1 UNK2CC32.1 UNK2CC33.1 UNK2CC34.1 UNK2CC35.1 UNK2CC42.1 UNK2CD3.1 UNK2CD17.1 UNK2CD18.1 UNK2CD19.1 UNK2CD20.1 UNK2CD21.1 UNK2CD22.1 UNK2K34.9 UNK2R85.1 UNK2SH3.1 UNK2TP_VDD_IO_33.1
S2_DPS_F_006: SITE2.72(VDD_TXREG_33_B) UNK2CA17.1 UNK2CA18.1 UNK2CC25.1 UNK2CC40.1 UNK2CD15.1 UNK2K42.4 UNK2SH18.1 UNK2TP_VDD_TXREG_33_B.1
S2_DPS_F_007: SITE2.78(VDDTXPST_11_B-1) SITE2.97(VDDTXPST_11_B-2) UNK2CA11.1 UNK2CA12.1 UNK2CC15.1 UNK2CC16.1 UNK2CC27.1 UNK2CC28.1 UNK2CD10.1 UNK2CD11.1 UNK2K39.4 UNK2SH12.1 UNK2TP_VDDTXPST_11_B.1
S2_DPS_F_009: SITE2.106(PLL_M_VDD33) UNK2CA13.1 UNK2CA14.1 UNK2CC19.1 UNK2CC20.1 UNK2CD13.1 UNK2K40.4 UNK2SH14.1 UNK2TP_PLL_M_VDD33.1
S2_DPS_F_010: SITE2.111(PLL_TX_VDD33) UNK2CA15.1 UNK2CA16.1 UNK2CC22.1 UNK2CC23.1 UNK2CD14.1 UNK2K40.9 UNK2SH16.1 UNK2TP_PLL_TX_VDD33.1
S2_DPS_F_011: SITE2.119(VDDTXPST_11_T-1) SITE2.139(VDDTXPST_11_T-2) UNK2CA35.1 UNK2CA36.1 UNK2CC17.1 UNK2CC29.1 UNK2CC37.1 UNK2CC38.1 UNK2CD12.1 UNK2CD24.1 UNK2K39.9 UNK2SH25.1 UNK2TP_VDDTXPST_11_T.1
S2_DPS_F_012: SITE2.144(VDD_TXREG_33_T) UNK2CA38.1 UNK2CA39.1 UNK2CC39.1 UNK2CC41.1 UNK2CD25.1 UNK2K42.9 UNK2SH27.1 UNK2TP_VDD_TXREG_33_T.1
S2_DPS_F_013: UNK2C8.1 UNK2C9.1 UNK2CA30.1 UNK2CA31.1 UNK2R82.2 UNK2R83.1 UNK2R84.1 UNK2R87.2 UNK2R88.2 UNK2R89.2 UNK2R90.2 UNK2R91.2 UNK2R92.2 UNK2R94.2 UNK2R95.2 UNK2R96.2 UNK2R97.2 UNK2R98.2 UNK2R99.2 UNK2R119.1 UNK2R120.1 UNK2SH22.1 UNK2TP_VCC3V3.1 UNK2U1.8 UNK2U2.8
S2_DPS_FS_001: UNK2SH20.2
S2_DPS_FS_002: UNK2SH1.2
S2_DPS_FS_003: UNK2SH3.2
S2_DPS_FS_004: UNK2SH7.2
S2_DPS_FS_005: UNK2SH10.2
S2_DPS_FS_006: UNK2SH18.2
S2_DPS_FS_007: UNK2SH12.2
S2_DPS_FS_008: UNK2SH23.2
S2_DPS_FS_009: UNK2SH14.2
S2_DPS_FS_010: UNK2SH16.2
S2_DPS_FS_011: UNK2SH25.2
S2_DPS_FS_012: UNK2SH27.2
S2_DPS_FS_013: UNK2SH22.2
S2_DPS_GS_001: UNK2SH19.2
S2_DPS_GS_002: UNK2SH2.2
S2_DPS_GS_003: UNK2SH4.2
S2_DPS_GS_004: UNK2SH8.2
S2_DPS_GS_005: UNK2SH9.2
S2_DPS_GS_006: UNK2SH17.2
S2_DPS_GS_007: UNK2SH11.2
S2_DPS_GS_008: UNK2SH24.2
S2_DPS_GS_009: UNK2SH13.2
S2_DPS_GS_010: UNK2SH15.2
S2_DPS_GS_011: UNK2SH26.2
S2_DPS_GS_012: UNK2SH28.2
S2_DPS_GS_013: UNK2SH21.2
S2_ISP00+: SITE2.73(AML0P) UNK2K43.7
S2_ISP00-: SITE2.74(AML0N) UNK2K43.2
S2_ISP14+: SITE2.112(CML0P) UNK2K43.5
S2_ISP14-: SITE2.113(CML0N) UNK2K43.4
S2_ISP_1LOCK: UNK2K33.3 UNK2R118.2
S2_M_DPS_F_001: SITE2.22(VDDC_11-1) SITE2.39(VDDC_11-2) SITE2.64(VDDC_11-3) SITE2.104(VDDC_11-4) SITE2.147(VDDC_11-5) UNK2CA5.1 UNK2CA6.1 UNK2CC6.1 UNK2CC7.1 UNK2CC8.1 UNK2CC9.1 UNK2CC36.1 UNK2CD4.1 UNK2CD5.1 UNK2CD6.1 UNK2CD7.1 UNK2CD23.1 UNK2K36.4 UNK2K36.9 UNK2SH5.1 UNK2TP_VDDC_11.1
S2_M_DPS_FS_001: UNK2SH5.2
S2_M_DPS_GS_001: UNK2SH6.2
S2_PS9G_DCH001: SITE2.18(TEST)
S2_PS9G_DCH002: S2_RST_N.1 SITE2.19(RESET_N) UNK2K10.3
S2_PS9G_DCH003: SITE2.24(HPD)
S2_PS9G_DCH004: SITE2.40(AGEN)
S2_PS9G_DCH005: SITE2.45(STV_IN)
S2_PS9G_DCH006: SITE2.46(EIO1)
S2_PS9G_DCH007: SITE2.47(EIO2)
S2_PS9G_DCH009: SITE2.49(PWMI)
S2_PS9G_DCH010: S2_I2C.1 SITE2.50(I2C_SCL) UNK2J4.2 UNK2K28.3
S2_PS9G_DCH011: S2_I2C.2 SITE2.51(I2C_SDA) UNK2J5.2 UNK2K28.6
S2_PS9G_DCH014: SITE2.54(LED_SPI_SIN_A)
S2_PS9G_DCH015: SITE2.55(LED_SPI_SCLK_A)
S2_PS9G_DCH022: SITE2.65(LED_SPI_SO_A)
S2_PS9G_DCH023: SITE2.66(LED_SPI_SO_B)
S2_PS9G_DCH027: SITE2.70(OSD_SPI_SDO)
S2_PS9G_DCH028: SITE2.77(NC_VDDTX_11_B)
S2_PS9G_DCH029: SITE2.118(NC_VDDTX_11_T)
S2_PS9G_DCH030: SITE2.148(ISP_LOCK) UNK2R118.1
S2_PS9G_DCH035: SITE2.153(CLK6)
S2_PS9G_DCH036: SITE2.154(CLK5)
S2_PS9G_DCH037: SITE2.155(CLK4)
S2_PS9G_DCH038: SITE2.156(CLK3)
S2_PS9G_DCH039: SITE2.157(CLK2)
S2_PS9G_DCH040: SITE2.158(CLK1)
S2_RLY_001: UNK2K1.8 UNK2K2.8
S2_RLY_003: UNK2K3.8 UNK2K4.8
S2_RLY_005: UNK2K5.8 UNK2K6.8
S2_RLY_007: UNK2K7.8
S2_RLY_008: UNK2K8.8 UNK2K11.8
S2_RLY_009: UNK2K9.8
S2_RLY_010: UNK2K10.8
S2_RLY_012: UNK2K12.8
S2_RLY_013: UNK2K13.8
S2_RLY_014: UNK2K14.8
S2_RLY_015: UNK2K15.8
S2_RLY_016: UNK2K16.8 UNK2K17.8
S2_RLY_018: UNK2K18.8
S2_RLY_019: UNK2K19.8
S2_RLY_020: UNK2K20.8
S2_RLY_021: UNK2K21.8 UNK2K29.8
S2_RLY_022: UNK2K22.8 UNK2K24.8
S2_RLY_023: UNK2K23.8
S2_RLY_025: UNK2K25.8 UNK2K27.8
S2_RLY_026: UNK2K26.8
S2_RLY_028: UNK2K28.8
S2_RLY_030: UNK2K30.8
S2_RLY_031: UNK2K31.12
S2_RLY_033: UNK2K33.8
S2_RLY_034: UNK2K34.12
S2_RLY_036: UNK2K36.12
S2_RLY_037: UNK2K37.12
S2_RLY_039: UNK2K39.12
S2_RLY_040: UNK2K40.12
S2_RLY_042: UNK2K42.12
S2_RLY_043: UNK2K43.8
S2_SCAN_DCH008: SITE2.48(FAIL_FLAG_O)
S2_SCAN_DCH012: SITE2.52(LED_SPI_BLANK_A)
S2_SCAN_DCH013: SITE2.53(LED_SPI_GSCLK_A)
S2_SCAN_DCH016: SITE2.56(LED_SPI_XLAT_A)
S2_SCAN_DCH017: SITE2.57(LED_SPI_BLANK_B)
S2_SCAN_DCH018: SITE2.58(LED_SPI_GSCLK_B)
S2_SCAN_DCH019: SITE2.59(LED_SPI_SIN_B)
S2_SCAN_DCH020: SITE2.60(LED_SPI_SCLK_B)
S2_SCAN_DCH021: SITE2.61(LED_SPI_XLAT_B)
S2_SCAN_DCH024: SITE2.67(OSD_SPI_SCK_I2CCLK) UNK2K13.3
S2_SCAN_DCH025: SITE2.68(OSD_SPI_SDI_I2CDAT) UNK2K13.6
S2_SCAN_DCH026: SITE2.69(OSD_SPI_CSN)
S2_SCAN_DCH031: SITE2.149(OE2)
S2_SCAN_DCH032: SITE2.150(OE1)
S2_SCAN_DCH033: SITE2.151(CLK8)
S2_SCAN_DCH034: SITE2.152(CLK7)
S2_SCAN_DCH050: UNK2K15.2
S2_SCAN_DCH051: UNK2K15.7
S2_SCAN_DCH052: UNK2K14.2
S2_SCAN_DCH053: UNK2K14.7
S2_SPI_1_CSN: UNK2K19.7 UNK2R87.1 UNK2U1.1
S2_SPI_1_SCK: UNK2K19.2 UNK2R91.1 UNK2U1.6
S2_SPI_1_SDI: UNK2K20.7 UNK2R127.1
S2_SPI_1_SDO: UNK2K20.2 UNK2R125.1
S2_SPI_2_CSN: UNK2K19.5 UNK2R94.1 UNK2U2.1
S2_SPI_2_SCK: UNK2K19.4 UNK2R98.1 UNK2U2.6
S2_SPI_2_SDI: UNK2K20.5 UNK2R128.1
S2_SPI_2_SDO: UNK2K20.4 UNK2R126.1
S2_SPI_11_SDI: UNK2R88.1 UNK2R127.2 UNK2U1.2
S2_SPI_11_SDO: UNK2R92.1 UNK2R125.2 UNK2U1.5
S2_SPI_22_SDI: UNK2R95.1 UNK2R128.2 UNK2U2.2
S2_SPI_22_SDO: UNK2R99.1 UNK2R126.2 UNK2U2.5
S2_SPI_CSN: SITE2.43(SPI_CSN) UNK2K15.6
S2_SPI_SCK: SITE2.42(SPI_SCK) UNK2K15.3
S2_SPI_SDI: SITE2.44(SPI_SDI) UNK2K14.6
S2_SPI_SDO: SITE2.41(SPI_SDO) UNK2K14.3
S2_XTAL_IN: SITE2.109(XTAL_IN) UNK2K18.3 UNK2TP_XTAL_IN.1
S2_XTAL_OUT: SITE2.110(XTAL_OUT) UNK2K18.6 UNK2TP_XTAL_OUT.1
S3_1AUX+: UNK3K9.4 UNK3R129.1
S3_1AUX-: UNK3K9.5 UNK3R130.1
S3_1SPI_CSN: UNK3K15.5 UNK3K19.6
S3_1SPI_SCK: UNK3K15.4 UNK3K19.3
S3_1SPI_SDI: UNK3K14.5 UNK3K20.6
S3_1SPI_SDO: UNK3K14.4 UNK3K20.3
S3_2AUX+: UNK3C3.1 UNK3R1.2 UNK3R3.1 UNK3R129.2
S3_2AUX-: UNK3C4.1 UNK3R2.2 UNK3R4.2 UNK3R130.2
S3_AUX_100DCH001+: UNK3K9.2
S3_AUX_100DCH001-: UNK3K9.7
S3_AUX_100DCH002+: UNK3C3.2
S3_AUX_100DCH002-: UNK3C4.2
S3_AUXCH+: SITE3.21(AUXCHP) UNK3K9.3 UNK3K12.3
S3_AUXCH-: SITE3.20(AUXCHN) UNK3K9.6 UNK3K12.6
S3_AVDD11_RX: SITE3.31(AVDD11_RX) UNK3CA9.1 UNK3CA10.1 UNK3CC13.1 UNK3CD9.1 UNK3K37.9 UNK3SH10.1 UNK3TP_AVDD11_RX.1
S3_AVDD11_XTAL: SITE3.105(AVDD11_XTAL) UNK3CA32.1 UNK3CA33.1 UNK3CC26.1 UNK3CD16.1 UNK3K31.4 UNK3SH23.1 UNK3TP_AVDD11_XTAL.1
S3_AVDD18_RX: SITE3.25(AVDD18_RX) UNK3CA7.1 UNK3CA8.1 UNK3CC11.1 UNK3CD8.1 UNK3K37.4 UNK3SH7.1 UNK3TP_AVDD18_RX.1
S3_DCH041: SITE3.159(STV2)
S3_DCH042: SITE3.160(STV1)
S3_DCH043: SITE3.161(POL)
S3_DCH044: SITE3.163(TP1)
S3_DCH045: SITE3.164(DC_EN)
S3_DCH046: SITE3.165(H2POL)
S3_DCH047: SITE3.166(SQINV)
S3_DCH048: UNK3K18.7
S3_DCH049: UNK3K18.2
S3_DPS_F_001: UNK3CA19.1 UNK3CA20.1 UNK3R1.1 UNK3R4.1 UNK3SH20.1 UNK3TP_AUXVCC.1
S3_DPS_F_002: SITE3.3(VDDA_33_LV) UNK3CA1.1 UNK3CA2.1 UNK3CC1.1 UNK3CC2.1 UNK3CD1.1 UNK3K34.4 UNK3SH1.1 UNK3TP_VDDA_33_LV.1
S3_DPS_F_003: SITE3.17(VDD_IO_33-1) SITE3.37(VDD_IO_33-2) SITE3.63(VDD_IO_33-3) SITE3.71(VDD_IO_33-4) SITE3.107(VDD_IO_33-5) SITE3.145(VDD_IO_33-6) SITE3.162(VDD_IO_33-7) UNK3CA3.1 UNK3CA4.1 UNK3CC4.1 UNK3CC30.1 UNK3CC31.1 UNK3CC32.1 UNK3CC33.1 UNK3CC34.1 UNK3CC35.1 UNK3CC42.1 UNK3CD3.1 UNK3CD17.1 UNK3CD18.1 UNK3CD19.1 UNK3CD20.1 UNK3CD21.1 UNK3CD22.1 UNK3K34.9 UNK3R85.1 UNK3SH3.1 UNK3TP_VDD_IO_33.1
S3_DPS_F_006: SITE3.72(VDD_TXREG_33_B) UNK3CA17.1 UNK3CA18.1 UNK3CC25.1 UNK3CC40.1 UNK3CD15.1 UNK3K42.4 UNK3SH18.1 UNK3TP_VDD_TXREG_33_B.1
S3_DPS_F_007: SITE3.78(VDDTXPST_11_B-1) SITE3.97(VDDTXPST_11_B-2) UNK3CA11.1 UNK3CA12.1 UNK3CC15.1 UNK3CC16.1 UNK3CC27.1 UNK3CC28.1 UNK3CD10.1 UNK3CD11.1 UNK3K39.4 UNK3SH12.1 UNK3TP_VDDTXPST_11_B.1
S3_DPS_F_009: SITE3.106(PLL_M_VDD33) UNK3CA13.1 UNK3CA14.1 UNK3CC19.1 UNK3CC20.1 UNK3CD13.1 UNK3K40.4 UNK3SH14.1 UNK3TP_PLL_M_VDD33.1
S3_DPS_F_010: SITE3.111(PLL_TX_VDD33) UNK3CA15.1 UNK3CA16.1 UNK3CC22.1 UNK3CC23.1 UNK3CD14.1 UNK3K40.9 UNK3SH16.1 UNK3TP_PLL_TX_VDD33.1
S3_DPS_F_011: SITE3.119(VDDTXPST_11_T-1) SITE3.139(VDDTXPST_11_T-2) UNK3CA35.1 UNK3CA36.1 UNK3CC17.1 UNK3CC29.1 UNK3CC37.1 UNK3CC38.1 UNK3CD12.1 UNK3CD24.1 UNK3K39.9 UNK3SH25.1 UNK3TP_VDDTXPST_11_T.1
S3_DPS_F_012: SITE3.144(VDD_TXREG_33_T) UNK3CA38.1 UNK3CA39.1 UNK3CC39.1 UNK3CC41.1 UNK3CD25.1 UNK3K42.9 UNK3SH27.1 UNK3TP_VDD_TXREG_33_T.1
S3_DPS_F_013: UNK3C8.1 UNK3C9.1 UNK3CA30.1 UNK3CA31.1 UNK3R82.2 UNK3R83.1 UNK3R84.1 UNK3R87.2 UNK3R88.2 UNK3R89.2 UNK3R90.2 UNK3R91.2 UNK3R92.2 UNK3R94.2 UNK3R95.2 UNK3R96.2 UNK3R97.2 UNK3R98.2 UNK3R99.2 UNK3R119.1 UNK3R120.1 UNK3SH22.1 UNK3TP_VCC3V3.1 UNK3U1.8 UNK3U2.8
S3_DPS_FS_001: UNK3SH20.2
S3_DPS_FS_002: UNK3SH1.2
S3_DPS_FS_003: UNK3SH3.2
S3_DPS_FS_004: UNK3SH7.2
S3_DPS_FS_005: UNK3SH10.2
S3_DPS_FS_006: UNK3SH18.2
S3_DPS_FS_007: UNK3SH12.2
S3_DPS_FS_008: UNK3SH23.2
S3_DPS_FS_009: UNK3SH14.2
S3_DPS_FS_010: UNK3SH16.2
S3_DPS_FS_011: UNK3SH25.2
S3_DPS_FS_012: UNK3SH27.2
S3_DPS_FS_013: UNK3SH22.2
S3_DPS_GS_001: UNK3SH19.2
S3_DPS_GS_002: UNK3SH2.2
S3_DPS_GS_003: UNK3SH4.2
S3_DPS_GS_004: UNK3SH8.2
S3_DPS_GS_005: UNK3SH9.2
S3_DPS_GS_006: UNK3SH17.2
S3_DPS_GS_007: UNK3SH11.2
S3_DPS_GS_008: UNK3SH24.2
S3_DPS_GS_009: UNK3SH13.2
S3_DPS_GS_010: UNK3SH15.2
S3_DPS_GS_011: UNK3SH26.2
S3_DPS_GS_012: UNK3SH28.2
S3_DPS_GS_013: UNK3SH21.2
S3_ISP00+: SITE3.73(AML0P) UNK3K43.7
S3_ISP00-: SITE3.74(AML0N) UNK3K43.2
S3_ISP14+: SITE3.112(CML0P) UNK3K43.5
S3_ISP14-: SITE3.113(CML0N) UNK3K43.4
S3_ISP_1LOCK: UNK3K33.3 UNK3R118.2
S3_M_DPS_F_001: SITE3.22(VDDC_11-1) SITE3.39(VDDC_11-2) SITE3.64(VDDC_11-3) SITE3.104(VDDC_11-4) SITE3.147(VDDC_11-5) UNK3CA5.1 UNK3CA6.1 UNK3CC6.1 UNK3CC7.1 UNK3CC8.1 UNK3CC9.1 UNK3CC36.1 UNK3CD4.1 UNK3CD5.1 UNK3CD6.1 UNK3CD7.1 UNK3CD23.1 UNK3K36.4 UNK3K36.9 UNK3SH5.1 UNK3TP_VDDC_11.1
S3_M_DPS_FS_001: UNK3SH5.2
S3_M_DPS_GS_001: UNK3SH6.2
S3_PS9G_DCH001: SITE3.18(TEST)
S3_PS9G_DCH002: S3_RST_N.1 SITE3.19(RESET_N) UNK3K10.3
S3_PS9G_DCH003: SITE3.24(HPD)
S3_PS9G_DCH004: SITE3.40(AGEN)
S3_PS9G_DCH005: SITE3.45(STV_IN)
S3_PS9G_DCH006: SITE3.46(EIO1)
S3_PS9G_DCH007: SITE3.47(EIO2)
S3_PS9G_DCH009: SITE3.49(PWMI)
S3_PS9G_DCH010: S3_I2C.1 SITE3.50(I2C_SCL) UNK3J4.2 UNK3K28.3
S3_PS9G_DCH011: S3_I2C.2 SITE3.51(I2C_SDA) UNK3J5.2 UNK3K28.6
S3_PS9G_DCH014: SITE3.54(LED_SPI_SIN_A)
S3_PS9G_DCH015: SITE3.55(LED_SPI_SCLK_A)
S3_PS9G_DCH022: SITE3.65(LED_SPI_SO_A)
S3_PS9G_DCH023: SITE3.66(LED_SPI_SO_B)
S3_PS9G_DCH027: SITE3.70(OSD_SPI_SDO)
S3_PS9G_DCH028: SITE3.77(NC_VDDTX_11_B)
S3_PS9G_DCH029: SITE3.118(NC_VDDTX_11_T)
S3_PS9G_DCH030: SITE3.148(ISP_LOCK) UNK3R118.1
S3_PS9G_DCH035: SITE3.153(CLK6)
S3_PS9G_DCH036: SITE3.154(CLK5)
S3_PS9G_DCH037: SITE3.155(CLK4)
S3_PS9G_DCH038: SITE3.156(CLK3)
S3_PS9G_DCH039: SITE3.157(CLK2)
S3_PS9G_DCH040: SITE3.158(CLK1)
S3_RLY_001: UNK3K1.8 UNK3K2.8
S3_RLY_003: UNK3K3.8 UNK3K4.8
S3_RLY_005: UNK3K5.8 UNK3K6.8
S3_RLY_007: UNK3K7.8
S3_RLY_008: UNK3K8.8 UNK3K11.8
S3_RLY_009: UNK3K9.8
S3_RLY_010: UNK3K10.8
S3_RLY_012: UNK3K12.8
S3_RLY_013: UNK3K13.8
S3_RLY_014: UNK3K14.8
S3_RLY_015: UNK3K15.8
S3_RLY_016: UNK3K16.8 UNK3K17.8
S3_RLY_018: UNK3K18.8
S3_RLY_019: UNK3K19.8
S3_RLY_020: UNK3K20.8
S3_RLY_021: UNK3K21.8 UNK3K29.8
S3_RLY_022: UNK3K22.8 UNK3K24.8
S3_RLY_023: UNK3K23.8
S3_RLY_025: UNK3K25.8 UNK3K27.8
S3_RLY_026: UNK3K26.8
S3_RLY_028: UNK3K28.8
S3_RLY_030: UNK3K30.8
S3_RLY_031: UNK3K31.12
S3_RLY_033: UNK3K33.8
S3_RLY_034: UNK3K34.12
S3_RLY_036: UNK3K36.12
S3_RLY_037: UNK3K37.12
S3_RLY_039: UNK3K39.12
S3_RLY_040: UNK3K40.12
S3_RLY_042: UNK3K42.12
S3_RLY_043: UNK3K43.8
S3_SCAN_DCH008: SITE3.48(FAIL_FLAG_O)
S3_SCAN_DCH012: SITE3.52(LED_SPI_BLANK_A)
S3_SCAN_DCH013: SITE3.53(LED_SPI_GSCLK_A)
S3_SCAN_DCH016: SITE3.56(LED_SPI_XLAT_A)
S3_SCAN_DCH017: SITE3.57(LED_SPI_BLANK_B)
S3_SCAN_DCH018: SITE3.58(LED_SPI_GSCLK_B)
S3_SCAN_DCH019: SITE3.59(LED_SPI_SIN_B)
S3_SCAN_DCH020: SITE3.60(LED_SPI_SCLK_B)
S3_SCAN_DCH021: SITE3.61(LED_SPI_XLAT_B)
S3_SCAN_DCH024: SITE3.67(OSD_SPI_SCK_I2CCLK) UNK3K13.3
S3_SCAN_DCH025: SITE3.68(OSD_SPI_SDI_I2CDAT) UNK3K13.6
S3_SCAN_DCH026: SITE3.69(OSD_SPI_CSN)
S3_SCAN_DCH031: SITE3.149(OE2)
S3_SCAN_DCH032: SITE3.150(OE1)
S3_SCAN_DCH033: SITE3.151(CLK8)
S3_SCAN_DCH034: SITE3.152(CLK7)
S3_SCAN_DCH050: UNK3K15.2
S3_SCAN_DCH051: UNK3K15.7
S3_SCAN_DCH052: UNK3K14.2
S3_SCAN_DCH053: UNK3K14.7
S3_SPI_1_CSN: UNK3K19.7 UNK3R87.1 UNK3U1.1
S3_SPI_1_SCK: UNK3K19.2 UNK3R91.1 UNK3U1.6
S3_SPI_1_SDI: UNK3K20.7 UNK3R127.1
S3_SPI_1_SDO: UNK3K20.2 UNK3R125.1
S3_SPI_2_CSN: UNK3K19.5 UNK3R94.1 UNK3U2.1
S3_SPI_2_SCK: UNK3K19.4 UNK3R98.1 UNK3U2.6
S3_SPI_2_SDI: UNK3K20.5 UNK3R128.1
S3_SPI_2_SDO: UNK3K20.4 UNK3R126.1
S3_SPI_11_SDI: UNK3R88.1 UNK3R127.2 UNK3U1.2
S3_SPI_11_SDO: UNK3R92.1 UNK3R125.2 UNK3U1.5
S3_SPI_22_SDI: UNK3R95.1 UNK3R128.2 UNK3U2.2
S3_SPI_22_SDO: UNK3R99.1 UNK3R126.2 UNK3U2.5
S3_SPI_CSN: SITE3.43(SPI_CSN) UNK3K15.6
S3_SPI_SCK: SITE3.42(SPI_SCK) UNK3K15.3
S3_SPI_SDI: SITE3.44(SPI_SDI) UNK3K14.6
S3_SPI_SDO: SITE3.41(SPI_SDO) UNK3K14.3
S3_XTAL_IN: SITE3.109(XTAL_IN) UNK3K18.3 UNK3TP_XTAL_IN.1
S3_XTAL_OUT: SITE3.110(XTAL_OUT) UNK3K18.6 UNK3TP_XTAL_OUT.1
S4_1AUX+: UNK4K9.4 UNK4R129.1
S4_1AUX-: UNK4K9.5 UNK4R130.1
S4_1SPI_CSN: UNK4K15.5 UNK4K19.6
S4_1SPI_SCK: UNK4K15.4 UNK4K19.3
S4_1SPI_SDI: UNK4K14.5 UNK4K20.6
S4_1SPI_SDO: UNK4K14.4 UNK4K20.3
S4_2AUX+: UNK4C3.1 UNK4R1.2 UNK4R3.1 UNK4R129.2
S4_2AUX-: UNK4C4.1 UNK4R2.2 UNK4R4.2 UNK4R130.2
S4_AUX_100DCH001+: UNK4K9.2
S4_AUX_100DCH001-: UNK4K9.7
S4_AUX_100DCH002+: UNK4C3.2
S4_AUX_100DCH002-: UNK4C4.2
S4_AUXCH+: SITE4.21(AUXCHP) UNK4K9.3 UNK4K12.3
S4_AUXCH-: SITE4.20(AUXCHN) UNK4K9.6 UNK4K12.6
S4_AVDD11_RX: SITE4.31(AVDD11_RX) UNK4CA9.1 UNK4CA10.1 UNK4CC13.1 UNK4CD9.1 UNK4K37.9 UNK4SH10.1 UNK4TP_AVDD11_RX.1
S4_AVDD11_XTAL: SITE4.105(AVDD11_XTAL) UNK4CA32.1 UNK4CA33.1 UNK4CC26.1 UNK4CD16.1 UNK4K31.4 UNK4SH23.1 UNK4TP_AVDD11_XTAL.1
S4_AVDD18_RX: SITE4.25(AVDD18_RX) UNK4CA7.1 UNK4CA8.1 UNK4CC11.1 UNK4CD8.1 UNK4K37.4 UNK4SH7.1 UNK4TP_AVDD18_RX.1
S4_DCH041: SITE4.159(STV2)
S4_DCH042: SITE4.160(STV1)
S4_DCH043: SITE4.161(POL)
S4_DCH044: SITE4.163(TP1)
S4_DCH045: SITE4.164(DC_EN)
S4_DCH046: SITE4.165(H2POL)
S4_DCH047: SITE4.166(SQINV)
S4_DCH048: UNK4K18.7
S4_DCH049: UNK4K18.2
S4_DPS_F_001: UNK4CA19.1 UNK4CA20.1 UNK4R1.1 UNK4R4.1 UNK4SH20.1 UNK4TP_AUXVCC.1
S4_DPS_F_002: SITE4.3(VDDA_33_LV) UNK4CA1.1 UNK4CA2.1 UNK4CC1.1 UNK4CC2.1 UNK4CD1.1 UNK4K34.4 UNK4SH1.1 UNK4TP_VDDA_33_LV.1
S4_DPS_F_003: SITE4.17(VDD_IO_33-1) SITE4.37(VDD_IO_33-2) SITE4.63(VDD_IO_33-3) SITE4.71(VDD_IO_33-4) SITE4.107(VDD_IO_33-5) SITE4.145(VDD_IO_33-6) SITE4.162(VDD_IO_33-7) UNK4CA3.1 UNK4CA4.1 UNK4CC4.1 UNK4CC30.1 UNK4CC31.1 UNK4CC32.1 UNK4CC33.1 UNK4CC34.1 UNK4CC35.1 UNK4CC42.1 UNK4CD3.1 UNK4CD17.1 UNK4CD18.1 UNK4CD19.1 UNK4CD20.1 UNK4CD21.1 UNK4CD22.1 UNK4K34.9 UNK4R85.1 UNK4SH3.1 UNK4TP_VDD_IO_33.1
S4_DPS_F_006: SITE4.72(VDD_TXREG_33_B) UNK4CA17.1 UNK4CA18.1 UNK4CC25.1 UNK4CC40.1 UNK4CD15.1 UNK4K42.4 UNK4SH18.1 UNK4TP_VDD_TXREG_33_B.1
S4_DPS_F_007: SITE4.78(VDDTXPST_11_B-1) SITE4.97(VDDTXPST_11_B-2) UNK4CA11.1 UNK4CA12.1 UNK4CC15.1 UNK4CC16.1 UNK4CC27.1 UNK4CC28.1 UNK4CD10.1 UNK4CD11.1 UNK4K39.4 UNK4SH12.1 UNK4TP_VDDTXPST_11_B.1
S4_DPS_F_009: SITE4.106(PLL_M_VDD33) UNK4CA13.1 UNK4CA14.1 UNK4CC19.1 UNK4CC20.1 UNK4CD13.1 UNK4K40.4 UNK4SH14.1 UNK4TP_PLL_M_VDD33.1
S4_DPS_F_010: SITE4.111(PLL_TX_VDD33) UNK4CA15.1 UNK4CA16.1 UNK4CC22.1 UNK4CC23.1 UNK4CD14.1 UNK4K40.9 UNK4SH16.1 UNK4TP_PLL_TX_VDD33.1
S4_DPS_F_011: SITE4.119(VDDTXPST_11_T-1) SITE4.139(VDDTXPST_11_T-2) UNK4CA35.1 UNK4CA36.1 UNK4CC17.1 UNK4CC29.1 UNK4CC37.1 UNK4CC38.1 UNK4CD12.1 UNK4CD24.1 UNK4K39.9 UNK4SH25.1 UNK4TP_VDDTXPST_11_T.1
S4_DPS_F_012: SITE4.144(VDD_TXREG_33_T) UNK4CA38.1 UNK4CA39.1 UNK4CC39.1 UNK4CC41.1 UNK4CD25.1 UNK4K42.9 UNK4SH27.1 UNK4TP_VDD_TXREG_33_T.1
S4_DPS_F_013: UNK4C8.1 UNK4C9.1 UNK4CA30.1 UNK4CA31.1 UNK4R82.2 UNK4R83.1 UNK4R84.1 UNK4R87.2 UNK4R88.2 UNK4R89.2 UNK4R90.2 UNK4R91.2 UNK4R92.2 UNK4R94.2 UNK4R95.2 UNK4R96.2 UNK4R97.2 UNK4R98.2 UNK4R99.2 UNK4R119.1 UNK4R120.1 UNK4SH22.1 UNK4TP_VCC3V3.1 UNK4U1.8 UNK4U2.8
S4_DPS_FS_001: UNK4SH20.2
S4_DPS_FS_002: UNK4SH1.2
S4_DPS_FS_003: UNK4SH3.2
S4_DPS_FS_004: UNK4SH7.2
S4_DPS_FS_005: UNK4SH10.2
S4_DPS_FS_006: UNK4SH18.2
S4_DPS_FS_007: UNK4SH12.2
S4_DPS_FS_008: UNK4SH23.2
S4_DPS_FS_009: UNK4SH14.2
S4_DPS_FS_010: UNK4SH16.2
S4_DPS_FS_011: UNK4SH25.2
S4_DPS_FS_012: UNK4SH27.2
S4_DPS_FS_013: UNK4SH22.2
S4_DPS_GS_001: UNK4SH19.2
S4_DPS_GS_002: UNK4SH2.2
S4_DPS_GS_003: UNK4SH4.2
S4_DPS_GS_004: UNK4SH8.2
S4_DPS_GS_005: UNK4SH9.2
S4_DPS_GS_006: UNK4SH17.2
S4_DPS_GS_007: UNK4SH11.2
S4_DPS_GS_008: UNK4SH24.2
S4_DPS_GS_009: UNK4SH13.2
S4_DPS_GS_010: UNK4SH15.2
S4_DPS_GS_011: UNK4SH26.2
S4_DPS_GS_012: UNK4SH28.2
S4_DPS_GS_013: UNK4SH21.2
S4_ISP00+: SITE4.73(AML0P) UNK4K43.7
S4_ISP00-: SITE4.74(AML0N) UNK4K43.2
S4_ISP14+: SITE4.112(CML0P) UNK4K43.5
S4_ISP14-: SITE4.113(CML0N) UNK4K43.4
S4_ISP_1LOCK: UNK4K33.3 UNK4R118.2
S4_M_DPS_F_001: SITE4.22(VDDC_11-1) SITE4.39(VDDC_11-2) SITE4.64(VDDC_11-3) SITE4.104(VDDC_11-4) SITE4.147(VDDC_11-5) UNK4CA5.1 UNK4CA6.1 UNK4CC6.1 UNK4CC7.1 UNK4CC8.1 UNK4CC9.1 UNK4CC36.1 UNK4CD4.1 UNK4CD5.1 UNK4CD6.1 UNK4CD7.1 UNK4CD23.1 UNK4K36.4 UNK4K36.9 UNK4SH5.1 UNK4TP_VDDC_11.1
S4_M_DPS_FS_001: UNK4SH5.2
S4_M_DPS_GS_001: UNK4SH6.2
S4_PS9G_DCH001: SITE4.18(TEST)
S4_PS9G_DCH002: S4_RST_N.1 SITE4.19(RESET_N) UNK4K10.3
S4_PS9G_DCH003: SITE4.24(HPD)
S4_PS9G_DCH004: SITE4.40(AGEN)
S4_PS9G_DCH005: SITE4.45(STV_IN)
S4_PS9G_DCH006: SITE4.46(EIO1)
S4_PS9G_DCH007: SITE4.47(EIO2)
S4_PS9G_DCH009: SITE4.49(PWMI)
S4_PS9G_DCH010: S4_I2C.1 SITE4.50(I2C_SCL) UNK4J4.2 UNK4K28.3
S4_PS9G_DCH011: S4_I2C.2 SITE4.51(I2C_SDA) UNK4J5.2 UNK4K28.6
S4_PS9G_DCH014: SITE4.54(LED_SPI_SIN_A)
S4_PS9G_DCH015: SITE4.55(LED_SPI_SCLK_A)
S4_PS9G_DCH022: SITE4.65(LED_SPI_SO_A)
S4_PS9G_DCH023: SITE4.66(LED_SPI_SO_B)
S4_PS9G_DCH027: SITE4.70(OSD_SPI_SDO)
S4_PS9G_DCH028: SITE4.77(NC_VDDTX_11_B)
S4_PS9G_DCH029: SITE4.118(NC_VDDTX_11_T)
S4_PS9G_DCH030: SITE4.148(ISP_LOCK) UNK4R118.1
S4_PS9G_DCH035: SITE4.153(CLK6)
S4_PS9G_DCH036: SITE4.154(CLK5)
S4_PS9G_DCH037: SITE4.155(CLK4)
S4_PS9G_DCH038: SITE4.156(CLK3)
S4_PS9G_DCH039: SITE4.157(CLK2)
S4_PS9G_DCH040: SITE4.158(CLK1)
S4_RLY_001: UNK4K1.8 UNK4K2.8
S4_RLY_003: UNK4K3.8 UNK4K4.8
S4_RLY_005: UNK4K5.8 UNK4K6.8
S4_RLY_007: UNK4K7.8
S4_RLY_008: UNK4K8.8 UNK4K11.8
S4_RLY_009: UNK4K9.8
S4_RLY_010: UNK4K10.8
S4_RLY_012: UNK4K12.8
S4_RLY_013: UNK4K13.8
S4_RLY_014: UNK4K14.8
S4_RLY_015: UNK4K15.8
S4_RLY_016: UNK4K16.8 UNK4K17.8
S4_RLY_018: UNK4K18.8
S4_RLY_019: UNK4K19.8
S4_RLY_020: UNK4K20.8
S4_RLY_021: UNK4K21.8 UNK4K29.8
S4_RLY_022: UNK4K22.8 UNK4K24.8
S4_RLY_023: UNK4K23.8
S4_RLY_025: UNK4K25.8 UNK4K27.8
S4_RLY_026: UNK4K26.8
S4_RLY_028: UNK4K28.8
S4_RLY_030: UNK4K30.8
S4_RLY_031: UNK4K31.12
S4_RLY_033: UNK4K33.8
S4_RLY_034: UNK4K34.12
S4_RLY_036: UNK4K36.12
S4_RLY_037: UNK4K37.12
S4_RLY_039: UNK4K39.12
S4_RLY_040: UNK4K40.12
S4_RLY_042: UNK4K42.12
S4_RLY_043: UNK4K43.8
S4_SCAN_DCH008: SITE4.48(FAIL_FLAG_O)
S4_SCAN_DCH012: SITE4.52(LED_SPI_BLANK_A)
S4_SCAN_DCH013: SITE4.53(LED_SPI_GSCLK_A)
S4_SCAN_DCH016: SITE4.56(LED_SPI_XLAT_A)
S4_SCAN_DCH017: SITE4.57(LED_SPI_BLANK_B)
S4_SCAN_DCH018: SITE4.58(LED_SPI_GSCLK_B)
S4_SCAN_DCH019: SITE4.59(LED_SPI_SIN_B)
S4_SCAN_DCH020: SITE4.60(LED_SPI_SCLK_B)
S4_SCAN_DCH021: SITE4.61(LED_SPI_XLAT_B)
S4_SCAN_DCH024: SITE4.67(OSD_SPI_SCK_I2CCLK) UNK4K13.3
S4_SCAN_DCH025: SITE4.68(OSD_SPI_SDI_I2CDAT) UNK4K13.6
S4_SCAN_DCH026: SITE4.69(OSD_SPI_CSN)
S4_SCAN_DCH031: SITE4.149(OE2)
S4_SCAN_DCH032: SITE4.150(OE1)
S4_SCAN_DCH033: SITE4.151(CLK8)
S4_SCAN_DCH034: SITE4.152(CLK7)
S4_SCAN_DCH050: UNK4K15.2
S4_SCAN_DCH051: UNK4K15.7
S4_SCAN_DCH052: UNK4K14.2
S4_SCAN_DCH053: UNK4K14.7
S4_SPI_1_CSN: UNK4K19.7 UNK4R87.1 UNK4U1.1
S4_SPI_1_SCK: UNK4K19.2 UNK4R91.1 UNK4U1.6
S4_SPI_1_SDI: UNK4K20.7 UNK4R127.1
S4_SPI_1_SDO: UNK4K20.2 UNK4R125.1
S4_SPI_2_CSN: UNK4K19.5 UNK4R94.1 UNK4U2.1
S4_SPI_2_SCK: UNK4K19.4 UNK4R98.1 UNK4U2.6
S4_SPI_2_SDI: UNK4K20.5 UNK4R128.1
S4_SPI_2_SDO: UNK4K20.4 UNK4R126.1
S4_SPI_11_SDI: UNK4R88.1 UNK4R127.2 UNK4U1.2
S4_SPI_11_SDO: UNK4R92.1 UNK4R125.2 UNK4U1.5
S4_SPI_22_SDI: UNK4R95.1 UNK4R128.2 UNK4U2.2
S4_SPI_22_SDO: UNK4R99.1 UNK4R126.2 UNK4U2.5
S4_SPI_CSN: SITE4.43(SPI_CSN) UNK4K15.6
S4_SPI_SCK: SITE4.42(SPI_SCK) UNK4K15.3
S4_SPI_SDI: SITE4.44(SPI_SDI) UNK4K14.6
S4_SPI_SDO: SITE4.41(SPI_SDO) UNK4K14.3
S4_XTAL_IN: SITE4.109(XTAL_IN) UNK4K18.3 UNK4TP_XTAL_IN.1
S4_XTAL_OUT: SITE4.110(XTAL_OUT) UNK4K18.6 UNK4TP_XTAL_OUT.1
UDBGND: BD29.2 BD30.2 BD31.2 BD32.2 BD33.2 BD34.2 BD35.2 BD36.2 BD37.2 BD38.2 BD39.2 BD40.2 BD41.2 BD42.2 BD43.2 BD44.2 CB1.2 CB2.2 CB3.2 CB4.2 CB5.2 CB6.2 CB7.2 CB8.2 CB9.2 CB10.2 CB11.2 CB12.2 CB13.2 CB14.2 CB15.2 CB16.2 CB19.1 LD902.2(B) UB1.1(NC) UB1.2(A1/NC) UB1.3(A2) UB1.4(GND) UB1.7(WP) UTL1.A02 UTL1.A08 UTL1.A10 UTL1.A12 UTL1.A14 UTL1.B01 UTL1.B07 UTL1.B09 UTL1.B11 UTL1.B13 UTL2.A02 UTL2.A08 UTL2.A10 UTL2.A12 UTL2.A14 UTL2.B01 UTL2.B07 UTL2.B09 UTL2.B11 UTL2.B13 UTL3.A02 UTL3.A08 UTL3.A10 UTL3.A12 UTL3.A14 UTL3.B01 UTL3.B07 UTL3.B09 UTL3.B11 UTL3.B13 UTL4.A02 UTL4.A08 UTL4.A10 UTL4.A12 UTL4.A14 UTL4.B01 UTL4.B07 UTL4.B09 UTL4.B11 UTL4.B13 UTL5.A02 UTL5.A08 UTL5.A10 UTL5.A12 UTL5.A14 UTL5.B01 UTL5.B07 UTL5.B09 UTL5.B11 UTL5.B13 UTL6.A02 UTL6.A08 UTL6.A10 UTL6.A12 UTL6.A14 UTL6.B01 UTL6.B07 UTL6.B09 UTL6.B11 UTL6.B13 UTL7.A02 UTL7.A08 UTL7.A10 UTL7.A12 UTL7.A14 UTL7.B01 UTL7.B07 UTL7.B09 UTL7.B11 UTL7.B13 UTL8.A02 UTL8.A08 UTL8.A10 UTL8.A12 UTL8.A14 UTL8.B01 UTL8.B07 UTL8.B09 UTL8.B11 UTL8.B13
UT1_PDCF: UTL1.B15
UT1_PDCS: UTL1.A15
UT1_PGDS: UTL1.A16
UT1_PGRD: UTL1.B16
UT1_UP5V: BR902.1 CB1.1 CB2.1 CB3.1 CB4.1 CB5.1 CB6.1 CB7.1 CB8.1 CB9.1 CB10.1 CB11.1 CB12.1 CB13.1 CB14.1 CB15.1 CB16.1 CB19.2 K1.1(V+) K2.1(V+) K3.1(V+) K4.1(V+) K5.1(V+) K6.1(V+) K7.1(V+) K8.1(V+) K9.1(V+) K10.1(V+) K11.1(V+) K12.1(V+) K13.1(V+) K14.1(V+) K15.1(V+) K16.1(V+) K17.1(V+) K18.1(V+) K19.1(V+) K20.1(V+) K21.1(V+) K22.1(V+) K23.1(V+) K24.1(V+) K25.1(V+) K26.1(V+) K27.1(V+) K28.1(V+) K29.1(V+) K30.1(V+) K31.1(V+) K33.1(V+) K34.1(V+) K36.1(V+) K37.1(V+) K39.1(V+) K40.1(V+) K42.1(V+) K43.1(V+) RB1.1 RB2.1 UB1.8(VCC) UNK2K1.1 UNK2K2.1 UNK2K3.1 UNK2K4.1 UNK2K5.1 UNK2K6.1 UNK2K7.1 UNK2K8.1 UNK2K9.1 UNK2K10.1 UNK2K11.1 UNK2K12.1 UNK2K13.1 UNK2K14.1 UNK2K15.1 UNK2K16.1 UNK2K17.1 UNK2K18.1 UNK2K19.1 UNK2K20.1 UNK2K21.1 UNK2K22.1 UNK2K23.1 UNK2K24.1 UNK2K25.1 UNK2K26.1 UNK2K27.1 UNK2K28.1 UNK2K29.1 UNK2K30.1 UNK2K31.1 UNK2K33.1 UNK2K34.1 UNK2K36.1 UNK2K37.1 UNK2K39.1 UNK2K40.1 UNK2K42.1 UNK2K43.1 UNK3K1.1 UNK3K2.1 UNK3K3.1 UNK3K4.1 UNK3K5.1 UNK3K6.1 UNK3K7.1 UNK3K8.1 UNK3K9.1 UNK3K10.1 UNK3K11.1 UNK3K12.1 UNK3K13.1 UNK3K14.1 UNK3K15.1 UNK3K16.1 UNK3K17.1 UNK3K18.1 UNK3K19.1 UNK3K20.1 UNK3K21.1 UNK3K22.1 UNK3K23.1 UNK3K24.1 UNK3K25.1 UNK3K26.1 UNK3K27.1 UNK3K28.1 UNK3K29.1 UNK3K30.1 UNK3K31.1 UNK3K33.1 UNK3K34.1 UNK3K36.1 UNK3K37.1 UNK3K39.1 UNK3K40.1 UNK3K42.1 UNK3K43.1 UNK4K1.1 UNK4K2.1 UNK4K3.1 UNK4K4.1 UNK4K5.1 UNK4K6.1 UNK4K7.1 UNK4K8.1 UNK4K9.1 UNK4K10.1 UNK4K11.1 UNK4K12.1 UNK4K13.1 UNK4K14.1 UNK4K15.1 UNK4K16.1 UNK4K17.1 UNK4K18.1 UNK4K19.1 UNK4K20.1 UNK4K21.1 UNK4K22.1 UNK4K23.1 UNK4K24.1 UNK4K25.1 UNK4K26.1 UNK4K27.1 UNK4K28.1 UNK4K29.1 UNK4K30.1 UNK4K31.1 UNK4K33.1 UNK4K34.1 UNK4K36.1 UNK4K37.1 UNK4K39.1 UNK4K40.1 UNK4K42.1 UNK4K43.1 UT_UP5V.1(TP) UTL1.A05 UTL1.B04 UTL2.A05 UTL2.B04 UTL3.A05 UTL3.B04 UTL4.A05 UTL4.B04 UTL5.A05 UTL5.B04 UTL6.A05 UTL6.B04 UTL7.A05 UTL7.B04 UTL8.A05 UTL8.B04
UT1_URW00: UTL1.A01
UT1_URW01: UTL1.B02
UT1_URW02: UTL1.A03
UT1_URW03: UTL1.B03
UT1_URW04: UTL1.A04
UT1_URW05: UTL1.B05
UT1_URW06: UTL1.A06
UT1_UW07: UTL1.B06
UT1_UW08: UTL1.A07
UT1_UW09: UTL1.B08
UT1_UW10: UTL1.A09
UT1_UW11: UTL1.B10
UT1_UW12: UTL1.A11
UT1_UW13: UTL1.B12
UT1_UW14: RB1.2 UB1.6(SCL) UTL1.A13
UT1_UW15: RB2.2 UB1.5(SDA) UTL1.B14
UT2_PDCF: UTL2.B15
UT2_PDCS: UTL2.A15
UT2_PGDS: UTL2.A16
UT2_PGRD: UTL2.B16
UT2_URW00: UTL2.A01
UT2_URW01: UTL2.B02
UT2_URW02: UTL2.A03
UT2_URW03: UTL2.B03
UT2_URW04: UTL2.A04
UT2_URW05: UTL2.B05
UT2_URW06: UTL2.A06
UT2_UW07: UTL2.B06
UT2_UW08: UTL2.A07
UT2_UW09: UTL2.B08
UT2_UW10: UTL2.A09
UT2_UW11: UTL2.B10
UT2_UW12: UTL2.A11
UT2_UW13: UTL2.B12
UT2_UW14: UTL2.A13
UT2_UW15: UTL2.B14
UT3_PDCF: UTL3.B15
UT3_PDCS: UTL3.A15
UT3_PGDS: UTL3.A16
UT3_PGRD: UTL3.B16
UT3_URW00: UTL3.A01
UT3_URW01: UTL3.B02
UT3_URW02: UTL3.A03
UT3_URW03: UTL3.B03
UT3_URW04: UTL3.A04
UT3_URW05: UTL3.B05
UT3_URW06: UTL3.A06
UT3_UW07: UTL3.B06
UT3_UW08: UTL3.A07
UT3_UW09: UTL3.B08
UT3_UW10: UTL3.A09
UT3_UW11: UTL3.B10
UT3_UW12: UTL3.A11
UT3_UW13: UTL3.B12
UT3_UW14: UTL3.A13
UT3_UW15: UTL3.B14
UT4_PDCF: UTL4.B15
UT4_PDCS: UTL4.A15
UT4_PGDS: UTL4.A16
UT4_PGRD: UTL4.B16
UT4_URW00: UTL4.A01
UT4_URW01: UTL4.B02
UT4_URW02: UTL4.A03
UT4_URW03: UTL4.B03
UT4_URW04: UTL4.A04
UT4_URW05: UTL4.B05
UT4_URW06: UTL4.A06
UT4_UW07: UTL4.B06
UT4_UW08: UTL4.A07
UT4_UW09: UTL4.B08
UT4_UW10: UTL4.A09
UT4_UW11: UTL4.B10
UT4_UW12: UTL4.A11
UT4_UW13: UTL4.B12
UT4_UW14: UTL4.A13
UT4_UW15: UTL4.B14
UT5_PDCF: UTL5.B15
UT5_PDCS: UTL5.A15
UT5_PGDS: UTL5.A16
UT5_PGRD: UTL5.B16
UT5_UW00: UTL5.A01
UT5_UW01: UTL5.B02
UT5_UW02: UTL5.A03
UT5_UW03: UTL5.B03
UT5_UW04: UTL5.A04
UT5_UW05: UTL5.B05
UT5_UW06: UTL5.A06
UT5_UW07: UTL5.B06
UT5_UW08: UTL5.A07
UT5_UW09: UTL5.B08
UT5_UW10: UTL5.A09
UT5_UW11: UTL5.B10
UT5_UW12: UTL5.A11
UT5_UW13: UTL5.B12
UT5_UW14: UTL5.A13
UT5_UW15: UTL5.B14
UT6_PDCF: UTL6.B15
UT6_PDCS: UTL6.A15
UT6_PGDS: UTL6.A16
UT6_PGRD: UTL6.B16
UT6_UW00: UTL6.A01
UT6_UW01: UTL6.B02
UT6_UW02: UTL6.A03
UT6_UW03: UTL6.B03
UT6_UW04: UTL6.A04
UT6_UW05: UTL6.B05
UT6_UW06: UTL6.A06
UT6_UW07: UTL6.B06
UT6_UW08: UTL6.A07
UT6_UW09: UTL6.B08
UT6_UW10: UTL6.A09
UT6_UW11: UTL6.B10
UT6_UW12: UTL6.A11
UT6_UW13: UTL6.B12
UT6_UW14: UTL6.A13
UT6_UW15: UTL6.B14
UT7_PDCF: UTL7.B15
UT7_PDCS: UTL7.A15
UT7_PGDS: UTL7.A16
UT7_PGRD: UTL7.B16
UT7_UW00: UTL7.A01
UT7_UW01: UTL7.B02
UT7_UW02: UTL7.A03
UT7_UW03: UTL7.B03
UT7_UW04: UTL7.A04
UT7_UW05: UTL7.B05
UT7_UW06: UTL7.A06
UT7_UW07: UTL7.B06
UT7_UW08: UTL7.A07
UT7_UW09: UTL7.B08
UT7_UW10: UTL7.A09
UT7_UW11: UTL7.B10
UT7_UW12: UTL7.A11
UT7_UW13: UTL7.B12
UT7_UW14: UTL7.A13
UT7_UW15: UTL7.B14
UT8_PDCF: UTL8.B15
UT8_PDCS: UTL8.A15
UT8_PGDS: UTL8.A16
UT8_PGRD: UTL8.B16
UT8_UW00: UTL8.A01
UT8_UW01: UTL8.B02
UT8_UW02: UTL8.A03
UT8_UW03: UTL8.B03
UT8_UW04: UTL8.A04
UT8_UW05: UTL8.B05
UT8_UW06: UTL8.A06
UT8_UW07: UTL8.B06
UT8_UW08: UTL8.A07
UT8_UW09: UTL8.B08
UT8_UW10: UTL8.A09
UT8_UW11: UTL8.B10
UT8_UW12: UTL8.A11
UT8_UW13: UTL8.B12
UT8_UW14: UTL8.A13
UT8_UW15: UTL8.B14
N16868442: BR902.2 LD902.1(A)
N24574244: J2.1 R89.1
N24574268: J3.1 R96.1
N24574272: J3.3 R93.1
N24574311: R90.1 U1.7(HOLD#)
N24574358: J2.2 U1.3(WP#)
N24574376: R97.1 U2.7(HOLD#)
N24574426: J3.2 U2.3(WP#)
N24574578: J2.3 R86.1
N24787993: CA21.1 K34.5
N24789529: CA23.1 K36.5 K36.8
N24789779: CA24.1 K37.5
N25330426: CA29.1 K42.5
N25334489: CA26.1 K39.5
N25337760: CA34.1 K31.5
N25339188: CA27.1 K40.5
N25462044: CA37.1 K39.8
N25462912: CA40.1 K42.8
N25463486: CA28.1 K40.8
N25464528: CA25.1 K37.8
N25465136: CA22.1 K34.8
N26125600: K25.3 R55.2
N26125602: K25.4 R56.1
N26125604: K25.6 R57.2
N26125606: K25.5 R58.1
N26125622: K26.3 R59.2
N26125624: K26.4 R60.1
N26125626: K26.6 R61.2
N26125628: K26.5 R62.1
N26125644: K27.5 R66.1
N26125646: K27.6 R65.2
N26125685: K22.6 R45.2
N26125687: K22.5 R46.1
N26125689: K23.3 R47.2
N26125691: K23.4 R48.1
N26125693: K23.6 R49.2
