# Allegro board 8880F5-0827_updates.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D31706: length 192.4
  TOP w0.147: D317.06 174.85,91.03 arc(175.01,91.27) 175.07,91.55 175.07,95.63 arc(175.04,95.76) 174.97,95.87 173.95,96.89 arc(173.83,96.97) 173.7,96.99 170.6,96.99 arc(170.32,97.05) 170.08,97.21 169.41,97.88 arc(168.5,100.07) 169.41,102.26 169.55,102.4 arc(170.14,102.8) 170.84,102.94 173.37,102.94 arc(173.5,102.96) 173.61,103.04 174.97,104.39 arc(175.04,104.5) 175.07,104.63 175.07,106.6 arc(175.04,106.73) 174.97,106.84 172.67,109.14 arc(172.56,109.22) 172.43,109.24 159.81,109.24 arc(159.52,109.3) 159.28,109.46 157.66,111.08 arc(157.5,111.32) 157.45,111.6 157.45,123.02 arc(157.5,123.3) 157.66,123.54 159.05,124.93 arc(159.29,125.08) 159.57,125.14 192.85,125.14 arc(192.98,125.17) 193.09,125.24 202.36,134.51 arc(202.6,134.67) 202.88,134.72 225.05,134.72 arc(225.18,134.75) 225.29,134.82 230.57,140.1 arc(230.64,140.21) 230.67,140.34 230.67,145.95 arc(230.72,146.23) 230.88,146.47 233.88,149.47 arc(234.12,149.63) 234.4,149.68 250.49,149.68 arc(250.62,149.71) 250.73,149.78 254.62,153.67 arc(254.69,153.78) 254.72,153.91 254.72,165.73 arc(254.69,165.86) 254.62,165.97 253.65,166.94 arc(253.49,167.18) 253.43,167.46 253.43,171.32 253.43,171.33 SITE3.29
D31708: length 192.4
  TOP w0.147: D317.08 175.68,91.02 arc(175.52,91.26) 175.46,91.54 175.46,95.63 arc(175.41,95.91) 175.25,96.15 174.23,97.17 arc(173.99,97.33) 173.7,97.39 170.6,97.39 arc(170.47,97.41) 170.36,97.49 169.69,98.16 arc(168.9,100.07) 169.69,101.98 169.83,102.12 arc(170.29,102.43) 170.84,102.54 173.37,102.54 arc(173.66,102.6) 173.89,102.76 175.25,104.11 arc(175.41,104.35) 175.46,104.63 175.46,106.6 arc(175.41,106.88) 175.25,107.12 172.95,109.42 arc(172.71,109.58) 172.43,109.64 159.81,109.64 arc(159.67,109.67) 159.56,109.74 157.94,111.36 arc(157.87,111.47) 157.84,111.6 157.84,123.02 arc(157.87,123.15) 157.94,123.26 159.33,124.64 arc(159.44,124.72) 159.57,124.74 192.85,124.74 arc(193.13,124.8) 193.37,124.96 202.64,134.23 arc(202.75,134.3) 202.88,134.33 225.05,134.33 arc(225.33,134.38) 225.57,134.54 230.85,139.82 arc(231.01,140.05) 231.06,140.34 231.06,145.95 arc(231.09,146.08) 231.16,146.19 234.16,149.19 arc(234.27,149.26) 234.4,149.29 250.49,149.29 arc(250.77,149.34) 251.01,149.5 254.9,153.39 arc(255.06,153.63) 255.11,153.91 255.11,165.73 arc(255.06,166.01) 254.9,166.25 253.93,167.22 arc(253.85,167.33) 253.83,167.46 253.83,171.32 253.83,171.33 SITE3.30
D31710: length 192.4
  TOP w0.147: SITE3.32 254.63,171.33 254.63,171.32 254.63,170.21 arc(254.69,169.93) 254.85,169.69 258.03,166.5 arc(258.11,166.39) 258.13,166.26 258.13,153.46 arc(258.11,153.33) 258.03,153.22 252.15,147.34 arc(252.04,147.26) 251.91,147.24 235.58,147.24 arc(235.3,147.18) 235.06,147.02 233.21,145.18 arc(233.06,144.94) 233,144.66 233,138.57 233,138.57 arc(232.78,137.46) 232.15,136.52 228.68,133.05 arc(227.74,132.43) 226.63,132.21 203.78,132.21 arc(203.5,132.15) 203.26,131.99 194.05,122.78 arc(193.94,122.71) 193.81,122.68 161.05,122.68 arc(160.77,122.62) 160.53,122.46 159.94,121.87 arc(159.78,121.63) 159.72,121.35 159.72,112.87 arc(159.78,112.59) 159.94,112.35 160.47,111.81 arc(160.71,111.65) 161,111.59 180.14,111.59 arc(180.27,111.57) 180.38,111.49 185.1,106.78 arc(185.17,106.67) 185.2,106.54 185.2,91.52 arc(185.14,91.24) 184.98,91 D317.10
D31712: length 192.4
  TOP w0.147: D317.12 185.81,91.05 arc(185.65,91.29) 185.6,91.57 185.6,106.54 arc(185.54,106.82) 185.38,107.06 180.66,111.77 arc(180.42,111.93) 180.14,111.99 161,111.99 arc(160.87,112.01) 160.75,112.09 160.22,112.63 arc(160.14,112.74) 160.12,112.87 160.12,121.35 arc(160.14,121.48) 160.22,121.59 160.81,122.18 arc(160.92,122.26) 161.05,122.28 193.81,122.28 arc(194.09,122.34) 194.33,122.5 203.54,131.71 arc(203.65,131.78) 203.78,131.81 226.63,131.81 arc(227.89,132.06) 228.96,132.77 232.43,136.24 arc(233.15,137.31) 233.4,138.57 233.4,144.66 arc(233.42,144.79) 233.5,144.9 235.34,146.74 arc(235.45,146.82) 235.58,146.84 251.91,146.84 arc(252.19,146.9) 252.43,147.06 258.31,152.94 arc(258.47,153.18) 258.53,153.46 258.53,166.26 arc(258.47,166.55) 258.31,166.79 255.13,169.97 arc(255.05,170.08) 255.03,170.21 255.03,171.32 255.03,171.33 SITE3.33
D31714: length 192.4
  TOP w0.147: SITE3.35 255.83,171.33 255.83,171.32 255.83,171.08 arc(255.87,170.87) 255.99,170.69 260.49,166.19 arc(260.56,166.08) 260.59,165.95 260.59,152.8 arc(260.56,152.67) 260.49,152.56 253.28,145.36 arc(253.17,145.29) 253.04,145.26 237.53,145.26 arc(237.25,145.2) 237.01,145.04 235.72,143.75 arc(235.56,143.51) 235.5,143.23 235.5,137.11 arc(235.28,136.02) 234.67,135.09 230.66,131.09 arc(229.73,130.47) 228.64,130.25 205.88,130.25 arc(205.6,130.2) 205.36,130.04 195.76,120.44 arc(195.65,120.36) 195.52,120.34 164.55,120.34 arc(164.27,120.28) 164.03,120.12 163.21,119.31 arc(163.05,119.07) 163,118.79 163,115.24 arc(163.05,114.96) 163.21,114.72 163.79,114.14 arc(164.03,113.98) 164.32,113.93 180.98,113.93 arc(181.11,113.9) 181.22,113.83 195.26,99.79 arc(195.33,99.68) 195.36,99.55 195.36,91.52 arc(195.3,91.24) 195.14,91 D317.14
D31716: length 192.4
  TOP w0.147: D317.16 195.97,91.05 arc(195.81,91.29) 195.75,91.57 195.75,99.55 arc(195.7,99.83) 195.54,100.07 181.5,114.11 arc(181.26,114.27) 180.98,114.32 164.32,114.32 arc(164.18,114.35) 164.07,114.42 163.49,115 arc(163.42,115.11) 163.39,115.24 163.39,118.79 arc(163.42,118.92) 163.49,119.03 164.31,119.84 arc(164.42,119.92) 164.55,119.94 195.52,119.94 arc(195.8,120) 196.04,120.16 205.64,129.76 arc(205.75,129.83) 205.88,129.85 228.64,129.85 arc(229.88,130.1) 230.94,130.81 234.95,134.81 arc(235.65,135.87) 235.9,137.11 235.9,143.23 arc(235.92,143.36) 236,143.47 237.29,144.76 arc(237.4,144.84) 237.53,144.86 253.04,144.86 arc(253.33,144.92) 253.57,145.08 260.77,152.28 arc(260.93,152.52) 260.98,152.8 260.98,165.95 arc(260.93,166.24) 260.77,166.48 256.27,170.97 arc(256.24,171.02) 256.23,171.08 256.23,171.32 256.23,171.33 SITE3.36
D32102: length 192.4
  TOP w0.147: D321.02 238.38,91.06 arc(238.54,91.3) 238.59,91.58 238.59,98.62 arc(238.65,98.9) 238.81,99.14 286.48,146.81 arc(286.55,146.92) 286.58,147.05 286.58,206.14 arc(286.47,206.69) 286.16,207.15 282.19,211.12 arc(281.72,211.43) 281.18,211.54 259.33,211.54 arc(259.04,211.6) 258.81,211.76 252.45,218.11 arc(252.29,218.35) 252.23,218.64 252.23,231.32 252.23,231.33 SITE1.26
D32104: length 192.4
  TOP w0.147: SITE1.27 252.63,231.33 252.63,231.32 252.63,218.64 arc(252.65,218.51) 252.73,218.39 259.09,212.04 arc(259.2,211.96) 259.33,211.94 281.18,211.94 arc(281.88,211.8) 282.47,211.4 286.44,207.43 arc(286.84,206.84) 286.98,206.14 286.98,147.05 arc(286.92,146.77) 286.76,146.53 239.09,98.86 arc(239.01,98.75) 238.99,98.62 238.99,91.52 arc(239.04,91.23) 239.2,91 D321.04
D32106: length 192.4
  TOP w0.147: SITE1.29 253.43,231.33 253.43,231.32 253.43,221.34 arc(253.49,221.06) 253.65,220.82 260.72,213.75 arc(260.95,213.59) 261.24,213.54 282.95,213.54 arc(283.08,213.51) 283.19,213.44 288.87,207.76 arc(288.94,207.65) 288.97,207.52 288.97,146.11 arc(288.94,145.98) 288.87,145.87 248.9,105.91 arc(248.74,105.67) 248.69,105.39 248.69,104.2 arc(248.74,103.92) 248.9,103.68 251.97,100.62 arc(252.4,99.97) 252.55,99.2 252.55,99.08 arc(252.4,98.31) 251.97,97.66 248.95,94.64 arc(248.79,94.4) 248.74,94.12 248.74,91.56 arc(248.68,91.28) 248.52,91.04 D321.06
D32108: length 192.4
  TOP w0.147: D321.08 249.35,91.01 arc(249.19,91.25) 249.13,91.53 249.13,94.12 arc(249.16,94.25) 249.23,94.36 252.25,97.38 arc(252.77,98.16) 252.95,99.08 252.95,99.2 arc(252.77,100.12) 252.25,100.9 249.18,103.96 arc(249.11,104.07) 249.08,104.2 249.08,105.39 arc(249.11,105.52) 249.18,105.63 289.15,145.59 arc(289.31,145.83) 289.36,146.11 289.36,207.52 arc(289.31,207.8) 289.15,208.04 283.47,213.72 arc(283.23,213.88) 282.95,213.93 261.24,213.93 arc(261.11,213.96) 261,214.03 253.93,221.1 arc(253.85,221.21) 253.83,221.34 253.83,231.32 253.83,231.33 SITE1.30
D32110: length 192.4
  TOP w0.147: SITE1.32 254.63,231.33 254.63,231.32 254.63,229.68 arc(254.69,229.4) 254.85,229.16 258.13,225.88 arc(258.2,225.77) 258.23,225.64 258.23,220.21 arc(258.29,219.93) 258.45,219.69 262.34,215.8 arc(262.58,215.64) 262.86,215.58 285.09,215.58 arc(285.22,215.55) 285.33,215.48 291.24,209.57 arc(291.31,209.46) 291.34,209.33 291.34,144.47 arc(291.31,144.34) 291.24,144.23 259.08,112.07 arc(258.92,111.83) 258.86,111.55 258.86,103.77 arc(258.92,103.49) 259.08,103.25 260.09,102.24 arc(260.33,102.08) 260.61,102.02 261.58,102.02 arc(262.25,101.89) 262.82,101.51 arc(263.2,100.94) 263.34,100.27 263.34,98.31 arc(263.23,97.75) 262.91,97.28 262.84,97.21 arc(262.36,96.89) 261.8,96.78 261.07,96.78 arc(260.79,96.72) 260.55,96.56 259.08,95.09 arc(258.92,94.85) 258.86,94.57 258.86,91.53 arc(258.81,91.25) 258.65,91.01 D321.10
D32112: length 192.4
  TOP w0.147: SITE1.33 255.03,231.33 255.03,231.32 255.03,229.68 arc(255.05,229.55) 255.13,229.44 258.41,226.16 arc(258.57,225.92) 258.63,225.64 258.63,220.21 arc(258.65,220.08) 258.73,219.97 262.62,216.08 arc(262.73,216) 262.86,215.98 285.09,215.98 arc(285.37,215.92) 285.61,215.76 291.52,209.85 arc(291.68,209.61) 291.74,209.33 291.74,144.47 arc(291.68,144.19) 291.52,143.95 259.36,111.79 arc(259.29,111.68) 259.26,111.55 259.26,103.77 arc(259.29,103.64) 259.36,103.53 260.37,102.52 arc(260.48,102.45) 260.61,102.42 261.58,102.42 arc(262.41,102.26) 263.1,101.79 arc(263.57,101.09) 263.73,100.27 263.73,98.31 arc(263.59,97.6) 263.19,97 263.12,96.93 arc(262.51,96.52) 261.8,96.38 261.07,96.38 arc(260.94,96.35) 260.83,96.28 259.36,94.81 arc(259.29,94.7) 259.26,94.57 259.26,91.56 arc(259.32,91.28) 259.48,91.04 D321.12
D32114: length 192.4
  TOP w0.147: D321.14 268.82,91.02 arc(268.98,91.26) 269.04,91.55 269.04,94.71 arc(269.1,95) 269.26,95.23 270.17,96.15 arc(270.41,96.31) 270.69,96.37 273.45,96.37 arc(273.58,96.39) 273.69,96.47 274.2,96.97 arc(274.81,97.88) 275.02,98.96 275.02,99.37 arc(274.81,100.45) 274.2,101.36 273.53,102.03 arc(273.42,102.1) 273.29,102.13 271.08,102.13 arc(270.8,102.18) 270.56,102.34 269.26,103.65 arc(269.1,103.89) 269.04,104.17 269.04,118.95 arc(269.1,119.23) 269.26,119.47 293.83,144.04 arc(293.9,144.15) 293.93,144.28 293.93,210.44 arc(293.9,210.57) 293.83,210.68 287.07,217.44 arc(286.96,217.51) 286.83,217.54 264.6,217.54 arc(264.31,217.59) 264.07,217.75 260.94,220.89 arc(260.78,221.13) 260.72,221.41 260.72,225.92 arc(260.7,226.05) 260.62,226.16 256.01,230.77 arc(255.88,230.97) 255.83,231.2 255.83,231.32 255.83,231.33 SITE1.35
D32116: length 192.4
  TOP w0.147: D321.16 269.65,91.03 arc(269.49,91.27) 269.44,91.55 269.44,94.71 arc(269.46,94.84) 269.54,94.95 270.45,95.87 arc(270.56,95.94) 270.69,95.97 273.45,95.97 arc(273.73,96.02) 273.97,96.18 274.48,96.69 arc(275.18,97.73) 275.42,98.96 275.42,99.37 arc(275.18,100.6) 274.48,101.64 273.81,102.31 arc(273.57,102.47) 273.29,102.52 271.08,102.52 arc(270.95,102.55) 270.84,102.62 269.54,103.93 arc(269.46,104.04) 269.44,104.17 269.44,118.95 arc(269.46,119.08) 269.54,119.19 294.11,143.76 arc(294.27,144) 294.32,144.28 294.32,210.44 arc(294.27,210.72) 294.11,210.96 287.35,217.72 arc(287.11,217.88) 286.83,217.93 264.6,217.93 arc(264.47,217.96) 264.35,218.03 261.22,221.17 arc(261.14,221.28) 261.12,221.41 261.12,225.92 arc(261.06,226.2) 260.9,226.44 256.29,231.06 arc(256.24,231.12) 256.23,231.2 256.23,231.32 256.23,231.33 SITE1.36
Net_652: length 3
  BOTTOM w0.119: 192.47,190.12 194.3,190.12 194.78,190.59 195.26,190.59
Net_653: length 3
  BOTTOM w0.119: 192.47,187.92 194.3,187.92 194.78,187.45 195.26,187.45
S1_1AUX+:
  vias: v1(221.73,229.11)
S1_1AUX-:
  vias: v1(218.45,229.11)
S1_2AUX+:
  vias: v1(184.65,132.33) v1(184.65,131.06) v1(220.73,229.11) v1(220.73,227.84)
S1_2AUX-:
  vias: v1(181.11,131.06) v1(182.11,132.33) v1(219.45,229.11) v1(219.45,227.84)
S1_AUX_100DCH002+:
  vias: v1(183.65,132.33)
S1_AUX_100DCH002-:
  vias: v1(181.11,132.33)
S1_AUXCH+: length 3.6
  TOP w0.203: v2(250.6,236.57) 250.23,236.2 SITE1.21
S1_AUXCH-: length 3.6
  TOP w0.203: SITE1.20 249.83,236.2 v2(249.46,236.57)
S1_AVDD11_RX: length 8.4
  TOP w0.231: SITE1.31 254.23,228.29 254.67,227.85
  TOP w0.508: v1(256.77,225.75) 254.67,227.85
  vias: v1(158.96,294) v1(158.96,292.1) v1(256.77,223.71)
S1_AVDD11_XTAL: length 8.8
  TOP w0.231: SITE1.105 253.03,260.95 252.87,261.11 252.87,261.45
  TOP w0.381: 252.87,261.45 252.87,263.59 253.72,264.44 v1(253.72,264.54)
  vias: v1(201.21,277.5) v1(201.21,275.59) v1(253.72,266.58)
S1_AVDD18_RX: length 7.7
  TOP w0.231: 251.28,230.01 251.83,230.56 SITE1.25
  TOP w0.508: v1(251.06,225.75) 251.06,228.68 251.28,228.9 251.28,230.01
  vias: v1(168.7,294) v1(168.7,292.1) v1(251.06,223.71)
S1_DCH041: length 2.2
  TOP w0.231: v1(237.23,243.03) 237.43,242.83 SITE1.159
S1_DCH042: length 3.7
  TOP w0.231: SITE1.160 236.43,242.43 v1(235.83,243.03)
S1_DCH043: length 5.3
  TOP w0.231: SITE1.161 235.44,242.03 v1(234.44,243.03)
S1_DCH044: length 2.2
  TOP w0.231: SITE1.163 237.43,241.23 v1(237.23,241.03)
S1_DCH045: length 5.4
  TOP w0.231: v1(244.35,239.83) 243.35,240.83 SITE1.164
S1_DCH046: length 3.9
  TOP w0.231: v1(242.95,239.83) 242.35,240.43 SITE1.165
S1_DCH047: length 2.3
  TOP w0.231: v1(241.56,239.83) 241.36,240.03 SITE1.166
S1_DCH048:
  vias: v1(229.05,276.97)
S1_DCH049:
  vias: v1(229.05,271.67)
S1_DPS_F_001:
  vias: v1(101.29,249.52) v1(101.29,247.61) v1(182.11,131.06) v1(221.73,227.84)
S1_DPS_F_002: length 10.1
  TOP w0.231: 240.65,229.55 241.72,229.55 243.03,230.86 SITE1.3
  TOP w0.508: 240.65,229.55 237.98,226.88 v1(237.98,225.75)
  vias: v1(185.21,294) v1(185.21,292.1) v1(236.32,222.9) v1(237.98,223.71)
S1_DPS_F_003: length 63.1
  TOP w0.231: SITE1.37 256.63,231.59 258.57,229.66 259.73,229.66 ; 265.2,242.93 264.9,243.23 SITE1.63 ; 267.84,245.53 266.94,246.43 SITE1.71 ; 234.63,241.63 SITE1.162 ; 249.28,228.85 248.63,229.5 SITE1.17 ; 232.83,248.18 233.08,248.43 SITE1.145 ; 251.69,261.16 251.69,260.65 252.23,260.11 SITE1.107
  TOP w0.381: v1(251.94,264.54) 251.69,264.28 251.69,261.16
  TOP w0.508: v1(271.22,243.91) 269.46,243.91 267.84,245.53 ; 259.73,229.66 262.36,227.02 v1(262.36,225.75) ; 234.63,241.63 234.37,241.63 232.59,243.41 v1(231.44,243.41) ; 265.2,242.93 265.45,242.67 266.8,242.67 268.11,241.37 v1(271.22,241.37) ; 232.83,248.18 232.58,247.93 v1(231.44,247.93) ; v1(249.28,225.75) 249.28,228.85
  vias: v1(114.29,230.12) v1(175.47,294) v1(175.47,292.1) v1(229.4,247.93) v1(229.4,243.41) v1(249.28,223.71) v1(251.54,252.61) v1(251.94,266.58) v1(262.36,223.71) v1(273.27,243.91) v1(273.27,243.91) v1(273.27,241.37) v1(273.27,241.37)
S1_DPS_F_006: length 9.6
  TOP w0.231: 268.55,246.19 267.92,246.83 SITE1.72
  TOP w0.508: 268.55,246.19 269.56,245.18 v1(271.22,245.18)
  vias: v1(168.7,277.5) v1(168.7,275.59) v1(259,246.67) v1(273.27,245.18) v1(273.27,245.18)
S1_DPS_F_007: length 19.1
  TOP w0.231: 264.37,249.01 264.15,249.23 SITE1.78 ; SITE1.97 256.23,260.71 259.65,264.13 v1(259.65,264.54)
  TOP w0.508: v1(271.22,249.5) 270.8,249.5 270.31,249.01 264.37,249.01
  BOTTOM w0.119: CC27.1 v1(273.27,249.5)
  vias: v1(185.21,277.5) v1(185.21,275.59) v1(259.65,266.58)
S1_DPS_F_009: length 8.8
  TOP w0.231: SITE1.106 252.63,260.53 252.26,260.9 252.26,261.12
  TOP w0.381: v1(252.83,264.54) 252.83,264.39 252.26,263.82 252.26,261.12
  vias: v1(201.21,294) v1(201.21,292.1) v1(252.83,266.58) v1(253.61,267.66)
S1_DPS_F_010: length 8.6
  TOP w0.231: SITE1.111 250.63,260.15 251.05,260.57 251.05,261.13
  TOP w0.381: 251.05,261.13 v1(251.05,264.54)
  vias: v1(191.48,294) v1(191.48,292.1) v1(250.34,253.59) v1(251.05,266.58)
S1_DPS_F_011: length 17.6
  TOP w0.231: 247.64,258.01 247.43,257.79 SITE1.119 ; SITE1.139 234.87,250.83 232.01,253.69 v1(231.44,253.69)
  TOP w0.508: v1(247.57,264.54) 247.64,264.47 247.64,258.01
  vias: v1(175.47,277.5) v1(175.47,275.59) v1(229.4,253.69) v1(247.57,266.58)
S1_DPS_F_012: length 8
  TOP w0.231: 232.2,248.83 SITE1.144
  TOP w0.508: 232.2,248.83 231.81,248.83 v1(231.44,249.2)
  vias: v1(158.96,277.5) v1(158.96,275.59) v1(229.4,249.2)
S1_DPS_F_013:
  vias: v1(89.53,207.41) v1(89.77,221.18) v1(96.02,215.5) v1(96.12,229.1) v1(96.42,249.57) v1(96.42,247.66) v1(97.27,241.05) v1(97.27,233.43) v1(98.56,215.5) v1(98.66,229.1) v1(101.1,215.5) v1(101.1,203.31) v1(101.2,229.1) v1(101.2,216.91) v1(103.64,203.31) v1(104.64,215.5) v1(104.74,229.1) v1(104.75,216.86) v1(122.12,241.1) v1(126.75,233.43) v1(126.75,225.81)
S1_ISP00+: length 59.5
  TOP w0.086: v1(273.81,245.88) 273.35,246.33 270.29,246.33 269.31,247.31 264.06,247.31 263.98,247.23 SITE1.73
  L30_SIGNAL w0.071: v1(270.04,277.62) 270.04,276.27 269.97,276.2 266.7,276.2 265.91,275.4 265.91,273.73 267.67,271.97 267.67,268.76 265.64,266.73 265.64,265.4 262.91,262.67 262.91,253.14 269.7,246.35 273.74,246.35 273.81,246.28 v1(273.81,245.88)
  BOTTOM w0.119: v1(270.04,277.62) K43.7
S1_ISP00-: length 58.9
  TOP w0.086: SITE1.74 263.98,247.63 264.06,247.55 269.41,247.55 270.39,246.57 273.35,246.57 v1(273.81,247.02)
  L30_SIGNAL w0.071: v1(270.04,274.58) 270.04,275.93 269.97,276 266.78,276 266.1,275.32 266.1,273.81 267.87,272.05 267.87,268.68 265.84,266.65 265.84,265.32 263.11,262.59 263.11,253.23 269.78,246.55 273.74,246.55 273.81,246.62 v1(273.81,247.02)
  BOTTOM w0.119: v1(270.04,274.58) K43.2
S1_ISP14+: length 65.2
  TOP w0.086: v1(251.93,269.9) 251.48,269.45 251.48,267.92 250.15,266.59 250.15,257.86 250.23,257.78 SITE1.112
  L28_SIGNAL w0.071: v1(265.64,280.1) 265.64,276.27 265.72,276.2 274.89,276.2 276.73,278.03 276.73,280.72 275.32,282.12 262.08,282.12 251.46,271.5 251.46,269.97 251.53,269.9 v1(251.93,269.9)
S1_ISP14-: length 66.2
  TOP w0.086: v1(250.79,269.9) 251.24,269.45 251.24,268.02 249.91,266.69 249.91,257.86 249.83,257.78 SITE1.113
  L28_SIGNAL w0.071: v1(265.64,272.1) 265.64,275.93 265.72,276 274.97,276 276.93,277.95 276.93,280.8 275.4,282.32 262,282.32 251.26,271.58 251.26,269.97 251.19,269.9 v1(250.79,269.9)
S1_ISP_1LOCK:
  vias: v1(229.91,245.39)
S1_M_DPS_F_001: length 45.2
  TOP w0.231: 250.63,230.54 SITE1.22 ; 260.57,230.37 258.54,230.37 257.43,231.49 SITE1.39 ; 266.49,243.63 SITE1.64 ; SITE1.147 233.7,247.63 233.24,247.18 ; SITE1.104 253.43,263.21
  TOP w0.381: 253.43,263.21 254.61,264.39 v1(254.61,264.54)
  TOP w0.508: 266.49,243.63 267.49,243.63 268.48,242.64 v1(271.22,242.64) ; 260.57,230.37 263.63,227.31 v1(263.63,225.75) ; v1(250.17,225.75) 250.17,228.96 250.38,229.17 250.38,230.28 250.63,230.54 ; 233.24,247.18 232.72,246.66 v1(231.44,246.66)
  vias: v1(118.32,292.74) v1(118.32,290.83) v1(229.4,246.66) v1(250.17,223.71) v1(254.61,266.58) v1(263.63,223.71) v1(273.27,242.64) v1(273.27,242.64)
S1_PS9G_DCH001: length 3.7
  TOP w0.231: v1(249.63,229.63) 249.03,230.23 SITE1.18
S1_PS9G_DCH002: length 2.2
  TOP w0.231: SITE1.19 249.43,231.23 v1(249.63,231.03)
S1_PS9G_DCH003: length 2.2
  TOP w0.231: v1(251.23,231.03) 251.43,231.23 SITE1.24
S1_PS9G_DCH004: length 2.2
  TOP w0.231: SITE1.40 257.83,235.03 v1(257.63,235.23)
S1_PS9G_DCH005: length 2.2
  TOP w0.231: SITE1.45 264.23,236.03 v1(264.43,235.83)
S1_PS9G_DCH006: length 3.7
  TOP w0.231: SITE1.46 265.23,236.43 v1(265.83,235.83)
S1_PS9G_DCH007: length 5.3
  TOP w0.231: v1(267.23,235.83) 266.22,236.83 SITE1.47
S1_PS9G_DCH009: length 2.2
  TOP w0.231: SITE1.49 264.23,237.63 v1(264.43,237.43)
S1_PS9G_DCH010: length 3.7
  TOP w0.231: SITE1.50 265.23,238.03 v1(265.83,237.43)
S1_PS9G_DCH011: length 5.3
  TOP w0.231: v1(267.23,237.43) 266.22,238.43 SITE1.51
S1_PS9G_DCH014: length 3.7
  TOP w0.231: v1(265.83,239.03) 265.23,239.63 SITE1.54
S1_PS9G_DCH015: length 5.3
  TOP w0.231: SITE1.55 266.22,240.03 v1(267.23,239.03)
S1_PS9G_DCH022: length 5.3
  TOP w0.231: v1(267.23,245.03) 267.05,245.03 266.05,244.03 SITE1.65
S1_PS9G_DCH023: length 2.5
  TOP w0.231: SITE1.66 264.03,244.43 264.43,244.83 v1(264.43,245.03)
S1_PS9G_DCH027: length 3.9
  TOP w0.231: v1(265.83,245.03) 264.83,246.03 SITE1.70
S1_PS9G_DCH028: length 2.3
  TOP w0.231: SITE1.77 260.6,248.83 v1(260.23,248.46)
S1_PS9G_DCH029: length 2.2
  TOP w0.119: SITE1.118 v1(247.83,253.92)
S1_PS9G_DCH030: length 9.2
  TOP w0.231: SITE1.148 237.62,247.23 237.3,246.91 234.16,246.91 232.63,245.39 v1(230.91,245.39)
S1_PS9G_DCH035: length 5.3
  TOP w0.231: v1(234.44,246.23) 235.44,245.23 SITE1.153
S1_PS9G_DCH036: length 2.2
  TOP w0.231: v1(241.43,245.03) 241.23,244.83 SITE1.154
S1_PS9G_DCH037: length 2.2
  TOP w0.231: v1(237.23,244.63) 237.43,244.43 SITE1.155
S1_PS9G_DCH038: length 3.7
  TOP w0.231: v1(235.83,244.63) 236.43,244.03 SITE1.156
S1_PS9G_DCH039: length 5.3
  TOP w0.231: SITE1.157 235.44,243.63 v1(234.44,244.63)
S1_PS9G_DCH040: length 2.2
  TOP w0.231: v1(241.43,243.43) 241.23,243.23 SITE1.158
S1_RLY_001:
  vias: v1(330.51,288.86) v1(343.98,288.86)
S1_RLY_003:
  vias: v1(293.31,280.1) v1(317.05,288.86)
S1_RLY_005:
  vias: v1(290.64,288.86) v1(303.84,288.86)
S1_RLY_007:
  vias: v1(277.17,288.86)
S1_RLY_008:
  vias: v1(250.5,288.86) v1(263.71,288.86)
S1_RLY_016:
  vias: v1(184.47,264.1) v1(244.8,296.61)
S1_RLY_018:
  vias: v1(232.25,276.97)
S1_RLY_021:
  vias: v1(167.7,264.1) v1(200.98,264.1)
S1_RLY_022:
  vias: v1(184.47,236.67) v1(201.23,236.67)
S1_RLY_023:
  vias: v1(167.7,222.95)
S1_RLY_025:
  vias: v1(184.47,250.38) v1(201.23,250.38)
S1_RLY_026:
  vias: v1(167.7,236.67)
S1_RLY_030:
  vias: v1(167.7,250.38)
S1_RLY_043:
  vias: v1(273.24,280.1)
S1_SCAN_DCH008: length 2.2
  TOP w0.231: v1(260.23,237.03) 260.43,237.23 SITE1.48
S1_SCAN_DCH012: length 2.2
  TOP w0.231: v1(260.23,238.63) 260.43,238.83 SITE1.52
S1_SCAN_DCH013: length 2.2
  TOP w0.231: SITE1.53 264.23,239.23 v1(264.43,239.03)
S1_SCAN_DCH016: length 2.2
  TOP w0.231: v1(260.23,240.23) 260.43,240.43 SITE1.56
S1_SCAN_DCH017: length 2.2
  TOP w0.231: SITE1.57 264.23,240.83 v1(264.43,240.63)
S1_SCAN_DCH018: length 3.7
  TOP w0.231: v1(265.83,240.63) 265.23,241.23 SITE1.58
S1_SCAN_DCH019: length 5.3
  TOP w0.231: v1(267.23,240.63) 266.22,241.63 SITE1.59
S1_SCAN_DCH020: length 2.2
  TOP w0.231: SITE1.60 260.43,242.03 v1(260.23,241.83)
S1_SCAN_DCH021: length 2.2
  TOP w0.231: v1(264.43,242.23) 264.23,242.43 SITE1.61
S1_SCAN_DCH024: length 2.2
  TOP w0.231: SITE1.67 260.43,244.83 v1(260.23,244.63)
S1_SCAN_DCH025: length 3.7
  TOP w0.231: SITE1.68 259.43,245.23 v1(258.83,244.63)
S1_SCAN_DCH026: length 5.3
  TOP w0.231: SITE1.69 258.44,245.63 v1(257.44,244.63)
S1_SCAN_DCH031: length 3.7
  TOP w0.231: SITE1.149 242.23,246.83 v1(242.83,247.43)
S1_SCAN_DCH032: length 5.3
  TOP w0.231: SITE1.150 243.22,246.43 v1(244.22,247.43)
S1_SCAN_DCH033: length 2.2
  TOP w0.231: SITE1.151 237.43,246.03 v1(237.23,246.23)
S1_SCAN_DCH034: length 3.7
  TOP w0.231: SITE1.152 236.43,245.63 v1(235.83,246.23)
S1_SPI_1_CSN:
  vias: v1(104.64,203.31)
S1_SPI_1_SCK:
  vias: v1(99.56,215.5)
S1_SPI_1_SDI:
  vias: v1(123.44,216.92)
S1_SPI_1_SDO:
  vias: v1(123.69,224.54)
S1_SPI_2_CSN:
  vias: v1(103.75,216.86)
S1_SPI_2_SCK:
  vias: v1(99.66,229.1)
S1_SPI_2_SDI:
  vias: v1(128.01,216.92)
S1_SPI_2_SDO:
  vias: v1(127.75,224.54)
S1_SPI_11_SDI:
  vias: v1(102.1,203.31) v1(122.44,216.92)
S1_SPI_11_SDO:
  vias: v1(97.02,215.5) v1(122.69,224.54)
S1_SPI_22_SDI:
  vias: v1(102.2,216.91) v1(127.01,216.92)
S1_SPI_22_SDO:
  vias: v1(97.12,229.1) v1(126.75,224.54)
S1_SPI_CSN: length 2.2
  TOP w0.231: SITE1.43 259.03,231.23 v1(259.23,231.03)
S1_SPI_SCK: length 2.2
  TOP w0.231: SITE1.42 258.63,235.03 v1(258.83,235.23)
S1_SPI_SDI: length 3.7
  TOP w0.231: SITE1.44 259.43,236.03 v1(258.83,236.63)
S1_SPI_SDO: length 3.7
  TOP w0.231: SITE1.41 258.23,236.03 v1(257.63,236.63)
S1_XTAL_IN: length 2.5
  TOP w0.119: SITE1.109 251.43,258.31 v1(251.63,258.51)
  vias: v1(226.85,271.67)
S1_XTAL_OUT: length 3.7
  TOP w0.231: v1(251.63,259.63) 251.03,259.03 SITE1.110
  vias: v1(226.85,276.97)
S2_1AUX+:
  vias: v1(301.73,229.11)
S2_1AUX-:
  vias: v1(298.45,229.11)
S2_2AUX+:
  vias: v1(290.31,132.08) v1(290.31,130.81) v1(300.73,229.11) v1(300.73,227.84)
S2_2AUX-:
  vias: v1(286.77,130.81) v1(287.77,132.08) v1(299.45,229.11) v1(299.45,227.84)
S2_AUX_100DCH002+:
  vias: v1(289.31,132.08)
S2_AUX_100DCH002-:
  vias: v1(286.77,132.08)
S2_AUXCH+: length 3.6
  TOP w0.203: v2(330.6,236.57) 330.23,236.2 SITE2.21
S2_AUXCH-: length 3.6
  TOP w0.203: SITE2.20 329.83,236.2 v2(329.46,236.57)
S2_AVDD11_RX: length 8.4
  TOP w0.231: SITE2.31 334.23,228.29 334.67,227.85
  TOP w0.508: v1(336.77,225.75) 334.67,227.85
  vias: v1(336.77,223.71) v1(452.33,278.76) v1(452.33,276.86)
S2_AVDD11_XTAL: length 8.8
  TOP w0.231: SITE2.105 333.03,260.95 332.87,261.11 332.87,261.45
  TOP w0.381: v1(333.72,264.54) 333.72,264.44 332.87,263.59 332.87,261.45
  vias: v1(333.72,266.58) v1(511.6,295.27) v1(511.6,293.37)
S2_AVDD18_RX: length 7.7
  TOP w0.231: SITE2.25 331.83,230.56 331.28,230.01
  TOP w0.508: 331.28,230.01 331.28,228.9 331.06,228.68 v1(331.06,225.75)
  vias: v1(331.06,223.71) v1(462.07,278.76) v1(462.07,276.86)
S2_DCH041: length 2.2
  TOP w0.231: SITE2.159 317.43,242.83 v1(317.23,243.03)
S2_DCH042: length 3.7
  TOP w0.231: SITE2.160 316.43,242.43 v1(315.83,243.03)
S2_DCH043: length 5.3
  TOP w0.231: SITE2.161 315.44,242.03 v1(314.43,243.03)
S2_DCH044: length 2.2
  TOP w0.231: SITE2.163 317.43,241.23 v1(317.23,241.03)
S2_DCH045: length 5.4
  TOP w0.231: SITE2.164 323.35,240.83 v1(324.35,239.83)
S2_DCH046: length 3.9
  TOP w0.231: SITE2.165 322.35,240.43 v1(322.95,239.83)
S2_DCH047: length 2.3
  TOP w0.231: v1(321.56,239.83) 321.36,240.03 SITE2.166
S2_DCH048:
  vias: v1(309.05,276.97)
S2_DCH049:
  vias: v1(309.05,271.67)
S2_DPS_F_001:
  vias: v1(92.04,249.81) v1(92.04,247.9) v1(287.77,130.81) v1(301.73,227.84)
S2_DPS_F_002: length 10.1
  TOP w0.231: 320.65,229.55 321.72,229.55 323.03,230.86 SITE2.3
  TOP w0.508: 320.65,229.55 317.98,226.88 v1(317.98,225.75)
  vias: v1(316.32,222.9) v1(317.98,223.71) v1(462.07,295.27) v1(462.07,293.37)
S2_DPS_F_003: length 63.1
  TOP w0.231: 312.83,248.18 313.08,248.43 SITE2.145 ; 345.2,242.93 344.9,243.23 SITE2.63 ; 347.84,245.53 346.94,246.43 SITE2.71 ; 339.73,229.66 338.57,229.66 336.63,231.59 SITE2.37 ; SITE2.17 328.63,229.5 329.28,228.85 ; SITE2.107 332.23,260.11 331.69,260.65 331.69,261.16 ; 314.63,241.63 SITE2.162
  TOP w0.381: 331.69,261.16 331.69,264.28 v1(331.94,264.54)
  TOP w0.508: v1(351.22,241.37) 348.11,241.37 346.8,242.67 345.45,242.67 345.2,242.93 ; v1(351.22,243.91) 349.45,243.91 347.84,245.53 ; v1(342.36,225.75) 342.36,227.02 339.73,229.66 ; v1(311.44,243.41) 312.59,243.41 314.37,241.63 314.63,241.63 ; v1(329.28,225.75) 329.28,228.85 ; 312.83,248.18 312.58,247.93 v1(311.44,247.93)
  vias: v1(309.4,247.93) v1(309.4,243.41) v1(329.28,223.71) v1(331.54,252.61) v1(331.94,266.58) v1(342.36,223.71) v1(353.27,243.91) v1(353.27,241.37) v1(452.33,295.27) v1(452.33,293.37) v1(464.57,235.71)
S2_DPS_F_006: length 9.6
  TOP w0.231: SITE2.72 347.92,246.83 348.55,246.19
  TOP w0.508: 348.55,246.19 349.56,245.18 v1(351.22,245.18)
  vias: v1(339,246.67) v1(353.27,245.18) v1(478.58,278.76) v1(478.58,276.86)
S2_DPS_F_007: length 19
  TOP w0.231: SITE2.78 344.15,249.23 344.37,249.01 ; SITE2.97 336.23,260.71 339.65,264.13 v1(339.65,264.54)
  TOP w0.508: 344.37,249.01 350.31,249.01 350.8,249.5 v1(351.22,249.5)
  vias: v1(339.65,266.58) v1(353.27,249.5) v1(495.09,278.76) v1(495.09,276.86)
S2_DPS_F_009: length 8.8
  TOP w0.231: 332.26,261.12 332.26,260.9 332.63,260.53 SITE2.106
  TOP w0.381: v1(332.83,264.54) 332.83,264.39 332.26,263.82 332.26,261.12
  vias: v1(332.83,266.58) v1(333.61,267.66) v1(478.58,295.27) v1(478.58,293.37)
S2_DPS_F_010: length 8.6
  TOP w0.231: SITE2.111 330.63,260.15 331.05,260.57 331.05,261.13
  TOP w0.381: 331.05,261.13 v1(331.05,264.54)
  vias: v1(330.34,253.59) v1(331.05,266.58) v1(468.84,295.27) v1(468.84,293.37)
S2_DPS_F_011: length 17.6
  TOP w0.231: v1(311.44,253.69) 312.01,253.69 314.87,250.83 SITE2.139 ; 327.64,258.01 327.43,257.79 SITE2.119
  TOP w0.508: 327.64,258.01 327.64,264.47 v1(327.57,264.54)
  vias: v1(309.4,253.69) v1(327.57,266.58) v1(485.35,278.76) v1(485.35,276.86)
S2_DPS_F_012: length 8
  TOP w0.231: 312.2,248.83 SITE2.144
  TOP w0.508: 312.2,248.83 311.81,248.83 v1(311.44,249.2)
  vias: v1(309.4,249.2) v1(468.84,278.76) v1(468.84,276.86)
S2_DPS_F_013:
  vias: v1(87.17,249.86) v1(87.17,247.96) v1(452.62,232.41) v1(452.62,224.79) v1(457.25,233.88) v1(474.87,217.23) v1(474.89,204.98) v1(474.99,218.59) v1(475.99,230.78) v1(478.43,217.17) v1(478.43,204.98) v1(478.53,230.78) v1(478.53,218.59) v1(480.97,204.98) v1(481.07,218.59) v1(482.1,241.3) v1(482.1,233.68) v1(483.51,204.98) v1(483.61,218.59) v1(489.86,212.91) v1(490.1,226.67)
S2_ISP00+: length 86.6
  TOP w0.086: v1(353.81,245.88) 353.35,246.33 350.29,246.33 349.31,247.31 344.06,247.31 343.98,247.23 SITE2.73
  L30_SIGNAL w0.071: v1(386.29,259.59) 386.29,260.94 386.22,261.01 381.57,261.01 379.76,259.2 379.76,257.34 381.79,255.3 391.12,255.3 392.89,253.53 392.89,249.22 387.91,244.23 357.27,244.23 355.16,246.35 353.88,246.35 353.81,246.28 v1(353.81,245.88)
  BOTTOM w0.119: v1(386.29,259.59) UNK2K43.7
S2_ISP00-: length 86.6
  TOP w0.086: v1(353.81,247.02) 353.35,246.57 350.39,246.57 349.41,247.55 344.06,247.55 343.98,247.63 SITE2.74
  L30_SIGNAL w0.071: v1(353.81,247.02) 353.81,246.62 353.88,246.55 355.24,246.55 357.35,244.43 387.82,244.43 392.69,249.3 392.69,253.45 391.04,255.11 381.71,255.11 379.56,257.25 379.56,259.28 381.49,261.21 386.22,261.21 386.29,261.28 v1(386.29,262.63)
  BOTTOM w0.119: v1(386.29,262.63) UNK2K43.2
S2_ISP14+: length 137.8
  TOP w0.086: v1(331.93,269.9) 331.48,269.45 331.48,267.92 330.15,266.59 330.15,257.86 330.23,257.78 SITE2.112
  L28_SIGNAL w0.071: v1(331.93,269.9) 331.53,269.9 331.46,269.83 331.46,268.27 330.18,266.99 330.18,263.09 334.92,258.35 342.04,258.35 347.72,252.67 354.79,252.67 356.71,254.59 360.18,254.59 367.29,247.47 404.65,247.47 407.37,250.19 407.37,257.24 403.6,261.01 390.76,261.01 390.69,260.94 v1(390.69,257.11)
S2_ISP14-: length 138.8
  TOP w0.086: v1(330.79,269.9) 331.24,269.45 331.24,268.02 329.91,266.69 329.91,257.86 329.83,257.78 SITE2.113
  L28_SIGNAL w0.071: v1(330.79,269.9) 331.19,269.9 331.26,269.83 331.26,268.35 329.98,267.07 329.98,263.01 334.84,258.16 341.95,258.16 347.64,252.47 354.88,252.47 356.79,254.39 360.09,254.39 367.21,247.27 404.73,247.27 407.57,250.11 407.57,257.33 403.68,261.21 390.76,261.21 390.69,261.28 v1(390.69,265.11)
S2_ISP_1LOCK:
  vias: v1(309.91,245.39)
S2_M_DPS_F_001: length 45.2
  TOP w0.231: SITE2.39 337.43,231.49 338.54,230.37 340.57,230.37 ; 313.24,247.18 313.7,247.63 SITE2.147 ; 346.49,243.63 SITE2.64 ; 330.63,230.54 SITE2.22 ; SITE2.104 333.43,263.21
  TOP w0.381: v1(334.61,264.54) 334.61,264.39 333.43,263.21
  TOP w0.508: 330.63,230.54 330.38,230.28 330.38,229.17 330.17,228.96 v1(330.17,225.75) ; 313.24,247.18 312.72,246.66 v1(311.44,246.66) ; v1(343.63,225.75) 343.63,227.31 340.57,230.37 ; 346.49,243.63 347.49,243.63 348.48,242.64 v1(351.22,242.64)
  vias: v1(309.4,246.66) v1(330.17,223.71) v1(334.61,266.58) v1(343.63,223.71) v1(353.27,242.64) v1(485.35,295.27) v1(485.35,293.37)
S2_PS9G_DCH001: length 3.7
  TOP w0.231: v1(329.63,229.63) 329.03,230.23 SITE2.18
S2_PS9G_DCH002: length 2.2
  TOP w0.231: v1(329.63,231.03) 329.43,231.23 SITE2.19
S2_PS9G_DCH003: length 2.2
  TOP w0.231: v1(331.23,231.03) 331.43,231.23 SITE2.24
S2_PS9G_DCH004: length 2.2
  TOP w0.231: v1(337.63,235.23) 337.83,235.03 SITE2.40
S2_PS9G_DCH005: length 2.2
  TOP w0.231: SITE2.45 344.23,236.03 v1(344.43,235.83)
S2_PS9G_DCH006: length 3.7
  TOP w0.231: v1(345.83,235.83) 345.23,236.43 SITE2.46
S2_PS9G_DCH007: length 5.3
  TOP w0.231: SITE2.47 346.22,236.83 v1(347.22,235.83)
S2_PS9G_DCH009: length 2.2
  TOP w0.231: SITE2.49 344.23,237.63 v1(344.43,237.43)
S2_PS9G_DCH010: length 3.7
  TOP w0.231: SITE2.50 345.23,238.03 v1(345.83,237.43)
S2_PS9G_DCH011: length 5.3
  TOP w0.231: v1(347.22,237.43) 346.22,238.43 SITE2.51
S2_PS9G_DCH014: length 3.7
  TOP w0.231: SITE2.54 345.23,239.63 v1(345.83,239.03)
S2_PS9G_DCH015: length 5.3
  TOP w0.231: v1(347.22,239.03) 346.22,240.03 SITE2.55
S2_PS9G_DCH022: length 5.3
  TOP w0.231: v1(347.22,245.03) 347.05,245.03 346.05,244.03 SITE2.65
S2_PS9G_DCH023: length 2.5
  TOP w0.231: v1(344.43,245.03) 344.43,244.83 344.03,244.43 SITE2.66
S2_PS9G_DCH027: length 3.9
  TOP w0.231: v1(345.83,245.03) 344.83,246.03 SITE2.70
S2_PS9G_DCH028: length 2.3
  TOP w0.231: SITE2.77 340.6,248.83 v1(340.23,248.46)
S2_PS9G_DCH029: length 2.2
  TOP w0.119: SITE2.118 v1(327.83,253.92)
S2_PS9G_DCH030: length 9.2
  TOP w0.231: SITE2.148 317.62,247.23 317.3,246.91 314.16,246.91 312.63,245.39 v1(310.91,245.39)
S2_PS9G_DCH035: length 5.3
  TOP w0.231: v1(314.43,246.23) 315.44,245.23 SITE2.153
S2_PS9G_DCH036: length 2.2
  TOP w0.231: SITE2.154 321.23,244.83 v1(321.43,245.03)
S2_PS9G_DCH037: length 2.2
  TOP w0.231: v1(317.23,244.63) 317.43,244.43 SITE2.155
S2_PS9G_DCH038: length 3.7
  TOP w0.231: v1(315.83,244.63) 316.43,244.03 SITE2.156
S2_PS9G_DCH039: length 5.3
  TOP w0.231: SITE2.157 315.44,243.63 v1(314.43,244.63)
S2_PS9G_DCH040: length 2.2
  TOP w0.231: SITE2.158 321.23,243.23 v1(321.43,243.43)
S2_RLY_001:
  vias: v1(369.38,241.11) v1(410.52,289.12)
S2_RLY_003:
  vias: v1(369.38,257.11) v1(396.55,257.37)
S2_RLY_005:
  vias: v1(410.27,257.37) v1(410.52,273.37)
S2_RLY_007:
  vias: v1(396.55,273.11)
S2_RLY_008:
  vias: v1(383.09,289.12) v1(383.09,273.11)
S2_RLY_016:
  vias: v1(369.63,273.11) v1(396.55,289.12)
S2_RLY_018:
  vias: v1(312.25,276.97)
S2_RLY_021:
  vias: v1(369.63,289.12) v1(383.09,241.11)
S2_RLY_022:
  vias: v1(389.7,209.36) v1(396.55,225.11)
S2_RLY_023:
  vias: v1(403.41,209.61)
S2_RLY_025:
  vias: v1(383.09,224.85) v1(410.52,241.11)
S2_RLY_026:
  vias: v1(369.38,224.6)
S2_RLY_030:
  vias: v1(396.55,241.11)
S2_RLY_043:
  vias: v1(383.09,257.11)
S2_SCAN_DCH008: length 2.2
  TOP w0.231: SITE2.48 340.43,237.23 v1(340.23,237.03)
S2_SCAN_DCH012: length 2.2
  TOP w0.231: v1(340.23,238.63) 340.43,238.83 SITE2.52
S2_SCAN_DCH013: length 2.2
  TOP w0.231: SITE2.53 344.23,239.23 v1(344.43,239.03)
S2_SCAN_DCH016: length 2.2
  TOP w0.231: v1(340.23,240.23) 340.43,240.43 SITE2.56
S2_SCAN_DCH017: length 2.2
  TOP w0.231: SITE2.57 344.23,240.83 v1(344.43,240.63)
S2_SCAN_DCH018: length 3.7
  TOP w0.231: v1(345.83,240.63) 345.23,241.23 SITE2.58
S2_SCAN_DCH019: length 5.3
  TOP w0.231: v1(347.22,240.63) 346.22,241.63 SITE2.59
S2_SCAN_DCH020: length 2.2
  TOP w0.231: SITE2.60 340.43,242.03 v1(340.23,241.83)
S2_SCAN_DCH021: length 2.2
  TOP w0.231: SITE2.61 344.23,242.43 v1(344.43,242.23)
S2_SCAN_DCH024: length 2.2
  TOP w0.231: v1(340.23,244.63) 340.43,244.83 SITE2.67
S2_SCAN_DCH025: length 3.7
  TOP w0.231: v1(338.83,244.63) 339.43,245.23 SITE2.68
S2_SCAN_DCH026: length 5.3
  TOP w0.231: v1(337.44,244.63) 338.44,245.63 SITE2.69
S2_SCAN_DCH031: length 3.7
  TOP w0.231: SITE2.149 322.23,246.83 v1(322.83,247.43)
S2_SCAN_DCH032: length 5.3
  TOP w0.231: SITE2.150 323.22,246.43 v1(324.22,247.43)
S2_SCAN_DCH033: length 2.2
  TOP w0.231: SITE2.151 317.43,246.03 v1(317.23,246.23)
S2_SCAN_DCH034: length 3.7
  TOP w0.231: SITE2.152 316.43,245.63 v1(315.83,246.23)
S2_SPI_1_CSN:
  vias: v1(474.99,230.78)
S2_SPI_1_SCK:
  vias: v1(480.07,218.59)
S2_SPI_1_SDI:
  vias: v1(456.19,217.17)
S2_SPI_1_SDO:
  vias: v1(455.94,209.55)
S2_SPI_2_CSN:
  vias: v1(475.87,217.23)
S2_SPI_2_SCK:
  vias: v1(479.97,204.98)
S2_SPI_2_SDI:
  vias: v1(451.62,217.17)
S2_SPI_2_SDO:
  vias: v1(451.87,209.55)
S2_SPI_11_SDI:
  vias: v1(457.19,217.17) v1(477.53,230.78)
S2_SPI_11_SDO:
  vias: v1(456.94,209.55) v1(482.61,218.59)
S2_SPI_22_SDI:
  vias: v1(452.62,217.17) v1(477.43,217.17)
S2_SPI_22_SDO:
  vias: v1(452.87,209.55) v1(482.51,204.98)
S2_SPI_CSN: length 2.2
  TOP w0.231: v1(339.23,231.03) 339.03,231.23 SITE2.43
S2_SPI_SCK: length 2.2
  TOP w0.231: v1(338.83,235.23) 338.63,235.03 SITE2.42
S2_SPI_SDI: length 3.7
  TOP w0.231: v1(338.83,236.63) 339.43,236.03 SITE2.44
S2_SPI_SDO: length 3.7
  TOP w0.231: SITE2.41 338.23,236.03 v1(337.63,236.63)
S2_XTAL_IN: length 2.5
  TOP w0.119: SITE2.109 331.43,258.31 v1(331.63,258.51)
  vias: v1(306.85,271.67)
S2_XTAL_OUT: length 3.7
  TOP w0.231: SITE2.110 331.03,259.03 v1(331.63,259.63)
  vias: v1(306.85,276.97)
S3_1AUX+:
  vias: v1(221.73,169.11)
S3_1AUX-:
  vias: v1(218.45,169.11)
S3_2AUX+:
  vias: v1(192.78,132.33) v1(192.78,131.06) v1(220.73,169.11) v1(220.73,167.84)
S3_2AUX-:
  vias: v1(189.24,131.06) v1(190.24,132.33) v1(219.45,169.11) v1(219.45,167.84)
S3_AUX_100DCH002+:
  vias: v1(191.78,132.33)
S3_AUX_100DCH002-:
  vias: v1(189.24,132.33)
S3_AUXCH+: length 3.6
  TOP w0.203: v2(250.6,176.57) 250.23,176.2 SITE3.21
S3_AUXCH-: length 3.6
  TOP w0.203: v2(249.46,176.57) 249.83,176.2 SITE3.20
S3_AVDD11_RX: length 8.4
  TOP w0.231: SITE3.31 254.23,168.29 254.67,167.85
  TOP w0.508: v1(256.77,165.75) 254.67,167.85
  vias: v1(118.32,276.23) v1(118.32,274.32) v1(256.77,163.71)
S3_AVDD11_XTAL: length 8.8
  TOP w0.231: SITE3.105 253.03,200.95 252.87,201.11 252.87,201.45
  TOP w0.381: v1(253.72,204.54) 253.72,204.45 252.87,203.59 252.87,201.45
  vias: v1(93.77,276.23) v1(93.77,274.32) v1(253.72,206.58)
S3_AVDD18_RX: length 7.7
  TOP w0.231: 251.28,170.01 251.83,170.56 SITE3.25
  TOP w0.508: 251.28,170.01 251.28,168.9 251.06,168.68 v1(251.06,165.75)
  vias: v1(128.06,276.23) v1(128.06,274.32) v1(251.06,163.71)
S3_DCH041: length 2.2
  TOP w0.231: SITE3.159 237.43,182.83 v1(237.23,183.03)
S3_DCH042: length 3.7
  TOP w0.231: SITE3.160 236.43,182.43 v1(235.83,183.03)
S3_DCH043: length 5.3
  TOP w0.231: v1(234.44,183.03) 235.44,182.03 SITE3.161
S3_DCH044: length 2.2
  TOP w0.231: SITE3.163 237.43,181.23 v1(237.23,181.03)
S3_DCH045: length 5.4
  TOP w0.231: v1(244.35,179.83) 243.35,180.83 SITE3.164
S3_DCH046: length 3.9
  TOP w0.231: v1(242.95,179.83) 242.35,180.43 SITE3.165
S3_DCH047: length 2.3
  TOP w0.231: v1(241.56,179.83) 241.36,180.03 SITE3.166
S3_DCH048:
  vias: v1(229.05,216.97)
S3_DCH049:
  vias: v1(229.05,211.67)
S3_DPS_F_001:
  vias: v1(112.05,249.13) v1(112.05,247.23) v1(190.24,131.06) v1(221.73,167.84)
S3_DPS_F_002: length 10.1
  TOP w0.231: 240.65,169.55 241.72,169.55 243.03,170.86 SITE3.3
  TOP w0.508: 240.65,169.55 237.98,166.88 v1(237.98,165.75)
  vias: v1(111.55,292.74) v1(111.55,290.83) v1(236.32,162.9) v1(237.98,163.71)
S3_DPS_F_003: length 63.1
  TOP w0.231: SITE3.107 252.23,200.11 251.69,200.65 251.69,201.16 ; SITE3.71 266.94,186.43 267.84,185.53 ; 234.63,181.63 SITE3.162 ; 232.83,188.18 233.08,188.43 SITE3.145 ; 265.2,182.93 264.9,183.23 SITE3.63 ; 249.28,168.85 248.63,169.5 SITE3.17 ; 259.73,169.66 258.57,169.66 256.63,171.59 SITE3.37
  TOP w0.381: 251.69,201.16 251.69,204.28 v1(251.94,204.54)
  TOP w0.508: v1(271.22,181.37) 268.11,181.37 266.8,182.68 265.45,182.68 265.2,182.93 ; v1(231.44,183.41) 232.59,183.41 234.37,181.63 234.63,181.63 ; v1(271.22,183.91) 269.46,183.91 267.84,185.53 ; v1(249.28,165.75) 249.28,168.85 ; 259.73,169.66 262.36,167.02 v1(262.36,165.75) ; 232.83,188.18 232.58,187.93 v1(231.44,187.93)
  vias: v1(101.81,292.74) v1(101.81,290.83) v1(114.55,186.44) v1(229.4,187.93) v1(229.4,183.41) v1(249.28,163.71) v1(251.54,192.61) v1(251.94,206.58) v1(262.36,163.71) v1(273.27,183.91) v1(273.27,181.37)
S3_DPS_F_006: length 9.6
  TOP w0.231: SITE3.72 267.92,186.83 268.55,186.19
  TOP w0.508: 268.55,186.19 269.56,185.18 v1(271.22,185.18)
  vias: v1(75.99,276.23) v1(75.99,274.32) v1(259,186.67) v1(273.27,185.18)
S3_DPS_F_007: length 19
  TOP w0.231: SITE3.97 256.23,200.71 259.65,204.13 v1(259.65,204.54) ; 264.37,189.01 264.15,189.23 SITE3.78
  TOP w0.508: 264.37,189.01 270.31,189.01 270.8,189.5 v1(271.22,189.5)
  vias: v1(75.99,292.74) v1(75.99,290.83) v1(259.65,206.58) v1(273.27,189.5)
S3_DPS_F_009: length 8.8
  TOP w0.231: SITE3.106 252.63,200.53 252.26,200.9 252.26,201.12
  TOP w0.381: 252.26,201.12 252.26,203.82 252.83,204.39 v1(252.83,204.54)
  vias: v1(93.77,292.74) v1(93.77,290.83) v1(252.83,206.58) v1(253.61,207.66)
S3_DPS_F_010: length 8.6
  TOP w0.231: SITE3.111 250.63,200.15 251.05,200.57 251.05,201.13
  TOP w0.381: 251.05,201.13 v1(251.05,204.54)
  vias: v1(84.03,292.74) v1(84.03,290.83) v1(250.34,193.59) v1(251.05,206.58)
S3_DPS_F_011: length 17.6
  TOP w0.231: v1(231.44,193.69) 232.01,193.69 234.87,190.83 SITE3.139 ; SITE3.119 247.43,197.79 247.64,198.01
  TOP w0.508: v1(247.57,204.54) 247.64,204.47 247.64,198.01
  vias: v1(66.25,292.74) v1(66.25,290.83) v1(229.4,193.69) v1(247.57,206.58)
S3_DPS_F_012: length 8
  TOP w0.231: 232.2,188.83 SITE3.144
  TOP w0.508: 232.2,188.83 231.81,188.83 v1(231.44,189.2)
  vias: v1(66.25,276.23) v1(66.25,274.32) v1(229.4,189.2)
S3_DPS_F_013:
  vias: v1(89.78,163.72) v1(90.02,177.49) v1(96.27,171.81) v1(96.37,185.42) v1(97.53,197.36) v1(97.53,189.74) v1(98.81,171.81) v1(98.91,185.42) v1(101.35,171.81) v1(101.35,159.62) v1(101.45,185.42) v1(101.45,173.22) v1(103.89,159.62) v1(104.89,171.81) v1(104.99,185.42) v1(105.01,173.17) v1(107.18,249.19) v1(107.18,247.28) v1(122.38,197.41) v1(127.01,189.74) v1(127.01,182.12)
S3_ISP00+: length 128.7
  TOP w0.086: SITE3.73 263.98,187.23 264.06,187.31 269.31,187.31 270.29,186.33 273.35,186.33 v1(273.81,185.88)
  L30_SIGNAL w0.071: v1(273.81,185.88) 273.81,186.28 273.88,186.35 274.79,186.35 275.51,187.07 275.51,192.02 274.98,192.56 272.06,192.56 267.5,197.12 230.83,197.12 226.54,201.4 221.84,201.4 212.34,191.9 192.82,191.9 188.37,187.44 188.37,178.93 188.3,178.86 v1(186.95,178.86)
  BOTTOM w0.119: v1(186.95,178.86) UNK3K43.7
S3_ISP00-: length 127.8
  TOP w0.086: v1(273.81,187.02) 273.35,186.57 270.39,186.57 269.41,187.55 264.06,187.55 263.98,187.63 SITE3.74
  L30_SIGNAL w0.071: v1(273.81,187.02) 273.81,186.62 273.88,186.55 274.71,186.55 275.31,187.15 275.31,191.94 274.89,192.36 271.98,192.36 267.42,196.92 230.74,196.92 226.46,201.2 221.93,201.2 212.43,191.7 192.91,191.7 188.57,187.36 188.57,178.93 188.64,178.86 v1(189.99,178.86)
  BOTTOM w0.119: v1(189.99,178.86) UNK3K43.2
S3_ISP14+: length 139.4
  TOP w0.086: SITE3.112 250.23,197.78 250.15,197.86 250.15,206.59 251.48,207.92 251.48,209.45 v1(251.93,209.9)
  L28_SIGNAL w0.071: v1(184.47,174.46) 188.3,174.46 188.37,174.53 188.37,183.84 187.48,184.73 180.44,184.73 177.05,188.12 177.05,204.98 180.49,208.42 220.57,208.42 223.35,211.2 223.35,212.34 224.66,213.65 249.38,213.65 251.46,211.57 251.46,209.97 251.53,209.9 v1(251.93,209.9)
S3_ISP14-: length 138.7
  TOP w0.086: v1(250.79,209.9) 251.24,209.45 251.24,208.02 249.91,206.69 249.91,197.86 249.83,197.78 SITE3.113
  L28_SIGNAL w0.071: v1(250.79,209.9) 251.19,209.9 251.26,209.97 251.26,211.49 249.29,213.45 224.74,213.45 223.54,212.25 223.54,211.11 220.65,208.22 180.57,208.22 177.25,204.9 177.25,188.2 180.52,184.93 187.57,184.93 188.57,183.93 188.57,174.53 188.64,174.46 v1(192.47,174.46)
S3_ISP_1LOCK:
  vias: v1(229.91,185.39)
S3_M_DPS_F_001: length 45.2
  TOP w0.231: 266.49,183.63 SITE3.64 ; SITE3.104 253.43,203.21 ; SITE3.147 233.7,187.63 233.24,187.18 ; 260.57,170.37 258.54,170.37 257.43,171.49 SITE3.39 ; 250.63,170.54 SITE3.22
  TOP w0.381: 253.43,203.21 254.61,204.39 v1(254.61,204.54)
  TOP w0.508: v1(263.63,165.75) 263.63,167.31 260.57,170.37 ; v1(231.44,186.66) 232.72,186.66 233.24,187.18 ; 250.63,170.54 250.38,170.28 250.38,169.17 250.17,168.96 v1(250.17,165.75) ; 266.49,183.63 267.49,183.63 268.48,182.64 v1(271.22,182.64)
  vias: v1(101.81,276.23) v1(101.81,274.32) v1(229.4,186.66) v1(250.17,163.71) v1(254.61,206.58) v1(263.63,163.71) v1(273.27,182.64)
S3_PS9G_DCH001: length 3.7
  TOP w0.231: SITE3.18 249.03,170.23 v1(249.63,169.63)
S3_PS9G_DCH002: length 2.2
  TOP w0.231: SITE3.19 249.43,171.23 v1(249.63,171.03)
S3_PS9G_DCH003: length 2.2
  TOP w0.231: SITE3.24 251.43,171.23 v1(251.23,171.03)
S3_PS9G_DCH004: length 2.2
  TOP w0.231: v1(257.63,175.23) 257.83,175.03 SITE3.40
S3_PS9G_DCH005: length 2.2
  TOP w0.231: v1(264.43,175.83) 264.23,176.03 SITE3.45
S3_PS9G_DCH006: length 3.7
  TOP w0.231: SITE3.46 265.23,176.43 v1(265.83,175.83)
S3_PS9G_DCH007: length 5.3
  TOP w0.231: SITE3.47 266.22,176.83 v1(267.23,175.83)
S3_PS9G_DCH009: length 2.2
  TOP w0.231: v1(264.43,177.43) 264.23,177.63 SITE3.49
S3_PS9G_DCH010: length 3.7
  TOP w0.231: v1(265.83,177.43) 265.23,178.03 SITE3.50
S3_PS9G_DCH011: length 5.3
  TOP w0.231: v1(267.23,177.43) 266.22,178.43 SITE3.51
S3_PS9G_DCH014: length 3.7
  TOP w0.231: SITE3.54 265.23,179.63 v1(265.83,179.03)
S3_PS9G_DCH015: length 5.3
  TOP w0.231: v1(267.23,179.03) 266.22,180.03 SITE3.55
S3_PS9G_DCH022: length 5.3
  TOP w0.231: SITE3.65 266.05,184.03 267.05,185.03 v1(267.23,185.03)
S3_PS9G_DCH023: length 2.5
  TOP w0.231: SITE3.66 264.03,184.43 264.43,184.83 v1(264.43,185.03)
S3_PS9G_DCH027: length 3.9
  TOP w0.231: v1(265.83,185.03) 264.83,186.03 SITE3.70
S3_PS9G_DCH028: length 2.3
  TOP w0.231: SITE3.77 260.6,188.83 v1(260.23,188.46)
S3_PS9G_DCH029: length 2.2
  TOP w0.119: SITE3.118 v1(247.83,193.92)
S3_PS9G_DCH030: length 9.2
  TOP w0.231: v1(230.91,185.39) 232.63,185.39 234.16,186.91 237.3,186.91 237.62,187.23 SITE3.148
S3_PS9G_DCH035: length 5.3
  TOP w0.231: SITE3.153 235.44,185.23 v1(234.44,186.23)
S3_PS9G_DCH036: length 2.2
  TOP w0.231: SITE3.154 241.23,184.83 v1(241.43,185.03)
S3_PS9G_DCH037: length 2.2
  TOP w0.231: SITE3.155 237.43,184.43 v1(237.23,184.63)
S3_PS9G_DCH038: length 3.7
  TOP w0.231: SITE3.156 236.43,184.03 v1(235.83,184.63)
S3_PS9G_DCH039: length 5.3
  TOP w0.231: v1(234.44,184.63) 235.44,183.63 SITE3.157
S3_PS9G_DCH040: length 2.2
  TOP w0.231: SITE3.158 241.23,183.23 v1(241.43,183.43)
S3_RLY_001:
  vias: v1(167.7,182.06) v1(256.73,140.14)
S3_RLY_003:
  vias: v1(269.69,143.19) v1(282.9,155.38)
S3_RLY_005:
  vias: v1(184.47,222.95) v1(201.23,222.95)
S3_RLY_007:
  vias: v1(184.47,209.49)
S3_RLY_008:
  vias: v1(167.7,209.49) v1(184.47,195.52)
S3_RLY_016:
  vias: v1(167.7,195.52) v1(201.23,209.49)
S3_RLY_018:
  vias: v1(232.25,216.97)
S3_RLY_021:
  vias: v1(201.23,195.52) v1(201.49,182.06)
S3_RLY_022:
  vias: v1(167.7,141.67) v1(184.47,154.88)
S3_RLY_023:
  vias: v1(201.49,155.13)
S3_RLY_025:
  vias: v1(167.7,154.88) v1(201.49,168.6)
S3_RLY_026:
  vias: v1(184.47,168.6)
S3_RLY_030:
  vias: v1(167.7,168.6)
S3_RLY_043:
  vias: v1(184.47,182.06)
S3_SCAN_DCH008: length 2.2
  TOP w0.231: SITE3.48 260.43,177.23 v1(260.23,177.03)
S3_SCAN_DCH012: length 2.2
  TOP w0.231: v1(260.23,178.63) 260.43,178.83 SITE3.52
S3_SCAN_DCH013: length 2.2
  TOP w0.231: SITE3.53 264.23,179.23 v1(264.43,179.03)
S3_SCAN_DCH016: length 2.2
  TOP w0.231: SITE3.56 260.43,180.43 v1(260.23,180.23)
S3_SCAN_DCH017: length 2.2
  TOP w0.231: v1(264.43,180.63) 264.23,180.83 SITE3.57
S3_SCAN_DCH018: length 3.7
  TOP w0.231: SITE3.58 265.23,181.23 v1(265.83,180.63)
S3_SCAN_DCH019: length 5.3
  TOP w0.231: SITE3.59 266.22,181.63 v1(267.23,180.63)
S3_SCAN_DCH020: length 2.2
  TOP w0.231: v1(260.23,181.83) 260.43,182.03 SITE3.60
S3_SCAN_DCH021: length 2.2
  TOP w0.231: v1(264.43,182.23) 264.23,182.43 SITE3.61
S3_SCAN_DCH024: length 2.2
  TOP w0.231: v1(260.23,184.63) 260.43,184.83 SITE3.67
S3_SCAN_DCH025: length 3.7
  TOP w0.231: v1(258.83,184.63) 259.43,185.23 SITE3.68
S3_SCAN_DCH026: length 5.3
  TOP w0.231: SITE3.69 258.44,185.63 v1(257.44,184.63)
S3_SCAN_DCH031: length 3.7
  TOP w0.231: v1(242.83,187.43) 242.23,186.83 SITE3.149
S3_SCAN_DCH032: length 5.3
  TOP w0.231: v1(244.22,187.43) 243.22,186.43 SITE3.150
S3_SCAN_DCH033: length 2.2
  TOP w0.231: SITE3.151 237.43,186.03 v1(237.23,186.23)
S3_SCAN_DCH034: length 3.7
  TOP w0.231: v1(235.83,186.23) 236.43,185.63 SITE3.152
S3_SPI_1_CSN:
  vias: v1(104.89,159.62)
S3_SPI_1_SCK:
  vias: v1(99.81,171.81)
S3_SPI_1_SDI:
  vias: v1(123.69,173.23)
S3_SPI_1_SDO:
  vias: v1(123.94,180.85)
S3_SPI_2_CSN:
  vias: v1(104.01,173.17)
S3_SPI_2_SCK:
  vias: v1(99.91,185.42)
S3_SPI_2_SDI:
  vias: v1(128.26,173.23)
S3_SPI_2_SDO:
  vias: v1(128.01,180.85)
S3_SPI_11_SDI:
  vias: v1(102.35,159.62) v1(122.69,173.23)
S3_SPI_11_SDO:
  vias: v1(97.27,171.81) v1(122.94,180.85)
S3_SPI_22_SDI:
  vias: v1(102.45,173.22) v1(127.26,173.23)
S3_SPI_22_SDO:
  vias: v1(97.37,185.42) v1(127.01,180.85)
S3_SPI_CSN: length 2.2
  TOP w0.231: SITE3.43 259.03,171.23 v1(259.23,171.03)
S3_SPI_SCK: length 2.2
  TOP w0.231: SITE3.42 258.63,175.03 v1(258.83,175.23)
S3_SPI_SDI: length 3.7
  TOP w0.231: v1(258.83,176.63) 259.43,176.03 SITE3.44
S3_SPI_SDO: length 3.7
  TOP w0.231: v1(257.63,176.63) 258.23,176.03 SITE3.41
S3_XTAL_IN: length 2.5
  TOP w0.119: v1(251.63,198.51) 251.43,198.31 SITE3.109
  vias: v1(226.85,211.67)
S3_XTAL_OUT: length 3.7
  TOP w0.231: SITE3.110 251.03,199.03 v1(251.63,199.63)
  vias: v1(226.85,216.97)
S4_1AUX+:
  vias: v1(301.73,169.11)
S4_1AUX-:
  vias: v1(298.45,169.11)
S4_2AUX+:
  vias: v1(300.22,132.08) v1(300.22,130.81) v1(300.73,169.11) v1(300.73,167.84)
S4_2AUX-:
  vias: v1(296.68,130.81) v1(297.68,132.08) v1(299.45,169.11) v1(299.45,167.84)
S4_AUX_100DCH002+:
  vias: v1(299.22,132.08)
S4_AUX_100DCH002-:
  vias: v1(296.68,132.08)
S4_AUXCH+: length 3.6
  TOP w0.203: SITE4.21 330.23,176.2 v2(330.6,176.57)
S4_AUXCH-: length 3.6
  TOP w0.203: SITE4.20 329.83,176.2 v2(329.46,176.57)
S4_AVDD11_RX: length 8.4
  TOP w0.231: SITE4.31 334.23,168.29 334.67,167.85
  TOP w0.508: v1(336.77,165.75) 334.67,167.85
  vias: v1(336.77,163.71) v1(518.37,278.76) v1(518.37,276.86)
S4_AVDD11_XTAL: length 8.8
  TOP w0.231: 332.87,201.45 332.87,201.11 333.03,200.95 SITE4.105
  TOP w0.381: v1(333.72,204.54) 333.72,204.45 332.87,203.59 332.87,201.45
  vias: v1(333.72,206.58) v1(511.6,262.25) v1(511.6,260.35)
S4_AVDD18_RX: length 7.7
  TOP w0.231: SITE4.25 331.83,170.56 331.28,170.01
  TOP w0.508: 331.28,170.01 331.28,168.9 331.06,168.68 v1(331.06,165.75)
  vias: v1(331.06,163.71) v1(528.11,278.76) v1(528.11,276.86)
S4_DCH041: length 2.2
  TOP w0.231: SITE4.159 317.43,182.83 v1(317.23,183.03)
S4_DCH042: length 3.7
  TOP w0.231: v1(315.83,183.03) 316.43,182.43 SITE4.160
S4_DCH043: length 5.3
  TOP w0.231: v1(314.43,183.03) 315.44,182.03 SITE4.161
S4_DCH044: length 2.2
  TOP w0.231: v1(317.23,181.03) 317.43,181.23 SITE4.163
S4_DCH045: length 5.4
  TOP w0.231: SITE4.164 323.35,180.83 v1(324.35,179.83)
S4_DCH046: length 3.9
  TOP w0.231: v1(322.95,179.83) 322.35,180.43 SITE4.165
S4_DCH047: length 2.3
  TOP w0.231: v1(321.56,179.83) 321.36,180.03 SITE4.166
S4_DCH048:
  vias: v1(309.05,216.97)
S4_DCH049:
  vias: v1(309.05,211.67)
S4_DPS_F_001:
  vias: v1(122.19,249.66) v1(122.19,247.75) v1(297.68,130.81) v1(301.73,167.84)
