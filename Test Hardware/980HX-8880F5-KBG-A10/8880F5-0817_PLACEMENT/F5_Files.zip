# Allegro board 8880F5-0827_updates.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D12216: length 161.3
  TOP w0.086: v1(273.81,194.92) 273.35,194.46 269.43,194.46 266.51,191.55 264.06,191.55 263.98,191.63 SITE3.84
  L05_SIGNAL w0.071: D122.16 269.33,81.19 269.33,81.55 270.19,82.41 276.1,82.41 278.61,84.93 278.61,110.34 265.79,123.17 265.79,133.64 265.17,134.26 263.69,134.26 263.09,133.66 263.09,132.47 263.02,132.4 v1(262.62,132.4)
  L30_SIGNAL w0.071: v1(273.81,194.92) 273.81,194.51 273.88,194.44 275.43,194.44 276.6,193.27 276.6,162.54 265.49,151.43 265.49,131.63 264.27,130.41 263.57,130.41 263.09,130.89 263.09,132.33 263.02,132.4 v1(262.62,132.4)
D12301: length 298.5
  TOP w0.086: SITE3.95 257.03,197.78 256.95,197.86 256.95,199.72 260.9,203.67 260.9,206.64 v1(261.36,207.09)
  L07_SIGNAL w0.071: v1(195.26,217.02) 195.26,216.62 195.33,216.55 196.08,216.55 196.59,217.06 196.59,217.73 195.41,218.91 190.99,218.91 188.71,216.64 188.71,144.17 195.81,137.07 195.81,115.28 224.3,86.79 224.3,54.33 228.67,49.95 234.64,49.95 236.17,51.49 236.17,53.39 D123.01
  L28_SIGNAL w0.071: v1(195.26,217.02) 195.26,216.62 195.33,216.55 196.14,216.55 196.67,217.08 196.67,217.91 198.84,220.08 221.83,220.08 223.6,218.31 223.6,216.04 225.04,214.6 256.44,214.6 258.76,212.28 258.76,211.33 260.88,209.2 260.88,207.16 260.96,207.09 v1(261.36,207.09)
D12302: length 269.5
  TOP w0.086: v1(257.1,211.08) 256.65,210.62 256.65,208.9 257.04,208.51 257.04,203.68 254.95,201.59 254.95,197.86 255.03,197.78 SITE3.100
  L07_SIGNAL w0.071: v1(195.26,203.56) 195.26,203.16 195.19,203.09 193.93,203.09 190.41,199.57 190.41,182.41 191.41,181.4 191.41,142.85 198.51,135.76 198.51,122.49 226.14,94.86 226.14,66.18 230.09,62.23 237.85,62.23 238.61,61.47 238.61,60.81 D123.02
  L28_SIGNAL w0.071: v1(195.26,203.56) 195.26,203.16 195.19,203.09 193.67,203.09 192.92,202.34 192.92,201.06 193.61,200.37 213.53,200.37 215.19,202.03 225.34,202.03 228.39,198.97 237.08,198.97 239.64,201.54 254.11,201.54 256.63,204.05 256.63,211 256.7,211.08 v1(257.1,211.08)
D12303: length 299.8
  TOP w0.086: v1(260.21,207.09) 260.67,206.64 260.67,203.77 256.71,199.82 256.71,197.86 256.63,197.78 SITE3.96
  L07_SIGNAL w0.071: v1(195.26,215.88) 195.26,216.28 195.33,216.35 196.17,216.35 196.79,216.98 196.79,217.81 195.49,219.11 190.91,219.11 188.52,216.72 188.52,144.08 195.61,136.99 195.61,115.2 224.1,86.71 224.1,54.25 228.59,49.76 234.72,49.76 236.37,51.41 236.37,53.49 D123.03
  L28_SIGNAL w0.071: v1(195.26,215.88) 195.26,216.28 195.33,216.35 196.22,216.35 196.87,217 196.87,217.83 198.92,219.88 221.75,219.88 223.4,218.23 223.4,215.95 224.96,214.4 256.35,214.4 258.56,212.2 258.56,211.24 260.69,209.12 260.69,207.16 260.62,207.09 v1(260.21,207.09)
D12304: length 268.2
  TOP w0.086: SITE3.101 254.63,197.78 254.71,197.86 254.71,201.69 256.8,203.78 256.8,208.41 256.41,208.8 256.41,210.62 v1(255.96,211.08)
  L07_SIGNAL w0.071: D123.04 238.81,60.91 238.81,61.56 237.94,62.43 230.17,62.43 226.34,66.26 226.34,94.95 198.71,122.58 198.71,135.84 191.61,142.93 191.61,181.48 190.61,182.49 190.61,199.49 194.01,202.89 195.19,202.89 195.26,202.82 v1(195.26,202.42)
  L28_SIGNAL w0.071: v1(255.96,211.08) 256.36,211.08 256.43,211 256.43,204.13 254.03,201.73 239.56,201.73 237,199.17 228.47,199.17 225.42,202.23 215.1,202.23 213.45,200.57 193.69,200.57 193.12,201.14 193.12,202.26 193.75,202.89 195.19,202.89 195.26,202.82 v1(195.26,202.42)
D12305: length 316
  TOP w0.086: v1(258.99,208.83) 258.54,208.38 258.54,204.15 255.75,201.37 255.75,197.86 255.83,197.78 SITE3.98
  L07_SIGNAL w0.071: v1(181.67,217.02) 181.67,216.62 181.75,216.55 182.84,216.55 183.39,216 183.39,205.37 185.68,203.08 185.68,143.04 193.88,134.83 193.88,125.72 192.58,124.42 192.58,114.25 221.92,84.91 221.92,53.5 227.05,48.37 244.06,48.37 246.38,50.69 246.38,53.34 D123.05
  L32_SIGNAL w0.071: v1(258.99,208.83) 258.59,208.83 258.52,208.9 258.52,212.18 256.31,214.38 233.53,214.38 229.15,218.77 206.39,218.77 202.3,214.68 184.57,214.68 182.7,216.55 181.75,216.55 181.67,216.62 v1(181.67,217.02)
D12307: length 315.9
  TOP w0.086: v1(257.84,208.83) 258.3,208.38 258.3,204.25 255.51,201.47 255.51,197.86 255.43,197.78 SITE3.99
  L07_SIGNAL w0.071: v1(181.67,215.88) 181.67,216.28 181.75,216.35 182.76,216.35 183.19,215.92 183.19,205.28 185.48,202.99 185.48,142.95 193.69,134.75 193.69,125.81 192.38,124.5 192.38,114.17 221.72,84.83 221.72,53.42 226.97,48.17 244.14,48.17 246.57,50.6 246.57,53.53 D123.07
  L32_SIGNAL w0.071: v1(181.67,215.88) 181.67,216.28 181.75,216.35 182.61,216.35 184.49,214.48 202.38,214.48 206.47,218.57 229.07,218.57 233.45,214.19 256.23,214.19 258.32,212.1 258.32,208.9 258.25,208.83 v1(257.84,208.83)
D12309: length 220.8
  TOP w0.086: v1(266.32,208.6) 265.87,208.15 265.87,205.63 265.31,205.07 265.31,202.18 263.95,200.83 261.74,200.83 259.35,198.44 259.35,197.86 259.43,197.78 SITE3.89
  L07_SIGNAL w0.071: v1(276.97,158.18) 276.57,158.18 276.5,158.11 276.5,157.04 279.58,153.95 279.58,136.79 280.74,135.63 280.74,108.56 287.33,101.96 287.33,57.81 277.25,47.73 259.58,47.73 256.36,50.94 256.36,53.52 D123.09
  L28_SIGNAL w0.071: v1(266.32,208.6) 265.92,208.6 265.85,208.53 265.85,205.5 264.97,204.62 264.97,192.68 269.53,188.13 269.53,177.79 276.5,170.82 276.5,158.25 276.57,158.18 v1(276.97,158.18)
D12310: length 260
  TOP w0.086: v1(237.56,205.42) 237.11,204.97 237.11,203.7 242.55,198.26 242.55,197.86 242.63,197.78 SITE3.131
  L07_SIGNAL w0.071: v1(212.03,189.59) 212.03,189.19 211.95,189.12 210.48,189.12 206.12,184.76 206.12,145.73 215.68,136.17 215.68,126.86 239.58,102.95 259.56,102.95 261.58,104.96 275.87,104.96 281.81,99.02 281.81,68.65 275.49,62.34 259.87,62.34 258.93,61.41 258.93,60.81 D123.10
  L32_SIGNAL w0.071: v1(212.03,189.59) 212.03,189.19 211.95,189.12 211.36,189.12 210.64,189.84 210.64,190.77 212.59,192.72 225.98,192.72 228.28,195.02 231.34,195.02 237.09,200.78 237.09,205.35 237.16,205.42 v1(237.56,205.42)
D12311: length 220.2
  TOP w0.086: v1(265.18,208.6) 265.63,208.15 265.63,205.73 265.07,205.17 265.07,202.28 263.85,201.07 261.64,201.07 259.11,198.54 259.11,197.86 259.03,197.78 SITE3.90
  L07_SIGNAL w0.071: D123.11 256.56,53.36 256.56,51.03 259.66,47.93 277.17,47.93 287.14,57.9 287.14,101.88 280.54,108.48 280.54,135.55 279.39,136.71 279.39,153.87 276.3,156.96 276.3,158.11 276.23,158.18 v1(275.82,158.18)
  L28_SIGNAL w0.071: v1(265.18,208.6) 265.58,208.6 265.65,208.53 265.65,205.58 264.77,204.7 264.77,192.6 269.33,188.04 269.33,177.71 276.3,170.74 276.3,158.25 276.23,158.18 v1(275.82,158.18)
D12312: length 260.1
  TOP w0.086: SITE3.132 242.23,197.78 242.31,197.86 242.31,198.16 236.87,203.6 236.87,204.97 v1(236.42,205.42)
  L07_SIGNAL w0.071: v1(212.03,188.45) 212.03,188.85 211.95,188.92 210.56,188.92 206.31,184.67 206.31,145.81 215.88,136.25 215.88,126.94 239.67,103.15 259.48,103.15 261.49,105.16 275.95,105.16 282.01,99.11 282.01,68.57 275.57,62.14 259.95,62.14 259.13,61.32 259.13,60.91 D123.12
  L32_SIGNAL w0.071: v1(212.03,188.45) 212.03,188.85 211.95,188.92 211.28,188.92 210.44,189.76 210.44,190.85 212.51,192.92 225.9,192.92 228.2,195.22 231.25,195.22 236.89,200.86 236.89,205.35 236.82,205.42 v1(236.42,205.42)
D12313: length 236.1
  TOP w0.086: v1(228.57,197.65) 229.02,197.2 231.68,197.2 236.53,192.35 237.6,192.35 237.68,192.43 SITE3.135
  L07_SIGNAL w0.071: v1(212.28,176.13) 212.28,175.73 212.35,175.66 213.52,175.66 216.26,172.92 216.26,161.78 230.8,147.23 230.8,139.74 233.92,136.62 233.92,128.81 248.82,113.92 259.74,113.92 264.22,109.44 275.89,109.44 285.1,100.23 285.1,61.23 273.67,49.79 268.51,49.79 266.67,51.63 266.67,53.37 D123.13
  L30_SIGNAL w0.071: v1(212.28,176.13) 212.28,175.73 212.35,175.66 213.61,175.66 214.22,176.26 214.22,191.42 219.98,197.18 228.49,197.18 228.57,197.25 v1(228.57,197.65)
D12314: length 186.5
  TOP w0.086: SITE3.87 263.98,192.83 264.06,192.91 264.96,192.91 270.67,198.62 273.35,198.62 v1(273.81,198.17)
  L05_SIGNAL w0.071: v1(276.97,144.59) 276.57,144.59 276.5,144.66 276.5,145.87 276.1,146.27 273.77,146.27 273.05,145.54 273.05,133.77 274.81,132.02 274.81,121.73 282.83,113.71 282.83,69.23 275.95,62.35 269.88,62.35 269.11,61.58 269.11,60.83 D123.14
  L30_SIGNAL w0.071: v1(273.81,198.17) 273.81,198.57 273.88,198.64 278.43,198.64 279.47,197.6 279.47,144.13 278.09,142.75 277.16,142.75 276.5,143.42 276.5,144.52 276.57,144.59 v1(276.97,144.59)
D12315: length 235.1
  TOP w0.086: SITE3.136 237.68,192.03 237.6,192.11 236.43,192.11 231.58,196.96 229.02,196.96 v1(228.57,196.51)
  L07_SIGNAL w0.071: D123.15 266.87,53.51 266.87,51.71 268.59,49.99 273.59,49.99 284.91,61.31 284.91,100.15 275.81,109.24 264.14,109.24 259.66,113.72 248.74,113.72 233.72,128.73 233.72,136.53 230.6,139.65 230.6,147.15 216.06,161.7 216.06,172.84 213.44,175.46 212.35,175.46 212.28,175.39 v1(212.28,174.99)
  L30_SIGNAL w0.071: v1(228.57,196.51) 228.57,196.91 228.49,196.98 220.06,196.98 214.42,191.33 214.42,176.18 213.69,175.46 212.35,175.46 212.28,175.39 v1(212.28,174.99)
D12316: length 186.9
  TOP w0.086: SITE3.88 263.98,193.23 264.06,193.15 264.86,193.15 270.57,198.86 273.35,198.86 v1(273.81,199.31)
  L05_SIGNAL w0.071: v1(275.82,144.59) 276.23,144.59 276.3,144.66 276.3,145.79 276.02,146.07 273.86,146.07 273.25,145.46 273.25,133.85 275,132.1 275,121.81 283.02,113.79 283.02,69.15 276.03,62.16 269.97,62.16 269.31,61.5 269.31,60.89 D123.16
  L30_SIGNAL w0.071: v1(275.82,144.59) 276.23,144.59 276.3,144.52 276.3,143.33 277.08,142.56 278.17,142.56 279.67,144.05 279.67,197.68 278.51,198.84 273.88,198.84 273.81,198.91 v1(273.81,199.31)
D12901: length 302.7
  TOP w0.086: v1(228.57,257.65) 229.02,257.2 231.68,257.2 236.53,252.35 237.6,252.35 237.68,252.43 SITE1.135
  L07_SIGNAL w0.071: v1(178.5,258.17) 178.5,257.77 178.57,257.7 179.19,257.7 179.79,258.3 179.79,259.17 179.48,259.48 172.28,259.48 166.83,254.03 158.17,254.03 137.29,233.15 137.29,168.07 80.35,111.12 80.35,92.52 82.38,90.48 86.55,90.48 88.77,92.7 88.77,94.11 D129.01
  L30_SIGNAL w0.071: v1(178.5,258.17) 178.5,257.77 178.57,257.7 179.58,257.7 180.18,257.11 180.18,255.88 181.56,254.5 213.1,254.5 215.78,257.18 228.49,257.18 228.57,257.25 v1(228.57,257.65)
D12902: length 287.3
  TOP w0.086: v1(238.79,269.08) 238.34,268.63 238.34,268.16 239.3,267.2 239.3,262.62 243.35,258.57 243.35,257.86 243.43,257.78 SITE1.129
  L07_SIGNAL w0.071: D129.02 91.44,101.6 91.44,119.41 140.01,167.98 140.01,231.74 158.9,250.64 165.17,250.64 169.5,254.97 178.9,254.97 179.93,256 179.93,256.79 180.83,257.7 181.6,257.7 181.67,257.77 v1(181.67,258.17)
  L30_SIGNAL w0.071: v1(181.67,258.17) 181.67,257.77 181.75,257.7 183.4,257.7 185.88,260.18 216.2,260.18 226.39,270.37 233.38,270.37 234.31,271.3 237.47,271.3 238.32,270.46 238.32,269.16 238.39,269.08 v1(238.79,269.08)
D12903: length 304.3
  TOP w0.086: v1(228.57,256.51) 229.02,256.96 231.58,256.96 236.43,252.11 237.6,252.11 237.68,252.03 SITE1.136
  L07_SIGNAL w0.071: D129.03 88.96,94.04 88.96,92.62 86.63,90.29 82.3,90.29 80.15,92.44 80.15,111.21 137.09,168.15 137.09,233.23 158.09,254.23 166.75,254.23 172.2,259.68 179.56,259.68 179.99,259.25 179.99,258.22 179.27,257.5 178.57,257.5 178.5,257.43 v1(178.5,257.03)
  L30_SIGNAL w0.071: v1(178.5,257.03) 178.5,257.43 178.57,257.5 179.5,257.5 179.98,257.02 179.98,255.8 181.48,254.3 213.18,254.3 215.86,256.98 228.49,256.98 228.57,256.91 v1(228.57,256.51)
D12904: length 286.5
  TOP w0.086: SITE1.130 243.03,257.78 243.11,257.86 243.11,258.47 239.06,262.52 239.06,267.1 238.1,268.06 238.1,268.63 v1(237.64,269.08)
  L07_SIGNAL w0.071: D129.04 91.64,101.4 91.64,119.33 140.2,167.9 140.2,231.66 158.99,250.44 165.25,250.44 169.58,254.77 178.98,254.77 180.13,255.92 180.13,256.71 180.92,257.5 181.6,257.5 181.67,257.43 v1(181.67,257.03)
  L30_SIGNAL w0.071: v1(181.67,257.03) 181.67,257.43 181.75,257.5 183.48,257.5 185.96,259.98 216.28,259.98 226.47,270.17 233.46,270.17 234.4,271.11 237.39,271.11 238.12,270.37 238.12,269.16 238.05,269.08 v1(237.64,269.08)
D12905: length 323.2
  TOP w0.086: v1(225.81,255.53) 226.27,255.08 232.64,255.08 236.17,251.55 237.6,251.55 237.68,251.63 SITE1.137
  L07_SIGNAL w0.071: D129.05 99.05,93.99 99.05,89.47 97.1,87.52 80.15,87.52 77.88,89.78 77.88,112.62 134.35,169.09 134.35,233.52 161.05,260.22 165.7,260.22 166.56,259.36 166.56,258.35 165.9,257.7 164.98,257.7 164.91,257.77 v1(164.91,258.17)
  L28_SIGNAL w0.071: v1(164.91,258.17) 164.91,257.77 164.98,257.7 165.94,257.7 168.58,255.06 225.74,255.06 225.81,255.13 v1(225.81,255.53)
D12906: length 265.1
  TOP w0.086: v1(225.81,259.77) 226.27,259.32 231.06,259.32 237.23,253.15 237.6,253.15 237.68,253.23 SITE1.133
  L07_SIGNAL w0.071: v1(198.18,258.17) 198.18,257.77 198.11,257.7 197.21,257.7 196.6,257.09 196.6,255.84 194.18,253.42 172.11,253.42 167.91,249.22 160,249.22 142.87,232.08 142.87,166.56 101.6,125.3 101.6,101.6 D129.06
  L28_SIGNAL w0.071: v1(225.81,259.77) 225.81,259.37 225.74,259.3 220.05,259.3 218.37,260.97 202.51,260.97 199.23,257.7 198.26,257.7 198.18,257.77 v1(198.18,258.17)
D12907: length 324.7
  TOP w0.086: SITE1.138 237.68,251.23 237.6,251.31 236.07,251.31 232.55,254.84 226.27,254.84 v1(225.81,254.39)
  L07_SIGNAL w0.071: v1(164.91,257.03) 164.91,257.43 164.98,257.5 165.98,257.5 166.76,258.27 166.76,259.44 165.78,260.41 160.96,260.41 134.15,233.6 134.15,169.17 77.68,112.7 77.68,89.7 80.06,87.32 97.18,87.32 99.25,89.39 99.25,94.17 D129.07
  L28_SIGNAL w0.071: v1(164.91,257.03) 164.91,257.43 164.98,257.5 165.85,257.5 168.5,254.86 225.74,254.86 225.81,254.79 v1(225.81,254.39)
D12908: length 264.7
  TOP w0.086: SITE1.134 237.68,252.83 237.6,252.91 237.13,252.91 230.96,259.08 226.27,259.08 v1(225.81,258.63)
  L07_SIGNAL w0.071: D129.08 101.8,101.4 101.8,125.21 143.07,166.48 143.07,232 160.09,249.02 167.99,249.02 172.19,253.22 194.26,253.22 196.8,255.76 196.8,257.01 197.29,257.5 198.11,257.5 198.18,257.43 v1(198.18,257.03)
  L28_SIGNAL w0.071: v1(225.81,258.63) 225.81,259.03 225.74,259.1 219.97,259.1 218.29,260.78 202.59,260.78 199.31,257.5 198.26,257.5 198.18,257.43 v1(198.18,257.03)
D12909: length 283.7
  TOP w0.086: SITE1.140 237.68,250.43 237.6,250.35 233.96,250.35 232.03,252.28 229.02,252.28 v1(228.57,252.73)
  L07_SIGNAL w0.071: D129.09 109.15,94.05 109.15,90.81 112.25,87.71 130.97,87.71 139.23,95.96 139.23,143.17 158.87,162.81 158.87,230.84 167.76,239.74 177.93,239.74 180,241.81 180,243.56 179.58,243.98 178.57,243.98 178.5,244.05 v1(178.5,244.46)
  L30_SIGNAL w0.071: v1(178.5,244.46) 178.5,244.05 178.57,243.98 179.71,243.98 180.07,244.35 180.07,249.12 184.12,253.16 210.41,253.16 211.3,252.26 228.49,252.26 228.57,252.33 v1(228.57,252.73)
D12910: length 276.8
  TOP w0.086: v1(237.56,265.42) 237.11,264.97 237.11,263.7 242.55,258.26 242.55,257.86 242.63,257.78 SITE1.131
  L07_SIGNAL w0.071: D129.10 111.79,101.63 111.79,117.28 122.43,127.93 122.43,142.14 128.75,148.46 132.78,148.46 145.53,161.21 145.53,230.73 161.79,246.98 167.83,246.98 170.08,249.24 202.29,249.24 210.75,257.7 211.7,257.7 211.77,257.77 v1(211.77,258.17)
  L32_SIGNAL w0.071: v1(211.77,258.17) 211.77,257.77 211.7,257.7 210.95,257.7 210.35,258.3 210.35,259.37 211.98,260.99 226.33,260.99 228.7,258.62 235.89,258.62 237.09,259.82 237.09,265.35 237.16,265.42 v1(237.56,265.42)
D12911: length 282.7
  TOP w0.086: SITE1.141 237.68,250.03 237.6,250.11 233.86,250.11 231.93,252.04 229.02,252.04 v1(228.57,251.59)
  L07_SIGNAL w0.071: D129.11 109.35,94.11 109.35,90.89 112.33,87.91 130.89,87.91 139.03,96.05 139.03,143.25 158.67,162.89 158.67,230.92 167.68,239.93 177.84,239.93 179.8,241.89 179.8,243.48 179.5,243.78 178.57,243.78 178.5,243.71 v1(178.5,243.31)
  L30_SIGNAL w0.071: v1(178.5,243.31) 178.5,243.71 178.57,243.78 179.79,243.78 180.27,244.27 180.27,249.04 184.2,252.96 210.32,252.96 211.22,252.06 228.49,252.06 228.57,251.99 v1(228.57,251.59)
D12912: length 276.7
  TOP w0.086: v1(236.42,265.42) 236.87,264.97 236.87,263.6 242.31,258.16 242.31,257.86 242.23,257.78 SITE1.132
  L07_SIGNAL w0.071: D129.12 111.99,101.37 111.99,117.2 122.63,127.84 122.63,142.06 128.84,148.26 132.86,148.26 145.73,161.13 145.73,230.65 161.87,246.79 167.91,246.79 170.16,249.04 202.37,249.04 210.83,257.5 211.7,257.5 211.77,257.43 v1(211.77,257.03)
  L32_SIGNAL w0.071: v1(236.42,265.42) 236.82,265.42 236.89,265.35 236.89,259.9 235.81,258.82 228.78,258.82 226.41,261.19 211.89,261.19 210.16,259.45 210.16,258.21 210.87,257.5 211.7,257.5 211.77,257.43 v1(211.77,257.03)
D12913: length 267
  TOP w0.086: SITE1.142 237.68,249.63 237.6,249.55 233.04,249.55 232.4,250.19 226.27,250.19 v1(225.81,250.64)
  L07_SIGNAL w0.071: D129.13 119.34,94.02 119.34,92.11 121.24,90.21 128.44,90.21 135.56,97.33 135.56,143.18 156.54,164.16 156.54,230.88 166.03,240.37 166.03,243.62 165.67,243.98 164.98,243.98 164.91,244.05 v1(164.91,244.46)
  L28_SIGNAL w0.071: v1(164.91,244.46) 164.91,244.05 164.98,243.98 166.42,243.98 167.67,245.23 174.07,245.23 182.24,253.41 221.45,253.41 224.7,250.16 225.74,250.16 225.81,250.24 v1(225.81,250.64)
D12914: length 272.9
  TOP w0.086: SITE1.126 244.63,257.78 244.55,257.86 244.55,258.72 241.08,262.2 241.08,263.24 v1(241.53,263.69)
  L05_SIGNAL w0.071: D129.14 121.76,101.44 121.76,110.77 133.98,122.99 133.98,219.45 168.07,253.54 190.39,253.54 194.55,257.7 195.19,257.7 195.26,257.77 v1(195.26,258.17)
  L32_SIGNAL w0.071: v1(195.26,258.17) 195.26,257.77 195.19,257.7 193.76,257.7 193.17,257.11 193.17,256.02 194.62,254.58 213.26,254.58 215.45,256.78 225.92,256.78 227.63,255.06 235.4,255.06 241.06,260.72 241.06,263.62 241.13,263.69 v1(241.53,263.69)
D12915: length 266
  TOP w0.086: v1(225.81,249.49) 226.27,249.95 232.3,249.95 232.94,249.31 237.6,249.31 237.68,249.23 SITE1.143
  L07_SIGNAL w0.071: v1(164.91,243.31) 164.91,243.71 164.98,243.78 165.59,243.78 165.84,243.54 165.84,240.46 156.34,230.96 156.34,164.24 135.36,143.26 135.36,97.41 128.36,90.41 121.32,90.41 119.54,92.19 119.54,94.14 D129.15
  L28_SIGNAL w0.071: v1(225.81,249.49) 225.81,249.9 225.74,249.97 224.62,249.97 221.37,253.21 182.33,253.21 174.15,245.04 167.75,245.04 166.5,243.78 164.98,243.78 164.91,243.71 v1(164.91,243.31)
D12916: length 271.6
  TOP w0.086: SITE1.127 244.23,257.78 244.31,257.86 244.31,258.63 240.84,262.1 240.84,263.24 v1(240.39,263.69)
  L05_SIGNAL w0.071: D129.16 121.96,101.56 121.96,110.69 134.18,122.91 134.18,219.37 168.15,253.34 190.47,253.34 194.63,257.5 195.19,257.5 195.26,257.43 v1(195.26,257.03)
  L32_SIGNAL w0.071: v1(240.39,263.69) 240.79,263.69 240.86,263.62 240.86,260.81 235.31,255.26 227.71,255.26 226,256.97 215.37,256.97 213.17,254.78 194.7,254.78 193.37,256.1 193.37,257.03 193.85,257.5 195.19,257.5 195.26,257.43 v1(195.26,257.03)
D13101: length 352.8
  TOP w0.086: SITE1.16 248.23,231.48 248.15,231.4 248.15,223.49 249.52,222.12 249.52,219.77 v1(249.98,219.32)
  L03_SIGNAL w0.071: v1(164.91,215.88) 164.91,216.28 164.84,216.35 160.27,216.35 144.96,201.04 96.07,201.04 79.98,184.96 79.98,55.22 84.51,50.7 87.72,50.7 88.87,51.85 88.87,53.37 D131.01
  L28_SIGNAL w0.071: v1(249.98,219.32) 249.57,219.32 249.5,219.24 249.5,217.26 247.75,215.51 226.52,215.51 225.63,216.39 225.63,217.92 221.97,221.58 171.92,221.58 166.7,216.35 164.98,216.35 164.91,216.28 v1(164.91,215.88)
D13102: length 330.6
  TOP w0.086: v1(247.8,222.06) 247.35,222.51 247.35,231.4 247.43,231.48 SITE1.14
  L03_SIGNAL w0.071: v1(178.5,215.88) 178.5,216.28 178.57,216.35 179.23,216.35 179.84,215.74 179.84,214.75 177.71,212.62 159.73,212.62 146.83,199.72 122.22,199.72 116.2,193.7 93.31,193.7 82.27,182.66 82.27,73.31 91.31,64.26 91.31,60.83 D131.02
  L30_SIGNAL w0.071: v1(178.5,215.88) 178.5,216.28 178.57,216.35 179.56,216.35 180.27,217.07 180.27,217.98 182.11,219.82 224.15,219.82 226.17,217.8 246.84,217.8 247.33,218.29 247.33,221.99 247.4,222.06 v1(247.8,222.06)
D13103: length 353.4
  TOP w0.086: SITE1.15 247.83,231.48 247.91,231.4 247.91,223.39 249.28,222.02 249.28,219.77 v1(248.83,219.32)
  L03_SIGNAL w0.071: D131.03 89.07,53.51 89.07,51.77 87.8,50.5 84.43,50.5 79.78,55.14 79.78,185.04 95.99,201.24 144.87,201.24 160.18,216.55 164.84,216.55 164.91,216.62 v1(164.91,217.02)
  L28_SIGNAL w0.071: v1(248.83,219.32) 249.23,219.32 249.3,219.24 249.3,217.35 247.67,215.71 226.6,215.71 225.83,216.48 225.83,218.01 222.06,221.78 171.84,221.78 166.61,216.55 164.98,216.55 164.91,216.62 v1(164.91,217.02)
D13104: length 330.7
  TOP w0.086: SITE1.13 247.03,231.48 247.11,231.4 247.11,222.51 v1(246.66,222.06)
  L03_SIGNAL w0.071: v1(178.5,217.02) 178.5,216.62 178.57,216.55 179.31,216.55 180.04,215.82 180.04,214.67 177.79,212.42 159.81,212.42 146.92,199.53 122.3,199.53 116.28,193.51 93.39,193.51 82.46,182.58 82.46,73.39 91.51,64.34 91.51,60.89 D131.04
  L30_SIGNAL w0.071: v1(178.5,217.02) 178.5,216.62 178.57,216.55 179.48,216.55 180.08,217.15 180.08,218.07 182.03,220.02 224.23,220.02 226.26,217.99 246.75,217.99 247.13,218.37 247.13,221.99 247.06,222.06 v1(246.66,222.06)
D13113: length 292.2
  TOP w0.086: SITE1.170 237.68,238.43 237.6,238.51 228.05,238.51 v1(227.59,238.06)
  L03_SIGNAL w0.071: D131.13 119.27,53.45 119.27,51.93 120.23,50.97 127.3,50.97 133.66,57.32 133.66,170.24 161.31,197.89 180.82,197.89 188.03,205.1 188.03,228.59 196.91,237.47 196.91,243.18 197.51,243.78 198.37,243.78 198.44,243.71 v1(198.44,243.31)
  L28_SIGNAL w0.071: v1(198.44,243.31) 198.44,243.71 198.51,243.78 199.75,243.78 202.62,240.91 222.71,240.91 225.09,238.53 227.52,238.53 227.59,238.46 v1(227.59,238.06)
D13114: length 300.2
  TOP w0.086: v1(246.02,219.32) 245.57,219.77 245.57,226.86 246.55,227.84 246.55,231.4 246.63,231.48 SITE1.12
  L03_SIGNAL w0.071: v1(181.67,229.6) 181.67,230 181.75,230.07 182.5,230.07 185.99,226.58 185.99,214.12 177.33,205.47 157.96,205.47 131.5,179.01 131.5,74.15 121.87,64.51 121.87,60.91 D131.14
  L28_SIGNAL w0.071: v1(181.67,229.6) 181.67,230 181.75,230.07 182.64,230.07 187.44,225.27 220.21,225.27 227.47,218.01 234.85,218.01 236.38,216.48 244.32,216.48 245.55,217.71 245.55,219.24 245.62,219.32 v1(246.02,219.32)
D13115: length 291.9
  TOP w0.086: SITE1.169 237.68,238.83 237.6,238.75 228.05,238.75 v1(227.59,239.2)
  L03_SIGNAL w0.071: v1(198.44,244.46) 198.44,244.05 198.37,243.98 197.43,243.98 196.71,243.26 196.71,237.55 187.83,228.67 187.83,205.19 180.74,198.09 161.22,198.09 133.46,170.33 133.46,57.4 127.22,51.17 120.31,51.17 119.47,52.01 119.47,53.43 D131.15
  L28_SIGNAL w0.071: v1(227.59,239.2) 227.59,238.8 227.52,238.73 225.17,238.73 222.79,241.11 202.71,241.11 199.83,243.98 198.51,243.98 198.44,244.05 v1(198.44,244.46)
D13116: length 300.2
  TOP w0.086: v1(244.88,219.32) 245.33,219.77 245.33,226.96 246.31,227.94 246.31,231.4 246.23,231.48 SITE1.11
  L03_SIGNAL w0.071: v1(181.67,230.74) 181.67,230.34 181.75,230.27 182.58,230.27 186.19,226.66 186.19,214.04 177.42,205.27 158.04,205.27 131.7,178.93 131.7,74.06 122.07,64.43 122.07,60.81 D131.16
  L28_SIGNAL w0.071: v1(244.88,219.32) 245.28,219.32 245.35,219.24 245.35,217.8 244.23,216.68 236.46,216.68 234.93,218.21 227.56,218.21 220.3,225.47 187.52,225.47 182.72,230.27 181.75,230.27 181.67,230.34 v1(181.67,230.74)
D13201: length 410.1
  TOP w0.086: v1(230.98,236.32) 231.43,236.77 232.68,236.77 233.62,237.71 237.6,237.71 237.68,237.63 SITE1.172
  L03_SIGNAL w0.071: v1(195.26,243.31) 195.26,243.71 195.19,243.78 194.27,243.78 191.67,241.19 130.35,241.19 127.04,244.5 92.14,244.5 60.14,212.49 60.14,45.57 77.59,28.11 86.59,28.11 88.79,30.31 88.79,33.13 D132.01
  L30_SIGNAL w0.071: v1(195.26,243.31) 195.26,243.71 195.33,243.78 196.41,243.78 196.73,243.46 196.73,242.65 198.47,240.91 209.39,240.91 212.95,237.35 223.14,237.35 223.7,236.79 230.91,236.79 230.98,236.72 v1(230.98,236.32)
D13202: length 379.9
  TOP w0.086: SITE1.174 237.68,236.83 237.6,236.91 234.63,236.91 232.6,234.88 228.05,234.88 v1(227.59,234.42)
  L03_SIGNAL w0.071: D132.02 91.33,40.53 91.33,41.98 89.9,43.41 81.28,43.41 74.13,50.57 74.13,216.48 94.91,237.26 129.81,237.26 132.66,234.41 165.29,234.41 166.65,233.05 166.65,231.01 165.71,230.07 164.98,230.07 164.91,230 v1(164.91,229.6)
  L32_SIGNAL w0.071: v1(227.59,234.42) 227.59,234.83 227.52,234.9 226.14,234.9 224.29,233.05 224.29,231.78 222.45,229.94 215.27,229.94 213.11,232.1 167.79,232.1 165.76,230.07 164.98,230.07 164.91,230 v1(164.91,229.6)
D13203: length 411.1
  TOP w0.086: SITE1.171 237.68,238.03 237.6,237.95 233.52,237.95 232.58,237.01 231.43,237.01 v1(230.98,237.46)
  L03_SIGNAL w0.071: D132.03 88.98,33.1 88.98,30.23 86.67,27.91 77.51,27.91 59.94,45.49 59.94,212.57 92.06,244.69 127.12,244.69 130.43,241.38 191.59,241.38 194.19,243.98 195.19,243.98 195.26,244.05 v1(195.26,244.46)
  L30_SIGNAL w0.071: v1(195.26,244.46) 195.26,244.05 195.33,243.98 196.49,243.98 196.93,243.54 196.93,242.73 198.56,241.1 209.47,241.1 213.03,237.55 223.22,237.55 223.78,236.99 230.91,236.99 230.98,237.06 v1(230.98,237.46)
D13204: length 378.9
  TOP w0.086: v1(227.59,235.57) 228.05,235.12 232.5,235.12 234.53,237.15 237.6,237.15 237.68,237.23 SITE1.173
  L03_SIGNAL w0.071: v1(164.91,230.74) 164.91,230.34 164.98,230.27 165.63,230.27 166.45,231.09 166.45,232.97 165.21,234.21 132.58,234.21 129.72,237.07 95,237.07 74.32,216.39 74.32,50.65 81.36,43.61 89.98,43.61 91.53,42.06 91.53,40.55 D132.04
  L32_SIGNAL w0.071: v1(227.59,235.57) 227.59,235.17 227.52,235.1 226.05,235.1 224.09,233.13 224.09,231.86 222.37,230.14 215.35,230.14 213.19,232.3 167.7,232.3 165.68,230.27 164.98,230.27 164.91,230.34 v1(164.91,230.74)
D13205: length 438.1
  TOP w0.086: SITE1.176 237.68,236.03 237.6,236.11 236.22,236.11 232.94,232.83 231.43,232.83 v1(230.98,232.38)
  L03_SIGNAL w0.071: v1(181.67,243.31) 181.67,243.71 181.6,243.78 180.71,243.78 180.13,244.36 180.13,245.71 179.16,246.69 130.7,246.69 129.99,245.98 88.22,245.98 56.47,214.24 56.47,43.5 75.34,24.63 95.66,24.63 99.05,28.02 99.05,33.03 D132.05
  L32_SIGNAL w0.071: v1(181.67,243.31) 181.67,243.71 181.75,243.78 183.11,243.78 186.04,240.85 208.23,240.85 211.71,237.37 223.48,237.37 224.1,236.75 228.08,236.75 229,235.83 229,233.65 229.79,232.85 230.91,232.85 230.98,232.78 v1(230.98,232.38)
D13206: length 369.2
  TOP w0.086: v1(227.59,229.94) 228.05,230.39 241.9,230.39 242.55,231.04 242.55,231.4 242.63,231.48 SITE1.2
  L03_SIGNAL w0.071: v1(178.5,229.6) 178.5,230 178.57,230.07 179.38,230.07 179.92,229.53 179.92,228.93 178.58,227.59 159.21,227.59 156.9,225.28 148.75,225.28 132.1,208.62 87,208.62 77.14,198.77 77.14,53.65 84.63,46.16 99.18,46.16 101.39,43.95 101.39,40.43 D132.06
  L32_SIGNAL w0.071: v1(227.59,229.94) 227.59,230.34 227.52,230.41 226.49,230.41 222.68,226.6 182.07,226.6 179.96,228.71 179.96,229.63 179.52,230.07 178.57,230.07 178.5,230 v1(178.5,229.6)
D13207: length 439
  TOP w0.086: v1(230.98,233.52) 231.43,233.07 232.84,233.07 236.12,236.35 237.6,236.35 237.68,236.43 SITE1.175
  L03_SIGNAL w0.071: v1(181.67,244.46) 181.67,244.05 181.6,243.98 180.79,243.98 180.33,244.44 180.33,245.79 179.24,246.89 130.61,246.89 129.91,246.18 88.13,246.18 56.27,214.32 56.27,43.42 75.26,24.44 95.74,24.44 99.24,27.94 99.24,33.2 D132.07
  L32_SIGNAL w0.071: v1(230.98,233.52) 230.98,233.12 230.91,233.05 229.88,233.05 229.2,233.73 229.2,235.91 228.16,236.95 224.18,236.95 223.56,237.57 211.79,237.57 208.31,241.05 186.13,241.05 183.19,243.98 181.75,243.98 181.67,244.05 v1(181.67,244.46)
D13208: length 369.2
  TOP w0.086: v1(227.59,231.08) 228.05,230.63 241.8,230.63 242.31,231.14 242.31,231.4 242.23,231.48 SITE1.1
  L03_SIGNAL w0.071: v1(178.5,230.74) 178.5,230.34 178.57,230.27 179.47,230.27 180.12,229.61 180.12,228.85 178.66,227.39 159.29,227.39 156.98,225.08 148.84,225.08 132.18,208.43 87.08,208.43 77.34,198.68 77.34,53.73 84.72,46.36 99.26,46.36 101.58,44.03 101.58,40.66 D132.08
  L32_SIGNAL w0.071: v1(178.5,230.74) 178.5,230.34 178.57,230.27 179.6,230.27 180.15,229.71 180.15,228.8 182.15,226.8 222.6,226.8 226.41,230.61 227.52,230.61 227.59,230.68 v1(227.59,231.08)
D13209: length 324.4
  TOP w0.086: SITE1.6 244.23,231.48 244.15,231.4 244.15,230.57 239.24,225.66 239.24,222.51 v1(239.69,222.06)
  L03_SIGNAL w0.071: v1(212.03,229.6) 212.03,230 211.95,230.07 210.77,230.07 203.32,222.62 203.32,203.25 183.21,183.14 183.21,175.42 179.35,171.56 168.45,171.56 140.01,143.12 140.01,34.31 130.46,24.76 114.04,24.76 109.14,29.66 109.14,33.1 D132.09
  L30_SIGNAL w0.071: v1(239.69,222.06) 239.29,222.06 239.22,221.99 239.22,220.8 237.97,219.55 228.32,219.55 221.32,226.56 217.22,226.56 213.71,230.07 212.1,230.07 212.03,230 v1(212.03,229.6)
D13210: length 302.7
  TOP w0.086: v1(230.98,240.03) 231.43,240.48 232.18,240.48 233.36,239.31 237.6,239.31 237.68,239.23 SITE1.168
  L03_SIGNAL w0.071: D132.10 111.57,40.45 111.57,42.83 115.21,46.47 125.74,46.47 135.16,55.88 135.16,164.43 162.02,191.3 175.29,191.3 189.34,205.35 189.34,228.11 207.22,245.99 213.12,245.99 213.66,245.45 213.66,244.35 213.1,243.78 212.1,243.78 212.03,243.71 v1(212.03,243.31)
  L30_SIGNAL w0.071: v1(230.98,240.03) 230.98,240.43 230.91,240.51 217.13,240.51 213.85,243.78 212.1,243.78 212.03,243.71 v1(212.03,243.31)
D13211: length 323.8
  TOP w0.086: v1(238.55,222.06) 239,222.51 239,225.76 243.91,230.67 243.91,231.4 243.83,231.48 SITE1.5
  L03_SIGNAL w0.071: D132.11 109.34,33.14 109.34,29.74 114.12,24.96 130.38,24.96 139.81,34.39 139.81,143.2 168.37,171.76 179.27,171.76 183.01,175.5 183.01,183.22 203.13,203.34 203.13,222.7 210.69,230.27 211.95,230.27 212.03,230.34 v1(212.03,230.74)
  L30_SIGNAL w0.071: v1(238.55,222.06) 238.95,222.06 239.02,221.99 239.02,220.88 237.89,219.75 228.41,219.75 221.4,226.75 217.31,226.75 213.79,230.27 212.1,230.27 212.03,230.34 v1(212.03,230.74)
D13212: length 301.8
  TOP w0.086: v1(230.98,241.18) 231.43,240.72 232.28,240.72 233.45,239.55 237.6,239.55 237.68,239.63 SITE1.167
  L03_SIGNAL w0.071: D132.12 111.77,40.63 111.77,42.74 115.3,46.27 125.82,46.27 135.35,55.8 135.35,164.35 162.11,191.1 175.37,191.1 189.53,205.27 189.53,228.03 207.3,245.79 213.04,245.79 213.46,245.37 213.46,244.43 213.01,243.98 212.1,243.98 212.03,244.05 v1(212.03,244.46)
  L30_SIGNAL w0.071: v1(230.98,241.18) 230.98,240.77 230.91,240.7 217.21,240.7 213.93,243.98 212.1,243.98 212.03,244.05 v1(212.03,244.46)
D13213: length 324.7
  TOP w0.086: v1(241.88,219.32) 241.42,219.77 241.42,226.55 244.95,230.08 244.95,231.4 245.03,231.48 SITE1.8
  L03_SIGNAL w0.071: D132.13 119.38,33.02 119.38,31.3 122.08,28.6 129.85,28.6 138.5,37.25 138.5,143.6 168.65,173.75 172.05,173.75 190.73,192.42 190.73,197.21 194.08,200.57 194.08,204.74 200.21,210.87 200.21,231.91 199.74,232.38 197.17,232.38 196.67,231.87 196.67,230.97 197.57,230.07 198.37,230.07 198.44,230 v1(198.44,229.6)
  L28_SIGNAL w0.071: v1(241.88,219.32) 241.47,219.32 241.4,219.24 241.4,218.21 240.73,217.54 236.97,217.54 235.35,219.16 228.33,219.16 221.14,226.35 203.69,226.35 199.97,230.07 198.51,230.07 198.44,230 v1(198.44,229.6)
D13214: length 297
  TOP w0.086: v1(244.03,222.06) 243.58,222.51 243.58,226.78 245.75,228.95 245.75,231.4 245.83,231.48 SITE1.10
  L03_SIGNAL w0.071: D132.14 121.75,40.47 121.75,42.08 124.38,44.71 127.06,44.71 136.84,54.49 136.84,151.75 165.92,180.83 168.25,180.83 169.49,182.08 169.49,184.11 190.65,205.27 190.65,217.62 196.6,223.58 196.6,229.55 196.09,230.07 195.33,230.07 195.26,230 v1(195.26,229.6)
  L30_SIGNAL w0.071: v1(195.26,229.6) 195.26,230 195.33,230.07 196.45,230.07 196.65,229.86 196.65,228.9 200.38,225.16 221.09,225.16 227.55,218.69 238.71,218.69 240.23,220.21 242.73,220.21 243.56,221.03 243.56,221.99 243.63,222.06 v1(244.03,222.06)
D13215: length 322.6
  TOP w0.086: SITE1.7 244.63,231.48 244.71,231.4 244.71,230.18 241.18,226.65 241.18,219.77 v1(240.73,219.32)
  L03_SIGNAL w0.071: v1(198.44,230.74) 198.44,230.34 198.37,230.27 197.65,230.27 196.87,231.05 196.87,231.79 197.25,232.18 199.66,232.18 200.01,231.83 200.01,210.96 193.88,204.83 193.88,200.65 190.53,197.29 190.53,192.5 171.97,173.94 168.57,173.94 138.3,143.68 138.3,37.33 129.77,28.8 122.16,28.8 119.57,31.38 119.57,33.21 D132.15
  L28_SIGNAL w0.071: v1(198.44,230.74) 198.44,230.34 198.51,230.27 200.06,230.27 203.78,226.55 221.22,226.55 228.41,219.36 235.43,219.36 237.05,217.74 240.65,217.74 241.2,218.29 241.2,219.24 241.13,219.32 v1(240.73,219.32)
D13216: length 297
  TOP w0.086: SITE1.9 245.43,231.48 245.51,231.4 245.51,229.05 243.34,226.88 243.34,222.51 v1(242.89,222.06)
  L03_SIGNAL w0.071: v1(195.26,230.74) 195.26,230.34 195.33,230.27 196.17,230.27 196.8,229.63 196.8,223.49 190.85,217.54 190.85,205.19 169.69,184.03 169.69,181.99 168.33,180.63 166,180.63 137.04,151.67 137.04,54.41 127.14,44.51 124.46,44.51 121.95,42 121.95,40.61 D132.16
  L30_SIGNAL w0.071: v1(195.26,230.74) 195.26,230.34 195.33,230.27 196.53,230.27 196.85,229.95 196.85,228.98 200.47,225.36 221.17,225.36 227.64,218.89 238.63,218.89 240.14,220.4 242.65,220.4 243.36,221.12 243.36,221.99 243.29,222.06 v1(242.89,222.06)
D30102: length 192.4
  TOP w0.147: D301.02 312.01,91.03 arc(312.17,91.27) 312.23,91.55 312.23,121.52 arc(312.18,121.76) 312.04,121.97 arc(311.63,122.25) 311.14,122.34 arc(310.63,122.24) 310.2,121.95 arc(310.05,121.72) 309.99,121.45 309.99,97.48 arc(309.9,97.01) 309.63,96.61 arc(309.04,96.22) 308.34,96.08 arc(307.63,96.22) 307.03,96.62 307.03,96.62 arc(306.75,97.03) 306.66,97.52 306.66,125.17 arc(306.74,125.57) 306.96,125.91 307.69,126.63 arc(308.03,126.86) 308.43,126.94 328.08,126.94 arc(328.21,126.97) 328.32,127.04 333.1,131.82 arc(333.18,131.93) 333.2,132.06 333.2,142.3 arc(333.18,142.43) 333.1,142.54 331.36,144.29 arc(331.25,144.36) 331.11,144.39 317.99,144.39 arc(317.71,144.44) 317.47,144.6 316.41,145.66 arc(316.25,145.9) 316.2,146.19 316.2,150.19 arc(316.25,150.47) 316.41,150.71 317.76,152.05 arc(317.99,152.21) 318.28,152.27 329.95,152.27 arc(330.08,152.3) 330.19,152.37 332.13,154.31 arc(332.21,154.42) 332.23,154.55 332.23,171.32 332.23,171.33 SITE4.26
D30104: length 192.4
  TOP w0.147: SITE4.27 332.63,171.33 332.63,171.32 332.63,154.55 arc(332.57,154.27) 332.41,154.03 330.47,152.09 arc(330.23,151.93) 329.95,151.87 318.28,151.87 arc(318.15,151.85) 318.04,151.77 316.69,150.43 arc(316.62,150.32) 316.59,150.19 316.59,146.19 arc(316.62,146.06) 316.69,145.94 317.75,144.88 arc(317.86,144.81) 317.99,144.79 331.11,144.79 arc(331.4,144.73) 331.64,144.57 333.38,142.82 arc(333.54,142.58) 333.6,142.3 333.6,132.06 arc(333.54,131.78) 333.38,131.54 328.6,126.76 arc(328.36,126.6) 328.08,126.54 308.43,126.54 arc(308.18,126.49) 307.97,126.35 307.24,125.63 arc(307.1,125.42) 307.05,125.17 307.05,97.52 arc(307.12,97.18) 307.31,96.9 307.31,96.9 arc(307.78,96.59) 308.34,96.47 arc(308.89,96.58) 309.35,96.89 arc(309.53,97.16) 309.6,97.48 309.6,121.45 arc(309.68,121.88) 309.92,122.23 arc(310.48,122.61) 311.14,122.74 arc(311.78,122.61) 312.32,122.25 arc(312.55,121.92) 312.62,121.52 312.62,91.54 arc(312.68,91.26) 312.84,91.02 D301.04
D30106: length 192.4
  TOP w0.147: SITE4.29 333.43,171.33 333.43,171.32 333.43,167.53 arc(333.49,167.25) 333.65,167.01 334.49,166.17 arc(334.56,166.06) 334.59,165.93 334.59,153.75 arc(334.56,153.62) 334.49,153.51 330.97,149.99 arc(330.86,149.91) 330.73,149.89 319.51,149.89 arc(319.23,149.83) 318.99,149.67 318.65,149.33 arc(318.49,149.09) 318.43,148.81 318.43,147.63 arc(318.49,147.35) 318.65,147.11 319.13,146.62 arc(319.37,146.46) 319.65,146.41 334.45,146.41 arc(334.58,146.38) 334.69,146.31 335.73,145.27 arc(335.8,145.16) 335.83,145.03 335.83,130.74 arc(335.8,130.61) 335.73,130.5 328.83,123.6 arc(328.67,123.36) 328.61,123.08 328.61,95.93 arc(328.56,95.65) 328.4,95.41 arc(327.96,95.12) 327.43,95.01 327.21,95.01 arc(326.69,95.11) 326.26,95.41 arc(326.1,95.64) 326.05,95.92 326.05,122.75 arc(325.99,123.04) 325.83,123.28 325.16,123.95 arc(324.92,124.11) 324.64,124.16 323.67,124.16 arc(323.39,124.11) 323.15,123.95 322.62,123.41 arc(322.46,123.17) 322.4,122.89 322.4,101.37 arc(322.37,101.24) 322.3,101.13 321.51,100.34 arc(321.4,100.27) 321.27,100.24 316.62,100.24 arc(316.14,100.15) 315.74,99.88 arc(315.23,99.12) 315.05,98.22 arc(315.24,97.31) 315.75,96.53 315.76,96.53 arc(316.17,96.25) 316.66,96.15 321.32,96.15 arc(321.73,96.07) 322.08,95.84 arc(322.32,95.49) 322.4,95.07 322.4,91.57 arc(322.34,91.28) 322.18,91.04 D301.06
D30108: length 192.4
  TOP w0.147: D301.08 323.01,91.01 arc(322.85,91.25) 322.8,91.53 322.8,95.07 arc(322.68,95.64) 322.36,96.12 arc(321.88,96.44) 321.32,96.55 316.66,96.55 arc(316.32,96.62) 316.04,96.81 316.03,96.81 arc(315.6,97.46) 315.45,98.22 arc(315.6,98.97) 316.02,99.6 arc(316.3,99.78) 316.62,99.85 321.27,99.85 arc(321.55,99.9) 321.79,100.06 322.58,100.85 arc(322.74,101.09) 322.8,101.37 322.8,122.89 arc(322.82,123.02) 322.9,123.13 323.43,123.67 arc(323.54,123.74) 323.67,123.77 324.64,123.77 arc(324.77,123.74) 324.88,123.67 325.55,123 arc(325.62,122.88) 325.65,122.75 325.65,95.92 arc(325.73,95.49) 325.98,95.13 arc(326.54,94.75) 327.21,94.61 327.44,94.61 arc(328.11,94.75) 328.68,95.13 arc(328.92,95.5) 329.01,95.93 329.01,123.08 arc(329.04,123.21) 329.11,123.32 336.01,130.22 arc(336.17,130.46) 336.22,130.74 336.22,145.03 arc(336.17,145.31) 336.01,145.55 334.97,146.59 arc(334.73,146.75) 334.45,146.8 319.65,146.8 arc(319.52,146.83) 319.41,146.9 318.93,147.39 arc(318.85,147.5) 318.83,147.63 318.83,148.81 arc(318.85,148.94) 318.93,149.05 319.27,149.39 arc(319.38,149.46) 319.51,149.49 330.73,149.49 arc(331.01,149.55) 331.25,149.7 334.77,153.23 arc(334.93,153.47) 334.99,153.75 334.99,165.93 arc(334.93,166.21) 334.77,166.45 333.93,167.29 arc(333.85,167.4) 333.83,167.53 333.83,171.32 333.83,171.33 SITE4.30
D30110: length 192.4
  TOP w0.147: SITE4.32 334.63,171.33 334.63,171.32 334.63,169.65 arc(334.69,169.37) 334.85,169.13 338.31,165.66 arc(338.39,165.55) 338.41,165.42 338.41,161.32 arc(338.45,161.12) 338.57,160.94 343.71,155.8 arc(343.95,155.64) 344.23,155.58 352.97,155.58 arc(353.1,155.56) 353.21,155.48 353.54,155.16 arc(353.61,155.04) 353.64,154.91 353.64,154.22 arc(353.62,154.12) 353.56,154.03 353.28,153.75 arc(353.17,153.68) 353.04,153.65 339.37,153.65 arc(339.09,153.6) 338.85,153.44 338.47,153.06 arc(338.31,152.81) 338.25,152.52 338.25,151.88 arc(338.31,151.59) 338.47,151.34 338.84,150.97 arc(339.08,150.81) 339.36,150.76 346.77,150.76 arc(347.04,150.7) 347.27,150.55 347.27,150.55 arc(347.52,150.17) 347.61,149.73 arc(347.52,149.29) 347.28,148.92 347.23,148.87 arc(347,148.72) 346.73,148.67 340.97,148.67 arc(340.69,148.61) 340.45,148.45 338.39,146.4 arc(338.23,146.16) 338.18,145.87 338.18,95.57 arc(338.12,95.28) 337.95,95.03 arc(337.43,94.68) 336.81,94.56 arc(336.26,94.67) 335.8,94.98 arc(335.67,95.17) 335.62,95.4 335.62,123.36 arc(335.54,123.76) 335.32,124.1 335.31,124.1 arc(334.75,124.48) 334.09,124.61 arc(333.41,124.48) 332.84,124.09 arc(332.6,123.73) 332.52,123.31 332.52,91.52 arc(332.46,91.24) 332.3,91 D301.10
D30112: length 192.4
  TOP w0.147: SITE4.33 335.03,171.33 335.03,171.32 335.03,169.65 arc(335.05,169.52) 335.13,169.41 338.59,165.94 arc(338.75,165.71) 338.81,165.42 338.81,161.32 arc(338.82,161.27) 338.85,161.22 343.99,156.08 arc(344.1,156) 344.23,155.98 352.97,155.98 arc(353.25,155.92) 353.49,155.76 353.82,155.44 arc(353.98,155.2) 354.04,154.91 354.04,154.22 arc(353.99,153.97) 353.84,153.75 353.7,153.61 353.56,153.47 arc(353.32,153.31) 353.04,153.26 339.37,153.26 arc(339.24,153.23) 339.13,153.16 338.76,152.78 arc(338.67,152.66) 338.65,152.52 338.65,151.88 arc(338.67,151.74) 338.76,151.62 339.12,151.25 arc(339.23,151.18) 339.36,151.15 346.77,151.15 arc(347.2,151.07) 347.55,150.83 arc(347.89,150.33) 348.01,149.73 arc(347.89,149.14) 347.56,148.64 347.51,148.59 arc(347.15,148.35) 346.73,148.27 340.97,148.27 arc(340.84,148.24) 340.73,148.17 338.67,146.11 arc(338.6,146) 338.57,145.87 338.57,95.57 arc(338.49,95.13) 338.23,94.75 arc(337.58,94.31) 336.81,94.16 arc(336.11,94.3) 335.52,94.7 arc(335.3,95.02) 335.23,95.4 335.23,123.36 arc(335.18,123.61) 335.03,123.82 arc(334.6,124.11) 334.09,124.21 arc(333.57,124.11) 333.12,123.81 arc(332.97,123.58) 332.91,123.31 332.91,91.57 arc(332.97,91.29) 333.13,91.05 D301.12
D30114: length 192.4
  TOP w0.147: D301.14 342.47,91.01 arc(342.63,91.25) 342.69,91.53 342.69,123.33 arc(342.77,123.77) 343.03,124.15 arc(343.62,124.54) 344.32,124.68 344.49,124.68 arc(345.18,124.55) 345.77,124.15 345.77,124.15 arc(346.02,123.79) 346.1,123.35 346.1,94.29 arc(346.13,94.16) 346.2,94.05 346.55,93.71 arc(346.99,93.41) 347.5,93.31 arc(348.02,93.41) 348.46,93.71 348.75,93.99 348.75,94 arc(348.83,94.11) 348.85,94.24 348.85,126.09 arc(348.79,126.41) 348.61,126.68 348.61,126.68 arc(348.34,126.86) 348.02,126.92 342.13,126.92 arc(341.62,127.02) 341.19,127.31 341.19,127.31 arc(340.91,127.74) 340.81,128.25 340.81,141.92 arc(340.86,142.2) 341.02,142.44 341.88,143.3 arc(342.12,143.46) 342.4,143.52 348.48,143.52 arc(348.61,143.55) 348.72,143.62 357.43,152.33 arc(357.67,152.49) 357.95,152.54 360.91,152.54 arc(361.04,152.57) 361.15,152.64 361.66,153.15 arc(361.73,153.27) 361.76,153.4 361.76,156.72 arc(361.73,156.85) 361.66,156.96 360.89,157.73 arc(360.78,157.8) 360.65,157.83 346.49,157.83 arc(346.21,157.89) 345.97,158.05 341.02,162.99 arc(340.86,163.23) 340.81,163.51 340.81,165.84 arc(340.78,165.97) 340.71,166.08 335.83,170.95 335.83,171.32 335.83,171.33 SITE4.35
D30116: length 192.4
  TOP w0.147: D301.16 343.3,91.04 arc(343.14,91.28) 343.08,91.56 343.08,123.33 arc(343.14,123.62) 343.31,123.87 343.31,123.87 arc(343.77,124.18) 344.32,124.29 344.49,124.29 arc(345.03,124.18) 345.49,123.87 345.49,123.87 arc(345.65,123.63) 345.71,123.35 345.71,94.29 arc(345.76,94.01) 345.92,93.77 346.27,93.43 arc(346.83,93.05) 347.5,92.91 arc(348.17,93.05) 348.74,93.43 349.03,93.71 arc(349.19,93.95) 349.25,94.24 349.25,126.09 arc(349.15,126.56) 348.89,126.96 arc(348.49,127.23) 348.02,127.32 342.13,127.32 arc(341.77,127.39) 341.47,127.59 341.47,127.59 arc(341.27,127.89) 341.2,128.25 341.2,141.92 arc(341.23,142.05) 341.3,142.16 342.16,143.02 arc(342.27,143.1) 342.4,143.12 348.48,143.12 arc(348.77,143.18) 349.01,143.34 357.71,152.05 arc(357.82,152.12) 357.95,152.15 360.91,152.15 arc(361.19,152.2) 361.43,152.36 361.94,152.87 arc(362.1,153.11) 362.15,153.4 362.15,156.72 arc(362.1,157) 361.94,157.24 361.17,158.01 arc(360.93,158.17) 360.65,158.23 346.49,158.23 arc(346.36,158.25) 346.25,158.33 341.3,163.27 arc(341.23,163.38) 341.2,163.51 341.2,165.84 arc(341.15,166.12) 340.99,166.36 336.23,171.12 336.23,171.32 336.23,171.33 SITE4.36
D30502: length 192.4
  TOP w0.147: D305.02 385.64,91 arc(385.8,91.24) 385.85,91.52 385.85,93.61 arc(385.91,93.89) 386.07,94.13 387.38,95.44 arc(387.62,95.6) 387.9,95.66 394.19,95.66 arc(394.41,95.7) 394.59,95.82 395.29,96.52 arc(395.79,97.27) 395.96,98.15 395.96,98.15 arc(395.74,99.27) 395.1,100.22 394.75,100.58 arc(394.36,100.84) 393.91,100.93 387.5,100.93 arc(387.22,100.98) 386.98,101.14 386.16,101.96 arc(386,102.2) 385.95,102.48 385.95,118.01 arc(385.92,118.14) 385.85,118.25 370.44,133.66 arc(370.28,133.9) 370.22,134.19 370.22,149.87 arc(370.2,150) 370.12,150.11 363.58,156.66 arc(363.42,156.9) 363.36,157.18 363.36,203.61 arc(363.34,203.74) 363.26,203.86 355.51,211.61 arc(355.46,211.64) 355.4,211.66 340.76,211.66 arc(340.09,211.79) 339.52,212.17 332.45,219.24 arc(332.29,219.48) 332.23,219.76 332.23,231.32 332.23,231.33 SITE2.26
D30504: length 192.4
  TOP w0.147: SITE2.27 332.63,231.33 332.63,231.32 332.63,219.76 arc(332.65,219.63) 332.73,219.52 339.8,212.45 arc(340.24,212.16) 340.76,212.05 355.4,212.05 arc(355.61,212.01) 355.79,211.89 363.54,204.14 arc(363.7,203.9) 363.76,203.61 363.76,157.18 arc(363.78,157.05) 363.86,156.94 370.4,150.39 arc(370.56,150.16) 370.62,149.87 370.62,134.19 arc(370.64,134.05) 370.72,133.94 386.13,118.53 arc(386.29,118.29) 386.34,118.01 386.34,102.48 arc(386.37,102.35) 386.44,102.24 387.26,101.42 arc(387.37,101.35) 387.5,101.32 393.91,101.32 arc(394.52,101.2) 395.03,100.86 395.38,100.51 arc(396.11,99.43) 396.36,98.15 396.36,98.15 arc(396.15,97.12) 395.57,96.24 394.87,95.54 arc(394.56,95.34) 394.19,95.26 387.9,95.26 arc(387.77,95.24) 387.66,95.16 386.35,93.85 arc(386.28,93.74) 386.25,93.61 386.25,91.57 arc(386.31,91.29) 386.47,91.05 D305.04
D30506: length 192.4
  TOP w0.147: SITE2.29 333.43,231.33 333.43,231.32 333.43,221.42 arc(333.49,221.14) 333.65,220.9 340.55,213.99 arc(340.79,213.83) 341.07,213.78 355.94,213.78 arc(356.07,213.75) 356.18,213.68 365.46,204.4 arc(365.54,204.29) 365.56,204.16 365.56,158.21 arc(365.62,157.93) 365.78,157.69 372.97,150.5 arc(373.04,150.39) 373.07,150.26 373.07,134.17 arc(373.12,133.89) 373.28,133.65 395.84,111.09 arc(395.92,110.98) 395.94,110.85 395.94,103.3 arc(396,103.02) 396.16,102.78 398.21,100.73 arc(398.45,100.57) 398.73,100.52 402.65,100.52 arc(403.24,100.4) 403.74,100.07 arc(404.31,99.21) 404.51,98.2 404.51,97.73 arc(404.38,97.08) 404.01,96.52 403.43,95.95 arc(403.23,95.81) 403,95.77 398.42,95.77 arc(398.14,95.71) 397.9,95.55 396.23,93.88 arc(396.07,93.64) 396.01,93.35 396.01,91.52 arc(395.96,91.24) 395.8,91 D305.06
D30508: length 192.4
  TOP w0.147: D305.08 396.63,91.05 arc(396.47,91.29) 396.41,91.58 396.41,93.35 arc(396.44,93.48) 396.51,93.6 398.18,95.27 arc(398.29,95.34) 398.42,95.37 403,95.37 arc(403.39,95.45) 403.71,95.67 404.29,96.24 arc(404.75,96.93) 404.91,97.73 404.91,98.2 arc(404.68,99.36) 404.02,100.35 404.02,100.35 arc(403.39,100.76) 402.65,100.91 398.73,100.91 arc(398.6,100.94) 398.49,101.01 396.44,103.06 arc(396.37,103.17) 396.34,103.3 396.34,110.85 arc(396.28,111.13) 396.12,111.37 373.56,133.93 arc(373.49,134.04) 373.46,134.17 373.46,150.26 arc(373.41,150.54) 373.25,150.78 366.06,157.97 arc(365.98,158.08) 365.96,158.21 365.96,204.16 arc(365.9,204.44) 365.74,204.68 356.46,213.96 arc(356.22,214.12) 355.94,214.17 341.07,214.17 arc(340.94,214.2) 340.83,214.27 333.93,221.18 arc(333.85,221.29) 333.83,221.42 333.83,231.32 333.83,231.33 SITE2.30
D30510: length 192.4
  TOP w0.147: SITE2.32 334.63,231.33 334.63,231.32 334.63,229.76 arc(334.69,229.47) 334.85,229.24 338.3,225.79 arc(338.37,225.67) 338.4,225.54 338.4,219.84 arc(338.45,219.56) 338.61,219.32 342.01,215.92 arc(342.25,215.76) 342.53,215.7 357.87,215.7 arc(358,215.68) 358.11,215.6 367.82,205.89 arc(367.9,205.78) 367.92,205.65 367.92,159.78 arc(367.98,159.49) 368.14,159.26 375.88,151.51 arc(375.95,151.4) 375.98,151.27 375.98,133.97 arc(376.04,133.68) 376.2,133.44 406.02,103.62 arc(406.09,103.51) 406.12,103.38 406.12,101.65 arc(406.17,101.37) 406.33,101.13 407.18,100.28 arc(407.42,100.12) 407.7,100.07 410.32,100.07 arc(410.82,99.97) 411.24,99.69 arc(411.82,98.82) 412.03,97.79 412.03,97.79 arc(411.86,96.94) 411.38,96.22 arc(411.11,96.04) 410.79,95.97 407.86,95.97 arc(407.55,95.91) 407.29,95.74 406.42,94.87 arc(406.25,94.61) 406.19,94.3 406.19,91.53 arc(406.13,91.25) 405.97,91.01 D305.10
D30512: length 192.4
  TOP w0.147: SITE2.33 335.03,231.33 335.03,231.32 335.03,229.76 arc(335.05,229.63) 335.13,229.52 338.58,226.07 arc(338.74,225.83) 338.79,225.54 338.79,219.84 arc(338.82,219.71) 338.89,219.6 342.29,216.2 arc(342.4,216.12) 342.53,216.1 357.87,216.1 arc(358.15,216.04) 358.39,215.88 368.1,206.17 arc(368.26,205.93) 368.32,205.65 368.32,159.78 arc(368.35,159.65) 368.42,159.54 376.16,151.79 arc(376.32,151.56) 376.38,151.27 376.38,133.97 arc(376.4,133.84) 376.48,133.72 406.3,103.9 arc(406.46,103.67) 406.51,103.38 406.51,101.65 arc(406.54,101.52) 406.61,101.41 407.46,100.56 arc(407.57,100.49) 407.7,100.46 410.32,100.46 arc(410.97,100.34) 411.52,99.97 411.52,99.97 arc(412.19,98.97) 412.42,97.79 412.42,97.79 arc(412.22,96.79) 411.66,95.94 arc(411.26,95.67) 410.79,95.58 407.86,95.58 arc(407.7,95.55) 407.57,95.46 406.71,94.59 arc(406.61,94.46) 406.58,94.3 406.58,91.56 arc(406.64,91.28) 406.8,91.04 D305.12
D30514: length 192.4
  TOP w0.147: SITE2.35 335.83,231.33 335.83,231.32 335.83,230.95 340.67,226.11 arc(340.75,226) 340.77,225.87 340.77,220.87 arc(340.83,220.59) 340.99,220.35 343.49,217.85 arc(343.73,217.69) 344.01,217.63 359.3,217.63 arc(359.44,217.61) 359.55,217.53 370.26,206.82 arc(370.33,206.71) 370.36,206.58 370.36,161.11 arc(370.41,160.82) 370.57,160.58 378.75,152.41 arc(378.82,152.3) 378.85,152.17 378.85,133.76 arc(378.9,133.48) 379.06,133.24 385.97,126.33 arc(386.21,126.17) 386.49,126.11 393.9,126.11 arc(394.7,125.95) 395.38,125.5 415.74,105.14 arc(416.2,104.46) 416.36,103.65 416.36,91.54 arc(416.3,91.26) 416.14,91.02 D305.14
D30516: length 192.4
  TOP w0.147: D305.16 416.97,91.03 arc(416.81,91.27) 416.76,91.55 416.76,103.65 arc(416.57,104.61) 416.03,105.42 395.66,125.78 arc(394.86,126.32) 393.9,126.51 386.49,126.51 arc(386.36,126.54) 386.25,126.61 379.34,133.52 arc(379.27,133.63) 379.24,133.76 379.24,152.17 arc(379.19,152.45) 379.03,152.69 370.85,160.86 arc(370.78,160.98) 370.75,161.11 370.75,206.58 arc(370.7,206.86) 370.54,207.1 359.83,217.81 arc(359.59,217.97) 359.3,218.03 344.01,218.03 arc(343.88,218.05) 343.77,218.13 341.27,220.63 arc(341.2,220.74) 341.17,220.87 341.17,225.87 arc(341.11,226.15) 340.95,226.39 336.23,231.12 336.23,231.32 336.23,231.33 SITE2.36
D31702: length 192.4
  TOP w0.147: D317.02 164.7,91.04 arc(164.86,91.27) 164.91,91.56 164.91,95.29 arc(164.89,95.42) 164.81,95.53 164.03,96.32 arc(163.91,96.39) 163.78,96.42 157,96.42 arc(156.71,96.47) 156.47,96.63 155.8,97.31 arc(155.07,98.39) 154.82,99.67 arc(155.13,101.25) 156.03,102.59 156.08,102.64 arc(156.58,102.97) 157.16,103.09 163.5,103.09 arc(163.63,103.11) 163.74,103.19 164.81,104.26 arc(164.89,104.37) 164.91,104.5 164.91,105.59 arc(164.89,105.72) 164.81,105.83 163.8,106.84 arc(163.69,106.91) 163.56,106.94 157.81,106.94 arc(157.52,107) 157.29,107.15 155.37,109.07 arc(155.21,109.31) 155.15,109.59 155.15,125.04 arc(155.21,125.32) 155.37,125.56 156.82,127.02 arc(157.06,127.18) 157.34,127.23 192.08,127.23 arc(192.21,127.26) 192.32,127.33 201.84,136.86 arc(202.08,137.01) 202.36,137.07 223.86,137.07 arc(223.99,137.1) 224.1,137.17 228.16,141.23 arc(228.23,141.34) 228.26,141.47 228.26,147.03 arc(228.31,147.31) 228.47,147.55 232.83,151.91 arc(233.05,152.06) 233.3,152.11 249.72,152.11 arc(249.88,152.14) 250.01,152.23 252.13,154.35 arc(252.21,154.46) 252.23,154.59 252.23,171.32 252.23,171.33 SITE3.26
D31704: length 192.4
  TOP w0.147: D317.04 165.52,91.02 arc(165.36,91.26) 165.31,91.54 165.31,95.29 arc(165.25,95.57) 165.09,95.81 164.31,96.6 arc(164.07,96.76) 163.78,96.81 157,96.81 arc(156.86,96.84) 156.75,96.91 156.08,97.59 arc(155.44,98.54) 155.22,99.67 arc(155.5,101.1) 156.31,102.31 156.36,102.36 arc(156.73,102.61) 157.16,102.69 163.5,102.69 arc(163.78,102.75) 164.02,102.91 165.09,103.98 arc(165.25,104.22) 165.31,104.5 165.31,105.59 arc(165.25,105.87) 165.09,106.11 164.08,107.12 arc(163.84,107.28) 163.56,107.34 157.81,107.34 arc(157.68,107.36) 157.57,107.44 155.65,109.35 arc(155.58,109.46) 155.55,109.59 155.55,125.04 arc(155.58,125.17) 155.65,125.28 157.1,126.73 arc(157.21,126.81) 157.34,126.83 192.08,126.83 arc(192.36,126.89) 192.6,127.05 202.12,136.58 arc(202.23,136.65) 202.36,136.67 223.86,136.67 arc(224.14,136.73) 224.38,136.89 228.44,140.95 arc(228.6,141.18) 228.65,141.47 228.65,147.03 arc(228.68,147.16) 228.75,147.27 233.11,151.63 arc(233.2,151.69) 233.3,151.71 249.72,151.71 arc(250.03,151.77) 250.29,151.95 252.41,154.07 arc(252.57,154.31) 252.63,154.59 252.63,171.32 252.63,171.33 SITE3.27
