# Allegro board 8880F5-0827_updates.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D11414: length 139.7
  TOP w0.086: SITE1.122 246.23,257.78 246.15,257.86 246.15,260.53 244.65,262.03 244.65,263.24 v1(245.11,263.69)
  L05_SIGNAL w0.071: v1(238.87,285.81) 238.47,285.81 238.4,285.89 238.4,287.1 294.41,343.12 309.57,343.12 312.69,346.25 312.69,348.25 D114.14
  L32_SIGNAL w0.071: v1(238.87,285.81) 238.47,285.81 238.4,285.74 238.4,282.79 243.29,277.9 243.29,267.68 244.63,266.34 244.63,263.76 244.7,263.69 v1(245.11,263.69)
D11415: length 158.5
  TOP w0.086: v1(240.97,269.08) 241.43,268.63 241.43,266.04 242.63,264.83 242.63,262.03 245.11,259.55 245.11,257.86 245.03,257.78 SITE1.125
  L05_SIGNAL w0.071: v1(237.72,299.4) 238.13,299.4 238.2,299.33 238.2,298.3 238.67,297.83 244.82,297.83 272.61,325.62 274.68,325.62 307.97,358.9 313.23,358.9 314.77,357.36 314.77,355.41 D114.15
  L28_SIGNAL w0.071: v1(240.97,269.08) 241.37,269.08 241.45,269.16 241.45,273.91 236.1,279.26 236.1,295.73 238.2,297.83 238.2,299.33 238.13,299.4 v1(237.72,299.4)
D11416: length 139.8
  TOP w0.086: SITE1.123 245.83,257.78 245.91,257.86 245.91,260.44 244.42,261.93 244.42,263.24 v1(243.96,263.69)
  L05_SIGNAL w0.071: v1(237.72,285.81) 238.13,285.81 238.2,285.89 238.2,287.19 294.33,343.32 309.49,343.32 312.5,346.33 312.5,347.9 D114.16
  L32_SIGNAL w0.071: v1(243.96,263.69) 244.36,263.69 244.44,263.76 244.44,266.25 243.1,267.59 243.1,277.81 238.2,282.71 238.2,285.74 238.13,285.81 v1(237.72,285.81)
D11501: length 230.3
  TOP w0.086: v1(258.99,268.83) 258.54,268.38 258.54,264.15 255.75,261.37 255.75,257.86 255.83,257.78 SITE1.98
  L07_SIGNAL w0.071: D115.01 345.38,375.98 345.38,378.43 346,379.06 348.4,379.06 361.67,365.8 361.67,306.17 347.46,291.96 301.68,291.96 297.04,287.32 297.04,286.14 296.97,286.07 v1(296.56,286.07)
  L32_SIGNAL w0.071: v1(296.56,286.07) 296.97,286.07 297.04,286.14 297.04,286.94 296.51,287.46 288.59,287.46 284.43,283.3 262.59,283.3 258.52,279.23 258.52,268.9 258.59,268.83 v1(258.99,268.83)
D11502: length 201.8
  TOP w0.086: v1(266.32,268.6) 265.87,268.15 265.87,265.63 265.31,265.07 265.31,262.18 263.95,260.83 261.74,260.83 259.35,258.44 259.35,257.86 259.43,257.78 SITE1.89
  L07_SIGNAL w0.071: v1(287.38,282.89) 286.98,282.89 286.91,282.96 286.91,284.43 289.68,287.21 293.5,287.21 300.07,293.78 336.85,293.78 359.8,316.73 359.8,360.17 353.55,366.43 344.47,366.43 343.18,367.72 343.18,368.58 D115.02
  L28_SIGNAL w0.071: v1(287.38,282.89) 286.98,282.89 286.91,282.82 286.91,281.08 276.72,270.89 266.94,270.89 265.85,269.79 265.85,268.68 265.92,268.6 v1(266.32,268.6)
D11503: length 231.4
  TOP w0.086: v1(257.84,268.83) 258.3,268.38 258.3,264.25 255.51,261.47 255.51,257.86 255.43,257.78 SITE1.99
  L07_SIGNAL w0.071: v1(297.71,286.07) 297.31,286.07 297.23,286.14 297.23,287.24 301.76,291.76 347.54,291.76 361.86,306.08 361.86,365.88 348.49,379.25 345.92,379.25 345.18,378.52 345.18,375.66 D115.03
  L32_SIGNAL w0.071: v1(297.71,286.07) 297.31,286.07 297.23,286.14 297.23,287.02 296.6,287.66 288.5,287.66 284.35,283.5 262.5,283.5 258.32,279.31 258.32,268.9 258.25,268.83 v1(257.84,268.83)
D11504: length 201.9
  TOP w0.086: SITE1.90 259.03,257.78 259.11,257.86 259.11,258.53 261.64,261.07 263.85,261.07 265.07,262.28 265.07,265.17 265.63,265.73 265.63,268.15 v1(265.18,268.6)
  L07_SIGNAL w0.071: v1(286.24,282.89) 286.64,282.89 286.71,282.96 286.71,284.51 289.6,287.4 293.41,287.4 299.98,293.97 336.77,293.97 359.61,316.82 359.61,360.09 353.47,366.23 344.39,366.23 342.98,367.64 342.98,368.22 D115.04
  L28_SIGNAL w0.071: v1(286.24,282.89) 286.64,282.89 286.71,282.82 286.71,281.16 276.64,271.09 266.86,271.09 265.65,269.87 265.65,268.68 265.58,268.6 v1(265.18,268.6)
D11505: length 240.7
  TOP w0.086: SITE1.93 257.83,257.78 257.75,257.86 257.75,259.44 262.61,264.3 262.61,268.15 v1(263.07,268.6)
  L07_SIGNAL w0.071: v1(309.77,286.07) 310.17,286.07 310.24,286.14 310.24,287.34 313.59,290.69 348.69,290.69 363.6,305.6 363.6,366.14 348.51,381.23 337.76,381.23 335.36,378.83 335.36,375.84 D115.05
  L32_SIGNAL w0.071: v1(309.77,286.07) 310.17,286.07 310.24,286.14 310.24,287.35 309.92,287.68 309.11,287.68 300.24,278.81 300.24,274.84 295.99,270.59 263.41,270.59 262.59,269.77 262.59,268.68 262.66,268.6 v1(263.07,268.6)
D11506: length 216.3
  TOP w0.086: SITE1.91 258.63,257.78 258.55,257.86 258.55,259 261.27,261.72 263.16,261.72 264.22,262.77 264.22,265.88 v1(264.67,266.34)
  L07_SIGNAL w0.071: v1(309.77,299.66) 310.17,299.66 310.24,299.58 310.24,299.05 311.23,298.07 316.01,298.07 327.54,309.6 345.76,309.6 357.55,321.39 357.55,357.94 352.1,363.38 335.35,363.38 332.9,365.83 332.9,368.46 D115.06
  L30_SIGNAL w0.071: v1(309.77,299.66) 310.17,299.66 310.24,299.73 310.24,301.03 309.17,302.11 304.39,302.11 296.28,294 287.47,294 277.04,283.57 266.13,283.57 262.89,280.33 262.89,271.36 264.2,270.05 264.2,266.41 264.27,266.34 v1(264.67,266.34)
D11507: length 242
  TOP w0.086: v1(261.92,268.6) 262.37,268.15 262.37,264.4 257.51,259.54 257.51,257.86 257.43,257.78 SITE1.94
  L07_SIGNAL w0.071: D115.07 335.16,375.8 335.16,378.91 337.68,381.42 348.6,381.42 363.79,366.23 363.79,305.52 348.77,290.5 313.68,290.5 310.44,287.26 310.44,286.14 310.51,286.07 v1(310.92,286.07)
  L32_SIGNAL w0.071: v1(310.92,286.07) 310.51,286.07 310.44,286.14 310.44,287.44 310,287.87 309.03,287.87 300.04,278.89 300.04,274.92 295.91,270.79 263.33,270.79 262.39,269.85 262.39,268.68 262.32,268.6 v1(261.92,268.6)
D11508: length 216.4
  TOP w0.086: SITE1.92 258.23,257.78 258.31,257.86 258.31,259.1 261.17,261.96 263.07,261.96 263.98,262.87 263.98,265.88 v1(263.52,266.34)
  L07_SIGNAL w0.071: v1(310.92,299.66) 310.51,299.66 310.44,299.58 310.44,299.13 311.31,298.27 315.92,298.27 327.46,309.8 345.67,309.8 357.35,321.47 357.35,357.85 352.02,363.18 335.26,363.18 332.7,365.75 332.7,368.34 D115.08
  L30_SIGNAL w0.071: v1(263.52,266.34) 263.93,266.34 264,266.41 264,269.97 262.69,271.28 262.69,280.41 266.04,283.76 276.96,283.76 287.39,294.2 296.2,294.2 304.31,302.3 309.25,302.3 310.44,301.11 310.44,299.73 310.51,299.66 v1(310.92,299.66)
D11601: length 255.6
  TOP w0.086: SITE2.133 317.68,253.23 317.6,253.15 317.23,253.15 311.06,259.32 306.27,259.32 v1(305.81,259.77)
  L07_SIGNAL w0.071: v1(375.56,286.32) 375.96,286.32 376.03,286.39 376.03,287.3 380.25,291.52 380.25,304.07 374.32,310.01 374.32,383.96 359.03,399.25 346.37,399.25 345.46,398.34 345.46,396.22 D116.01
  L28_SIGNAL w0.071: v1(305.81,259.77) 305.81,259.37 305.74,259.3 304.38,259.3 303.92,259.76 303.92,264.9 321.07,282.05 341.09,282.05 352.41,293.37 370.54,293.37 376.03,287.88 376.03,286.39 375.96,286.32 v1(375.56,286.32)
D11602: length 222.2
  TOP w0.086: v1(317.56,265.42) 317.11,264.97 317.11,263.7 322.55,258.26 322.55,257.86 322.63,257.78 SITE2.131
  L07_SIGNAL w0.071: v1(375.56,299.91) 375.96,299.91 376.03,299.84 376.03,299.23 375.54,298.74 374.73,298.74 374.35,299.12 374.35,304.56 372.27,306.64 372.27,379.36 364.69,386.94 344,386.94 342.9,388.04 342.9,388.62 D116.02
  L32_SIGNAL w0.071: v1(317.56,265.42) 317.16,265.42 317.09,265.49 317.09,267.46 315.97,268.58 315.97,275.67 320.62,280.33 350.03,280.33 352.68,282.98 352.68,290.26 365.11,302.69 374.57,302.69 376.03,301.23 376.03,299.98 375.96,299.91 v1(375.56,299.91)
D11603: length 257.2
  TOP w0.086: SITE2.134 317.68,252.83 317.6,252.91 317.13,252.91 310.96,259.08 306.27,259.08 v1(305.81,258.63)
  L07_SIGNAL w0.071: v1(376.7,286.32) 376.3,286.32 376.23,286.39 376.23,287.22 380.45,291.44 380.45,304.16 374.51,310.09 374.51,384.05 359.11,399.45 346.29,399.45 345.26,398.42 345.26,396.06 D116.03
  L28_SIGNAL w0.071: v1(305.81,258.63) 305.81,259.03 305.74,259.1 304.29,259.1 303.72,259.67 303.72,264.98 320.99,282.25 341.01,282.25 352.33,293.57 370.62,293.57 376.23,287.96 376.23,286.39 376.3,286.32 v1(376.7,286.32)
D11604: length 223.4
  TOP w0.086: SITE2.132 322.23,257.78 322.31,257.86 322.31,258.16 316.87,263.6 316.87,264.97 v1(316.42,265.42)
  L07_SIGNAL w0.071: D116.04 342.7,388.82 342.7,387.95 343.92,386.74 364.61,386.74 372.07,379.28 372.07,306.56 374.15,304.48 374.15,299.04 374.64,298.54 375.62,298.54 376.23,299.15 376.23,299.84 376.3,299.91 v1(376.7,299.91)
  L32_SIGNAL w0.071: v1(376.7,299.91) 376.3,299.91 376.23,299.98 376.23,301.31 374.66,302.89 365.03,302.89 352.48,290.34 352.48,283.06 349.95,280.52 320.54,280.52 315.77,275.76 315.77,268.5 316.89,267.38 316.89,265.49 316.82,265.42 v1(316.42,265.42)
D11605: length 284.2
  TOP w0.086: SITE2.129 323.43,257.78 323.35,257.86 323.35,258.57 319.3,262.62 319.3,267.2 318.34,268.16 318.34,268.63 v1(318.79,269.08)
  L07_SIGNAL w0.071: v1(402.48,286.32) 402.88,286.32 402.95,286.39 402.95,286.81 401.05,288.72 401.05,289.93 376,314.97 376,385.69 358.74,402.95 340.97,402.95 335.33,397.31 335.33,396.19 D116.05
  L30_SIGNAL w0.071: v1(318.79,269.08) 318.39,269.08 318.32,269.16 318.32,276.39 325.43,283.5 330.06,283.5 339.32,292.76 398.1,292.76 402.95,287.9 402.95,286.39 402.88,286.32 v1(402.48,286.32)
D11606: length 277.7
  TOP w0.086: v1(337.1,271.07) 336.65,270.62 336.65,268.9 337.04,268.51 337.04,263.68 334.95,261.59 334.95,257.86 335.03,257.78 SITE2.100
  L07_SIGNAL w0.071: v1(402.48,283.91) 402.88,283.91 402.95,283.84 402.95,282.74 399.89,279.68 375.67,279.68 373.11,282.23 373.11,299.14 370.61,301.64 370.61,378.03 363.01,385.62 334.91,385.62 332.68,387.86 332.68,388.56 D116.06
  L28_SIGNAL w0.071: v1(337.1,271.07) 336.7,271.07 336.63,271 336.63,270.66 336.94,270.35 337.83,270.35 342.54,275.06 352.38,275.06 364.74,262.69 377.78,262.69 390.14,275.06 395.62,275.06 402.95,282.39 402.95,283.84 402.88,283.91 v1(402.48,283.91)
D11607: length 285.5
  TOP w0.086: SITE2.130 323.03,257.78 323.11,257.86 323.11,258.47 319.06,262.52 319.06,267.1 318.1,268.06 318.1,268.63 v1(317.64,269.08)
  L07_SIGNAL w0.071: D116.07 335.13,396.09 335.13,397.39 340.89,403.15 358.82,403.15 376.2,385.77 376.2,315.06 401.25,290.01 401.25,288.8 403.15,286.89 403.15,286.39 403.22,286.32 v1(403.63,286.32)
  L30_SIGNAL w0.071: v1(317.64,269.08) 318.05,269.08 318.12,269.16 318.12,276.47 325.35,283.7 329.98,283.7 339.24,292.96 398.18,292.96 403.15,287.98 403.15,286.39 403.22,286.32 v1(403.63,286.32)
D11608: length 278.8
  TOP w0.086: SITE2.101 334.63,257.78 334.71,257.86 334.71,261.69 336.8,263.78 336.8,268.41 336.41,268.8 336.41,270.62 v1(335.96,271.07)
  L07_SIGNAL w0.071: D116.08 332.48,388.88 332.48,387.78 334.83,385.43 362.93,385.43 370.41,377.95 370.41,301.56 372.91,299.06 372.91,282.15 375.58,279.48 399.98,279.48 403.15,282.66 403.15,283.84 403.22,283.91 v1(403.63,283.91)
  L28_SIGNAL w0.071: v1(403.63,283.91) 403.22,283.91 403.15,283.84 403.15,282.31 395.7,274.86 390.23,274.86 377.86,262.49 364.66,262.49 352.29,274.86 342.62,274.86 337.91,270.15 336.86,270.15 336.43,270.58 336.43,271 336.36,271.07 v1(335.96,271.07)
D11609: length 290
  TOP w0.086: v1(346.32,268.6) 345.87,268.15 345.87,265.63 345.31,265.07 345.31,262.18 343.95,260.83 341.74,260.83 339.35,258.44 339.35,257.86 339.43,257.78 SITE2.89
  L07_SIGNAL w0.071: v1(375.3,254.32) 375.71,254.32 375.78,254.39 375.78,255.42 381.7,261.34 393.92,261.34 397.63,265.05 397.63,273.28 406.02,281.67 406.02,291.36 377.66,319.72 377.66,386.7 359.42,404.95 331.81,404.95 325.28,398.42 325.28,396.08 D116.09
  L28_SIGNAL w0.071: v1(375.3,254.32) 375.71,254.32 375.78,254.39 375.78,255.75 372.34,259.18 364.47,259.18 352.23,271.42 347.23,271.42 345.85,270.04 345.85,268.68 345.92,268.6 v1(346.32,268.6)
D11610: length 303
  TOP w0.086: SITE2.135 317.68,252.43 317.6,252.35 316.53,252.35 311.68,257.2 309.02,257.2 v1(308.57,257.65)
  L07_SIGNAL w0.071: v1(389.02,251.9) 389.42,251.9 389.49,251.83 389.49,251 388.72,250.23 374.48,250.23 370.93,253.78 370.93,298.87 369.07,300.73 369.07,375.76 360.81,384.01 325.89,384.01 322.49,387.41 322.49,388.53 D116.10
  L30_SIGNAL w0.071: v1(389.02,251.9) 389.42,251.9 389.49,251.83 389.49,250.52 385.38,246.41 357.48,246.41 355.37,248.51 349.49,248.51 340.83,257.18 308.64,257.18 308.57,257.25 v1(308.57,257.65)
D11611: length 291.4
  TOP w0.086: v1(345.18,268.6) 345.63,268.15 345.63,265.73 345.07,265.17 345.07,262.28 343.85,261.07 341.64,261.07 339.11,258.53 339.11,257.86 339.03,257.78 SITE2.90
  L07_SIGNAL w0.071: v1(376.45,254.32) 376.05,254.32 375.97,254.39 375.97,255.34 381.78,261.14 394.01,261.14 397.83,264.97 397.83,273.2 406.22,281.59 406.22,291.44 377.86,319.8 377.86,386.78 359.5,405.14 331.72,405.14 325.08,398.5 325.08,396.2 D116.11
  L28_SIGNAL w0.071: v1(376.45,254.32) 376.05,254.32 375.97,254.39 375.97,255.83 372.42,259.38 364.55,259.38 352.31,271.62 347.15,271.62 345.65,270.13 345.65,268.68 345.58,268.6 v1(345.18,268.6)
D11612: length 303.8
  TOP w0.086: SITE2.136 317.68,252.03 317.6,252.11 316.43,252.11 311.58,256.96 309.02,256.96 v1(308.57,256.51)
  L07_SIGNAL w0.071: D116.12 322.3,388.9 322.3,387.33 325.81,383.81 360.73,383.81 368.87,375.68 368.87,300.65 370.73,298.78 370.73,253.7 374.4,250.03 388.81,250.03 389.69,250.92 389.69,251.83 389.76,251.9 v1(390.16,251.9)
  L30_SIGNAL w0.071: v1(308.57,256.51) 308.57,256.91 308.64,256.98 340.75,256.98 349.41,248.32 355.29,248.32 357.39,246.21 385.46,246.21 389.69,250.44 389.69,251.83 389.76,251.9 v1(390.16,251.9)
D11613: length 306.1
  TOP w0.086: SITE2.102 334.23,257.78 334.15,257.86 334.15,261.95 335.98,263.78 335.98,268.13 334.78,269.33 v1(334.78,269.97)
  L07_SIGNAL w0.071: v1(402.48,270.32) 402.88,270.32 402.95,270.39 402.95,271.6 407.89,276.54 407.89,297.8 379.36,326.33 379.36,387.57 359.6,407.33 323.26,407.33 315.07,399.14 315.07,396.13 D116.13
  L32_SIGNAL w0.071: v1(402.48,270.32) 402.88,270.32 402.95,270.39 402.95,271.6 399.72,274.84 335.88,274.84 333.58,272.53 333.58,270.51 334.4,269.69 334.5,269.69 v1(334.78,269.97)
D11615: length 307.3
  TOP w0.086: v1(333.98,269.17) 334.61,269.17 335.74,268.03 335.74,263.88 333.91,262.05 333.91,257.86 333.83,257.78 SITE2.103
  L07_SIGNAL w0.071: v1(403.63,270.32) 403.22,270.32 403.15,270.39 403.15,271.52 408.09,276.45 408.09,297.88 379.56,326.41 379.56,387.65 359.68,407.52 323.17,407.52 314.87,399.22 314.87,396.15 D116.15
  L32_SIGNAL w0.071: v1(403.63,270.32) 403.22,270.32 403.15,270.39 403.15,271.69 399.81,275.04 335.8,275.04 333.38,272.62 333.38,270.43 334.26,269.55 334.26,269.45 v1(333.98,269.17)
D11801: length 245.2
  TOP w0.086: v1(247.41,211.17) 246.96,210.72 246.96,208.41 248.55,206.82 248.55,197.86 248.63,197.78 SITE3.116
  L05_SIGNAL w0.071: v1(178.5,203.56) 178.5,203.16 178.57,203.09 179.47,203.09 180.08,202.48 180.08,195.78 170.37,186.07 170.37,130.5 171.18,129.69 171.18,127.05 170.07,125.94 170.07,117.5 168.49,115.92 168.49,111.65 164.53,107.69 164.53,104.74 154.77,94.98 154.77,74.59 156.99,72.38 161.76,72.38 162.51,73.13 162.51,73.71 D118.01
  L28_SIGNAL w0.071: v1(178.5,203.56) 178.5,203.16 178.57,203.09 179.49,203.09 180.07,203.67 180.07,204.48 181.84,206.25 222.99,206.25 227.53,210.79 232.89,210.79 234.8,212.7 246.26,212.7 246.94,212.03 246.94,211.24 247.01,211.17 v1(247.41,211.17)
D11802: length 216.5
  TOP w0.086: SITE3.126 244.63,197.78 244.55,197.86 244.55,198.73 241.08,202.2 241.08,203.24 v1(241.53,203.69)
  L05_SIGNAL w0.071: D118.02 165.04,81.22 165.04,81.6 164.11,82.53 158.9,82.53 157.71,83.72 157.71,93.45 167.42,103.16 167.42,107.12 171.22,110.92 171.22,121.84 173.64,124.27 173.64,130.02 172.31,131.35 172.31,184.51 176.92,189.12 178.43,189.12 178.5,189.19 v1(178.5,189.59)
  L32_SIGNAL w0.071: v1(241.53,203.69) 241.13,203.69 241.06,203.62 241.06,198.23 233.22,190.38 228.99,190.38 226.43,187.82 223.8,187.82 222.83,188.79 217.71,188.79 215.9,186.98 177.62,186.98 177.04,187.55 177.04,188.59 177.58,189.12 178.43,189.12 178.5,189.19 v1(178.5,189.59)
D11803: length 245.1
  TOP w0.086: SITE3.117 248.23,197.78 248.31,197.86 248.31,206.72 246.72,208.31 246.72,210.72 v1(246.26,211.17)
  L05_SIGNAL w0.071: D118.03 162.71,73.81 162.71,73.05 161.84,72.18 156.9,72.18 154.57,74.51 154.57,95.06 164.33,104.82 164.33,107.77 168.29,111.73 168.29,116 169.87,117.59 169.87,126.03 170.98,127.13 170.98,129.61 170.17,130.41 170.17,186.15 179.88,195.86 179.88,202.4 179.39,202.89 178.57,202.89 178.5,202.82 v1(178.5,202.42)
  L28_SIGNAL w0.071: v1(246.26,211.17) 246.67,211.17 246.74,211.24 246.74,211.95 246.18,212.51 234.88,212.51 232.97,210.59 227.61,210.59 223.07,206.05 181.92,206.05 180.27,204.4 180.27,203.59 179.57,202.89 178.57,202.89 178.5,202.82 v1(178.5,202.42)
D11804: length 215.2
  TOP w0.086: v1(240.39,203.69) 240.84,203.24 240.84,202.1 244.31,198.63 244.31,197.86 244.23,197.78 SITE3.127
  L05_SIGNAL w0.071: D118.04 165.24,81.14 165.24,81.68 164.2,82.73 158.98,82.73 157.91,83.8 157.91,93.37 167.62,103.08 167.62,107.04 171.41,110.83 171.41,121.76 173.84,124.18 173.84,130.1 172.51,131.43 172.51,184.43 177,188.92 178.43,188.92 178.5,188.85 v1(178.5,188.45)
  L32_SIGNAL w0.071: v1(178.5,188.45) 178.5,188.85 178.43,188.92 177.66,188.92 177.24,188.5 177.24,187.63 177.7,187.18 215.82,187.18 217.63,188.98 222.92,188.98 223.88,188.02 226.34,188.02 228.91,190.58 233.13,190.58 240.86,198.31 240.86,203.62 240.79,203.69 v1(240.39,203.69)
D11805: length 215.9
  TOP w0.086: SITE3.142 237.68,189.63 237.6,189.55 233.04,189.55 232.4,190.19 226.27,190.19 v1(225.81,190.64)
  L07_SIGNAL w0.071: v1(164.91,162.67) 164.91,162.27 164.98,162.2 165.72,162.2 166.11,161.8 166.11,160.77 143.69,138.35 143.69,84.81 156.12,72.38 172.11,72.38 172.63,72.91 172.63,73.75 D118.05
  L28_SIGNAL w0.071: v1(164.91,162.67) 164.91,162.27 164.98,162.2 166.16,162.2 175.64,171.68 202.38,171.68 211.12,180.42 211.12,183.57 216.53,188.98 222.57,188.98 223.75,190.16 225.74,190.16 225.81,190.24 v1(225.81,190.64)
D11806: length 212.1
  TOP w0.086: v1(228.57,192.73) 229.02,192.28 232.03,192.28 233.96,190.35 237.6,190.35 237.68,190.43 SITE3.140
  L07_SIGNAL w0.071: D118.06 175.11,81.13 175.11,82.13 174.78,82.46 154.48,82.46 145.52,91.42 145.52,135.77 169.19,159.44 174.36,159.44 177.12,162.2 178.43,162.2 178.5,162.27 v1(178.5,162.67)
  L30_SIGNAL w0.071: v1(178.5,162.67) 178.5,162.27 178.57,162.2 179.62,162.2 179.93,162.51 179.93,167.76 184.31,172.14 213.08,172.14 215.37,174.43 215.37,180.15 216.31,181.08 223.1,181.08 226.64,184.63 226.64,191.45 227.45,192.26 228.49,192.26 228.57,192.33 v1(228.57,192.73)
D11807: length 216.2
  TOP w0.086: v1(225.81,189.49) 226.27,189.95 232.3,189.95 232.94,189.31 237.6,189.31 237.68,189.23 SITE3.143
  L07_SIGNAL w0.071: v1(164.91,161.52) 164.91,161.93 164.98,162 165.64,162 165.91,161.72 165.91,160.85 143.49,138.43 143.49,84.73 156.04,72.19 172.2,72.19 172.83,72.82 172.83,73.77 D118.07
  L28_SIGNAL w0.071: v1(225.81,189.49) 225.81,189.9 225.74,189.97 223.83,189.97 222.65,188.79 216.62,188.79 211.32,183.49 211.32,180.34 202.46,171.48 175.73,171.48 166.24,162 164.98,162 164.91,161.93 v1(164.91,161.52)
D11808: length 211.8
  TOP w0.086: SITE3.141 237.68,190.03 237.6,190.11 233.86,190.11 231.93,192.04 229.02,192.04 v1(228.57,191.59)
  L07_SIGNAL w0.071: v1(178.5,161.52) 178.5,161.93 178.43,162 177.2,162 174.44,159.24 169.28,159.24 145.72,135.68 145.72,91.5 154.56,82.66 174.86,82.66 175.31,82.21 175.31,81.23 D118.08
  L30_SIGNAL w0.071: v1(228.57,191.59) 228.57,191.99 228.49,192.06 227.53,192.06 226.84,191.37 226.84,184.54 223.18,180.89 216.39,180.89 215.57,180.07 215.57,174.35 213.16,171.94 184.4,171.94 180.13,167.67 180.13,162.43 179.7,162 178.57,162 178.5,161.93 v1(178.5,161.52)
D11809: length 263.5
  TOP w0.086: SITE3.102 254.23,197.78 254.15,197.86 254.15,201.95 255.98,203.78 255.98,208.13 254.78,209.33 v1(254.78,209.97)
  L07_SIGNAL w0.071: v1(181.67,203.56) 181.67,203.16 181.75,203.09 182.52,203.09 183.57,202.03 183.57,136.36 186.39,133.55 186.39,126.75 185.33,125.7 185.33,116.34 206.32,95.35 206.32,77.05 201.38,72.12 183.64,72.12 182.84,72.93 182.84,73.7 D118.09
  L32_SIGNAL w0.071: v1(254.78,209.97) 254.5,209.69 254.4,209.69 251,213.09 224.37,213.09 223.42,212.14 223.42,210.59 218.89,206.06 186.03,206.06 183.06,203.09 181.75,203.09 181.67,203.16 v1(181.67,203.56)
D11810: length 260.7
  TOP w0.086: v1(238.79,209.08) 238.34,208.63 238.34,207.86 239.3,206.9 239.3,202.62 243.35,198.57 243.35,197.86 243.43,197.78 SITE3.129
  L07_SIGNAL w0.071: D118.10 185.33,81.19 185.33,82.05 186,82.72 202.46,82.72 203.75,84.02 203.75,91.29 177.73,117.31 177.73,131.8 180.1,134.17 180.1,169.55 178.34,171.31 165.02,171.31 163.15,173.18 163.15,188.43 163.84,189.12 164.84,189.12 164.91,189.19 v1(164.91,189.59)
  L30_SIGNAL w0.071: v1(164.91,189.59) 164.91,189.19 164.98,189.12 166.35,189.12 176.85,199.62 215.03,199.62 225.68,210.27 225.68,212.38 226.59,213.29 236.12,213.29 238.32,211.1 238.32,209.16 238.39,209.08 v1(238.79,209.08)
D11811: length 262.1
  TOP w0.086: SITE3.103 253.83,197.78 253.91,197.86 253.91,202.05 255.74,203.88 255.74,208.03 254.61,209.17 v1(253.98,209.17)
  L07_SIGNAL w0.071: v1(181.67,202.42) 181.67,202.82 181.75,202.89 182.43,202.89 183.37,201.95 183.37,136.28 186.19,133.46 186.19,126.83 185.13,125.78 185.13,116.25 206.12,95.27 206.12,77.14 201.3,72.32 183.73,72.32 183.04,73.01 183.04,73.82 D118.11
  L32_SIGNAL w0.071: v1(181.67,202.42) 181.67,202.82 181.75,202.89 183.14,202.89 186.11,205.86 218.97,205.86 223.62,210.51 223.62,212.06 224.45,212.9 250.91,212.9 254.26,209.55 254.26,209.45 v1(253.98,209.17)
D11812: length 260.1
  TOP w0.086: v1(237.64,209.08) 238.1,208.63 238.1,207.76 239.06,206.8 239.06,202.52 243.11,198.47 243.11,197.86 243.03,197.78 SITE3.130
  L07_SIGNAL w0.071: D118.12 185.53,81.17 185.53,81.97 186.08,82.52 202.54,82.52 203.95,83.93 203.95,91.37 177.93,117.39 177.93,131.72 180.3,134.09 180.3,169.63 178.42,171.51 165.11,171.51 163.35,173.27 163.35,188.35 163.92,188.92 164.84,188.92 164.91,188.85 v1(164.91,188.45)
  L30_SIGNAL w0.071: v1(237.64,209.08) 238.05,209.08 238.12,209.16 238.12,211.02 236.04,213.09 226.68,213.09 225.88,212.3 225.88,210.19 215.11,199.42 176.93,199.42 166.43,188.92 164.98,188.92 164.91,188.85 v1(164.91,188.45)
D11813: length 238.2
  TOP w0.086: SITE3.114 249.43,197.78 249.35,197.86 249.35,207.66 v1(249.8,208.11)
  L05_SIGNAL w0.071: v1(181.67,189.59) 181.67,189.19 181.75,189.12 182.59,189.12 183.4,188.31 183.4,136.26 178.92,131.78 178.92,124.97 204.62,99.28 204.62,75 201.83,72.22 193.67,72.22 192.97,72.92 192.97,73.73 D118.13
  L30_SIGNAL w0.071: v1(181.67,189.59) 181.67,189.19 181.75,189.12 182.78,189.12 191.86,198.2 216.17,198.2 228.23,210.26 233.64,210.26 235.92,207.98 246,207.98 247.82,209.79 248.69,209.79 249.33,209.15 249.33,208.18 249.4,208.11 v1(249.8,208.11)
D11814: length 134.7
  L05_SIGNAL w0.071: v1(178.5,176.13) 178.5,175.73 178.43,175.66 177.62,175.66 174.12,172.16 174.12,131.71 175.15,130.68 175.15,124.74 202.32,97.58 202.32,83.75 201.26,82.69 196.16,82.69 195.5,82.04 195.5,81.2 D118.14
  L32_SIGNAL w0.071: v1(186.95,176.66) 188.3,176.66 188.37,176.59 188.37,175.52 187.78,174.93 186.19,174.93 184.7,176.43 181.27,176.43 180.5,175.66 178.57,175.66 178.5,175.73 v1(178.5,176.13)
  BOTTOM w0.119: v1(186.95,176.66) UNK3K43.6
D11815: length 236.8
  TOP w0.086: v1(248.66,208.11) 249.11,207.66 249.11,197.86 249.03,197.78 SITE3.115
  L05_SIGNAL w0.071: D118.15 193.17,73.79 193.17,73 193.75,72.42 201.75,72.42 204.42,75.09 204.42,99.19 178.72,124.89 178.72,131.86 183.2,136.34 183.2,188.23 182.51,188.92 181.75,188.92 181.67,188.85 v1(181.67,188.45)
  L30_SIGNAL w0.071: v1(181.67,188.45) 181.67,188.85 181.75,188.92 182.86,188.92 191.94,198 216.25,198 228.31,210.06 233.56,210.06 235.84,207.78 246.09,207.78 247.9,209.59 248.61,209.59 249.13,209.07 249.13,208.18 249.06,208.11 v1(248.66,208.11)
D11816: length 134.6
  L05_SIGNAL w0.071: D118.16 195.7,81.16 195.7,81.95 196.24,82.49 201.34,82.49 202.51,83.67 202.51,97.66 175.35,124.83 175.35,130.77 174.32,131.79 174.32,172.08 177.7,175.46 178.43,175.46 178.5,175.39 v1(178.5,174.99)
  L32_SIGNAL w0.071: v1(189.99,176.66) 188.64,176.66 188.57,176.59 188.57,175.44 187.86,174.74 186.11,174.74 184.62,176.23 181.35,176.23 180.59,175.46 178.57,175.46 178.5,175.39 v1(178.5,174.99)
  BOTTOM w0.119: v1(189.99,176.66) UNK3K43.3
D11901: length 214.6
  TOP w0.086: SITE3.8 245.03,171.48 244.95,171.4 244.95,170.08 241.42,166.55 241.42,159.77 v1(241.88,159.32)
  L03_SIGNAL w0.071: D119.01 162.53,53.37 162.53,51.04 160.86,49.37 156.78,49.37 152.06,54.09 152.06,105.55 155.51,109 155.51,128.08 162.51,135.07 164.84,135.07 164.91,135 v1(164.91,134.6)
  L28_SIGNAL w0.071: v1(164.91,134.6) 164.91,135 164.98,135.07 166.44,135.07 171.08,139.71 171.08,146.05 182.1,157.07 240.59,157.07 241.4,157.88 241.4,159.24 241.47,159.32 v1(241.88,159.32)
D11902: length 194.1
  TOP w0.086: v1(239.69,162.06) 239.24,162.51 239.24,165.66 244.15,170.57 244.15,171.4 244.23,171.48 SITE3.6
  L03_SIGNAL w0.071: v1(178.5,134.6) 178.5,135 178.57,135.07 179.78,135.07 180.31,134.54 180.31,133.76 176.9,130.35 162.2,130.35 158.59,126.74 158.59,121.35 157.35,120.11 157.35,63.45 158.62,62.18 164.2,62.18 164.98,61.41 164.98,60.84 D119.02
  L30_SIGNAL w0.071: v1(239.69,162.06) 239.29,162.06 239.22,161.99 239.22,160.73 237.49,159 207.22,159 202.07,153.85 194.58,153.85 183.45,142.72 183.45,137.41 181.1,135.07 178.57,135.07 178.5,135 v1(178.5,134.6)
D11903: length 215.2
  TOP w0.086: v1(240.73,159.32) 241.18,159.77 241.18,166.65 244.71,170.18 244.71,171.4 244.63,171.48 SITE3.7
  L03_SIGNAL w0.071: D119.03 162.73,53.51 162.73,50.95 160.95,49.17 156.7,49.17 151.86,54.01 151.86,105.63 155.31,109.09 155.31,128.16 162.43,135.27 164.84,135.27 164.91,135.34 v1(164.91,135.74)
  L28_SIGNAL w0.071: v1(164.91,135.74) 164.91,135.34 164.98,135.27 166.36,135.27 170.88,139.79 170.88,146.14 182.01,157.27 240.51,157.27 241.2,157.97 241.2,159.24 241.13,159.32 v1(240.73,159.32)
D11904: length 194.1
  TOP w0.086: v1(238.55,162.06) 239,162.51 239,165.76 243.91,170.67 243.91,171.4 243.83,171.48 SITE3.5
  L03_SIGNAL w0.071: D119.04 165.18,60.88 165.18,61.49 164.29,62.38 158.71,62.38 157.55,63.54 157.55,120.03 158.79,121.27 158.79,126.66 162.28,130.15 176.98,130.15 180.51,133.68 180.51,134.63 179.86,135.27 178.57,135.27 178.5,135.34 v1(178.5,135.74)
  L30_SIGNAL w0.071: v1(238.55,162.06) 238.95,162.06 239.02,161.99 239.02,160.81 237.41,159.19 207.14,159.19 201.99,154.05 194.49,154.05 183.25,142.8 183.25,137.5 181.02,135.27 178.57,135.27 178.5,135.34 v1(178.5,135.74)
D11905: length 327.7
  TOP w0.086: SITE3.75 263.98,188.03 264.06,188.11 277.07,188.11 v1(277.52,187.66)
  L05_SIGNAL w0.071: D119.05 172.93,53.13 172.93,51.8 167.72,46.59 155.39,46.59 137.9,64.09 137.9,157.76 152.84,172.7 165.52,172.7 166.47,173.65 166.47,174.97 165.79,175.66 164.98,175.66 164.91,175.73 v1(164.91,176.13)
  L32_SIGNAL w0.071: v1(164.91,176.13) 164.91,175.73 164.84,175.66 163.75,175.66 163.25,176.16 163.25,181.42 166.39,184.55 209.65,184.55 213.03,181.17 223.32,181.17 226.46,184.31 231.9,184.31 232.93,185.34 232.93,186.84 235.96,189.87 264.1,189.87 265.84,188.13 277.45,188.13 277.52,188.06 v1(277.52,187.66)
D11906: length 292.7
  TOP w0.086: SITE3.120 247.03,197.78 246.95,197.86 246.95,204.17 244.91,206.21 244.91,208.63 v1(245.36,209.08)
  L05_SIGNAL w0.071: v1(164.91,203.56) 164.91,203.16 164.84,203.09 163.68,203.09 163.13,202.53 163.13,181.8 168.58,176.35 168.58,173.54 166.28,171.24 156.97,171.24 144.68,158.95 144.68,73.31 155.76,62.24 174.53,62.24 175.14,61.63 175.14,60.84 D119.06
  L30_SIGNAL w0.071: v1(245.36,209.08) 244.96,209.08 244.89,209.16 244.89,210.69 240.78,214.8 225.79,214.8 223.38,212.39 223.38,210.92 219.02,206.56 169.82,206.56 166.34,203.09 164.98,203.09 164.91,203.16 v1(164.91,203.56)
D11907: length 328.4
  TOP w0.086: SITE3.76 263.98,188.43 264.06,188.35 277.07,188.35 v1(277.52,188.8)
  L05_SIGNAL w0.071: v1(164.91,174.99) 164.91,175.39 164.98,175.46 165.7,175.46 166.27,174.89 166.27,173.74 165.44,172.9 152.76,172.9 137.7,157.84 137.7,64.01 155.31,46.39 167.8,46.39 173.13,51.72 173.13,53.75 D119.07
  L32_SIGNAL w0.071: v1(164.91,174.99) 164.91,175.39 164.84,175.46 163.66,175.46 163.05,176.07 163.05,181.5 166.3,184.75 209.73,184.75 213.12,181.37 223.24,181.37 226.38,184.51 231.82,184.51 232.73,185.42 232.73,186.92 235.88,190.07 264.18,190.07 265.93,188.33 277.45,188.33 277.52,188.4 v1(277.52,188.8)
D11908: length 292
  TOP w0.086: v1(244.22,209.08) 244.67,208.63 244.67,206.11 246.71,204.07 246.71,197.86 246.63,197.78 SITE3.121
  L05_SIGNAL w0.071: D119.08 175.34,60.88 175.34,61.71 174.62,62.43 155.84,62.43 144.88,73.39 144.88,158.87 157.05,171.04 166.36,171.04 168.78,173.46 168.78,176.43 163.32,181.88 163.32,202.45 163.77,202.89 164.84,202.89 164.91,202.82 v1(164.91,202.42)
  L30_SIGNAL w0.071: v1(244.22,209.08) 244.62,209.08 244.69,209.16 244.69,210.61 240.69,214.61 225.87,214.61 223.57,212.31 223.57,210.84 219.1,206.36 169.9,206.36 166.42,202.89 164.98,202.89 164.91,202.82 v1(164.91,202.42)
D11909: length 238.7
  TOP w0.086: v1(245.11,203.69) 244.65,203.24 244.65,202.03 246.15,200.53 246.15,197.86 246.23,197.78 SITE3.122
  L05_SIGNAL w0.071: D119.09 182.8,53.42 182.8,49.01 185.2,46.6 198.47,46.6 208.44,56.58 208.44,138.68 213.82,144.06 213.82,202.43 213.16,203.09 212.1,203.09 212.03,203.16 v1(212.03,203.56)
  L32_SIGNAL w0.071: v1(212.03,203.56) 212.03,203.16 212.1,203.09 218.83,203.09 226.44,210.7 234.68,210.7 237.41,207.97 242.9,207.97 244.63,206.24 244.63,203.76 244.7,203.69 v1(245.11,203.69)
D11910: length 234.3
  TOP w0.086: v1(242.12,209.08) 241.66,208.63 241.66,206.13 242.87,204.93 242.87,202.13 245.35,199.65 245.35,197.86 245.43,197.78 SITE3.124
  L05_SIGNAL w0.071: D119.10 185.27,60.81 185.27,61.76 185.83,62.31 201.89,62.31 206.3,66.72 206.3,114.42 195.43,125.29 195.43,133.73 196.9,135.2 196.9,202.73 197.26,203.09 198.37,203.09 198.44,203.16 v1(198.44,203.56)
  L28_SIGNAL w0.071: v1(242.12,209.08) 241.71,209.08 241.64,209.16 241.64,210.26 240.81,211.1 234.6,211.1 233.41,209.9 228.33,209.9 223.69,205.26 201.93,205.26 199.75,203.09 198.51,203.09 198.44,203.16 v1(198.44,203.56)
D11911: length 237.3
  TOP w0.086: SITE3.123 245.83,197.78 245.91,197.86 245.91,200.44 244.42,201.93 244.42,203.24 v1(243.96,203.69)
  L05_SIGNAL w0.071: D119.11 183,53.46 183,49.09 185.28,46.8 198.39,46.8 208.24,56.66 208.24,138.77 213.63,144.15 213.63,202.34 213.08,202.89 212.1,202.89 212.03,202.82 v1(212.03,202.42)
  L32_SIGNAL w0.071: v1(212.03,202.42) 212.03,202.82 212.1,202.89 218.91,202.89 226.52,210.5 234.6,210.5 237.32,207.77 242.82,207.77 244.44,206.16 244.44,203.76 244.36,203.69 v1(243.96,203.69)
D11912: length 233.7
  TOP w0.086: v1(240.97,209.08) 241.43,208.63 241.43,206.04 242.63,204.83 242.63,202.03 245.11,199.55 245.11,197.86 245.03,197.78 SITE3.125
  L05_SIGNAL w0.071: v1(198.44,202.42) 198.44,202.82 198.37,202.89 197.34,202.89 197.1,202.65 197.1,135.12 195.63,133.65 195.63,125.37 206.5,114.5 206.5,66.64 201.98,62.12 185.91,62.12 185.47,61.68 185.47,60.91 D119.12
  L28_SIGNAL w0.071: v1(240.97,209.08) 241.37,209.08 241.45,209.16 241.45,210.18 240.72,210.9 234.69,210.9 233.49,209.7 228.41,209.7 223.77,205.07 202.01,205.07 199.83,202.89 198.51,202.89 198.44,202.82 v1(198.44,202.42)
D11913: length 187.3
  TOP w0.086: SITE3.10 245.83,171.48 245.75,171.4 245.75,168.95 243.58,166.78 243.58,162.51 v1(244.03,162.06)
  L03_SIGNAL w0.071: v1(195.26,147.81) 195.26,148.21 195.19,148.28 194.85,148.28 194.19,147.62 194.19,144.75 199.22,139.72 199.22,132.4 204.85,126.76 204.85,54.97 201.11,51.23 193.86,51.23 192.92,52.18 192.92,53.46 D119.13
  L30_SIGNAL w0.071: v1(244.03,162.06) 243.63,162.06 243.56,161.99 243.56,158.6 242.03,157.07 208.38,157.07 202.37,151.06 198.03,151.06 197.28,150.31 197.28,148.89 196.68,148.28 195.33,148.28 195.26,148.21 v1(195.26,147.81)
D11914: length 193.3
  TOP w0.086: SITE3.12 246.63,171.48 246.55,171.4 246.55,167.84 245.57,166.86 245.57,159.77 v1(246.02,159.32)
  L03_SIGNAL w0.071: D119.14 195.45,60.83 195.45,61.35 196.51,62.41 201.5,62.41 202.59,63.51 202.59,123.83 195.75,130.67 195.75,138.68 191.99,142.44 188.81,142.44 182.97,148.28 181.75,148.28 181.67,148.21 v1(181.67,147.81)
  L28_SIGNAL w0.071: v1(181.67,147.81) 181.67,148.21 181.75,148.28 182.96,148.28 188.5,153.82 241.97,153.82 245.55,157.4 245.55,159.24 245.62,159.32 v1(246.02,159.32)
D11915: length 186.7
  TOP w0.086: v1(242.89,162.06) 243.34,162.51 243.34,166.88 245.51,169.05 245.51,171.4 245.43,171.48 SITE3.9
  L03_SIGNAL w0.071: D119.15 193.11,53.41 193.11,52.26 193.94,51.43 201.03,51.43 204.65,55.06 204.65,126.68 199.02,132.31 199.02,139.64 193.99,144.67 193.99,147.71 194.77,148.48 195.19,148.48 195.26,148.55 v1(195.26,148.95)
  L30_SIGNAL w0.071: v1(195.26,148.95) 195.26,148.55 195.33,148.48 196.6,148.48 197.09,148.97 197.09,150.39 197.95,151.26 202.29,151.26 208.3,157.27 241.95,157.27 243.36,158.68 243.36,161.99 243.29,162.06 v1(242.89,162.06)
D11916: length 193.4
  TOP w0.086: v1(244.88,159.32) 245.33,159.77 245.33,166.96 246.31,167.94 246.31,171.4 246.23,171.48 SITE3.11
  L03_SIGNAL w0.071: D119.16 195.64,60.9 195.64,61.27 196.59,62.22 201.58,62.22 202.79,63.43 202.79,123.91 195.95,130.75 195.95,138.77 192.08,142.63 188.9,142.63 183.05,148.48 181.75,148.48 181.67,148.55 v1(181.67,148.95)
  L28_SIGNAL w0.071: v1(244.88,159.32) 245.28,159.32 245.35,159.24 245.35,157.48 241.89,154.02 188.42,154.02 182.88,148.48 181.75,148.48 181.67,148.55 v1(181.67,148.95)
D12001: length 249.2
  TOP w0.086: v1(227.59,169.94) 228.05,170.39 241.9,170.39 242.55,171.04 242.55,171.4 242.63,171.48 SITE3.2
  L03_SIGNAL w0.071: v1(195.26,161.52) 195.26,161.93 195.19,162 194.61,162 190.75,158.14 165.63,158.14 143.08,135.59 143.08,35.9 149.95,29.04 159.84,29.04 162.49,31.68 162.49,33.09 D120.01
  L32_SIGNAL w0.071: v1(195.26,161.52) 195.26,161.93 195.33,162 196.58,162 196.93,161.64 196.93,160.39 198.62,158.7 214.61,158.7 226.32,170.41 227.52,170.41 227.59,170.34 v1(227.59,169.94)
D12002: length 240
  TOP w0.086: SITE3.168 237.68,179.23 237.6,179.31 233.36,179.31 232.18,180.49 231.43,180.49 v1(230.98,180.03)
  L03_SIGNAL w0.071: v1(178.5,147.81) 178.5,148.21 178.57,148.28 179.49,148.28 180.21,149 180.21,150.29 179.46,151.04 163.61,151.04 144.39,131.83 144.39,49.59 150.84,43.14 164.11,43.14 164.89,42.36 164.89,40.43 D120.02
  L30_SIGNAL w0.071: v1(230.98,180.03) 230.98,180.43 230.91,180.51 226.97,180.51 223.85,177.38 217.72,177.38 216.65,176.31 216.65,172.06 203.06,158.47 184.81,158.47 180.14,153.8 180.14,148.64 179.79,148.28 178.57,148.28 178.5,148.21 v1(178.5,147.81)
D12003: length 249.7
  TOP w0.086: SITE3.1 242.23,171.48 242.31,171.4 242.31,171.14 241.8,170.63 228.05,170.63 v1(227.59,171.09)
  L03_SIGNAL w0.071: v1(195.26,162.67) 195.26,162.27 195.19,162.2 194.53,162.2 190.67,158.34 165.55,158.34 142.89,135.67 142.89,35.82 149.87,28.84 159.92,28.84 162.69,31.6 162.69,33.15 D120.03
  L32_SIGNAL w0.071: v1(227.59,171.09) 227.59,170.68 227.52,170.61 226.24,170.61 214.53,158.9 198.7,158.9 197.13,160.47 197.13,161.73 196.66,162.2 195.33,162.2 195.26,162.27 v1(195.26,162.67)
D12004: length 239.1
  TOP w0.086: SITE3.167 237.68,179.63 237.6,179.55 233.45,179.55 232.28,180.72 231.43,180.72 v1(230.98,181.18)
  L03_SIGNAL w0.071: D120.04 165.09,40.65 165.09,42.44 164.19,43.34 150.92,43.34 144.59,49.67 144.59,131.74 163.69,150.84 179.38,150.84 180.01,150.21 180.01,149.08 179.41,148.48 178.57,148.48 178.5,148.55 v1(178.5,148.95)
  L30_SIGNAL w0.071: v1(178.5,148.95) 178.5,148.55 178.57,148.48 179.7,148.48 179.95,148.72 179.95,153.88 184.73,158.66 202.97,158.66 216.45,172.14 216.45,176.39 217.64,177.58 223.77,177.58 226.89,180.7 230.91,180.7 230.98,180.77 v1(230.98,181.18)
D12005: length 265.9
  TOP w0.086: SITE3.174 237.68,176.83 237.6,176.91 234.63,176.91 232.6,174.88 228.05,174.88 v1(227.59,174.42)
  L03_SIGNAL w0.071: D120.05 172.74,33 172.74,29.05 170.22,26.53 149.28,26.53 141.5,34.32 141.5,139.52 161.96,159.99 179.63,159.99 180.14,160.5 180.14,161.61 180.53,162 181.6,162 181.67,161.93 v1(181.67,161.52)
  L32_SIGNAL w0.071: v1(181.67,161.52) 181.67,161.93 181.75,162 183.31,162 184.71,163.4 191.94,163.4 205.94,177.4 222.78,177.4 225.28,174.9 227.52,174.9 227.59,174.83 v1(227.59,174.42)
D12006: length 234.5
  TOP w0.086: SITE3.170 237.68,178.43 237.6,178.51 228.05,178.51 v1(227.59,178.06)
  L03_SIGNAL w0.071: D120.06 175.09,40.47 175.09,43.57 172.68,45.97 155.96,45.97 146.03,55.9 146.03,124 166.34,144.31 166.34,147.98 166.05,148.28 164.98,148.28 164.91,148.21 v1(164.91,147.81)
  L28_SIGNAL w0.071: v1(227.59,178.06) 227.59,178.46 227.52,178.53 224.07,178.53 222.89,177.35 217.63,177.35 211.97,171.69 208.94,171.69 204.53,167.28 179.68,167.28 171.08,158.68 171.08,152.93 166.43,148.28 164.98,148.28 164.91,148.21 v1(164.91,147.81)
D12007: length 266.7
  TOP w0.086: SITE3.173 237.68,177.23 237.6,177.15 234.53,177.15 232.5,175.12 228.05,175.12 v1(227.59,175.57)
  L03_SIGNAL w0.071: D120.07 172.94,33.24 172.94,28.97 170.3,26.33 149.2,26.33 141.3,34.23 141.3,139.6 161.88,160.19 179.55,160.19 179.95,160.58 179.95,161.69 180.45,162.2 181.6,162.2 181.67,162.27 v1(181.67,162.67)
  L32_SIGNAL w0.071: v1(181.67,162.67) 181.67,162.27 181.75,162.2 183.23,162.2 184.63,163.6 191.85,163.6 205.85,177.6 222.86,177.6 225.36,175.1 227.52,175.1 227.59,175.17 v1(227.59,175.57)
D12008: length 234.9
  TOP w0.086: SITE3.169 237.68,178.83 237.6,178.75 228.05,178.75 v1(227.59,179.2)
  L03_SIGNAL w0.071: D120.08 175.28,40.62 175.28,43.65 172.76,46.17 156.04,46.17 146.23,55.99 146.23,123.91 166.54,144.23 166.54,148.06 166.13,148.48 164.98,148.48 164.91,148.55 v1(164.91,148.95)
  L28_SIGNAL w0.071: v1(227.59,179.2) 227.59,178.8 227.52,178.73 223.99,178.73 222.81,177.55 217.55,177.55 211.89,171.89 208.86,171.89 204.45,167.48 179.6,167.48 170.88,158.77 170.88,153.02 166.34,148.48 164.98,148.48 164.91,148.55 v1(164.91,148.95)
D12009: length 210
  TOP w0.086: v1(247.8,162.06) 247.35,162.51 247.35,171.4 247.43,171.48 SITE3.14
  L03_SIGNAL w0.071: D120.09 182.9,33 182.9,31.62 186.69,27.82 201.61,27.82 212.92,39.13 212.92,131.28 209.43,134.77 209.43,146.73 211.24,148.53 212.21,148.53 212.28,148.46 v1(212.28,148.06)
  L30_SIGNAL w0.071: v1(247.8,162.06) 247.4,162.06 247.33,161.99 247.33,157.2 245.1,154.97 221.12,154.97 214.68,148.53 212.35,148.53 212.28,148.46 v1(212.28,148.06)
D12010: length 205.8
  TOP w0.086: SITE3.16 248.23,171.48 248.15,171.4 248.15,163.49 249.52,162.12 249.52,159.77 v1(249.98,159.32)
  L03_SIGNAL w0.071: v1(198.69,148.06) 198.69,148.46 198.76,148.53 199.68,148.53 202.67,145.55 202.67,137.66 201.48,136.48 201.48,134 202.67,132.82 202.67,131.61 206.85,127.43 206.85,51.04 201.3,45.49 188.13,45.49 185.19,42.54 185.19,40.41 D120.10
  L28_SIGNAL w0.071: v1(198.69,148.06) 198.69,148.46 198.76,148.53 200.05,148.53 203.64,152.12 244.99,152.12 249.5,156.64 249.5,159.24 249.57,159.32 v1(249.98,159.32)
D12011: length 209.2
  TOP w0.086: v1(246.66,162.06) 247.11,162.51 247.11,171.4 247.03,171.48 SITE3.13
  L03_SIGNAL w0.071: v1(212.28,149.21) 212.28,148.8 212.21,148.73 211.16,148.73 209.23,146.81 209.23,134.68 212.72,131.19 212.72,39.22 201.53,28.02 186.77,28.02 183.09,31.7 183.09,33.23 D120.11
  L30_SIGNAL w0.071: v1(246.66,162.06) 247.06,162.06 247.13,161.99 247.13,157.29 245.02,155.17 221.04,155.17 214.6,148.73 212.35,148.73 212.28,148.8 v1(212.28,149.21)
D12012: length 205.9
  TOP w0.086: v1(248.83,159.32) 249.28,159.77 249.28,162.02 247.91,163.39 247.91,171.4 247.83,171.48 SITE3.15
  L03_SIGNAL w0.071: D120.12 185.38,40.68 185.38,42.46 188.22,45.29 201.38,45.29 207.05,50.96 207.05,127.51 202.87,131.69 202.87,132.9 201.68,134.08 201.68,136.4 202.87,137.58 202.87,145.63 199.76,148.73 198.76,148.73 198.69,148.8 v1(198.69,149.21)
  L28_SIGNAL w0.071: v1(198.69,149.21) 198.69,148.8 198.76,148.73 199.97,148.73 203.56,152.32 244.91,152.32 249.3,156.72 249.3,159.24 249.23,159.32 v1(248.83,159.32)
D12013: length 194.9
  TOP w0.086: v1(230.98,176.32) 231.43,176.77 232.68,176.77 233.62,177.71 237.6,177.71 237.68,177.63 SITE3.172
  L03_SIGNAL w0.071: D120.13 192.99,33.07 192.99,31.71 194.58,30.13 200.89,30.13 211.36,40.59 211.36,129.31 205.74,134.93 205.74,137.67 207.35,139.27 207.35,158.24 211.11,162 212.21,162 212.28,161.93 v1(212.28,161.52)
  L30_SIGNAL w0.071: v1(212.28,161.52) 212.28,161.93 212.35,162 218.92,162 224.4,167.49 224.4,175.05 226.14,176.79 230.91,176.79 230.98,176.72 v1(230.98,176.32)
D12014: length 185.8
  TOP w0.086: v1(230.98,172.38) 231.43,172.83 232.94,172.83 236.22,176.11 237.6,176.11 237.68,176.03 SITE3.176
  L03_SIGNAL w0.071: v1(198.69,161.52) 198.69,161.93 198.76,162 198.86,162 204.32,156.54 204.32,132.31 208.96,127.67 208.96,49.91 202.06,43.01 197.01,43.01 195.31,41.31 195.31,40.37 D120.14
  L32_SIGNAL w0.071: v1(198.69,161.52) 198.69,161.93 198.76,162 200.25,162 201.86,163.6 207.9,163.6 214.24,169.95 223.12,169.95 226.02,172.85 230.91,172.85 230.98,172.78 v1(230.98,172.38)
D12015: length 194.5
  TOP w0.086: v1(230.98,177.46) 231.43,177.01 232.58,177.01 233.52,177.95 237.6,177.95 237.68,178.03 SITE3.171
  L03_SIGNAL w0.071: v1(212.28,162.67) 212.28,162.27 212.21,162.2 211.03,162.2 207.15,158.32 207.15,139.36 205.54,137.75 205.54,134.85 211.16,129.23 211.16,40.68 200.81,30.33 194.66,30.33 193.19,31.8 193.19,33.17 D120.15
  L30_SIGNAL w0.071: v1(212.28,162.67) 212.28,162.27 212.35,162.2 218.83,162.2 224.21,167.57 224.21,175.14 226.06,176.99 230.91,176.99 230.98,177.06 v1(230.98,177.46)
D12016: length 186.3
  TOP w0.086: v1(230.98,173.52) 231.43,173.07 232.84,173.07 236.12,176.35 237.6,176.35 237.68,176.43 SITE3.175
  L03_SIGNAL w0.071: D120.16 195.51,40.71 195.51,41.22 197.09,42.81 202.14,42.81 209.16,49.83 209.16,127.75 204.52,132.39 204.52,156.62 198.95,162.2 198.76,162.2 198.69,162.27 v1(198.69,162.67)
  L32_SIGNAL w0.071: v1(198.69,162.67) 198.69,162.27 198.76,162.2 200.17,162.2 201.78,163.8 207.82,163.8 214.16,170.14 223.04,170.14 225.94,173.05 230.91,173.05 230.98,173.12 v1(230.98,173.52)
D12201: length 184.7
  TOP w0.086: SITE3.81 263.98,190.43 264.06,190.51 267.99,190.51 270.02,192.53 277.07,192.53 v1(277.52,192.08)
  L05_SIGNAL w0.071: v1(250.81,142.94) 250.4,142.94 250.33,142.87 250.33,141.73 226.34,117.74 226.34,77.59 231.46,72.47 235.35,72.47 236.21,73.33 236.21,73.67 D122.01
  L28_SIGNAL w0.071: v1(277.52,192.08) 277.52,192.48 277.59,192.55 278.55,192.55 280.57,190.54 280.57,156.21 268.92,144.56 258.2,144.56 255.21,141.56 250.75,141.56 250.33,141.98 250.33,142.87 250.4,142.94 v1(250.81,142.94)
D12202: length 165.2
  TOP w0.086: SITE3.79 263.98,189.63 264.06,189.71 269.05,189.71 269.94,190.59 273.35,190.59 v1(273.81,190.14)
  L05_SIGNAL w0.071: D122.02 238.7,81.22 238.7,81.64 237.91,82.43 230.47,82.43 228.88,84.03 228.88,116.96 242.92,131 249.42,131 250.33,130.09 250.33,129.42 250.4,129.35 v1(250.81,129.35)
  L30_SIGNAL w0.071: v1(250.81,129.35) 250.4,129.35 250.33,129.42 250.33,130.71 251.97,132.35 251.97,138.76 258.31,145.1 258.31,166.24 262.18,170.11 262.18,187.18 265.61,190.61 273.74,190.61 273.81,190.54 v1(273.81,190.14)
D12203: length 186.3
  TOP w0.086: v1(277.52,193.22) 277.07,192.77 269.92,192.77 267.9,190.75 264.06,190.75 263.98,190.83 SITE3.82
  L05_SIGNAL w0.071: D122.03 236.41,73.85 236.41,73.25 235.43,72.27 231.38,72.27 226.15,77.51 226.15,117.83 250.14,141.82 250.14,142.87 250.06,142.94 v1(249.66,142.94)
  L28_SIGNAL w0.071: v1(277.52,193.22) 277.52,192.82 277.59,192.75 278.64,192.75 280.77,190.62 280.77,156.13 269,144.36 258.29,144.36 255.29,141.36 250.67,141.36 250.14,141.9 250.14,142.87 250.06,142.94 v1(249.66,142.94)
D12204: length 164.8
  TOP w0.086: SITE3.80 263.98,190.03 264.06,189.95 268.95,189.95 269.84,190.83 273.35,190.83 v1(273.81,191.28)
  L05_SIGNAL w0.071: v1(249.66,129.35) 250.06,129.35 250.14,129.42 250.14,130.01 249.34,130.81 243,130.81 229.07,116.88 229.07,84.11 230.55,82.63 237.99,82.63 238.9,81.73 238.9,81.14 D122.04
  L30_SIGNAL w0.071: v1(273.81,191.28) 273.81,190.88 273.74,190.81 265.53,190.81 261.98,187.26 261.98,170.19 258.11,166.33 258.11,145.18 251.77,138.84 251.77,132.43 250.14,130.79 250.14,129.42 250.06,129.35 v1(249.66,129.35)
D12205: length 271.6
  TOP w0.086: SITE3.93 257.83,197.78 257.75,197.86 257.75,199.44 262.61,204.3 262.61,208.15 v1(263.07,208.6)
  L07_SIGNAL w0.071: D122.05 246.3,73.74 246.3,72.78 245.85,72.32 230.94,72.32 229.08,74.19 229.08,96.88 202.7,123.26 202.7,127.13 201.09,128.74 201.09,137.72 193.87,144.95 193.87,197.59 196.89,200.61 196.89,211.86 199.81,214.77 199.81,216.28 199.54,216.55 198.51,216.55 198.44,216.62 v1(198.44,217.02)
  L32_SIGNAL w0.071: v1(198.44,217.02) 198.44,216.62 198.51,216.55 199.62,216.55 202.69,219.62 233.6,219.62 236.94,216.28 259.02,216.28 262.59,212.71 262.59,208.68 262.66,208.6 v1(263.07,208.6)
D12206: length 193
  TOP w0.086: SITE3.133 237.68,193.23 237.6,193.15 237.23,193.15 231.06,199.32 226.27,199.32 v1(225.81,199.77)
  L07_SIGNAL w0.071: v1(198.44,189.59) 198.44,189.19 198.37,189.12 197.61,189.12 196.56,188.07 196.56,181.02 195.58,180.03 195.58,168.34 196.56,167.36 196.56,144.02 204.69,135.89 204.69,125.43 231.35,98.76 231.35,84.26 233.13,82.48 248.05,82.48 248.77,81.77 248.77,81.13 D122.06
  L28_SIGNAL w0.071: v1(198.44,189.59) 198.44,189.19 198.51,189.12 199.81,189.12 209.99,199.3 225.74,199.3 225.81,199.37 v1(225.81,199.77)
D12207: length 271.6
  TOP w0.086: v1(261.92,208.6) 262.37,208.15 262.37,204.4 257.51,199.54 257.51,197.86 257.43,197.78 SITE3.94
  L07_SIGNAL w0.071: v1(198.44,215.88) 198.44,216.28 198.51,216.35 199.46,216.35 199.61,216.2 199.61,214.86 196.69,211.94 196.69,200.69 193.67,197.67 193.67,144.86 200.9,137.64 200.9,128.66 202.51,127.05 202.51,123.17 228.88,96.8 228.88,74.1 230.86,72.13 245.93,72.13 246.5,72.7 246.5,73.78 D122.07
  L32_SIGNAL w0.071: v1(261.92,208.6) 262.32,208.6 262.39,208.68 262.39,212.62 258.93,216.09 236.85,216.09 233.52,219.42 202.77,219.42 199.7,216.35 198.51,216.35 198.44,216.28 v1(198.44,215.88)
D12208: length 192.7
  TOP w0.086: v1(225.81,198.63) 226.27,199.08 230.96,199.08 237.13,192.91 237.6,192.91 237.68,192.83 SITE3.134
  L07_SIGNAL w0.071: v1(198.44,188.45) 198.44,188.85 198.37,188.92 197.7,188.92 196.76,187.99 196.76,180.93 195.78,179.95 195.78,168.42 196.76,167.44 196.76,144.1 204.89,135.98 204.89,125.51 231.55,98.85 231.55,84.34 233.21,82.68 248.13,82.68 248.97,81.85 248.97,81.23 D122.08
  L28_SIGNAL w0.071: v1(198.44,188.45) 198.44,188.85 198.51,188.92 199.89,188.92 210.08,199.1 225.74,199.1 225.81,199.03 v1(225.81,198.63)
D12209: length 304.6
  TOP w0.086: v1(264.67,206.34) 264.22,205.88 264.22,202.77 263.16,201.72 261.27,201.72 258.55,199 258.55,197.86 258.63,197.78 SITE3.91
  L07_SIGNAL w0.071: D122.09 256.42,73.78 256.42,72.84 257.1,72.17 275.1,72.17 279.25,76.32 279.25,93.48 272,100.73 238.48,100.73 212.16,127.05 212.16,135.81 204.66,143.31 204.66,210.97 206.78,213.09 212,213.09 213.78,214.87 213.78,216.13 213.36,216.55 212.1,216.55 212.03,216.62 v1(212.03,217.02)
  L30_SIGNAL w0.071: v1(264.67,206.34) 264.27,206.34 264.2,206.41 264.2,209.66 261.89,211.97 259.01,211.97 255.03,215.94 224.03,215.94 223.67,216.31 223.67,217.83 222.6,218.89 218.09,218.89 215.75,216.55 212.1,216.55 212.03,216.62 v1(212.03,217.02)
D12210: length 225
  TOP w0.086: v1(225.81,195.53) 226.27,195.08 232.64,195.08 236.17,191.55 237.6,191.55 237.68,191.63 SITE3.137
  L07_SIGNAL w0.071: D122.10 258.98,81.18 258.98,82.18 259.47,82.67 275.23,82.67 276.59,84.03 276.59,92.91 270.96,98.55 235.98,98.55 207.8,126.73 207.8,135.44 200.21,143.03 200.21,168.74 197.2,171.74 197.2,174.92 197.94,175.66 198.62,175.66 198.69,175.73 v1(198.69,176.13)
  L28_SIGNAL w0.071: v1(225.81,195.53) 225.81,195.13 225.74,195.06 212.13,195.06 205.22,188.15 205.22,180.44 200.43,175.66 198.76,175.66 198.69,175.73 v1(198.69,176.13)
D12211: length 303.3
  TOP w0.086: v1(263.52,206.34) 263.98,205.88 263.98,202.87 263.07,201.96 261.17,201.96 258.31,199.1 258.31,197.86 258.23,197.78 SITE3.92
  L07_SIGNAL w0.071: v1(212.03,215.88) 212.03,216.28 212.1,216.35 213.28,216.35 213.59,216.05 213.59,214.95 211.92,213.28 206.69,213.28 204.46,211.05 204.46,143.22 211.96,135.73 211.96,126.97 238.4,100.53 271.92,100.53 279.05,93.4 279.05,76.4 275.01,72.37 257.18,72.37 256.62,72.93 256.62,73.74 D122.11
  L30_SIGNAL w0.071: v1(263.52,206.34) 263.93,206.34 264,206.41 264,209.58 261.81,211.77 258.92,211.77 254.95,215.74 223.95,215.74 223.47,216.23 223.47,217.75 222.52,218.7 218.17,218.7 215.83,216.35 212.1,216.35 212.03,216.28 v1(212.03,215.88)
D12212: length 224.7
  TOP w0.086: SITE3.138 237.68,191.23 237.6,191.31 236.07,191.31 232.55,194.84 226.27,194.84 v1(225.81,194.39)
  L07_SIGNAL w0.071: D122.12 259.18,81.18 259.18,82.09 259.55,82.47 275.32,82.47 276.79,83.94 276.79,92.99 271.04,98.74 236.06,98.74 207.99,126.81 207.99,135.52 200.4,143.11 200.4,168.82 197.4,171.82 197.4,174.83 198.02,175.46 198.62,175.46 198.69,175.39 v1(198.69,174.99)
  L28_SIGNAL w0.071: v1(225.81,194.39) 225.81,194.79 225.74,194.86 212.21,194.86 205.42,188.07 205.42,180.36 200.52,175.46 198.76,175.46 198.69,175.39 v1(198.69,174.99)
D12213: length 179
  TOP w0.086: v1(277.52,196.03) 277.07,196.49 270.12,196.49 265.74,192.11 264.06,192.11 263.98,192.03 SITE3.85
  L05_SIGNAL w0.071: D122.13 266.55,73.81 266.55,72.93 267.31,72.17 275.07,72.17 280.49,77.59 280.49,113.74 268.43,125.8 268.43,139.36 263.29,144.5 263.29,145.91 263.36,145.99 v1(263.76,145.99)
  L28_SIGNAL w0.071: v1(277.52,196.03) 277.52,196.44 277.45,196.51 276.8,196.51 275.82,195.53 275.82,175.46 279.18,172.1 279.18,156.44 275.64,152.89 267.84,152.89 263.29,148.34 263.29,146.06 263.36,145.99 v1(263.76,145.99)
D12214: length 159.7
  TOP w0.086: SITE3.83 263.98,191.23 264.06,191.31 266.61,191.31 269.53,194.22 273.35,194.22 v1(273.81,193.77)
  L05_SIGNAL w0.071: v1(263.76,132.4) 263.36,132.4 263.29,132.47 263.29,133.57 263.77,134.06 265.09,134.06 265.59,133.56 265.59,123.08 278.42,110.26 278.42,85.01 276.02,82.61 270.11,82.61 269.13,81.64 269.13,81.17 D122.14
  L30_SIGNAL w0.071: v1(263.76,132.4) 263.36,132.4 263.29,132.33 263.29,130.97 263.66,130.61 264.18,130.61 265.3,131.72 265.3,151.51 276.4,162.62 276.4,193.19 275.35,194.24 273.88,194.24 273.81,194.17 v1(273.81,193.77)
D12215: length 178.7
  TOP w0.086: SITE3.86 263.98,192.43 264.06,192.35 265.64,192.35 270.02,196.73 277.07,196.73 v1(277.52,197.18)
  L05_SIGNAL w0.071: v1(262.62,145.99) 263.02,145.99 263.09,145.91 263.09,144.42 268.24,139.27 268.24,125.71 280.29,113.66 280.29,77.67 274.99,72.37 267.39,72.37 266.75,73.01 266.75,73.71 D122.15
  L28_SIGNAL w0.071: v1(262.62,145.99) 263.02,145.99 263.09,146.06 263.09,148.42 267.75,153.09 275.55,153.09 278.98,156.52 278.98,172.02 275.62,175.38 275.62,195.61 276.72,196.7 277.45,196.7 277.52,196.78 v1(277.52,197.18)
