# Allegro board 8880F5-0827_updates.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
UNK2R79  49.9-1-S4  [R0402]  388.52 251.9 180 bottom
UNK2R80  49.9-1-S4  [R0402]  390.66 251.9 180 bottom
UNK2R82  4.7K-1-S4-WA  [R0402]  456.75 233.88 0 bottom
UNK2R83  4.7K-1-S4-WA  [R0402]  482.6 241.3 0 bottom
UNK2R84  4.7K-1-S4-WA  [R0402]  482.6 233.68 0 bottom
UNK2R85  100K-1-S4  [R0402]  465.07 235.71 0 bottom
UNK2R86  4.7K-1-S4-WA  [R0402]  486.3 226.62 0 bottom
UNK2R87  4.7K-1-S4-WA  [R0402]  475.49 230.78 0 bottom
UNK2R88  4.7K-1-S4-WA  [R0402]  478.03 230.78 0 bottom
UNK2R89  4.7K-1-S4-WA  [R0402]  490.6 226.67 180 bottom
UNK2R90  4.7K-1-S4-WA  [R0402]  478.03 218.59 0 bottom
UNK2R91  4.7K-1-S4-WA  [R0402]  480.57 218.59 0 bottom
UNK2R92  4.7K-1-S4-WA  [R0402]  483.11 218.59 0 bottom
UNK2R93  4.7K-1-S4-WA  [R0402]  486.3 212.91 0 bottom
UNK2R94  4.7K-1-S4-WA  [R0402]  475.37 217.23 180 bottom
UNK2R95  4.7K-1-S4-WA  [R0402]  477.93 217.17 0 bottom
UNK2R96  4.7K-1-S4-WA  [R0402]  490.36 212.91 180 bottom
UNK2R97  4.7K-1-S4-WA  [R0402]  477.93 204.98 0 bottom
UNK2R98  4.7K-1-S4-WA  [R0402]  480.47 204.98 0 bottom
UNK2R99  4.7K-1-S4-WA  [R0402]  483.01 204.98 0 bottom
UNK2R100  49.9-1-S4  [R0402]  401.98 238.32 180 bottom
UNK2R101  49.9-1-S4  [R0402]  404.13 238.32 180 bottom
UNK2R102  49.9-1-S4  [R0402]  401.98 235.9 180 bottom
UNK2R103  49.9-1-S4  [R0402]  404.13 235.9 180 bottom
UNK2R104  49.9-1-S4  [R0402]  388.52 235.65 180 bottom
UNK2R105  49.9-1-S4  [R0402]  390.66 235.65 180 bottom
UNK2R117  1K-1-S4  [R0402]  452.18 233.88 0 bottom
UNK2R118  NC/0-5-S4  [R0402]  310.41 245.39 180 bottom
UNK2R119  4.7K-1-S4-WA  [R0402]  452.12 224.79 180 bottom
UNK2R120  4.7K-1-S4-WA  [R0402]  452.12 232.41 180 bottom
UNK2R125  0-5-S4  [R0402]  456.44 209.55 0 bottom
UNK2R126  0-5-S4  [R0402]  452.37 209.55 0 bottom
UNK2R127  0-5-S4  [R0402]  456.69 217.17 0 bottom
UNK2R128  0-5-S4  [R0402]  452.12 217.17 0 bottom
UNK2R129  0-5-S4  [R0402]  301.23 229.11 180 bottom
UNK2R130  0-5-S4  [R0402]  298.95 229.11 0 bottom
UNK2R131  50-0.1-S4-HF-VI  [R0402]  303.77 243.33 90 bottom
UNK2R132  50-0.1-S4-HF-VI  [R0402]  296.15 243.33 90 bottom
UNK2R133  0-5-S4  [R0402]  302.38 276.48 90 bottom
UNK2SH1  SHORT  [DEFAULT_SHORT_SMALL]  462.05 291.99 0 top
UNK2SH2  SHORT  [DEFAULT_SHORT_SMALL]  464 291.99 0 top
UNK2SH3  SHORT  [DEFAULT_SHORT_SMALL]  452.21 291.99 0 top
UNK2SH4  SHORT  [DEFAULT_SHORT_SMALL]  450.26 292.12 180 top
UNK2SH5  SHORT  [DEFAULT_SHORT_SMALL]  485.23 291.99 0 top
UNK2SH6  SHORT  [DEFAULT_SHORT_SMALL]  483.28 292.12 180 top
UNK2SH7  SHORT  [DEFAULT_SHORT_SMALL]  462.05 275.48 0 top
UNK2SH8  SHORT  [DEFAULT_SHORT_SMALL]  450.26 275.61 180 top
UNK2SH9  SHORT  [DEFAULT_SHORT_SMALL]  464 275.48 0 top
UNK2SH10  SHORT  [DEFAULT_SHORT_SMALL]  452.21 275.48 0 top
UNK2SH11  SHORT  [DEFAULT_SHORT_SMALL]  483.28 275.61 180 top
UNK2SH12  SHORT  [DEFAULT_SHORT_SMALL]  495.07 275.48 0 top
UNK2SH13  SHORT  [DEFAULT_SHORT_SMALL]  480.51 291.99 0 top
UNK2SH14  SHORT  [DEFAULT_SHORT_SMALL]  478.56 291.99 0 top
UNK2SH15  SHORT  [DEFAULT_SHORT_SMALL]  466.77 292.12 180 top
UNK2SH16  SHORT  [DEFAULT_SHORT_SMALL]  468.72 291.99 0 top
UNK2SH17  SHORT  [DEFAULT_SHORT_SMALL]  466.77 275.61 180 top
UNK2SH18  SHORT  [DEFAULT_SHORT_SMALL]  478.56 275.48 0 top
UNK2SH19  SHORT  [DEFAULT_SHORT_SMALL]  90.17 246.75 0 top
UNK2SH20  SHORT  [DEFAULT_SHORT_SMALL]  92.37 246.75 0 top
UNK2SH21  SHORT  [DEFAULT_SHORT_SMALL]  85.31 246.8 0 top
UNK2SH22  SHORT  [DEFAULT_SHORT_SMALL]  87.51 246.8 0 top
UNK2SH23  SHORT  [DEFAULT_SHORT_SMALL]  511.58 291.99 0 top
UNK2SH24  SHORT  [DEFAULT_SHORT_SMALL]  513.76 291.86 180 top
UNK2SH25  SHORT  [DEFAULT_SHORT_SMALL]  485.23 275.48 0 top
UNK2SH26  SHORT  [DEFAULT_SHORT_SMALL]  497.02 275.48 0 top
UNK2SH27  SHORT  [DEFAULT_SHORT_SMALL]  468.72 275.48 0 top
UNK2SH28  SHORT  [DEFAULT_SHORT_SMALL]  480.51 275.48 0 top
UNK2TP_AUXVCC  TP01  [TP_040_T]  92.04 247.9 180 top
UNK2TP_AVDD11_RX  TP01  [TP_040_T]  452.33 276.86 180 top
UNK2TP_AVDD11_XTAL  TP01  [TP_040_T]  511.6 293.37 0 top
UNK2TP_AVDD18_RX  TP01  [TP_040_T]  462.07 276.86 0 top
UNK2TP_PLL_M_VDD33  TP01  [TP_040_T]  478.58 293.37 0 top
UNK2TP_PLL_TX_VDD33  TP01  [TP_040_T]  468.84 293.37 180 top
UNK2TP_VCC3V3  TP01  [TP_040_T]  87.17 247.96 180 top
UNK2TP_VDD_IO_33  TP01  [TP_040_T]  452.33 293.37 180 top
UNK2TP_VDD_TXREG_33_B  TP01  [TP_040_T]  478.58 276.86 0 top
UNK2TP_VDD_TXREG_33_T  TP01  [TP_040_T]  468.84 276.86 180 top
UNK2TP_VDDA_33_LV  TP01  [TP_040_T]  462.07 293.37 0 top
UNK2TP_VDDC_11  TP01  [TP_040_T]  485.35 293.37 180 top
UNK2TP_VDDTXPST_11_B  TP01  [TP_040_T]  495.09 276.86 0 top
UNK2TP_VDDTXPST_11_T  TP01  [TP_040_T]  485.35 276.86 180 top
UNK2TP_XTAL_IN  TP01  [TP_040_T]  306.85 271.67 0 top
UNK2TP_XTAL_OUT  TP01  [TP_040_T]  306.85 276.97 0 top
UNK2U1  SOLDER-DIP8-SOCKET  [DIP8_300X100_RLPIN]  474.97 228.55 270 bottom
UNK2U2  SOLDER-DIP8-SOCKET  [DIP8_300X100_RLPIN]  474.87 214.94 270 bottom
UNK2UF1  MX25L4006EM2I-12G-SOP8  [SOCKET_CODE]  360.09 283.74 180 top
UNK2UF2  MX25L4006EM2I-12G-SOP8  [SOCKET_CODE]  474.97 228.55 90 top
UNK2Y1  XTAL27M-S2520-ABRACON-10P  [XTAL_2X2P5MM_4P]  298.76 274.89 270 bottom
UNK2Y2  NC/XTAL27M-S3225-TXC-10P  [XTAL_3P2X2P5MM_4P_TXC_0201]  298.76 274.89 270 bottom
UNK3C3  0.1U-16-X-S4-MU  [C0402]  192.28 132.33 180 bottom
UNK3C4  0.1U-16-X-S4-MU  [C0402]  189.74 132.33 180 bottom
UNK3C5  22P-50-N-S4-AVX  [C0402]  221.21 217.48 90 bottom
UNK3C6  22P-50-N-S4-AVX  [C0402]  221.21 211.16 270 bottom
UNK3C7  0.1U-16-X-S4-MU  [C0402]  111 186.44 0 bottom
UNK3C8  0.1U-16-X-S4-MU  [C0402]  104.39 171.81 180 bottom
UNK3C9  0.1U-16-X-S4-MU  [C0402]  104.49 185.42 180 bottom
UNK3CA1  NC/10U-10-X6S-S6-MU  [C0603]  112.39 290.83 0 bottom
UNK3CA2  NC/47U-10-X5R-S8-TDK  [C0805]  112.5 292.74 0 bottom
UNK3CA3  NC/10U-10-X6S-S6-MU  [C0603]  100.96 290.83 180 bottom
UNK3CA4  NC/47U-10-X5R-S8-TDK  [C0805]  100.86 292.74 180 bottom
UNK3CA5  NC/10U-10-X6S-S6-MU  [C0603]  100.96 274.32 180 bottom
UNK3CA6  NC/47U-10-X5R-S8-TDK  [C0805]  100.86 276.23 180 bottom
UNK3CA7  NC/10U-10-X6S-S6-MU  [C0603]  128.9 274.32 0 bottom
UNK3CA8  NC/47U-10-X5R-S8-TDK  [C0805]  129.01 276.23 0 bottom
UNK3CA9  NC/10U-10-X6S-S6-MU  [C0603]  117.47 274.32 180 bottom
UNK3CA10  NC/47U-10-X5R-S8-TDK  [C0805]  117.37 276.23 180 bottom
UNK3CA11  NC/10U-10-X6S-S6-MU  [C0603]  76.83 290.83 0 bottom
UNK3CA12  NC/47U-10-X5R-S8-TDK  [C0805]  76.94 292.74 0 bottom
UNK3CA13  NC/47U-10-X5R-S8-TDK  [C0805]  94.72 292.74 0 bottom
UNK3CA14  NC/10U-10-X6S-S6-MU  [C0603]  94.61 290.83 0 bottom
UNK3CA15  NC/47U-10-X5R-S8-TDK  [C0805]  83.08 292.74 180 bottom
UNK3CA16  NC/10U-10-X6S-S6-MU  [C0603]  83.18 290.83 180 bottom
UNK3CA17  NC/47U-10-X5R-S8-TDK  [C0805]  76.94 276.23 0 bottom
UNK3CA18  NC/10U-10-X6S-S6-MU  [C0603]  76.83 274.32 0 bottom
UNK3CA19  NC/47U-10-X5R-S8-TDK  [C0805]  111.1 249.13 180 bottom
UNK3CA20  NC/10U-10-X6S-S6-MU  [C0603]  111.2 247.23 180 bottom
UNK3CA21  10U-10-X6S-S6-MU  [C0603]  112.39 288.29 0 bottom
UNK3CA22  10U-10-X6S-S6-MU  [C0603]  100.96 288.29 180 bottom
UNK3CA23  10U-10-X6S-S6-MU  [C0603]  100.96 271.78 180 bottom
UNK3CA24  10U-10-X6S-S6-MU  [C0603]  128.9 271.78 0 bottom
UNK3CA25  10U-10-X6S-S6-MU  [C0603]  117.47 271.78 180 bottom
UNK3CA26  10U-10-X6S-S6-MU  [C0603]  76.83 288.29 0 bottom
UNK3CA27  10U-10-X6S-S6-MU  [C0603]  94.61 288.29 0 bottom
UNK3CA28  10U-10-X6S-S6-MU  [C0603]  83.18 288.29 180 bottom
UNK3CA29  10U-10-X6S-S6-MU  [C0603]  76.83 271.78 0 bottom
UNK3CA30  NC/47U-10-X5R-S8-TDK  [C0805]  106.23 249.19 180 bottom
UNK3CA31  10U-10-X6S-S6-MU  [C0603]  106.33 247.28 180 bottom
UNK3CA32  NC/10U-10-X6S-S6-MU  [C0603]  94.61 274.32 0 bottom
UNK3CA33  NC/47U-10-X5R-S8-TDK  [C0805]  94.72 276.23 0 bottom
UNK3CA34  10U-10-X6S-S6-MU  [C0603]  94.61 271.78 0 bottom
UNK3CA35  NC/10U-10-X6S-S6-MU  [C0603]  65.4 290.83 180 bottom
UNK3CA36  NC/47U-10-X5R-S8-TDK  [C0805]  65.3 292.74 180 bottom
UNK3CA37  10U-10-X6S-S6-MU  [C0603]  65.4 288.29 180 bottom
UNK3CA38  NC/10U-10-X6S-S6-MU  [C0603]  65.4 274.32 180 bottom
UNK3CA39  NC/47U-10-X5R-S8-TDK  [C0805]  65.3 276.23 180 bottom
UNK3CA40  10U-10-X6S-S6-MU  [C0603]  65.4 271.78 180 bottom
UNK3CC1  0.47U-10-X6S-S2-TY  [C0201]  237.98 164.12 90 bottom
UNK3CC2  4.7U-10-X6T-S4-MU  [C0402]  236.32 162.4 270 bottom
UNK3CC4  0.47U-10-X6S-S2-TY  [C0201]  229.81 187.93 0 bottom
UNK3CC6  0.47U-10-X6S-S2-TY  [C0201]  250.17 164.12 90 bottom
UNK3CC7  0.47U-10-X6S-S2-TY  [C0201]  229.81 186.66 0 bottom
UNK3CC8  0.47U-10-X6S-S2-TY  [C0201]  263.63 164.12 90 bottom
UNK3CC9  0.47U-10-X6S-S2-TY  [C0201]  254.61 206.16 270 bottom
UNK3CC11  0.47U-10-X6S-S2-TY  [C0201]  251.06 164.12 90 bottom
UNK3CC13  0.47U-10-X6S-S2-TY  [C0201]  256.77 164.12 90 bottom
UNK3CC15  4.7U-2.5-X6S-S2-MU  [C0201]  259.65 204.95 90 bottom
UNK3CC16  NC/4.7U-2.5-X6S-S2-MU  [C0201]  271.64 189.5 0 bottom
UNK3CC17  4.7U-2.5-X6S-S2-MU  [C0201]  229.81 193.69 0 bottom
UNK3CC19  0.47U-10-X6S-S2-TY  [C0201]  252.83 206.16 270 bottom
UNK3CC20  4.7U-10-X6T-S4-MU  [C0402]  254.11 207.66 0 bottom
UNK3CC22  0.47U-10-X6S-S2-TY  [C0201]  251.05 206.16 270 bottom
UNK3CC23  4.7U-10-X6T-S4-MU  [C0402]  250.34 193.09 270 bottom
UNK3CC25  0.47U-10-X6S-S2-TY  [C0201]  272.85 185.18 180 bottom
UNK3CC26  0.47U-10-X6S-S2-TY  [C0201]  253.72 206.16 270 bottom
UNK3CC27  0.47U-10-X6S-S2-TY  [C0201]  272.85 189.5 180 bottom
UNK3CC28  0.47U-10-X6S-S2-TY  [C0201]  259.65 206.16 270 bottom
UNK3CC29  0.47U-10-X6S-S2-TY  [C0201]  231.03 193.69 180 bottom
UNK3CC30  0.47U-10-X6S-S2-TY  [C0201]  229.81 183.41 0 bottom
UNK3CC31  0.47U-10-X6S-S2-TY  [C0201]  249.28 164.12 90 bottom
UNK3CC32  0.47U-10-X6S-S2-TY  [C0201]  262.36 164.12 90 bottom
UNK3CC33  0.47U-10-X6S-S2-TY  [C0201]  272.85 183.91 180 bottom
UNK3CC34  0.47U-10-X6S-S2-TY  [C0201]  251.94 206.16 270 bottom
UNK3CC35  0.47U-10-X6S-S2-TY  [C0201]  272.85 181.37 180 bottom
UNK3CC36  0.47U-10-X6S-S2-TY  [C0201]  272.85 182.64 180 bottom
UNK3CC37  0.47U-10-X6S-S2-TY  [C0201]  247.57 204.95 90 bottom
UNK3CC38  NC/4.7U-2.5-X6S-S2-MU  [C0201]  247.57 206.16 270 bottom
UNK3CC39  0.47U-10-X6S-S2-TY  [C0201]  231.03 189.2 180 bottom
UNK3CC40  4.7U-2.5-X6S-S2-MU  [C0201]  258.5 186.67 180 bottom
UNK3CC41  4.7U-2.5-X6S-S2-MU  [C0201]  229.81 189.2 0 bottom
UNK3CC42  4.7U-2.5-X6S-S2-MU  [C0201]  251.54 193.03 90 bottom
UNK3CD1  0.1U-10-X7R-S2-MU  [C0201]  237.98 165.34 270 top
UNK3CD3  0.1U-10-X7R-S2-MU  [C0201]  271.64 181.37 0 top
UNK3CD4  0.1U-10-X7R-S2-MU  [C0201]  254.61 204.95 90 top
UNK3CD5  0.1U-10-X7R-S2-MU  [C0201]  263.63 165.34 270 top
UNK3CD6  0.1U-10-X7R-S2-MU  [C0201]  231.03 186.66 180 top
UNK3CD7  0.1U-10-X7R-S2-MU  [C0201]  271.64 182.64 0 top
UNK3CD8  0.1U-10-X7R-S2-MU  [C0201]  251.06 165.34 270 top
UNK3CD9  0.1U-10-X7R-S2-MU  [C0201]  256.77 165.34 270 top
UNK3CD10  0.1U-10-X7R-S2-MU  [C0201]  271.64 189.5 0 top
UNK3CD11  0.1U-10-X7R-S2-MU  [C0201]  259.65 204.95 90 top
UNK3CD12  0.1U-10-X7R-S2-MU  [C0201]  231.03 193.69 180 top
UNK3CD13  0.1U-10-X7R-S2-MU  [C0201]  252.83 204.95 90 top
UNK3CD14  0.1U-10-X7R-S2-MU  [C0201]  251.05 204.95 90 top
UNK3CD15  0.1U-10-X7R-S2-MU  [C0201]  271.64 185.18 0 top
UNK3CD16  0.1U-10-X7R-S2-MU  [C0201]  253.72 204.95 90 top
UNK3CD17  0.1U-10-X7R-S2-MU  [C0201]  231.03 187.93 180 top
UNK3CD18  0.1U-10-X7R-S2-MU  [C0201]  251.94 204.95 90 top
UNK3CD19  0.1U-10-X7R-S2-MU  [C0201]  231.03 183.41 180 top
UNK3CD20  0.1U-10-X7R-S2-MU  [C0201]  271.64 183.91 0 top
UNK3CD21  0.1U-10-X7R-S2-MU  [C0201]  262.36 165.34 270 top
UNK3CD22  0.1U-10-X7R-S2-MU  [C0201]  249.28 165.34 270 top
UNK3CD23  0.1U-10-X7R-S2-MU  [C0201]  250.17 165.34 270 top
UNK3CD24  0.1U-10-X7R-S2-MU  [C0201]  247.57 204.95 90 top
UNK3CD25  0.1U-10-X7R-S2-MU  [C0201]  231.03 189.2 180 top
UNK3GND1  TP01  [TP_040_T]  99.91 292.74 0 top
UNK3GND2  TP01  [TP_040_T]  113.45 292.74 180 top
UNK3GND3  TP01  [TP_040_T]  99.91 276.23 0 top
UNK3GND4  TP01  [TP_040_T]  116.42 276.23 0 top
UNK3GND5  TP01  [TP_040_T]  129.96 276.23 180 top
UNK3GND6  TP01  [TP_040_T]  64.35 292.74 0 top
UNK3GND7  TP01  [TP_040_T]  95.67 292.74 180 top
UNK3GND8  TP01  [TP_040_T]  82.13 292.74 0 top
UNK3GND9  TP01  [TP_040_T]  77.89 276.23 180 top
UNK3GND10  TP01  [TP_040_T]  110.12 249.08 0 top
UNK3GND11  TP01  [TP_040_T]  105.25 249.13 0 top
UNK3GND12  TP01  [TP_040_T]  95.67 276.23 180 top
UNK3GND13  TP01  [TP_040_T]  77.89 292.74 180 top
UNK3GND14  TP01  [TP_040_T]  64.35 276.23 0 top
UNK3J1  HDR-2X1-M  [JP_2P_100]  110.49 188.72 270 bottom
UNK3J2  HDR-3X1-M  [JP_3P_100]  89.01 161.74 90 bottom
UNK3J3  HDR-3X1-M  [JP_3P_100]  89.01 175.46 90 bottom
UNK3J4  HDR-2X1-M  [JP_2P_100]  96.52 187.71 90 bottom
UNK3J5  HDR-2X1-M  [JP_2P_100]  96.52 199.39 90 bottom
UNK3K1  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  171.7 178.31 270 bottom
UNK3K2  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  252.98 136.14 180 bottom
UNK3K3  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  265.94 139.19 180 bottom
UNK3K4  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  279.15 151.38 180 bottom
UNK3K5  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  205.23 219.2 270 bottom
UNK3K6  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  188.47 219.2 270 bottom
UNK3K7  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  188.47 205.74 270 bottom
UNK3K8  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  188.47 191.77 270 bottom
UNK3K9  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  219.96 175.46 90 bottom
UNK3K10  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  112.01 193.55 0 bottom
UNK3K11  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  171.7 205.74 270 bottom
UNK3K12  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  219.96 186.89 90 bottom
UNK3K13  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  123.95 185.93 180 bottom
UNK3K14  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  112.27 177.04 180 bottom
UNK3K15  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  124.24 169.5 180 bottom
UNK3K16  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  205.23 205.74 270 bottom
UNK3K17  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  171.7 191.77 270 bottom
UNK3K18  UB2-5NU-B  [RL_NECUB2_5V]  228.45 214.32 0 bottom
UNK3K19  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  112.27 169.42 180 bottom
UNK3K20  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  124.21 177.04 180 bottom
UNK3K21  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  205.23 191.77 270 bottom
UNK3K22  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  171.7 137.92 270 bottom
UNK3K23  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  205.49 151.38 270 bottom
UNK3K24  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  188.47 151.13 270 bottom
UNK3K25  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  171.7 151.13 270 bottom
UNK3K26  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  188.47 164.85 270 bottom
UNK3K27  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  205.49 164.85 270 bottom
UNK3K28  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  100.58 193.55 0 bottom
UNK3K29  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  205.49 178.31 270 bottom
UNK3K30  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  171.7 164.85 270 bottom
UNK3K31  EC2-5NJ-A  [RL_NECEC2_10P_5V]  88.9 275.59 90 bottom
UNK3K33  NC/UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  123.95 193.55 180 bottom
UNK3K34  EC2-5NJ-A  [RL_NECEC2_10P_5V]  106.68 292.1 90 bottom
UNK3K36  EC2-5NJ-A  [RL_NECEC2_10P_5V]  106.68 275.59 90 bottom
UNK3K37  EC2-5NJ-A  [RL_NECEC2_10P_5V]  123.19 275.59 90 bottom
UNK3K39  EC2-5NJ-A  [RL_NECEC2_10P_5V]  71.12 292.1 90 bottom
UNK3K40  EC2-5NJ-A  [RL_NECEC2_10P_5V]  88.9 292.1 90 bottom
UNK3K42  EC2-5NJ-A  [RL_NECEC2_10P_5V]  71.12 275.59 90 bottom
UNK3K43  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  188.47 178.31 270 bottom
UNK3R1  NC/1M-1-S4  [R0402]  221.23 167.84 180 bottom
UNK3R2  NC/1M-1-S4  [R0402]  218.95 167.84 0 bottom
UNK3R3  NC/100K-1-S4  [R0402]  192.28 131.06 180 bottom
UNK3R4  NC/100K-1-S4  [R0402]  189.74 131.06 180 bottom
UNK3R5  0-5-S4  [R0402]  222.38 212.16 270 bottom
UNK3R6  1M-1-S4  [R0402]  222.38 214.32 270 bottom
UNK3R7  49.9-1-S4  [R0402]  178.5 176.63 90 bottom
UNK3R8  49.9-1-S4  [R0402]  178.5 174.49 90 bottom
UNK3R9  49.9-1-S4  [R0402]  164.91 176.63 90 bottom
UNK3R10  49.9-1-S4  [R0402]  164.91 174.49 90 bottom
UNK3R11  49.9-1-S4  [R0402]  251.31 129.35 0 bottom
UNK3R12  49.9-1-S4  [R0402]  249.16 129.35 0 bottom
UNK3R13  49.9-1-S4  [R0402]  251.31 142.94 0 bottom
UNK3R14  49.9-1-S4  [R0402]  249.16 142.94 0 bottom
UNK3R15  49.9-1-S4  [R0402]  264.26 132.4 0 bottom
UNK3R16  49.9-1-S4  [R0402]  262.12 132.4 0 bottom
UNK3R17  49.9-1-S4  [R0402]  264.26 145.99 0 bottom
UNK3R18  49.9-1-S4  [R0402]  262.12 145.99 0 bottom
UNK3R19  49.9-1-S4  [R0402]  277.47 144.59 0 bottom
UNK3R20  49.9-1-S4  [R0402]  275.32 144.59 0 bottom
UNK3R21  49.9-1-S4  [R0402]  277.47 158.18 0 bottom
UNK3R22  49.9-1-S4  [R0402]  275.32 158.18 0 bottom
UNK3R23  49.9-1-S4  [R0402]  212.03 217.52 90 bottom
UNK3R24  49.9-1-S4  [R0402]  212.03 215.38 90 bottom
UNK3R25  49.9-1-S4  [R0402]  198.44 217.52 90 bottom
UNK3R26  49.9-1-S4  [R0402]  198.44 215.38 90 bottom
UNK3R27  49.9-1-S4  [R0402]  195.26 217.52 90 bottom
UNK3R28  49.9-1-S4  [R0402]  195.26 215.38 90 bottom
UNK3R29  49.9-1-S4  [R0402]  181.67 217.52 90 bottom
UNK3R30  49.9-1-S4  [R0402]  181.67 215.38 90 bottom
UNK3R31  49.9-1-S4  [R0402]  195.26 204.06 90 bottom
UNK3R32  49.9-1-S4  [R0402]  195.26 201.92 90 bottom
UNK3R33  49.9-1-S4  [R0402]  181.67 204.06 90 bottom
UNK3R34  49.9-1-S4  [R0402]  181.67 201.92 90 bottom
UNK3R37  49.9-1-S4  [R0402]  181.67 190.09 90 bottom
UNK3R38  49.9-1-S4  [R0402]  181.67 187.95 90 bottom
UNK3R39  49.9-1-S4  [R0402]  178.5 204.06 90 bottom
UNK3R40  49.9-1-S4  [R0402]  178.5 201.92 90 bottom
UNK3R41  49.9-1-S4  [R0402]  164.91 204.06 90 bottom
UNK3R42  49.9-1-S4  [R0402]  164.91 201.92 90 bottom
UNK3R43  49.9-1-S4  [R0402]  198.69 176.63 90 bottom
UNK3R44  49.9-1-S4  [R0402]  198.69 174.49 90 bottom
UNK3R45  49.9-1-S4  [R0402]  164.91 136.24 90 bottom
UNK3R46  49.9-1-S4  [R0402]  164.91 134.1 90 bottom
UNK3R47  49.9-1-S4  [R0402]  212.28 149.71 90 bottom
UNK3R48  49.9-1-S4  [R0402]  212.28 147.56 90 bottom
UNK3R49  49.9-1-S4  [R0402]  198.69 149.71 90 bottom
UNK3R50  49.9-1-S4  [R0402]  198.69 147.56 90 bottom
UNK3R51  49.9-1-S4  [R0402]  195.26 149.45 90 bottom
UNK3R52  49.9-1-S4  [R0402]  195.26 147.31 90 bottom
UNK3R53  49.9-1-S4  [R0402]  181.67 149.45 90 bottom
UNK3R54  49.9-1-S4  [R0402]  181.67 147.31 90 bottom
UNK3R55  49.9-1-S4  [R0402]  178.5 149.45 90 bottom
UNK3R56  49.9-1-S4  [R0402]  178.5 147.31 90 bottom
UNK3R57  49.9-1-S4  [R0402]  164.91 149.45 90 bottom
UNK3R58  49.9-1-S4  [R0402]  164.91 147.31 90 bottom
UNK3R59  49.9-1-S4  [R0402]  195.26 163.17 90 bottom
UNK3R60  49.9-1-S4  [R0402]  195.26 161.02 90 bottom
UNK3R61  49.9-1-S4  [R0402]  181.67 163.17 90 bottom
UNK3R62  49.9-1-S4  [R0402]  181.67 161.02 90 bottom
UNK3R63  49.9-1-S4  [R0402]  178.5 163.17 90 bottom
UNK3R64  49.9-1-S4  [R0402]  178.5 161.02 90 bottom
UNK3R65  49.9-1-S4  [R0402]  198.69 163.17 90 bottom
UNK3R66  49.9-1-S4  [R0402]  198.69 161.02 90 bottom
UNK3R67  49.9-1-S4  [R0402]  212.03 204.06 90 bottom
UNK3R68  49.9-1-S4  [R0402]  212.03 201.92 90 bottom
UNK3R69  49.9-1-S4  [R0402]  198.44 204.06 90 bottom
UNK3R70  49.9-1-S4  [R0402]  198.44 201.92 90 bottom
UNK3R71  49.9-1-S4  [R0402]  178.5 190.09 90 bottom
UNK3R72  49.9-1-S4  [R0402]  178.5 187.95 90 bottom
UNK3R73  49.9-1-S4  [R0402]  164.91 190.09 90 bottom
UNK3R74  49.9-1-S4  [R0402]  164.91 187.95 90 bottom
UNK3R75  49.9-1-S4  [R0402]  212.03 190.09 90 bottom
UNK3R76  49.9-1-S4  [R0402]  212.03 187.95 90 bottom
UNK3R77  49.9-1-S4  [R0402]  198.44 190.09 90 bottom
UNK3R78  49.9-1-S4  [R0402]  198.44 187.95 90 bottom
UNK3R79  49.9-1-S4  [R0402]  212.28 176.63 90 bottom
UNK3R80  49.9-1-S4  [R0402]  212.28 174.49 90 bottom
UNK3R82  4.7K-1-S4-WA  [R0402]  122.88 197.41 180 bottom
UNK3R83  4.7K-1-S4-WA  [R0402]  97.03 189.74 180 bottom
UNK3R84  4.7K-1-S4-WA  [R0402]  97.03 197.36 180 bottom
UNK3R85  100K-1-S4  [R0402]  114.05 186.44 180 bottom
UNK3R86  4.7K-1-S4-WA  [R0402]  93.59 163.77 180 bottom
UNK3R87  4.7K-1-S4-WA  [R0402]  104.39 159.62 180 bottom
UNK3R88  4.7K-1-S4-WA  [R0402]  101.85 159.62 180 bottom
UNK3R89  4.7K-1-S4-WA  [R0402]  89.28 163.72 0 bottom
UNK3R90  4.7K-1-S4-WA  [R0402]  101.85 171.81 180 bottom
UNK3R91  4.7K-1-S4-WA  [R0402]  99.31 171.81 180 bottom
UNK3R92  4.7K-1-S4-WA  [R0402]  96.77 171.81 180 bottom
UNK3R93  4.7K-1-S4-WA  [R0402]  93.59 177.49 180 bottom
UNK3R94  4.7K-1-S4-WA  [R0402]  104.51 173.17 0 bottom
UNK3R95  4.7K-1-S4-WA  [R0402]  101.95 173.22 180 bottom
UNK3R96  4.7K-1-S4-WA  [R0402]  89.52 177.49 0 bottom
UNK3R97  4.7K-1-S4-WA  [R0402]  101.95 185.42 180 bottom
UNK3R98  4.7K-1-S4-WA  [R0402]  99.41 185.42 180 bottom
UNK3R99  4.7K-1-S4-WA  [R0402]  96.87 185.42 180 bottom
UNK3R100  49.9-1-S4  [R0402]  164.91 163.17 90 bottom
UNK3R101  49.9-1-S4  [R0402]  164.91 161.02 90 bottom
UNK3R102  49.9-1-S4  [R0402]  178.5 136.24 90 bottom
UNK3R103  49.9-1-S4  [R0402]  178.5 134.1 90 bottom
UNK3R104  49.9-1-S4  [R0402]  212.28 163.17 90 bottom
UNK3R105  49.9-1-S4  [R0402]  212.28 161.02 90 bottom
UNK3R117  1K-1-S4  [R0402]  127.45 197.41 180 bottom
UNK3R118  NC/0-5-S4  [R0402]  230.41 185.39 180 bottom
UNK3R119  4.7K-1-S4-WA  [R0402]  127.51 189.74 0 bottom
UNK3R120  4.7K-1-S4-WA  [R0402]  127.51 182.12 0 bottom
UNK3R125  0-5-S4  [R0402]  123.44 180.85 180 bottom
UNK3R126  0-5-S4  [R0402]  127.51 180.85 180 bottom
UNK3R127  0-5-S4  [R0402]  123.19 173.23 180 bottom
UNK3R128  0-5-S4  [R0402]  127.76 173.23 180 bottom
UNK3R129  0-5-S4  [R0402]  221.23 169.11 180 bottom
UNK3R130  0-5-S4  [R0402]  218.95 169.11 0 bottom
UNK3R131  50-0.1-S4-HF-VI  [R0402]  223.77 183.33 90 bottom
UNK3R132  50-0.1-S4-HF-VI  [R0402]  216.15 183.33 90 bottom
UNK3R133  0-5-S4  [R0402]  222.38 216.48 90 bottom
UNK3SH1  SHORT  [DEFAULT_SHORT_SMALL]  111.53 289.45 0 top
UNK3SH2  SHORT  [DEFAULT_SHORT_SMALL]  113.48 289.45 0 top
UNK3SH3  SHORT  [DEFAULT_SHORT_SMALL]  101.69 289.45 0 top
UNK3SH4  SHORT  [DEFAULT_SHORT_SMALL]  99.74 289.58 180 top
UNK3SH5  SHORT  [DEFAULT_SHORT_SMALL]  101.69 272.94 0 top
UNK3SH6  SHORT  [DEFAULT_SHORT_SMALL]  99.74 273.07 180 top
UNK3SH7  SHORT  [DEFAULT_SHORT_SMALL]  128.04 272.94 0 top
UNK3SH8  SHORT  [DEFAULT_SHORT_SMALL]  116.25 273.07 180 top
UNK3SH9  SHORT  [DEFAULT_SHORT_SMALL]  129.99 272.94 0 top
UNK3SH10  SHORT  [DEFAULT_SHORT_SMALL]  118.2 272.94 0 top
UNK3SH11  SHORT  [DEFAULT_SHORT_SMALL]  64.18 289.58 180 top
UNK3SH12  SHORT  [DEFAULT_SHORT_SMALL]  75.97 289.45 0 top
UNK3SH13  SHORT  [DEFAULT_SHORT_SMALL]  95.7 289.45 0 top
UNK3SH14  SHORT  [DEFAULT_SHORT_SMALL]  93.75 289.45 0 top
UNK3SH15  SHORT  [DEFAULT_SHORT_SMALL]  81.96 289.58 180 top
UNK3SH16  SHORT  [DEFAULT_SHORT_SMALL]  83.91 289.45 0 top
UNK3SH17  SHORT  [DEFAULT_SHORT_SMALL]  58.65 287.91 180 top
UNK3SH18  SHORT  [DEFAULT_SHORT_SMALL]  75.97 272.94 0 top
UNK3SH19  SHORT  [DEFAULT_SHORT_SMALL]  110.18 246.07 0 top
UNK3SH20  SHORT  [DEFAULT_SHORT_SMALL]  112.38 246.07 0 top
UNK3SH21  SHORT  [DEFAULT_SHORT_SMALL]  105.32 246.12 0 top
UNK3SH22  SHORT  [DEFAULT_SHORT_SMALL]  107.52 246.12 0 top
UNK3SH23  SHORT  [DEFAULT_SHORT_SMALL]  93.75 272.94 0 top
UNK3SH24  SHORT  [DEFAULT_SHORT_SMALL]  95.93 272.81 180 top
UNK3SH25  SHORT  [DEFAULT_SHORT_SMALL]  66.13 289.45 0 top
UNK3SH26  SHORT  [DEFAULT_SHORT_SMALL]  77.92 289.45 0 top
UNK3SH27  SHORT  [DEFAULT_SHORT_SMALL]  66.13 272.94 0 top
UNK3SH28  SHORT  [DEFAULT_SHORT_SMALL]  77.92 272.94 0 top
UNK3TP_AUXVCC  TP01  [TP_040_T]  112.05 247.23 180 top
UNK3TP_AVDD11_RX  TP01  [TP_040_T]  118.32 274.32 180 top
UNK3TP_AVDD11_XTAL  TP01  [TP_040_T]  93.77 274.32 0 top
UNK3TP_AVDD18_RX  TP01  [TP_040_T]  128.06 274.32 0 top
UNK3TP_PLL_M_VDD33  TP01  [TP_040_T]  93.77 290.83 0 top
UNK3TP_PLL_TX_VDD33  TP01  [TP_040_T]  84.03 290.83 180 top
UNK3TP_VCC3V3  TP01  [TP_040_T]  107.18 247.28 180 top
UNK3TP_VDD_IO_33  TP01  [TP_040_T]  101.81 290.83 180 top
UNK3TP_VDD_TXREG_33_B  TP01  [TP_040_T]  75.99 274.32 0 top
UNK3TP_VDD_TXREG_33_T  TP01  [TP_040_T]  66.25 274.32 180 top
UNK3TP_VDDA_33_LV  TP01  [TP_040_T]  111.55 290.83 0 top
UNK3TP_VDDC_11  TP01  [TP_040_T]  101.81 274.32 180 top
UNK3TP_VDDTXPST_11_B  TP01  [TP_040_T]  75.99 290.83 0 top
UNK3TP_VDDTXPST_11_T  TP01  [TP_040_T]  66.25 290.83 180 top
UNK3TP_XTAL_IN  TP01  [TP_040_T]  226.85 211.67 0 top
UNK3TP_XTAL_OUT  TP01  [TP_040_T]  226.85 216.97 0 top
UNK3U1  SOLDER-DIP8-SOCKET  [DIP8_300X100_RLPIN]  104.91 161.85 90 bottom
UNK3U2  SOLDER-DIP8-SOCKET  [DIP8_300X100_RLPIN]  105.02 175.46 90 bottom
UNK3UF1  MX25L4006EM2I-12G-SOP8  [SOCKET_CODE]  104.91 161.85 270 top
UNK3UF2  MX25L4006EM2I-12G-SOP8  [SOCKET_CODE]  105 175.51 270 top
UNK3Y1  XTAL27M-S2520-ABRACON-10P  [XTAL_2X2P5MM_4P]  218.76 214.89 270 bottom
UNK3Y2  NC/XTAL27M-S3225-TXC-10P  [XTAL_3P2X2P5MM_4P_TXC_0201]  218.76 214.89 270 bottom
UNK4C3  0.1U-16-X-S4-MU  [C0402]  299.72 132.08 180 bottom
UNK4C4  0.1U-16-X-S4-MU  [C0402]  297.18 132.08 180 bottom
UNK4C5  22P-50-N-S4-AVX  [C0402]  301.21 217.48 90 bottom
UNK4C6  22P-50-N-S4-AVX  [C0402]  301.21 211.16 270 bottom
UNK4C7  0.1U-16-X-S4-MU  [C0402]  468.12 192.28 180 bottom
UNK4C8  0.1U-16-X-S4-MU  [C0402]  475.39 161.55 0 bottom
UNK4C9  0.1U-16-X-S4-MU  [C0402]  475.49 175.15 0 bottom
UNK4CA1  NC/10U-10-X6S-S6-MU  [C0603]  512.44 276.86 0 bottom
UNK4CA2  NC/47U-10-X5R-S8-TDK  [C0805]  512.55 278.76 0 bottom
UNK4CA3  NC/10U-10-X6S-S6-MU  [C0603]  501.01 276.86 180 bottom
UNK4CA4  NC/47U-10-X5R-S8-TDK  [C0805]  500.91 278.76 180 bottom
UNK4CA5  NC/10U-10-X6S-S6-MU  [C0603]  517.52 293.37 180 bottom
UNK4CA6  NC/47U-10-X5R-S8-TDK  [C0805]  517.42 295.27 180 bottom
UNK4CA7  NC/10U-10-X6S-S6-MU  [C0603]  528.95 276.86 0 bottom
UNK4CA8  NC/47U-10-X5R-S8-TDK  [C0805]  529.06 278.76 0 bottom
UNK4CA9  NC/10U-10-X6S-S6-MU  [C0603]  517.52 276.86 180 bottom
UNK4CA10  NC/47U-10-X5R-S8-TDK  [C0805]  517.42 278.76 180 bottom
UNK4CA11  NC/10U-10-X6S-S6-MU  [C0603]  528.95 260.35 0 bottom
UNK4CA12  NC/47U-10-X5R-S8-TDK  [C0805]  529.06 262.25 0 bottom
UNK4CA13  NC/47U-10-X5R-S8-TDK  [C0805]  496.04 262.25 0 bottom
UNK4CA14  NC/10U-10-X6S-S6-MU  [C0603]  495.93 260.35 0 bottom
UNK4CA15  NC/47U-10-X5R-S8-TDK  [C0805]  484.4 262.25 180 bottom
UNK4CA16  NC/10U-10-X6S-S6-MU  [C0603]  484.5 260.35 180 bottom
UNK4CA17  NC/47U-10-X5R-S8-TDK  [C0805]  479.53 262.25 0 bottom
UNK4CA18  NC/10U-10-X6S-S6-MU  [C0603]  479.42 260.35 0 bottom
UNK4CA19  NC/47U-10-X5R-S8-TDK  [C0805]  121.24 249.66 180 bottom
UNK4CA20  NC/10U-10-X6S-S6-MU  [C0603]  121.34 247.75 180 bottom
UNK4CA21  10U-10-X6S-S6-MU  [C0603]  512.44 274.32 0 bottom
UNK4CA22  10U-10-X6S-S6-MU  [C0603]  501.01 274.32 180 bottom
UNK4CA23  10U-10-X6S-S6-MU  [C0603]  517.52 290.83 180 bottom
UNK4CA24  10U-10-X6S-S6-MU  [C0603]  528.95 274.32 0 bottom
UNK4CA25  10U-10-X6S-S6-MU  [C0603]  517.52 274.32 180 bottom
UNK4CA26  10U-10-X6S-S6-MU  [C0603]  528.95 257.81 0 bottom
UNK4CA27  10U-10-X6S-S6-MU  [C0603]  495.93 257.81 0 bottom
UNK4CA28  10U-10-X6S-S6-MU  [C0603]  484.5 257.81 180 bottom
UNK4CA29  10U-10-X6S-S6-MU  [C0603]  479.42 257.81 0 bottom
UNK4CA30  NC/47U-10-X5R-S8-TDK  [C0805]  116.38 249.71 180 bottom
UNK4CA31  10U-10-X6S-S6-MU  [C0603]  116.48 247.8 180 bottom
UNK4CA32  NC/10U-10-X6S-S6-MU  [C0603]  512.44 260.35 0 bottom
UNK4CA33  NC/47U-10-X5R-S8-TDK  [C0805]  512.55 262.25 0 bottom
UNK4CA34  10U-10-X6S-S6-MU  [C0603]  512.44 257.81 0 bottom
UNK4CA35  NC/10U-10-X6S-S6-MU  [C0603]  517.52 260.35 180 bottom
UNK4CA36  NC/47U-10-X5R-S8-TDK  [C0805]  517.42 262.25 180 bottom
UNK4CA37  10U-10-X6S-S6-MU  [C0603]  517.52 257.81 180 bottom
UNK4CA38  NC/10U-10-X6S-S6-MU  [C0603]  468 260.35 180 bottom
UNK4CA39  NC/47U-10-X5R-S8-TDK  [C0805]  467.89 262.25 180 bottom
UNK4CA40  10U-10-X6S-S6-MU  [C0603]  468 257.81 180 bottom
UNK4CC1  0.47U-10-X6S-S2-TY  [C0201]  317.98 164.12 90 bottom
UNK4CC2  4.7U-10-X6T-S4-MU  [C0402]  316.32 162.4 270 bottom
UNK4CC4  0.47U-10-X6S-S2-TY  [C0201]  309.81 187.93 0 bottom
UNK4CC6  0.47U-10-X6S-S2-TY  [C0201]  330.17 164.12 90 bottom
UNK4CC7  0.47U-10-X6S-S2-TY  [C0201]  309.81 186.66 0 bottom
UNK4CC8  0.47U-10-X6S-S2-TY  [C0201]  343.63 164.12 90 bottom
UNK4CC9  0.47U-10-X6S-S2-TY  [C0201]  334.61 206.16 270 bottom
UNK4CC11  0.47U-10-X6S-S2-TY  [C0201]  331.06 164.12 90 bottom
UNK4CC13  0.47U-10-X6S-S2-TY  [C0201]  336.77 164.12 90 bottom
UNK4CC15  4.7U-2.5-X6S-S2-MU  [C0201]  339.65 204.95 90 bottom
UNK4CC16  NC/4.7U-2.5-X6S-S2-MU  [C0201]  351.64 189.5 0 bottom
UNK4CC17  4.7U-2.5-X6S-S2-MU  [C0201]  309.81 193.69 0 bottom
UNK4CC19  0.47U-10-X6S-S2-TY  [C0201]  332.83 206.16 270 bottom
UNK4CC20  4.7U-10-X6T-S4-MU  [C0402]  334.11 207.66 0 bottom
UNK4CC22  0.47U-10-X6S-S2-TY  [C0201]  331.05 206.16 270 bottom
UNK4CC23  4.7U-10-X6T-S4-MU  [C0402]  330.34 193.09 270 bottom
UNK4CC25  0.47U-10-X6S-S2-TY  [C0201]  352.85 185.18 180 bottom
UNK4CC26  0.47U-10-X6S-S2-TY  [C0201]  333.72 206.16 270 bottom
UNK4CC27  0.47U-10-X6S-S2-TY  [C0201]  352.85 189.5 180 bottom
UNK4CC28  0.47U-10-X6S-S2-TY  [C0201]  339.65 206.16 270 bottom
UNK4CC29  0.47U-10-X6S-S2-TY  [C0201]  311.03 193.69 180 bottom
UNK4CC30  0.47U-10-X6S-S2-TY  [C0201]  309.81 183.41 0 bottom
UNK4CC31  0.47U-10-X6S-S2-TY  [C0201]  329.28 164.12 90 bottom
UNK4CC32  0.47U-10-X6S-S2-TY  [C0201]  342.36 164.12 90 bottom
UNK4CC33  0.47U-10-X6S-S2-TY  [C0201]  352.85 183.91 180 bottom
UNK4CC34  0.47U-10-X6S-S2-TY  [C0201]  331.94 206.16 270 bottom
UNK4CC35  0.47U-10-X6S-S2-TY  [C0201]  352.85 181.37 180 bottom
UNK4CC36  0.47U-10-X6S-S2-TY  [C0201]  352.85 182.64 180 bottom
UNK4CC37  0.47U-10-X6S-S2-TY  [C0201]  327.57 204.95 90 bottom
UNK4CC38  NC/4.7U-2.5-X6S-S2-MU  [C0201]  327.57 206.16 270 bottom
UNK4CC39  0.47U-10-X6S-S2-TY  [C0201]  311.03 189.2 180 bottom
UNK4CC40  4.7U-2.5-X6S-S2-MU  [C0201]  338.5 186.67 180 bottom
UNK4CC41  4.7U-2.5-X6S-S2-MU  [C0201]  309.81 189.2 0 bottom
UNK4CC42  4.7U-2.5-X6S-S2-MU  [C0201]  331.54 193.03 90 bottom
UNK4CD1  0.1U-10-X7R-S2-MU  [C0201]  317.98 165.34 270 top
UNK4CD3  0.1U-10-X7R-S2-MU  [C0201]  351.64 181.37 0 top
UNK4CD4  0.1U-10-X7R-S2-MU  [C0201]  334.61 204.95 90 top
UNK4CD5  0.1U-10-X7R-S2-MU  [C0201]  343.63 165.34 270 top
UNK4CD6  0.1U-10-X7R-S2-MU  [C0201]  311.03 186.66 180 top
UNK4CD7  0.1U-10-X7R-S2-MU  [C0201]  351.64 182.64 0 top
UNK4CD8  0.1U-10-X7R-S2-MU  [C0201]  331.06 165.34 270 top
UNK4CD9  0.1U-10-X7R-S2-MU  [C0201]  336.77 165.34 270 top
UNK4CD10  0.1U-10-X7R-S2-MU  [C0201]  351.64 189.5 0 top
UNK4CD11  0.1U-10-X7R-S2-MU  [C0201]  339.65 204.95 90 top
UNK4CD12  0.1U-10-X7R-S2-MU  [C0201]  311.03 193.69 180 top
UNK4CD13  0.1U-10-X7R-S2-MU  [C0201]  332.83 204.95 90 top
UNK4CD14  0.1U-10-X7R-S2-MU  [C0201]  331.05 204.95 90 top
UNK4CD15  0.1U-10-X7R-S2-MU  [C0201]  351.64 185.18 0 top
UNK4CD16  0.1U-10-X7R-S2-MU  [C0201]  333.72 204.95 90 top
UNK4CD17  0.1U-10-X7R-S2-MU  [C0201]  311.03 187.93 180 top
UNK4CD18  0.1U-10-X7R-S2-MU  [C0201]  331.94 204.95 90 top
UNK4CD19  0.1U-10-X7R-S2-MU  [C0201]  311.03 183.41 180 top
UNK4CD20  0.1U-10-X7R-S2-MU  [C0201]  351.64 183.91 0 top
UNK4CD21  0.1U-10-X7R-S2-MU  [C0201]  342.36 165.34 270 top
UNK4CD22  0.1U-10-X7R-S2-MU  [C0201]  329.28 165.34 270 top
UNK4CD23  0.1U-10-X7R-S2-MU  [C0201]  330.17 165.34 270 top
UNK4CD24  0.1U-10-X7R-S2-MU  [C0201]  327.57 204.95 90 top
UNK4CD25  0.1U-10-X7R-S2-MU  [C0201]  311.03 189.2 180 top
UNK4GND1  TP01  [TP_040_T]  499.96 278.76 0 top
UNK4GND2  TP01  [TP_040_T]  513.5 278.76 180 top
UNK4GND3  TP01  [TP_040_T]  516.47 295.27 0 top
UNK4GND4  TP01  [TP_040_T]  516.47 278.76 0 top
UNK4GND5  TP01  [TP_040_T]  530.01 278.76 180 top
UNK4GND6  TP01  [TP_040_T]  516.47 262.25 0 top
UNK4GND7  TP01  [TP_040_T]  496.99 262.25 180 top
UNK4GND8  TP01  [TP_040_T]  483.45 262.25 0 top
UNK4GND9  TP01  [TP_040_T]  480.48 262.25 180 top
UNK4GND10  TP01  [TP_040_T]  120.26 249.61 0 top
UNK4GND11  TP01  [TP_040_T]  115.4 249.66 0 top
UNK4GND12  TP01  [TP_040_T]  513.5 262.25 180 top
UNK4GND13  TP01  [TP_040_T]  530.01 262.25 180 top
UNK4GND14  TP01  [TP_040_T]  466.94 262.25 0 top
UNK4J1  HDR-2X1-M  [JP_2P_100]  468.63 189.99 90 bottom
UNK4J2  HDR-3X1-M  [JP_3P_100]  490.87 185.22 270 bottom
UNK4J3  HDR-3X1-M  [JP_3P_100]  490.87 171.51 270 bottom
UNK4J4  HDR-2X1-M  [JP_2P_100]  483.11 199.9 270 bottom
UNK4J5  HDR-2X1-M  [JP_2P_100]  483.11 188.21 270 bottom
UNK4K1  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  418.85 167.64 0 bottom
UNK4K2  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  378.97 167.39 0 bottom
UNK4K3  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  392.18 167.64 0 bottom
UNK4K4  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  405.64 167.64 0 bottom
UNK4K5  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  378.97 184.15 0 bottom
UNK4K6  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  392.18 184.15 0 bottom
UNK4K7  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  419.61 185.17 270 bottom
UNK4K8  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  405.64 184.15 0 bottom
UNK4K9  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  299.96 175.46 90 bottom
UNK4K10  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  467.11 185.17 180 bottom
UNK4K11  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  379.73 198.63 270 bottom
UNK4K12  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  299.96 186.89 90 bottom
UNK4K13  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  455.68 185.17 0 bottom
UNK4K14  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  467.61 169.93 0 bottom
UNK4K15  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  455.64 177.46 0 bottom
UNK4K16  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  396.24 198.63 270 bottom
UNK4K17  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  379.98 213.11 0 bottom
UNK4K18  UB2-5NU-B  [RL_NECUB2_5V]  308.45 214.32 0 bottom
UNK4K19  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  467.61 177.55 0 bottom
UNK4K20  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  455.68 169.93 0 bottom
UNK4K21  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  392.18 150.88 0 bottom
UNK4K22  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  388.11 135.89 0 bottom
UNK4K23  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  414.53 135.89 0 bottom
UNK4K24  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  401.32 135.89 0 bottom
UNK4K25  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  308.57 150.05 0 bottom
UNK4K26  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  350.27 134.62 270 bottom
UNK4K27  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  322.07 135.64 0 bottom
UNK4K28  UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  479.04 194.06 180 bottom
UNK4K29  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  405.89 150.88 0 bottom
UNK4K30  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  419.35 150.88 0 bottom
UNK4K31  EC2-5NJ-A  [RL_NECEC2_10P_5V]  506.73 261.62 90 bottom
UNK4K33  NC/UA2-5NJ-A-V3  [RL_NECUA2_5V_V3]  455.68 194.31 0 bottom
UNK4K34  EC2-5NJ-A  [RL_NECEC2_10P_5V]  506.73 278.13 90 bottom
UNK4K36  EC2-5NJ-A  [RL_NECEC2_10P_5V]  523.24 294.64 90 bottom
UNK4K37  EC2-5NJ-A  [RL_NECEC2_10P_5V]  523.24 278.13 90 bottom
UNK4K39  EC2-5NJ-A  [RL_NECEC2_10P_5V]  523.24 261.62 90 bottom
UNK4K40  EC2-5NJ-A  [RL_NECEC2_10P_5V]  490.22 261.62 90 bottom
UNK4K42  EC2-5NJ-A  [RL_NECEC2_10P_5V]  473.71 261.62 90 bottom
UNK4K43  G6K-2F-RF-T-5V-SPECIAL  [RL_G6K2FRT_8P_5V_GR]  308.36 135.64 0 bottom
UNK4R1  NC/1M-1-S4  [R0402]  301.23 167.84 180 bottom
UNK4R2  NC/1M-1-S4  [R0402]  298.95 167.84 0 bottom
UNK4R3  NC/100K-1-S4  [R0402]  299.72 130.81 180 bottom
UNK4R4  NC/100K-1-S4  [R0402]  297.18 130.81 180 bottom
UNK4R5  0-5-S4  [R0402]  302.38 212.16 270 bottom
UNK4R6  1M-1-S4  [R0402]  302.38 214.32 270 bottom
UNK4R7  49.9-1-S4  [R0402]  420.52 174.43 180 bottom
UNK4R8  49.9-1-S4  [R0402]  422.67 174.43 180 bottom
UNK4R9  49.9-1-S4  [R0402]  420.52 160.85 180 bottom
UNK4R10  49.9-1-S4  [R0402]  422.67 160.85 180 bottom
UNK4R11  49.9-1-S4  [R0402]  380.65 174.18 180 bottom
UNK4R12  49.9-1-S4  [R0402]  382.79 174.18 180 bottom
UNK4R13  49.9-1-S4  [R0402]  380.65 160.59 180 bottom
UNK4R14  49.9-1-S4  [R0402]  382.79 160.59 180 bottom
UNK4R15  49.9-1-S4  [R0402]  393.85 174.43 180 bottom
UNK4R16  49.9-1-S4  [R0402]  396 174.43 180 bottom
UNK4R17  49.9-1-S4  [R0402]  393.85 160.85 180 bottom
UNK4R18  49.9-1-S4  [R0402]  396 160.85 180 bottom
UNK4R19  49.9-1-S4  [R0402]  407.32 174.43 180 bottom
UNK4R20  49.9-1-S4  [R0402]  409.46 174.43 180 bottom
UNK4R21  49.9-1-S4  [R0402]  407.32 160.85 180 bottom
UNK4R22  49.9-1-S4  [R0402]  409.46 160.85 180 bottom
UNK4R23  49.9-1-S4  [R0402]  380.65 190.94 180 bottom
UNK4R24  49.9-1-S4  [R0402]  382.79 190.94 180 bottom
UNK4R25  49.9-1-S4  [R0402]  380.65 177.36 180 bottom
UNK4R26  49.9-1-S4  [R0402]  382.79 177.36 180 bottom
UNK4R27  49.9-1-S4  [R0402]  393.85 190.94 180 bottom
UNK4R28  49.9-1-S4  [R0402]  396 190.94 180 bottom
UNK4R29  49.9-1-S4  [R0402]  393.85 177.36 180 bottom
UNK4R30  49.9-1-S4  [R0402]  396 177.36 180 bottom
UNK4R31  49.9-1-S4  [R0402]  426.4 183.49 90 bottom
UNK4R32  49.9-1-S4  [R0402]  426.4 181.34 90 bottom
UNK4R33  49.9-1-S4  [R0402]  412.81 183.49 90 bottom
UNK4R34  49.9-1-S4  [R0402]  412.81 181.34 90 bottom
UNK4R37  49.9-1-S4  [R0402]  407.32 177.36 180 bottom
UNK4R38  49.9-1-S4  [R0402]  409.46 177.36 180 bottom
UNK4R39  49.9-1-S4  [R0402]  386.52 196.95 90 bottom
UNK4R40  49.9-1-S4  [R0402]  386.52 194.81 90 bottom
UNK4R41  49.9-1-S4  [R0402]  372.94 196.95 90 bottom
UNK4R42  49.9-1-S4  [R0402]  372.94 194.81 90 bottom
UNK4R43  49.9-1-S4  [R0402]  407.57 144.08 180 bottom
UNK4R44  49.9-1-S4  [R0402]  409.71 144.08 180 bottom
UNK4R45  49.9-1-S4  [R0402]  389.79 129.1 180 bottom
UNK4R46  49.9-1-S4  [R0402]  391.93 129.1 180 bottom
UNK4R47  49.9-1-S4  [R0402]  416.21 142.68 180 bottom
UNK4R48  49.9-1-S4  [R0402]  418.35 142.68 180 bottom
UNK4R49  49.9-1-S4  [R0402]  416.21 129.1 180 bottom
UNK4R50  49.9-1-S4  [R0402]  418.35 129.1 180 bottom
UNK4R51  49.9-1-S4  [R0402]  403 142.68 180 bottom
UNK4R52  49.9-1-S4  [R0402]  405.14 142.68 180 bottom
UNK4R53  49.9-1-S4  [R0402]  403 129.1 180 bottom
UNK4R54  49.9-1-S4  [R0402]  405.14 129.1 180 bottom
UNK4R55  49.9-1-S4  [R0402]  310.25 156.84 180 bottom
UNK4R56  49.9-1-S4  [R0402]  312.39 156.84 180 bottom
UNK4R57  49.9-1-S4  [R0402]  310.25 143.26 180 bottom
UNK4R58  49.9-1-S4  [R0402]  312.39 143.26 180 bottom
UNK4R59  49.9-1-S4  [R0402]  357.06 132.94 90 bottom
UNK4R60  49.9-1-S4  [R0402]  357.06 130.8 90 bottom
UNK4R61  49.9-1-S4  [R0402]  343.47 132.94 90 bottom
UNK4R62  49.9-1-S4  [R0402]  343.47 130.8 90 bottom
UNK4R63  49.9-1-S4  [R0402]  421.03 157.67 180 bottom
UNK4R64  49.9-1-S4  [R0402]  423.18 157.67 180 bottom
UNK4R65  49.9-1-S4  [R0402]  323.75 128.84 180 bottom
UNK4R66  49.9-1-S4  [R0402]  325.89 128.84 180 bottom
UNK4R67  49.9-1-S4  [R0402]  403.03 196.95 90 bottom
UNK4R68  49.9-1-S4  [R0402]  403.03 194.81 90 bottom
UNK4R69  49.9-1-S4  [R0402]  389.45 196.95 90 bottom
UNK4R70  49.9-1-S4  [R0402]  389.45 194.81 90 bottom
UNK4R71  49.9-1-S4  [R0402]  381.66 219.9 180 bottom
UNK4R72  49.9-1-S4  [R0402]  383.81 219.9 180 bottom
UNK4R73  49.9-1-S4  [R0402]  381.66 206.31 180 bottom
UNK4R74  49.9-1-S4  [R0402]  383.81 206.31 180 bottom
UNK4R75  49.9-1-S4  [R0402]  393.85 157.67 180 bottom
UNK4R76  49.9-1-S4  [R0402]  396 157.67 180 bottom
UNK4R77  49.9-1-S4  [R0402]  393.85 144.08 180 bottom
UNK4R78  49.9-1-S4  [R0402]  396 144.08 180 bottom
UNK4R79  49.9-1-S4  [R0402]  407.57 157.67 180 bottom
UNK4R80  49.9-1-S4  [R0402]  409.71 157.67 180 bottom
UNK4R82  4.7K-1-S4-WA  [R0402]  456.75 190.45 0 bottom
UNK4R83  4.7K-1-S4-WA  [R0402]  482.6 197.87 0 bottom
UNK4R84  4.7K-1-S4-WA  [R0402]  482.6 190.25 0 bottom
UNK4R85  100K-1-S4  [R0402]  465.07 192.28 0 bottom
UNK4R86  4.7K-1-S4-WA  [R0402]  486.3 183.19 0 bottom
UNK4R87  4.7K-1-S4-WA  [R0402]  475.49 187.35 0 bottom
UNK4R88  4.7K-1-S4-WA  [R0402]  478.03 187.35 0 bottom
UNK4R89  4.7K-1-S4-WA  [R0402]  490.6 183.24 180 bottom
UNK4R90  4.7K-1-S4-WA  [R0402]  478.03 175.15 0 bottom
UNK4R91  4.7K-1-S4-WA  [R0402]  480.57 175.15 0 bottom
UNK4R92  4.7K-1-S4-WA  [R0402]  483.11 175.15 0 bottom
UNK4R93  4.7K-1-S4-WA  [R0402]  486.3 169.47 0 bottom
UNK4R94  4.7K-1-S4-WA  [R0402]  475.37 173.79 180 bottom
UNK4R95  4.7K-1-S4-WA  [R0402]  477.93 173.74 0 bottom
UNK4R96  4.7K-1-S4-WA  [R0402]  490.36 169.47 180 bottom
UNK4R97  4.7K-1-S4-WA  [R0402]  477.93 161.55 0 bottom
UNK4R98  4.7K-1-S4-WA  [R0402]  480.47 161.55 0 bottom
UNK4R99  4.7K-1-S4-WA  [R0402]  483.01 161.55 0 bottom
UNK4R100  49.9-1-S4  [R0402]  421.03 144.08 180 bottom
UNK4R101  49.9-1-S4  [R0402]  423.18 144.08 180 bottom
UNK4R102  49.9-1-S4  [R0402]  389.79 142.68 180 bottom
UNK4R103  49.9-1-S4  [R0402]  391.93 142.68 180 bottom
UNK4R104  49.9-1-S4  [R0402]  323.75 142.43 180 bottom
UNK4R105  49.9-1-S4  [R0402]  325.89 142.43 180 bottom
UNK4R117  1K-1-S4  [R0402]  452.18 190.45 0 bottom
UNK4R118  NC/0-5-S4  [R0402]  310.41 185.39 180 bottom
UNK4R119  4.7K-1-S4-WA  [R0402]  452.12 181.36 180 bottom
UNK4R120  4.7K-1-S4-WA  [R0402]  452.12 188.98 180 bottom
UNK4R125  0-5-S4  [R0402]  456.44 166.12 0 bottom
UNK4R126  0-5-S4  [R0402]  452.37 166.12 0 bottom
UNK4R127  0-5-S4  [R0402]  456.69 173.74 0 bottom
UNK4R128  0-5-S4  [R0402]  452.12 173.74 0 bottom
UNK4R129  0-5-S4  [R0402]  301.23 169.11 180 bottom
UNK4R130  0-5-S4  [R0402]  298.95 169.11 0 bottom
UNK4R131  50-0.1-S4-HF-VI  [R0402]  303.77 183.33 90 bottom
UNK4R132  50-0.1-S4-HF-VI  [R0402]  296.15 183.33 90 bottom
UNK4R133  0-5-S4  [R0402]  302.38 216.48 90 bottom
UNK4SH1  SHORT  [DEFAULT_SHORT_SMALL]  511.58 275.48 0 top
UNK4SH2  SHORT  [DEFAULT_SHORT_SMALL]  513.53 275.48 0 top
UNK4SH3  SHORT  [DEFAULT_SHORT_SMALL]  501.74 275.48 0 top
UNK4SH4  SHORT  [DEFAULT_SHORT_SMALL]  499.79 275.61 180 top
UNK4SH5  SHORT  [DEFAULT_SHORT_SMALL]  518.25 291.99 0 top
UNK4SH6  SHORT  [DEFAULT_SHORT_SMALL]  516.3 292.12 180 top
UNK4SH7  SHORT  [DEFAULT_SHORT_SMALL]  528.09 275.48 0 top
UNK4SH8  SHORT  [DEFAULT_SHORT_SMALL]  516.3 275.61 180 top
UNK4SH9  SHORT  [DEFAULT_SHORT_SMALL]  530.04 275.48 0 top
UNK4SH10  SHORT  [DEFAULT_SHORT_SMALL]  518.25 275.48 0 top
UNK4SH11  SHORT  [DEFAULT_SHORT_SMALL]  516.3 259.1 180 top
UNK4SH12  SHORT  [DEFAULT_SHORT_SMALL]  528.09 258.97 0 top
UNK4SH13  SHORT  [DEFAULT_SHORT_SMALL]  497.02 258.97 0 top
UNK4SH14  SHORT  [DEFAULT_SHORT_SMALL]  495.07 258.97 0 top
UNK4SH15  SHORT  [DEFAULT_SHORT_SMALL]  483.53 258.9 180 top
UNK4SH16  SHORT  [DEFAULT_SHORT_SMALL]  485.23 258.97 0 top
UNK4SH17  SHORT  [DEFAULT_SHORT_SMALL]  466.77 259.1 180 top
UNK4SH18  SHORT  [DEFAULT_SHORT_SMALL]  478.56 258.97 0 top
UNK4SH19  SHORT  [DEFAULT_SHORT_SMALL]  120.32 246.59 0 top
UNK4SH20  SHORT  [DEFAULT_SHORT_SMALL]  122.53 246.59 0 top
UNK4SH21  SHORT  [DEFAULT_SHORT_SMALL]  115.46 246.65 0 top
UNK4SH22  SHORT  [DEFAULT_SHORT_SMALL]  117.66 246.65 0 top
UNK4SH23  SHORT  [DEFAULT_SHORT_SMALL]  511.58 258.97 0 top
UNK4SH24  SHORT  [DEFAULT_SHORT_SMALL]  513.76 258.84 180 top
UNK4SH25  SHORT  [DEFAULT_SHORT_SMALL]  518.25 258.97 0 top
UNK4SH26  SHORT  [DEFAULT_SHORT_SMALL]  530.04 258.97 0 top
UNK4SH27  SHORT  [DEFAULT_SHORT_SMALL]  468.72 258.97 0 top
UNK4SH28  SHORT  [DEFAULT_SHORT_SMALL]  481.33 259.08 0 top
UNK4TP_AUXVCC  TP01  [TP_040_T]  122.19 247.75 180 top
UNK4TP_AVDD11_RX  TP01  [TP_040_T]  518.37 276.86 180 top
UNK4TP_AVDD11_XTAL  TP01  [TP_040_T]  511.6 260.35 0 top
UNK4TP_AVDD18_RX  TP01  [TP_040_T]  528.11 276.86 0 top
UNK4TP_PLL_M_VDD33  TP01  [TP_040_T]  495.09 260.35 0 top
UNK4TP_PLL_TX_VDD33  TP01  [TP_040_T]  485.35 260.35 180 top
UNK4TP_VCC3V3  TP01  [TP_040_T]  117.33 247.8 180 top
UNK4TP_VDD_IO_33  TP01  [TP_040_T]  501.86 276.86 180 top
UNK4TP_VDD_TXREG_33_B  TP01  [TP_040_T]  478.58 260.35 0 top
UNK4TP_VDD_TXREG_33_T  TP01  [TP_040_T]  468.84 260.35 180 top
UNK4TP_VDDA_33_LV  TP01  [TP_040_T]  511.6 276.86 0 top
UNK4TP_VDDC_11  TP01  [TP_040_T]  518.37 293.37 180 top
UNK4TP_VDDTXPST_11_B  TP01  [TP_040_T]  528.11 260.35 0 top
UNK4TP_VDDTXPST_11_T  TP01  [TP_040_T]  518.37 260.35 180 top
UNK4TP_XTAL_IN  TP01  [TP_040_T]  306.85 211.67 0 top
UNK4TP_XTAL_OUT  TP01  [TP_040_T]  306.85 216.97 0 top
UNK4U1  SOLDER-DIP8-SOCKET  [DIP8_300X100_RLPIN]  474.97 185.11 270 bottom
UNK4U2  SOLDER-DIP8-SOCKET  [DIP8_300X100_RLPIN]  474.87 171.51 270 bottom
UNK4UF1  MX25L4006EM2I-12G-SOP8  [SOCKET_CODE]  474.97 185.11 90 top
UNK4UF2  MX25L4006EM2I-12G-SOP8  [SOCKET_CODE]  474.59 171.58 180 top
UNK4Y1  XTAL27M-S2520-ABRACON-10P  [XTAL_2X2P5MM_4P]  298.76 214.89 270 bottom
UNK4Y2  NC/XTAL27M-S3225-TXC-10P  [XTAL_3P2X2P5MM_4P_TXC_0201]  298.76 214.89 270 bottom
UNK038HX-8880F5K4Q-A100  REF-CODE-PCB  [PCB_CODE]  559.05 289.81 0 top
UNK980HX-8880F5-KBG-  REF-CODE-PCB  [PCB_CODE]  559.05 292.35 0 top
UT_UP5V  TP01  [TP_040_T]  36.83 135.89 0 top
UTL1  V93K_UTL  [PG_VG93K_F_G3UTI1]  180.34 16.51 0 top
UTL2  V93K_UTL  [PG_VG93K_F_G1UTI2]  327.66 16.51 0 top
UTL3  V93K_UTL  [PG_VG93K_F_G2UTI3]  401.32 412.75 0 top
UTL4  V93K_UTL  [PG_VG93K_F_G8UTI4]  254 412.75 0 top
UTL5  V93K_UTL  [PG_VG93K_F_G4UTI5]  33.02 16.51 0 top
UTL6  V93K_UTL  [PG_VG93K_F_G5UTI6]  474.98 16.51 0 top
UTL7  V93K_UTL  [PG_VG93K_F_G6UTI7]  548.64 412.75 0 top
UTL8  V93K_UTL  [PG_VG93K_F_G7UTI8]  106.68 412.75 0 top
Y1  XTAL27M-S2520-ABRACON-10P  [XTAL_2X2P5MM_4P]  218.76 274.89 270 bottom
Y2  NC/XTAL27M-S3225-TXC-10P  [XTAL_3P2X2P5MM_4P_TXC_0201]  218.76 274.89 270 bottom

## Library data of the parts
BD29-BD44 = BD120-3A-S8: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
BR902 = 330-1-S4: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C3 C4 C7-C9 UNK2C3 UNK2C4 UNK2C7-UNK2C9 UNK3C3 UNK3C4 UNK3C7-UNK3C9 UNK4C3 UNK4C4 UNK4C7-UNK4C9 = 0.1U-16-X-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
C5 C6 UNK2C5 UNK2C6 UNK3C5 UNK3C6 UNK4C5 UNK4C6 = 22P-50-N-S4-AVX: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CA1 CA3 CA5 CA7 CA9 CA11 CA14 CA16 CA18 CA20-CA29 CA31 CA32 CA34 CA35 CA37 CA38 CA40 UNK2CA1 UNK2CA3 UNK2CA5 UNK2CA7 UNK2CA9 UNK2CA11 UNK2CA14 UNK2CA16 UNK2CA18 UNK2CA20-UNK2CA29 UNK2CA31 UNK2CA32 UNK2CA34 UNK2CA35 UNK2CA37 UNK2CA38 UNK2CA40 UNK3CA1 UNK3CA3 UNK3CA5 UNK3CA7 UNK3CA9 UNK3CA11 UNK3CA14 UNK3CA16 UNK3CA18 UNK3CA20-UNK3CA29 UNK3CA31 UNK3CA32 UNK3CA34 UNK3CA35 UNK3CA37 UNK3CA38 UNK3CA40 UNK4CA1 UNK4CA3 UNK4CA5 UNK4CA7 UNK4CA9 UNK4CA11 UNK4CA14 UNK4CA16 UNK4CA18 UNK4CA20-UNK4CA29 UNK4CA31 UNK4CA32 UNK4CA34 UNK4CA35 UNK4CA37 UNK4CA38 UNK4CA40 = 10U-10-X6S-S6-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CA2 CA4 CA6 CA8 CA10 CA12 CA13 CA15 CA17 CA19 CA30 CA33 CA36 CA39 UNK2CA2 UNK2CA4 UNK2CA6 UNK2CA8 UNK2CA10 UNK2CA12 UNK2CA13 UNK2CA15 UNK2CA17 UNK2CA19 UNK2CA30 UNK2CA33 UNK2CA36 UNK2CA39 UNK3CA2 UNK3CA4 UNK3CA6 UNK3CA8 UNK3CA10 UNK3CA12 UNK3CA13 UNK3CA15 UNK3CA17 UNK3CA19 UNK3CA30 UNK3CA33 UNK3CA36 UNK3CA39 UNK4CA2 UNK4CA4 UNK4CA6 UNK4CA8 UNK4CA10 UNK4CA12 UNK4CA13 UNK4CA15 UNK4CA17 UNK4CA19 UNK4CA30 UNK4CA33 UNK4CA36 UNK4CA39 = 47U-10-X5R-S8-TDK: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB1 CB3 CB5 CB7 CB9 CB11 CB13 CB15 = 0.1U-25-X-S6: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB2 CB4 CB6 CB8 = 10U-16-T-SA: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
CB10 CB12 CB14 CB16 = 10U-25-X7R-SA: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CB19 = 0.1U-25-X7R-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CC1 CC4 CC6-CC9 CC11 CC13 CC19 CC22 CC25-CC37 CC39 UNK2CC1 UNK2CC4 UNK2CC6-UNK2CC9 UNK2CC11 UNK2CC13 UNK2CC19 UNK2CC22 UNK2CC25-UNK2CC37 UNK2CC39 UNK3CC1 UNK3CC4 UNK3CC6-UNK3CC9 UNK3CC11 UNK3CC13 UNK3CC19 UNK3CC22 UNK3CC25-UNK3CC37 UNK3CC39 UNK4CC1 UNK4CC4 UNK4CC6-UNK4CC9 UNK4CC11 UNK4CC13 UNK4CC19 UNK4CC22 UNK4CC25-UNK4CC37 UNK4CC39 = 0.47U-10-X6S-S2-TY: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CC2 CC20 CC23 UNK2CC2 UNK2CC20 UNK2CC23 UNK3CC2 UNK3CC20 UNK3CC23 UNK4CC2 UNK4CC20 UNK4CC23 = 4.7U-10-X6T-S4-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CC15-CC17 CC38 CC40-CC42 UNK2CC15-UNK2CC17 UNK2CC38 UNK2CC40-UNK2CC42 UNK3CC15-UNK3CC17 UNK3CC38 UNK3CC40-UNK3CC42 UNK4CC15-UNK4CC17 UNK4CC38 UNK4CC40-UNK4CC42 = 4.7U-2.5-X6S-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CD1 CD3-CD25 UNK2CD1 UNK2CD3-UNK2CD25 UNK3CD1 UNK3CD3-UNK3CD25 UNK4CD1 UNK4CD3-UNK4CD25 = 0.1U-10-X7R-S2-MU: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
CSDPS225 CSDPS229 CSDPS425 CSDPS429 = V93K_CSDPS_DPS32: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
D101/D501 D105/D505 D117/D517 D121/D521 = V93K_PS1600_HD: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
D102-D104 D106-D116 D118-D120 D122-D132 D231 D301 D302 D305 D306 D317 D318 D321 D322 D431 = V93K_CH: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
D309 D313 = V93K_PSSL: User Part Number: PNXXXXXXXXXX; Tolerance: TOL
DPS1-DPS3 DPS8 = V93K_DPS: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
FD1-FD16 = FD_040_V2: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
GND1-GND14 TP_AUXVCC TP_AVDD11_RX TP_AVDD11_XTAL TP_AVDD18_RX TP_PLL_M_VDD33 TP_PLL_TX_VDD33 TP_VCC3V3 TP_VDD_IO_33 TP_VDD_TXREG_33_B TP_VDD_TXREG_33_T TP_VDDA_33_LV TP_VDDC_11 TP_VDDTXPST_11_B TP_VDDTXPST_11_T TP_XTAL_IN TP_XTAL_OUT UNK2GND1-UNK2GND14 UNK2TP_AUXVCC UNK2TP_AVDD11_RX UNK2TP_AVDD11_XTAL UNK2TP_AVDD18_RX UNK2TP_PLL_M_VDD33 UNK2TP_PLL_TX_VDD33 UNK2TP_VCC3V3 UNK2TP_VDD_IO_33 UNK2TP_VDD_TXREG_33_B UNK2TP_VDD_TXREG_33_T UNK2TP_VDDA_33_LV UNK2TP_VDDC_11 UNK2TP_VDDTXPST_11_B UNK2TP_VDDTXPST_11_T UNK2TP_XTAL_IN UNK2TP_XTAL_OUT UNK3GND1-UNK3GND14 UNK3TP_AUXVCC UNK3TP_AVDD11_RX UNK3TP_AVDD11_XTAL UNK3TP_AVDD18_RX UNK3TP_PLL_M_VDD33 UNK3TP_PLL_TX_VDD33 UNK3TP_VCC3V3 UNK3TP_VDD_IO_33 UNK3TP_VDD_TXREG_33_B UNK3TP_VDD_TXREG_33_T UNK3TP_VDDA_33_LV UNK3TP_VDDC_11 UNK3TP_VDDTXPST_11_B UNK3TP_VDDTXPST_11_T UNK3TP_XTAL_IN UNK3TP_XTAL_OUT UNK4GND1-UNK4GND14 UNK4TP_AUXVCC UNK4TP_AVDD11_RX UNK4TP_AVDD11_XTAL UNK4TP_AVDD18_RX UNK4TP_PLL_M_VDD33 UNK4TP_PLL_TX_VDD33 UNK4TP_VCC3V3 UNK4TP_VDD_IO_33 UNK4TP_VDD_TXREG_33_B UNK4TP_VDD_TXREG_33_T UNK4TP_VDDA_33_LV UNK4TP_VDDC_11 UNK4TP_VDDTXPST_11_B UNK4TP_VDDTXPST_11_T UNK4TP_XTAL_IN UNK4TP_XTAL_OUT UT_UP5V = TP01: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
HX8880-F05 LQFP176-20X20-P0.4 = REF-CODE-CHIP
J1 J4 J5 S1_RST_N S2_RST_N S3_RST_N S4_RST_N UNK2J1 UNK2J4 UNK2J5 UNK3J1 UNK3J4 UNK3J5 UNK4J1 UNK4J4 UNK4J5 = HDR-2X1-M: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
J2 J3 UNK2J2 UNK2J3 UNK3J2 UNK3J3 UNK4J2 UNK4J3 = HDR-3X1-M: Tolerance: TOL; User Part Number: PNXXXXXXXXXX
