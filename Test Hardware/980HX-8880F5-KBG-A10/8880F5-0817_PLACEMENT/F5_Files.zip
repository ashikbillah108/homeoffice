# Allegro board 8880F5-0827_updates.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D10201: length 270.4
  TOP w0.086: SITE4.120 327.03,197.78 326.95,197.86 326.95,204.17 324.91,206.21 324.91,208.63 v1(325.36,209.08)
  L05_SIGNAL w0.071: D102.01 309.8,73.74 309.8,72.86 309.28,72.34 305.46,72.34 301.03,76.78 301.03,92.14 307.93,99.05 349.1,99.05 352.1,102.05 352.1,118.78 367.88,134.56 367.88,148.28 367.14,149.01 367.14,154.24 368.51,155.61 368.51,184.34 374.27,190.09 374.27,195.66 373.95,195.98 373.01,195.98 372.94,196.05 v1(372.94,196.45)
  L30_SIGNAL w0.071: v1(325.36,209.08) 324.96,209.08 324.89,209.16 324.89,211.79 326.96,213.87 337.92,213.87 338.8,212.99 341.51,212.99 342.27,213.75 355.77,213.75 369.54,199.98 373.69,199.98 374.73,198.94 374.73,196.75 373.95,195.98 373.01,195.98 372.94,196.05 v1(372.94,196.45)
D10202: length 281.6
  TOP w0.086: SITE4.116 328.63,197.78 328.55,197.86 328.55,206.82 326.96,208.41 326.96,210.72 v1(327.41,211.17)
  L05_SIGNAL w0.071: v1(386.52,196.45) 386.52,196.05 386.45,195.98 385.74,195.98 384.66,194.9 384.66,185.98 382.87,184.19 371.89,184.19 370.49,182.79 370.49,153.66 372.02,152.13 372.02,149.36 370.81,148.15 370.81,134.3 354.14,117.62 354.14,99.68 350.86,96.41 308.6,96.41 303.67,91.48 303.67,85.2 306.44,82.43 311.69,82.43 312.24,81.87 312.24,81.1 D102.02
  L28_SIGNAL w0.071: v1(386.52,196.45) 386.52,196.05 386.45,195.98 384.89,195.98 381.55,199.32 366.54,199.32 365.38,200.49 353.49,200.49 351.87,198.86 344.47,198.86 342.36,200.98 329.11,200.98 326.43,203.66 326.43,207.77 326.94,208.28 326.94,211.1 327.01,211.17 v1(327.41,211.17)
D10203: length 271.7
  TOP w0.086: SITE4.121 326.63,197.78 326.71,197.86 326.71,204.07 324.67,206.11 324.67,208.63 v1(324.22,209.08)
  L05_SIGNAL w0.071: v1(372.94,195.31) 372.94,195.71 373.01,195.78 373.87,195.78 374.07,195.58 374.07,190.18 368.32,184.42 368.32,155.69 366.94,154.32 366.94,148.93 367.68,148.19 367.68,134.64 351.91,118.86 351.91,102.14 349.01,99.24 307.85,99.24 300.83,92.22 300.83,76.7 305.38,72.14 309.36,72.14 310,72.78 310,73.78 D102.03
  L30_SIGNAL w0.071: v1(372.94,195.31) 372.94,195.71 373.01,195.78 374.03,195.78 374.93,196.67 374.93,199.02 373.77,200.18 369.62,200.18 355.85,213.95 342.19,213.95 341.43,213.19 338.88,213.19 338,214.07 326.88,214.07 324.69,211.88 324.69,209.16 324.62,209.08 v1(324.22,209.08)
D10204: length 281.7
  TOP w0.086: SITE4.117 328.23,197.78 328.31,197.86 328.31,206.72 326.72,208.31 326.72,210.72 v1(326.26,211.17)
  L05_SIGNAL w0.071: D102.04 312.44,81.26 312.44,81.96 311.77,82.62 306.52,82.62 303.87,85.28 303.87,91.4 308.68,96.21 350.95,96.21 354.33,99.6 354.33,117.54 371.01,134.21 371.01,148.07 372.22,149.28 372.22,152.21 370.69,153.74 370.69,182.71 371.97,183.99 382.95,183.99 384.86,185.9 384.86,194.82 385.82,195.78 386.45,195.78 386.52,195.71 v1(386.52,195.31)
  L28_SIGNAL w0.071: v1(326.26,211.17) 326.67,211.17 326.74,211.1 326.74,208.36 326.23,207.85 326.23,203.58 329.03,200.78 342.28,200.78 344.39,198.67 351.95,198.67 353.57,200.29 365.29,200.29 366.46,199.13 381.46,199.13 384.81,195.78 386.45,195.78 386.52,195.71 v1(386.52,195.31)
D10205: length 363.4
  TOP w0.086: SITE4.100 335.03,197.78 334.95,197.86 334.95,201.59 337.04,203.68 337.04,208.51 336.65,208.9 336.65,210.62 v1(337.1,211.08)
  L07_SIGNAL w0.071: D102.05 319.98,73.72 319.98,72.87 319.48,72.37 303.23,72.37 302.27,73.33 302.27,89.34 325.98,113.05 325.98,115.24 333.58,122.84 333.58,139.03 340.03,145.47 351.15,145.47 356.56,150.88 356.56,152.59 358.7,154.73 360.77,154.73 365.6,159.57 365.6,178.47 368.12,180.99 371.49,180.99 376.32,185.82 427.5,185.82 427.9,185.42 427.9,182.98 427.44,182.52 426.47,182.52 426.4,182.59 v1(426.4,182.99)
  L28_SIGNAL w0.071: v1(426.4,182.99) 426.4,182.59 426.47,182.52 428.22,182.52 429.09,183.38 429.09,190.49 420.96,198.62 399.39,198.62 390.32,207.68 381.09,207.68 380.2,206.79 363.59,206.79 356.78,213.6 342.61,213.6 341.42,212.42 337.06,212.42 336.63,211.99 336.63,211.15 336.7,211.08 v1(337.1,211.08)
D10206: length 325.6
  TOP w0.086: SITE4.102 334.23,197.78 334.15,197.86 334.15,201.95 335.98,203.78 335.98,208.13 334.78,209.33 v1(334.78,209.97)
  L07_SIGNAL w0.071: v1(412.81,182.99) 412.81,182.59 412.74,182.52 374.02,182.52 367.82,176.32 367.82,155.58 369.25,154.16 369.25,148.89 368.11,147.76 368.11,137.59 354.77,124.25 343.9,124.25 341.34,121.7 336.06,121.7 325.41,111.05 325.41,108.23 310.28,93.1 308.39,93.1 304.22,88.92 304.22,84.14 305.9,82.45 321.72,82.45 322.53,81.65 322.53,81.23 D102.06
  L32_SIGNAL w0.071: v1(412.81,182.99) 412.81,182.59 412.89,182.52 413.77,182.52 414.41,183.15 414.41,184.2 413.68,184.93 402.73,184.93 397.66,190.01 397.66,199.73 390.07,207.32 380.37,207.32 377.78,204.74 369.07,204.74 359.88,213.92 341.84,213.92 340.96,213.04 338.65,213.04 337.99,213.7 335.2,213.7 333.5,212 333.5,210.59 334.4,209.69 334.5,209.69 v1(334.78,209.97)
D10207: length 366
  TOP w0.086: SITE4.101 334.63,197.78 334.71,197.86 334.71,201.69 336.8,203.78 336.8,208.41 336.41,208.8 336.41,210.62 v1(335.96,211.08)
  L07_SIGNAL w0.071: v1(426.4,181.84) 426.4,182.25 426.47,182.32 427.52,182.32 428.1,182.89 428.1,185.5 427.58,186.02 376.24,186.02 371.41,181.19 368.04,181.19 365.4,178.55 365.4,159.65 360.69,154.93 358.62,154.93 356.37,152.68 356.37,150.97 351.07,145.67 339.94,145.67 333.38,139.11 333.38,122.92 325.78,115.32 325.78,113.13 302.07,89.42 302.07,73.25 303.14,72.17 319.57,72.17 320.18,72.78 320.18,73.8 D102.07
  L28_SIGNAL w0.071: v1(335.96,211.08) 336.36,211.08 336.43,211.15 336.43,212.07 336.98,212.62 341.34,212.62 342.53,213.8 356.86,213.8 363.67,206.99 380.12,206.99 381.01,207.88 390.41,207.88 399.47,198.81 421.04,198.81 429.29,190.57 429.29,183.3 428.31,182.32 426.47,182.32 426.4,182.25 v1(426.4,181.84)
D10208: length 326.2
  TOP w0.086: v1(333.98,209.17) 334.61,209.17 335.74,208.03 335.74,203.88 333.91,202.05 333.91,197.86 333.83,197.78 SITE4.103
  L07_SIGNAL w0.071: v1(412.81,181.84) 412.81,182.25 412.74,182.32 374.1,182.32 368.02,176.24 368.02,155.66 369.44,154.24 369.44,148.81 368.31,147.68 368.31,137.51 354.86,124.05 343.98,124.05 341.43,121.5 336.14,121.5 325.61,110.97 325.61,108.15 310.36,92.9 308.48,92.9 304.41,88.84 304.41,84.22 305.98,82.65 321.81,82.65 322.73,81.73 322.73,81.13 D102.08
  L32_SIGNAL w0.071: v1(412.81,181.84) 412.81,182.25 412.89,182.32 413.86,182.32 414.6,183.06 414.6,184.29 413.76,185.13 402.81,185.13 397.86,190.09 397.86,199.81 390.15,207.52 380.28,207.52 377.7,204.93 369.15,204.93 359.97,214.12 341.76,214.12 340.88,213.24 338.73,213.24 338.07,213.9 335.11,213.9 333.3,212.09 333.3,210.51 334.26,209.55 334.26,209.45 v1(333.98,209.17)
D10209: length 250.7
  TOP w0.086: v1(338.99,208.83) 338.54,208.38 338.54,204.15 335.75,201.37 335.75,197.86 335.83,197.78 SITE4.98
  L07_SIGNAL w0.071: D102.09 330.14,73.72 330.14,72.97 330.96,72.16 349.07,72.16 355.69,78.78 355.69,114.17 372.07,130.55 372.07,133.27 373.94,135.14 373.94,160.79 372.65,162.07 372.65,171.77 373.5,172.62 382.78,172.62 388.49,178.32 394.54,178.32 394.83,178.04 394.83,177.43 394.76,177.36 v1(394.35,177.36)
  L32_SIGNAL w0.071: v1(394.35,177.36) 394.76,177.36 394.83,177.43 394.83,178.64 384.98,188.48 384.98,192.21 378.05,199.14 370.87,199.14 358.32,211.69 339.62,211.69 338.52,210.58 338.52,208.9 338.59,208.83 v1(338.99,208.83)
D10210: length 211.7
  TOP w0.086: v1(343.07,208.6) 342.61,208.15 342.61,204.3 337.75,199.44 337.75,197.86 337.83,197.78 SITE4.93
  L07_SIGNAL w0.071: D102.10 332.59,81.13 332.59,81.8 333.47,82.68 348.9,82.68 352.48,86.25 352.48,116.3 370.7,134.52 370.7,148.16 371.86,149.32 371.86,152.75 370.52,154.08 370.52,172.2 374.07,175.75 380.86,175.75 381.62,176.51 381.62,177.28 381.55,177.36 v1(381.15,177.36)
  L32_SIGNAL w0.071: v1(343.07,208.6) 342.66,208.6 342.59,208.53 342.59,199.44 349.3,192.73 355.15,192.73 357.4,190.47 360.58,190.47 362.69,188.36 372.44,188.36 379.04,181.76 379.04,177.34 380.38,176 381.35,176 381.62,176.27 381.62,177.28 381.55,177.36 v1(381.15,177.36)
D10211: length 251.3
  TOP w0.086: SITE4.99 335.43,197.78 335.51,197.86 335.51,201.47 338.3,204.25 338.3,208.38 v1(337.84,208.83)
  L07_SIGNAL w0.071: v1(395.5,177.36) 395.1,177.36 395.03,177.43 395.03,178.12 394.62,178.52 388.41,178.52 382.7,172.82 373.41,172.82 372.45,171.86 372.45,161.99 373.74,160.7 373.74,135.22 371.88,133.36 371.88,130.64 355.49,114.25 355.49,78.86 348.98,72.35 331.04,72.35 330.34,73.06 330.34,73.8 D102.11
  L32_SIGNAL w0.071: v1(395.5,177.36) 395.1,177.36 395.02,177.43 395.02,178.72 385.18,188.56 385.18,192.3 378.14,199.34 370.95,199.34 358.4,211.89 339.54,211.89 338.32,210.66 338.32,208.9 338.25,208.83 v1(337.84,208.83)
D10212: length 212.4
  TOP w0.086: v1(341.92,208.6) 342.37,208.15 342.37,204.4 337.51,199.54 337.51,197.86 337.43,197.78 SITE4.94
  L07_SIGNAL w0.071: v1(382.29,177.36) 381.89,177.36 381.82,177.28 381.82,176.43 380.94,175.55 374.15,175.55 370.72,172.12 370.72,154.16 372.06,152.83 372.06,149.24 370.9,148.08 370.9,134.44 352.67,116.21 352.67,86.17 348.98,82.48 333.55,82.48 332.79,81.72 332.79,81.23 D102.12
  L32_SIGNAL w0.071: v1(341.92,208.6) 342.32,208.6 342.39,208.53 342.39,199.35 349.22,192.53 355.07,192.53 357.32,190.27 360.49,190.27 362.61,188.16 372.36,188.16 378.84,181.68 378.84,177.26 380.3,175.81 381.44,175.81 381.82,176.19 381.82,177.28 381.89,177.36 v1(382.29,177.36)
D10213: length 285.3
  TOP w0.086: v1(325.11,203.69) 324.65,203.24 324.65,202.03 326.15,200.53 326.15,197.86 326.23,197.78 SITE4.122
  L05_SIGNAL w0.071: D102.13 340.39,73.63 340.39,72.89 341.12,72.16 353.78,72.16 359.71,78.09 359.71,117.3 376.49,134.08 376.49,177.93 380.02,181.46 392.74,181.46 405.05,193.77 405.05,195.29 404.36,195.98 403.11,195.98 403.03,196.05 v1(403.03,196.45)
  L32_SIGNAL w0.071: v1(403.03,196.45) 403.03,196.05 403.11,195.98 405.84,195.98 406.89,197.03 406.89,201.51 392.72,215.68 343.18,215.68 342.22,214.72 332.99,214.72 324.63,206.36 324.63,203.76 324.7,203.69 v1(325.11,203.69)
D10214: length 250.1
  TOP w0.086: v1(322.12,209.08) 321.66,208.63 321.66,206.13 322.87,204.93 322.87,202.13 325.35,199.65 325.35,197.86 325.43,197.78 SITE4.124
  L05_SIGNAL w0.071: D102.14 342.84,81.22 342.84,82.21 343.37,82.74 352.31,82.74 357.22,87.64 357.22,117.46 373.68,133.92 373.68,161.46 372.94,162.2 372.94,180.96 375.04,183.06 386.93,183.06 389.46,185.59 389.46,189.5 387.9,191.05 387.9,195.45 388.43,195.98 389.37,195.98 389.45,196.05 v1(389.45,196.45)
  L28_SIGNAL w0.071: v1(389.45,196.45) 389.45,196.05 389.37,195.98 388.3,195.98 387.89,195.56 387.89,194.47 386.93,193.52 367.89,193.52 362.42,198.99 357.18,198.99 355.06,196.87 326.68,196.87 322.72,200.84 322.72,205.06 321.64,206.14 321.64,209.01 321.71,209.08 v1(322.12,209.08)
D10215: length 285.2
  TOP w0.086: SITE4.123 325.83,197.78 325.91,197.86 325.91,200.44 324.42,201.93 324.42,203.24 v1(323.96,203.69)
  L05_SIGNAL w0.071: v1(403.03,195.31) 403.03,195.71 403.11,195.78 404.27,195.78 404.85,195.2 404.85,193.85 392.66,181.66 379.94,181.66 376.29,178.01 376.29,134.16 359.51,117.38 359.51,78.17 353.7,72.36 341.2,72.36 340.59,72.97 340.59,73.89 D102.15
  L32_SIGNAL w0.071: v1(323.96,203.69) 324.36,203.69 324.44,203.76 324.44,206.44 332.9,214.91 342.14,214.91 343.1,215.88 392.8,215.88 407.09,201.59 407.09,196.94 405.92,195.78 403.11,195.78 403.03,195.71 v1(403.03,195.31)
D10216: length 250.1
  TOP w0.086: v1(320.97,209.08) 321.43,208.63 321.43,206.04 322.63,204.83 322.63,202.03 325.11,199.55 325.11,197.86 325.03,197.78 SITE4.125
  L05_SIGNAL w0.071: v1(389.45,195.31) 389.45,195.71 389.37,195.78 388.52,195.78 388.1,195.36 388.1,191.14 389.66,189.58 389.66,185.51 387.01,182.86 375.12,182.86 373.14,180.88 373.14,162.29 373.88,161.55 373.88,133.84 357.42,117.37 357.42,87.56 352.4,82.54 343.45,82.54 343.04,82.13 343.04,81.14 D102.16
  L28_SIGNAL w0.071: v1(320.97,209.08) 321.37,209.08 321.45,209.01 321.45,206.06 322.53,204.98 322.53,200.75 326.6,196.68 355.15,196.68 357.26,198.79 362.34,198.79 367.81,193.32 387.01,193.32 388.08,194.39 388.08,195.48 388.38,195.78 389.37,195.78 389.45,195.71 v1(389.45,195.31)
D10301: length 284.3
  TOP w0.086: SITE4.91 338.63,197.78 338.55,197.86 338.55,199 341.27,201.72 343.16,201.72 344.22,202.77 344.22,205.88 v1(344.67,206.34)
  L07_SIGNAL w0.071: v1(381.15,190.94) 381.55,190.94 381.62,191.02 381.62,191.81 380.57,192.86 368.01,192.86 361.09,185.94 361.09,162.83 349.46,151.2 339.11,151.2 330.28,142.37 330.28,127.34 324.99,122.05 324.99,120.22 294.83,90.06 294.83,51.67 298.26,48.25 307.8,48.25 309.91,50.36 309.91,53.31 D103.01
  L30_SIGNAL w0.071: v1(344.67,206.34) 344.27,206.34 344.2,206.41 344.2,209.73 346.25,211.78 352.46,211.78 361.33,202.92 361.33,200.05 368.52,192.85 380.89,192.85 381.62,192.13 381.62,191.02 381.55,190.94 v1(381.15,190.94)
D10302: length 310.7
  TOP w0.086: v1(321.53,203.69) 321.08,203.24 321.08,202.2 324.55,198.73 324.55,197.86 324.63,197.78 SITE4.126
  L05_SIGNAL w0.071: v1(382.16,219.9) 382.56,219.9 382.63,219.83 382.63,218.32 365.94,201.63 365.94,167.96 352.93,154.95 352.93,125.37 343.12,115.56 333.39,115.56 325.67,107.85 309.75,107.85 297.56,95.66 297.56,66.91 302.25,62.22 311.65,62.22 312.37,61.5 312.37,60.91 D103.02
  L32_SIGNAL w0.071: v1(382.16,219.9) 382.56,219.9 382.63,219.97 382.63,221.06 382.24,221.46 380.86,221.46 377.49,218.08 340.82,218.08 339.86,217.12 326.54,217.12 319.98,210.57 319.98,208.24 321.06,207.16 321.06,203.76 321.13,203.69 v1(321.53,203.69)
D10303: length 286.1
  TOP w0.086: v1(343.52,206.34) 343.98,205.88 343.98,202.87 343.07,201.96 341.17,201.96 338.31,199.1 338.31,197.86 338.23,197.78 SITE4.92
  L07_SIGNAL w0.071: D103.03 310.11,53.57 310.11,50.28 307.88,48.05 298.18,48.05 294.64,51.59 294.64,90.14 324.79,120.3 324.79,122.14 330.08,127.42 330.08,142.45 339.03,151.4 349.38,151.4 360.89,162.91 360.89,186.02 367.93,193.06 380.65,193.06 381.82,191.89 381.82,191.02 381.89,190.94 v1(382.29,190.94)
  L30_SIGNAL w0.071: v1(343.52,206.34) 343.93,206.34 344,206.41 344,209.81 346.17,211.98 352.54,211.98 361.52,203 361.52,200.13 368.61,193.05 380.98,193.05 381.82,192.21 381.82,191.02 381.89,190.94 v1(382.29,190.94)
D10304: length 311.4
  TOP w0.086: SITE4.127 324.23,197.78 324.31,197.86 324.31,198.63 320.84,202.1 320.84,203.24 v1(320.39,203.69)
  L05_SIGNAL w0.071: v1(383.31,219.9) 382.9,219.9 382.83,219.83 382.83,218.24 366.14,201.54 366.14,167.88 353.13,154.87 353.13,125.29 343.2,115.37 333.47,115.37 325.75,107.65 309.83,107.65 297.76,95.58 297.76,67 302.34,62.42 311.74,62.42 312.57,61.58 312.57,60.81 D103.04
  L32_SIGNAL w0.071: v1(320.39,203.69) 320.79,203.69 320.86,203.76 320.86,207.08 319.78,208.16 319.78,210.65 326.46,217.32 339.77,217.32 340.74,218.28 377.41,218.28 380.78,221.65 382.33,221.65 382.83,221.15 382.83,219.97 382.9,219.9 v1(383.31,219.9)
D10305: length 339.3
  TOP w0.086: v1(318.79,209.08) 318.34,208.63 318.34,208.16 319.3,207.2 319.3,202.62 323.35,198.57 323.35,197.86 323.43,197.78 SITE4.129
  L07_SIGNAL w0.071: D103.05 319.93,53.45 319.93,48.79 316.99,45.84 295.94,45.84 292.12,49.67 292.12,90.85 329.34,128.08 329.34,145.04 337.93,153.63 348.1,153.63 359.93,165.46 359.93,196.57 363.1,199.74 364.64,199.74 372.77,207.87 382.2,207.87 382.63,207.44 382.63,206.38 382.56,206.31 v1(382.16,206.31)
  L30_SIGNAL w0.071: v1(318.79,209.08) 318.39,209.08 318.32,209.16 318.32,213.29 319.98,214.96 343.22,214.96 343.84,215.58 375.16,215.58 382.63,208.1 382.63,206.38 382.56,206.31 v1(382.16,206.31)
D10306: length 302.2
  TOP w0.086: v1(341.36,207.09) 340.9,206.64 340.9,203.67 336.95,199.72 336.95,197.86 337.03,197.78 SITE4.95
  L07_SIGNAL w0.071: v1(394.35,190.94) 394.76,190.94 394.83,190.87 394.83,189.75 391.71,186.63 373.26,186.63 371.35,184.72 368.05,184.72 363.34,180.01 363.34,161.71 350.33,148.7 340.76,148.7 338.5,146.43 336.43,146.43 333.26,143.26 333.26,141.5 331.45,139.69 331.45,132.41 332.08,131.78 332.08,129.69 331.05,128.66 331.05,124.11 324.96,118.01 324.96,116.08 297.07,88.19 297.07,64.45 299.43,62.08 321.99,62.08 322.53,61.55 322.53,60.91 D103.06
  L28_SIGNAL w0.071: v1(394.35,190.94) 394.76,190.94 394.83,191.02 394.83,196.58 387.03,204.38 370.35,204.38 369.53,205.2 366.33,205.2 365.67,204.55 362.24,204.55 354.77,212.02 343.01,212.02 340.88,209.89 340.88,207.16 340.96,207.09 v1(341.36,207.09)
D10307: length 341.2
  TOP w0.086: SITE4.130 323.03,197.78 323.11,197.86 323.11,198.47 319.06,202.52 319.06,207.1 318.1,208.06 318.1,208.63 v1(317.64,209.08)
  L07_SIGNAL w0.071: D103.07 320.13,53.43 320.13,48.71 317.07,45.64 295.86,45.64 291.92,49.59 291.92,90.93 329.15,128.16 329.15,145.13 337.85,153.83 348.02,153.83 359.73,165.54 359.73,196.65 363.02,199.94 364.55,199.94 372.68,208.07 382.28,208.07 382.83,207.52 382.83,206.38 382.9,206.31 v1(383.31,206.31)
  L30_SIGNAL w0.071: v1(317.64,209.08) 318.05,209.08 318.12,209.16 318.12,213.37 319.9,215.16 343.14,215.16 343.76,215.78 375.24,215.78 382.83,208.18 382.83,206.38 382.9,206.31 v1(383.31,206.31)
D10308: length 302.8
  TOP w0.086: v1(340.21,207.09) 340.67,206.64 340.67,203.77 336.71,199.82 336.71,197.86 336.63,197.78 SITE4.96
  L07_SIGNAL w0.071: D103.08 322.73,60.81 322.73,61.63 322.08,62.28 299.51,62.28 297.26,64.53 297.26,88.1 325.15,115.99 325.15,117.93 331.25,124.02 331.25,128.58 332.28,129.61 332.28,131.86 331.65,132.49 331.65,139.6 333.46,141.42 333.46,143.18 336.52,146.23 338.58,146.23 340.85,148.5 350.41,148.5 363.54,161.63 363.54,179.93 368.13,184.52 371.43,184.52 373.34,186.43 391.79,186.43 395.03,189.67 395.03,190.87 395.1,190.94 v1(395.5,190.94)
  L28_SIGNAL w0.071: v1(395.5,190.94) 395.1,190.94 395.03,191.02 395.03,196.67 387.11,204.58 370.43,204.58 369.61,205.4 366.25,205.4 365.59,204.74 362.33,204.74 354.86,212.21 342.92,212.21 340.69,209.98 340.69,207.16 340.62,207.09 v1(340.21,207.09)
D10309: length 288.4
  TOP w0.086: v1(346.32,208.6) 345.87,208.15 345.87,205.63 345.31,205.07 345.31,202.18 343.95,200.83 341.74,200.83 339.35,198.44 339.35,197.86 339.43,197.78 SITE4.89
  L07_SIGNAL w0.071: v1(407.82,160.85) 408.22,160.85 408.29,160.92 408.29,161.54 407.49,162.34 404.07,162.34 399.18,157.46 399.18,141.68 398.65,141.15 398.65,127.91 393.02,122.27 386.97,122.27 368.52,103.82 368.52,70.62 355.64,57.73 355.64,51.89 349.8,46.05 334.74,46.05 330.14,50.66 330.14,53.4 D103.09
  L28_SIGNAL w0.071: v1(346.32,208.6) 345.92,208.6 345.85,208.68 345.85,209.39 346.38,209.93 353.81,209.93 360.21,203.52 371.73,203.52 374.25,201 387.36,201 391.39,196.97 391.39,186.89 398.45,179.83 398.45,172.33 408.29,162.49 408.29,160.92 408.21,160.85 v1(407.82,160.85)
D10311: length 289
  TOP w0.086: v1(345.18,208.6) 345.63,208.15 345.63,205.73 345.07,205.17 345.07,202.28 343.85,201.07 341.64,201.07 339.11,198.54 339.11,197.86 339.03,197.78 SITE4.90
  L07_SIGNAL w0.071: v1(408.96,160.85) 408.56,160.85 408.49,160.92 408.49,161.63 407.57,162.54 403.98,162.54 398.98,157.54 398.98,141.76 398.46,141.23 398.46,127.99 392.93,122.47 386.89,122.47 368.33,103.9 368.33,70.7 355.44,57.81 355.44,51.97 349.71,46.25 334.83,46.25 330.34,50.74 330.34,53.48 D103.11
  L28_SIGNAL w0.071: v1(408.96,160.85) 408.55,160.85 408.48,160.92 408.48,162.57 398.65,172.41 398.65,179.91 391.59,186.97 391.59,197.05 387.44,201.2 374.33,201.2 371.81,203.72 360.29,203.72 353.89,210.12 346.3,210.12 345.65,209.47 345.65,208.68 345.58,208.6 v1(345.18,208.6)
D10313: length 280.8
  TOP w0.086: SITE4.133 317.68,193.23 317.6,193.15 317.23,193.15 311.06,199.32 306.27,199.32 v1(305.81,199.77)
  L07_SIGNAL w0.071: D103.13 340.29,53.41 340.29,50.8 342.04,49.05 348.65,49.05 351.33,51.73 351.33,59.79 363.66,72.12 363.66,104.87 385.82,127.02 385.82,142 389.1,145.28 394.67,145.28 394.83,145.13 394.83,144.15 394.76,144.08 v1(394.35,144.08)
  L28_SIGNAL w0.071: v1(394.35,144.08) 394.76,144.08 394.83,144.15 394.83,145.22 390.43,149.62 377.91,149.62 372.95,154.57 358.25,154.57 356.93,153.26 350.99,153.26 336.64,167.61 326.16,167.61 311.55,182.22 303.98,182.22 302.88,183.33 302.88,198.15 304.03,199.3 305.74,199.3 305.81,199.37 v1(305.81,199.77)
D10314: length 262.4
  TOP w0.086: SITE4.131 322.63,197.78 322.55,197.86 322.55,198.26 317.11,203.7 317.11,204.97 v1(317.56,205.42)
  L07_SIGNAL w0.071: v1(394.35,157.67) 394.76,157.67 394.83,157.6 394.83,156.64 394.33,156.14 378.54,156.14 376.09,153.69 376.09,133.08 374.52,131.51 374.52,125.24 360.32,111.05 360.32,73.29 349.45,62.41 343.32,62.41 342.75,61.84 342.75,60.81 D103.14
  L32_SIGNAL w0.071: v1(317.56,205.42) 317.16,205.42 317.09,205.35 317.09,190.98 320.06,188 320.06,176.73 324.32,172.48 355.32,172.48 362.04,165.75 383.26,165.75 393.1,155.92 394.26,155.92 394.83,156.48 394.83,157.6 394.76,157.67 v1(394.35,157.67)
D10315: length 280.4
  TOP w0.086: v1(305.81,198.63) 306.27,199.08 310.96,199.08 317.13,192.91 317.6,192.91 317.68,192.83 SITE4.134
  L07_SIGNAL w0.071: D103.15 340.48,53.46 340.48,50.88 342.12,49.25 348.56,49.25 351.13,51.82 351.13,59.87 363.47,72.21 363.47,104.95 385.62,127.11 385.62,142.08 389.02,145.48 394.76,145.48 395.02,145.21 395.02,144.15 395.1,144.08 v1(395.5,144.08)
  L28_SIGNAL w0.071: v1(395.5,144.08) 395.1,144.08 395.03,144.15 395.03,145.3 390.51,149.82 377.99,149.82 373.03,154.77 358.16,154.77 356.85,153.46 351.07,153.46 336.72,167.81 326.24,167.81 311.63,182.42 304.07,182.42 303.08,183.41 303.08,198.07 304.11,199.1 305.74,199.1 305.81,199.03 v1(305.81,198.63)
D10316: length 263.1
  TOP w0.086: v1(316.42,205.42) 316.87,204.97 316.87,203.6 322.31,198.16 322.31,197.86 322.23,197.78 SITE4.132
  L07_SIGNAL w0.071: D103.16 342.95,60.91 342.95,61.76 343.41,62.22 349.53,62.22 360.52,73.21 360.52,110.96 374.71,125.16 374.71,131.43 376.29,133 376.29,153.61 378.63,155.94 394.41,155.94 395.03,156.56 395.03,157.6 395.1,157.67 v1(395.5,157.67)
  L32_SIGNAL w0.071: v1(316.42,205.42) 316.82,205.42 316.89,205.35 316.89,190.9 319.87,187.92 319.87,176.65 324.24,172.28 355.24,172.28 361.96,165.55 383.18,165.55 393.01,155.72 394.34,155.72 395.02,156.4 395.02,157.6 395.1,157.67 v1(395.5,157.67)
D10601: length 185.7
  TOP w0.086: SITE4.85 343.98,192.03 344.06,192.11 345.74,192.11 350.12,196.49 357.07,196.49 v1(357.52,196.03)
  L05_SIGNAL w0.071: D106.01 383.48,73.72 383.48,73.1 382.79,72.41 378.34,72.41 375.78,74.97 375.78,99.77 392.59,116.58 392.59,161.42 393.52,162.35 394.42,162.35 394.83,161.95 394.83,160.92 394.76,160.85 v1(394.35,160.85)
  L28_SIGNAL w0.071: v1(357.52,196.03) 357.52,196.44 357.59,196.51 361.06,196.51 368.66,188.9 371.17,188.9 373.93,186.14 377.44,186.14 393.85,169.73 393.85,163.08 394.83,162.1 394.83,160.92 394.76,160.85 v1(394.35,160.85)
D10602: length 177.1
  TOP w0.086: v1(353.81,193.77) 353.35,194.22 349.53,194.22 346.61,191.31 344.06,191.31 343.98,191.23 SITE4.83
  L05_SIGNAL w0.071: D106.02 385.96,81.16 385.96,81.84 385.38,82.42 379.91,82.42 378.14,84.18 378.14,93.42 393.65,108.94 393.65,115.74 398.59,120.68 398.59,169.13 394.83,172.9 394.83,174.36 394.76,174.43 v1(394.35,174.43)
  L30_SIGNAL w0.071: v1(353.81,193.77) 353.81,194.17 353.88,194.24 359.5,194.24 369.36,184.39 380,184.39 388.62,175.77 394.36,175.77 394.83,175.31 394.83,174.51 394.76,174.43 v1(394.35,174.43)
D10603: length 187.3
  TOP w0.086: v1(357.52,197.18) 357.07,196.73 350.02,196.73 345.64,192.35 344.06,192.35 343.98,192.43 SITE4.86
  L05_SIGNAL w0.071: D106.03 383.68,73.8 383.68,73.02 382.87,72.22 378.26,72.22 375.58,74.89 375.58,99.86 392.39,116.66 392.39,161.5 393.44,162.55 394.5,162.55 395.03,162.03 395.03,160.92 395.1,160.85 v1(395.5,160.85)
  L28_SIGNAL w0.071: v1(395.5,160.85) 395.1,160.85 395.03,160.92 395.03,162.19 394.05,163.16 394.05,169.81 377.53,186.33 374.01,186.33 371.25,189.1 368.75,189.1 361.14,196.7 357.59,196.7 357.52,196.78 v1(357.52,197.18)
D10604: length 177.5
  TOP w0.086: SITE4.84 343.98,191.63 344.06,191.55 346.51,191.55 349.43,194.46 353.35,194.46 v1(353.81,194.92)
  L05_SIGNAL w0.071: D106.04 386.16,81.2 386.16,81.92 385.46,82.62 379.99,82.62 378.34,84.27 378.34,93.34 393.85,108.86 393.85,115.66 398.79,120.6 398.79,169.22 395.02,172.98 395.02,174.36 395.1,174.43 v1(395.5,174.43)
  L30_SIGNAL w0.071: v1(353.81,194.92) 353.81,194.51 353.88,194.44 359.58,194.44 369.44,184.59 380.08,184.59 388.7,175.97 394.45,175.97 395.02,175.39 395.02,174.51 395.1,174.43 v1(395.5,174.43)
D10605: length 263.3
  TOP w0.086: SITE4.135 317.68,192.43 317.6,192.35 316.53,192.35 311.68,197.2 309.02,197.2 v1(308.57,197.65)
  L07_SIGNAL w0.071: D106.05 393.72,73.64 393.72,73.35 392.76,72.39 379.39,72.39 374.61,77.18 374.61,94.03 394.42,113.84 394.42,118.17 400.13,123.89 401.89,123.89 406.37,128.37 406.37,146.16 412.09,151.88 412.09,157.84 410.65,159.28 409.26,159.28 408.54,158.57 408.54,157.74 408.47,157.67 v1(408.07,157.67)
  L30_SIGNAL w0.071: v1(408.07,157.67) 408.47,157.67 408.54,157.6 408.54,156.9 407.96,156.32 405.36,156.32 392.04,169.64 359.42,169.64 350.03,179.04 350.03,184.43 339.16,195.3 326.92,195.3 325.04,197.18 308.64,197.18 308.57,197.25 v1(308.57,197.65)
D10606: length 245.1
  TOP w0.086: SITE4.137 317.68,191.63 317.6,191.55 316.17,191.55 312.64,195.08 306.27,195.08 v1(305.81,195.53)
  L07_SIGNAL w0.071: v1(408.07,144.08) 408.47,144.08 408.54,144.01 408.54,126.23 396.59,114.28 396.59,110.65 377.66,91.72 377.66,85.08 380.33,82.42 395.52,82.42 396.14,81.8 396.14,81.18 D106.06
  L28_SIGNAL w0.071: v1(305.81,195.53) 305.81,195.13 305.74,195.06 304.85,195.06 303.96,194.17 303.96,187.36 307.01,184.3 312.28,184.3 313.06,183.51 313.06,182.43 322.53,172.97 350.65,172.97 366.83,156.78 374.65,156.78 378.91,152.53 401.43,152.53 408.54,145.42 408.54,144.15 408.47,144.08 v1(408.07,144.08)
D10607: length 263.5
  TOP w0.086: v1(308.57,196.51) 309.02,196.96 311.58,196.96 316.43,192.11 317.6,192.11 317.68,192.03 SITE4.136
  L07_SIGNAL w0.071: v1(409.21,157.67) 408.81,157.67 408.74,157.74 408.74,158.48 409.34,159.08 410.57,159.08 411.89,157.76 411.89,151.96 406.18,146.25 406.18,128.45 401.81,124.09 400.05,124.09 394.22,118.26 394.22,113.93 374.41,94.12 374.41,77.09 379.31,72.19 392.84,72.19 393.92,73.26 393.92,73.88 D106.07
  L30_SIGNAL w0.071: v1(409.21,157.67) 408.81,157.67 408.74,157.6 408.74,156.82 408.04,156.12 405.28,156.12 391.96,169.44 359.34,169.44 349.83,178.95 349.83,184.35 339.08,195.1 326.84,195.1 324.96,196.98 308.64,196.98 308.57,196.91 v1(308.57,196.51)
D10608: length 244.8
  TOP w0.086: v1(305.81,194.39) 306.27,194.84 312.55,194.84 316.07,191.31 317.6,191.31 317.68,191.23 SITE4.138
  L07_SIGNAL w0.071: v1(409.21,144.08) 408.81,144.08 408.74,144.01 408.74,126.15 396.79,114.2 396.79,110.57 377.86,91.64 377.86,85.17 380.41,82.62 395.61,82.62 396.34,81.89 396.34,81.18 D106.08
  L28_SIGNAL w0.071: v1(305.81,194.39) 305.81,194.79 305.74,194.86 304.93,194.86 304.16,194.09 304.16,187.44 307.1,184.5 312.36,184.5 313.26,183.6 313.26,182.52 322.61,173.17 350.73,173.17 366.91,156.98 374.74,156.98 378.99,152.73 401.52,152.73 408.74,145.51 408.74,144.15 408.81,144.08 v1(409.21,144.08)
D10609: length 269.6
  TOP w0.086: SITE4.140 317.68,190.43 317.6,190.35 313.96,190.35 312.03,192.28 309.02,192.28 v1(308.57,192.73)
  L07_SIGNAL w0.071: v1(421.53,157.67) 421.93,157.67 422,157.74 422,158.65 422.63,159.28 423.91,159.28 426.36,156.83 426.36,75.93 422.62,72.19 404.2,72.19 403.73,72.67 403.73,73.79 D106.09
  L30_SIGNAL w0.071: v1(308.57,192.73) 308.57,192.33 308.64,192.26 323.76,192.26 326.77,189.25 326.77,174.7 328.29,173.18 351.75,173.18 359.74,165.2 382.02,165.2 393.42,153.8 419.2,153.8 422,156.6 422,157.6 421.93,157.67 v1(421.53,157.67)
D10610: length 250.2
  TOP w0.086: SITE4.142 317.68,189.63 317.6,189.55 313.04,189.55 312.4,190.19 306.27,190.19 v1(305.81,190.64)
  L07_SIGNAL w0.071: v1(421.53,144.08) 421.93,144.08 422,144.01 422,104.44 424.87,101.57 424.87,84.47 423.09,82.68 407.13,82.68 406.26,81.81 406.26,81.14 D106.10
  L28_SIGNAL w0.071: v1(305.81,190.64) 305.81,190.24 305.89,190.16 308.65,190.16 309.54,191.06 323.05,191.06 326.66,187.44 326.66,177.95 330.33,174.28 356.97,174.28 369.56,161.69 374.07,161.69 379.52,156.24 418.09,156.24 420.16,154.18 420.16,142.79 420.57,142.37 421.35,142.37 422,143.03 422,144.01 421.93,144.08 v1(421.53,144.08)
D10611: length 268.6
  TOP w0.086: SITE4.141 317.68,190.03 317.6,190.11 313.86,190.11 311.93,192.04 309.02,192.04 v1(308.57,191.59)
  L07_SIGNAL w0.071: v1(422.68,157.67) 422.27,157.67 422.2,157.74 422.2,158.57 422.71,159.08 423.83,159.08 426.16,156.75 426.16,76.01 422.54,72.39 404.29,72.39 403.92,72.75 403.92,73.72 D106.11
  L30_SIGNAL w0.071: v1(422.68,157.67) 422.27,157.67 422.2,157.6 422.2,156.52 419.28,153.6 393.34,153.6 381.94,165 359.65,165 351.67,172.98 328.21,172.98 326.57,174.62 326.57,189.16 323.68,192.06 308.64,192.06 308.57,191.99 v1(308.57,191.59)
D10612: length 250.5
  TOP w0.086: v1(305.81,189.49) 306.27,189.95 312.3,189.95 312.94,189.31 317.6,189.31 317.68,189.23 SITE4.143
  L07_SIGNAL w0.071: v1(422.68,144.08) 422.27,144.08 422.2,144.01 422.2,104.52 425.07,101.65 425.07,84.38 423.18,82.49 407.22,82.49 406.46,81.73 406.46,81.22 D106.12
  L28_SIGNAL w0.071: v1(305.81,189.49) 305.81,189.9 305.89,189.97 308.73,189.97 309.62,190.86 322.97,190.86 326.47,187.36 326.47,177.87 330.25,174.09 356.89,174.09 369.48,161.5 373.99,161.5 379.44,156.05 418.01,156.05 419.96,154.1 419.96,142.7 420.49,142.17 421.43,142.17 422.2,142.94 422.2,144.01 422.27,144.08 v1(422.68,144.08)
D10613: length 271.5
  TOP w0.086: SITE4.114 329.43,197.78 329.35,197.86 329.35,207.66 v1(329.8,208.11)
  L05_SIGNAL w0.071: v1(407.82,177.36) 408.22,177.36 408.29,177.43 408.29,178.41 408.88,179 415.74,179 418.47,176.27 418.47,154.03 413.51,149.07 413.51,141.13 415.74,138.9 415.74,105.08 427.77,93.05 427.77,76.79 423.23,72.26 414.78,72.26 413.94,73.09 413.94,73.74 D106.13
  L30_SIGNAL w0.071: v1(407.82,177.36) 408.22,177.36 408.29,177.43 408.29,178.69 409.18,179.58 410.25,179.58 411.48,178.36 411.48,174.8 409.36,172.67 376.91,172.67 373.32,176.27 370.55,176.27 366.58,180.24 362.94,180.24 354.97,188.21 350.34,188.21 337.76,200.78 328.75,200.78 326.47,203.06 326.47,208.59 327.73,209.85 328.83,209.85 329.33,209.35 329.33,208.18 329.4,208.11 v1(329.8,208.11)
D10614: length 189
  TOP w0.086: v1(353.81,198.17) 353.35,198.62 350.67,198.62 344.96,192.91 344.06,192.91 343.98,192.83 SITE4.87
  L05_SIGNAL w0.071: D106.14 416.44,81.16 416.44,81.96 417.17,82.7 422.24,82.7 423.18,83.64 423.18,93.55 412.04,104.68 412.04,169.14 408.29,172.89 408.29,174.36 408.22,174.43 v1(407.82,174.43)
  L30_SIGNAL w0.071: v1(353.81,198.17) 353.81,198.57 353.88,198.64 359.07,198.64 369.66,188.05 372.01,188.05 374.12,185.95 390.92,185.95 401.05,175.81 407.82,175.81 408.29,175.34 408.29,174.51 408.22,174.43 v1(407.82,174.43)
D10615: length 268.2
  TOP w0.086: SITE4.115 329.03,197.78 329.11,197.86 329.11,207.66 v1(328.66,208.11)
  L05_SIGNAL w0.071: v1(408.96,177.36) 408.56,177.36 408.49,177.43 408.49,178.33 408.96,178.8 415.66,178.8 418.28,176.18 418.28,154.12 413.31,149.15 413.31,141.05 415.54,138.82 415.54,104.99 427.57,92.96 427.57,76.88 423.15,72.45 414.86,72.45 414.14,73.18 414.14,73.78 D106.15
  L30_SIGNAL w0.071: v1(408.96,177.36) 408.56,177.36 408.49,177.43 408.49,178.61 409.27,179.39 410.17,179.39 411.28,178.28 411.28,174.88 409.27,172.87 376.99,172.87 373.4,176.47 370.64,176.47 366.66,180.44 363.02,180.44 355.05,188.4 350.42,188.4 337.85,200.98 328.83,200.98 326.66,203.14 326.66,208.51 327.81,209.65 328.75,209.65 329.13,209.27 329.13,208.18 329.06,208.11 v1(328.66,208.11)
D10616: length 189.4
  TOP w0.086: SITE4.88 343.98,193.23 344.06,193.15 344.86,193.15 350.57,198.86 353.35,198.86 v1(353.81,199.31)
  L05_SIGNAL w0.071: D106.16 416.64,81.2 416.64,81.88 417.26,82.5 422.32,82.5 423.38,83.55 423.38,93.63 412.24,104.77 412.24,169.22 408.49,172.97 408.49,174.36 408.56,174.43 v1(408.96,174.43)
  L30_SIGNAL w0.071: v1(408.96,174.43) 408.56,174.43 408.49,174.51 408.49,175.42 407.9,176.01 401.14,176.01 391,186.14 374.2,186.14 372.09,188.25 369.75,188.25 359.16,198.84 353.88,198.84 353.81,198.91 v1(353.81,199.31)
D10701: length 215.7
  TOP w0.086: v1(310.98,176.32) 311.43,176.77 312.68,176.77 313.62,177.71 317.6,177.71 317.68,177.63 SITE4.172
  L03_SIGNAL w0.071: v1(325.39,142.43) 324.99,142.43 324.92,142.36 324.92,141.4 325.93,140.39 340.08,140.39 376.74,103.73 376.74,51.31 378.67,49.39 382.41,49.39 383.51,50.49 383.51,53.37 D107.01
  L30_SIGNAL w0.071: v1(310.98,176.32) 310.98,176.72 311.05,176.79 312.11,176.79 312.59,177.27 312.59,181.47 311.58,182.49 305.7,182.49 304.01,180.8 304.01,159.18 313.89,149.3 313.89,144.2 317.32,140.77 324.28,140.77 324.92,141.41 324.92,142.36 324.99,142.43 v1(325.39,142.43)
D10702: length 197.6
  TOP w0.086: SITE4.2 322.63,171.48 322.55,171.4 322.55,171.04 321.9,170.39 308.05,170.39 v1(307.59,169.94)
  L03_SIGNAL w0.071: D107.02 385.93,60.81 385.93,61.15 384.9,62.18 380.11,62.18 378.65,63.63 378.65,112.9 359.78,131.77 357.13,131.77 357.06,131.7 v1(357.06,131.3)
  L32_SIGNAL w0.071: v1(357.06,131.3) 357.06,131.7 356.99,131.77 356.46,131.77 351.88,127.19 341.52,127.19 333.46,135.24 333.46,143.72 334.63,144.9 334.63,164.46 331.7,167.4 321.36,167.4 318.35,170.41 307.67,170.41 307.59,170.34 v1(307.59,169.94)
D10703: length 214.7
  TOP w0.086: SITE4.171 317.68,178.03 317.6,177.95 313.52,177.95 312.58,177.01 311.43,177.01 v1(310.98,177.46)
  L03_SIGNAL w0.071: D107.03 383.71,53.51 383.71,50.41 382.49,49.19 378.59,49.19 376.55,51.23 376.55,103.64 340,140.19 325.85,140.19 324.72,141.32 324.72,142.36 324.65,142.43 v1(324.25,142.43)
  L30_SIGNAL w0.071: v1(324.25,142.43) 324.65,142.43 324.72,142.36 324.72,141.49 324.2,140.97 317.4,140.97 314.09,144.28 314.09,149.38 304.21,159.26 304.21,180.72 305.78,182.29 311.5,182.29 312.39,181.39 312.39,177.35 312.03,176.99 311.05,176.99 310.98,177.06 v1(310.98,177.46)
D10704: length 197.5
  TOP w0.086: SITE4.1 322.23,171.48 322.31,171.4 322.31,171.14 321.8,170.63 308.05,170.63 v1(307.59,171.09)
  L03_SIGNAL w0.071: v1(357.06,132.44) 357.06,132.04 357.13,131.97 359.86,131.97 378.85,112.98 378.85,63.72 380.19,62.38 384.99,62.38 386.13,61.24 386.13,60.91 D107.04
  L32_SIGNAL w0.071: v1(357.06,132.44) 357.06,132.04 356.99,131.97 356.38,131.97 351.79,127.38 341.6,127.38 333.66,135.32 333.66,143.64 334.83,144.81 334.83,164.55 331.78,167.6 321.44,167.6 318.43,170.61 307.67,170.61 307.59,170.68 v1(307.59,171.09)
D10705: length 208.9
  TOP w0.086: SITE4.81 343.98,190.43 344.06,190.51 347.99,190.51 350.02,192.53 357.07,192.53 v1(357.52,192.08)
  L05_SIGNAL w0.071: D107.05 393.65,53.39 393.65,51.73 389.54,47.62 380.67,47.62 371.9,56.4 371.9,106.44 377.35,111.89 377.35,129.14 379.17,130.96 379.17,161.33 379.87,162.03 381.27,162.03 381.62,161.68 381.62,160.66 381.55,160.59 v1(381.15,160.59)
  L28_SIGNAL w0.071: v1(381.15,160.59) 381.55,160.59 381.62,160.66 381.62,162.15 374.46,169.31 369.24,169.31 363.61,174.95 363.61,190.08 361.13,192.55 357.59,192.55 357.52,192.48 v1(357.52,192.08)
D10706: length 191.1
  TOP w0.086: SITE4.79 343.98,189.63 344.06,189.71 349.05,189.71 349.94,190.59 353.35,190.59 v1(353.81,190.14)
  L05_SIGNAL w0.071: D107.06 396.07,60.79 396.07,61.7 395.59,62.19 378.21,62.19 373.83,66.57 373.83,106.2 385.36,117.73 385.36,169.24 381.62,172.98 381.62,174.11 381.55,174.18 v1(381.15,174.18)
  L30_SIGNAL w0.071: v1(381.15,174.18) 381.55,174.18 381.62,174.25 381.62,175.3 381.29,175.63 376.64,175.63 371.96,180.31 369.57,180.31 359.27,190.61 353.88,190.61 353.81,190.54 v1(353.81,190.14)
D10707: length 210.4
  TOP w0.086: SITE4.82 343.98,190.83 344.06,190.75 347.89,190.75 349.92,192.77 357.07,192.77 v1(357.52,193.22)
  L05_SIGNAL w0.071: v1(382.29,160.59) 381.89,160.59 381.82,160.66 381.82,161.76 381.35,162.23 379.79,162.23 378.97,161.41 378.97,131.05 377.15,129.23 377.15,111.97 371.7,106.52 371.7,56.31 380.59,47.42 389.62,47.42 393.85,51.65 393.85,53.49 D107.07
  L28_SIGNAL w0.071: v1(382.29,160.59) 381.89,160.59 381.82,160.66 381.82,162.24 374.54,169.51 369.33,169.51 363.8,175.03 363.8,190.16 361.22,192.75 357.59,192.75 357.52,192.82 v1(357.52,193.22)
D10708: length 191.5
  TOP w0.086: v1(353.81,191.28) 353.35,190.83 349.84,190.83 348.95,189.95 344.06,189.95 343.98,190.03 SITE4.80
  L05_SIGNAL w0.071: v1(382.29,174.18) 381.89,174.18 381.82,174.11 381.82,173.06 385.56,169.32 385.56,117.64 374.03,106.11 374.03,66.65 378.29,62.39 395.67,62.39 396.27,61.78 396.27,60.93 D107.08
  L30_SIGNAL w0.071: v1(353.81,191.28) 353.81,190.88 353.88,190.81 359.35,190.81 369.66,180.51 372.04,180.51 376.72,175.83 381.37,175.83 381.82,175.39 381.82,174.25 381.89,174.18 v1(382.29,174.18)
D10709: length 346.6
  L05_SIGNAL w0.071: v1(421.02,174.43) 421.43,174.43 421.5,174.51 421.5,175.58 422.03,176.12 423.9,176.12 435.7,164.32 435.7,60.05 421.98,46.33 407.05,46.33 403.83,49.55 403.83,53.37 D107.09
  L32_SIGNAL w0.071: v1(310.01,134.11) 310.01,135.47 310.08,135.54 328.97,135.54 341.4,123.11 355.19,123.11 369.94,137.86 422.41,137.86 427.04,142.49 427.04,174.93 425.07,176.9 422.55,176.9 421.5,175.84 421.5,174.51 421.43,174.43 v1(421.02,174.43)
  BOTTOM w0.119: v1(310.01,134.11) UNK4K43.6
D10710: length 222.5
  TOP w0.086: v1(357.52,187.66) 357.07,188.11 344.06,188.11 343.98,188.03 SITE4.75
  L05_SIGNAL w0.071: D107.10 406.13,60.69 406.13,61.58 406.83,62.28 422.74,62.28 432.88,72.42 432.88,90.42 419.95,103.35 419.95,158.47 421.5,160.02 421.5,160.77 421.43,160.85 v1(421.02,160.85)
  L32_SIGNAL w0.071: v1(357.52,187.66) 357.52,188.06 357.59,188.13 358.17,188.13 369.5,176.8 374.11,176.8 382.05,168.86 414.74,168.86 421.5,162.11 421.5,160.92 421.43,160.85 v1(421.02,160.85)
D10711: length 344.2
  L05_SIGNAL w0.071: D107.11 404.03,53.51 404.03,49.64 407.13,46.53 421.9,46.53 435.5,60.14 435.5,164.24 423.82,175.92 422.12,175.92 421.7,175.5 421.7,174.51 421.77,174.43 v1(422.17,174.43)
  L32_SIGNAL w0.071: v1(422.17,174.43) 421.77,174.43 421.69,174.51 421.69,175.76 422.64,176.7 424.99,176.7 426.84,174.85 426.84,142.57 422.33,138.06 369.85,138.06 355.1,123.31 341.48,123.31 329.05,135.74 310.08,135.74 310.01,135.81 v1(310.01,137.16)
  BOTTOM w0.119: v1(310.01,137.16) UNK4K43.3
D10712: length 223
  TOP w0.086: v1(357.52,188.8) 357.07,188.35 344.06,188.35 343.98,188.43 SITE4.76
  L05_SIGNAL w0.071: v1(422.17,160.85) 421.77,160.85 421.69,160.77 421.69,159.93 420.15,158.39 420.15,103.44 433.08,90.51 433.08,72.34 422.82,62.08 406.91,62.08 406.33,61.5 406.33,61.03 D107.12
  L32_SIGNAL w0.071: v1(422.17,160.85) 421.77,160.85 421.69,160.92 421.69,162.19 414.83,169.06 382.13,169.06 374.19,177 369.58,177 358.26,188.33 357.59,188.33 357.52,188.4 v1(357.52,188.8)
D10713: length 221.5
  TOP w0.086: v1(319.69,162.06) 319.24,162.51 319.24,165.66 324.15,170.57 324.15,171.4 324.23,171.48 SITE4.6
  L03_SIGNAL w0.071: D107.13 413.83,53.53 413.83,51.92 415.33,50.41 421.68,50.41 424.19,52.93 424.19,104.21 401.72,126.68 401.72,130.86 390.96,141.62 390.96,142.61 391.03,142.68 v1(391.43,142.68)
  L30_SIGNAL w0.071: v1(391.43,142.68) 391.03,142.68 390.96,142.76 390.96,144.31 389.67,145.61 378.54,145.61 371.89,152.26 357.58,152.26 356.65,153.19 331.58,153.19 330.5,152.12 320.93,152.12 319.22,153.82 319.22,161.99 319.29,162.06 v1(319.69,162.06)
D10714: length 197.7
  TOP w0.086: SITE4.8 325.03,171.48 324.95,171.4 324.95,170.08 321.42,166.55 321.42,159.77 v1(321.88,159.32)
  L03_SIGNAL w0.071: v1(391.43,129.1) 391.03,129.1 390.96,129.17 390.96,129.98 391.28,130.3 395.77,130.3 422.99,103.08 422.99,63.01 422.28,62.3 417.48,62.3 416.44,61.27 416.44,60.84 D107.14
  L28_SIGNAL w0.071: v1(321.88,159.32) 321.47,159.32 321.4,159.24 321.4,155.23 342.35,134.28 387.36,134.28 390.96,130.68 390.96,129.17 391.03,129.1 v1(391.43,129.1)
D10715: length 220.9
  TOP w0.086: v1(318.55,162.06) 319,162.51 319,165.76 323.91,170.67 323.91,171.4 323.83,171.48 SITE4.5
  L03_SIGNAL w0.071: D107.15 414.02,53.34 414.02,52 415.41,50.61 421.59,50.61 423.99,53.01 423.99,104.13 401.52,126.6 401.52,130.78 390.76,141.54 390.76,142.61 390.69,142.68 v1(390.29,142.68)
  L30_SIGNAL w0.071: v1(318.55,162.06) 318.95,162.06 319.02,161.99 319.02,153.74 320.84,151.92 330.59,151.92 331.66,152.99 356.57,152.99 357.5,152.06 371.81,152.06 378.46,145.41 389.58,145.41 390.76,144.23 390.76,142.76 390.69,142.68 v1(390.29,142.68)
D10716: length 198.4
  TOP w0.086: v1(320.73,159.32) 321.18,159.77 321.18,166.65 324.71,170.18 324.71,171.4 324.63,171.48 SITE4.7
  L03_SIGNAL w0.071: v1(390.29,129.1) 390.69,129.1 390.76,129.17 390.76,130.06 391.2,130.5 395.85,130.5 423.19,103.16 423.19,62.93 422.36,62.1 417.56,62.1 416.64,61.19 416.64,60.88 D107.16
  L28_SIGNAL w0.071: v1(390.29,129.1) 390.69,129.1 390.76,129.17 390.76,130.6 387.28,134.08 342.26,134.08 321.2,155.14 321.2,159.24 321.13,159.32 v1(320.73,159.32)
D10801: length 216.1
  TOP w0.086: v1(310.98,180.03) 311.43,180.49 312.18,180.49 313.35,179.31 317.6,179.31 317.68,179.23 SITE4.168
  L03_SIGNAL w0.071: v1(311.89,156.84) 311.49,156.84 311.42,156.77 311.42,155.6 314.45,152.57 314.45,149.22 322.63,141.04 322.63,125.58 327.73,120.47 333.13,120.47 338.77,114.83 346.44,114.83 371.7,89.57 371.7,34.1 375.91,29.89 381.03,29.89 383.52,32.38 383.52,33.04 D108.01
  L30_SIGNAL w0.071: v1(310.98,180.03) 310.98,180.43 310.91,180.51 306.49,180.51 305.63,179.65 305.63,162.35 308.97,159.02 310.12,159.02 311.42,157.72 311.42,156.92 311.49,156.84 v1(311.89,156.84)
D10802: length 215.6
  TOP w0.086: v1(310.98,172.38) 311.43,172.83 312.94,172.83 316.22,176.11 317.6,176.11 317.68,176.03 SITE4.176
  L03_SIGNAL w0.071: v1(325.39,128.84) 324.99,128.84 324.92,128.91 324.92,129.48 325.61,130.17 335.01,130.17 337.76,127.42 341.34,127.42 372.97,95.78 372.97,47.6 377.01,43.56 384.68,43.56 386.02,42.22 386.02,40.58 D108.02
  L32_SIGNAL w0.071: v1(325.39,128.84) 324.99,128.84 324.92,128.91 324.92,130.03 324.31,130.65 303.11,130.65 301.42,132.34 301.42,165.81 304.63,169.03 304.63,170.63 306.86,172.85 310.91,172.85 310.98,172.78 v1(310.98,172.38)
D10803: length 217
  TOP w0.086: SITE4.167 317.68,179.63 317.6,179.55 313.45,179.55 312.28,180.72 311.43,180.72 v1(310.98,181.18)
  L03_SIGNAL w0.071: D108.03 383.71,33.19 383.71,32.29 381.12,29.7 375.83,29.7 371.5,34.02 371.5,89.49 346.35,114.64 338.69,114.64 333.05,120.28 327.65,120.28 322.43,125.49 322.43,140.96 314.25,149.14 314.25,152.49 311.22,155.51 311.22,156.77 311.15,156.84 v1(310.75,156.84)
  L30_SIGNAL w0.071: v1(310.98,181.18) 310.98,180.77 310.91,180.7 306.41,180.7 305.44,179.73 305.44,162.27 308.88,158.82 310.04,158.82 311.22,157.64 311.22,156.92 311.15,156.84 v1(310.75,156.84)
D10804: length 216.5
  TOP w0.086: SITE4.175 317.68,176.43 317.6,176.35 316.12,176.35 312.84,173.07 311.43,173.07 v1(310.98,173.52)
  L03_SIGNAL w0.071: v1(324.25,128.84) 324.65,128.84 324.72,128.91 324.72,129.56 325.53,130.37 335.1,130.37 337.85,127.62 341.42,127.62 373.17,95.87 373.17,47.68 377.1,43.76 384.76,43.76 386.21,42.3 386.21,40.51 D108.04
  L32_SIGNAL w0.071: v1(324.25,128.84) 324.65,128.84 324.72,128.91 324.72,129.95 324.23,130.45 303.03,130.45 301.22,132.26 301.22,165.89 304.44,169.11 304.44,170.71 306.77,173.05 310.91,173.05 310.98,173.12 v1(310.98,173.52)
D10805: length 228.7
  TOP w0.086: v1(307.59,178.06) 308.05,178.51 317.6,178.51 317.68,178.43 SITE4.170
  L03_SIGNAL w0.071: D108.05 393.65,33.07 393.65,31.88 389.09,27.32 374.82,27.32 369.76,32.37 369.76,87.09 352.73,104.13 341.49,104.13 319.81,125.81 319.81,135.37 314.39,140.79 312.25,140.79 311.42,141.63 311.42,143.18 311.49,143.26 v1(311.89,143.26)
  L28_SIGNAL w0.071: v1(311.89,143.26) 311.49,143.26 311.42,143.33 311.42,144.93 310.12,146.23 310.12,153.87 305.07,158.92 305.07,177.85 305.75,178.53 307.52,178.53 307.59,178.46 v1(307.59,178.06)
D10806: length 213.5
  TOP w0.086: v1(307.59,174.42) 308.05,174.88 312.6,174.88 314.63,176.91 317.6,176.91 317.68,176.83 SITE4.174
  L03_SIGNAL w0.071: v1(343.47,131.3) 343.47,131.7 343.54,131.77 345.3,131.77 374.8,102.27 374.8,50.05 379.24,45.61 393.29,45.61 396.23,42.67 396.23,40.63 D108.06
  L32_SIGNAL w0.071: v1(343.47,131.3) 343.47,131.7 343.4,131.77 342.69,131.77 342.4,132.06 340.71,132.06 338.34,134.43 338.34,150.55 339.37,151.58 339.37,165.65 336.55,168.47 322.48,168.47 316.06,174.9 307.67,174.9 307.59,174.83 v1(307.59,174.42)
D10807: length 229.7
  TOP w0.086: v1(307.59,179.2) 308.05,178.75 317.6,178.75 317.68,178.83 SITE4.169
  L03_SIGNAL w0.071: v1(310.75,143.26) 311.15,143.26 311.22,143.18 311.22,141.54 312.17,140.59 314.31,140.59 319.61,135.29 319.61,125.73 341.41,103.93 352.64,103.93 369.57,87.01 369.57,32.29 374.74,27.12 389.17,27.12 393.85,31.8 393.85,33.17 D108.07
  L28_SIGNAL w0.071: v1(307.59,179.2) 307.59,178.8 307.52,178.73 305.67,178.73 304.87,177.93 304.87,158.83 309.92,153.78 309.92,146.15 311.22,144.85 311.22,143.33 311.15,143.26 v1(310.75,143.26)
D10808: length 213.7
  TOP w0.086: v1(307.59,175.57) 308.05,175.12 312.5,175.12 314.53,177.15 317.6,177.15 317.68,177.23 SITE4.173
  L03_SIGNAL w0.071: v1(343.47,132.44) 343.47,132.04 343.54,131.97 345.38,131.97 375,102.36 375,50.13 379.32,45.81 393.38,45.81 396.43,42.75 396.43,40.45 D108.08
  L32_SIGNAL w0.071: v1(307.59,175.57) 307.59,175.17 307.67,175.1 316.14,175.1 322.57,168.67 336.64,168.67 339.57,165.73 339.57,151.5 338.54,150.46 338.54,134.51 340.79,132.26 342.49,132.26 342.78,131.97 343.4,131.97 343.47,132.04 v1(343.47,132.44)
D10809: length 277.7
  TOP w0.086: SITE4.14 327.43,171.48 327.35,171.4 327.35,162.51 v1(327.8,162.06)
  L03_SIGNAL w0.071: v1(417.85,142.68) 417.45,142.68 417.38,142.61 417.38,141.64 437.84,121.18 437.84,40.75 422.84,25.74 406.42,25.74 403.72,28.44 403.72,33.16 D108.09
  L30_SIGNAL w0.071: v1(417.85,142.68) 417.45,142.68 417.38,142.76 417.38,145.22 416.83,145.76 416.83,147.69 412.74,151.77 383.72,151.77 376.78,158.72 370.81,158.72 369.67,157.58 366.34,157.58 365.51,158.41 340.61,158.41 339.07,156.87 335.4,156.87 334.71,157.56 327.95,157.56 327.33,158.19 327.33,161.99 327.4,162.06 v1(327.8,162.06)
D10810: length 234.2
  TOP w0.086: v1(326.02,159.32) 325.57,159.77 325.57,166.86 326.55,167.84 326.55,171.4 326.63,171.48 SITE4.12
  L03_SIGNAL w0.071: D108.10 406.29,40.53 406.29,42.71 408.39,44.81 421.74,44.81 425.31,48.38 425.31,114.03 408.69,130.65 404.8,130.65 404.17,130.01 404.17,129.17 404.24,129.1 v1(404.64,129.1)
  L28_SIGNAL w0.071: v1(404.64,129.1) 404.24,129.1 404.17,129.17 404.17,130.75 397.12,137.81 369.68,137.81 367.35,135.48 344.94,135.48 325.55,154.87 325.55,159.24 325.62,159.32 v1(326.02,159.32)
D10811: length 277.1
  TOP w0.086: v1(326.66,162.06) 327.11,162.51 327.11,171.4 327.03,171.48 SITE4.13
  L03_SIGNAL w0.071: v1(416.71,142.68) 417.11,142.68 417.18,142.61 417.18,141.56 437.65,121.09 437.65,40.83 422.76,25.94 406.5,25.94 403.92,28.53 403.92,33.08 D108.11
  L30_SIGNAL w0.071: v1(416.71,142.68) 417.11,142.68 417.18,142.76 417.18,145.14 416.64,145.68 416.64,147.6 412.66,151.58 383.64,151.58 376.69,158.52 370.89,158.52 369.75,157.38 366.26,157.38 365.43,158.21 340.69,158.21 339.15,156.67 335.32,156.67 334.63,157.36 327.87,157.36 327.13,158.1 327.13,161.99 327.06,162.06 v1(326.66,162.06)
D10812: length 234.9
  TOP w0.086: SITE4.11 326.23,171.48 326.31,171.4 326.31,167.94 325.33,166.96 325.33,159.77 v1(324.88,159.32)
  L03_SIGNAL w0.071: v1(403.5,129.1) 403.9,129.1 403.97,129.17 403.97,130.1 404.72,130.85 408.77,130.85 425.51,114.11 425.51,48.3 421.82,44.61 408.47,44.61 406.48,42.63 406.48,40.56 D108.12
  L28_SIGNAL w0.071: v1(324.88,159.32) 325.28,159.32 325.35,159.24 325.35,154.79 344.86,135.28 367.43,135.28 369.76,137.61 397.03,137.61 403.97,130.67 403.97,129.17 403.9,129.1 v1(403.5,129.1)
D10813: length 260.5
  TOP w0.086: SITE4.10 325.83,171.48 325.75,171.4 325.75,168.95 323.58,166.78 323.58,162.51 v1(324.03,162.06)
  L03_SIGNAL w0.071: D108.13 413.98,33.06 413.98,30.47 415.91,28.54 420.94,28.54 435.6,43.21 435.6,119.45 417.32,137.74 407.56,137.74 404.17,141.13 404.17,142.61 404.24,142.68 v1(404.64,142.68)
  L30_SIGNAL w0.071: v1(404.64,142.68) 404.24,142.68 404.17,142.76 404.17,144.54 403.27,145.43 403.27,147.9 401.63,149.54 378.73,149.54 372.92,155.35 325.21,155.35 323.56,156.99 323.56,161.99 323.63,162.06 v1(324.03,162.06)
D10814: length 228.3
  TOP w0.086: SITE4.16 328.23,171.48 328.15,171.4 328.15,163.49 329.52,162.12 329.52,159.77 v1(329.98,159.32)
  L03_SIGNAL w0.071: D108.14 416.43,40.51 416.43,41.1 418.18,42.85 422.76,42.85 426.71,46.8 426.71,122.2 418.87,130.04 417.85,130.04 417.38,129.56 417.38,129.17 417.45,129.1 v1(417.85,129.1)
  L28_SIGNAL w0.071: v1(417.85,129.1) 417.45,129.1 417.38,129.17 417.38,130.45 406.19,141.64 370.19,141.64 365.78,137.22 351.45,137.22 347.69,140.98 343.88,140.98 329.5,155.36 329.5,159.24 329.57,159.32 v1(329.98,159.32)
D10815: length 259.7
  TOP w0.086: v1(322.89,162.06) 323.34,162.51 323.34,166.88 325.51,169.05 325.51,171.4 325.43,171.48 SITE4.9
  L03_SIGNAL w0.071: v1(403.5,142.68) 403.9,142.68 403.97,142.61 403.97,141.05 407.48,137.54 417.23,137.54 435.4,119.37 435.4,43.29 420.85,28.74 415.99,28.74 414.18,30.55 414.18,33.18 D108.15
  L30_SIGNAL w0.071: v1(322.89,162.06) 323.29,162.06 323.36,161.99 323.36,156.91 325.12,155.15 372.84,155.15 378.64,149.34 401.55,149.34 403.07,147.82 403.07,145.35 403.97,144.45 403.97,142.76 403.9,142.68 v1(403.5,142.68)
D10816: length 229
  TOP w0.086: v1(328.83,159.32) 329.28,159.77 329.28,162.02 327.91,163.39 327.91,171.4 327.83,171.48 SITE4.15
  L03_SIGNAL w0.071: D108.16 416.63,40.57 416.63,41.02 418.26,42.65 422.85,42.65 426.91,46.71 426.91,122.28 418.95,130.24 417.77,130.24 417.18,129.65 417.18,129.17 417.11,129.1 v1(416.71,129.1)
  L28_SIGNAL w0.071: v1(328.83,159.32) 329.23,159.32 329.3,159.24 329.3,155.27 343.8,140.78 347.61,140.78 351.36,137.02 365.86,137.02 370.28,141.44 406.1,141.44 417.18,130.36 417.18,129.17 417.11,129.1 v1(416.71,129.1)
D10901: length 234.7
  TOP w0.086: SITE2.168 317.68,239.23 317.6,239.31 313.35,239.31 312.18,240.48 311.43,240.48 v1(310.98,240.03)
  L03_SIGNAL w0.071: D109.01 419.2,335.18 419.2,336.7 420.55,338.05 422.62,338.05 426.13,334.55 426.13,252.08 424.19,250.15 418.71,250.15 417.12,251.73 417.12,251.83 417.19,251.9 v1(417.6,251.9)
  L30_SIGNAL w0.071: v1(310.98,240.03) 310.98,240.43 311.05,240.51 314.71,240.51 316.83,238.39 334.61,238.39 339.64,243.42 345.94,243.42 350.53,238.82 359.89,238.82 360.55,239.48 406.27,239.48 417.12,250.34 417.12,251.83 417.19,251.9 v1(417.6,251.9)
D10902: length 227.5
  TOP w0.086: v1(307.59,238.06) 308.05,238.51 317.6,238.51 317.68,238.43 SITE2.170
  L03_SIGNAL w0.071: D109.02 416.72,327.82 416.72,306.26 414.7,304.24 414.7,241.52 417.12,239.1 417.12,238.39 417.19,238.32 v1(417.6,238.32)
  L28_SIGNAL w0.071: v1(417.6,238.32) 417.19,238.32 417.12,238.24 417.12,233.87 412.78,229.53 354.96,229.53 352.33,232.16 325.01,232.16 318.63,238.53 307.67,238.53 307.59,238.46 v1(307.59,238.06)
