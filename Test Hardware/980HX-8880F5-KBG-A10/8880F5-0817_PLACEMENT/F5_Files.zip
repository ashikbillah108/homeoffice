# Allegro board 8880F5-0827_updates.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D10903: length 235.7
  TOP w0.086: SITE2.167 317.68,239.63 317.6,239.55 313.45,239.55 312.28,240.72 311.43,240.72 v1(310.98,241.18)
  L03_SIGNAL w0.071: v1(416.45,251.9) 416.85,251.9 416.92,251.83 416.92,251.65 418.62,249.95 424.28,249.95 426.32,252 426.32,334.63 422.71,338.25 420.47,338.25 419,336.78 419,335.18 D109.03
  L30_SIGNAL w0.071: v1(310.98,241.18) 310.98,240.77 311.05,240.7 314.8,240.7 316.91,238.59 334.53,238.59 339.56,243.62 346.02,243.62 350.61,239.02 359.81,239.02 360.46,239.68 406.18,239.68 416.92,250.42 416.92,251.83 416.85,251.9 v1(416.45,251.9)
D10904: length 227.2
  TOP w0.086: SITE2.169 317.68,238.83 317.6,238.75 308.05,238.75 v1(307.59,239.2)
  L03_SIGNAL w0.071: v1(416.45,238.32) 416.85,238.32 416.92,238.39 416.92,239.01 414.5,241.44 414.5,304.32 416.52,306.34 416.52,327.7 D109.04
  L28_SIGNAL w0.071: v1(307.59,239.2) 307.59,238.8 307.67,238.73 318.72,238.73 325.09,232.35 352.41,232.35 355.04,229.72 412.7,229.72 416.92,233.95 416.92,238.24 416.85,238.32 v1(416.45,238.32)
D10905: length 274.2
  TOP w0.086: v1(319.69,222.06) 319.24,222.51 319.24,225.66 324.15,230.57 324.15,231.4 324.23,231.48 SITE2.6
  L03_SIGNAL w0.071: D109.05 409.03,335.19 409.03,339.2 411.51,341.68 424.85,341.68 435.92,330.62 435.92,242.89 427.23,234.2 403.79,234.2 403.15,234.84 403.15,235.83 403.22,235.9 v1(403.63,235.9)
  L30_SIGNAL w0.071: v1(403.63,235.9) 403.22,235.9 403.15,235.83 403.15,234.49 400.17,231.5 366.07,231.5 365.2,232.37 324.45,232.37 319.22,227.14 319.22,222.13 319.29,222.06 v1(319.69,222.06)
D10906: length 218.2
  TOP w0.086: SITE2.14 327.43,231.48 327.35,231.4 327.35,222.51 v1(327.8,222.06)
  L03_SIGNAL w0.071: D109.06 406.53,327.79 406.53,307.57 400.89,301.93 400.89,231.51 410.01,222.39 410.01,220.48 410.08,220.41 v1(410.48,220.41)
  L30_SIGNAL w0.071: v1(410.48,220.41) 410.08,220.41 410.01,220.34 410.01,218.76 407.59,216.34 399.93,216.34 398.07,218.21 343.65,218.21 341.59,220.26 331.08,220.26 328.38,222.96 327.77,222.96 327.33,222.52 327.33,222.13 327.4,222.06 v1(327.8,222.06)
D10907: length 275.5
  TOP w0.086: v1(318.55,222.06) 319,222.51 319,225.76 323.91,230.67 323.91,231.4 323.83,231.48 SITE2.5
  L03_SIGNAL w0.071: D109.07 408.83,335.17 408.83,339.29 411.42,341.88 424.94,341.88 436.12,330.7 436.12,242.81 427.31,234.01 403.71,234.01 402.95,234.76 402.95,235.83 402.88,235.9 v1(402.48,235.9)
  L30_SIGNAL w0.071: v1(318.55,222.06) 318.95,222.06 319.02,222.13 319.02,227.22 324.37,232.57 365.28,232.57 366.15,231.7 400.09,231.7 402.95,234.57 402.95,235.83 402.88,235.9 v1(402.48,235.9)
D10908: length 218.2
  TOP w0.086: v1(326.66,222.06) 327.11,222.51 327.11,231.4 327.03,231.48 SITE2.13
  L03_SIGNAL w0.071: v1(409.34,220.41) 409.74,220.41 409.81,220.48 409.81,222.31 400.69,231.43 400.69,302.01 406.34,307.65 406.34,327.72 D109.08
  L30_SIGNAL w0.071: v1(409.34,220.41) 409.74,220.41 409.81,220.34 409.81,218.84 407.51,216.54 400.01,216.54 398.15,218.4 343.73,218.4 341.67,220.46 331.16,220.46 328.46,223.16 327.69,223.16 327.13,222.6 327.13,222.13 327.06,222.06 v1(326.66,222.06)
D10909: length 264.4
  TOP w0.086: SITE2.176 317.68,236.03 317.6,236.11 316.22,236.11 312.94,232.83 311.43,232.83 v1(310.98,232.38)
  L03_SIGNAL w0.071: v1(390.16,222.06) 389.76,222.06 389.69,221.99 389.69,220.76 389.22,220.3 387.72,220.3 386.36,221.66 386.36,233.13 380.13,239.36 380.13,300.7 372.54,308.29 372.54,336.85 378.95,343.26 393.78,343.26 398.86,338.19 398.86,335.2 D109.09
  L32_SIGNAL w0.071: v1(390.16,222.06) 389.76,222.06 389.69,221.99 389.69,221.89 389.7,221.88 389.7,220.52 389.03,219.85 387.29,219.85 383.84,223.31 380.53,223.31 376.41,219.19 364.1,219.19 351.28,232.02 322.43,232.02 321.6,232.85 311.05,232.85 310.98,232.78 v1(310.98,232.38)
D10910: length 217.8
  TOP w0.086: v1(321.88,219.32) 321.42,219.77 321.42,226.55 324.95,230.08 324.95,231.4 325.03,231.48 SITE2.8
  L03_SIGNAL w0.071: D109.10 396.38,327.8 396.38,314.52 397.74,313.15 397.74,228.73 403.15,223.32 403.15,222.39 403.22,222.31 v1(403.63,222.31)
  L28_SIGNAL w0.071: v1(321.88,219.32) 321.47,219.32 321.4,219.39 321.4,219.95 321.87,220.42 346.77,220.42 347.65,219.53 365.2,219.53 369.64,215.09 398.51,215.09 403.15,219.73 403.15,222.24 403.22,222.31 v1(403.63,222.31)
D10911: length 262.7
  TOP w0.086: v1(310.98,233.52) 311.43,233.07 312.84,233.07 316.12,236.35 317.6,236.35 317.68,236.43 SITE2.175
  L03_SIGNAL w0.071: v1(389.02,222.06) 389.42,222.06 389.49,221.99 389.49,220.84 389.14,220.49 387.8,220.49 386.56,221.74 386.56,233.21 380.33,239.44 380.33,300.78 372.74,308.37 372.74,336.76 379.04,343.06 393.7,343.06 398.66,338.1 398.66,335.16 D109.11
  L32_SIGNAL w0.071: v1(389.02,222.06) 389.42,222.06 389.49,221.99 389.49,221.81 389.5,221.8 389.5,220.6 388.95,220.05 387.38,220.05 383.92,223.51 380.45,223.51 376.33,219.39 364.19,219.39 351.36,232.21 322.51,232.21 321.68,233.05 311.05,233.05 310.98,233.12 v1(310.98,233.52)
D10912: length 217.8
  TOP w0.086: SITE2.7 324.63,231.48 324.71,231.4 324.71,230.18 321.18,226.65 321.18,219.77 v1(320.73,219.32)
  L03_SIGNAL w0.071: v1(402.48,222.31) 402.88,222.31 402.95,222.39 402.95,223.24 397.55,228.64 397.55,313.07 396.18,314.44 396.18,327.72 D109.12
  L28_SIGNAL w0.071: v1(402.48,222.31) 402.88,222.31 402.95,222.24 402.95,219.82 398.43,215.29 369.72,215.29 365.28,219.73 347.73,219.73 346.85,220.61 321.79,220.61 321.2,220.03 321.2,219.39 321.13,219.32 v1(320.73,219.32)
D10913: length 219.8
  TOP w0.086: SITE2.172 317.68,237.63 317.6,237.71 313.62,237.71 312.68,236.77 311.43,236.77 v1(310.98,236.32)
  L03_SIGNAL w0.071: v1(390.16,235.65) 389.76,235.65 389.69,235.58 389.69,235.11 389.28,234.7 387.78,234.7 385.88,236.6 385.88,254.72 384.16,256.43 384.16,302.9 377.44,309.62 377.44,337.33 379.6,339.49 386.82,339.49 388.74,337.57 388.74,335.16 D109.13
  L30_SIGNAL w0.071: v1(390.16,235.65) 389.76,235.65 389.69,235.58 389.69,234.9 388.55,233.75 322.74,233.75 319.71,236.79 311.05,236.79 310.98,236.72 v1(310.98,236.32)
D10914: length 219.8
  TOP w0.086: SITE2.10 325.83,231.48 325.75,231.4 325.75,228.95 323.58,226.78 323.58,222.51 v1(324.03,222.06)
  L03_SIGNAL w0.071: v1(396.77,220.15) 396.37,220.15 396.3,220.23 396.3,223.01 393.4,225.91 393.4,306.63 386.16,313.87 386.16,327.74 D109.14
  L30_SIGNAL w0.071: v1(396.77,220.15) 396.37,220.15 396.3,220.23 396.3,222.75 388.65,230.4 341.76,230.4 339.2,227.84 324.19,227.84 321.06,224.72 321.06,220.93 321.54,220.45 322.86,220.45 323.56,221.14 323.56,221.99 323.63,222.06 v1(324.03,222.06)
D10915: length 218.2
  TOP w0.086: v1(310.98,237.46) 311.43,237.01 312.58,237.01 313.52,237.95 317.6,237.95 317.68,238.03 SITE2.171
  L03_SIGNAL w0.071: v1(389.02,235.65) 389.42,235.65 389.49,235.58 389.49,235.19 389.19,234.89 387.86,234.89 386.08,236.68 386.08,254.8 384.36,256.52 384.36,302.98 377.64,309.71 377.64,337.25 379.68,339.3 386.74,339.3 388.54,337.49 388.54,335.2 D109.15
  L30_SIGNAL w0.071: v1(389.02,235.65) 389.42,235.65 389.49,235.58 389.49,234.98 388.47,233.95 322.83,233.95 319.79,236.99 311.05,236.99 310.98,237.06 v1(310.98,237.46)
D10916: length 218.5
  TOP w0.086: v1(322.89,222.06) 323.34,222.51 323.34,226.88 325.51,229.05 325.51,231.4 325.43,231.48 SITE2.9
  L03_SIGNAL w0.071: D109.16 385.96,327.78 385.96,313.79 393.2,306.55 393.2,225.83 396.1,222.93 396.1,220.23 396.03,220.15 v1(395.62,220.15)
  L30_SIGNAL w0.071: v1(322.89,222.06) 323.29,222.06 323.36,221.99 323.36,221.23 322.78,220.65 321.62,220.65 321.26,221.01 321.26,224.64 324.27,227.64 339.29,227.64 341.84,230.2 388.57,230.2 396.1,222.67 396.1,220.23 396.03,220.15 v1(395.62,220.15)
D11001: length 295.4
  TOP w0.086: SITE2.16 328.23,231.48 328.15,231.4 328.15,223.49 329.52,222.12 329.52,219.77 v1(329.98,219.32)
  L03_SIGNAL w0.071: v1(410.48,206.82) 410.08,206.82 410.01,206.75 410.01,205.48 410.66,204.83 413.58,204.83 440.49,231.74 440.49,350.39 431.64,359.24 421.78,359.24 419.17,356.62 419.17,355.53 D110.01
  L28_SIGNAL w0.071: v1(329.98,219.32) 329.57,219.32 329.5,219.24 329.5,218.16 330.01,217.65 359.77,217.65 364.19,213.24 404.6,213.24 410.01,207.82 410.01,206.89 410.08,206.82 v1(410.48,206.82)
D11002: length 280.5
  TOP w0.086: SITE2.12 326.63,231.48 326.55,231.4 326.55,227.84 325.57,226.86 325.57,219.77 v1(326.02,219.32)
  L03_SIGNAL w0.071: D110.02 416.41,347.83 416.41,345.52 416.96,344.96 427.17,344.96 438,334.13 438,234 417.42,213.42 402.05,213.42 396.3,207.67 396.3,206.64 396.37,206.57 v1(396.77,206.57)
  L28_SIGNAL w0.071: v1(326.02,219.32) 325.62,219.32 325.55,219.24 325.55,217.67 328.17,215.04 343.32,215.04 344.03,215.76 358.72,215.76 363.92,210.56 393.86,210.56 396.29,208.12 396.29,206.64 396.37,206.57 v1(396.77,206.57)
D11003: length 296.7
  TOP w0.086: SITE2.15 327.83,231.48 327.91,231.4 327.91,223.39 329.28,222.02 329.28,219.77 v1(328.83,219.32)
  L03_SIGNAL w0.071: v1(409.34,206.82) 409.74,206.82 409.81,206.75 409.81,205.4 410.58,204.63 413.66,204.63 440.69,231.66 440.69,350.47 431.72,359.43 421.7,359.43 418.97,356.71 418.97,355.47 D110.03
  L28_SIGNAL w0.071: v1(409.34,206.82) 409.74,206.82 409.81,206.89 409.81,207.74 404.51,213.04 364.11,213.04 359.69,217.45 329.92,217.45 329.3,218.07 329.3,219.24 329.23,219.32 v1(328.83,219.32)
D11004: length 280.3
  TOP w0.086: v1(324.88,219.32) 325.33,219.77 325.33,226.96 326.31,227.94 326.31,231.4 326.23,231.48 SITE2.11
  L03_SIGNAL w0.071: v1(395.62,206.57) 396.03,206.57 396.1,206.64 396.1,207.75 401.96,213.62 417.34,213.62 437.8,234.08 437.8,334.05 427.09,344.77 416.88,344.77 416.21,345.44 416.21,348.33 D110.04
  L28_SIGNAL w0.071: v1(324.88,219.32) 325.28,219.32 325.35,219.24 325.35,217.59 328.09,214.85 343.4,214.85 344.11,215.56 358.63,215.56 363.84,210.36 393.78,210.36 396.1,208.04 396.1,206.64 396.03,206.57 v1(395.62,206.57)
D11005: length 200.1
  TOP w0.086: v1(329.8,268.11) 329.35,267.66 329.35,257.86 329.43,257.78 SITE2.114
  L05_SIGNAL w0.071: D110.05 409,355.54 409,358.46 411.14,360.61 421.06,360.61 425.97,355.7 425.97,328.04 405.26,307.34 405.26,298.25 402.64,295.62 397.59,295.62 389.49,287.52 389.49,286.39 389.42,286.32 v1(389.02,286.32)
  L30_SIGNAL w0.071: v1(389.02,286.32) 389.42,286.32 389.49,286.39 389.49,287.64 388.77,288.36 386.38,288.36 373.56,275.54 332.2,275.54 329.33,272.67 329.33,268.18 329.4,268.11 v1(329.8,268.11)
D11006: length 211.6
  TOP w0.086: v1(321.53,263.69) 321.08,263.24 321.08,262.2 324.55,258.72 324.55,257.86 324.63,257.78 SITE2.126
  L05_SIGNAL w0.071: D110.06 406.54,348.12 406.54,344.57 408.51,342.6 420.96,342.6 424,339.55 424,328.7 420.33,325.04 405.26,325.04 400.3,320.08 400.3,298.92 400.77,298.45 402.33,298.45 402.95,299.08 402.95,299.84 402.88,299.91 v1(402.48,299.91)
  L32_SIGNAL w0.071: v1(321.53,263.69) 321.13,263.69 321.06,263.76 321.06,266.66 319.99,267.73 319.99,273.51 325.46,278.97 351.62,278.97 353.92,281.27 353.92,289.25 362.98,298.31 379.96,298.31 383.57,301.92 402.46,301.92 402.95,301.42 402.95,299.98 402.88,299.91 v1(402.48,299.91)
D11007: length 201.4
  TOP w0.086: SITE2.115 329.03,257.78 329.11,257.86 329.11,267.66 v1(328.66,268.11)
  L05_SIGNAL w0.071: v1(390.16,286.32) 389.76,286.32 389.69,286.39 389.69,287.44 397.67,295.42 402.72,295.42 405.46,298.17 405.46,307.26 426.17,327.96 426.17,355.78 421.14,360.8 411.06,360.8 408.8,358.54 408.8,355.46 D110.07
  L30_SIGNAL w0.071: v1(390.16,286.32) 389.76,286.32 389.69,286.39 389.69,287.72 388.85,288.56 386.3,288.56 373.48,275.74 332.12,275.74 329.13,272.75 329.13,268.18 329.06,268.11 v1(328.66,268.11)
D11008: length 212.9
  TOP w0.086: v1(320.39,263.69) 320.84,263.24 320.84,262.1 324.31,258.63 324.31,257.86 324.23,257.78 SITE2.127
  L05_SIGNAL w0.071: v1(403.63,299.91) 403.22,299.91 403.15,299.84 403.15,299 402.41,298.26 400.69,298.26 400.11,298.84 400.11,320.16 405.18,325.23 420.25,325.23 423.8,328.78 423.8,339.47 420.87,342.4 408.43,342.4 406.34,344.48 406.34,348.04 D110.08
  L32_SIGNAL w0.071: v1(320.39,263.69) 320.79,263.69 320.86,263.76 320.86,266.58 319.79,267.65 319.79,273.59 325.37,279.17 351.54,279.17 353.72,281.35 353.72,289.34 362.9,298.51 379.88,298.51 383.48,302.12 402.54,302.12 403.15,301.51 403.15,299.98 403.22,299.91 v1(403.63,299.91)
D11009: length 243
  TOP w0.086: SITE2.120 327.03,257.78 326.95,257.86 326.95,264.17 324.91,266.21 324.91,268.63 v1(325.36,269.08)
  L05_SIGNAL w0.071: D110.09 398.84,355.54 398.84,357.37 395.05,361.16 382.55,361.16 377.87,356.49 377.87,303.84 379.14,302.58 379.14,281.08 389.49,270.73 389.49,270.39 389.42,270.32 v1(389.02,270.32)
  L30_SIGNAL w0.071: v1(325.36,269.08) 324.96,269.08 324.89,269.16 324.89,273.22 331.17,279.49 354.08,279.49 356.23,277.35 370.69,277.35 373.78,280.44 373.78,288.32 376.64,291.17 390.78,291.17 392.8,289.15 392.8,275.04 389.49,271.73 389.49,270.39 389.42,270.32 v1(389.02,270.32)
D11010: length 194.8
  TOP w0.086: v1(327.41,271.17) 326.96,270.72 326.96,268.41 328.55,266.82 328.55,257.86 328.63,257.78 SITE2.116
  L05_SIGNAL w0.071: v1(389.02,283.91) 389.42,283.91 389.49,283.84 389.49,282.67 388.75,281.93 385.83,281.93 380.61,287.15 380.61,303.41 379.52,304.5 379.52,337.39 386.88,344.75 394.01,344.75 396.43,347.17 396.43,348.17 D110.10
  L28_SIGNAL w0.071: v1(389.02,283.91) 389.42,283.91 389.49,283.84 389.49,282.95 388.13,281.59 388.13,274.72 377.3,263.89 365.19,263.89 352.72,276.36 328.07,276.36 324.98,273.27 324.98,270.81 325.43,270.36 326.58,270.36 326.94,270.72 326.94,271.1 327.01,271.17 v1(327.41,271.17)
D11011: length 243
  TOP w0.086: SITE2.121 326.63,257.78 326.71,257.86 326.71,264.07 324.67,266.11 324.67,268.63 v1(324.22,269.08)
  L05_SIGNAL w0.071: v1(390.16,270.32) 389.76,270.32 389.69,270.39 389.69,270.81 379.33,281.16 379.33,302.67 378.07,303.93 378.07,356.4 382.63,360.96 394.97,360.96 398.64,357.29 398.64,355.46 D110.11
  L30_SIGNAL w0.071: v1(390.16,270.32) 389.76,270.32 389.69,270.39 389.69,271.65 393,274.96 393,289.23 390.86,291.37 376.56,291.37 373.58,288.4 373.58,280.52 370.61,277.55 356.31,277.55 354.17,279.69 331.09,279.69 324.69,273.3 324.69,269.16 324.62,269.08 v1(324.22,269.08)
D11012: length 194.9
  TOP w0.086: SITE2.117 328.23,257.78 328.31,257.86 328.31,266.72 326.72,268.31 326.72,270.72 v1(326.26,271.17)
  L05_SIGNAL w0.071: D110.12 396.23,347.99 396.23,347.26 393.92,344.95 386.8,344.95 379.32,337.47 379.32,304.42 380.41,303.33 380.41,287.07 385.74,281.73 388.83,281.73 389.69,282.59 389.69,283.84 389.76,283.91 v1(390.16,283.91)
  L28_SIGNAL w0.071: v1(326.26,271.17) 326.67,271.17 326.74,271.1 326.74,270.81 326.49,270.56 325.51,270.56 325.18,270.89 325.18,273.18 328.15,276.16 352.64,276.16 365.1,263.69 377.38,263.69 388.33,274.64 388.33,281.51 389.69,282.87 389.69,283.84 389.76,283.91 v1(390.16,283.91)
D11013: length 258.9
  TOP w0.086: v1(307.59,234.42) 308.05,234.88 312.6,234.88 314.63,236.91 317.6,236.91 317.68,236.83 SITE2.174
  L03_SIGNAL w0.071: v1(376.45,221.81) 376.05,221.81 375.98,221.73 375.98,220.56 375.65,220.23 374.01,220.23 372.55,221.69 372.55,291 366.86,296.69 366.86,349.92 376.78,359.84 387.62,359.84 388.69,358.76 388.69,355.53 D110.13
  L32_SIGNAL w0.071: v1(307.59,234.42) 307.59,234.83 307.67,234.9 322.42,234.9 324.3,233.01 353.57,233.01 366.37,220.21 375.37,220.21 375.98,220.82 375.98,221.73 376.05,221.81 v1(376.45,221.81)
D11014: length 236
  TOP w0.086: SITE2.2 322.63,231.48 322.55,231.4 322.55,231.04 321.9,230.39 308.05,230.39 v1(307.59,229.94)
  L03_SIGNAL w0.071: D110.14 386.24,348.14 386.24,346.28 385.17,345.21 375.89,345.21 370.36,339.69 370.36,300.93 378.66,292.64 378.66,237.9 377.55,236.78 376.62,236.78 375.98,236.14 375.98,235.47 376.05,235.39 v1(376.45,235.39)
  L32_SIGNAL w0.071: v1(376.45,235.39) 376.05,235.39 375.98,235.47 375.98,236.43 375.49,236.91 351.49,236.91 348.96,234.38 334.67,234.38 330.21,238.83 309.85,238.83 308.02,237 306.35,237 304.9,235.56 304.9,231.14 305.63,230.41 307.52,230.41 307.59,230.34 v1(307.59,229.94)
D11015: length 257.2
  TOP w0.086: v1(307.59,235.57) 308.05,235.12 312.5,235.12 314.53,237.15 317.6,237.15 317.68,237.23 SITE2.173
  L03_SIGNAL w0.071: D110.15 388.5,355.48 388.5,358.68 387.53,359.64 376.86,359.64 367.06,349.84 367.06,296.77 372.75,291.08 372.75,221.77 374.09,220.43 375.57,220.43 375.78,220.64 375.78,221.73 375.71,221.81 v1(375.3,221.81)
  L32_SIGNAL w0.071: v1(307.59,235.57) 307.59,235.17 307.67,235.1 322.5,235.1 324.38,233.21 353.65,233.21 366.45,220.41 375.28,220.41 375.78,220.9 375.78,221.73 375.71,221.81 v1(375.3,221.81)
D11016: length 234.7
  TOP w0.086: SITE2.1 322.23,231.48 322.31,231.4 322.31,231.14 321.8,230.63 308.05,230.63 v1(307.59,231.08)
  L03_SIGNAL w0.071: D110.16 386.04,348.02 386.04,346.37 385.09,345.41 375.81,345.41 370.17,339.77 370.17,300.85 378.46,292.55 378.46,237.98 377.46,236.98 376.53,236.98 375.78,236.22 375.78,235.47 375.71,235.39 v1(375.3,235.39)
  L32_SIGNAL w0.071: v1(375.3,235.39) 375.71,235.39 375.78,235.47 375.78,236.35 375.41,236.71 351.57,236.71 349.04,234.18 334.58,234.18 330.13,238.63 309.93,238.63 308.1,236.8 306.43,236.8 305.1,235.47 305.1,231.22 305.71,230.61 307.52,230.61 307.59,230.68 v1(307.59,231.08)
D11101: length 223
  TOP w0.086: v1(357.52,256.03) 357.07,256.49 350.12,256.49 345.74,252.11 344.06,252.11 343.98,252.03 SITE2.85
  L05_SIGNAL w0.071: D111.01 419.09,375.93 419.09,377.43 420.99,379.33 424.53,379.33 430.06,373.8 430.06,322.85 421.32,314.11 421.32,299.66 417.48,295.82 412.4,295.82 407.15,290.57 407.15,259.78 402.95,255.59 402.95,254.64 402.88,254.57 v1(402.48,254.57)
  L28_SIGNAL w0.071: v1(402.48,254.57) 402.88,254.57 402.95,254.64 402.95,255.43 402.36,256.02 386.04,256.02 379.87,249.84 369.79,249.84 363.12,256.51 357.59,256.51 357.52,256.44 v1(357.52,256.03)
D11102: length 170.7
  L05_SIGNAL w0.071: D111.02 416.71,368.45 416.71,366.38 418.47,364.61 425.14,364.61 428.77,360.99 428.77,323.97 414.95,310.14 414.95,299.42 415.39,298.98 416.67,298.98 416.92,299.23 416.92,299.84 416.85,299.91 v1(416.45,299.91)
  L32_SIGNAL w0.071: v1(416.45,299.91) 416.85,299.91 416.92,299.98 416.92,301.68 416.29,302.31 415.51,302.31 414.56,301.37 414.56,279.13 419.64,274.05 419.64,265.15 415.5,261.01 388.56,261.01 388.49,260.94 v1(388.49,259.59)
  BOTTOM w0.119: v1(388.49,259.59) UNK2K43.6
D11103: length 223.9
  TOP w0.086: v1(357.52,257.18) 357.07,256.73 350.02,256.73 345.64,252.35 344.06,252.35 343.98,252.43 SITE2.86
  L05_SIGNAL w0.071: D111.03 418.89,375.71 418.89,377.52 420.91,379.53 424.62,379.53 430.26,373.89 430.26,322.77 421.52,314.03 421.52,299.58 417.56,295.63 412.48,295.63 407.34,290.49 407.34,259.7 403.15,255.51 403.15,254.64 403.22,254.57 v1(403.63,254.57)
  L28_SIGNAL w0.071: v1(403.63,254.57) 403.22,254.57 403.15,254.64 403.15,255.51 402.45,256.22 385.96,256.22 379.78,250.04 369.87,250.04 363.21,256.7 357.59,256.7 357.52,256.78 v1(357.52,257.18)
D11104: length 171.7
  L05_SIGNAL w0.071: v1(417.6,299.91) 417.19,299.91 417.12,299.84 417.12,299.15 416.76,298.79 415.3,298.79 414.75,299.34 414.75,310.22 428.57,324.05 428.57,360.9 425.06,364.42 418.39,364.42 416.51,366.3 416.51,368.35 D111.04
  L32_SIGNAL w0.071: v1(417.6,299.91) 417.19,299.91 417.12,299.98 417.12,301.76 416.37,302.51 415.42,302.51 414.37,301.46 414.37,279.05 419.44,273.97 419.44,265.23 415.42,261.21 388.56,261.21 388.49,261.28 v1(388.49,262.63)
  BOTTOM w0.119: v1(388.49,262.63) UNK2K43.3
D11105: length 270.1
  TOP w0.086: SITE2.75 343.98,248.03 344.06,248.11 357.07,248.11 v1(357.52,247.66)
  L05_SIGNAL w0.071: D111.05 409.05,375.81 409.05,380.81 412.38,384.14 427.11,384.14 438.86,372.39 438.86,300.91 429.6,291.64 421.54,291.64 416.92,287.03 416.92,286.39 416.85,286.32 v1(416.45,286.32)
  L32_SIGNAL w0.071: v1(416.45,286.32) 416.85,286.32 416.92,286.39 416.92,287.72 417.48,288.28 419.21,288.28 422.39,285.1 422.39,251.8 417.55,246.96 363.91,246.96 362.74,248.13 357.59,248.13 357.52,248.06 v1(357.52,247.66)
D11106: length 222.3
  TOP w0.086: v1(353.81,253.77) 353.35,254.22 349.53,254.22 346.61,251.31 344.06,251.31 343.98,251.23 SITE2.83
  L05_SIGNAL w0.071: v1(402.48,268.16) 402.88,268.16 402.95,268.09 402.95,267.23 402.36,266.64 396.4,266.64 393.9,269.14 393.9,289.81 398.05,293.96 404.24,293.96 408.73,298.46 408.73,307.37 427.33,325.97 427.33,358.6 423.52,362.4 410.08,362.4 406.53,365.94 406.53,368.43 D111.06
  L30_SIGNAL w0.071: v1(402.48,268.16) 402.88,268.16 402.95,268.09 402.95,267.41 402.08,266.53 381.8,266.53 376.09,260.82 368.35,260.82 362.51,254.98 356.36,254.98 355.08,256.26 352.82,256.26 352.2,255.63 352.2,254.68 352.63,254.24 353.73,254.24 353.81,254.17 v1(353.81,253.77)
D11107: length 269.8
  TOP w0.086: v1(357.52,248.8) 357.07,248.35 344.06,248.35 343.98,248.43 SITE2.76
  L05_SIGNAL w0.071: v1(417.6,286.32) 417.19,286.32 417.12,286.39 417.12,286.94 421.63,291.45 429.68,291.45 439.06,300.83 439.06,372.47 427.19,384.34 412.3,384.34 408.85,380.89 408.85,375.83 D111.07
  L32_SIGNAL w0.071: v1(357.52,248.8) 357.52,248.4 357.59,248.33 362.82,248.33 363.99,247.15 417.46,247.15 422.19,251.88 422.19,285.01 419.12,288.08 417.56,288.08 417.12,287.64 417.12,286.39 417.19,286.32 v1(417.6,286.32)
D11108: length 222.7
  TOP w0.086: v1(353.81,254.92) 353.35,254.46 349.43,254.46 346.51,251.55 344.06,251.55 343.98,251.63 SITE2.84
  L05_SIGNAL w0.071: D111.08 406.34,368.36 406.34,365.86 409.99,362.2 423.44,362.2 427.13,358.52 427.13,326.05 408.53,307.46 408.53,298.54 404.15,294.16 397.97,294.16 393.7,289.9 393.7,269.06 396.32,266.44 402.45,266.44 403.15,267.15 403.15,268.09 403.22,268.16 v1(403.63,268.16)
  L30_SIGNAL w0.071: v1(403.63,268.16) 403.22,268.16 403.15,268.09 403.15,267.32 402.16,266.33 381.89,266.33 376.17,260.62 368.43,260.62 362.59,254.78 356.27,254.78 355,256.06 352.91,256.06 352.4,255.55 352.4,254.76 352.71,254.44 353.73,254.44 353.81,254.51 v1(353.81,254.92)
D11109: length 225.9
  TOP w0.086: SITE2.81 343.98,250.43 344.06,250.51 347.99,250.51 350.02,252.53 357.07,252.53 v1(357.52,252.08)
  L05_SIGNAL w0.071: D111.09 398.77,375.93 398.77,379.69 395.05,383.4 375.18,383.4 370.74,378.96 370.74,267.26 378.13,259.86 378.13,241.99 375.78,239.63 375.78,238.39 375.71,238.32 v1(375.3,238.32)
  L28_SIGNAL w0.071: v1(375.3,238.32) 375.71,238.32 375.78,238.39 375.78,239.65 371.06,244.37 367.43,244.37 359.25,252.55 357.59,252.55 357.52,252.48 v1(357.52,252.08)
D11110: length 185.8
  TOP w0.086: SITE2.122 326.23,257.78 326.15,257.86 326.15,260.53 324.65,262.03 324.65,263.24 v1(325.11,263.69)
  L05_SIGNAL w0.071: v1(375.56,283.91) 375.96,283.91 376.03,283.84 376.03,282.94 376.27,282.7 377.44,282.7 378.16,283.43 378.16,301.41 375.97,303.6 375.97,357.99 381.19,363.21 393.2,363.21 396.38,366.39 396.38,368.44 D111.10
  L32_SIGNAL w0.071: v1(375.56,283.91) 375.96,283.91 376.03,283.84 376.03,282.74 369.74,276.46 334.44,276.46 322.46,264.48 322.46,262.62 322.94,262.14 324.13,262.14 324.63,262.65 324.63,263.62 324.7,263.69 v1(325.11,263.69)
D11111: length 225.5
  TOP w0.086: SITE2.82 343.98,250.83 344.06,250.75 347.89,250.75 349.92,252.77 357.07,252.77 v1(357.52,253.22)
  L05_SIGNAL w0.071: v1(376.45,238.32) 376.05,238.32 375.98,238.39 375.98,239.55 378.33,241.91 378.33,259.94 370.94,267.34 370.94,378.88 375.26,383.2 394.97,383.2 398.57,379.6 398.57,375.71 D111.11
  L28_SIGNAL w0.071: v1(357.52,253.22) 357.52,252.82 357.59,252.75 359.33,252.75 367.52,244.57 371.14,244.57 375.97,239.73 375.97,238.39 376.05,238.32 v1(376.45,238.32)
D11112: length 184.5
  TOP w0.086: SITE2.123 325.83,257.78 325.91,257.86 325.91,260.44 324.42,261.93 324.42,263.24 v1(323.96,263.69)
  L05_SIGNAL w0.071: v1(376.7,283.91) 376.3,283.91 376.23,283.84 376.23,283.03 376.35,282.9 377.36,282.9 377.96,283.51 377.96,301.33 375.77,303.52 375.77,358.07 381.1,363.41 393.11,363.41 396.18,366.48 396.18,368.36 D111.12
  L32_SIGNAL w0.071: v1(376.7,283.91) 376.3,283.91 376.23,283.84 376.23,282.66 369.83,276.26 334.52,276.26 322.66,264.4 322.66,262.7 323.03,262.34 324.05,262.34 324.44,262.73 324.44,263.62 324.36,263.69 v1(323.96,263.69)
D11113: length 211.6
  TOP w0.086: SITE2.124 325.43,257.78 325.35,257.86 325.35,259.65 322.87,262.13 322.87,264.93 321.66,266.13 321.66,268.63 v1(322.12,269.08)
  L05_SIGNAL w0.071: v1(375.56,270.32) 375.96,270.32 376.03,270.39 376.03,271.42 372.48,274.97 372.48,376.87 375.97,380.36 386.62,380.36 388.62,378.36 388.62,375.92 D111.13
  L28_SIGNAL w0.071: v1(375.56,270.32) 375.96,270.32 376.03,270.39 376.03,271.63 370.48,277.18 326.72,277.18 321.64,272.1 321.64,269.16 321.71,269.08 v1(322.12,269.08)
D11114: length 164
  TOP w0.086: v1(353.81,258.17) 353.35,258.62 350.67,258.62 344.96,252.91 344.06,252.91 343.98,252.83 SITE2.87
  L05_SIGNAL w0.071: v1(375.3,267.91) 375.71,267.91 375.78,267.83 375.78,267.08 376.13,266.72 378.12,266.72 378.65,267.26 378.65,272.18 373.9,276.94 373.9,358.8 380.87,365.77 384.69,365.77 386.28,367.36 386.28,368.5 D111.14
  L30_SIGNAL w0.071: v1(375.3,267.91) 375.71,267.91 375.78,267.83 375.78,266.62 371.7,262.54 360.43,262.54 355.09,257.2 352.95,257.2 352.52,257.63 352.52,258.29 352.88,258.64 353.73,258.64 353.81,258.57 v1(353.81,258.17)
D11115: length 211.5
  TOP w0.086: v1(320.97,269.08) 321.43,268.63 321.43,266.04 322.63,264.83 322.63,262.03 325.11,259.55 325.11,257.86 325.03,257.78 SITE2.125
  L05_SIGNAL w0.071: v1(376.7,270.32) 376.3,270.32 376.23,270.39 376.23,271.5 372.68,275.05 372.68,376.79 376.05,380.16 386.54,380.16 388.43,378.27 388.43,375.73 D111.15
  L28_SIGNAL w0.071: v1(376.7,270.32) 376.3,270.32 376.23,270.39 376.23,271.71 370.57,277.38 326.64,277.38 321.45,272.19 321.45,269.16 321.37,269.08 v1(320.97,269.08)
D11116: length 164.4
  TOP w0.086: SITE2.88 343.98,253.23 344.06,253.15 344.86,253.15 350.57,258.86 353.35,258.86 v1(353.81,259.31)
  L05_SIGNAL w0.071: v1(376.45,267.91) 376.05,267.91 375.98,267.83 375.98,267.16 376.21,266.92 378.04,266.92 378.46,267.34 378.46,272.1 373.7,276.85 373.7,358.88 380.79,365.97 384.6,365.97 386.08,367.44 386.08,368.3 D111.16
  L30_SIGNAL w0.071: v1(376.45,267.91) 376.05,267.91 375.97,267.83 375.97,266.54 371.78,262.34 360.52,262.34 355.17,257 352.87,257 352.33,257.54 352.33,258.37 352.8,258.84 353.73,258.84 353.81,258.91 v1(353.81,259.31)
D11201: length 258.3
  TOP w0.086: SITE2.98 335.83,257.78 335.75,257.86 335.75,261.37 338.54,264.15 338.54,268.38 v1(338.99,268.83)
  L07_SIGNAL w0.071: v1(416.45,270.57) 416.85,270.57 416.92,270.65 416.92,271.29 421.18,275.54 429.02,275.54 437.8,284.32 437.8,383.88 423.52,398.16 420.01,398.16 419.15,397.3 419.15,396.19 D112.01
  L32_SIGNAL w0.071: v1(338.99,268.83) 338.59,268.83 338.52,268.9 338.52,270.71 339.45,271.65 363.24,271.65 368.58,266.31 406.61,266.31 412.74,272.44 416.17,272.44 416.92,271.69 416.92,270.65 416.85,270.57 v1(416.45,270.57)
D11202: length 252.9
  TOP w0.086: v1(344.67,266.34) 344.22,265.88 344.22,262.77 343.16,261.72 341.27,261.72 338.55,259 338.55,257.86 338.63,257.78 SITE2.91
  L07_SIGNAL w0.071: v1(416.2,268.16) 416.6,268.16 416.67,268.09 416.67,267.29 415.85,266.47 415.09,266.47 414.38,267.18 414.38,273.59 418,277.21 426.78,277.21 435.32,285.74 435.32,375.47 424.62,386.17 418.08,386.17 416.68,387.57 416.68,388.74 D112.02
  L30_SIGNAL w0.071: v1(416.2,268.16) 416.6,268.16 416.67,268.09 416.67,266.92 415.22,265.47 413.45,265.47 407.12,271.8 400.94,271.8 397.21,268.06 386.56,268.06 382.97,271.66 350.57,271.66 345.81,266.9 345.81,266.16 345.26,265.61 344.35,265.61 344.2,265.76 344.2,266.26 344.27,266.34 v1(344.67,266.34)
D11203: length 259.6
  TOP w0.086: v1(337.84,268.83) 338.3,268.38 338.3,264.25 335.51,261.47 335.51,257.86 335.43,257.78 SITE2.99
  L07_SIGNAL w0.071: D112.03 418.95,396.09 418.95,397.38 419.92,398.36 423.6,398.36 437.99,383.96 437.99,284.24 429.1,275.34 421.26,275.34 417.12,271.2 417.12,270.65 417.19,270.57 v1(417.6,270.57)
  L32_SIGNAL w0.071: v1(417.6,270.57) 417.19,270.57 417.12,270.65 417.12,271.77 416.25,272.64 412.66,272.64 406.53,266.51 368.66,266.51 363.33,271.84 339.37,271.84 338.32,270.79 338.32,268.9 338.25,268.83 v1(337.84,268.83)
D11204: length 254.2
  TOP w0.086: v1(343.52,266.34) 343.98,265.88 343.98,262.87 343.07,261.96 341.17,261.96 338.31,259.1 338.31,257.86 338.23,257.78 SITE2.92
  L07_SIGNAL w0.071: v1(417.34,268.16) 416.94,268.16 416.87,268.09 416.87,267.21 415.93,266.27 415.01,266.27 414.18,267.1 414.18,273.67 417.91,277.4 426.7,277.4 435.12,285.83 435.12,375.39 424.54,385.97 417.99,385.97 416.48,387.49 416.48,388.7 D112.04
  L30_SIGNAL w0.071: v1(417.34,268.16) 416.94,268.16 416.87,268.09 416.87,266.84 415.31,265.27 413.36,265.27 407.04,271.6 401.02,271.6 397.29,267.87 386.48,267.87 382.89,271.46 350.65,271.46 346.01,266.82 346.01,266.08 345.34,265.41 344.27,265.41 344,265.68 344,266.26 343.93,266.34 v1(343.52,266.34)
D11205: length 287.7
  TOP w0.086: SITE2.93 337.83,257.78 337.75,257.86 337.75,259.44 342.61,264.3 342.61,268.15 v1(343.07,268.6)
  L07_SIGNAL w0.071: v1(416.2,254.57) 416.6,254.57 416.67,254.64 416.67,255.1 417.3,255.73 423.45,255.73 440.12,272.39 440.12,386.52 426.45,400.19 409.83,400.19 408.73,399.09 408.73,396.45 D112.05
  L32_SIGNAL w0.071: v1(343.07,268.6) 342.66,268.6 342.59,268.68 342.59,269.68 343.28,270.37 359.86,270.37 374.3,255.93 416.02,255.93 416.67,255.28 416.67,254.64 416.6,254.57 v1(416.2,254.57)
D11206: length 297.2
  TOP w0.086: SITE2.140 317.68,250.43 317.6,250.35 313.96,250.35 312.03,252.28 309.02,252.28 v1(308.57,252.73)
  L07_SIGNAL w0.071: D112.06 406.52,388.74 406.52,386.17 410.38,382.31 423.36,382.31 426.81,378.87 426.81,282.5 423.61,279.3 416.96,279.3 411.75,274.09 411.75,253.04 408.57,249.85 403.68,249.85 402.95,250.58 402.95,251.83 402.88,251.9 v1(402.48,251.9)
  L30_SIGNAL w0.071: v1(402.48,251.9) 402.88,251.9 402.95,251.83 402.95,250.31 395.29,242.64 361.2,242.64 358.64,240.09 351.08,240.09 349.19,241.98 349.19,245.15 343.87,250.47 329.12,250.47 327.32,252.26 308.64,252.26 308.57,252.33 v1(308.57,252.73)
D11207: length 288.8
  TOP w0.086: SITE2.94 337.43,257.78 337.51,257.86 337.51,259.54 342.37,264.4 342.37,268.15 v1(341.92,268.6)
  L07_SIGNAL w0.071: v1(417.34,254.57) 416.94,254.57 416.87,254.64 416.87,255.01 417.38,255.53 423.53,255.53 440.31,272.31 440.31,386.6 426.53,400.39 409.74,400.39 408.53,399.17 408.53,395.83 D112.07
  L32_SIGNAL w0.071: v1(417.34,254.57) 416.94,254.57 416.87,254.64 416.87,255.37 416.1,256.13 374.38,256.13 359.94,270.57 343.2,270.57 342.39,269.76 342.39,268.68 342.32,268.6 v1(341.92,268.6)
D11208: length 296.9
  TOP w0.086: v1(308.57,251.59) 309.02,252.04 311.93,252.04 313.86,250.11 317.6,250.11 317.68,250.03 SITE2.141
  L07_SIGNAL w0.071: D112.08 406.32,388.7 406.32,386.09 410.3,382.11 423.28,382.11 426.61,378.78 426.61,282.58 423.53,279.5 416.88,279.5 411.56,274.18 411.56,253.12 408.49,250.05 403.77,250.05 403.15,250.66 403.15,251.83 403.22,251.9 v1(403.63,251.9)
  L30_SIGNAL w0.071: v1(403.63,251.9) 403.22,251.9 403.15,251.83 403.15,250.23 395.37,242.45 361.28,242.45 358.72,239.89 351,239.89 348.99,241.9 348.99,245.07 343.79,250.27 329.03,250.27 327.24,252.06 308.64,252.06 308.57,251.99 v1(308.57,251.59)
D11209: length 366
  TOP w0.086: SITE2.137 317.68,251.63 317.6,251.55 316.17,251.55 312.64,255.08 306.27,255.08 v1(305.81,255.53)
  L07_SIGNAL w0.071: v1(389.02,238.32) 389.42,238.32 389.49,238.39 389.49,239.59 393.2,243.3 415.82,243.3 442.42,269.91 442.42,387.22 428.04,401.6 400.59,401.6 398.8,399.81 398.8,396.22 D112.09
  L28_SIGNAL w0.071: v1(389.02,238.32) 389.42,238.32 389.49,238.39 389.49,239.28 388.57,240.2 384.65,240.2 378.29,233.84 355.83,233.84 349.91,239.76 349.91,246.86 341.17,255.6 313.31,255.6 310.34,258.57 307.44,258.57 305.98,257.11 304.57,257.11 303.86,256.41 303.86,255.52 304.33,255.06 305.74,255.06 305.81,255.13 v1(305.81,255.53)
D11210: length 262.6
  TOP w0.086: SITE2.95 337.03,257.78 336.95,257.86 336.95,259.72 340.9,263.67 340.9,266.64 v1(341.36,267.09)
  L07_SIGNAL w0.071: D112.10 396.39,388.77 396.39,385.28 401.84,379.83 422.11,379.83 425.29,376.64 425.29,286.17 421.43,282.3 417.77,282.3 416.92,283.15 416.92,284.09 416.85,284.16 v1(416.45,284.16)
  L28_SIGNAL w0.071: v1(416.45,284.16) 416.85,284.16 416.92,284.09 416.92,282.65 411.88,277.61 405.05,277.61 395.55,268.12 387.1,268.12 384.26,265.28 384.26,256.42 378.8,250.97 371.17,250.97 362.97,259.17 357.17,259.17 354.86,256.87 346.24,256.87 340.88,262.22 340.88,267.02 340.96,267.09 v1(341.36,267.09)
D11211: length 367.6
  TOP w0.086: SITE2.138 317.68,251.23 317.6,251.31 316.07,251.31 312.55,254.84 306.27,254.84 v1(305.81,254.39)
  L07_SIGNAL w0.071: D112.11 398.6,396.06 398.6,399.89 400.51,401.8 428.12,401.8 442.62,387.3 442.62,269.82 415.9,243.11 393.29,243.11 389.69,239.51 389.69,238.39 389.76,238.32 v1(390.16,238.32)
  L28_SIGNAL w0.071: v1(390.16,238.32) 389.76,238.32 389.69,238.39 389.69,239.36 388.65,240.4 384.56,240.4 378.21,234.04 355.91,234.04 350.11,239.85 350.11,246.94 341.25,255.8 313.39,255.8 310.42,258.77 307.35,258.77 305.9,257.31 304.49,257.31 303.67,256.49 303.67,255.43 304.24,254.86 305.74,254.86 305.81,254.79 v1(305.81,254.39)
D11212: length 262.6
  TOP w0.086: v1(340.21,267.09) 340.67,266.64 340.67,263.77 336.71,259.82 336.71,257.86 336.63,257.78 SITE2.96
  L07_SIGNAL w0.071: v1(417.6,284.16) 417.19,284.16 417.12,284.09 417.12,283.23 417.85,282.5 421.35,282.5 425.09,286.25 425.09,376.56 422.02,379.63 401.76,379.63 396.19,385.2 396.19,388.67 D112.12
  L28_SIGNAL w0.071: v1(417.6,284.16) 417.19,284.16 417.12,284.09 417.12,282.57 411.96,277.41 405.13,277.41 395.64,267.92 387.18,267.92 384.45,265.2 384.45,256.34 378.89,250.77 371.09,250.77 362.89,258.97 357.25,258.97 354.95,256.67 346.16,256.67 340.69,262.14 340.69,267.02 340.62,267.09 v1(340.21,267.09)
D11213: length 384.8
  TOP w0.086: v1(305.81,250.64) 306.27,250.19 312.4,250.19 313.04,249.55 317.6,249.55 317.68,249.63 SITE2.142
  L07_SIGNAL w0.071: v1(402.48,238.32) 402.88,238.32 402.95,238.39 402.95,239.04 403.72,239.81 419.11,239.81 444.79,265.48 444.79,388.15 429.28,403.66 392.41,403.66 388.66,399.91 388.66,396.2 D112.13
  L28_SIGNAL w0.071: v1(402.48,238.32) 402.88,238.32 402.95,238.39 402.95,239.65 402.09,240.52 400.38,240.52 390.52,230.66 356.78,230.66 348.89,238.56 348.89,245.93 344.27,250.55 309.21,250.55 306.66,248 304.39,248 303.84,248.55 303.84,249.53 304.48,250.16 305.74,250.16 305.81,250.24 v1(305.81,250.64)
D11214: length 205.6
  TOP w0.086: SITE2.79 343.98,249.63 344.06,249.71 349.05,249.71 349.94,250.59 353.35,250.59 v1(353.81,250.14)
  L05_SIGNAL w0.071: D112.14 386.18,388.72 386.18,387.88 384.73,386.43 374.81,386.43 368.94,380.56 368.94,369.71 366.13,366.9 366.13,289.85 368.14,287.84 368.14,281.9 366.08,279.84 366.08,258.12 373.9,250.3 375.22,250.3 375.78,250.85 375.78,251.83 375.71,251.9 v1(375.3,251.9)
  L30_SIGNAL w0.071: v1(353.81,250.14) 353.81,250.54 353.73,250.61 353.02,250.61 352.61,251.03 352.61,252.12 353.21,252.72 354.83,252.72 357.27,250.27 375.25,250.27 375.78,250.79 375.78,251.83 375.71,251.9 v1(375.3,251.9)
D11215: length 385
  TOP w0.086: SITE2.143 317.68,249.23 317.6,249.31 312.94,249.31 312.3,249.95 306.27,249.95 v1(305.81,249.49)
  L07_SIGNAL w0.071: v1(403.63,238.32) 403.22,238.32 403.15,238.39 403.15,238.96 403.8,239.61 419.2,239.61 444.98,265.4 444.98,388.24 429.36,403.86 392.33,403.86 388.46,399.99 388.46,396.08 D112.15
  L28_SIGNAL w0.071: v1(305.81,249.49) 305.81,249.9 305.74,249.97 304.56,249.97 304.04,249.45 304.04,248.63 304.48,248.2 306.58,248.2 309.13,250.75 344.36,250.75 349.09,246.01 349.09,238.64 356.87,230.86 390.44,230.86 400.29,240.72 402.17,240.72 403.15,239.74 403.15,238.39 403.22,238.32 v1(403.63,238.32)
D11216: length 206
  TOP w0.086: SITE2.80 343.98,250.03 344.06,249.95 348.95,249.95 349.84,250.83 353.35,250.83 v1(353.81,251.28)
  L05_SIGNAL w0.071: v1(376.45,251.9) 376.05,251.9 375.98,251.83 375.98,250.77 375.31,250.1 373.81,250.1 365.88,258.04 365.88,279.92 367.94,281.98 367.94,287.76 365.93,289.77 365.93,366.98 368.74,369.79 368.74,380.64 374.72,386.62 384.64,386.62 385.98,387.96 385.98,388.72 D112.16
  L30_SIGNAL w0.071: v1(376.45,251.9) 376.05,251.9 375.97,251.83 375.97,250.71 375.34,250.07 357.19,250.07 354.74,252.52 353.29,252.52 352.81,252.03 352.81,251.11 353.1,250.81 353.73,250.81 353.81,250.88 v1(353.81,251.28)
D11301: length 162.2
  TOP w0.086: SITE1.79 263.98,249.63 264.06,249.71 269.05,249.71 269.94,250.59 273.35,250.59 v1(273.81,250.14)
  L05_SIGNAL w0.071: D113.01 345.45,335.27 345.45,337.18 345.99,337.72 348.49,337.72 349.93,336.28 349.93,314.36 336.91,301.34 336.91,299.73 336.84,299.66 v1(336.44,299.66)
  L30_SIGNAL w0.071: v1(273.81,250.14) 273.81,250.54 273.88,250.61 281.88,250.61 298.9,267.63 301.59,267.63 303.63,269.66 303.63,284.78 313.01,294.17 323.02,294.17 331.55,302.7 335.95,302.7 336.91,301.73 336.91,299.73 336.84,299.66 v1(336.44,299.66)
D11302: length 147.1
  TOP w0.086: SITE1.85 263.98,252.03 264.06,252.11 265.74,252.11 270.12,256.49 277.07,256.49 v1(277.52,256.03)
  L05_SIGNAL w0.071: v1(322.98,286.07) 323.38,286.07 323.45,286 323.45,284.69 324.23,283.91 331.76,283.91 334.05,286.2 334.05,301.52 343.15,310.61 343.15,327.91 D113.02
  L28_SIGNAL w0.071: v1(322.98,286.07) 323.38,286.07 323.45,286.14 323.45,287.41 320.12,290.74 309.98,290.74 297.11,277.87 297.11,271.37 282.25,256.51 277.59,256.51 277.52,256.44 v1(277.52,256.03)
D11303: length 163.1
  TOP w0.086: SITE1.80 263.98,250.03 264.06,249.95 268.95,249.95 269.84,250.83 273.35,250.83 v1(273.81,251.28)
  L05_SIGNAL w0.071: v1(337.59,299.66) 337.18,299.66 337.11,299.73 337.11,301.26 350.12,314.27 350.12,336.36 348.57,337.92 345.91,337.92 345.25,337.26 345.25,335.09 D113.03
  L30_SIGNAL w0.071: v1(337.59,299.66) 337.18,299.66 337.11,299.73 337.11,301.82 336.03,302.9 331.47,302.9 322.94,294.36 312.93,294.36 303.43,284.86 303.43,269.75 301.51,267.83 298.82,267.83 281.8,250.81 273.88,250.81 273.81,250.88 v1(273.81,251.28)
D11304: length 146.9
  TOP w0.086: SITE1.86 263.98,252.43 264.06,252.35 265.64,252.35 270.02,256.73 277.07,256.73 v1(277.52,257.18)
  L05_SIGNAL w0.071: D113.04 342.95,327.61 342.95,310.69 333.86,301.6 333.86,286.29 331.68,284.11 324.32,284.11 323.65,284.77 323.65,286 323.72,286.07 v1(324.12,286.07)
  L28_SIGNAL w0.071: v1(324.12,286.07) 323.72,286.07 323.65,286.14 323.65,287.49 320.2,290.94 309.9,290.94 296.91,277.95 296.91,271.45 282.16,256.7 277.59,256.7 277.52,256.78 v1(277.52,257.18)
D11305: length 183.4
  TOP w0.086: SITE1.81 263.98,250.43 264.06,250.51 267.99,250.51 270.02,252.53 277.07,252.53 v1(277.52,252.08)
  L05_SIGNAL w0.071: D113.05 335.39,335.17 335.39,339.64 337.97,342.22 349.7,342.22 351.52,340.4 351.52,306 347.71,302.2 347.71,297.29 336.91,286.49 336.91,286.14 336.84,286.07 v1(336.44,286.07)
  L28_SIGNAL w0.071: v1(336.44,286.07) 336.84,286.07 336.91,286.14 336.91,287.79 336.45,288.25 334.75,288.25 330.76,284.26 306.09,284.26 300.12,278.29 300.12,272.28 280.39,252.55 277.59,252.55 277.52,252.48 v1(277.52,252.08)
D11306: length 136
  TOP w0.086: v1(273.81,253.77) 273.35,254.22 269.53,254.22 266.61,251.31 264.06,251.31 263.98,251.23 SITE1.83
  L05_SIGNAL w0.071: v1(322.98,299.66) 323.38,299.66 323.45,299.58 323.45,298.39 324.08,297.76 327.81,297.76 333.04,302.99 333.04,327.96 D113.06
  L30_SIGNAL w0.071: v1(273.81,253.77) 273.81,254.17 273.88,254.24 280.14,254.24 299.52,273.63 299.52,290.04 303.49,294 309.96,294 317.46,301.5 322.98,301.5 323.45,301.03 323.45,299.73 323.38,299.66 v1(322.98,299.66)
D11307: length 184.4
  TOP w0.086: SITE1.82 263.98,250.83 264.06,250.75 267.9,250.75 269.92,252.77 277.07,252.77 v1(277.52,253.22)
  L05_SIGNAL w0.071: D113.07 335.19,335.19 335.19,339.72 337.89,342.42 349.78,342.42 351.71,340.48 351.71,305.92 347.91,302.12 347.91,297.21 337.11,286.41 337.11,286.14 337.18,286.07 v1(337.59,286.07)
  L28_SIGNAL w0.071: v1(337.59,286.07) 337.18,286.07 337.11,286.14 337.11,287.87 336.53,288.45 334.67,288.45 330.68,284.46 306,284.46 299.92,278.38 299.92,272.36 280.31,252.75 277.59,252.75 277.52,252.82 v1(277.52,253.22)
D11308: length 135.9
  TOP w0.086: SITE1.84 263.98,251.63 264.06,251.55 266.51,251.55 269.43,254.46 273.35,254.46 v1(273.81,254.92)
  L05_SIGNAL w0.071: v1(324.12,299.66) 323.72,299.66 323.65,299.58 323.65,298.47 324.17,297.96 327.73,297.96 332.84,303.07 332.84,327.56 D113.08
  L30_SIGNAL w0.071: v1(273.81,254.92) 273.81,254.51 273.88,254.44 280.06,254.44 299.33,273.71 299.33,290.12 303.4,294.2 309.88,294.2 317.38,301.7 323.06,301.7 323.65,301.11 323.65,299.73 323.72,299.66 v1(324.12,299.66)
D11309: length 156.7
  TOP w0.086: SITE1.116 248.63,257.78 248.55,257.86 248.55,266.82 246.96,268.41 246.96,270.72 v1(247.41,271.17)
  L05_SIGNAL w0.071: v1(256.43,299.66) 256.83,299.66 256.9,299.73 256.9,301.94 297.16,342.19 321.63,342.19 325.3,338.53 325.3,335.1 D113.09
  L28_SIGNAL w0.071: v1(256.43,299.66) 256.83,299.66 256.9,299.73 256.9,299.83 256.9,299.83 256.9,302.07 255.33,303.65 249.81,303.65 246.94,300.78 246.94,271.24 247.01,271.17 v1(247.41,271.17)
D11310: length 120.3
  TOP w0.086: v1(273.81,258.17) 273.35,258.62 270.67,258.62 264.96,252.91 264.06,252.91 263.98,252.83 SITE1.87
  L05_SIGNAL w0.071: v1(287.38,269.3) 286.98,269.3 286.91,269.38 286.91,270.2 299.53,282.82 314.94,282.82 321.66,289.54 321.66,301.39 323.11,302.85 323.11,328.19 D113.10
  L30_SIGNAL w0.071: v1(287.38,269.3) 286.98,269.3 286.91,269.23 286.91,266.52 279.03,258.64 273.88,258.64 273.81,258.57 v1(273.81,258.17)
D11311: length 156.7
  TOP w0.086: v1(246.26,271.17) 246.72,270.72 246.72,268.31 248.31,266.72 248.31,257.86 248.23,257.78 SITE1.117
  L05_SIGNAL w0.071: D113.11 325.1,335.26 325.1,338.45 321.55,341.99 297.24,341.99 257.1,301.85 257.1,299.73 257.17,299.66 v1(257.58,299.66)
  L28_SIGNAL w0.071: v1(246.26,271.17) 246.67,271.17 246.74,271.24 246.74,300.86 249.72,303.85 255.41,303.85 257.1,302.16 257.1,299.91 257.1,299.91 257.1,299.73 257.17,299.66 v1(257.58,299.66)
D11312: length 120.3
  TOP w0.086: SITE1.88 263.98,253.23 264.06,253.15 264.86,253.15 270.57,258.86 273.35,258.86 v1(273.81,259.31)
  L05_SIGNAL w0.071: v1(286.24,269.3) 286.64,269.3 286.71,269.38 286.71,270.28 299.44,283.02 314.86,283.02 321.46,289.62 321.46,301.48 322.91,302.93 322.91,327.33 D113.12
  L30_SIGNAL w0.071: v1(273.81,259.31) 273.81,258.91 273.88,258.84 278.95,258.84 286.71,266.6 286.71,269.23 286.64,269.3 v1(286.24,269.3)
D11313: length 134.2
  TOP w0.086: SITE1.120 247.03,257.78 246.95,257.86 246.95,264.17 244.91,266.21 244.91,268.63 v1(245.36,269.08)
  L05_SIGNAL w0.071: v1(256.43,286.07) 256.83,286.07 256.9,286.14 256.9,286.64 266.66,296.39 266.66,304.62 301.33,339.29 312.53,339.29 315.03,336.78 315.03,335.21 D113.13
  L30_SIGNAL w0.071: v1(256.43,286.07) 256.83,286.07 256.9,286.14 256.9,287.6 256.17,288.34 254.48,288.34 244.89,278.74 244.89,269.16 244.96,269.08 v1(245.36,269.08)
D11314: length 139.4
  TOP w0.086: v1(249.8,268.11) 249.35,267.66 249.35,257.86 249.43,257.78 SITE1.114
  L05_SIGNAL w0.071: D113.14 312.58,327.82 312.58,317.56 318.32,311.83 318.32,295.44 313.89,291.02 297.09,291.02 290.37,284.29 270.77,284.29 270.11,284.95 270.11,286 270.04,286.07 v1(269.64,286.07)
  L30_SIGNAL w0.071: v1(269.64,286.07) 270.04,286.07 270.11,286.14 270.11,287.61 269.59,288.13 264.69,288.13 249.33,272.77 249.33,268.18 249.4,268.11 v1(249.8,268.11)
D11315: length 134.2
  TOP w0.086: v1(244.22,269.08) 244.67,268.63 244.67,266.11 246.71,264.07 246.71,257.86 246.63,257.78 SITE1.121
  L05_SIGNAL w0.071: v1(257.58,286.07) 257.17,286.07 257.1,286.14 257.1,286.55 266.86,296.31 266.86,304.53 301.41,339.09 312.44,339.09 314.83,336.7 314.83,335.15 D113.15
  L30_SIGNAL w0.071: v1(257.58,286.07) 257.17,286.07 257.1,286.14 257.1,287.68 256.25,288.54 254.4,288.54 244.69,278.83 244.69,269.16 244.62,269.08 v1(244.22,269.08)
D11316: length 139.4
  TOP w0.086: SITE1.115 249.03,257.78 249.11,257.86 249.11,267.66 v1(248.66,268.11)
  L05_SIGNAL w0.071: D113.16 312.38,327.7 312.38,317.48 318.12,311.74 318.12,295.52 313.81,291.22 297.01,291.22 290.29,284.49 270.85,284.49 270.31,285.04 270.31,286 270.38,286.07 v1(270.78,286.07)
  L30_SIGNAL w0.071: v1(248.66,268.11) 249.06,268.11 249.13,268.18 249.13,272.85 264.61,288.33 269.67,288.33 270.31,287.69 270.31,286.14 270.38,286.07 v1(270.78,286.07)
D11401: length 213.1
  TOP w0.086: v1(277.52,247.66) 277.07,248.11 264.06,248.11 263.98,248.03 SITE1.75
  L05_SIGNAL w0.071: v1(349.9,286.07) 350.31,286.07 350.38,286.14 350.38,287.07 356.69,293.38 356.69,356.41 352.24,360.85 347.26,360.85 345.56,359.15 345.56,355.48 D114.01
  L32_SIGNAL w0.071: v1(349.9,286.07) 350.31,286.07 350.38,286.14 350.38,287.39 349.85,287.92 346.08,287.92 340.47,282.3 307.09,282.3 303.68,278.9 303.68,269.81 301.06,267.18 288.61,267.18 284.92,263.49 284.92,252.45 280.6,248.13 277.59,248.13 277.52,248.06 v1(277.52,247.66)
D11402: length 166.1
  L05_SIGNAL w0.071: D114.02 343.02,348.1 343.02,346.56 344.35,345.23 351.65,345.23 354.84,342.04 354.84,299.15 353.48,297.79 350.76,297.79 350.38,298.17 350.38,299.58 350.31,299.66 v1(349.9,299.66)
  L32_SIGNAL w0.071: v1(349.9,299.66) 350.31,299.66 350.38,299.58 350.38,298.04 345.88,293.55 312,293.55 294.65,276.2 267.92,276.2 267.84,276.27 v1(267.84,277.62)
  BOTTOM w0.119: v1(267.84,277.62) K43.6
D11403: length 214.1
  TOP w0.086: v1(277.52,248.8) 277.07,248.35 264.06,248.35 263.98,248.43 SITE1.76
  L05_SIGNAL w0.071: D114.03 345.36,355.52 345.36,359.24 347.18,361.05 352.33,361.05 356.89,356.49 356.89,293.3 350.57,286.99 350.57,286.14 350.65,286.07 v1(351.05,286.07)
  L32_SIGNAL w0.071: v1(351.05,286.07) 350.65,286.07 350.57,286.14 350.57,287.48 349.93,288.12 346,288.12 340.39,282.5 307.01,282.5 303.49,278.98 303.49,269.89 300.97,267.38 288.52,267.38 284.72,263.57 284.72,252.53 280.52,248.33 277.59,248.33 277.52,248.4 v1(277.52,248.8)
D11404: length 165.8
  L05_SIGNAL w0.071: v1(351.05,299.66) 350.65,299.66 350.57,299.58 350.57,298.25 350.84,297.99 353.4,297.99 354.64,299.23 354.64,341.95 351.57,345.03 344.27,345.03 342.82,346.48 342.82,348.06 D114.04
  L32_SIGNAL w0.071: v1(351.05,299.66) 350.65,299.66 350.58,299.58 350.58,297.96 345.96,293.35 312.08,293.35 294.73,276 267.92,276 267.84,275.93 v1(267.84,274.58)
  BOTTOM w0.119: v1(267.84,274.58) K43.3
D11405: length 205.7
  TOP w0.086: SITE1.102 254.23,257.78 254.15,257.86 254.15,261.95 255.98,263.78 255.98,268.13 254.78,269.33 v1(254.78,269.97)
  L07_SIGNAL w0.071: D114.05 335.19,355.69 335.19,357.26 337.43,359.5 349.45,359.5 353.78,355.17 353.78,325.48 343.41,315.12 320.97,315.12 307.94,302.09 307.94,297.71 306.02,295.78 292.33,295.78 283.57,287.03 283.57,286.14 283.5,286.07 v1(283.1,286.07)
  L32_SIGNAL w0.071: v1(254.78,269.97) 254.5,269.69 254.4,269.69 253.64,270.45 253.64,277.66 263.41,287.43 282.95,287.43 283.57,286.81 283.57,286.14 283.5,286.07 v1(283.1,286.07)
D11406: length 181.6
  TOP w0.086: v1(261.36,267.09) 260.9,266.64 260.9,263.67 256.95,259.72 256.95,257.86 257.03,257.78 SITE1.95
  L07_SIGNAL w0.071: D114.06 332.82,348.06 332.82,346.47 334.61,344.69 348.37,344.69 350.99,342.07 350.99,327.43 340.82,317.26 320.22,317.26 300.87,297.92 297.63,297.92 297.04,298.51 297.04,299.58 296.97,299.66 v1(296.56,299.66)
  L28_SIGNAL w0.071: v1(261.36,267.09) 260.96,267.09 260.88,267.02 260.88,265.88 261.73,265.03 264.89,265.03 265.84,265.98 265.84,266.94 268.85,269.96 280.24,269.96 289.67,279.39 289.67,282.84 295.82,288.99 295.82,297.31 297.04,298.53 297.04,299.58 296.97,299.66 v1(296.56,299.66)
D11407: length 206.8
  TOP w0.086: SITE1.103 253.83,257.78 253.91,257.86 253.91,262.05 255.74,263.88 255.74,268.03 254.61,269.17 v1(253.98,269.17)
  L07_SIGNAL w0.071: D114.07 334.99,355.31 334.99,357.34 337.34,359.7 349.53,359.7 353.98,355.25 353.98,325.4 343.5,314.92 321.06,314.92 308.14,302 308.14,297.63 306.1,295.59 292.41,295.59 283.77,286.95 283.77,286.14 283.84,286.07 v1(284.25,286.07)
  L32_SIGNAL w0.071: v1(253.98,269.17) 254.26,269.45 254.26,269.55 253.44,270.37 253.44,277.74 263.33,287.63 283.03,287.63 283.77,286.89 283.77,286.14 283.84,286.07 v1(284.25,286.07)
D11408: length 181.5
  TOP w0.086: v1(260.21,267.09) 260.67,266.64 260.67,263.77 256.71,259.82 256.71,257.86 256.63,257.78 SITE1.96
  L07_SIGNAL w0.071: v1(297.71,299.66) 297.31,299.66 297.24,299.58 297.24,298.59 297.71,298.11 300.79,298.11 320.14,317.46 340.74,317.46 350.79,327.51 350.79,341.99 348.29,344.49 334.53,344.49 332.63,346.39 332.63,348.09 D114.08
  L28_SIGNAL w0.071: v1(297.71,299.66) 297.31,299.66 297.24,299.58 297.24,298.44 296.01,297.22 296.01,288.91 289.87,282.76 289.87,279.31 280.32,269.76 268.94,269.76 266.04,266.86 266.04,265.9 264.97,264.84 261.65,264.84 260.69,265.79 260.69,267.02 260.62,267.09 v1(260.21,267.09)
D11410: length 176.1
  TOP w0.086: SITE1.100 255.03,257.78 254.95,257.86 254.95,261.59 257.04,263.68 257.04,268.51 256.65,268.9 256.65,270.62 v1(257.1,271.07)
  L07_SIGNAL w0.071: D114.10 322.84,348.24 322.84,343.91 318.65,339.72 300.38,339.72 286.68,326.02 286.68,298.81 285.72,297.85 284.16,297.85 283.57,298.43 283.57,299.58 283.5,299.66 v1(283.1,299.66)
  L28_SIGNAL w0.071: v1(283.1,299.66) 283.5,299.66 283.57,299.58 283.57,298.45 280.06,294.93 273.28,294.93 265.34,286.99 260.98,286.99 253.33,279.34 253.33,275.64 246.43,268.73 246.43,263.93 247.44,262.92 254.82,262.92 256.63,264.72 256.63,271 256.7,271.07 v1(257.1,271.07)
D11412: length 174.9
  TOP w0.086: v1(255.96,271.07) 256.41,270.62 256.41,268.8 256.8,268.41 256.8,263.78 254.71,261.69 254.71,257.86 254.63,257.78 SITE1.101
  L07_SIGNAL w0.071: v1(284.25,299.66) 283.84,299.66 283.77,299.58 283.77,298.51 284.24,298.05 285.64,298.05 286.48,298.89 286.48,326.1 300.29,339.92 318.56,339.92 322.64,344 322.64,347.92 D114.12
  L28_SIGNAL w0.071: v1(255.96,271.07) 256.36,271.07 256.43,271 256.43,264.81 254.74,263.12 247.52,263.12 246.62,264.02 246.62,268.65 253.53,275.56 253.53,279.26 261.07,286.79 265.42,286.79 273.37,294.74 280.14,294.74 283.77,298.37 283.77,299.58 283.84,299.66 v1(284.25,299.66)
D11413: length 158.6
  TOP w0.086: SITE1.124 245.43,257.78 245.35,257.86 245.35,259.65 242.87,262.13 242.87,264.93 241.66,266.13 241.66,268.63 v1(242.12,269.08)
  L05_SIGNAL w0.071: v1(238.87,299.4) 238.47,299.4 238.4,299.33 238.4,298.38 238.75,298.02 244.73,298.02 272.53,325.82 274.6,325.82 307.89,359.1 313.31,359.1 314.97,357.44 314.97,355.59 D114.13
  L28_SIGNAL w0.071: v1(238.87,299.4) 238.47,299.4 238.4,299.33 238.4,297.75 236.29,295.65 236.29,279.34 241.64,273.99 241.64,269.16 241.71,269.08 v1(242.12,269.08)
