# Allegro board 8880F5-0830.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D10201: length 385
  TOP w0.086: v1(325.36,209.08) 324.91,208.63 324.91,206.21 326.95,204.17 326.95,197.86 327.03,197.78 SITE4.120
  L05_SIGNAL w0.071: D102.01 308.48,75.06 309.86,75.06 310.39,74.52 310.39,72.94 309.8,72.34 289.81,72.34 287.62,74.53 287.62,94.83 273.75,108.7 273.75,118.8 282.76,127.81 282.76,140.8 280.09,143.48 280.09,184.42 282.42,186.75 282.42,206.83 285.03,209.44 288.54,209.44 289.77,210.67 289.77,216.41 290.98,217.62 298.52,217.62 299.41,216.73 299.41,210.56 300.53,209.44 302.38,209.44 303.71,210.76 303.71,212.79 305.72,214.81 341.38,214.81 342.3,215.73 352.77,215.73 354.47,214.02 359.67,214.02 360.39,213.31 368.19,213.31 370.6,210.9 370.6,194.55 371.42,193.73 373.49,193.73 374.27,194.51 374.27,195.66 373.95,195.98 373.01,195.98 372.94,196.05 v1(372.94,196.45)
  L30_SIGNAL w0.071: v1(325.36,209.08) 324.96,209.08 324.89,209.16 324.89,211.79 326.96,213.87 337.92,213.87 338.8,212.99 341.51,212.99 342.27,213.75 355.77,213.75 369.54,199.98 373.69,199.98 374.73,198.94 374.73,196.75 373.95,195.98 373.01,195.98 372.94,196.05 v1(372.94,196.45)
D10202: length 385
  TOP w0.086: SITE4.116 328.63,197.78 328.55,197.86 328.55,206.82 326.96,208.41 326.96,210.72 v1(327.41,211.17)
  L05_SIGNAL w0.071: v1(386.52,196.45) 386.52,196.05 386.45,195.98 384.93,195.98 381.81,192.86 369.64,192.86 368.57,193.93 368.57,208.86 365.09,212.33 352.9,212.33 351.6,213.63 341.15,213.63 340.8,213.28 338.62,213.28 337.96,213.94 306.6,213.94 305.66,213.01 305.66,210.55 303.82,208.71 298.98,208.71 297.79,209.9 297.79,213.4 296.66,214.53 293.48,214.53 292.09,213.14 292.09,211.52 283.84,203.27 283.84,186.01 281.66,183.83 281.66,147 284.24,144.42 284.24,141 283.66,140.42 283.66,136.95 285.26,135.34 285.26,131.65 284,130.38 284,127.23 275.44,118.68 275.44,109.64 289.11,95.97 289.11,84.37 291.05,82.43 312.08,82.43 312.32,82.19 312.32,81.18 D102.02
  L28_SIGNAL w0.071: v1(386.52,196.45) 386.52,196.05 386.45,195.98 384.89,195.98 381.55,199.32 366.54,199.32 365.38,200.49 353.49,200.49 351.87,198.86 344.47,198.86 342.36,200.98 329.11,200.98 326.43,203.66 326.43,207.77 326.94,208.28 326.94,211.1 327.01,211.17 v1(327.41,211.17)
D10203: length 385
  TOP w0.086: v1(324.22,209.08) 324.67,208.63 324.67,206.11 326.71,204.07 326.71,197.86 326.63,197.78 SITE4.121
  L05_SIGNAL w0.071: v1(372.94,195.31) 372.94,195.71 373.01,195.78 373.87,195.78 374.07,195.58 374.07,194.59 373.41,193.93 371.5,193.93 370.8,194.63 370.8,210.98 368.28,213.51 360.47,213.51 359.75,214.22 354.56,214.22 352.85,215.92 342.22,215.92 341.3,215.01 305.64,215.01 303.51,212.87 303.51,210.85 302.3,209.64 300.62,209.64 299.61,210.64 299.61,216.81 298.61,217.82 290.9,217.82 289.57,216.49 289.57,210.75 288.46,209.64 284.95,209.64 282.22,206.91 282.22,186.83 279.89,184.5 279.89,143.4 282.57,140.72 282.57,127.9 273.55,118.88 273.55,108.62 287.42,94.75 287.42,74.45 289.73,72.14 309.88,72.14 310.59,72.85 310.59,74.37 D102.03
  L30_SIGNAL w0.071: v1(372.94,195.31) 372.94,195.71 373.01,195.78 374.03,195.78 374.93,196.67 374.93,199.02 373.77,200.18 369.62,200.18 355.85,213.95 342.19,213.95 341.43,213.19 338.88,213.19 338,214.07 326.88,214.07 324.69,211.88 324.69,209.16 324.62,209.08 v1(324.22,209.08)
D10204: length 385
  TOP w0.086: v1(326.26,211.17) 326.72,210.72 326.72,208.31 328.31,206.72 328.31,197.86 328.23,197.78 SITE4.117
  L05_SIGNAL w0.071: D102.04 312.51,81.19 312.51,82.27 312.16,82.62 291.13,82.62 289.31,84.45 289.31,96.06 275.64,109.73 275.64,118.59 284.2,127.15 284.2,130.3 285.46,131.56 285.46,135.43 283.86,137.03 283.86,140.34 284.44,140.92 284.44,144.51 281.86,147.08 281.86,183.75 284.04,185.93 284.04,203.19 292.29,211.44 292.29,213.06 293.56,214.33 296.57,214.33 297.59,213.32 297.59,209.82 298.9,208.51 303.9,208.51 305.86,210.47 305.86,212.92 306.68,213.74 337.87,213.74 338.54,213.08 340.88,213.08 341.23,213.43 351.52,213.43 352.82,212.13 365.01,212.13 368.37,208.77 368.37,193.85 369.56,192.66 381.89,192.66 385.01,195.78 386.45,195.78 386.52,195.71 v1(386.52,195.31)
  L28_SIGNAL w0.071: v1(386.52,195.31) 386.52,195.71 386.45,195.78 384.81,195.78 381.46,199.13 366.46,199.13 365.29,200.29 353.57,200.29 351.95,198.67 344.39,198.67 342.28,200.78 329.03,200.78 326.23,203.58 326.23,207.85 326.74,208.36 326.74,211.1 326.67,211.17 v1(326.26,211.17)
D10205: length 385
  TOP w0.086: v1(337.1,211.08) 336.65,210.62 336.65,208.9 337.04,208.51 337.04,203.68 334.95,201.59 334.95,197.86 335.03,197.78 SITE4.100
  L07_SIGNAL w0.071: D102.05 318.92,74.78 320.78,74.78 321.21,74.35 321.21,73.05 320.53,72.37 305.41,72.37 302.27,75.51 302.27,89.34 309.59,96.65 351.63,96.65 353.65,98.68 353.65,134.09 351.77,135.97 351.77,146.09 356.56,150.88 356.56,152.59 358.7,154.73 360.77,154.73 365.6,159.57 365.6,178.47 368.12,180.99 371.49,180.99 375.8,185.29 427.83,185.29 428.32,184.8 428.32,182.88 427.86,182.42 426.32,182.42 426.15,182.59 426.15,182.74 426.4,182.99 v1(426.4,182.99)
  L28_SIGNAL w0.071: v1(426.4,182.99) 426.4,182.59 426.47,182.52 428.22,182.52 429.09,183.38 429.09,190.49 420.96,198.62 399.39,198.62 390.32,207.68 381.09,207.68 380.2,206.79 363.59,206.79 356.78,213.6 342.61,213.6 341.42,212.42 337.06,212.42 336.63,211.99 336.63,211.15 336.7,211.08 v1(337.1,211.08)
D10206: length 385
  TOP w0.086: v1(334.78,209.97) 334.78,209.33 335.98,208.13 335.98,203.78 334.15,201.95 334.15,197.86 334.23,197.78 SITE4.102
  L07_SIGNAL w0.071: v1(412.81,182.99) 412.81,182.59 412.74,182.52 381.39,182.52 367.82,168.95 367.82,155.58 370.41,153 370.41,138.2 368.12,135.92 368.12,73.64 365.97,71.49 357.68,71.49 354.75,74.42 354.75,87.78 349.43,93.1 308.39,93.1 304.22,88.92 304.22,84.14 305.9,82.45 322.88,82.45 323.18,82.16 323.18,81.81 321.49,80.12 321.42,80.12 D102.06
  L32_SIGNAL w0.071: v1(334.78,209.97) 334.5,209.69 334.4,209.69 333.5,210.59 333.5,212 335.2,213.7 337.99,213.7 338.65,213.04 340.96,213.04 341.84,213.92 359.88,213.92 369.07,204.74 377.78,204.74 380.37,207.32 390.07,207.32 397.66,199.73 397.66,190.01 402.73,184.93 413.68,184.93 414.41,184.2 414.41,183.15 413.77,182.52 412.89,182.52 412.81,182.59 v1(412.81,182.99)
D10207: length 385
  TOP w0.086: v1(335.96,211.08) 336.41,210.62 336.41,208.8 336.8,208.41 336.8,203.78 334.71,201.69 334.71,197.86 334.63,197.78 SITE4.101
  L07_SIGNAL w0.071: D102.07 321.41,75.03 321.41,72.97 320.61,72.17 305.33,72.17 302.07,75.43 302.07,89.42 309.5,96.85 351.55,96.85 353.45,98.76 353.45,134.01 351.57,135.88 351.57,146.17 356.37,150.97 356.37,152.68 358.62,154.93 360.69,154.93 365.4,159.65 365.4,178.55 368.04,181.19 371.41,181.19 375.71,185.49 427.91,185.49 428.52,184.89 428.52,182.8 427.94,182.22 426.47,182.22 426.4,182.15 v1(426.4,181.84)
  L28_SIGNAL w0.071: v1(426.4,181.84) 426.4,182.25 426.47,182.32 428.31,182.32 429.29,183.3 429.29,190.57 421.04,198.81 399.47,198.81 390.41,207.88 381.01,207.88 380.12,206.99 363.67,206.99 356.86,213.8 342.53,213.8 341.34,212.62 336.98,212.62 336.43,212.07 336.43,211.15 336.36,211.08 v1(335.96,211.08)
D10208: length 385
  TOP w0.086: v1(333.98,209.17) 334.61,209.17 335.74,208.03 335.74,203.88 333.91,202.05 333.91,197.86 333.83,197.78 SITE4.103
  L07_SIGNAL w0.071: D102.08 323.38,80.48 323.38,82.24 322.97,82.65 305.98,82.65 304.41,84.22 304.41,88.84 308.48,92.9 349.35,92.9 354.55,87.7 354.55,74.34 357.6,71.29 366.05,71.29 368.32,73.56 368.32,135.83 370.6,138.12 370.6,153.08 368.02,155.66 368.02,168.87 381.47,182.32 412.74,182.32 412.81,182.25 v1(412.81,181.84)
  L32_SIGNAL w0.071: v1(333.98,209.17) 334.26,209.45 334.26,209.55 333.3,210.51 333.3,212.09 335.11,213.9 338.07,213.9 338.73,213.24 340.88,213.24 341.76,214.12 359.97,214.12 369.15,204.93 377.7,204.93 380.28,207.52 390.15,207.52 397.86,199.81 397.86,190.09 402.81,185.13 413.76,185.13 414.6,184.29 414.6,183.06 413.86,182.32 412.89,182.32 412.81,182.25 v1(412.81,181.84)
D10209: length 385
  TOP w0.086: v1(338.99,208.83) 338.54,208.38 338.54,204.15 335.75,201.37 335.75,197.86 335.83,197.78 SITE4.98
  L07_SIGNAL w0.071: D102.09 329.6,74.26 329.98,74.26 330.63,73.61 330.63,73 331.48,72.16 347.21,72.16 351.34,68.03 351.34,45.53 355.16,41.71 355.16,26.15 357.48,23.84 370.6,23.84 372.34,25.57 372.34,98.98 379.4,106.05 405.78,106.05 410.08,110.34 410.08,120.75 405.14,125.69 398.42,125.69 385.79,138.32 385.79,171.88 392.24,178.32 394.54,178.32 394.83,178.04 394.83,177.43 394.76,177.36 v1(394.35,177.36)
  L32_SIGNAL w0.071: v1(338.99,208.83) 338.59,208.83 338.52,208.9 338.52,210.58 340.07,212.13 357.88,212.13 370.87,199.14 378.05,199.14 384.98,192.21 384.98,188.48 394.83,178.64 394.83,177.43 394.76,177.36 v1(394.35,177.36)
D10210: length 385
  TOP w0.086: SITE4.93 337.83,197.78 337.75,197.86 337.75,199.44 342.61,204.3 342.61,208.66 v1(343.07,209.11)
  L07_SIGNAL w0.071: D102.10 333.45,81.99 333.45,82.15 333.97,82.68 347.01,82.68 353.03,76.66 353.03,46.61 357.2,42.44 357.2,27.23 358.59,25.83 368.86,25.83 370.4,27.37 370.4,100.33 378.48,108.42 402.67,108.42 407.27,113.02 407.27,120.29 403.9,123.67 393.01,123.67 387.73,128.95 387.73,132.67 382.1,138.3 382.1,154.81 384.04,156.75 384.04,163.59 383.27,164.36 376.4,164.36 375.8,164.96 375.8,165.98 376.45,166.63 383.07,166.63 383.79,167.35 383.79,168.46 382.57,169.68 380.98,169.68 379.03,171.63 379.03,174.65 380.13,175.75 380.86,175.75 381.62,176.51 381.62,177.26 381.52,177.36 v1(381.15,177.36)
  L32_SIGNAL w0.071: v1(343.07,209.11) 342.66,209.11 342.59,209.18 342.59,210.18 343.7,211.3 352.75,211.3 361.11,202.93 362.62,202.93 375.47,190.08 376.38,190.08 378.71,187.75 378.71,179.41 379.95,178.17 381.41,178.17 381.62,177.96 381.62,177.43 381.55,177.36 v1(381.15,177.36)
D10211: length 385
  TOP w0.086: v1(337.84,208.83) 338.3,208.38 338.3,204.25 335.51,201.47 335.51,197.86 335.43,197.78 SITE4.99
  L07_SIGNAL w0.071: D102.11 330.83,74.29 330.83,73.09 331.56,72.35 347.29,72.35 351.54,68.11 351.54,45.61 355.36,41.79 355.36,26.24 357.56,24.03 370.51,24.03 372.14,25.66 372.14,99.07 379.32,106.24 405.7,106.24 409.88,110.43 409.88,120.67 405.05,125.5 398.33,125.5 385.6,138.23 385.6,171.96 392.16,178.52 394.62,178.52 395.03,178.12 395.03,177.43 395.1,177.36 v1(395.5,177.36)
  L32_SIGNAL w0.071: v1(395.5,177.36) 395.1,177.36 395.02,177.43 395.02,178.72 385.18,188.56 385.18,192.3 378.14,199.34 370.95,199.34 357.96,212.33 339.99,212.33 338.32,210.66 338.32,208.9 338.25,208.83 v1(337.84,208.83)
D10212: length 385
  TOP w0.086: SITE4.94 337.43,197.78 337.51,197.86 337.51,199.54 342.37,204.4 342.37,208.66 v1(341.92,209.11)
  L07_SIGNAL w0.071: D102.12 333.65,80.37 333.65,82.07 334.06,82.48 346.93,82.48 352.84,76.58 352.84,46.52 357,42.36 357,27.15 358.51,25.63 368.94,25.63 370.59,27.28 370.59,100.25 378.56,108.22 402.75,108.22 407.47,112.94 407.47,120.37 403.98,123.86 393.1,123.86 387.92,129.04 387.92,132.75 382.3,138.38 382.3,154.73 384.24,156.67 384.24,163.67 383.35,164.55 376.49,164.55 376,165.04 376,165.89 376.54,166.43 383.15,166.43 383.99,167.27 383.99,168.55 382.65,169.88 381.06,169.88 379.23,171.71 379.23,174.56 380.21,175.55 380.94,175.55 381.82,176.43 381.82,177.28 381.89,177.36 v1(382.29,177.36)
  L32_SIGNAL w0.071: v1(382.29,177.36) 381.89,177.36 381.82,177.43 381.82,178.04 381.49,178.37 380.03,178.37 378.91,179.5 378.91,187.84 376.47,190.28 375.55,190.28 362.7,203.13 361.19,203.13 352.83,211.49 343.62,211.49 342.39,210.27 342.39,209.18 342.32,209.11 v1(341.92,209.11)
D10213: length 385
  TOP w0.086: v1(325.11,203.69) 324.65,203.24 324.65,202.03 326.15,200.53 326.15,197.86 326.23,197.78 SITE4.122
  L05_SIGNAL w0.071: v1(403.03,196.45) 403.03,196.05 403.11,195.98 404.36,195.98 405.05,195.29 405.05,193.77 393.22,181.94 368.72,181.94 359.73,172.95 314.97,172.95 312.89,170.87 309.89,170.87 308.05,172.71 306.72,172.71 304.7,170.69 304.7,166.28 302.42,164 302.42,108.54 314.13,96.82 350.09,96.82 352.85,94.06 352.85,76.13 348.88,72.16 341.12,72.16 340.27,73.01 340.27,73.75 D102.13
  L32_SIGNAL w0.071: v1(403.03,196.45) 403.03,196.05 403.11,195.98 405.84,195.98 406.89,197.03 406.89,202.26 393.47,215.68 343.18,215.68 342.22,214.72 332.99,214.72 324.63,206.36 324.63,203.76 324.7,203.69 v1(325.11,203.69)
D10214: length 385
  TOP w0.086: SITE4.124 325.43,197.78 325.35,197.86 325.35,199.65 322.87,202.13 322.87,204.93 321.66,206.13 321.66,208.63 v1(322.12,209.08)
  L05_SIGNAL w0.071: D102.14 342.8,81.18 342.8,82.17 343.37,82.74 349.11,82.74 350.36,83.99 350.36,92.14 348.57,93.93 296.19,93.93 293.46,96.66 293.46,194.07 300.86,201.47 306.31,201.47 311.63,196.15 354.15,196.15 356.43,198.43 359.51,198.43 368.24,189.7 385.03,189.7 387.9,192.57 387.9,195.45 388.43,195.98 389.37,195.98 389.45,196.05 v1(389.45,196.45)
  L28_SIGNAL w0.071: v1(322.12,209.08) 321.71,209.08 321.64,209.01 321.64,206.14 322.72,205.06 322.72,200.84 326.68,196.87 355.06,196.87 357.18,198.99 362.42,198.99 367.89,193.52 386.93,193.52 387.89,194.47 387.89,195.56 388.3,195.98 389.37,195.98 389.45,196.05 v1(389.45,196.45)
D10215: length 385
  TOP w0.086: v1(323.96,203.69) 324.42,203.24 324.42,201.93 325.91,200.44 325.91,197.86 325.83,197.78 SITE4.123
  L05_SIGNAL w0.071: D102.15 340.46,73.76 340.46,73.09 341.2,72.36 348.8,72.36 352.65,76.21 352.65,93.98 350,96.62 314.05,96.62 302.22,108.45 302.22,164.08 304.5,166.37 304.5,170.77 306.64,172.9 308.13,172.9 309.97,171.06 312.81,171.06 314.89,173.14 359.64,173.14 368.64,182.14 393.14,182.14 404.85,193.85 404.85,195.2 404.27,195.78 403.11,195.78 403.03,195.71 v1(403.03,195.31)
  L32_SIGNAL w0.071: v1(323.96,203.69) 324.36,203.69 324.44,203.76 324.44,206.44 332.9,214.91 342.14,214.91 343.1,215.88 393.56,215.88 407.09,202.35 407.09,196.94 405.92,195.78 403.11,195.78 403.03,195.71 v1(403.03,195.31)
D10216: length 385
  TOP w0.086: SITE4.125 325.03,197.78 325.11,197.86 325.11,199.55 322.63,202.03 322.63,204.83 321.43,206.04 321.43,208.63 v1(320.97,209.08)
  L05_SIGNAL w0.071: D102.16 343,81.18 343,82.08 343.45,82.54 349.19,82.54 350.56,83.91 350.56,92.22 348.65,94.13 296.27,94.13 293.66,96.74 293.66,193.98 300.94,201.27 306.23,201.27 311.55,195.95 354.23,195.95 356.51,198.23 359.43,198.23 368.16,189.5 385.11,189.5 388.1,192.49 388.1,195.36 388.52,195.78 389.37,195.78 389.45,195.71 v1(389.45,195.31)
  L28_SIGNAL w0.071: v1(389.45,195.31) 389.45,195.71 389.37,195.78 388.38,195.78 388.08,195.48 388.08,194.39 387.01,193.32 367.81,193.32 362.34,198.79 357.26,198.79 355.15,196.68 326.6,196.68 322.53,200.75 322.53,204.98 321.45,206.06 321.45,209.01 321.37,209.08 v1(320.97,209.08)
D10301: length 385
  TOP w0.086: SITE4.91 338.63,197.78 338.55,197.86 338.55,199 341.27,201.72 343.16,201.72 344.22,202.77 344.22,205.88 v1(344.67,206.34)
  L07_SIGNAL w0.071: v1(381.15,190.94) 381.55,190.94 381.62,191.02 381.62,191.81 380.57,192.86 368.01,192.86 361.09,185.94 361.09,162.83 349.46,151.2 339.11,151.2 330.28,142.37 330.28,127.34 324.99,122.05 324.99,120.22 306.03,101.26 291.32,101.26 286.74,96.68 286.74,35 287.5,34.25 289.74,34.25 290.29,34.8 290.29,73.48 291.62,74.81 293.59,74.81 294.83,73.57 294.83,51.67 298.26,48.25 307.77,48.25 311.02,51.5 311.02,53.81 310.36,54.47 308.75,54.47 D103.01
  L30_SIGNAL w0.071: v1(381.15,190.94) 381.55,190.94 381.62,191.02 381.62,192.13 380.89,192.85 368.52,192.85 361.33,200.05 361.33,202.92 352.46,211.78 346.25,211.78 344.2,209.73 344.2,206.41 344.27,206.34 v1(344.67,206.34)
D10302: length 385
  TOP w0.086: v1(321.53,203.69) 321.08,203.24 321.08,202.2 324.55,198.73 324.55,197.86 324.63,197.78 SITE4.126
  L05_SIGNAL w0.071: D103.02 311.56,60.1 311.94,60.1 312.84,61 312.84,61.88 312.51,62.22 292.1,62.22 285.36,68.95 285.36,94.89 279.04,101.21 277.1,101.21 272.04,106.27 272.04,121.57 280.01,129.55 280.01,138.79 278.34,140.46 278.34,185.38 280.9,187.94 280.9,211.05 289.32,219.47 312.44,219.47 314.11,217.8 355.14,217.8 357.4,215.53 379.85,215.53 382.63,218.32 382.63,219.83 382.56,219.9 v1(382.16,219.9)
  L32_SIGNAL w0.071: v1(321.53,203.69) 321.13,203.69 321.06,203.76 321.06,207.16 319.98,208.24 319.98,210.57 326.54,217.12 339.86,217.12 340.82,218.08 377.49,218.08 380.86,221.46 382.24,221.46 382.63,221.06 382.63,219.97 382.56,219.9 v1(382.16,219.9)
D10303: length 385
  TOP w0.086: SITE4.92 338.23,197.78 338.31,197.86 338.31,199.1 341.17,201.96 343.07,201.96 343.98,202.87 343.98,205.88 v1(343.52,206.34)
  L07_SIGNAL w0.071: v1(382.29,190.94) 381.89,190.94 381.82,191.02 381.82,191.89 380.65,193.06 367.93,193.06 360.89,186.02 360.89,162.91 349.38,151.4 339.03,151.4 330.08,142.45 330.08,127.42 324.79,122.14 324.79,120.3 305.95,101.46 291.23,101.46 286.54,96.77 286.54,34.92 287.41,34.05 289.82,34.05 290.48,34.72 290.48,73.39 291.7,74.61 293.51,74.61 294.64,73.49 294.64,51.59 298.18,48.05 307.86,48.05 311.22,51.41 311.22,54.68 D103.03
  L30_SIGNAL w0.071: v1(343.52,206.34) 343.93,206.34 344,206.41 344,209.81 346.17,211.98 352.54,211.98 361.52,203 361.52,200.13 368.61,193.05 380.98,193.05 381.82,192.21 381.82,191.02 381.89,190.94 v1(382.29,190.94)
D10304: length 385
  TOP w0.086: SITE4.127 324.23,197.78 324.31,197.86 324.31,198.63 320.84,202.1 320.84,203.24 v1(320.39,203.69)
  L05_SIGNAL w0.071: v1(383.31,219.9) 382.9,219.9 382.83,219.83 382.83,218.24 379.93,215.33 357.32,215.33 355.05,217.6 314.03,217.6 312.36,219.27 289.4,219.27 281.1,210.97 281.1,187.86 278.54,185.3 278.54,140.54 280.21,138.87 280.21,129.46 272.24,121.49 272.24,106.35 277.18,101.41 279.12,101.41 285.56,94.97 285.56,69.03 292.18,62.42 312.59,62.42 313.04,61.96 313.04,60.34 D103.04
  L32_SIGNAL w0.071: v1(320.39,203.69) 320.79,203.69 320.86,203.76 320.86,207.08 319.78,208.16 319.78,210.65 326.46,217.32 339.77,217.32 340.74,218.28 377.41,218.28 380.78,221.65 382.33,221.65 382.83,221.15 382.83,219.97 382.9,219.9 v1(383.31,219.9)
D10305: length 385
  TOP w0.086: SITE4.129 323.43,197.78 323.35,197.86 323.35,198.57 319.3,202.62 319.3,207.2 318.34,208.16 318.34,208.63 v1(318.79,209.08)
  L07_SIGNAL w0.071: D103.05 318.94,54.44 320.59,54.44 321.15,53.89 321.15,49.99 315.02,43.86 308.31,43.86 303.72,39.27 303.72,33.49 300.08,29.85 289.14,29.85 285.16,33.83 285.16,97.63 291.17,103.64 304.9,103.64 329.34,128.08 329.34,145.04 337.93,153.63 348.1,153.63 359.93,165.46 359.93,196.57 363.1,199.74 364.64,199.74 372.77,207.87 382.2,207.87 382.63,207.44 382.63,206.38 382.56,206.31 v1(382.16,206.31)
  L30_SIGNAL w0.071: v1(382.16,206.31) 382.56,206.31 382.63,206.38 382.63,208.1 375.16,215.58 343.84,215.58 343.22,214.96 319.98,214.96 318.32,213.29 318.32,209.16 318.39,209.08 v1(318.79,209.08)
D10306: length 385
  TOP w0.086: SITE4.95 337.03,197.78 336.95,197.86 336.95,199.72 340.9,203.67 340.9,207.1 v1(341.36,207.55)
  L07_SIGNAL w0.071: D103.06 321.32,59.7 321.92,59.7 322.85,60.63 322.85,61.63 322.4,62.08 299.43,62.08 297.07,64.45 297.07,88.19 307.81,98.93 348.9,98.93 349.28,99.3 349.28,99.77 348.92,100.13 316.42,100.13 315.94,100.6 315.94,101.3 316.49,101.84 348.07,101.84 348.97,102.73 348.97,147.33 363.34,161.71 363.34,180.01 368.05,184.72 371.35,184.72 373.26,186.63 391.71,186.63 394.83,189.75 394.83,190.87 394.76,190.94 v1(394.35,190.94)
  L28_SIGNAL w0.071: v1(394.35,190.94) 394.76,190.94 394.83,191.02 394.83,196.58 387.03,204.38 370.35,204.38 369.53,205.2 366.33,205.2 365.67,204.55 362.24,204.55 354.77,212.02 342.84,212.02 340.88,210.06 340.88,207.62 340.96,207.55 v1(341.36,207.55)
D10307: length 385
  TOP w0.086: SITE4.130 323.03,197.78 323.11,197.86 323.11,198.47 319.06,202.52 319.06,207.1 318.1,208.06 318.1,208.63 v1(317.64,209.08)
  L07_SIGNAL w0.071: D103.07 321.34,54.64 321.34,49.91 315.1,43.67 308.4,43.67 303.92,39.19 303.92,33.41 300.16,29.65 289.06,29.65 284.96,33.75 284.96,97.72 291.08,103.84 304.82,103.84 329.15,128.16 329.15,145.13 337.85,153.83 348.02,153.83 359.73,165.54 359.73,196.65 363.02,199.94 364.55,199.94 372.68,208.07 382.28,208.07 382.83,207.52 382.83,206.38 382.9,206.31 v1(383.31,206.31)
  L30_SIGNAL w0.071: v1(317.64,209.08) 318.05,209.08 318.12,209.16 318.12,213.37 319.9,215.16 343.14,215.16 343.76,215.78 375.24,215.78 382.83,208.18 382.83,206.38 382.9,206.31 v1(383.31,206.31)
D10308: length 385
  TOP w0.086: v1(340.21,207.55) 340.67,207.1 340.67,203.77 336.71,199.82 336.71,197.86 336.63,197.78 SITE4.96
  L07_SIGNAL w0.071: D103.08 323.05,60.49 323.05,61.71 322.48,62.28 299.51,62.28 297.26,64.53 297.26,88.1 307.89,98.73 348.98,98.73 349.47,99.22 349.47,99.85 349,100.32 316.51,100.32 316.14,100.69 316.14,101.22 316.57,101.65 348.16,101.65 349.16,102.65 349.16,147.25 363.54,161.63 363.54,179.93 368.13,184.52 371.43,184.52 373.34,186.43 391.79,186.43 395.03,189.67 395.03,190.87 395.1,190.94 v1(395.5,190.94)
  L28_SIGNAL w0.071: v1(340.21,207.55) 340.62,207.55 340.69,207.62 340.69,210.14 342.76,212.21 354.86,212.21 362.33,204.74 365.59,204.74 366.25,205.4 369.61,205.4 370.43,204.58 387.11,204.58 395.03,196.67 395.03,191.02 395.1,190.94 v1(395.5,190.94)
D10309: length 385
  TOP w0.086: v1(346.32,208.6) 345.87,208.15 345.87,205.63 345.31,205.07 345.31,202.18 343.95,200.83 341.74,200.83 339.35,198.44 339.35,197.86 339.43,197.78 SITE4.89
  L07_SIGNAL w0.071: D103.09 328.97,54.57 329.09,54.57 330.82,52.84 330.82,46.42 334.19,43.05 346.15,43.05 350.36,38.84 350.36,23.39 355.42,18.33 372.3,18.33 376.54,22.58 376.54,93.35 382.09,98.9 413.68,98.9 421.03,106.24 421.03,117.8 401.97,136.85 401.97,142.46 399.18,145.26 399.18,157.46 404.07,162.34 407.49,162.34 408.29,161.54 408.29,160.92 408.22,160.85 v1(407.82,160.85)
  L28_SIGNAL w0.071: v1(407.82,160.85) 408.21,160.85 408.29,160.92 408.29,162.49 398.45,172.33 398.45,179.83 391.39,186.89 391.39,196.97 387.36,201 374.25,201 371.73,203.52 360.21,203.52 353.81,209.93 346.38,209.93 345.85,209.39 345.85,208.68 345.92,208.6 v1(346.32,208.6)
D10311: length 385
  TOP w0.086: v1(345.18,208.6) 345.63,208.15 345.63,205.73 345.07,205.17 345.07,202.28 343.85,201.07 341.64,201.07 339.11,198.54 339.11,197.86 339.03,197.78 SITE4.90
  L07_SIGNAL w0.071: D103.11 331.02,54.16 331.02,46.5 334.27,43.24 346.23,43.24 350.56,38.92 350.56,23.48 355.51,18.52 372.21,18.52 376.35,22.66 376.35,93.43 382.01,99.09 413.6,99.09 420.83,106.33 420.83,117.72 401.78,136.77 401.78,142.38 398.98,145.17 398.98,157.54 403.98,162.54 407.57,162.54 408.49,161.63 408.49,160.92 408.56,160.85 v1(408.96,160.85)
  L28_SIGNAL w0.071: v1(345.18,208.6) 345.58,208.6 345.65,208.68 345.65,209.47 346.3,210.12 353.89,210.12 360.29,203.72 371.81,203.72 374.33,201.2 387.44,201.2 391.59,197.05 391.59,186.97 398.65,179.91 398.65,172.41 408.48,162.57 408.48,160.92 408.55,160.85 v1(408.96,160.85)
D10313: length 385
  TOP w0.086: SITE4.133 317.68,193.23 317.6,193.15 317.23,193.15 311.06,199.32 306.27,199.32 v1(305.81,199.77)
  L07_SIGNAL w0.071: D103.13 339.86,53.84 339.86,53.76 339.86,46.56 341.5,44.92 346.59,44.92 351.84,39.68 351.84,24.81 356.12,20.53 372.04,20.53 375.07,23.56 375.07,95.15 380.82,100.9 409.84,100.9 418.17,109.23 418.17,118.23 405.39,131.01 402.86,131.01 392.88,140.99 392.88,145.85 393.26,146.23 394.48,146.23 394.83,145.88 394.83,144.15 394.76,144.08 v1(394.35,144.08)
  L28_SIGNAL w0.071: v1(305.81,199.77) 305.81,199.37 305.74,199.3 304.03,199.3 302.88,198.15 302.88,183.33 303.98,182.22 311.55,182.22 326.16,167.61 336.64,167.61 350.99,153.26 356.93,153.26 358.25,154.57 372.95,154.57 377.91,149.62 390.43,149.62 394.83,145.22 394.83,144.15 394.76,144.08 v1(394.35,144.08)
D10314: length 385
  TOP w0.086: SITE4.131 322.63,197.78 322.55,197.86 322.55,198.26 317.11,203.7 317.11,204.97 v1(317.56,205.42)
  L07_SIGNAL w0.071: v1(394.35,157.67) 394.76,157.67 394.83,157.6 394.83,156.64 393.04,154.86 393.04,148.28 388.57,143.81 388.57,137.96 399.43,127.1 406.8,127.1 413.3,120.6 413.3,109.25 407.67,103.62 402.58,103.62 401.61,104.59 381.39,104.59 373.37,96.58 373.37,24.69 371.37,22.69 356.77,22.69 353.57,25.88 353.57,41.33 350.03,44.88 350.03,60.2 347.81,62.41 343.97,62.41 343.18,61.63 343.18,60.66 342.13,59.6 341.54,59.6 D103.14
  L32_SIGNAL w0.071: v1(317.56,205.42) 317.16,205.42 317.09,205.35 317.09,200.93 321.73,196.28 349.32,196.28 353.57,200.54 361.4,200.54 363.82,198.12 363.82,186.58 370.51,179.89 370.51,170.63 375.39,165.75 383.26,165.75 393.1,155.92 394.26,155.92 394.83,156.48 394.83,157.6 394.76,157.67 v1(394.35,157.67)
D10315: length 385
  TOP w0.086: v1(305.81,198.63) 306.27,199.08 310.96,199.08 317.13,192.91 317.6,192.91 317.68,192.83 SITE4.134
  L07_SIGNAL w0.071: D103.15 340.06,53.04 340.06,46.64 341.58,45.12 346.68,45.12 352.04,39.76 352.04,24.89 356.2,20.73 371.96,20.73 374.87,23.64 374.87,95.23 380.74,101.1 409.76,101.1 417.97,109.31 417.97,118.14 405.3,130.81 402.78,130.81 392.68,140.91 392.68,145.93 393.18,146.43 394.56,146.43 395.02,145.96 395.02,144.15 395.1,144.08 v1(395.5,144.08)
  L28_SIGNAL w0.071: v1(395.5,144.08) 395.1,144.08 395.03,144.15 395.03,145.3 390.51,149.82 377.99,149.82 373.03,154.77 358.16,154.77 356.85,153.46 351.07,153.46 336.72,167.81 326.24,167.81 311.63,182.42 304.07,182.42 303.08,183.41 303.08,198.07 304.11,199.1 305.74,199.1 305.81,199.03 v1(305.81,198.63)
D10316: length 385
  TOP w0.086: v1(316.42,205.42) 316.87,204.97 316.87,203.6 322.31,198.16 322.31,197.86 322.23,197.78 SITE4.132
  L07_SIGNAL w0.071: D103.16 343.38,60.48 343.38,61.54 344.06,62.22 347.73,62.22 349.83,60.11 349.83,44.8 353.38,41.25 353.38,25.8 356.69,22.49 371.46,22.49 373.57,24.6 373.57,96.5 381.47,104.39 401.53,104.39 402.5,103.42 407.75,103.42 413.5,109.17 413.5,120.68 406.88,127.3 399.51,127.3 388.77,138.04 388.77,143.72 393.24,148.19 393.24,154.77 395.03,156.56 395.03,157.6 395.1,157.67 v1(395.5,157.67)
  L32_SIGNAL w0.071: v1(316.42,205.42) 316.82,205.42 316.89,205.35 316.89,200.85 321.65,196.09 349.4,196.09 353.65,200.34 361.31,200.34 363.62,198.04 363.62,186.5 370.31,179.8 370.31,170.55 375.31,165.55 383.18,165.55 393.01,155.72 394.34,155.72 395.02,156.4 395.02,157.6 395.1,157.67 v1(395.5,157.67)
D10601: length 385
  TOP w0.086: v1(357.52,196.03) 357.07,196.49 350.12,196.49 345.74,192.11 344.06,192.11 343.98,192.03 SITE4.85
  L05_SIGNAL w0.071: D106.01 382.47,74.73 383.82,74.73 384.47,74.08 384.47,73.5 383.38,72.41 371.12,72.41 366.99,76.55 366.99,128.56 358.38,137.17 352.52,137.17 348.77,140.92 340.28,140.92 338.71,142.48 336.81,142.48 336.16,141.84 334.24,141.84 332.92,143.15 332.92,144.17 332.39,144.71 331.64,144.71 330.33,143.4 329.7,143.4 329.02,144.09 329.02,154.01 328.27,154.76 327.45,154.76 326.67,153.97 326.67,149.95 327.15,149.47 327.15,144.8 326.48,144.14 325.82,144.14 325.17,144.79 325.17,154.24 324.62,154.79 323.84,154.79 322.8,153.75 322.8,150.37 323.48,149.69 323.48,144.7 322.65,143.86 322.1,143.86 321.57,144.39 321.57,151.89 320.94,152.52 319.56,152.52 318.3,151.26 318.3,148.26 319.55,147.01 319.55,136.03 318.65,135.13 316.86,135.13 316.16,135.83 316.16,151.77 318.13,153.73 320.97,153.73 323.15,155.91 354.14,155.91 359.15,160.92 363.55,160.92 365.97,163.34 367.91,163.34 375.07,156.18 383.76,156.18 389.93,162.35 394.42,162.35 394.83,161.95 394.83,160.92 394.76,160.85 v1(394.35,160.85)
  L28_SIGNAL w0.071: v1(357.52,196.03) 357.52,196.44 357.59,196.51 361.06,196.51 368.66,188.9 371.17,188.9 373.93,186.14 377.44,186.14 393.85,169.73 393.85,163.08 394.83,162.1 394.83,160.92 394.76,160.85 v1(394.35,160.85)
D10602: length 385
  TOP w0.086: v1(353.81,193.77) 353.35,194.22 349.53,194.22 346.61,191.31 344.06,191.31 343.98,191.23 SITE4.83
  L05_SIGNAL w0.071: D106.02 386.38,81.58 386.38,81.91 385.87,82.42 381.58,82.42 378.17,79 378.17,75.25 377.04,74.13 371.93,74.13 368.79,77.26 368.79,127.85 358.46,138.18 356.11,138.18 355.11,139.18 355.11,140.34 353.27,142.18 342.41,142.18 340.71,143.89 335.73,143.89 331.57,148.04 331.57,148.92 332.19,149.54 339.59,149.54 340.24,148.89 353.94,148.89 354.79,149.74 354.79,150.36 354.08,151.07 332.88,151.07 332.45,151.5 332.45,152.35 332.88,152.78 339.55,152.78 340.26,153.5 355.75,153.5 359.96,157.71 363.26,157.71 371.67,149.3 379.98,149.3 381.38,147.9 397.12,147.9 398.13,148.91 398.13,149.92 397.62,150.42 379.13,150.42 378.36,151.19 374.36,151.19 373.49,152.06 373.49,152.9 374.01,153.41 395.65,153.41 398.59,156.35 398.59,169.13 394.83,172.9 394.83,174.36 394.76,174.43 v1(394.35,174.43)
  L30_SIGNAL w0.071: v1(394.35,174.43) 394.76,174.43 394.83,174.51 394.83,175.31 394.36,175.77 388.62,175.77 380,184.39 369.36,184.39 359.5,194.24 353.88,194.24 353.81,194.17 v1(353.81,193.77)
D10603: length 385
  TOP w0.086: SITE4.86 343.98,192.43 344.06,192.35 345.64,192.35 350.02,196.73 357.07,196.73 v1(357.52,197.18)
  L05_SIGNAL w0.071: D106.03 384.67,74.79 384.67,74.69 384.67,73.42 383.46,72.22 371.04,72.22 366.79,76.47 366.79,128.48 358.3,136.97 352.44,136.97 348.69,140.72 340.2,140.72 338.63,142.29 336.89,142.29 336.25,141.64 334.15,141.64 332.73,143.07 332.73,144.09 332.3,144.51 331.72,144.51 330.42,143.21 329.62,143.21 328.82,144 328.82,153.92 328.19,154.56 327.53,154.56 326.87,153.89 326.87,150.03 327.34,149.55 327.34,144.72 326.56,143.94 325.73,143.94 324.97,144.7 324.97,154.16 324.54,154.59 323.92,154.59 323,153.67 323,150.46 323.68,149.78 323.68,144.62 322.73,143.67 322.02,143.67 321.37,144.31 321.37,151.81 320.86,152.32 319.64,152.32 318.5,151.18 318.5,148.34 319.75,147.09 319.75,135.95 318.73,134.94 316.77,134.94 315.96,135.75 315.96,151.85 318.04,153.93 320.89,153.93 323.07,156.11 354.05,156.11 359.07,161.12 363.46,161.12 365.88,163.54 368,163.54 375.15,156.38 383.68,156.38 389.85,162.55 394.5,162.55 395.03,162.03 395.03,160.92 395.1,160.85 v1(395.5,160.85)
  L28_SIGNAL w0.071: v1(395.5,160.85) 395.1,160.85 395.03,160.92 395.03,162.19 394.05,163.16 394.05,169.81 377.53,186.33 374.01,186.33 371.25,189.1 368.75,189.1 361.14,196.7 357.59,196.7 357.52,196.78 v1(357.52,197.18)
D10604: length 385
  TOP w0.086: SITE4.84 343.98,191.63 344.06,191.55 346.51,191.55 349.43,194.46 353.35,194.46 v1(353.81,194.92)
  L05_SIGNAL w0.071: v1(395.5,174.43) 395.1,174.43 395.02,174.36 395.02,172.98 398.79,169.22 398.79,156.27 395.74,153.22 374.09,153.22 373.69,152.81 373.69,152.14 374.44,151.39 378.45,151.39 379.21,150.62 397.71,150.62 398.33,150 398.33,148.83 397.2,147.7 381.3,147.7 379.9,149.1 371.58,149.1 363.17,157.51 360.05,157.51 355.84,153.3 340.34,153.3 339.63,152.59 332.97,152.59 332.65,152.27 332.65,151.58 332.96,151.27 354.16,151.27 354.99,150.44 354.99,149.66 354.02,148.69 340.16,148.69 339.51,149.34 332.27,149.34 331.77,148.84 331.77,148.13 335.81,144.09 340.79,144.09 342.49,142.38 353.35,142.38 355.31,140.42 355.31,139.26 356.19,138.38 358.55,138.38 368.99,127.93 368.99,77.35 372.01,74.33 376.96,74.33 377.97,75.33 377.97,79.08 381.5,82.62 385.95,82.62 386.58,81.99 386.58,80.78 D106.04
  L30_SIGNAL w0.071: v1(353.81,194.92) 353.81,194.51 353.88,194.44 359.58,194.44 369.44,184.59 380.08,184.59 388.7,175.97 394.45,175.97 395.02,175.39 395.02,174.51 395.1,174.43 v1(395.5,174.43)
D10605: length 385
  TOP w0.086: SITE4.135 317.68,192.43 317.6,192.35 316.53,192.35 311.68,197.2 309.02,197.2 v1(308.57,197.65)
  L07_SIGNAL w0.071: v1(408.07,157.67) 408.47,157.67 408.54,157.74 408.54,158.57 409.26,159.28 410.65,159.28 412.09,157.84 412.09,151.88 406.37,146.16 406.37,141.01 410.69,136.7 443.88,136.7 460.11,120.46 460.11,87.13 454.41,81.42 436.62,81.42 423.75,94.3 382.08,94.3 377.54,89.75 377.54,74.24 379.39,72.39 393.49,72.39 393.9,72.8 393.9,73.59 392.71,74.78 392.58,74.78 D106.05
  L30_SIGNAL w0.071: v1(308.57,197.65) 308.57,197.25 308.64,197.18 325.04,197.18 326.92,195.3 339.16,195.3 350.03,184.43 350.03,179.04 359.42,169.64 392.04,169.64 405.36,156.32 407.96,156.32 408.54,156.9 408.54,157.6 408.47,157.67 v1(408.07,157.67)
D10606: length 385
  TOP w0.086: v1(305.81,195.53) 306.27,195.08 312.64,195.08 316.17,191.55 317.6,191.55 317.68,191.63 SITE4.137
  L07_SIGNAL w0.071: D106.06 395.78,80.82 395.78,82 395.37,82.42 380.33,82.42 378.95,83.79 378.95,89.63 382.34,93.01 421.93,93.01 435.79,79.14 460,79.14 462.12,81.26 462.12,136.03 454.84,143.32 432.28,143.32 427.1,138.13 415.81,138.13 412.43,141.51 409.59,141.51 408.54,142.56 408.54,144.01 408.47,144.08 v1(408.07,144.08)
  L28_SIGNAL w0.071: v1(408.07,144.08) 408.47,144.08 408.54,144.15 408.54,145.42 401.43,152.53 378.91,152.53 374.65,156.78 366.83,156.78 350.65,172.97 322.53,172.97 313.06,182.43 313.06,183.51 312.28,184.3 307.01,184.3 303.96,187.36 303.96,194.17 304.85,195.06 305.74,195.06 305.81,195.13 v1(305.81,195.53)
D10607: length 385
  TOP w0.086: SITE4.136 317.68,192.03 317.6,192.11 316.43,192.11 311.58,196.96 309.02,196.96 v1(308.57,196.51)
  L07_SIGNAL w0.071: v1(409.21,157.67) 408.81,157.67 408.74,157.74 408.74,158.48 409.34,159.08 410.57,159.08 411.89,157.76 411.89,151.96 406.18,146.25 406.18,140.93 410.6,136.5 443.8,136.5 459.92,120.38 459.92,87.21 454.32,81.62 436.7,81.62 423.83,94.49 382,94.49 377.34,89.84 377.34,74.16 379.31,72.19 393.58,72.19 394.1,72.71 394.1,74.06 D106.07
  L30_SIGNAL w0.071: v1(308.57,196.51) 308.57,196.91 308.64,196.98 324.96,196.98 326.84,195.1 339.08,195.1 349.83,184.35 349.83,178.95 359.34,169.44 391.96,169.44 405.28,156.12 408.04,156.12 408.74,156.82 408.74,157.6 408.81,157.67 v1(409.21,157.67)
D10608: length 385
  TOP w0.086: SITE4.138 317.68,191.23 317.6,191.31 316.07,191.31 312.55,194.84 306.27,194.84 v1(305.81,194.39)
  L07_SIGNAL w0.071: D106.08 396.89,80.63 396.84,80.63 395.98,81.48 395.98,82.08 395.45,82.62 380.41,82.62 379.15,83.87 379.15,89.54 382.42,92.81 421.85,92.81 435.71,78.94 460.08,78.94 462.32,81.18 462.32,136.12 454.92,143.52 432.2,143.52 427.01,138.33 415.89,138.33 412.52,141.71 409.67,141.71 408.74,142.64 408.74,144.01 408.81,144.08 v1(409.21,144.08)
  L28_SIGNAL w0.071: v1(305.81,194.39) 305.81,194.79 305.74,194.86 304.93,194.86 304.16,194.09 304.16,187.44 307.1,184.5 312.36,184.5 313.26,183.6 313.26,182.52 322.61,173.17 350.73,173.17 366.91,156.98 374.74,156.98 378.99,152.73 401.52,152.73 408.74,145.51 408.74,144.15 408.81,144.08 v1(409.21,144.08)
D10609: length 385
  TOP w0.086: SITE4.140 317.68,190.43 317.6,190.35 313.96,190.35 312.03,192.28 309.02,192.28 v1(308.57,192.73)
  L07_SIGNAL w0.071: D106.09 403.3,74.22 403.3,73.1 404.2,72.19 472.91,72.19 487.95,87.23 487.95,154.91 483.58,159.28 422.63,159.28 422,158.65 422,157.74 421.93,157.67 v1(421.53,157.67)
  L30_SIGNAL w0.071: v1(421.53,157.67) 421.93,157.67 422,157.6 422,156.6 419.2,153.8 393.42,153.8 382.02,165.2 359.74,165.2 351.75,173.18 328.29,173.18 326.77,174.7 326.77,189.25 323.76,192.26 308.64,192.26 308.57,192.33 v1(308.57,192.73)
D10610: length 385
  TOP w0.086: v1(305.81,190.64) 306.27,190.19 312.4,190.19 313.04,189.55 317.6,189.55 317.68,189.63 SITE4.142
  L07_SIGNAL w0.071: v1(421.53,144.08) 421.93,144.08 422,144.01 422,141.07 422.95,140.13 425.12,140.13 432,147 481.69,147 486.1,142.6 486.1,88.97 471.63,74.51 428.38,74.51 420.2,82.68 407.18,82.68 406.63,82.13 406.63,81.42 405.27,80.05 405.17,80.05 D106.10
  L28_SIGNAL w0.071: v1(305.81,190.64) 305.81,190.24 305.89,190.16 308.65,190.16 309.54,191.06 323.05,191.06 326.66,187.44 326.66,177.95 330.33,174.28 356.97,174.28 369.56,161.69 374.07,161.69 379.52,156.24 418.09,156.24 420.16,154.18 420.16,142.79 420.57,142.37 421.35,142.37 422,143.03 422,144.01 421.93,144.08 v1(421.53,144.08)
D10611: length 385
  TOP w0.086: SITE4.141 317.68,190.03 317.6,190.11 313.86,190.11 311.93,192.04 309.02,192.04 v1(308.57,191.59)
  L07_SIGNAL w0.071: D106.11 405.07,74.87 404.05,74.87 403.49,74.31 403.49,73.18 404.29,72.39 472.83,72.39 487.75,87.31 487.75,154.83 483.5,159.08 422.71,159.08 422.2,158.57 422.2,157.74 422.27,157.67 v1(422.68,157.67)
  L30_SIGNAL w0.071: v1(308.57,191.59) 308.57,191.99 308.64,192.06 323.68,192.06 326.57,189.16 326.57,174.62 328.21,172.98 351.67,172.98 359.65,165 381.94,165 393.34,153.6 419.28,153.6 422.2,156.52 422.2,157.6 422.27,157.67 v1(422.68,157.67)
D10612: length 385
  TOP w0.086: v1(305.81,189.49) 306.27,189.95 312.3,189.95 312.94,189.31 317.6,189.31 317.68,189.23 SITE4.143
  L07_SIGNAL w0.071: D106.12 406.83,80.85 406.83,82.05 407.26,82.49 420.12,82.49 428.3,74.31 471.72,74.31 486.29,88.89 486.29,142.68 481.77,147.2 431.92,147.2 425.04,140.32 423.03,140.32 422.2,141.15 422.2,144.01 422.27,144.08 v1(422.68,144.08)
  L28_SIGNAL w0.071: v1(305.81,189.49) 305.81,189.9 305.89,189.97 308.73,189.97 309.62,190.86 322.97,190.86 326.47,187.36 326.47,177.87 330.25,174.09 356.89,174.09 369.48,161.5 373.99,161.5 379.44,156.05 418.01,156.05 419.96,154.1 419.96,142.7 420.49,142.17 421.43,142.17 422.2,142.94 422.2,144.01 422.27,144.08 v1(422.68,144.08)
D10613: length 385
  TOP w0.086: SITE4.114 329.43,197.78 329.35,197.86 329.35,207.66 v1(329.8,208.11)
  L05_SIGNAL w0.071: D106.13 412.79,74.89 412.79,72.54 413.07,72.26 484.53,72.26 486.85,74.58 486.85,155.81 484.28,158.38 431.59,158.38 418.47,171.5 418.47,176.27 414.97,179.77 409.22,179.77 408.29,178.84 408.29,177.43 408.22,177.36 v1(407.82,177.36)
  L30_SIGNAL w0.071: v1(329.8,208.11) 329.4,208.11 329.33,208.18 329.33,209.35 328.83,209.85 327.73,209.85 326.47,208.59 326.47,203.06 328.75,200.78 337.76,200.78 350.34,188.21 354.97,188.21 362.94,180.24 366.58,180.24 370.55,176.27 373.32,176.27 376.91,172.67 409.36,172.67 411.48,174.8 411.48,178.36 410.25,179.58 409.18,179.58 408.29,178.69 408.29,177.43 408.22,177.36 v1(407.82,177.36)
D10614: length 385
  TOP w0.086: v1(353.81,198.17) 353.35,198.62 350.67,198.62 344.96,192.91 344.06,192.91 343.98,192.83 SITE4.87
  L05_SIGNAL w0.071: D106.14 415.75,80.47 415.83,80.47 416.8,81.43 416.8,82.24 417.25,82.7 422.24,82.7 423.18,83.64 423.18,93.55 416.17,100.55 407.92,100.55 406.83,99.46 406.83,97.93 407.56,97.19 411.67,97.19 412.8,96.06 412.8,95.24 411.64,94.08 379.15,94.08 377.45,95.78 377.45,127.31 376.42,128.33 375.2,128.33 373.97,127.11 373.97,77 373.25,76.28 371.75,76.28 370.03,78 370.03,132.29 371,133.26 371,143.62 372.64,145.26 397.32,145.26 399.81,147.74 399.81,164.9 408.29,173.38 408.29,174.36 408.22,174.43 v1(407.82,174.43)
  L30_SIGNAL w0.071: v1(353.81,198.17) 353.81,198.57 353.88,198.64 359.07,198.64 369.66,188.05 372.01,188.05 374.12,185.95 390.92,185.95 401.05,175.81 407.82,175.81 408.29,175.34 408.29,174.51 408.22,174.43 v1(407.82,174.43)
D10615: length 385
  TOP w0.086: v1(328.66,208.11) 329.11,207.66 329.11,197.86 329.03,197.78 SITE4.115
  L05_SIGNAL w0.071: D106.15 415.33,74.97 413.06,74.97 412.98,74.9 412.98,72.62 413.15,72.45 484.45,72.45 486.66,74.66 486.66,155.73 484.2,158.18 431.51,158.18 418.28,171.41 418.28,176.18 414.89,179.57 409.3,179.57 408.49,178.76 408.49,176.89 408.58,176.8 408.8,176.8 408.88,176.87 408.88,177.27 v1(408.96,177.36)
  L30_SIGNAL w0.071: v1(408.96,177.36) 408.56,177.36 408.49,177.43 408.49,178.61 409.27,179.39 410.17,179.39 411.28,178.28 411.28,174.88 409.27,172.87 376.99,172.87 373.4,176.47 370.64,176.47 366.66,180.44 363.02,180.44 355.05,188.4 350.42,188.4 337.85,200.98 328.83,200.98 326.66,203.14 326.66,208.51 327.81,209.65 328.75,209.65 329.13,209.27 329.13,208.18 329.06,208.11 v1(328.66,208.11)
D10616: length 385
  TOP w0.086: SITE4.88 343.98,193.23 344.06,193.15 344.86,193.15 350.57,198.86 353.35,198.86 v1(353.81,199.31)
  L05_SIGNAL w0.071: D106.16 416.99,80.85 416.99,82.16 417.33,82.5 422.32,82.5 423.38,83.55 423.38,93.63 416.26,100.75 407.84,100.75 406.63,99.54 406.63,97.85 407.48,97 411.59,97 412.61,95.98 412.61,95.32 411.55,94.27 379.23,94.27 377.65,95.86 377.65,127.39 376.51,128.53 375.12,128.53 373.77,127.19 373.77,77.08 373.17,76.48 371.84,76.48 370.23,78.09 370.23,132.2 371.2,133.18 371.2,143.54 372.72,145.06 397.4,145.06 400.01,147.66 400.01,164.82 408.49,173.3 408.49,174.36 408.56,174.43 v1(408.96,174.43)
  L30_SIGNAL w0.071: v1(408.96,174.43) 408.56,174.43 408.49,174.51 408.49,175.42 407.9,176.01 401.14,176.01 391,186.14 374.2,186.14 372.09,188.25 369.75,188.25 359.16,198.84 353.88,198.84 353.81,198.91 v1(353.81,199.31)
D10701: length 439
  TOP w0.086: SITE4.172 317.68,177.63 317.6,177.71 313.62,177.71 312.68,176.77 311.43,176.77 v1(310.98,176.32)
  L03_SIGNAL w0.071: v1(325.39,142.43) 324.99,142.43 324.92,142.36 324.92,141.4 326.86,139.46 326.86,127.77 325.79,126.69 303.96,126.69 302.11,128.55 302.11,142.99 296.69,148.41 290.56,148.41 288.1,145.94 266.91,145.94 265.01,144.05 265.01,133.77 265.88,132.9 277.83,132.9 280.26,130.47 280.26,120.03 299.74,100.55 299.74,26.63 305.91,20.45 364.96,20.45 367.18,22.67 367.18,24.18 366.07,25.29 360.82,25.29 360.02,26.09 360.02,29.07 361.38,30.42 365.31,30.42 382.96,48.07 382.96,53.92 D107.01
  L30_SIGNAL w0.071: v1(310.98,176.32) 310.98,176.72 311.05,176.79 312.11,176.79 312.59,177.27 312.59,181.47 311.58,182.49 305.7,182.49 304.01,180.8 304.01,159.18 313.89,149.3 313.89,144.2 317.32,140.77 324.28,140.77 324.92,141.41 324.92,142.36 324.99,142.43 v1(325.39,142.43)
D10702: length 439
  TOP w0.086: v1(307.59,169.94) 308.05,170.39 321.9,170.39 322.55,171.04 322.55,171.4 322.63,171.48 SITE4.2
  L03_SIGNAL w0.071: D107.02 385.47,60.35 385.47,61.68 384.97,62.18 380.25,62.18 348.55,93.88 338.85,93.88 328.7,104.03 328.7,127.42 329.36,128.08 329.36,148.36 339.37,158.37 339.37,168.34 344.17,173.13 410.09,173.13 414.12,177.16 420.6,177.16 421.7,176.06 421.7,174.51 421.77,174.43 v1(422.17,174.43)
  L32_SIGNAL w0.071: v1(307.59,169.94) 307.59,170.34 307.67,170.41 320.32,170.41 328.75,178.85 332.98,178.85 336.15,182.02 336.15,186.71 339,189.56 348.44,189.56 351.33,192.45 354.99,192.45 357.2,190.24 359.36,190.24 360.42,189.18 360.42,166.85 376.96,150.31 423.12,150.31 425.96,153.15 425.96,169.3 421.7,173.57 421.7,174.36 421.77,174.43 v1(422.17,174.43)
D10703: length 439
  TOP w0.086: v1(310.98,177.46) 311.43,177.01 312.58,177.01 313.52,177.95 317.6,177.95 317.68,178.03 SITE4.171
  L03_SIGNAL w0.071: v1(324.25,142.43) 324.65,142.43 324.72,142.36 324.72,141.32 326.66,139.38 326.66,127.85 325.71,126.89 304.04,126.89 302.31,128.63 302.31,143.07 296.77,148.61 290.48,148.61 288.01,146.14 266.83,146.14 264.82,144.13 264.82,133.69 265.8,132.71 277.75,132.71 280.06,130.39 280.06,119.95 299.54,100.47 299.54,26.55 305.83,20.25 365.04,20.25 367.37,22.59 367.37,24.26 366.15,25.49 360.91,25.49 360.22,26.17 360.22,28.99 361.46,30.22 365.39,30.22 383.16,47.99 383.16,53.97 384,54.82 385.02,54.82 D107.03
  L30_SIGNAL w0.071: v1(310.98,177.46) 310.98,177.06 311.05,176.99 312.03,176.99 312.39,177.35 312.39,181.39 311.5,182.29 305.78,182.29 304.21,180.72 304.21,159.26 314.09,149.38 314.09,144.28 317.4,140.97 324.2,140.97 324.72,141.49 324.72,142.36 324.65,142.43 v1(324.25,142.43)
D10704: length 439
  TOP w0.086: SITE4.1 322.23,171.48 322.31,171.4 322.31,171.14 321.8,170.63 308.05,170.63 v1(307.59,171.09)
  L03_SIGNAL w0.071: v1(421.02,174.43) 421.43,174.43 421.5,174.51 421.5,175.98 420.52,176.96 414.2,176.96 410.17,172.93 344.25,172.93 339.57,168.25 339.57,158.29 329.55,148.28 329.55,127.99 328.9,127.34 328.9,104.11 338.93,94.08 348.63,94.08 380.34,62.38 385.05,62.38 385.67,61.76 385.67,59.72 385.77,59.62 387.42,59.62 D107.04
  L32_SIGNAL w0.071: v1(421.02,174.43) 421.43,174.43 421.5,174.36 421.5,173.49 425.77,169.22 425.77,153.24 423.04,150.51 377.04,150.51 360.62,166.93 360.62,189.26 359.45,190.44 357.29,190.44 355.08,192.65 351.25,192.65 348.36,189.76 338.91,189.76 335.95,186.8 335.95,182.1 332.9,179.04 328.67,179.04 320.24,170.61 307.67,170.61 307.59,170.68 v1(307.59,171.09)
D10705: length 385
  TOP w0.086: v1(357.52,192.08) 357.07,192.53 350.02,192.53 347.99,190.51 344.06,190.51 343.98,190.43 SITE4.81
  L05_SIGNAL w0.071: D107.05 392.56,54.48 393.9,54.48 394.62,53.81 394.62,47.29 392.77,45.44 362.56,45.44 359.12,48.88 359.12,96.26 349.4,105.97 349.4,122.85 352.25,125.7 356.75,125.7 360,128.95 360,132.11 358.12,134 347.24,134 344.57,136.67 329.13,136.67 328.55,136.09 328.55,135.16 329.16,134.54 330.29,134.54 330.95,133.88 330.95,133.23 330.42,132.69 306.95,132.69 306.15,133.5 306.15,158.09 306.92,158.86 318.69,158.86 321.42,161.59 321.42,167.81 321.91,168.31 340.22,168.31 343.05,171.14 357.54,171.14 359.35,169.33 372.79,169.33 380.09,162.03 381.27,162.03 381.62,161.68 381.62,160.66 381.55,160.59 v1(381.15,160.59)
  L28_SIGNAL w0.071: v1(381.15,160.59) 381.55,160.59 381.62,160.66 381.62,162.15 374.46,169.31 369.24,169.31 363.61,174.95 363.61,190.08 361.13,192.55 357.59,192.55 357.52,192.48 v1(357.52,192.08)
D10706: length 385
  TOP w0.086: SITE4.79 343.98,189.63 344.06,189.71 349.05,189.71 349.94,190.59 353.73,190.59 v1(354.19,190.14)
  L05_SIGNAL w0.071: v1(381.15,174.18) 381.55,174.18 381.62,174.11 381.62,172.98 385.36,169.24 385.36,160.53 383.62,158.79 376.98,158.79 372.65,163.12 372.65,164.38 371.3,165.73 360.7,165.73 353.32,158.35 342.72,158.35 338.77,162.3 338.77,165.4 336.92,167.24 327.93,167.24 325.2,164.52 325.2,161.14 322.91,158.86 322.91,157.63 320.85,155.57 309.64,155.57 307.68,153.61 307.68,139.22 308.09,138.82 309.3,138.82 309.76,139.28 309.76,152.11 310.51,152.86 312.14,152.86 314.09,150.92 314.09,139.35 311.95,137.21 311.95,134.2 312.47,133.67 326.7,133.67 327.53,134.51 327.53,135.4 326.76,136.17 321.57,136.17 320.92,136.82 320.92,137.64 321.7,138.43 329.8,138.43 331.43,140.07 339.28,140.07 341.77,137.58 349.2,137.58 351.65,135.12 358.16,135.12 364.52,128.76 364.52,75.88 378.21,62.19 396.05,62.19 396.53,61.7 396.53,61.25 D107.06
  L30_SIGNAL w0.071: v1(381.15,174.18) 381.55,174.18 381.62,174.25 381.62,175.3 381.29,175.63 376.64,175.63 371.96,180.31 369.57,180.31 359.27,190.61 354.26,190.61 354.19,190.54 v1(354.19,190.14)
D10707: length 385
  TOP w0.086: SITE4.82 343.98,190.83 344.06,190.75 347.89,190.75 349.92,192.77 357.07,192.77 v1(357.52,193.22)
  L05_SIGNAL w0.071: D107.07 394.81,54.45 394.81,47.2 392.85,45.24 362.47,45.24 358.92,48.79 358.92,96.18 349.21,105.89 349.21,122.93 352.17,125.9 356.67,125.9 359.81,129.03 359.81,132.03 358.03,133.8 347.16,133.8 344.49,136.47 329.21,136.47 328.75,136.01 328.75,135.24 329.25,134.74 330.37,134.74 331.15,133.96 331.15,133.15 330.5,132.49 306.87,132.49 305.95,133.41 305.95,158.18 306.83,159.06 318.61,159.06 321.22,161.67 321.22,167.89 321.83,168.5 340.14,168.5 342.97,171.33 357.62,171.33 359.43,169.53 372.88,169.53 380.18,162.23 381.35,162.23 381.82,161.76 381.82,160.66 381.89,160.59 v1(382.29,160.59)
  L28_SIGNAL w0.071: v1(357.52,193.22) 357.52,192.82 357.59,192.75 361.22,192.75 363.8,190.16 363.8,175.03 369.33,169.51 374.54,169.51 381.82,162.24 381.82,160.66 381.89,160.59 v1(382.29,160.59)
D10708: length 385
  TOP w0.086: v1(354.19,191.28) 353.73,190.83 349.84,190.83 348.95,189.95 344.06,189.95 343.98,190.03 SITE4.80
  L05_SIGNAL w0.071: D107.08 396.73,60.47 396.73,61.78 396.13,62.39 378.29,62.39 364.72,75.96 364.72,128.84 358.25,135.32 351.74,135.32 349.28,137.78 341.85,137.78 339.36,140.26 331.35,140.26 329.72,138.63 321.62,138.63 320.72,137.73 320.72,136.74 321.48,135.97 326.68,135.97 327.33,135.32 327.33,134.59 326.61,133.87 312.55,133.87 312.14,134.28 312.14,137.13 314.28,139.27 314.28,151 312.23,153.06 310.43,153.06 309.56,152.19 309.56,139.36 309.22,139.01 308.17,139.01 307.88,139.31 307.88,153.53 309.72,155.37 320.94,155.37 323.11,157.55 323.11,158.78 325.4,161.06 325.4,164.43 328.01,167.05 336.84,167.05 338.57,165.32 338.57,162.22 342.64,158.15 353.4,158.15 360.78,165.53 371.22,165.53 372.45,164.3 372.45,163.04 376.89,158.59 383.7,158.59 385.56,160.45 385.56,169.32 381.82,173.06 381.82,174.11 381.89,174.18 v1(382.29,174.18)
  L30_SIGNAL w0.071: v1(382.29,174.18) 381.89,174.18 381.82,174.25 381.82,175.39 381.37,175.83 376.72,175.83 372.04,180.51 369.66,180.51 359.35,190.81 354.26,190.81 354.19,190.88 v1(354.19,191.28)
D10709: length 220.5
  L05_SIGNAL w0.071: D107.09 403.48,53.72 403.48,47.62 399.8,43.94 360.84,43.94 356.11,48.67 356.11,97.41 347.15,106.38 347.15,122.95 351.51,127.31 356.46,127.31 359.04,129.9 359.04,130.98 358.06,131.97 357.13,131.97 357.06,132.04 v1(357.06,132.44)
  L32_SIGNAL w0.071: v1(357.06,132.44) 357.06,132.04 357.13,131.97 358.63,131.97 360.28,130.32 360.28,128.95 358.72,127.39 341.02,127.39 332.87,135.54 310.08,135.54 310.01,135.47 v1(310.01,134.11)
  BOTTOM w0.119: v1(310.01,134.11) UNK4K43.6
D10710: length 385
  TOP w0.086: SITE4.75 343.98,188.03 344.06,188.11 357.07,188.11 v1(357.52,187.66)
  L05_SIGNAL w0.071: v1(343.47,132.44) 343.47,132.04 343.4,131.97 342.79,131.97 342.12,132.64 342.12,133.65 343.32,134.85 344.54,134.85 345.33,134.05 345.33,130.85 343.78,129.3 333.59,129.3 332.5,130.39 307,130.39 304.48,127.86 304.48,110.17 316.3,98.35 347.86,98.35 348.82,99.3 351.75,99.3 354.2,96.85 354.2,47.8 359.83,42.17 427.86,42.17 433.88,48.18 433.88,58.13 429.64,62.37 407.39,62.37 406.34,61.32 406.34,60.39 405.63,59.67 405.11,59.67 D107.10
  L32_SIGNAL w0.071: v1(343.47,132.44) 343.47,132.04 343.54,131.97 344.18,131.97 344.43,132.21 344.43,136.32 352.65,144.54 352.65,154.44 359.06,160.85 359.06,187.65 358.59,188.13 357.59,188.13 357.52,188.06 v1(357.52,187.66)
D10711: length 220.5
  L05_SIGNAL w0.071: v1(357.06,131.3) 357.06,131.7 357.13,131.77 357.98,131.77 358.85,130.9 358.85,129.98 356.37,127.51 351.43,127.51 346.95,123.03 346.95,106.29 355.91,97.33 355.91,48.58 360.75,43.74 399.88,43.74 403.68,47.54 403.68,53.32 404.97,54.61 405.13,54.61 D107.11
  L32_SIGNAL w0.071: v1(357.06,131.3) 357.06,131.7 357.13,131.77 358.54,131.77 360.08,130.23 360.08,129.03 358.64,127.58 341.1,127.58 332.95,135.74 310.08,135.74 310.01,135.81 v1(310.01,137.16)
  BOTTOM w0.119: v1(310.01,137.16) UNK4K43.3
D10712: length 385
  TOP w0.086: SITE4.76 343.98,188.43 344.06,188.35 357.07,188.35 v1(357.52,188.8)
  L05_SIGNAL w0.071: v1(343.47,131.3) 343.47,131.7 343.4,131.77 342.71,131.77 341.93,132.56 341.93,133.73 343.24,135.04 344.62,135.04 345.53,134.13 345.53,130.76 343.86,129.1 333.51,129.1 332.42,130.19 307.08,130.19 304.68,127.78 304.68,110.25 316.38,98.54 347.78,98.54 348.73,99.5 351.83,99.5 354.4,96.93 354.4,47.88 359.91,42.37 427.78,42.37 433.68,48.27 433.68,58.05 429.56,62.17 407.47,62.17 406.54,61.23 406.54,60.82 D107.12
  L32_SIGNAL w0.071: v1(343.47,131.3) 343.47,131.7 343.54,131.77 344.26,131.77 344.62,132.13 344.62,136.24 352.85,144.46 352.85,154.35 359.26,160.77 359.26,187.74 358.67,188.33 357.59,188.33 357.52,188.4 v1(357.52,188.8)
D10713: length 353.4
  TOP w0.086: SITE4.6 324.23,171.48 324.15,171.4 324.15,170.57 319.24,165.66 319.24,162.51 v1(319.69,162.06)
  L03_SIGNAL w0.071: v1(391.43,142.68) 391.03,142.68 390.96,142.61 390.96,141.62 398.8,133.78 398.8,129.59 430.86,97.54 454.51,97.54 455.5,98.53 455.5,99.6 454.47,100.62 433.75,100.62 432.98,101.39 432.98,102.71 433.8,103.53 460.58,103.53 466.48,97.63 466.48,53.96 462.94,50.41 414.72,50.41 413.27,51.86 413.27,54.09 D107.13
  L30_SIGNAL w0.071: v1(319.69,162.06) 319.29,162.06 319.22,161.99 319.22,153.82 320.93,152.12 330.5,152.12 331.58,153.19 356.65,153.19 357.58,152.26 371.89,152.26 378.54,145.61 389.67,145.61 390.96,144.31 390.96,142.76 391.03,142.68 v1(391.43,142.68)
