# Allegro board 8880F5-0830.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D30504: length 192.4
  TOP w0.147: D305.04 386.47,91.05 arc(386.31,91.29) 386.25,91.57 386.25,93.61 arc(386.28,93.74) 386.35,93.85 387.66,95.16 arc(387.77,95.24) 387.9,95.26 394.19,95.26 arc(394.56,95.34) 394.87,95.54 395.57,96.24 arc(396.15,97.12) 396.36,98.15 396.36,98.15 arc(396.11,99.43) 395.38,100.51 395.03,100.86 arc(394.52,101.2) 393.91,101.32 387.5,101.32 arc(387.37,101.35) 387.26,101.42 386.44,102.24 arc(386.37,102.35) 386.34,102.48 386.34,118.01 arc(386.29,118.29) 386.13,118.53 370.72,133.94 arc(370.64,134.05) 370.62,134.19 370.62,149.87 arc(370.56,150.16) 370.4,150.39 363.86,156.94 arc(363.78,157.05) 363.76,157.18 363.76,203.61 arc(363.7,203.9) 363.54,204.14 355.79,211.89 arc(355.61,212.01) 355.4,212.05 340.76,212.05 arc(340.24,212.16) 339.8,212.45 332.73,219.52 arc(332.65,219.63) 332.63,219.76 332.63,231.32 332.63,231.33 SITE2.27
D30506: length 192.4
  TOP w0.147: D305.06 395.8,91 arc(395.96,91.24) 396.01,91.52 396.01,93.35 arc(396.07,93.64) 396.23,93.88 397.9,95.55 arc(398.14,95.71) 398.42,95.77 403,95.77 arc(403.23,95.81) 403.43,95.95 404.01,96.52 arc(404.38,97.08) 404.51,97.73 404.51,98.2 arc(404.31,99.21) 403.74,100.07 arc(403.24,100.4) 402.65,100.52 398.73,100.52 arc(398.45,100.57) 398.21,100.73 396.16,102.78 arc(396,103.02) 395.94,103.3 395.94,110.85 arc(395.92,110.98) 395.84,111.09 373.28,133.65 arc(373.12,133.89) 373.07,134.17 373.07,150.26 arc(373.04,150.39) 372.97,150.5 365.78,157.69 arc(365.62,157.93) 365.56,158.21 365.56,204.16 arc(365.54,204.29) 365.46,204.4 356.18,213.68 arc(356.07,213.75) 355.94,213.78 341.07,213.78 arc(340.79,213.83) 340.55,213.99 333.65,220.9 arc(333.49,221.14) 333.43,221.42 333.43,231.32 333.43,231.33 SITE2.29
D30508: length 192.4
  TOP w0.147: D305.08 396.63,91.05 arc(396.47,91.29) 396.41,91.58 396.41,93.35 arc(396.44,93.48) 396.51,93.6 398.18,95.27 arc(398.29,95.34) 398.42,95.37 403,95.37 arc(403.39,95.45) 403.71,95.67 404.29,96.24 arc(404.75,96.93) 404.91,97.73 404.91,98.2 arc(404.68,99.36) 404.02,100.35 404.02,100.35 arc(403.39,100.76) 402.65,100.91 398.73,100.91 arc(398.6,100.94) 398.49,101.01 396.44,103.06 arc(396.37,103.17) 396.34,103.3 396.34,110.85 arc(396.28,111.13) 396.12,111.37 373.56,133.93 arc(373.49,134.04) 373.46,134.17 373.46,150.26 arc(373.41,150.54) 373.25,150.78 366.06,157.97 arc(365.98,158.08) 365.96,158.21 365.96,204.16 arc(365.9,204.44) 365.74,204.68 356.46,213.96 arc(356.22,214.12) 355.94,214.17 341.07,214.17 arc(340.94,214.2) 340.83,214.27 333.93,221.18 arc(333.85,221.29) 333.83,221.42 333.83,231.32 333.83,231.33 SITE2.30
D30510: length 192.4
  TOP w0.147: D305.10 405.97,91.01 arc(406.13,91.25) 406.19,91.53 406.19,94.3 arc(406.25,94.61) 406.42,94.87 407.29,95.74 arc(407.55,95.91) 407.86,95.97 410.79,95.97 arc(411.11,96.04) 411.38,96.22 arc(411.86,96.94) 412.03,97.79 412.03,97.79 arc(411.82,98.82) 411.24,99.69 arc(410.82,99.97) 410.32,100.07 407.7,100.07 arc(407.42,100.12) 407.18,100.28 406.33,101.13 arc(406.17,101.37) 406.12,101.65 406.12,103.38 arc(406.09,103.51) 406.02,103.62 376.2,133.44 arc(376.04,133.68) 375.98,133.97 375.98,151.27 arc(375.95,151.4) 375.88,151.51 368.14,159.26 arc(367.98,159.49) 367.92,159.78 367.92,205.65 arc(367.9,205.78) 367.82,205.89 358.11,215.6 arc(358,215.68) 357.87,215.7 342.53,215.7 arc(342.25,215.76) 342.01,215.92 338.61,219.32 arc(338.45,219.56) 338.4,219.84 338.4,225.54 arc(338.37,225.67) 338.3,225.79 334.85,229.24 arc(334.69,229.47) 334.63,229.76 334.63,231.32 334.63,231.33 SITE2.32
D30512: length 192.4
  TOP w0.147: D305.12 406.8,91.04 arc(406.64,91.28) 406.58,91.56 406.58,94.3 arc(406.61,94.46) 406.71,94.59 407.57,95.46 arc(407.7,95.55) 407.86,95.58 410.79,95.58 arc(411.26,95.67) 411.66,95.94 arc(412.22,96.79) 412.42,97.79 412.42,97.79 arc(412.19,98.97) 411.52,99.97 411.52,99.97 arc(410.97,100.34) 410.32,100.46 407.7,100.46 arc(407.57,100.49) 407.46,100.56 406.61,101.41 arc(406.54,101.52) 406.51,101.65 406.51,103.38 arc(406.46,103.67) 406.3,103.9 376.48,133.72 arc(376.4,133.84) 376.38,133.97 376.38,151.27 arc(376.32,151.56) 376.16,151.79 368.42,159.54 arc(368.35,159.65) 368.32,159.78 368.32,205.65 arc(368.26,205.93) 368.1,206.17 358.39,215.88 arc(358.15,216.04) 357.87,216.1 342.53,216.1 arc(342.4,216.12) 342.29,216.2 338.89,219.6 arc(338.82,219.71) 338.79,219.84 338.79,225.54 arc(338.74,225.83) 338.58,226.07 335.13,229.52 arc(335.05,229.63) 335.03,229.76 335.03,231.32 335.03,231.33 SITE2.33
D30514: length 192.4
  TOP w0.147: D305.14 416.14,91.02 arc(416.3,91.26) 416.36,91.54 416.36,103.65 arc(416.2,104.46) 415.74,105.14 395.38,125.5 arc(394.7,125.95) 393.9,126.11 386.49,126.11 arc(386.21,126.17) 385.97,126.33 379.06,133.24 arc(378.9,133.48) 378.85,133.76 378.85,152.17 arc(378.82,152.3) 378.75,152.41 370.57,160.58 arc(370.41,160.82) 370.36,161.11 370.36,206.58 arc(370.33,206.71) 370.26,206.82 359.55,217.53 arc(359.44,217.61) 359.3,217.63 344.01,217.63 arc(343.73,217.69) 343.49,217.85 340.99,220.35 arc(340.83,220.59) 340.77,220.87 340.77,225.87 arc(340.75,226) 340.67,226.11 335.83,230.95 335.83,231.32 335.83,231.33 SITE2.35
D30516: length 192.4
  TOP w0.147: D305.16 416.97,91.03 arc(416.81,91.27) 416.76,91.55 416.76,103.65 arc(416.57,104.61) 416.03,105.42 395.66,125.78 arc(394.86,126.32) 393.9,126.51 386.49,126.51 arc(386.36,126.54) 386.25,126.61 379.34,133.52 arc(379.27,133.63) 379.24,133.76 379.24,152.17 arc(379.19,152.45) 379.03,152.69 370.85,160.86 arc(370.78,160.98) 370.75,161.11 370.75,206.58 arc(370.7,206.86) 370.54,207.1 359.83,217.81 arc(359.59,217.97) 359.3,218.03 344.01,218.03 arc(343.88,218.05) 343.77,218.13 341.27,220.63 arc(341.2,220.74) 341.17,220.87 341.17,225.87 arc(341.11,226.15) 340.95,226.39 336.23,231.12 336.23,231.32 336.23,231.33 SITE2.36
D31702: length 192.4
  TOP w0.147: SITE3.26 252.23,171.33 252.23,171.32 252.23,154.59 arc(252.21,154.46) 252.13,154.35 250.01,152.23 arc(249.88,152.14) 249.72,152.11 233.3,152.11 arc(233.05,152.06) 232.83,151.91 228.47,147.55 arc(228.31,147.31) 228.26,147.03 228.26,141.47 arc(228.23,141.34) 228.16,141.23 224.1,137.17 arc(223.99,137.1) 223.86,137.07 202.36,137.07 arc(202.08,137.01) 201.84,136.86 192.32,127.33 arc(192.21,127.26) 192.08,127.23 157.34,127.23 arc(157.06,127.18) 156.82,127.02 155.37,125.56 arc(155.21,125.32) 155.15,125.04 155.15,109.59 arc(155.21,109.31) 155.37,109.07 157.29,107.15 arc(157.52,107) 157.81,106.94 163.56,106.94 arc(163.69,106.91) 163.8,106.84 164.81,105.83 arc(164.89,105.72) 164.91,105.59 164.91,104.5 arc(164.89,104.37) 164.81,104.26 163.74,103.19 arc(163.63,103.11) 163.5,103.09 157.16,103.09 arc(156.58,102.97) 156.08,102.64 156.03,102.59 arc(155.13,101.25) 154.82,99.67 arc(155.07,98.39) 155.8,97.31 156.47,96.63 arc(156.71,96.47) 157,96.42 163.78,96.42 arc(163.91,96.39) 164.03,96.32 164.81,95.53 arc(164.89,95.42) 164.91,95.29 164.91,91.56 arc(164.86,91.27) 164.7,91.04 D317.02
D31704: length 192.4
  TOP w0.147: D317.04 165.52,91.02 arc(165.36,91.26) 165.31,91.54 165.31,95.29 arc(165.25,95.57) 165.09,95.81 164.31,96.6 arc(164.07,96.76) 163.78,96.81 157,96.81 arc(156.86,96.84) 156.75,96.91 156.08,97.59 arc(155.44,98.54) 155.22,99.67 arc(155.5,101.1) 156.31,102.31 156.36,102.36 arc(156.73,102.61) 157.16,102.69 163.5,102.69 arc(163.78,102.75) 164.02,102.91 165.09,103.98 arc(165.25,104.22) 165.31,104.5 165.31,105.59 arc(165.25,105.87) 165.09,106.11 164.08,107.12 arc(163.84,107.28) 163.56,107.34 157.81,107.34 arc(157.68,107.36) 157.57,107.44 155.65,109.35 arc(155.58,109.46) 155.55,109.59 155.55,125.04 arc(155.58,125.17) 155.65,125.28 157.1,126.73 arc(157.21,126.81) 157.34,126.83 192.08,126.83 arc(192.36,126.89) 192.6,127.05 202.12,136.58 arc(202.23,136.65) 202.36,136.67 223.86,136.67 arc(224.14,136.73) 224.38,136.89 228.44,140.95 arc(228.6,141.18) 228.65,141.47 228.65,147.03 arc(228.68,147.16) 228.75,147.27 233.11,151.63 arc(233.2,151.69) 233.3,151.71 249.72,151.71 arc(250.03,151.77) 250.29,151.95 252.41,154.07 arc(252.57,154.31) 252.63,154.59 252.63,171.32 252.63,171.33 SITE3.27
D31706: length 192.4
  TOP w0.147: SITE3.29 253.43,171.33 253.43,171.32 253.43,167.46 arc(253.49,167.18) 253.65,166.94 254.62,165.97 arc(254.69,165.86) 254.72,165.73 254.72,153.91 arc(254.69,153.78) 254.62,153.67 250.73,149.78 arc(250.62,149.71) 250.49,149.68 234.4,149.68 arc(234.12,149.63) 233.88,149.47 230.88,146.47 arc(230.72,146.23) 230.67,145.95 230.67,140.34 arc(230.64,140.21) 230.57,140.1 225.29,134.82 arc(225.18,134.75) 225.05,134.72 202.88,134.72 arc(202.6,134.67) 202.36,134.51 193.09,125.24 arc(192.98,125.17) 192.85,125.14 159.57,125.14 arc(159.29,125.08) 159.05,124.93 157.66,123.54 arc(157.5,123.3) 157.45,123.02 157.45,111.6 arc(157.5,111.32) 157.66,111.08 159.28,109.46 arc(159.52,109.3) 159.81,109.24 172.43,109.24 arc(172.56,109.22) 172.67,109.14 174.97,106.84 arc(175.04,106.73) 175.07,106.6 175.07,104.63 arc(175.04,104.5) 174.97,104.39 173.61,103.04 arc(173.5,102.96) 173.37,102.94 170.84,102.94 arc(170.14,102.8) 169.55,102.4 169.41,102.26 arc(168.5,100.07) 169.41,97.88 170.08,97.21 arc(170.32,97.05) 170.6,96.99 173.7,96.99 arc(173.83,96.97) 173.95,96.89 174.97,95.87 arc(175.04,95.76) 175.07,95.63 175.07,91.55 arc(175.01,91.27) 174.85,91.03 D317.06
D31708: length 192.4
  TOP w0.147: D317.08 175.68,91.02 arc(175.52,91.26) 175.46,91.54 175.46,95.63 arc(175.41,95.91) 175.25,96.15 174.23,97.17 arc(173.99,97.33) 173.7,97.39 170.6,97.39 arc(170.47,97.41) 170.36,97.49 169.69,98.16 arc(168.9,100.07) 169.69,101.98 169.83,102.12 arc(170.29,102.43) 170.84,102.54 173.37,102.54 arc(173.66,102.6) 173.89,102.76 175.25,104.11 arc(175.41,104.35) 175.46,104.63 175.46,106.6 arc(175.41,106.88) 175.25,107.12 172.95,109.42 arc(172.71,109.58) 172.43,109.64 159.81,109.64 arc(159.67,109.67) 159.56,109.74 157.94,111.36 arc(157.87,111.47) 157.84,111.6 157.84,123.02 arc(157.87,123.15) 157.94,123.26 159.33,124.64 arc(159.44,124.72) 159.57,124.74 192.85,124.74 arc(193.13,124.8) 193.37,124.96 202.64,134.23 arc(202.75,134.3) 202.88,134.33 225.05,134.33 arc(225.33,134.38) 225.57,134.54 230.85,139.82 arc(231.01,140.05) 231.06,140.34 231.06,145.95 arc(231.09,146.08) 231.16,146.19 234.16,149.19 arc(234.27,149.26) 234.4,149.29 250.49,149.29 arc(250.77,149.34) 251.01,149.5 254.9,153.39 arc(255.06,153.63) 255.11,153.91 255.11,165.73 arc(255.06,166.01) 254.9,166.25 253.93,167.22 arc(253.85,167.33) 253.83,167.46 253.83,171.32 253.83,171.33 SITE3.30
D31710: length 192.4
  TOP w0.147: D317.10 184.98,91 arc(185.14,91.24) 185.2,91.52 185.2,106.54 arc(185.17,106.67) 185.1,106.78 180.38,111.49 arc(180.27,111.57) 180.14,111.59 161,111.59 arc(160.71,111.65) 160.47,111.81 159.94,112.35 arc(159.78,112.59) 159.72,112.87 159.72,121.35 arc(159.78,121.63) 159.94,121.87 160.53,122.46 arc(160.77,122.62) 161.05,122.68 193.81,122.68 arc(193.94,122.71) 194.05,122.78 203.26,131.99 arc(203.5,132.15) 203.78,132.21 226.63,132.21 arc(227.74,132.43) 228.68,133.05 232.15,136.52 arc(232.78,137.46) 233,138.57 233,138.57 233,144.66 arc(233.06,144.94) 233.21,145.18 235.06,147.02 arc(235.3,147.18) 235.58,147.24 251.91,147.24 arc(252.04,147.26) 252.15,147.34 258.03,153.22 arc(258.11,153.33) 258.13,153.46 258.13,166.26 arc(258.11,166.39) 258.03,166.5 254.85,169.69 arc(254.69,169.93) 254.63,170.21 254.63,171.32 254.63,171.33 SITE3.32
D31712: length 192.4
  TOP w0.147: SITE3.33 255.03,171.33 255.03,171.32 255.03,170.21 arc(255.05,170.08) 255.13,169.97 258.31,166.79 arc(258.47,166.55) 258.53,166.26 258.53,153.46 arc(258.47,153.18) 258.31,152.94 252.43,147.06 arc(252.19,146.9) 251.91,146.84 235.58,146.84 arc(235.45,146.82) 235.34,146.74 233.5,144.9 arc(233.42,144.79) 233.4,144.66 233.4,138.57 arc(233.15,137.31) 232.43,136.24 228.96,132.77 arc(227.89,132.06) 226.63,131.81 203.78,131.81 arc(203.65,131.78) 203.54,131.71 194.33,122.5 arc(194.09,122.34) 193.81,122.28 161.05,122.28 arc(160.92,122.26) 160.81,122.18 160.22,121.59 arc(160.14,121.48) 160.12,121.35 160.12,112.87 arc(160.14,112.74) 160.22,112.63 160.75,112.09 arc(160.87,112.01) 161,111.99 180.14,111.99 arc(180.42,111.93) 180.66,111.77 185.38,107.06 arc(185.54,106.82) 185.6,106.54 185.6,91.57 arc(185.65,91.29) 185.81,91.05 D317.12
D31714: length 192.4
  TOP w0.147: D317.14 195.14,91 arc(195.3,91.24) 195.36,91.52 195.36,99.55 arc(195.33,99.68) 195.26,99.79 181.22,113.83 arc(181.11,113.9) 180.98,113.93 164.32,113.93 arc(164.03,113.98) 163.79,114.14 163.21,114.72 arc(163.05,114.96) 163,115.24 163,118.79 arc(163.05,119.07) 163.21,119.31 164.03,120.12 arc(164.27,120.28) 164.55,120.34 195.52,120.34 arc(195.65,120.36) 195.76,120.44 205.36,130.04 arc(205.6,130.2) 205.88,130.25 228.64,130.25 arc(229.73,130.47) 230.66,131.09 234.67,135.09 arc(235.28,136.02) 235.5,137.11 235.5,143.23 arc(235.56,143.51) 235.72,143.75 237.01,145.04 arc(237.25,145.2) 237.53,145.26 253.04,145.26 arc(253.17,145.29) 253.28,145.36 260.49,152.56 arc(260.56,152.67) 260.59,152.8 260.59,165.95 arc(260.56,166.08) 260.49,166.19 255.99,170.69 arc(255.87,170.87) 255.83,171.08 255.83,171.32 255.83,171.33 SITE3.35
D31716: length 192.4
  TOP w0.147: D317.16 195.97,91.05 arc(195.81,91.29) 195.75,91.57 195.75,99.55 arc(195.7,99.83) 195.54,100.07 181.5,114.11 arc(181.26,114.27) 180.98,114.32 164.32,114.32 arc(164.18,114.35) 164.07,114.42 163.49,115 arc(163.42,115.11) 163.39,115.24 163.39,118.79 arc(163.42,118.92) 163.49,119.03 164.31,119.84 arc(164.42,119.92) 164.55,119.94 195.52,119.94 arc(195.8,120) 196.04,120.16 205.64,129.76 arc(205.75,129.83) 205.88,129.85 228.64,129.85 arc(229.88,130.1) 230.94,130.81 234.95,134.81 arc(235.65,135.87) 235.9,137.11 235.9,143.23 arc(235.92,143.36) 236,143.47 237.29,144.76 arc(237.4,144.84) 237.53,144.86 253.04,144.86 arc(253.33,144.92) 253.57,145.08 260.77,152.28 arc(260.93,152.52) 260.98,152.8 260.98,165.95 arc(260.93,166.24) 260.77,166.48 256.27,170.97 arc(256.24,171.02) 256.23,171.08 256.23,171.32 256.23,171.33 SITE3.36
D32102: length 192.4
  TOP w0.147: D321.02 238.38,91.06 arc(238.54,91.3) 238.59,91.58 238.59,98.62 arc(238.65,98.9) 238.81,99.14 286.48,146.81 arc(286.55,146.92) 286.58,147.05 286.58,206.14 arc(286.47,206.69) 286.16,207.15 282.19,211.12 arc(281.72,211.43) 281.18,211.54 259.33,211.54 arc(259.04,211.6) 258.81,211.76 252.45,218.11 arc(252.29,218.35) 252.23,218.64 252.23,231.32 252.23,231.33 SITE1.26
D32104: length 192.4
  TOP w0.147: SITE1.27 252.63,231.33 252.63,231.32 252.63,218.64 arc(252.65,218.51) 252.73,218.39 259.09,212.04 arc(259.2,211.96) 259.33,211.94 281.18,211.94 arc(281.88,211.8) 282.47,211.4 286.44,207.43 arc(286.84,206.84) 286.98,206.14 286.98,147.05 arc(286.92,146.77) 286.76,146.53 239.09,98.86 arc(239.01,98.75) 238.99,98.62 238.99,91.52 arc(239.04,91.23) 239.2,91 D321.04
D32106: length 192.4
  TOP w0.147: SITE1.29 253.43,231.33 253.43,231.32 253.43,221.34 arc(253.49,221.06) 253.65,220.82 260.72,213.75 arc(260.95,213.59) 261.24,213.54 282.95,213.54 arc(283.08,213.51) 283.19,213.44 288.87,207.76 arc(288.94,207.65) 288.97,207.52 288.97,146.11 arc(288.94,145.98) 288.87,145.87 248.9,105.91 arc(248.74,105.67) 248.69,105.39 248.69,104.2 arc(248.74,103.92) 248.9,103.68 251.97,100.62 arc(252.4,99.97) 252.55,99.2 252.55,99.08 arc(252.4,98.31) 251.97,97.66 248.95,94.64 arc(248.79,94.4) 248.74,94.12 248.74,91.56 arc(248.68,91.28) 248.52,91.04 D321.06
D32108: length 192.4
  TOP w0.147: D321.08 249.35,91.01 arc(249.19,91.25) 249.13,91.53 249.13,94.12 arc(249.16,94.25) 249.23,94.36 252.25,97.38 arc(252.77,98.16) 252.95,99.08 252.95,99.2 arc(252.77,100.12) 252.25,100.9 249.18,103.96 arc(249.11,104.07) 249.08,104.2 249.08,105.39 arc(249.11,105.52) 249.18,105.63 289.15,145.59 arc(289.31,145.83) 289.36,146.11 289.36,207.52 arc(289.31,207.8) 289.15,208.04 283.47,213.72 arc(283.23,213.88) 282.95,213.93 261.24,213.93 arc(261.11,213.96) 261,214.03 253.93,221.1 arc(253.85,221.21) 253.83,221.34 253.83,231.32 253.83,231.33 SITE1.30
D32110: length 192.4
  TOP w0.147: SITE1.32 254.63,231.33 254.63,231.32 254.63,229.68 arc(254.69,229.4) 254.85,229.16 258.13,225.88 arc(258.2,225.77) 258.23,225.64 258.23,220.21 arc(258.29,219.93) 258.45,219.69 262.34,215.8 arc(262.58,215.64) 262.86,215.58 285.09,215.58 arc(285.22,215.55) 285.33,215.48 291.24,209.57 arc(291.31,209.46) 291.34,209.33 291.34,144.47 arc(291.31,144.34) 291.24,144.23 259.08,112.07 arc(258.92,111.83) 258.86,111.55 258.86,103.77 arc(258.92,103.49) 259.08,103.25 260.09,102.24 arc(260.33,102.08) 260.61,102.02 261.58,102.02 arc(262.25,101.89) 262.82,101.51 arc(263.2,100.94) 263.34,100.27 263.34,98.31 arc(263.23,97.75) 262.91,97.28 262.84,97.21 arc(262.36,96.89) 261.8,96.78 261.07,96.78 arc(260.79,96.72) 260.55,96.56 259.08,95.09 arc(258.92,94.85) 258.86,94.57 258.86,91.53 arc(258.81,91.25) 258.65,91.01 D321.10
D32112: length 192.4
  TOP w0.147: SITE1.33 255.03,231.33 255.03,231.32 255.03,229.68 arc(255.05,229.55) 255.13,229.44 258.41,226.16 arc(258.57,225.92) 258.63,225.64 258.63,220.21 arc(258.65,220.08) 258.73,219.97 262.62,216.08 arc(262.73,216) 262.86,215.98 285.09,215.98 arc(285.37,215.92) 285.61,215.76 291.52,209.85 arc(291.68,209.61) 291.74,209.33 291.74,144.47 arc(291.68,144.19) 291.52,143.95 259.36,111.79 arc(259.29,111.68) 259.26,111.55 259.26,103.77 arc(259.29,103.64) 259.36,103.53 260.37,102.52 arc(260.48,102.45) 260.61,102.42 261.58,102.42 arc(262.41,102.26) 263.1,101.79 arc(263.57,101.09) 263.73,100.27 263.73,98.31 arc(263.59,97.6) 263.19,97 263.12,96.93 arc(262.51,96.52) 261.8,96.38 261.07,96.38 arc(260.94,96.35) 260.83,96.28 259.36,94.81 arc(259.29,94.7) 259.26,94.57 259.26,91.56 arc(259.32,91.28) 259.48,91.04 D321.12
D32114: length 192.4
  TOP w0.147: SITE1.35 255.83,231.33 255.83,231.32 255.83,231.2 arc(255.88,230.97) 256.01,230.77 260.62,226.16 arc(260.7,226.05) 260.72,225.92 260.72,221.41 arc(260.78,221.13) 260.94,220.89 264.07,217.75 arc(264.31,217.59) 264.6,217.54 286.83,217.54 arc(286.96,217.51) 287.07,217.44 293.83,210.68 arc(293.9,210.57) 293.93,210.44 293.93,144.28 arc(293.9,144.15) 293.83,144.04 269.26,119.47 arc(269.1,119.23) 269.04,118.95 269.04,104.17 arc(269.1,103.89) 269.26,103.65 270.56,102.34 arc(270.8,102.18) 271.08,102.13 273.29,102.13 arc(273.42,102.1) 273.53,102.03 274.2,101.36 arc(274.81,100.45) 275.02,99.37 275.02,98.96 arc(274.81,97.88) 274.2,96.97 273.69,96.47 arc(273.58,96.39) 273.45,96.37 270.69,96.37 arc(270.41,96.31) 270.17,96.15 269.26,95.23 arc(269.1,95) 269.04,94.71 269.04,91.55 arc(268.98,91.26) 268.82,91.02 D321.14
D32116: length 192.4
  TOP w0.147: D321.16 269.65,91.03 arc(269.49,91.27) 269.44,91.55 269.44,94.71 arc(269.46,94.84) 269.54,94.95 270.45,95.87 arc(270.56,95.94) 270.69,95.97 273.45,95.97 arc(273.73,96.02) 273.97,96.18 274.48,96.69 arc(275.18,97.73) 275.42,98.96 275.42,99.37 arc(275.18,100.6) 274.48,101.64 273.81,102.31 arc(273.57,102.47) 273.29,102.52 271.08,102.52 arc(270.95,102.55) 270.84,102.62 269.54,103.93 arc(269.46,104.04) 269.44,104.17 269.44,118.95 arc(269.46,119.08) 269.54,119.19 294.11,143.76 arc(294.27,144) 294.32,144.28 294.32,210.44 arc(294.27,210.72) 294.11,210.96 287.35,217.72 arc(287.11,217.88) 286.83,217.93 264.6,217.93 arc(264.47,217.96) 264.35,218.03 261.22,221.17 arc(261.14,221.28) 261.12,221.41 261.12,225.92 arc(261.06,226.2) 260.9,226.44 256.29,231.06 arc(256.24,231.12) 256.23,231.2 256.23,231.32 256.23,231.33 SITE1.36
Net_654: length 3
  BOTTOM w0.119: 192.47,190.12 194.3,190.12 194.78,190.59 195.26,190.59
Net_655: length 3
  BOTTOM w0.119: 192.47,187.92 194.3,187.92 194.78,187.45 195.26,187.45
S1_1AUX+:
  vias: v1(221.73,229.11)
S1_1AUX-:
  vias: v1(218.45,229.11)
S1_2AUX+:
  vias: v1(184.65,132.33) v1(184.65,131.06) v1(220.73,229.11) v1(220.73,227.84)
S1_2AUX-:
  vias: v1(181.11,131.06) v1(182.11,132.33) v1(219.45,229.11) v1(219.45,227.84)
S1_AUX_100DCH002+:
  vias: v1(183.65,132.33)
S1_AUX_100DCH002-:
  vias: v1(181.11,132.33)
S1_AUXCH+: length 3.6
  TOP w0.203: SITE1.21 250.23,236.2 v2(250.6,236.57)
S1_AUXCH-: length 3.6
  TOP w0.203: v2(249.46,236.57) 249.83,236.2 SITE1.20
S1_AVDD11_RX: length 8.4
  TOP w0.231: SITE1.31 254.23,228.29 254.67,227.85
  TOP w0.508: v1(256.77,225.75) 254.67,227.85
  vias: v1(158.96,294) v1(158.96,292.1) v1(256.77,223.71)
S1_AVDD11_XTAL: length 8.8
  TOP w0.231: SITE1.105 253.03,260.95 252.87,261.11 252.87,261.45
  TOP w0.381: 252.87,261.45 252.87,263.59 253.72,264.44 v1(253.72,264.54)
  vias: v1(201.21,277.5) v1(201.21,275.59) v1(253.72,266.58)
S1_AVDD18_RX: length 7.7
  TOP w0.231: 251.28,230.01 251.83,230.56 SITE1.25
  TOP w0.508: v1(251.06,225.75) 251.06,228.68 251.28,228.9 251.28,230.01
  vias: v1(168.7,294) v1(168.7,292.1) v1(251.06,223.71)
S1_DCH041: length 2.2
  TOP w0.231: v1(237.23,243.03) 237.43,242.83 SITE1.159
S1_DCH042: length 3.7
  TOP w0.231: SITE1.160 236.43,242.43 v1(235.83,243.03)
S1_DCH043: length 5.3
  TOP w0.231: v1(234.44,243.03) 235.44,242.03 SITE1.161
S1_DCH044: length 2.2
  TOP w0.231: v1(237.23,241.03) 237.43,241.23 SITE1.163
S1_DCH045: length 5.4
  TOP w0.231: SITE1.164 243.35,240.83 v1(244.35,239.83)
S1_DCH046: length 3.9
  TOP w0.231: SITE1.165 242.35,240.43 v1(242.95,239.83)
S1_DCH047: length 2.3
  TOP w0.231: SITE1.166 241.36,240.03 v1(241.56,239.83)
S1_DCH048:
  vias: v1(229.05,276.97)
S1_DCH049:
  vias: v1(229.05,271.67)
S1_DPS_F_001:
  vias: v1(101.29,249.52) v1(101.29,247.61) v1(182.11,131.06) v1(221.73,227.84)
S1_DPS_F_002: length 10.1
  TOP w0.231: SITE1.3 243.03,230.86 241.72,229.55 240.65,229.55
  TOP w0.508: v1(237.98,225.75) 237.98,226.88 240.65,229.55
  vias: v1(185.21,294) v1(185.21,292.1) v1(236.32,222.9) v1(237.98,223.71)
S1_DPS_F_003: length 63.1
  TOP w0.231: SITE1.71 266.94,246.43 267.84,245.53 ; SITE1.145 233.08,248.43 232.83,248.18 ; 251.69,261.16 251.69,260.65 252.23,260.11 SITE1.107 ; SITE1.63 264.9,243.23 265.2,242.93 ; 259.73,229.66 258.57,229.66 256.63,231.59 SITE1.37 ; SITE1.17 248.63,229.5 249.28,228.85 ; 234.63,241.63 SITE1.162
  TOP w0.381: 251.69,261.16 251.69,264.28 v1(251.94,264.54)
  TOP w0.508: v1(262.36,225.75) 262.36,227.02 259.73,229.66 ; v1(249.28,225.75) 249.28,228.85 ; 267.84,245.53 269.46,243.91 v1(271.22,243.91) ; v1(231.44,247.93) 232.58,247.93 232.83,248.18 ; v1(231.44,243.41) 232.59,243.41 234.37,241.63 234.63,241.63 ; v1(271.22,241.37) 268.11,241.37 266.8,242.67 265.45,242.67 265.2,242.93
  vias: v1(114.29,230.12) v1(175.47,294) v1(175.47,292.1) v1(229.4,247.93) v1(229.4,243.41) v1(249.28,223.71) v1(251.54,252.61) v1(251.94,266.58) v1(262.36,223.71) v1(273.27,243.91) v1(273.27,243.91) v1(273.27,241.37) v1(273.27,241.37)
S1_DPS_F_006: length 9.6
  TOP w0.231: 268.55,246.19 267.92,246.83 SITE1.72
  TOP w0.508: 268.55,246.19 269.56,245.18 v1(271.22,245.18)
  vias: v1(168.7,277.5) v1(168.7,275.59) v1(259,246.67) v1(273.27,245.18) v1(273.27,245.18)
S1_DPS_F_007: length 19.1
  TOP w0.231: 264.37,249.01 264.15,249.23 SITE1.78 ; v1(259.65,264.54) 259.65,264.13 256.23,260.71 SITE1.97
  TOP w0.508: v1(271.22,249.5) 270.8,249.5 270.31,249.01 264.37,249.01
  BOTTOM w0.119: CC27.1 v1(273.27,249.5)
  vias: v1(185.21,277.5) v1(185.21,275.59) v1(259.65,266.58)
S1_DPS_F_009: length 8.8
  TOP w0.231: 252.26,261.12 252.26,260.9 252.63,260.53 SITE1.106
  TOP w0.381: v1(252.83,264.54) 252.83,264.39 252.26,263.82 252.26,261.12
  vias: v1(201.21,294) v1(201.21,292.1) v1(252.83,266.58) v1(253.61,267.66)
S1_DPS_F_010: length 8.6
  TOP w0.231: SITE1.111 250.63,260.15 251.05,260.57 251.05,261.13
  TOP w0.381: 251.05,261.13 v1(251.05,264.54)
  vias: v1(191.48,294) v1(191.48,292.1) v1(250.34,253.59) v1(251.05,266.58)
S1_DPS_F_011: length 17.6
  TOP w0.231: SITE1.139 234.87,250.83 232.01,253.69 v1(231.44,253.69) ; SITE1.119 247.43,257.79 247.64,258.01
  TOP w0.508: 247.64,258.01 247.64,264.47 v1(247.57,264.54)
  vias: v1(175.47,277.5) v1(175.47,275.59) v1(229.4,253.69) v1(247.57,266.58)
S1_DPS_F_012: length 8
  TOP w0.231: 232.2,248.83 SITE1.144
  TOP w0.508: 232.2,248.83 231.81,248.83 v1(231.44,249.2)
  vias: v1(158.96,277.5) v1(158.96,275.59) v1(229.4,249.2)
S1_DPS_F_013:
  vias: v1(89.53,207.41) v1(89.77,221.18) v1(96.02,215.5) v1(96.12,229.1) v1(96.42,249.57) v1(96.42,247.66) v1(97.27,241.05) v1(97.27,233.43) v1(98.56,215.5) v1(98.66,229.1) v1(101.1,215.5) v1(101.1,203.31) v1(101.2,229.1) v1(101.2,216.91) v1(103.64,203.31) v1(104.64,215.5) v1(104.74,229.1) v1(104.75,216.86) v1(122.12,241.1) v1(126.75,233.43) v1(126.75,225.81)
S1_ISP00+: length 66.2
  TOP w0.086: v1(274.19,245.88) 273.74,246.33 270.29,246.33 269.31,247.31 264.06,247.31 263.98,247.23 SITE1.73
  L30_SIGNAL w0.071: v1(270.04,277.62) 270.04,276.87 269.63,276.45 266.95,276.45 265.91,275.4 265.91,273.73 267.67,271.97 267.67,268.76 265.64,266.73 265.64,265.4 258.89,258.65 258.89,252.17 264.71,246.35 274.12,246.35 274.19,246.28 v1(274.19,245.88)
  BOTTOM w0.119: v1(270.04,277.62) K43.7
S1_ISP00-: length 66.2
  TOP w0.086: SITE1.74 263.98,247.63 264.06,247.55 269.41,247.55 270.39,246.57 273.74,246.57 v1(274.19,247.02)
  L30_SIGNAL w0.071: v1(270.04,274.58) 270.04,276.09 269.88,276.25 267.03,276.25 266.1,275.32 266.1,273.81 267.87,272.05 267.87,268.68 265.84,266.65 265.84,265.32 259.09,258.57 259.09,252.25 264.8,246.55 274.12,246.55 274.19,246.62 v1(274.19,247.02)
  BOTTOM w0.119: v1(270.04,274.58) K43.2
S1_ISP14+: length 66.2
  TOP w0.086: v1(251.93,269.9) 251.48,269.45 251.48,267.92 250.15,266.59 250.15,257.86 250.23,257.78 SITE1.112
  L28_SIGNAL w0.071: v1(265.64,280.1) 265.64,276.16 265.74,276.06 275.88,276.06 277,277.18 277,280.31 275.18,282.12 262.08,282.12 251.46,271.5 251.46,269.97 251.53,269.9 v1(251.93,269.9)
S1_ISP14-: length 66.2
  TOP w0.086: SITE1.113 249.83,257.78 249.91,257.86 249.91,266.69 251.24,268.02 251.24,269.45 v1(250.79,269.9)
  L28_SIGNAL w0.071: v1(250.79,269.9) 251.19,269.9 251.26,269.97 251.26,271.58 262,282.32 275.26,282.32 277.2,280.39 277.2,277.09 275.96,275.86 266.95,275.86 265.64,274.55 v1(265.64,272.1)
S1_ISP_1LOCK:
  vias: v1(229.91,245.39)
S1_M_DPS_F_001: length 45.2
  TOP w0.231: SITE1.39 257.43,231.49 258.54,230.37 260.57,230.37 ; SITE1.147 233.7,247.63 233.24,247.18 ; 250.63,230.54 SITE1.22 ; SITE1.104 253.43,263.21 ; 266.49,243.63 SITE1.64
  TOP w0.381: 253.43,263.21 254.61,264.39 v1(254.61,264.54)
  TOP w0.508: 233.24,247.18 232.72,246.66 v1(231.44,246.66) ; 260.57,230.37 263.63,227.31 v1(263.63,225.75) ; v1(250.17,225.75) 250.17,228.96 250.38,229.17 250.38,230.28 250.63,230.54 ; v1(271.22,242.64) 268.48,242.64 267.49,243.63 266.49,243.63
  vias: v1(118.32,292.74) v1(118.32,290.83) v1(229.4,246.66) v1(250.17,223.71) v1(254.61,266.58) v1(263.63,223.71) v1(273.27,242.64) v1(273.27,242.64)
S1_PS9G_DCH001: length 3.7
  TOP w0.231: v1(249.63,229.63) 249.03,230.23 SITE1.18
S1_PS9G_DCH002: length 2.2
  TOP w0.231: SITE1.19 249.43,231.23 v1(249.63,231.03)
S1_PS9G_DCH003: length 2.2
  TOP w0.231: SITE1.24 251.43,231.23 v1(251.23,231.03)
S1_PS9G_DCH004: length 2.2
  TOP w0.231: SITE1.40 257.83,235.03 v1(257.63,235.23)
S1_PS9G_DCH005: length 2.2
  TOP w0.231: v1(264.43,235.83) 264.23,236.03 SITE1.45
S1_PS9G_DCH006: length 3.7
  TOP w0.231: v1(265.83,235.83) 265.23,236.43 SITE1.46
S1_PS9G_DCH007: length 5.3
  TOP w0.231: SITE1.47 266.22,236.83 v1(267.23,235.83)
S1_PS9G_DCH009: length 2.2
  TOP w0.231: v1(264.43,237.43) 264.23,237.63 SITE1.49
S1_PS9G_DCH010: length 3.7
  TOP w0.231: v1(265.83,237.43) 265.23,238.03 SITE1.50
S1_PS9G_DCH011: length 5.3
  TOP w0.231: SITE1.51 266.22,238.43 v1(267.23,237.43)
S1_PS9G_DCH014: length 3.7
  TOP w0.231: v1(265.83,239.03) 265.23,239.63 SITE1.54
S1_PS9G_DCH015: length 5.3
  TOP w0.231: v1(267.23,239.03) 266.22,240.03 SITE1.55
S1_PS9G_DCH022: length 5.3
  TOP w0.231: v1(267.23,245.03) 267.05,245.03 266.05,244.03 SITE1.65
S1_PS9G_DCH023: length 2.5
  TOP w0.231: SITE1.66 264.03,244.43 264.43,244.83 v1(264.43,245.03)
S1_PS9G_DCH027: length 3.9
  TOP w0.231: SITE1.70 264.83,246.03 v1(265.83,245.03)
S1_PS9G_DCH028: length 2.3
  TOP w0.231: SITE1.77 260.6,248.83 v1(260.23,248.46)
S1_PS9G_DCH029: length 2.2
  TOP w0.119: SITE1.118 v1(247.83,253.92)
S1_PS9G_DCH030: length 9.2
  TOP w0.231: v1(230.91,245.39) 232.63,245.39 234.16,246.91 237.3,246.91 237.62,247.23 SITE1.148
S1_PS9G_DCH035: length 5.3
  TOP w0.231: SITE1.153 235.44,245.23 v1(234.44,246.23)
S1_PS9G_DCH036: length 2.2
  TOP w0.231: v1(241.43,245.03) 241.23,244.83 SITE1.154
S1_PS9G_DCH037: length 2.2
  TOP w0.231: SITE1.155 237.43,244.43 v1(237.23,244.63)
S1_PS9G_DCH038: length 3.7
  TOP w0.231: SITE1.156 236.43,244.03 v1(235.83,244.63)
S1_PS9G_DCH039: length 5.3
  TOP w0.231: v1(234.44,244.63) 235.44,243.63 SITE1.157
S1_PS9G_DCH040: length 2.2
  TOP w0.231: v1(241.43,243.43) 241.23,243.23 SITE1.158
S1_RLY_001:
  vias: v1(330.51,288.86) v1(343.98,288.86)
S1_RLY_003:
  vias: v1(293.31,280.1) v1(317.05,288.86)
S1_RLY_005:
  vias: v1(290.64,288.86) v1(303.84,288.86)
S1_RLY_007:
  vias: v1(277.17,288.86)
S1_RLY_008:
  vias: v1(250.5,288.86) v1(263.71,288.86)
S1_RLY_016:
  vias: v1(184.47,264.1) v1(244.8,296.61)
S1_RLY_018:
  vias: v1(232.25,276.97)
S1_RLY_021:
  vias: v1(167.7,264.1) v1(200.98,264.1)
S1_RLY_022:
  vias: v1(184.47,236.67) v1(201.23,236.67)
S1_RLY_023:
  vias: v1(167.7,222.95)
S1_RLY_025:
  vias: v1(184.47,250.38) v1(201.23,250.38)
S1_RLY_026:
  vias: v1(167.7,236.67)
S1_RLY_030:
  vias: v1(167.7,250.38)
S1_RLY_043:
  vias: v1(273.24,280.1)
S1_SCAN_DCH008: length 2.2
  TOP w0.231: v1(260.23,237.03) 260.43,237.23 SITE1.48
S1_SCAN_DCH012: length 2.2
  TOP w0.231: SITE1.52 260.43,238.83 v1(260.23,238.63)
S1_SCAN_DCH013: length 2.2
  TOP w0.231: v1(264.43,239.03) 264.23,239.23 SITE1.53
S1_SCAN_DCH016: length 2.2
  TOP w0.231: v1(260.23,240.23) 260.43,240.43 SITE1.56
S1_SCAN_DCH017: length 2.2
  TOP w0.231: v1(264.43,240.63) 264.23,240.83 SITE1.57
S1_SCAN_DCH018: length 3.7
  TOP w0.231: SITE1.58 265.23,241.23 v1(265.83,240.63)
S1_SCAN_DCH019: length 5.3
  TOP w0.231: SITE1.59 266.22,241.63 v1(267.23,240.63)
S1_SCAN_DCH020: length 2.2
  TOP w0.231: SITE1.60 260.43,242.03 v1(260.23,241.83)
S1_SCAN_DCH021: length 2.2
  TOP w0.231: SITE1.61 264.23,242.43 v1(264.43,242.23)
S1_SCAN_DCH024: length 2.2
  TOP w0.231: SITE1.67 260.43,244.83 v1(260.23,244.63)
S1_SCAN_DCH025: length 3.7
  TOP w0.231: SITE1.68 259.43,245.23 v1(258.83,244.63)
S1_SCAN_DCH026: length 5.3
  TOP w0.231: v1(257.44,244.63) 258.44,245.63 SITE1.69
S1_SCAN_DCH031: length 3.7
  TOP w0.231: SITE1.149 242.23,246.83 v1(242.83,247.43)
S1_SCAN_DCH032: length 5.3
  TOP w0.231: v1(244.22,247.43) 243.22,246.43 SITE1.150
S1_SCAN_DCH033: length 2.2
  TOP w0.231: v1(237.23,246.23) 237.43,246.03 SITE1.151
S1_SCAN_DCH034: length 3.7
  TOP w0.231: v1(235.83,246.23) 236.43,245.63 SITE1.152
S1_SPI_1_CSN:
  vias: v1(104.64,203.31)
S1_SPI_1_SCK:
  vias: v1(99.56,215.5)
S1_SPI_1_SDI:
  vias: v1(123.44,216.92)
S1_SPI_1_SDO:
  vias: v1(123.69,224.54)
S1_SPI_2_CSN:
  vias: v1(103.75,216.86)
S1_SPI_2_SCK:
  vias: v1(99.66,229.1)
S1_SPI_2_SDI:
  vias: v1(128.01,216.92)
S1_SPI_2_SDO:
  vias: v1(127.75,224.54)
S1_SPI_11_SDI:
  vias: v1(102.1,203.31) v1(122.44,216.92)
S1_SPI_11_SDO:
  vias: v1(97.02,215.5) v1(122.69,224.54)
S1_SPI_22_SDI:
  vias: v1(102.2,216.91) v1(127.01,216.92)
S1_SPI_22_SDO:
  vias: v1(97.12,229.1) v1(126.75,224.54)
S1_SPI_CSN: length 2.2
  TOP w0.231: v1(259.23,231.03) 259.03,231.23 SITE1.43
S1_SPI_SCK: length 2.2
  TOP w0.231: v1(258.83,235.23) 258.63,235.03 SITE1.42
S1_SPI_SDI: length 3.7
  TOP w0.231: SITE1.44 259.43,236.03 v1(258.83,236.63)
S1_SPI_SDO: length 3.7
  TOP w0.231: v1(257.63,236.63) 258.23,236.03 SITE1.41
S1_XTAL_IN: length 2.5
  TOP w0.119: v1(251.63,258.51) 251.43,258.31 SITE1.109
  vias: v1(226.85,271.67)
S1_XTAL_OUT: length 3.7
  TOP w0.231: SITE1.110 251.03,259.03 v1(251.63,259.63)
  vias: v1(226.85,276.97)
S2_1AUX+:
  vias: v1(301.73,229.11)
S2_1AUX-:
  vias: v1(298.45,229.11)
S2_2AUX+:
  vias: v1(290.31,132.08) v1(290.31,130.81) v1(300.73,229.11) v1(300.73,227.84)
S2_2AUX-:
  vias: v1(286.77,130.81) v1(287.77,132.08) v1(299.45,229.11) v1(299.45,227.84)
S2_AUX_100DCH002+:
  vias: v1(289.31,132.08)
S2_AUX_100DCH002-:
  vias: v1(286.77,132.08)
S2_AUXCH+: length 3.6
  TOP w0.203: SITE2.21 330.23,236.2 v2(330.6,236.57)
S2_AUXCH-: length 3.6
  TOP w0.203: SITE2.20 329.83,236.2 v2(329.46,236.57)
S2_AVDD11_RX: length 8.4
  TOP w0.231: 334.67,227.85 334.23,228.29 SITE2.31
  TOP w0.508: v1(336.77,225.75) 334.67,227.85
  vias: v1(336.77,223.71) v1(452.33,278.76) v1(452.33,276.86)
S2_AVDD11_XTAL: length 8.8
  TOP w0.231: SITE2.105 333.03,260.95 332.87,261.11 332.87,261.45
  TOP w0.381: 332.87,261.45 332.87,263.59 333.72,264.44 v1(333.72,264.54)
  vias: v1(333.72,266.58) v1(511.6,295.27) v1(511.6,293.37)
S2_AVDD18_RX: length 7.7
  TOP w0.231: 331.28,230.01 331.83,230.56 SITE2.25
  TOP w0.508: v1(331.06,225.75) 331.06,228.68 331.28,228.9 331.28,230.01
  vias: v1(331.06,223.71) v1(462.07,278.76) v1(462.07,276.86)
S2_DCH041: length 2.2
  TOP w0.231: SITE2.159 317.43,242.83 v1(317.23,243.03)
S2_DCH042: length 3.7
  TOP w0.231: SITE2.160 316.43,242.43 v1(315.83,243.03)
S2_DCH043: length 5.3
  TOP w0.231: SITE2.161 315.44,242.03 v1(314.43,243.03)
S2_DCH044: length 2.2
  TOP w0.231: v1(317.23,241.03) 317.43,241.23 SITE2.163
S2_DCH045: length 5.4
  TOP w0.231: SITE2.164 323.35,240.83 v1(324.35,239.83)
S2_DCH046: length 3.9
  TOP w0.231: SITE2.165 322.35,240.43 v1(322.95,239.83)
S2_DCH047: length 2.3
  TOP w0.231: SITE2.166 321.36,240.03 v1(321.56,239.83)
S2_DCH048:
  vias: v1(309.05,276.97)
S2_DCH049:
  vias: v1(309.05,271.67)
S2_DPS_F_001:
  vias: v1(92.04,249.81) v1(92.04,247.9) v1(287.77,130.81) v1(301.73,227.84)
S2_DPS_F_002: length 10.1
  TOP w0.231: 320.65,229.55 321.72,229.55 323.03,230.86 SITE2.3
  TOP w0.508: 320.65,229.55 317.98,226.88 v1(317.98,225.75)
  vias: v1(316.32,222.9) v1(317.98,223.71) v1(462.07,295.27) v1(462.07,293.37)
S2_DPS_F_003: length 63.1
  TOP w0.231: SITE2.71 346.94,246.43 347.84,245.53 ; 331.69,261.16 331.69,260.65 332.23,260.11 SITE2.107 ; 345.2,242.93 344.9,243.23 SITE2.63 ; 339.73,229.66 338.57,229.66 336.63,231.59 SITE2.37 ; SITE2.17 328.63,229.5 329.28,228.85 ; 314.63,241.63 SITE2.162 ; SITE2.145 313.08,248.43 312.83,248.18
  TOP w0.381: 331.69,261.16 331.69,264.28 v1(331.94,264.54)
  TOP w0.508: 312.83,248.18 312.58,247.93 v1(311.44,247.93) ; 347.84,245.53 349.45,243.91 v1(351.22,243.91) ; 345.2,242.93 345.45,242.67 346.8,242.67 348.11,241.37 v1(351.22,241.37) ; v1(311.44,243.41) 312.59,243.41 314.37,241.63 314.63,241.63 ; v1(342.36,225.75) 342.36,227.02 339.73,229.66 ; v1(329.28,225.75) 329.28,228.85
  vias: v1(309.4,247.93) v1(309.4,243.41) v1(329.28,223.71) v1(331.54,252.61) v1(331.94,266.58) v1(342.36,223.71) v1(353.27,243.91) v1(353.27,241.37) v1(452.33,295.27) v1(452.33,293.37) v1(464.57,235.71)
S2_DPS_F_006: length 9.6
  TOP w0.231: SITE2.72 347.92,246.83 348.55,246.19
  TOP w0.508: 348.55,246.19 349.56,245.18 v1(351.22,245.18)
  vias: v1(339,246.67) v1(353.27,245.18) v1(478.58,278.76) v1(478.58,276.86)
S2_DPS_F_007: length 19
  TOP w0.231: 344.37,249.01 344.15,249.23 SITE2.78 ; v1(339.65,264.54) 339.65,264.13 336.23,260.71 SITE2.97
  TOP w0.508: v1(351.22,249.5) 350.8,249.5 350.31,249.01 344.37,249.01
  vias: v1(339.65,266.58) v1(353.27,249.5) v1(495.09,278.76) v1(495.09,276.86)
S2_DPS_F_009: length 8.8
  TOP w0.231: 332.26,261.12 332.26,260.9 332.63,260.53 SITE2.106
  TOP w0.381: 332.26,261.12 332.26,263.82 332.83,264.39 v1(332.83,264.54)
  vias: v1(332.83,266.58) v1(333.61,267.66) v1(478.58,295.27) v1(478.58,293.37)
S2_DPS_F_010: length 8.6
  TOP w0.231: SITE2.111 330.63,260.15 331.05,260.57 331.05,261.13
  TOP w0.381: 331.05,261.13 v1(331.05,264.54)
  vias: v1(330.34,253.59) v1(331.05,266.58) v1(468.84,295.27) v1(468.84,293.37)
S2_DPS_F_011: length 17.6
  TOP w0.231: SITE2.119 327.43,257.79 327.64,258.01 ; SITE2.139 314.87,250.83 312.01,253.69 v1(311.44,253.69)
  TOP w0.508: 327.64,258.01 327.64,264.47 v1(327.57,264.54)
  vias: v1(309.4,253.69) v1(327.57,266.58) v1(485.35,278.76) v1(485.35,276.86)
S2_DPS_F_012: length 8
  TOP w0.231: 312.2,248.83 SITE2.144
  TOP w0.508: v1(311.44,249.2) 311.81,248.83 312.2,248.83
  vias: v1(309.4,249.2) v1(468.84,278.76) v1(468.84,276.86)
S2_DPS_F_013:
  vias: v1(87.17,249.86) v1(87.17,247.96) v1(452.62,232.41) v1(452.62,224.79) v1(457.25,233.88) v1(474.87,217.23) v1(474.89,204.98) v1(474.99,218.59) v1(475.99,230.78) v1(478.43,217.17) v1(478.43,204.98) v1(478.53,230.78) v1(478.53,218.59) v1(480.97,204.98) v1(481.07,218.59) v1(482.1,241.3) v1(482.1,233.68) v1(483.51,204.98) v1(483.61,218.59) v1(489.86,212.91) v1(490.1,226.67)
S2_ISP00+: length 138.8
  TOP w0.086: v1(354.19,245.88) 353.73,246.33 350.29,246.33 349.31,247.31 344.06,247.31 343.98,247.23 SITE2.73
  L30_SIGNAL w0.071: v1(386.29,259.59) 386.29,260.94 386.21,261.02 378.51,261.02 377.05,259.56 377.05,256.93 378.67,255.3 391.19,255.3 397.75,261.87 410.58,261.87 411.84,260.6 411.84,256.72 410.96,255.84 400.73,255.84 397.98,253.09 397.98,247.48 394.73,244.23 357.27,244.23 355.16,246.35 354.26,246.35 354.19,246.28 v1(354.19,245.88)
  BOTTOM w0.119: v1(386.29,259.59) UNK2K43.7
S2_ISP00-: length 138.8
  TOP w0.086: SITE2.74 343.98,247.63 344.06,247.55 349.41,247.55 350.39,246.57 353.73,246.57 v1(354.19,247.02)
  L30_SIGNAL w0.071: v1(386.29,262.63) 386.29,261.29 386.22,261.22 378.43,261.22 376.85,259.65 376.85,256.84 378.59,255.11 391.27,255.11 397.84,261.67 410.49,261.67 411.64,260.52 411.64,256.8 410.88,256.04 400.65,256.04 397.78,253.17 397.78,247.56 394.65,244.43 357.35,244.43 355.24,246.55 354.26,246.55 354.19,246.62 v1(354.19,247.02)
  BOTTOM w0.119: v1(386.29,262.63) UNK2K43.2
S2_ISP14+: length 138.8
  TOP w0.086: SITE2.112 330.23,257.78 330.15,257.86 330.15,266.59 331.48,267.92 331.48,269.45 v1(331.93,269.9)
  L28_SIGNAL w0.071: v1(331.93,269.9) 331.53,269.9 331.46,269.83 331.46,268.27 330.18,266.99 330.18,263.09 334.92,258.35 342.04,258.35 347.72,252.67 354.79,252.67 356.71,254.59 360.18,254.59 367.29,247.47 404.65,247.47 407.37,250.19 407.37,257.93 403.6,261.7 391.45,261.7 390.69,260.94 v1(390.69,257.11)
S2_ISP14-: length 138.8
  TOP w0.086: SITE2.113 329.83,257.78 329.91,257.86 329.91,266.69 331.24,268.02 331.24,269.45 v1(330.79,269.9)
  L28_SIGNAL w0.071: v1(330.79,269.9) 331.19,269.9 331.26,269.83 331.26,268.35 329.98,267.07 329.98,263.01 334.84,258.16 341.95,258.16 347.64,252.47 354.88,252.47 356.79,254.39 360.09,254.39 367.21,247.27 404.73,247.27 407.57,250.11 407.57,258.01 403.68,261.89 390.76,261.89 390.69,261.97 v1(390.69,265.11)
S2_ISP_1LOCK:
  vias: v1(309.91,245.39)
S2_M_DPS_F_001: length 45.2
  TOP w0.231: 330.63,230.54 SITE2.22 ; 340.57,230.37 338.54,230.37 337.43,231.49 SITE2.39 ; SITE2.147 313.7,247.63 313.24,247.18 ; SITE2.104 333.43,263.21 ; 346.49,243.63 SITE2.64
  TOP w0.381: v1(334.61,264.54) 334.61,264.39 333.43,263.21
  TOP w0.508: 330.63,230.54 330.38,230.28 330.38,229.17 330.17,228.96 v1(330.17,225.75) ; 346.49,243.63 347.49,243.63 348.48,242.64 v1(351.22,242.64) ; 313.24,247.18 312.72,246.66 v1(311.44,246.66) ; v1(343.63,225.75) 343.63,227.31 340.57,230.37
  vias: v1(309.4,246.66) v1(330.17,223.71) v1(334.61,266.58) v1(343.63,223.71) v1(353.27,242.64) v1(485.35,295.27) v1(485.35,293.37)
S2_PS9G_DCH001: length 3.7
  TOP w0.231: v1(329.63,229.63) 329.03,230.23 SITE2.18
S2_PS9G_DCH002: length 2.2
  TOP w0.231: SITE2.19 329.43,231.23 v1(329.63,231.03)
S2_PS9G_DCH003: length 2.2
  TOP w0.231: SITE2.24 331.43,231.23 v1(331.23,231.03)
S2_PS9G_DCH004: length 2.2
  TOP w0.231: SITE2.40 337.83,235.03 v1(337.63,235.23)
S2_PS9G_DCH005: length 2.2
  TOP w0.231: SITE2.45 344.23,236.03 v1(344.43,235.83)
S2_PS9G_DCH006: length 3.7
  TOP w0.231: v1(345.83,235.83) 345.23,236.43 SITE2.46
S2_PS9G_DCH007: length 5.3
  TOP w0.231: v1(347.22,235.83) 346.22,236.83 SITE2.47
S2_PS9G_DCH009: length 2.2
  TOP w0.231: SITE2.49 344.23,237.63 v1(344.43,237.43)
S2_PS9G_DCH010: length 3.7
  TOP w0.231: v1(345.83,237.43) 345.23,238.03 SITE2.50
S2_PS9G_DCH011: length 5.3
  TOP w0.231: SITE2.51 346.22,238.43 v1(347.22,237.43)
S2_PS9G_DCH014: length 3.7
  TOP w0.231: SITE2.54 345.23,239.63 v1(345.83,239.03)
S2_PS9G_DCH015: length 5.3
  TOP w0.231: SITE2.55 346.22,240.03 v1(347.22,239.03)
S2_PS9G_DCH022: length 5.3
  TOP w0.231: SITE2.65 346.05,244.03 347.05,245.03 v1(347.22,245.03)
S2_PS9G_DCH023: length 2.5
  TOP w0.231: SITE2.66 344.03,244.43 344.43,244.83 v1(344.43,245.03)
S2_PS9G_DCH027: length 3.9
  TOP w0.231: SITE2.70 344.83,246.03 v1(345.83,245.03)
S2_PS9G_DCH028: length 2.3
  TOP w0.231: v1(340.23,248.46) 340.6,248.83 SITE2.77
S2_PS9G_DCH029: length 2.2
  TOP w0.119: SITE2.118 v1(327.83,253.92)
S2_PS9G_DCH030: length 9.2
  TOP w0.231: SITE2.148 317.62,247.23 317.3,246.91 314.16,246.91 312.63,245.39 v1(310.91,245.39)
S2_PS9G_DCH035: length 5.3
  TOP w0.231: SITE2.153 315.44,245.23 v1(314.43,246.23)
S2_PS9G_DCH036: length 2.2
  TOP w0.231: v1(321.43,245.03) 321.23,244.83 SITE2.154
S2_PS9G_DCH037: length 2.2
  TOP w0.231: SITE2.155 317.43,244.43 v1(317.23,244.63)
S2_PS9G_DCH038: length 3.7
  TOP w0.231: SITE2.156 316.43,244.03 v1(315.83,244.63)
S2_PS9G_DCH039: length 5.3
  TOP w0.231: v1(314.43,244.63) 315.44,243.63 SITE2.157
S2_PS9G_DCH040: length 2.2
  TOP w0.231: SITE2.158 321.23,243.23 v1(321.43,243.43)
S2_RLY_001:
  vias: v1(369.38,241.11) v1(410.52,289.12)
S2_RLY_003:
  vias: v1(369.38,257.11) v1(396.55,257.37)
S2_RLY_005:
  vias: v1(410.27,257.37) v1(410.52,273.37)
S2_RLY_007:
  vias: v1(396.55,273.11)
S2_RLY_008:
  vias: v1(383.09,289.12) v1(383.09,273.11)
S2_RLY_016:
  vias: v1(369.63,273.11) v1(396.55,289.12)
S2_RLY_018:
  vias: v1(312.25,276.97)
S2_RLY_021:
  vias: v1(369.63,289.12) v1(383.09,241.11)
S2_RLY_022:
  vias: v1(389.7,209.36) v1(396.55,225.11)
S2_RLY_023:
  vias: v1(403.41,209.61)
S2_RLY_025:
  vias: v1(383.09,224.85) v1(410.52,241.11)
S2_RLY_026:
  vias: v1(369.38,224.6)
S2_RLY_030:
  vias: v1(396.55,241.11)
S2_RLY_043:
  vias: v1(383.09,257.11)
S2_SCAN_DCH008: length 2.2
  TOP w0.231: SITE2.48 340.43,237.23 v1(340.23,237.03)
S2_SCAN_DCH012: length 2.2
  TOP w0.231: SITE2.52 340.43,238.83 v1(340.23,238.63)
S2_SCAN_DCH013: length 2.2
  TOP w0.231: v1(344.43,239.03) 344.23,239.23 SITE2.53
S2_SCAN_DCH016: length 2.2
  TOP w0.231: SITE2.56 340.43,240.43 v1(340.23,240.23)
S2_SCAN_DCH017: length 2.2
  TOP w0.231: SITE2.57 344.23,240.83 v1(344.43,240.63)
S2_SCAN_DCH018: length 3.7
  TOP w0.231: SITE2.58 345.23,241.23 v1(345.83,240.63)
S2_SCAN_DCH019: length 5.3
  TOP w0.231: SITE2.59 346.22,241.63 v1(347.22,240.63)
S2_SCAN_DCH020: length 2.2
  TOP w0.231: v1(340.23,241.83) 340.43,242.03 SITE2.60
S2_SCAN_DCH021: length 2.2
  TOP w0.231: v1(344.43,242.23) 344.23,242.43 SITE2.61
S2_SCAN_DCH024: length 2.2
  TOP w0.231: SITE2.67 340.43,244.83 v1(340.23,244.63)
S2_SCAN_DCH025: length 3.7
  TOP w0.231: SITE2.68 339.43,245.23 v1(338.83,244.63)
S2_SCAN_DCH026: length 5.3
  TOP w0.231: v1(337.44,244.63) 338.44,245.63 SITE2.69
S2_SCAN_DCH031: length 3.7
  TOP w0.231: SITE2.149 322.23,246.83 v1(322.83,247.43)
S2_SCAN_DCH032: length 5.3
  TOP w0.231: v1(324.22,247.43) 323.22,246.43 SITE2.150
S2_SCAN_DCH033: length 2.2
  TOP w0.231: SITE2.151 317.43,246.03 v1(317.23,246.23)
S2_SCAN_DCH034: length 3.7
  TOP w0.231: SITE2.152 316.43,245.63 v1(315.83,246.23)
S2_SPI_1_CSN:
  vias: v1(474.99,230.78)
S2_SPI_1_SCK:
  vias: v1(480.07,218.59)
S2_SPI_1_SDI:
  vias: v1(456.19,217.17)
S2_SPI_1_SDO:
  vias: v1(455.94,209.55)
S2_SPI_2_CSN:
  vias: v1(475.87,217.23)
S2_SPI_2_SCK:
  vias: v1(479.97,204.98)
S2_SPI_2_SDI:
  vias: v1(451.62,217.17)
S2_SPI_2_SDO:
  vias: v1(451.87,209.55)
S2_SPI_11_SDI:
  vias: v1(457.19,217.17) v1(477.53,230.78)
S2_SPI_11_SDO:
  vias: v1(456.94,209.55) v1(482.61,218.59)
S2_SPI_22_SDI:
  vias: v1(452.62,217.17) v1(477.43,217.17)
S2_SPI_22_SDO:
  vias: v1(452.87,209.55) v1(482.51,204.98)
S2_SPI_CSN: length 2.2
  TOP w0.231: SITE2.43 339.03,231.23 v1(339.23,231.03)
S2_SPI_SCK: length 2.2
  TOP w0.231: v1(338.83,235.23) 338.63,235.03 SITE2.42
S2_SPI_SDI: length 3.7
  TOP w0.231: v1(338.83,236.63) 339.43,236.03 SITE2.44
S2_SPI_SDO: length 3.7
  TOP w0.231: SITE2.41 338.23,236.03 v1(337.63,236.63)
S2_XTAL_IN: length 2.5
  TOP w0.119: SITE2.109 331.43,258.31 v1(331.63,258.51)
  vias: v1(306.85,271.67)
S2_XTAL_OUT: length 3.7
  TOP w0.231: SITE2.110 331.03,259.03 v1(331.63,259.63)
  vias: v1(306.85,276.97)
S3_1AUX+:
  vias: v1(221.73,169.11)
S3_1AUX-:
  vias: v1(218.45,169.11)
S3_2AUX+:
  vias: v1(192.78,132.33) v1(192.78,131.06) v1(220.73,169.11) v1(220.73,167.84)
S3_2AUX-:
  vias: v1(189.24,131.06) v1(190.24,132.33) v1(219.45,169.11) v1(219.45,167.84)
S3_AUX_100DCH002+:
  vias: v1(191.78,132.33)
S3_AUX_100DCH002-:
  vias: v1(189.24,132.33)
S3_AUXCH+: length 3.6
  TOP w0.203: SITE3.21 250.23,176.2 v2(250.6,176.57)
S3_AUXCH-: length 3.6
  TOP w0.203: SITE3.20 249.83,176.2 v2(249.46,176.57)
S3_AVDD11_RX: length 8.4
  TOP w0.231: 254.67,167.85 254.23,168.29 SITE3.31
  TOP w0.508: v1(256.77,165.75) 254.67,167.85
  vias: v1(118.32,276.23) v1(118.32,274.32) v1(256.77,163.71)
S3_AVDD11_XTAL: length 8.8
  TOP w0.231: SITE3.105 253.03,200.95 252.87,201.11 252.87,201.45
  TOP w0.381: 252.87,201.45 252.87,203.59 253.72,204.45 v1(253.72,204.54)
  vias: v1(93.77,276.23) v1(93.77,274.32) v1(253.72,206.58)
S3_AVDD18_RX: length 7.7
  TOP w0.231: SITE3.25 251.83,170.56 251.28,170.01
  TOP w0.508: v1(251.06,165.75) 251.06,168.68 251.28,168.9 251.28,170.01
  vias: v1(128.06,276.23) v1(128.06,274.32) v1(251.06,163.71)
S3_DCH041: length 2.2
  TOP w0.231: v1(237.23,183.03) 237.43,182.83 SITE3.159
S3_DCH042: length 3.7
  TOP w0.231: SITE3.160 236.43,182.43 v1(235.83,183.03)
S3_DCH043: length 5.3
  TOP w0.231: SITE3.161 235.44,182.03 v1(234.44,183.03)
S3_DCH044: length 2.2
  TOP w0.231: v1(237.23,181.03) 237.43,181.23 SITE3.163
S3_DCH045: length 5.4
  TOP w0.231: v1(244.35,179.83) 243.35,180.83 SITE3.164
S3_DCH046: length 3.9
  TOP w0.231: SITE3.165 242.35,180.43 v1(242.95,179.83)
S3_DCH047: length 2.3
  TOP w0.231: SITE3.166 241.36,180.03 v1(241.56,179.83)
S3_DCH048:
  vias: v1(229.05,216.97)
S3_DCH049:
  vias: v1(229.05,211.67)
S3_DPS_F_001:
  vias: v1(112.05,249.13) v1(112.05,247.23) v1(190.24,131.06) v1(221.73,167.84)
S3_DPS_F_002: length 10.1
  TOP w0.231: SITE3.3 243.03,170.86 241.72,169.55 240.65,169.55
  TOP w0.508: v1(237.98,165.75) 237.98,166.88 240.65,169.55
  vias: v1(111.55,292.74) v1(111.55,290.83) v1(236.32,162.9) v1(237.98,163.71)
S3_DPS_F_003: length 63.1
  TOP w0.231: 232.83,188.18 233.08,188.43 SITE3.145 ; SITE3.37 256.63,171.59 258.57,169.66 259.73,169.66 ; 267.84,185.53 266.94,186.43 SITE3.71 ; 265.2,182.93 264.9,183.23 SITE3.63 ; 251.69,201.16 251.69,200.65 252.23,200.11 SITE3.107 ; 234.63,181.63 SITE3.162 ; SITE3.17 248.63,169.5 249.28,168.85
  TOP w0.381: 251.69,201.16 251.69,204.28 v1(251.94,204.54)
  TOP w0.508: 259.73,169.66 262.36,167.02 v1(262.36,165.75) ; v1(231.44,187.93) 232.58,187.93 232.83,188.18 ; v1(271.22,181.37) 268.11,181.37 266.8,182.68 265.45,182.68 265.2,182.93 ; 267.84,185.53 269.46,183.91 v1(271.22,183.91) ; 234.63,181.63 234.37,181.63 232.59,183.41 v1(231.44,183.41) ; v1(249.28,165.75) 249.28,168.85
  vias: v1(101.81,292.74) v1(101.81,290.83) v1(114.55,186.44) v1(229.4,187.93) v1(229.4,183.41) v1(249.28,163.71) v1(251.54,192.61) v1(251.94,206.58) v1(262.36,163.71) v1(273.27,183.91) v1(273.27,181.37)
S3_DPS_F_006: length 9.6
  TOP w0.231: SITE3.72 267.92,186.83 268.55,186.19
  TOP w0.508: 268.55,186.19 269.56,185.18 v1(271.22,185.18)
  vias: v1(75.99,276.23) v1(75.99,274.32) v1(259,186.67) v1(273.27,185.18)
S3_DPS_F_007: length 19
  TOP w0.231: SITE3.97 256.23,200.71 259.65,204.13 v1(259.65,204.54) ; SITE3.78 264.15,189.23 264.37,189.01
  TOP w0.508: v1(271.22,189.5) 270.8,189.5 270.31,189.01 264.37,189.01
  vias: v1(75.99,292.74) v1(75.99,290.83) v1(259.65,206.58) v1(273.27,189.5)
S3_DPS_F_009: length 8.8
  TOP w0.231: 252.26,201.12 252.26,200.9 252.63,200.53 SITE3.106
  TOP w0.381: 252.26,201.12 252.26,203.82 252.83,204.39 v1(252.83,204.54)
  vias: v1(93.77,292.74) v1(93.77,290.83) v1(252.83,206.58) v1(253.61,207.66)
S3_DPS_F_010: length 8.6
  TOP w0.231: SITE3.111 250.63,200.15 251.05,200.57 251.05,201.13
  TOP w0.381: 251.05,201.13 v1(251.05,204.54)
  vias: v1(84.03,292.74) v1(84.03,290.83) v1(250.34,193.59) v1(251.05,206.58)
S3_DPS_F_011: length 17.6
  TOP w0.231: SITE3.119 247.43,197.79 247.64,198.01 ; v1(231.44,193.69) 232.01,193.69 234.87,190.83 SITE3.139
  TOP w0.508: v1(247.57,204.54) 247.64,204.47 247.64,198.01
  vias: v1(66.25,292.74) v1(66.25,290.83) v1(229.4,193.69) v1(247.57,206.58)
S3_DPS_F_012: length 8
  TOP w0.231: 232.2,188.83 SITE3.144
  TOP w0.508: 232.2,188.83 231.81,188.83 v1(231.44,189.2)
  vias: v1(66.25,276.23) v1(66.25,274.32) v1(229.4,189.2)
S3_DPS_F_013:
  vias: v1(89.78,163.72) v1(90.02,177.49) v1(96.27,171.81) v1(96.37,185.42) v1(97.53,197.36) v1(97.53,189.74) v1(98.81,171.81) v1(98.91,185.42) v1(101.35,171.81) v1(101.35,159.62) v1(101.45,185.42) v1(101.45,173.22) v1(103.89,159.62) v1(104.89,171.81) v1(104.99,185.42) v1(105.01,173.17) v1(107.18,249.19) v1(107.18,247.28) v1(122.38,197.41) v1(127.01,189.74) v1(127.01,182.12)
S3_ISP00+: length 139.4
  TOP w0.086: SITE3.73 263.98,187.23 264.06,187.31 269.31,187.31 270.29,186.33 273.74,186.33 v1(274.19,185.88)
  L30_SIGNAL w0.071: v1(274.19,185.88) 274.19,186.28 274.26,186.35 275.68,186.35 276.26,186.93 276.26,191.9 275.6,192.56 272.06,192.56 269.25,195.37 262.3,195.37 261.75,194.82 261.75,193.71 262.27,193.19 263.66,193.19 264.22,192.63 264.22,191.94 263.46,191.18 236.77,191.18 226.54,201.4 221.84,201.4 212.34,191.9 192.82,191.9 188.29,187.36 188.29,179.45 187.7,178.86 v1(186.95,178.86)
  BOTTOM w0.119: v1(186.95,178.86) UNK3K43.7
S3_ISP00-: length 139.4
  TOP w0.086: v1(274.19,187.02) 273.74,186.57 270.39,186.57 269.41,187.55 264.06,187.55 263.98,187.63 SITE3.74
  L30_SIGNAL w0.071: v1(189.99,178.86) 189.09,178.86 188.71,178.48 188.58,178.48 188.48,178.58 188.48,187.28 192.91,191.7 212.43,191.7 221.93,201.2 226.46,201.2 236.68,190.98 263.54,190.98 264.42,191.86 264.42,192.71 263.74,193.39 262.35,193.39 261.95,193.79 261.95,194.74 262.38,195.17 269.16,195.17 271.98,192.36 275.52,192.36 276.06,191.82 276.06,187.01 275.6,186.55 274.26,186.55 274.19,186.62 v1(274.19,187.02)
  BOTTOM w0.119: v1(189.99,178.86) UNK3K43.2
S3_ISP14+: length 139.4
  TOP w0.086: v1(251.93,209.9) 251.48,209.45 251.48,207.92 250.15,206.59 250.15,197.86 250.23,197.78 SITE3.112
  L28_SIGNAL w0.071: v1(251.93,209.9) 251.53,209.9 251.46,209.97 251.46,211.57 249.38,213.65 224.66,213.65 223.35,212.34 223.35,211.2 220.57,208.42 178.35,208.42 177.01,207.08 177.01,186.45 178.73,184.73 184.89,184.73 188.11,181.5 188.11,175.21 187.36,174.46 v1(184.47,174.46)
