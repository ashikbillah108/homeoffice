# Allegro board 8880F5-0830.brd (continued)
## Nets (continued)
N26495835: UNK3K1.6 UNK3R9.2
N26495836: UNK3K1.4 UNK3R8.1
N26495837: UNK3K1.3 UNK3R7.2
N26495839: UNK3K2.3 UNK3R11.2
N26495840: UNK3K2.4 UNK3R12.1
N26495841: UNK3K4.5 UNK3R22.1
N26495843: UNK3K4.3 UNK3R19.2
N26495844: UNK3K4.4 UNK3R20.1
N26495845: UNK3K4.6 UNK3R21.2
N26495846: UNK3K2.5 UNK3R14.1
N26495847: UNK3K2.6 UNK3R13.2
N26496033: UNK3K12.4 UNK3R131.1
N26496035: UNK3K12.5 UNK3R132.1
N26496039: UNK3K33.2 UNK3R82.1
N26496040: UNK3K33.4 UNK3R117.1
N26496047: UNK3K18.4 UNK3R5.1 UNK3R6.2
N26496049: UNK3K18.5 UNK3R6.1 UNK3R133.1
N26496050: UNK3C5.1 UNK3R133.2 UNK3Y1.1 UNK3Y2.1
N26496051: UNK3C6.1 UNK3R5.2 UNK3Y1.3 UNK3Y2.3
N26496080: UNK3K13.5 UNK3R120.2
N26496081: UNK3K13.4 UNK3R119.2
N26496142: UNK3J5.1 UNK3K28.5 UNK3R84.2
N26496146: UNK3J4.1 UNK3K28.4 UNK3R83.2
N26500269: UNK3J2.1 UNK3R89.1
N26500273: UNK3J3.1 UNK3R96.1
N26500275: UNK3J3.3 UNK3R93.1
N26500282: UNK3R90.1 UNK3U1.7
N26500307: UNK3J2.2 UNK3U1.3
N26500316: UNK3R97.1 UNK3U2.7
N26500343: UNK3J3.2 UNK3U2.3
N26500354: UNK3J2.3 UNK3R86.1
N26501112: UNK3CA21.1 UNK3K34.5
N26501118: UNK3CA23.1 UNK3K36.5 UNK3K36.8
N26501123: UNK3CA24.1 UNK3K37.5
N26501243: UNK3CA29.1 UNK3K42.5
N26501249: UNK3CA26.1 UNK3K39.5
N26501321: UNK3CA34.1 UNK3K31.5
N26501327: UNK3CA27.1 UNK3K40.5
N26501460: UNK3CA37.1 UNK3K39.8
N26501466: UNK3CA40.1 UNK3K42.8
N26501470: UNK3CA28.1 UNK3K40.8
N26501472: UNK3CA25.1 UNK3K37.8
N26501478: UNK3CA22.1 UNK3K34.8
N26504239: UNK4K25.3 UNK4R55.2
N26504240: UNK4K25.4 UNK4R56.1
N26504241: UNK4K25.6 UNK4R57.2
N26504242: UNK4K25.5 UNK4R58.1
N26504244: UNK4K26.3 UNK4R59.2
N26504245: UNK4K26.4 UNK4R60.1
N26504246: UNK4K26.6 UNK4R61.2
N26504247: UNK4K26.5 UNK4R62.1
N26504249: UNK4K27.5 UNK4R66.1
N26504250: UNK4K27.6 UNK4R65.2
N26504257: UNK4K22.6 UNK4R45.2
N26504258: UNK4K22.5 UNK4R46.1
N26504259: UNK4K23.3 UNK4R47.2
N26504260: UNK4K23.4 UNK4R48.1
N26504261: UNK4K23.6 UNK4R49.2
N26504262: UNK4K23.5 UNK4R50.1
N26504264: UNK4K24.3 UNK4R51.2
N26504265: UNK4K24.4 UNK4R52.1
N26504266: UNK4K24.6 UNK4R53.2
N26504267: UNK4K24.5 UNK4R54.1
N26504282: UNK4K22.3 UNK4R102.2
N26504283: UNK4K22.4 UNK4R103.1
N26504284: UNK4K27.3 UNK4R104.2
N26504285: UNK4K27.4 UNK4R105.1
N26504400: S4_RST_N.2 UNK4J1.2 UNK4K10.4 UNK4R85.2
N26504405: UNK4C7.1 UNK4J1.1
N26504440: UNK4K17.3 UNK4R71.2
N26504441: UNK4K17.4 UNK4R72.1
N26504442: UNK4K17.5 UNK4R74.1
N26504443: UNK4K17.6 UNK4R73.2
N26504444: UNK4K21.3 UNK4R75.2
N26504445: UNK4K21.4 UNK4R76.1
N26504446: UNK4K21.5 UNK4R78.1
N26504447: UNK4K21.6 UNK4R77.2
N26504448: UNK4K29.3 UNK4R79.2
N26504449: UNK4K29.4 UNK4R80.1
N26504450: UNK4K29.6 UNK4R43.2
N26504451: UNK4K29.5 UNK4R44.1
N26504452: UNK4K30.3 UNK4R63.2
N26504453: UNK4K30.4 UNK4R64.1
N26504454: UNK4K30.5 UNK4R101.1
N26504455: UNK4K30.6 UNK4R100.2
N26504536: UNK4K16.3 UNK4R67.2
N26504537: UNK4K16.4 UNK4R68.1
N26504538: UNK4K16.5 UNK4R70.1
N26504539: UNK4K16.6 UNK4R69.2
N26504561: UNK4K6.5 UNK4R30.1
N26504563: UNK4K6.3 UNK4R27.2
N26504564: UNK4K6.4 UNK4R28.1
N26504565: UNK4K6.6 UNK4R29.2
N26504566: UNK4K7.5 UNK4R34.1
N26504568: UNK4K7.3 UNK4R31.2
N26504569: UNK4K7.4 UNK4R32.1
N26504570: UNK4K7.6 UNK4R33.2
N26504612: UNK4K11.3 UNK4R39.2
N26504613: UNK4K11.4 UNK4R40.1
N26504614: UNK4K8.5 UNK4R38.1
N26504616: UNK4K8.6 UNK4R37.2
N26504617: UNK4K11.6 UNK4R41.2
N26504618: UNK4K11.5 UNK4R42.1
N26504660: UNK4K5.5 UNK4R26.1
N26504662: UNK4K5.3 UNK4R23.2
N26504663: UNK4K5.4 UNK4R24.1
N26504664: UNK4K5.6 UNK4R25.2
N26504685: UNK4K3.5 UNK4R18.1
N26504686: UNK4K3.6 UNK4R17.2
N26504687: UNK4K3.4 UNK4R16.1
N26504688: UNK4K3.3 UNK4R15.2
N26504691: UNK4K1.5 UNK4R10.1
N26504692: UNK4K1.6 UNK4R9.2
N26504693: UNK4K1.4 UNK4R8.1
N26504694: UNK4K1.3 UNK4R7.2
N26504696: UNK4K2.3 UNK4R11.2
N26504697: UNK4K2.4 UNK4R12.1
N26504698: UNK4K4.5 UNK4R22.1
N26504700: UNK4K4.3 UNK4R19.2
N26504701: UNK4K4.4 UNK4R20.1
N26504702: UNK4K4.6 UNK4R21.2
N26504703: UNK4K2.5 UNK4R14.1
N26504704: UNK4K2.6 UNK4R13.2
N26504890: UNK4K12.4 UNK4R131.1
N26504892: UNK4K12.5 UNK4R132.1
N26504896: UNK4K33.2 UNK4R82.1
N26504897: UNK4K33.4 UNK4R117.1
N26504904: UNK4K18.4 UNK4R5.1 UNK4R6.2
N26504906: UNK4K18.5 UNK4R6.1 UNK4R133.1
N26504907: UNK4C5.1 UNK4R133.2 UNK4Y1.1 UNK4Y2.1
N26504908: UNK4C6.1 UNK4R5.2 UNK4Y1.3 UNK4Y2.3
N26504937: UNK4K13.5 UNK4R120.2
N26504938: UNK4K13.4 UNK4R119.2
N26504999: UNK4J5.1 UNK4K28.5 UNK4R84.2
N26505003: UNK4J4.1 UNK4K28.4 UNK4R83.2
N26509126: UNK4J2.1 UNK4R89.1
N26509130: UNK4J3.1 UNK4R96.1
N26509132: UNK4J3.3 UNK4R93.1
N26509139: UNK4R90.1 UNK4U1.7
N26509164: UNK4J2.2 UNK4U1.3
N26509173: UNK4R97.1 UNK4U2.7
N26509200: UNK4J3.2 UNK4U2.3
N26509211: UNK4J2.3 UNK4R86.1
N26509969: UNK4CA21.1 UNK4K34.5
N26509975: UNK4CA23.1 UNK4K36.5 UNK4K36.8
N26509980: UNK4CA24.1 UNK4K37.5
N26510100: UNK4CA29.1 UNK4K42.5
N26510106: UNK4CA26.1 UNK4K39.5
N26510178: UNK4CA34.1 UNK4K31.5
N26510184: UNK4CA27.1 UNK4K40.5
N26510317: UNK4CA37.1 UNK4K39.8
N26510323: UNK4CA40.1 UNK4K42.8
N26510327: UNK4CA28.1 UNK4K40.8
N26510329: UNK4CA25.1 UNK4K37.8
N26510335: UNK4CA22.1 UNK4K34.8

Pads without a net: CSDPS225 A17 B17 C17 D17; CSDPS229 A17 B17 C17 D17; CSDPS425 A17 B17 C17 D17; CSDPS429 A17 B17 C17 D17; D101/D501 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16; D102 17 A17 B17; D103 17 A17 B17; D104 17 A17 B17; D105/D505 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16; D106 17 A17 B17; D107 17 A17 B17; D108 17 A17 B17; D109 17 A17 B17; D110 17 A17 B17; D111 17 A17 B17; D112 17 A17 B17; D113 17 A17 B17; D114 17 A17 B17; D115 17 A17 B17; D116 17 A17 B17; D117/D517 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16; D118 17 A17 B17; D119 17 A17 B17; D120 17 A17 B17; D121/D521 A1 A2 A3 A4 A5 A6 A7 A8 A9 A10 A11 A12 A13 A14 A15 A16 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11 D12 D13 D14 D15 D16; D122 17 A17 B17; D123 17 A17 B17; D124 17 A17 B17; D125 17 A17 B17; D126 17 A17 B17; D127 17 A17 B17; D128 17 A17 B17; D129 17 A17 B17; D130 17 A17 B17; D131 17 A17 B17; D132 17 A17 B17; D301 17 A17 B17; D302 17 A17 B17; D305 17 A17 B17; D306 17 A17 B17; D309 A1 A3 A5 A7 A9 A11 A13 A15 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 D2 D4 D6 D8 D10 D12 D14 D16; D313 A1 A3 A5 A7 A9 A11 A13 A15 A17 B1 B2 B3 B4 B5 B6 B7 B8 B9 B10 B11 B12 B13 B14 B15 B16 B17 C1 C2 C3 C4 C5 C6 C7 C8 C9 C10 C11 C12 C13 C14 C15 C16 C17 D2 D4 D6 D8 D10 D12 D14 D16; D317 17 A17 B17; D318 17 A17 B17; D321 17 A17 B17; D322 17 A17 B17; DPS1 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS2 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS3 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; DPS8 A04 A08 A10 A14 B04 B08 B10 B14 C04 C08 C10 C14; FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; FD7 1; FD8 1; FD9 1; FD10 1; FD11 1; FD12 1; FD13 1; FD14 1; FD15 1; FD16 1; HX8880-F05 1; JG_220919AA01 1; JG_220919AA02 1; K1 2 7; K2 2 7; K3 2 7; K4 2 7; K5 2 7; K6 2 7; K7 2 7; K8 2 3 4 7; K10 2 5 6 7; K11 2 7; K12 2 7; K13 2 7; K16 2 7; K17 2 7; K21 2 7; K22 2 7; K23 2 7; K24 2 7; K25 2 7; K26 2 7; K27 2 7; K28 2 7; K29 2 7; K30 2 7; K31 3 8 9 10; K33 5 6 7; K34 3 10; K36 3 10; K37 3 10; K39 3 10; K40 3 10; K42 3 10; LOGO1 1; LOGO2 1; LQFP176-20X20-P0.4 1; S1_I2C 3; S2_I2C 3; S3_I2C 3; S4_I2C 3; SITE1 NUT1 NUT2 NUT3 NUT4; SITE2 NUT1 NUT2 NUT3 NUT4; SITE3 NUT1 NUT2 NUT3 NUT4; SITE4 NUT1 NUT2 NUT3 NUT4; SKB NUT1 NUT2 NUT3 NUT4; TPL1 1; TPL2 1; TPL3 1; TPL4 1; TPL5 1; TPL6 1; TPL7 1; TPL8 1; TPL9 1; TPL10 1; TPL11 1; TPL12 1; TPL13 1; TPL14 1; TPL15 1; TPL16 1; TPL17 1; TPL18 1; TPL19 1; TPL20 1; TPL21 1; TPL22 1; TPL23 1; TPL24 1; TPL25 1; TPL26 1; TPL27 1; TPL28 1; TPL29 1; TPL30 1; TPL31 1; TPL32 1; TPL33 1; TPL34 1; TPL35 1; TPL36 1; TPL37 1; TPL38 1; TPL39 1; TPL40 1; UF1 1; UF2 1; UNK2K1 2 7; UNK2K2 2 7; UNK2K3 2 7; UNK2K4 2 7; UNK2K5 2 7; UNK2K6 2 7; UNK2K7 2 7; UNK2K8 2 3 4 7; UNK2K10 2 5 6 7; UNK2K11 2 7; UNK2K12 2 7; UNK2K13 2 7; UNK2K16 2 7; UNK2K17 2 7; UNK2K21 2 7; UNK2K22 2 7; UNK2K23 2 7; UNK2K24 2 7; UNK2K25 2 7; UNK2K26 2 7; UNK2K27 2 7; UNK2K28 2 7; UNK2K29 2 7; UNK2K30 2 7; UNK2K31 3 8 9 10; UNK2K33 5 6 7; UNK2K34 3 10; UNK2K36 3 10; UNK2K37 3 10; UNK2K39 3 10; UNK2K40 3 10; UNK2K42 3 10; UNK2UF1 1; UNK2UF2 1; UNK3K1 2 7; UNK3K2 2 7; UNK3K3 2 7; UNK3K4 2 7; UNK3K5 2 7; UNK3K6 2 7; UNK3K7 2 7; UNK3K8 2 3 4 7; UNK3K10 2 5 6 7; UNK3K11 2 7; UNK3K12 2 7; UNK3K13 2 7; UNK3K16 2 7; UNK3K17 2 7; UNK3K21 2 7; UNK3K22 2 7; UNK3K23 2 7; UNK3K24 2 7; UNK3K25 2 7; UNK3K26 2 7; UNK3K27 2 7; UNK3K28 2 7; UNK3K29 2 7; UNK3K30 2 7; UNK3K31 3 8 9 10; UNK3K33 5 6 7; UNK3K34 3 10; UNK3K36 3 10; UNK3K37 3 10; UNK3K39 3 10; UNK3K40 3 10; UNK3K42 3 10; UNK3UF1 1; UNK3UF2 1; UNK4K1 2 7; UNK4K2 2 7; UNK4K3 2 7; UNK4K4 2 7; UNK4K5 2 7; UNK4K6 2 7; UNK4K7 2 7; UNK4K8 2 3 4 7; UNK4K10 2 5 6 7; UNK4K11 2 7; UNK4K12 2 7; UNK4K13 2 7; UNK4K16 2 7; UNK4K17 2 7; UNK4K21 2 7; UNK4K22 2 7; UNK4K23 2 7; UNK4K24 2 7; UNK4K25 2 7; UNK4K26 2 7; UNK4K27 2 7; UNK4K28 2 7; UNK4K29 2 7; UNK4K30 2 7; UNK4K31 3 8 9 10; UNK4K33 5 6 7; UNK4K34 3 10; UNK4K36 3 10; UNK4K37 3 10; UNK4K39 3 10; UNK4K40 3 10; UNK4K42 3 10; UNK4UF1 1; UNK4UF2 1; UNK038HX-8880F5K4Q-A100 1; UNK980HX-8880F5-KBG- 1; UTL1 A17 B17; UTL2 A17 B17; UTL3 A17 B17; UTL4 A17 B17; UTL5 A17 B17; UTL6 A17 B17; UTL7 A17 B17; UTL8 A17 B17

## Via types
v1: diameter 0.559, hole 0.305, TOP to BOTTOM, 7573 vias
v2: diameter 0.508, hole 0.305, TOP to BOTTOM, 8 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
GND: length 97902.5
  TOP w0.119: UNK3CC42.2 251.83,193.63 SITE3.108 ; UNK2CC42.2 331.83,253.63 SITE2.108 ; SITE4.108 331.83,193.63 UNK4CC42.2 ; SITE1.108 251.83,253.63 CC42.2
  TOP w0.231: SITE2.146 321.07,248.03 321.43,247.67 v1(321.43,247.43) ; v1(243.23,194.03) 243.47,194.03 243.83,194.39 SITE3.128 ; SITE4.4 323.43,175.03 323.63,175.23 v1(323.63,175.36) ; SITE1.62 v1(260.23,242.83) ; v1(254.76,235.23) 255.03,235.23 255.43,234.83 SITE1.34 ; SITE3.4 243.43,175.03 243.63,175.23 v1(243.63,175.36) ; SITE4.23 331.03,175.16 v1(330.96,175.23) ; v1(250.96,175.23) 251.03,175.16 SITE3.23 ; SITE3.28 253.03,174.83 252.63,175.23 v1(252.36,175.23) ; v1(334.76,235.23) 335.03,235.23 335.43,234.83 SITE2.34 ; SITE3.146 241.07,188.03 241.43,187.67 v1(241.43,187.43) ; SITE1.28 253.03,234.83 252.63,235.23 v1(252.36,235.23) ; SITE2.62 v1(340.23,242.83) ; SITE2.28 333.03,234.83 332.63,235.23 v1(332.36,235.23) ; SITE4.34 335.43,174.83 335.03,175.23 v1(334.76,175.23) ; v1(243.23,254.03) 243.47,254.03 243.83,254.39 SITE1.128 ; SITE2.38 337.03,234.83 336.63,235.23 v1(336.36,235.23) ; SITE4.146 321.07,188.03 321.43,187.67 v1(321.43,187.43) ; SITE4.28 333.03,174.83 332.63,175.23 v1(332.36,175.23) ; SITE2.23 331.03,235.16 v1(330.96,235.23) ; SITE2.128 323.83,254.39 323.47,254.03 v1(323.23,254.03) ; SITE4.128 323.83,194.39 323.47,194.03 v1(323.23,194.03) ; v1(254.76,175.23) 255.03,175.23 255.43,174.83 SITE3.34 ; SITE1.38 257.03,234.83 256.63,235.23 v1(256.36,235.23) ; SITE3.62 v1(260.23,182.83) ; SITE1.146 241.07,248.03 241.43,247.67 v1(241.43,247.43) ; SITE4.38 337.03,174.83 336.63,175.23 v1(336.36,175.23) ; SITE1.23 251.03,235.16 v1(250.96,235.23) ; v1(256.36,175.23) 256.63,175.23 257.03,174.83 SITE3.38 ; v1(243.63,235.36) 243.63,235.23 243.43,235.03 SITE1.4 ; SITE2.4 323.43,235.03 323.63,235.23 v1(323.63,235.36) ; SITE4.62 v1(340.23,182.83)
  TOP w0.381: v1(272.24,245.18) CD15.2 ; v1(251.94,265.56) CD18.2 ; v1(339.65,265.56) UNK2CD11.2 ; v1(331.94,205.56) UNK4CD18.2 ; v1(331.06,164.73) UNK4CD8.2 ; v1(252.83,265.56) CD13.2 ; v1(249.28,164.73) UNK3CD22.2 ; v1(352.24,181.37) UNK4CD3.2 ; v1(334.61,205.56) UNK4CD4.2 ; v1(332.83,265.56) UNK2CD13.2 ; v1(230.42,247.93) CD17.2 ; v1(237.98,164.73) UNK3CD1.2 ; v1(352.24,185.18) UNK4CD15.2 ; v1(259.65,265.56) CD11.2 ; v1(310.42,186.66) UNK4CD6.2 ; v1(250.17,164.73) UNK3CD23.2 ; v1(336.77,164.73) UNK4CD9.2 ; v1(230.42,189.2) UNK3CD25.2 ; v1(327.57,265.56) UNK2CD24.2 ; v1(331.05,265.56) UNK2CD14.2 ; v1(330.17,224.73) UNK2CD23.2 ; UNK3CD5.2 v1(263.63,164.73) ; v1(352.24,182.64) UNK4CD7.2 ; v1(352.24,249.5) UNK2CD10.2 ; v1(230.42,186.66) UNK3CD6.2 ; v1(272.24,182.64) UNK3CD7.2 ; v1(249.28,224.73) CD22.2 ; v1(254.61,265.56) CD4.2 ; v1(247.57,205.56) UNK3CD24.2 ; v1(250.17,224.73) CD23.2 ; v1(230.42,249.2) CD25.2 ; v1(339.65,205.56) UNK4CD11.2 ; v1(310.42,183.41) UNK4CD19.2 ; v1(251.05,265.56) CD14.2 ; v1(317.98,224.73) UNK2CD1.2 ; v1(251.06,224.73) CD8.2 ; v1(310.42,189.2) UNK4CD25.2 ; v1(352.24,183.91) UNK4CD20.2 ; v1(352.24,189.5) UNK4CD10.2 ; UNK2CD21.2 v1(342.36,224.73) ; v1(251.05,205.56) UNK3CD14.2 ; UNK2CD5.2 v1(343.63,224.73) ; v1(272.24,185.18) UNK3CD15.2 ; v1(272.24,243.91) CD20.2 ; v1(352.24,241.37) UNK2CD3.2 ; v1(333.72,265.56) UNK2CD16.2 ; v1(310.42,253.69) UNK2CD12.2 ; v1(256.77,224.73) CD9.2 ; v1(251.94,205.56) UNK3CD18.2 ; v1(230.42,246.66) CD6.2 ; v1(330.17,164.73) UNK4CD23.2 ; v1(310.42,249.2) UNK2CD25.2 ; v1(336.77,224.73) UNK2CD9.2 ; v1(317.98,164.73) UNK4CD1.2 ; UNK3CD21.2 v1(262.36,164.73) ; v1(253.72,205.56) UNK3CD16.2 ; v1(254.61,205.56) UNK3CD4.2 ; v1(331.05,205.56) UNK4CD14.2 ; v1(310.42,243.41) UNK2CD19.2 ; v1(252.83,205.56) UNK3CD13.2 ; v1(230.42,253.69) CD12.2 ; UNK4CD5.2 v1(343.63,164.73) ; v1(332.83,205.56) UNK4CD13.2 ; CD5.2 v1(263.63,224.73) ; v1(329.28,164.73) UNK4CD22.2 ; v1(310.42,187.93) UNK4CD17.2 ; UNK4CD21.2 v1(342.36,164.73) ; v1(237.98,224.73) CD1.2 ; v1(310.42,193.69) UNK4CD12.2 ; v1(352.24,245.18) UNK2CD15.2 ; v1(230.42,187.93) UNK3CD17.2 ; v1(253.72,265.56) CD16.2 ; v1(230.42,183.41) UNK3CD19.2 ; v1(272.24,249.5) CD10.2 ; v1(329.28,224.73) UNK2CD22.2 ; v1(256.77,164.73) UNK3CD9.2 ; v1(331.06,224.73) UNK2CD8.2 ; v1(333.72,205.56) UNK4CD16.2 ; v1(327.57,205.56) UNK4CD24.2 ; v1(230.42,193.69) UNK3CD12.2 ; CD21.2 v1(262.36,224.73) ; v1(247.57,265.56) CD24.2 ; v1(230.42,243.41) CD19.2 ; v1(251.06,164.73) UNK3CD8.2 ; v1(331.94,265.56) UNK2CD18.2 ; v1(272.24,183.91) UNK3CD20.2 ; v1(272.24,181.37) UNK3CD3.2 ; v1(272.24,241.37) CD3.2 ; v1(272.24,242.64) CD7.2 ; v1(352.24,242.64) UNK2CD7.2 ; v1(310.42,247.93) UNK2CD17.2 ; v1(310.42,246.66) UNK2CD6.2 ; v1(259.65,205.56) UNK3CD11.2 ; v1(352.24,243.91) UNK2CD20.2 ; v1(334.61,265.56) UNK2CD4.2 ; v1(272.24,189.5) UNK3CD10.2
  L02_DGND w0.203: D120.B2 163.37,40.64 ; D120.B2 161.75,40.64 ; D120.B2 162.56,41.45 ; D120.B2 162.56,39.83 ; 86.36,77.93 D130.B1 ; D130.B1 86.36,79.55 ; D130.B1 85.55,78.74 ; D130.B1 87.17,78.74 ; D122.A12 261.62,77.01 ; D122.A12 262.43,76.2 ; D122.A12 261.62,75.39 ; D122.A12 260.81,76.2 ; D124.A2 236.22,36.37 ; D124.A2 237.03,35.56 ; D124.A2 236.22,34.75 ; D124.A2 235.41,35.56 ; 235.41,55.88 D123.A2 ; D123.A2 236.22,55.07 ; D123.A2 237.03,55.88 ; D123.A2 236.22,56.69 ; D130.B16 124.46,82.09 ; D130.B16 124.46,80.47 ; D130.B16 125.27,81.28 ; D130.B16 123.65,81.28 ; 334.47,393.7 D116.A6 ; D116.A6 335.28,394.51 ; D116.A6 335.28,392.89 ; D116.A6 336.09,393.7 ; 392.99,91.44 D305.B6 ; D305.B6 393.7,90.73 ; D305.B6 393.7,92.15 ; D305.B6 394.41,91.44 ; 342.09,391.16 D116.B3 ; D116.B3 343.71,391.16 ; D116.B3 342.9,390.35 ; D116.B3 342.9,391.97 ; 235.51,71.12 D322.B2 ; D322.B2 236.22,70.41 ; D322.B2 236.93,71.12 ; D322.B2 236.22,71.83 ; D112.A1 421.64,397.05 ; D112.A1 422.45,396.24 ; D112.A1 421.64,395.43 ; D112.A1 420.83,396.24 ; D125.A15 49.07,93.98 ; D125.A15 48.26,94.79 ; D125.A15 48.26,93.17 ; D125.A15 47.45,93.98 ; 397.97,332.74 D109.A10 ; D109.A10 398.78,333.55 ; D109.A10 398.78,331.93 ; D109.A10 399.59,332.74 ; 327.66,83.11 D301.A9 ; D301.A9 326.95,83.82 ; D301.A9 327.66,84.53 ; D301.A9 328.37,83.82 ; D102.A11 332.74,74.47 ; D102.A11 333.55,73.66 ; D102.A11 331.93,73.66 ; D102.A11 332.74,72.85 ; 317.5,57.61 D103.B5 ; D103.B5 316.69,58.42 ; D103.B5 318.31,58.42 ; D103.B5 317.5,59.23 ; D102.B2 310.69,81.28 ; D102.B2 309.07,81.28 ; D102.B2 309.88,80.47 ; D102.B2 309.88,82.09 ; D306.A8 399.49,66.04 ; D306.A8 398.78,65.33 ; D306.A8 398.07,66.04 ; D306.A8 398.78,66.75 ; 330.95,182.83 SITE4.G15 ; SITE4.G15 331.43,182.35 ; SITE4.G15 331.43,183.31 ; SITE4.G15 331.91,182.83 ; 413.31,71.12 D306.B14 ; D306.B14 414.73,71.12 ; D306.B14 414.02,71.83 ; D306.B14 414.02,70.41 ; 397.97,60.96 D107.B8 ; D107.B8 398.78,60.15 ; D107.B8 398.78,61.77 ; D107.B8 399.59,60.96 ; D119.A3 165.91,53.34 ; D119.A3 165.1,54.15 ; D119.A3 165.1,52.53 ; D119.A3 164.29,53.34 ; 329.39,388.62 D116.B8 ; D116.B8 330.2,387.81 ; D116.B8 331.01,388.62 ; D116.B8 330.2,389.43 ; 70.61,208.1 S1_I2C.4 ; S1_I2C.4 69.67,209.04 ; S1_I2C.4 70.61,209.98 ; S1_I2C.4 71.55,209.04 ; D302.B15 343.61,68.58 ; D302.B15 342.9,67.87 ; D302.B15 342.19,68.58 ; D302.B15 342.9,69.29 ; 169.47,83.82 D317.A5 ; D317.A5 170.89,83.82 ; D317.A5 170.18,84.53 ; D317.A5 170.18,83.11 ; D122.A16 271.78,77.01 ; D122.A16 272.59,76.2 ; D122.A16 270.97,76.2 ; D122.A16 271.78,75.39 ; 180.34,370.03 D231.B9 ; D231.B9 180.34,371.65 ; D231.B9 181.15,370.84 ; D231.B9 179.53,370.84 ; D317.B9 180.34,89.61 ; D317.B9 181.05,88.9 ; D317.B9 179.63,88.9 ; D317.B9 180.34,88.19 ; D126.B1 12.7,79.55 ; D126.B1 11.89,78.74 ; D126.B1 12.7,77.93 ; D126.B1 13.51,78.74 ; D127.A3 17.78,54.15 ; D127.A3 17.78,52.53 ; D127.A3 16.97,53.34 ; D127.A3 18.59,53.34 ; D108.A8 398.78,36.37 ; D108.A8 397.97,35.56 ; D108.A8 398.78,34.75 ; D108.A8 399.59,35.56 ; SITE2.G7 328.33,248.41 ; SITE2.G7 327.85,247.93 ; SITE2.G7 328.33,247.45 ; SITE2.G7 328.81,247.93 ; CSDPS229.C1 200.66,331.01 ; CSDPS229.C1 200.66,329.39 ; CSDPS229.C1 201.47,330.2 ; CSDPS229.C1 199.85,330.2 ; 24.59,96.52 D125.A6 ; D125.A6 25.4,97.33 ; D125.A6 26.21,96.52 ; D125.A6 25.4,95.71 ; D306.B11 406.4,69.29 ; D306.B11 405.69,68.58 ; D306.B11 407.11,68.58 ; D306.B11 406.4,67.87 ; 162.56,342.09 CSDPS429.B16 ; CSDPS429.B16 162.56,343.71 ; CSDPS429.B16 161.75,342.9 ; CSDPS429.B16 163.37,342.9 ; DPS8.A01 200.66,416.1 ; DPS8.A01 199.85,415.29 ; DPS8.A01 200.66,414.48 ; DPS8.A01 201.47,415.29 ; 411.48,354.79 D110.A5 ; D110.A5 410.67,355.6 ; D110.A5 411.48,356.41 ; D110.A5 412.29,355.6 ; 261.62,331.93 CSDPS225.B6 ; CSDPS225.B6 261.62,333.55 ; CSDPS225.B6 262.43,332.74 ; CSDPS225.B6 260.81,332.74 ; 42.37,93.98 D125.A13 ; D125.A13 43.18,94.79 ; D125.A13 43.18,93.17 ; D125.A13 43.99,93.98 ; D122.B11 259.89,78.74 ; D122.B11 259.08,79.55 ; D122.B11 259.08,77.93 ; D122.B11 258.27,78.74 ; D120.B9 180.34,38.91 ; D120.B9 179.53,38.1 ; D120.B9 181.15,38.1 ; D120.B9 180.34,37.29 ; D431.B13 170.18,381.81 ; D431.B13 170.18,380.19 ; D431.B13 170.99,381 ; D431.B13 169.37,381 ; D103.B8 325.93,60.96 ; D103.B8 325.12,60.15 ; D103.B8 325.12,61.77 ; D103.B8 324.31,60.96 ; 481.55,171.51 UNK4U2.4 ; UNK4U2.4 482.49,172.45 ; UNK4U2.4 483.43,171.51 ; UNK4U2.4 482.49,170.56 ; 198.12,342.09 CSDPS429.B2 ; CSDPS429.B2 198.12,343.71 ; CSDPS429.B2 198.93,342.9 ; CSDPS429.B2 197.31,342.9 ; D116.B9 328.47,391.16 ; D116.B9 326.85,391.16 ; D116.B9 327.66,390.35 ; D116.B9 327.66,391.97 ; 172.72,55.07 D119.A6 ; D119.A6 171.91,55.88 ; D119.A6 172.72,56.69 ; D119.A6 173.53,55.88 ; 387.81,373.38 D111.A14 ; D111.A14 388.62,374.19 ; D111.A14 389.43,373.38 ; D111.A14 388.62,372.57 ; D108.A6 393.7,36.37 ; D108.A6 394.51,35.56 ; D108.A6 392.89,35.56 ; D108.A6 393.7,34.75 ; D123.A12 262.43,55.88 ; D123.A12 260.81,55.88 ; D123.A12 261.62,56.69 ; D123.A12 261.62,55.07 ; 400.61,63.5 D306.A9 ; D306.A9 401.32,62.79 ; D306.A9 402.03,63.5 ; D306.A9 401.32,64.21 ; D118.B12 188.77,81.28 ; D118.B12 187.96,80.47 ; D118.B12 187.15,81.28 ; D118.B12 187.96,82.09 ; D131.A9 106.68,54.15 ; D131.A9 106.68,52.53 ; D131.A9 105.87,53.34 ; D131.A9 107.49,53.34 ; D301.B6 320.75,91.44 ; D301.B6 319.33,91.44 ; D301.B6 320.04,90.73 ; D301.B6 320.04,92.15 ; SITE3.G4 251.33,181.81 ; SITE3.G4 250.85,181.33 ; SITE3.G4 251.33,180.85 ; SITE3.G4 251.81,181.33 ; D431.A13 170.18,386.89 ; D431.A13 169.37,386.08 ; D431.A13 170.99,386.08 ; D431.A13 170.18,385.27 ; D108.A3 386.08,33.83 ; D108.A3 386.08,32.21 ; D108.A3 386.89,33.02 ; D108.A3 385.27,33.02 ; 103.33,101.6 D129.B8 ; D129.B8 104.14,100.79 ; D129.B8 104.14,102.41 ; D129.B8 104.95,101.6 ; D122.B4 241.3,82.09 ; D122.B4 242.11,81.28 ; D122.B4 240.49,81.28 ; D122.B4 241.3,80.47 ; D110.A9 401.32,356.41 ; D110.A9 400.51,355.6 ; D110.A9 402.13,355.6 ; D110.A9 401.32,354.79 ; 334.47,81.28 D102.B12 ; D102.B12 335.28,82.09 ; D102.B12 335.28,80.47 ; D102.B12 336.09,81.28 ; D318.B13 190.5,69.29 ; D318.B13 190.5,67.87 ; D318.B13 191.21,68.58 ; D318.B13 189.79,68.58 ; 398.78,39.83 D108.B8 ; D108.B8 399.59,40.64 ; D108.B8 397.97,40.64 ; D108.B8 398.78,41.45 ; 403.86,352.25 D110.A8 ; D110.A8 403.86,353.87 ; D110.A8 404.67,353.06 ; D110.A8 403.05,353.06 ; 392.89,368.3 D111.B12 ; D111.B12 393.7,369.11 ; D111.B12 393.7,367.49 ; D111.B12 394.51,368.3 ; D110.A13 391.97,355.6 ; D110.A13 391.16,356.41 ; D110.A13 390.35,355.6 ; D110.A13 391.16,354.79 ; D109.A5 411.48,336.09 ; D109.A5 411.48,334.47 ; D109.A5 410.67,335.28 ; D109.A5 412.29,335.28 ; 25.4,80.47 D126.B6 ; D126.B6 26.21,81.28 ; D126.B6 25.4,82.09 ; D126.B6 24.59,81.28 ; D118.A14 193.04,77.01 ; D118.A14 192.23,76.2 ; D118.A14 193.85,76.2 ; D118.A14 193.04,75.39 ; D124.A6 246.38,36.37 ; D124.A6 245.57,35.56 ; D124.A6 247.19,35.56 ; D124.A6 246.38,34.75 ; 273.51,340.36 CSDPS425.C1 ; CSDPS425.C1 274.32,339.55 ; CSDPS425.C1 275.13,340.36 ; CSDPS425.C1 274.32,341.17 ; 91.44,98.25 D129.B3 ; D129.B3 92.25,99.06 ; D129.B3 90.63,99.06 ; D129.B3 91.44,99.87 ; SITE2.G19 331.91,246.43 ; SITE2.G19 331.43,246.91 ; SITE2.G19 331.43,245.95 ; SITE2.G19 330.95,246.43 ; SITE3.G6 253.81,181.33 ; SITE3.G6 253.33,181.81 ; SITE3.G6 253.33,180.85 ; SITE3.G6 252.85,181.33 ; 329.33,247.45 SITE2.G8 ; SITE2.G8 329.33,248.41 ; SITE2.G8 329.81,247.93 ; SITE2.G8 328.85,247.93 ; D110.B5 411.48,351.33 ; D110.B5 411.48,349.71 ; D110.B5 412.29,350.52 ; D110.B5 410.67,350.52 ; 345.44,392.89 D116.A2 ; D116.A2 345.44,394.51 ; D116.A2 344.63,393.7 ; D116.A2 346.25,393.7 ; 47.45,58.42 D127.B15 ; D127.B15 48.26,59.23 ; D127.B15 48.26,57.61 ; D127.B15 49.07,58.42 ; D107.B6 393.7,61.77 ; D107.B6 394.51,60.96 ; D107.B6 392.89,60.96 ; D107.B6 393.7,60.15 ; 185.42,88.19 D317.B11 ; D317.B11 184.71,88.9 ; D317.B11 185.42,89.61 ; D317.B11 186.13,88.9 ; 22.86,98.25 D125.B5 ; D125.B5 22.05,99.06 ; D125.B5 22.86,99.87 ; D125.B5 23.67,99.06 ; 264.16,57.61 D123.B13 ; D123.B13 263.35,58.42 ; D123.B13 264.97,58.42 ; D123.B13 264.16,59.23 ; 390.35,33.02 D108.A5 ; D108.A5 391.97,33.02 ; D108.A5 391.16,33.83 ; D108.A5 391.16,32.21 ; 189.69,330.2 CSDPS229.C5 ; CSDPS229.C5 191.31,330.2 ; CSDPS229.C5 190.5,331.01 ; CSDPS229.C5 190.5,329.39 ; 95.71,78.74 D130.B5 ; D130.B5 96.52,79.55 ; D130.B5 97.33,78.74 ; D130.B5 96.52,77.93 ; 251.43,185.95 SITE3.G19 ; SITE3.G19 250.95,186.43 ; SITE3.G19 251.91,186.43 ; SITE3.G19 251.43,186.91 ; D102.A13 337.82,74.47 ; D102.A13 338.63,73.66 ; D102.A13 337.01,73.66 ; D102.A13 337.82,72.85 ; 14.43,81.28 D126.B2 ; D126.B2 15.24,82.09 ; D126.B2 15.24,80.47 ; D126.B2 16.05,81.28 ; D131.B10 109.22,61.77 ; D131.B10 110.03,60.96 ; D131.B10 108.41,60.96 ; D131.B10 109.22,60.15 ; 382.73,35.56 D108.A2 ; D108.A2 384.35,35.56 ; D108.A2 383.54,36.37 ; D108.A2 383.54,34.75 ; D112.B10 399.59,388.62 ; D112.B10 398.78,387.81 ; D112.B10 397.97,388.62 ; D112.B10 398.78,389.43 ; 121.92,77.93 D130.B15 ; D130.B15 121.11,78.74 ; D130.B15 121.92,79.55 ; D130.B15 122.73,78.74 ; D110.B14 389.43,347.98 ; D110.B14 388.62,348.79 ; D110.B14 387.81,347.98 ; D110.B14 388.62,347.17 ; 249.33,187.45 SITE3.G8 ; SITE3.G8 249.33,188.41 ; SITE3.G8 248.85,187.93 ; SITE3.G8 249.81,187.93 ; D128.B5 23.67,38.1 ; D128.B5 22.86,37.29 ; D128.B5 22.05,38.1 ; D128.B5 22.86,38.91 ; D102.A9 328.47,73.66 ; D102.A9 327.66,74.47 ; D102.A9 326.85,73.66 ; D102.A9 327.66,72.85 ; 329.39,332.74 D113.A8 ; D113.A8 330.2,333.55 ; D113.A8 330.2,331.93 ; D113.A8 331.01,332.74 ; D114.B13 318.31,350.52 ; D114.B13 317.5,351.33 ; D114.B13 316.69,350.52 ; D114.B13 317.5,349.71 ; CSDPS225.C5 264.16,331.01 ; CSDPS225.C5 264.97,330.2 ; CSDPS225.C5 263.35,330.2 ; CSDPS225.C5 264.16,329.39 ; 312.42,354.79 D114.A15 ; D114.A15 311.61,355.6 ; D114.A15 312.42,356.41 ; D114.A15 313.23,355.6 ; D321.B8 251.46,92.15 ; D321.B8 252.17,91.44 ; D321.B8 251.46,90.73 ; D321.B8 250.75,91.44 ; D118.A11 185.42,74.47 ; D118.A11 185.42,72.85 ; D118.A11 186.23,73.66 ; D118.A11 184.61,73.66 ; 387.91,91.44 D305.B4 ; D305.B4 388.62,92.15 ; D305.B4 389.33,91.44 ; D305.B4 388.62,90.73 ; 177.8,34.75 D120.A8 ; D120.A8 178.61,35.56 ; D120.A8 176.99,35.56 ; D120.A8 177.8,36.37 ; 337.11,83.82 D301.A13 ; D301.A13 337.82,84.53 ; D301.A13 337.82,83.11 ; D301.A13 338.53,83.82 ; 246.38,90.73 D321.B6 ; D321.B6 247.09,91.44 ; D321.B6 246.38,92.15 ; D321.B6 245.67,91.44 ; D129.B5 96.52,99.87 ; D129.B5 97.33,99.06 ; D129.B5 95.71,99.06 ; D129.B5 96.52,98.25 ; 383.54,65.33 D306.A2 ; D306.A2 382.83,66.04 ; D306.A2 384.25,66.04 ; D306.A2 383.54,66.75 ; D231.A7 186.23,375.92 ; D231.A7 185.42,376.73 ; D231.A7 185.42,375.11 ; D231.A7 184.61,375.92 ; D131.A15 122.73,53.34 ; D131.A15 121.92,52.53 ; D131.A15 121.92,54.15 ; D131.A15 121.11,53.34 ; D103.A15 343.71,53.34 ; D103.A15 342.9,52.53 ; D103.A15 342.09,53.34 ; D103.A15 342.9,54.15 ; 184.61,58.42 D119.B11 ; D119.B11 185.42,57.61 ; D119.B11 186.23,58.42 ; D119.B11 185.42,59.23 ; 327.66,88.19 D301.B9 ; D301.B9 327.66,89.61 ; D301.B9 328.37,88.9 ; D301.B9 326.95,88.9 ; 17.78,98.25 D125.B3 ; D125.B3 18.59,99.06 ; D125.B3 17.78,99.87 ; D125.B3 16.97,99.06 ; 48.26,32.21 D128.A15 ; D128.A15 49.07,33.02 ; D128.A15 47.45,33.02 ; D128.A15 48.26,33.83 ; D129.A6 99.06,97.33 ; D129.A6 99.87,96.52 ; D129.A6 98.25,96.52 ; D129.A6 99.06,95.71 ; D118.A6 173.53,76.2 ; D118.A6 171.91,76.2 ; D118.A6 172.72,75.39 ; D118.A6 172.72,77.01 ; D119.B6 172.72,61.77 ; D119.B6 173.53,60.96 ; D119.B6 172.72,60.15 ; D119.B6 171.91,60.96 ; D306.A11 406.4,64.21 ; D306.A11 406.4,62.79 ; D306.A11 407.11,63.5 ; D306.A11 405.69,63.5 ; 111.76,57.61 D131.B11 ; D131.B11 112.57,58.42 ; D131.B11 110.95,58.42 ; D131.B11 111.76,59.23 ; SITE3.G7 248.33,188.41 ; SITE3.G7 248.81,187.93 ; SITE3.G7 248.33,187.45 ; SITE3.G7 247.85,187.93 ; D116.A8 330.2,394.51 ; D116.A8 329.39,393.7 ; D116.A8 330.2,392.89 ; D116.A8 331.01,393.7 ; 114.3,100.79 D129.B12 ; D129.B12 114.3,102.41 ; D129.B12 113.49,101.6 ; D129.B12 115.11,101.6 ; 24.59,76.2 D126.A6 ; D126.A6 25.4,77.01 ; D126.A6 26.21,76.2 ; D126.A6 25.4,75.39 ; D131.A13 117.65,53.34 ; D131.A13 116.84,54.15 ; D131.A13 116.84,52.53 ; D131.A13 116.03,53.34 ; 401.32,375.11 D111.A9 ; D111.A9 400.51,375.92 ; D111.A9 402.13,375.92 ; D111.A9 401.32,376.73 ; D102.A2 310.69,76.2 ; D102.A2 309.88,77.01 ; D102.A2 309.07,76.2 ; D102.A2 309.88,75.39 ; D106.A16 419.1,77.01 ; D106.A16 419.1,75.39 ; D106.A16 418.29,76.2 ; D106.A16 419.91,76.2 ; D122.B10 256.54,82.09 ; D122.B10 255.73,81.28 ; D122.B10 257.35,81.28 ; D122.B10 256.54,80.47 ; 382.73,393.7 D112.A16 ; D112.A16 383.54,394.51 ; D112.A16 383.54,392.89 ; D112.A16 384.35,393.7 ; 249.33,240.85 SITE1.G2 ; SITE1.G2 249.81,241.33 ; SITE1.G2 248.85,241.33 ; SITE1.G2 249.33,241.81 ; D104.A3 313.23,33.02 ; D104.A3 311.61,33.02 ; D104.A3 312.42,33.83 ; D104.A3 312.42,32.21 ; 113.49,40.64 D132.B12 ; D132.B12 115.11,40.64 ; D132.B12 114.3,41.45 ; D132.B12 114.3,39.83 ; 251.33,247.45 SITE1.G10 ; SITE1.G10 251.33,248.41 ; SITE1.G10 250.85,247.93 ; SITE1.G10 251.81,247.93 ; 264.16,83.11 D321.A13 ; D321.A13 264.16,84.53 ; D321.A13 264.87,83.82 ; D321.A13 263.45,83.82 ; SITE2.G9 330.81,247.93 ; SITE2.G9 329.85,247.93 ; SITE2.G9 330.33,248.41 ; SITE2.G9 330.33,247.45 ; D116.B11 323.39,391.16 ; D116.B11 321.77,391.16 ; D116.B11 322.58,390.35 ; D116.B11 322.58,391.97 ; D102.A8 325.12,77.01 ; D102.A8 325.12,75.39 ; D102.A8 324.31,76.2 ; D102.A8 325.93,76.2 ; UNK3U1.4 97.29,162.79 ; UNK3U1.4 98.23,161.85 ; UNK3U1.4 97.29,160.91 ; UNK3U1.4 96.35,161.85 ; D112.A9 402.13,396.24 ; D112.A9 401.32,395.43 ; D112.A9 400.51,396.24 ; D112.A9 401.32,397.05 ; 342.09,38.1 D104.B15 ; D104.B15 342.9,38.91 ; D104.B15 343.71,38.1 ; D104.B15 342.9,37.29 ; 160.02,370.03 D231.B17 ; D231.B17 160.83,370.84 ; D231.B17 160.02,371.65 ; D231.B17 159.21,370.84 ; D104.A5 317.5,33.83 ; D104.A5 316.69,33.02 ; D104.A5 318.31,33.02 ; D104.A5 317.5,32.21 ; 166.83,40.64 D120.B4 ; D120.B4 167.64,39.83 ; D120.B4 167.64,41.45 ; D120.B4 168.45,40.64 ; D107.A9 401.32,54.15 ; D107.A9 401.32,52.53 ; D107.A9 402.13,53.34 ; D107.A9 400.51,53.34 ; D131.A10 110.03,55.88 ; D131.A10 108.41,55.88 ; D131.A10 109.22,55.07 ; D131.A10 109.22,56.69 ; D317.B2 162.56,92.15 ; D317.B2 162.56,90.73 ; D317.B2 161.85,91.44 ; D317.B2 163.27,91.44 ; 413.21,327.66 D109.B4 ; D109.B4 414.02,326.85 ; D109.B4 414.83,327.66 ; D109.B4 414.02,328.47 ; 195.58,72.85 D118.A15 ; D118.A15 196.39,73.66 ; D118.A15 194.77,73.66 ; D118.A15 195.58,74.47 ; D120.B3 165.91,38.1 ; D120.B3 165.1,38.91 ; D120.B3 164.29,38.1 ; D120.B3 165.1,37.29 ; D112.B8 404.67,388.62 ; D112.B8 403.86,389.43 ; D112.B8 403.86,387.81 ; D112.B8 403.05,388.62 ; 337.11,63.5 D302.A13 ; D302.A13 338.53,63.5 ; D302.A13 337.82,64.21 ; D302.A13 337.82,62.79 ; D306.B1 381.71,68.58 ; D306.B1 380.29,68.58 ; D306.B1 381,67.87 ; D306.B1 381,69.29 ; 322.58,32.21 D104.A7 ; D104.A7 322.58,33.83 ; D104.A7 323.39,33.02 ; D104.A7 321.77,33.02 ; 253.33,240.85 SITE1.G6 ; SITE1.G6 252.85,241.33 ; SITE1.G6 253.81,241.33 ; SITE1.G6 253.33,241.81 ; D108.B1 381.81,38.1 ; D108.B1 380.19,38.1 ; D108.B1 381,37.29 ; D108.B1 381,38.91 ; 271.07,71.12 D322.B16 ; D322.B16 272.49,71.12 ; D322.B16 271.78,70.41 ; D322.B16 271.78,71.83 ; 314.96,60.15 D103.B4 ; D103.B4 314.96,61.77 ; D103.B4 314.15,60.96 ; D103.B4 315.77,60.96 ; D306.B13 412.19,68.58 ; D306.B13 411.48,67.87 ; D306.B13 411.48,69.29 ; D306.B13 410.77,68.58 ; D132.A4 94.79,35.56 ; D132.A4 93.17,35.56 ; D132.A4 93.98,36.37 ; D132.A4 93.98,34.75 ; 38.1,32.21 D128.A11 ; D128.A11 38.91,33.02 ; D128.A11 37.29,33.02 ; D128.A11 38.1,33.83 ; 197.31,55.88 D119.A16 ; D119.A16 198.12,56.69 ; D119.A16 198.93,55.88 ; D119.A16 198.12,55.07 ; 177.8,65.33 D318.A8 ; D318.A8 177.8,66.75 ; D318.A8 178.51,66.04 ; D318.A8 177.09,66.04 ; 235.41,76.2 D122.A2 ; D122.A2 236.22,75.39 ; D122.A2 236.22,77.01 ; D122.A2 237.03,76.2 ; 332.74,349.71 D114.B7 ; D114.B7 332.74,351.33 ; D114.B7 331.93,350.52 ; D114.B7 333.55,350.52 ; 166.83,60.96 D119.B4 ; D119.B4 167.64,60.15 ; D119.B4 167.64,61.77 ; D119.B4 168.45,60.96 ; D116.B2 346.25,388.62 ; D116.B2 344.63,388.62 ; D116.B2 345.44,387.81 ; D116.B2 345.44,389.43 ; D125.B7 27.94,99.87 ; D125.B7 28.75,99.06 ; D125.B7 27.94,98.25 ; D125.B7 27.13,99.06 ; 88.9,60.15 D131.B2 ; D131.B2 89.71,60.96 ; D131.B2 88.09,60.96 ; D131.B2 88.9,61.77 ; 85.55,53.34 D131.A1 ; D131.A1 86.36,52.53 ; D131.A1 86.36,54.15 ; D131.A1 87.17,53.34 ; 245.57,55.88 D123.A6 ; D123.A6 246.38,56.69 ; D123.A6 246.38,55.07 ; D123.A6 247.19,55.88 ; D127.B16 51.61,60.96 ; D127.B16 50.8,61.77 ; D127.B16 50.8,60.15 ; D127.B16 49.99,60.96 ; 421.64,349.71 D110.B1 ; D110.B1 421.64,351.33 ; D110.B1 420.83,350.52 ; D110.B1 422.45,350.52 ; 255.83,66.04 D322.A10 ; D322.A10 256.54,66.75 ; D322.A10 256.54,65.33 ; D322.A10 257.25,66.04 ; 395.43,375.92 D111.A11 ; D111.A11 396.24,375.11 ; D111.A11 396.24,376.73 ; D111.A11 397.05,375.92 ; D321.A11 259.79,83.82 ; D321.A11 259.08,83.11 ; D321.A11 258.37,83.82 ; D321.A11 259.08,84.53 ; D231.B1 201.47,370.84 ; D231.B1 200.66,370.03 ; D231.B1 200.66,371.65 ; D231.B1 199.85,370.84 ; D107.A8 399.59,55.88 ; D107.A8 397.97,55.88 ; D107.A8 398.78,56.69 ; D107.A8 398.78,55.07 ; D120.B1 160.83,38.1 ; D120.B1 160.02,38.91 ; D120.B1 160.02,37.29 ; D120.B1 159.21,38.1 ; D107.B13 411.48,59.23 ; D107.B13 411.48,57.61 ; D107.B13 412.29,58.42 ; D107.B13 410.67,58.42 ; D122.A14 267.51,76.2 ; D122.A14 266.7,75.39 ; D122.A14 266.7,77.01 ; D122.A14 265.89,76.2 ; 309.17,71.12 D302.B2 ; D302.B2 310.59,71.12 ; D302.B2 309.88,71.83 ; D302.B2 309.88,70.41 ; D103.A14 341.17,55.88 ; D103.A14 339.55,55.88 ; D103.A14 340.36,56.69 ; D103.A14 340.36,55.07 ; 40.64,60.15 D127.B12 ; D127.B12 40.64,61.77 ; D127.B12 39.83,60.96 ; D127.B12 41.45,60.96 ; 330.2,80.47 D102.B10 ; D102.B10 329.39,81.28 ; D102.B10 331.01,81.28 ; D102.B10 330.2,82.09 ; 172.72,382.73 D431.A12 ; D431.A12 171.91,383.54 ; D431.A12 172.72,384.35 ; D431.A12 173.53,383.54 ; 240.59,91.44 D321.B4 ; D321.B4 242.01,91.44 ; D321.B4 241.3,92.15 ; D321.B4 241.3,90.73 ; D112.A2 419.1,394.51 ; D112.A2 419.1,392.89 ; D112.A2 419.91,393.7 ; D112.A2 418.29,393.7 ; D306.B10 404.57,71.12 ; D306.B10 403.86,71.83 ; D306.B10 403.15,71.12 ; D306.B10 403.86,70.41 ; 418.29,388.62 D112.B2 ; D112.B2 419.91,388.62 ; D112.B2 419.1,389.43 ; D112.B2 419.1,387.81 ; SITE4.G1 328.33,181.81 ; SITE4.G1 328.81,181.33 ; SITE4.G1 327.85,181.33 ; SITE4.G1 328.33,180.85 ; D125.A9 33.02,94.79 ; D125.A9 33.02,93.17 ; D125.A9 33.83,93.98 ; D125.A9 32.21,93.98 ; D115.A13 317.5,376.73 ; D115.A13 316.69,375.92 ; D115.A13 318.31,375.92 ; D115.A13 317.5,375.11 ; 170.18,52.53 D119.A5 ; D119.A5 170.99,53.34 ; D119.A5 169.37,53.34 ; D119.A5 170.18,54.15 ; D431.A11 175.26,386.89 ; D431.A11 176.07,386.08 ; D431.A11 175.26,385.27 ; D431.A11 174.45,386.08 ; 190.5,380.19 D431.B5 ; D431.B5 191.31,381 ; D431.B5 189.69,381 ; D431.B5 190.5,381.81 ; D431.B10 177.8,379.27 ; D431.B10 176.99,378.46 ; D431.B10 177.8,377.65 ; D431.B10 178.61,378.46 ; 44.91,101.6 D125.B14 ; D125.B14 45.72,100.79 ; D125.B14 46.53,101.6 ; D125.B14 45.72,102.41 ; D118.A2 162.56,77.01 ; D118.A2 161.75,76.2 ; D118.A2 162.56,75.39 ; D118.A2 163.37,76.2 ; 418.29,368.3 D111.B2 ; D111.B2 419.1,369.11 ; D111.B2 419.1,367.49 ; D111.B2 419.91,368.3 ; 182.88,55.07 D119.A10 ; D119.A10 183.69,55.88 ; D119.A10 182.07,55.88 ; D119.A10 182.88,56.69 ; 324.31,393.7 D116.A10 ; D116.A10 325.12,394.51 ; D116.A10 325.93,393.7 ; D116.A10 325.12,392.89 ; 179.53,386.08 D431.A9 ; D431.A9 181.15,386.08 ; D431.A9 180.34,385.27 ; D431.A9 180.34,386.89 ; 406.4,18.24 DPS1.C11 ; DPS1.C11 407.21,19.05 ; DPS1.C11 405.59,19.05 ; DPS1.C11 406.4,19.86 ; D122.B3 238.76,79.55 ; D122.B3 238.76,77.93 ; D122.B3 237.95,78.74 ; D122.B3 239.57,78.74 ; 400.51,58.42 D107.B9 ; D107.B9 401.32,59.23 ; D107.B9 401.32,57.61 ; D107.B9 402.13,58.42 ; 408.94,352.25 D110.A6 ; D110.A6 408.13,353.06 ; D110.A6 409.75,353.06 ; D110.A6 408.94,353.87 ; D103.B12 336.09,60.96 ; D103.B12 335.28,61.77 ; D103.B12 334.47,60.96 ; D103.B12 335.28,60.15 ; D102.B9 328.47,78.74 ; D102.B9 326.85,78.74 ; D102.B9 327.66,79.55 ; D102.B9 327.66,77.93 ; D103.A12 336.09,55.88 ; D103.A12 334.47,55.88 ; D103.A12 335.28,55.07 ; D103.A12 335.28,56.69 ; 306.63,63.5 D302.A1 ; D302.A1 307.34,62.79 ; D302.A1 308.05,63.5 ; D302.A1 307.34,64.21 ; D231.A8 182.88,374.19 ; D231.A8 182.07,373.38 ; D231.A8 182.88,372.57 ; D231.A8 183.69,373.38 ; D124.B2 236.22,41.45 ; D124.B2 237.03,40.64 ; D124.B2 236.22,39.83 ; D124.B2 235.41,40.64 ; 393.7,65.33 D306.A6 ; D306.A6 393.7,66.75 ; D306.A6 394.41,66.04 ; D306.A6 392.99,66.04 ; 88.9,80.47 D130.B2 ; D130.B2 88.09,81.28 ; D130.B2 88.9,82.09 ; D130.B2 89.71,81.28 ; 50.8,80.47 D126.B16 ; D126.B16 51.61,81.28 ; D126.B16 49.99,81.28 ; D126.B16 50.8,82.09 ; D120.A12 188.77,35.56 ; D120.A12 187.96,34.75 ; D120.A12 187.15,35.56 ; D120.A12 187.96,36.37 ; 238.76,57.61 D123.B3 ; D123.B3 239.57,58.42 ; D123.B3 237.95,58.42 ; D123.B3 238.76,59.23 ; 330.2,34.75 D104.A10 ; D104.A10 329.39,35.56 ; D104.A10 330.2,36.37 ; D104.A10 331.01,35.56 ; 256.54,60.15 D123.B10 ; D123.B10 257.35,60.96 ; D123.B10 255.73,60.96 ; D123.B10 256.54,61.77 ; D128.B8 30.48,41.45 ; D128.B8 29.67,40.64 ; D128.B8 31.29,40.64 ; D128.B8 30.48,39.83 ; 254,67.87 D322.B9 ; D322.B9 254,69.29 ; D322.B9 253.29,68.58 ; D322.B9 254.71,68.58 ; D126.A12 41.45,76.2 ; D126.A12 40.64,75.39 ; D126.A12 40.64,77.01 ; D126.A12 39.83,76.2 ; 42.37,58.42 D127.B13 ; D127.B13 43.99,58.42 ; D127.B13 43.18,57.61 ; D127.B13 43.18,59.23 ; D102.B4 315.77,81.28 ; D102.B4 314.15,81.28 ; D102.B4 314.96,80.47 ; D102.B4 314.96,82.09 ; 345.44,39.83 D104.B16 ; D104.B16 344.63,40.64 ; D104.B16 346.25,40.64 ; D104.B16 345.44,41.45 ; SITE1.G18 250.23,246.91 ; SITE1.G18 250.23,245.95 ; SITE1.G18 250.71,246.43 ; SITE1.G18 249.75,246.43 ; 237.95,330.2 CSDPS225.C15 ; CSDPS225.C15 238.76,331.01 ; CSDPS225.C15 239.57,330.2 ; CSDPS225.C15 238.76,329.39 ; D104.B5 318.31,38.1 ; D104.B5 316.69,38.1 ; D104.B5 317.5,38.91 ; D104.B5 317.5,37.29 ; D118.B14 193.85,81.28 ; D118.B14 192.23,81.28 ; D118.B14 193.04,80.47 ; D118.B14 193.04,82.09 ; 182.07,368.3 D231.B8 ; D231.B8 182.88,369.11 ; D231.B8 183.69,368.3 ; D231.B8 182.88,367.49 ; 194.77,386.08 D431.A3 ; D431.A3 195.58,386.89 ; D431.A3 196.39,386.08 ; D431.A3 195.58,385.27 ; 167.64,75.39 D118.A4 ; D118.A4 168.45,76.2 ; D118.A4 167.64,77.01 ; D118.A4 166.83,76.2 ; 250.65,55.88 D123.A8 ; D123.A8 251.46,56.69 ; D123.A8 252.27,55.88 ; D123.A8 251.46,55.07 ; D116.A13 317.5,397.05 ; D116.A13 318.31,396.24 ; D116.A13 317.5,395.43 ; D116.A13 316.69,396.24 ; 175.26,83.11 D317.A7 ; D317.A7 175.26,84.53 ; D317.A7 174.55,83.82 ; D317.A7 175.97,83.82 ; 307.34,88.19 D301.B1 ; D301.B1 306.63,88.9 ; D301.B1 308.05,88.9 ; D301.B1 307.34,89.61 ; 322.58,67.87 D302.B7 ; D302.B7 323.29,68.58 ; D302.B7 321.87,68.58 ; D302.B7 322.58,69.29 ; D130.B8 104.14,82.09 ; D130.B8 104.95,81.28 ; D130.B8 103.33,81.28 ; D130.B8 104.14,80.47 ; D116.A16 309.88,394.51 ; D116.A16 309.07,393.7 ; D116.A16 310.69,393.7 ; D116.A16 309.88,392.89 ; 42.37,73.66 D126.A13 ; D126.A13 43.18,74.47 ; D126.A13 43.18,72.85 ; D126.A13 43.99,73.66 ; D111.A12 394.51,373.38 ; D111.A12 392.89,373.38 ; D111.A12 393.7,374.19 ; D111.A12 393.7,372.57 ; D132.A8 104.95,35.56 ; D132.A8 103.33,35.56 ; D132.A8 104.14,36.37 ; D132.A8 104.14,34.75 ; D109.A7 406.4,336.09 ; D109.A7 405.59,335.28 ; D109.A7 407.21,335.28 ; D109.A7 406.4,334.47 ; 381,32.21 D108.A1 ; D108.A1 380.19,33.02 ; D108.A1 381.81,33.02 ; D108.A1 381,33.83 ; 252.85,187.93 SITE3.G12 ; SITE3.G12 253.81,187.93 ; SITE3.G12 253.33,188.41 ; SITE3.G12 253.33,187.45 ; 344.63,35.56 D104.A16 ; D104.A16 345.44,36.37 ; D104.A16 346.25,35.56 ; D104.A16 345.44,34.75 ; D118.A3 165.1,74.47 ; D118.A3 165.91,73.66 ; D118.A3 165.1,72.85 ; D118.A3 164.29,73.66 ; D108.B16 419.1,41.45 ; D108.B16 419.1,39.83 ; D108.B16 418.29,40.64 ; D108.B16 419.91,40.64 ; 116.84,72.85 D130.A13 ; D130.A13 117.65,73.66 ; D130.A13 116.03,73.66 ; D130.A13 116.84,74.47 ; 416.56,354.79 D110.A3 ; D110.A3 417.37,355.6 ; D110.A3 415.75,355.6 ; D110.A3 416.56,356.41 ; 317.5,334.47 D113.A13 ; D113.A13 317.5,336.09 ; D113.A13 318.31,335.28 ; D113.A13 316.69,335.28 ; 193.04,34.75 D120.A14 ; D120.A14 192.23,35.56 ; D120.A14 193.04,36.37 ; D120.A14 193.85,35.56 ; 330.23,182.35 SITE4.G14 ; SITE4.G14 330.23,183.31 ; SITE4.G14 330.71,182.83 ; SITE4.G14 329.75,182.83 ; 169.37,33.02 D120.A5 ; D120.A5 170.18,32.21 ; D120.A5 170.99,33.02 ; D120.A5 170.18,33.83 ; 95.71,33.02 D132.A5 ; D132.A5 96.52,33.83 ; D132.A5 97.33,33.02 ; D132.A5 96.52,32.21 ; D108.A12 408.94,36.37 ; D108.A12 409.75,35.56 ; D108.A12 408.94,34.75 ; D108.A12 408.13,35.56 ; 164.29,370.84 D231.B15 ; D231.B15 165.1,370.03 ; D231.B15 165.91,370.84 ; D231.B15 165.1,371.65 ; D301.A7 323.29,83.82 ; D301.A7 322.58,84.53 ; D301.A7 321.87,83.82 ; D301.A7 322.58,83.11 ; 321.87,63.5 D302.A7 ; D302.A7 323.29,63.5 ; D302.A7 322.58,64.21 ; D302.A7 322.58,62.79 ; 344.63,368.3 D115.B2 ; D115.B2 345.44,367.49 ; D115.B2 345.44,369.11 ; D115.B2 346.25,368.3 ; CSDPS425.B12 247.19,342.9 ; CSDPS425.B12 246.38,342.09 ; CSDPS425.B12 245.57,342.9 ; CSDPS425.B12 246.38,343.71 ; 174.45,381 D431.B11 ; D431.B11 175.26,381.81 ; D431.B11 176.07,381 ; D431.B11 175.26,380.19 ; D102.A1 308.15,73.66 ; D102.A1 307.34,72.85 ; D102.A1 307.34,74.47 ; D102.A1 306.53,73.66 ; SITE1.G12 253.81,247.93 ; SITE1.G12 253.33,248.41 ; SITE1.G12 252.85,247.93 ; SITE1.G12 253.33,247.45 ; CSDPS225.B14 241.3,333.55 ; CSDPS225.B14 242.11,332.74 ; CSDPS225.B14 241.3,331.93 ; CSDPS225.B14 240.49,332.74 ; 254,339.55 CSDPS425.C9 ; CSDPS425.C9 254,341.17 ; CSDPS425.C9 254.81,340.36 ; CSDPS425.C9 253.19,340.36 ; 342.9,32.21 D104.A15 ; D104.A15 342.09,33.02 ; D104.A15 342.9,33.83 ; D104.A15 343.71,33.02 ; D128.A12 41.45,35.56 ; D128.A12 39.83,35.56 ; D128.A12 40.64,36.37 ; D128.A12 40.64,34.75 ; 382.73,81.28 D106.B2 ; D106.B2 383.54,82.09 ; D106.B2 383.54,80.47 ; D106.B2 384.35,81.28 ; D124.A11 259.08,33.83 ; D124.A11 258.27,33.02 ; D124.A11 259.89,33.02 ; D124.A11 259.08,32.21 ; 391.16,329.39 D109.B13 ; D109.B13 391.16,331.01 ; D109.B13 391.97,330.2 ; D109.B13 390.35,330.2 ; 22.86,77.93 D126.B5 ; D126.B5 23.67,78.74 ; D126.B5 22.86,79.55 ; D126.B5 22.05,78.74 ; 19.51,96.52 D125.A4 ; D125.A4 20.32,97.33 ; D125.A4 21.13,96.52 ; D125.A4 20.32,95.71 ; 270.97,35.56 D124.A16 ; D124.A16 271.78,36.37 ; D124.A16 271.78,34.75 ; D124.A16 272.59,35.56 ; 166.93,86.36 D317.A4 ; D317.A4 168.35,86.36 ; D317.A4 167.64,85.65 ; D317.A4 167.64,87.07 ; D104.B6 320.85,40.64 ; D104.B6 320.04,39.83 ; D104.B6 320.04,41.45 ; D104.B6 319.23,40.64 ; D115.B8 330.2,369.11 ; D115.B8 330.2,367.49 ; D115.B8 329.39,368.3 ; D115.B8 331.01,368.3 ; 195.58,37.29 D120.B15 ; D120.B15 196.39,38.1 ; D120.B15 194.77,38.1 ; D120.B15 195.58,38.91 ; 96.52,72.85 D130.A5 ; D130.A5 95.71,73.66 ; D130.A5 97.33,73.66 ; D130.A5 96.52,74.47 ; 326.85,33.02 D104.A9 ; D104.A9 327.66,32.21 ; D104.A9 327.66,33.83 ; D104.A9 328.47,33.02 ; 24.59,40.64 D128.B6 ; D128.B6 25.4,39.83 ; D128.B6 26.21,40.64 ; D128.B6 25.4,41.45 ; 332.03,83.82 D301.A11 ; D301.A11 333.45,83.82 ; D301.A11 332.74,83.11 ; D301.A11 332.74,84.53 ; D431.B8 182.88,379.27 ; D431.B8 182.07,378.46 ; D431.B8 183.69,378.46 ; D431.B8 182.88,377.65 ; 27.94,57.61 D127.B7 ; D127.B7 27.13,58.42 ; D127.B7 27.94,59.23 ; D127.B7 28.75,58.42 ; 105.87,33.02 D132.A9 ; D132.A9 107.49,33.02 ; D132.A9 106.68,33.83 ; D132.A9 106.68,32.21 ; 182.07,383.54 D431.A8 ; D431.A8 183.69,383.54 ; D431.A8 182.88,384.35 ; D431.A8 182.88,382.73 ; 238.76,88.19 D321.B3 ; D321.B3 239.47,88.9 ; D321.B3 238.76,89.61 ; D321.B3 238.05,88.9 ; 314.96,90.73 D301.B4 ; D301.B4 314.25,91.44 ; D301.B4 314.96,92.15 ; D301.B4 315.67,91.44 ; 330.2,90.73 D301.B10 ; D301.B10 330.2,92.15 ; D301.B10 329.49,91.44 ; D301.B10 330.91,91.44 ; 33.02,52.53 D127.A9 ; D127.A9 32.21,53.34 ; D127.A9 33.02,54.15 ; D127.A9 33.83,53.34 ; D301.A1 308.05,83.82 ; D301.A1 306.63,83.82 ; D301.A1 307.34,83.11 ; D301.A1 307.34,84.53 ; 314.15,76.2 D102.A4 ; D102.A4 314.96,77.01 ; D102.A4 315.77,76.2 ; D102.A4 314.96,75.39 ; 311.71,83.82 D301.A3 ; D301.A3 312.42,84.53 ; D301.A3 312.42,83.11 ; D301.A3 313.13,83.82 ; 258.27,340.36 CSDPS425.C7 ; CSDPS425.C7 259.08,341.17 ; CSDPS425.C7 259.08,339.55 ; CSDPS425.C7 259.89,340.36 ; D302.A12 335.99,66.04 ; D302.A12 335.28,66.75 ; D302.A12 334.57,66.04 ; D302.A12 335.28,65.33 ; 255.83,86.36 D321.A10 ; D321.A10 256.54,85.65 ; D321.A10 257.25,86.36 ; D321.A10 256.54,87.07 ; 172.72,90.73 D317.B6 ; D317.B6 172.01,91.44 ; D317.B6 173.43,91.44 ; D317.B6 172.72,92.15 ; D126.A8 30.48,77.01 ; D126.A8 30.48,75.39 ; D126.A8 31.29,76.2 ; D126.A8 29.67,76.2 ; SITE2.G10 331.33,248.41 ; SITE2.G10 331.33,247.45 ; SITE2.G10 331.81,247.93 ; SITE2.G10 330.85,247.93 ; 408.94,367.49 D111.B6 ; D111.B6 408.13,368.3 ; D111.B6 408.94,369.11 ; D111.B6 409.75,368.3 ; D107.A14 414.02,56.69 ; D107.A14 414.83,55.88 ; D107.A14 414.02,55.07 ; D107.A14 413.21,55.88 ; 410.67,73.66 D106.A13 ; D106.A13 412.29,73.66 ; D106.A13 411.48,74.47 ; D106.A13 411.48,72.85 ; D103.A13 337.82,54.15 ; D103.A13 337.82,52.53 ; D103.A13 338.63,53.34 ; D103.A13 337.01,53.34 ; D302.B1 307.34,69.29 ; D302.B1 307.34,67.87 ; D302.B1 306.63,68.58 ; D302.B1 308.05,68.58 ; 329.85,241.33 SITE2.G3 ; SITE2.G3 330.33,241.81 ; SITE2.G3 330.81,241.33 ; SITE2.G3 330.33,240.85 ; D106.B16 419.1,82.09 ; D106.B16 418.29,81.28 ; D106.B16 419.91,81.28 ; D106.B16 419.1,80.47 ; D109.A14 389.43,332.74 ; D109.A14 388.62,333.55 ; D109.A14 388.62,331.93 ; D109.A14 387.81,332.74 ; D115.A1 347.98,376.73 ; D115.A1 348.79,375.92 ; D115.A1 347.98,375.11 ; D115.A1 347.17,375.92 ; D109.A1 421.64,336.09 ; D109.A1 421.64,334.47 ; D109.A1 422.45,335.28 ; D109.A1 420.83,335.28 ; 119.38,75.39 D130.A14 ; D130.A14 118.57,76.2 ; D130.A14 119.38,77.01 ; D130.A14 120.19,76.2 ; D317.B4 167.64,92.15 ; D317.B4 166.93,91.44 ; D317.B4 167.64,90.73 ; D317.B4 168.35,91.44 ; 415.75,330.2 D109.B3 ; D109.B3 416.56,331.01 ; D109.B3 416.56,329.39 ; D109.B3 417.37,330.2 ; 251.43,245.95 SITE1.G19 ; SITE1.G19 250.95,246.43 ; SITE1.G19 251.43,246.91 ; SITE1.G19 251.91,246.43 ; D129.B14 119.38,102.41 ; D129.B14 118.57,101.6 ; D129.B14 120.19,101.6 ; D129.B14 119.38,100.79 ; D128.A14 45.72,36.37 ; D128.A14 45.72,34.75 ; D128.A14 46.53,35.56 ; D128.A14 44.91,35.56 ; D103.B11 332.74,59.23 ; D103.B11 331.93,58.42 ; D103.B11 332.74,57.61 ; D103.B11 333.55,58.42 ; D103.A5 318.31,53.34 ; D103.A5 317.5,54.15 ; D103.A5 316.69,53.34 ; D103.A5 317.5,52.53 ; 252.33,187.45 SITE3.G11 ; SITE3.G11 251.85,187.93 ; SITE3.G11 252.81,187.93 ; SITE3.G11 252.33,188.41 ; 195.58,77.93 D118.B15 ; D118.B15 195.58,79.55 ; D118.B15 194.77,78.74 ; D118.B15 196.39,78.74 ; D306.A13 411.48,64.21 ; D306.A13 412.19,63.5 ; D306.A13 411.48,62.79 ; D306.A13 410.77,63.5 ; D103.B15 342.9,59.23 ; D103.B15 343.71,58.42 ; D103.B15 342.09,58.42 ; D103.B15 342.9,57.61 ; 321.77,330.2 D113.B11 ; D113.B11 322.58,329.39 ; D113.B11 322.58,331.01 ; D113.B11 323.39,330.2 ; D130.B13 117.65,78.74 ; D130.B13 116.84,77.93 ; D130.B13 116.03,78.74 ; D130.B13 116.84,79.55 ; 344.73,91.44 D301.B16 ; D301.B16 345.44,90.73 ; D301.B16 346.15,91.44 ; D301.B16 345.44,92.15 ; 246.38,331.93 CSDPS225.B12 ; CSDPS225.B12 245.57,332.74 ; CSDPS225.B12 246.38,333.55 ; CSDPS225.B12 247.19,332.74 ; D128.A10 35.56,36.37 ; D128.A10 35.56,34.75 ; D128.A10 36.37,35.56 ; D128.A10 34.75,35.56 ; 395.43,396.24 D112.A11 ; D112.A11 396.24,397.05 ; D112.A11 397.05,396.24 ; D112.A11 396.24,395.43 ; D321.B1 234.39,88.9 ; D321.B1 233.68,88.19 ; D321.B1 233.68,89.61 ; D321.B1 232.97,88.9 ; 250.65,35.56 D124.A8 ; D124.A8 252.27,35.56 ; D124.A8 251.46,36.37 ; D124.A8 251.46,34.75 ; 172.01,86.36 D317.A6 ; D317.A6 173.43,86.36 ; D317.A6 172.72,85.65 ; D317.A6 172.72,87.07 ; D118.A13 190.5,74.47 ; D118.A13 190.5,72.85 ; D118.A13 189.69,73.66 ; D118.A13 191.31,73.66 ; 90.63,73.66 D130.A3 ; D130.A3 91.44,72.85 ; D130.A3 91.44,74.47 ; D130.A3 92.25,73.66 ; D129.A2 88.9,97.33 ; D129.A2 89.71,96.52 ; D129.A2 88.09,96.52 ; D129.A2 88.9,95.71 ; D306.A10 404.57,66.04 ; D306.A10 403.86,66.75 ; D306.A10 403.15,66.04 ; D306.A10 403.86,65.33 ; D123.B12 262.43,60.96 ; D123.B12 261.62,60.15 ; D123.B12 261.62,61.77 ; D123.B12 260.81,60.96 ; CSDPS429.B6 188.77,342.9 ; CSDPS429.B6 187.96,343.71 ; CSDPS429.B6 187.96,342.09 ; CSDPS429.B6 187.15,342.9 ; D106.A8 398.78,77.01 ; D106.A8 398.78,75.39 ; D106.A8 399.59,76.2 ; D106.A8 397.97,76.2 ; 416.56,62.79 D306.A15 ; D306.A15 417.27,63.5 ; D306.A15 416.56,64.21 ; D306.A15 415.85,63.5 ; 193.04,85.65 D317.A14 ; D317.A14 193.75,86.36 ; D317.A14 193.04,87.07 ; D317.A14 192.33,86.36 ; D231.A15 165.91,375.92 ; D231.A15 165.1,375.11 ; D231.A15 164.29,375.92 ; D231.A15 165.1,376.73 ; D321.B10 256.54,92.15 ; D321.B10 257.25,91.44 ; D321.B10 255.83,91.44 ; D321.B10 256.54,90.73 ; D108.A16 419.91,35.56 ; D108.A16 419.1,36.37 ; D108.A16 418.29,35.56 ; D108.A16 419.1,34.75 ; 174.45,78.74 D118.B7 ; D118.B7 176.07,78.74 ; D118.B7 175.26,77.93 ; D118.B7 175.26,79.55 ; 311.61,375.92 D115.A15 ; D115.A15 312.42,376.73 ; D115.A15 312.42,375.11 ; D115.A15 313.23,375.92 ; D231.A10 178.61,373.38 ; D231.A10 177.8,372.57 ; D231.A10 176.99,373.38 ; D231.A10 177.8,374.19 ; SITE3.G20 253.11,186.43 ; SITE3.G20 252.63,185.95 ; SITE3.G20 252.15,186.43 ; SITE3.G20 252.63,186.91 ; D124.A3 238.76,33.83 ; D124.A3 237.95,33.02 ; D124.A3 239.57,33.02 ; D124.A3 238.76,32.21 ; SITE4.G10 331.33,188.41 ; SITE4.G10 331.33,187.45 ; SITE4.G10 330.85,187.93 ; SITE4.G10 331.81,187.93 ; D305.A2 383.54,87.07 ; D305.A2 382.83,86.36 ; D305.A2 383.54,85.65 ; D305.A2 384.25,86.36 ; 406.4,88.19 D305.B11 ; D305.B11 407.11,88.9 ; D305.B11 406.4,89.61 ; D305.B11 405.69,88.9 ; D305.B12 408.94,92.15 ; D305.B12 408.23,91.44 ; D305.B12 409.65,91.44 ; D305.B12 408.94,90.73 ; D431.A6 187.96,384.35 ; D431.A6 187.15,383.54 ; D431.A6 188.77,383.54 ; D431.A6 187.96,382.73 ; D127.A16 51.61,55.88 ; D127.A16 50.8,56.69 ; D127.A16 49.99,55.88 ; D127.A16 50.8,55.07 ; D126.B13 43.18,79.55 ; D126.B13 43.18,77.93 ; D126.B13 43.99,78.74 ; D126.B13 42.37,78.74 ; 314.96,65.33 D302.A4 ; D302.A4 314.25,66.04 ; D302.A4 314.96,66.75 ; D302.A4 315.67,66.04 ; SITE4.G12 333.33,188.41 ; SITE4.G12 333.33,187.45 ; SITE4.G12 333.81,187.93 ; SITE4.G12 332.85,187.93 ; D132.B9 106.68,38.91 ; D132.B9 105.87,38.1 ; D132.B9 106.68,37.29 ; D132.B9 107.49,38.1 ; D306.A4 389.33,66.04 ; D306.A4 388.62,66.75 ; D306.A4 388.62,65.33 ; D306.A4 387.91,66.04 ; 174.55,68.58 D318.B7 ; D318.B7 175.97,68.58 ; D318.B7 175.26,67.87 ; D318.B7 175.26,69.29 ; 197.31,40.64 D120.B16 ; D120.B16 198.12,41.45 ; D120.B16 198.93,40.64 ; D120.B16 198.12,39.83 ; D111.A15 386.08,376.73 ; D111.A15 386.89,375.92 ; D111.A15 386.08,375.11 ; D111.A15 385.27,375.92 ; 243.03,33.02 D124.A5 ; D124.A5 243.84,32.21 ; D124.A5 244.65,33.02 ; D124.A5 243.84,33.83 ; 197.31,60.96 D119.B16 ; D119.B16 198.93,60.96 ; D119.B16 198.12,61.77 ; D119.B16 198.12,60.15 ; 199.85,410.21 DPS8.C01 ; DPS8.C01 200.66,411.02 ; DPS8.C01 200.66,409.4 ; DPS8.C01 201.47,410.21 ; CSDPS229.B10 178.61,332.74 ; CSDPS229.B10 177.8,333.55 ; CSDPS229.B10 177.8,331.93 ; CSDPS229.B10 176.99,332.74 ; D128.A3 18.59,33.02 ; D128.A3 16.97,33.02 ; D128.A3 17.78,33.83 ; D128.A3 17.78,32.21 ; 15.24,39.83 D128.B2 ; D128.B2 15.24,41.45 ; D128.B2 14.43,40.64 ; D128.B2 16.05,40.64 ; D107.A16 419.1,56.69 ; D107.A16 418.29,55.88 ; D107.A16 419.1,55.07 ; D107.A16 419.91,55.88 ; CSDPS225.C1 274.32,331.01 ; CSDPS225.C1 274.32,329.39 ; CSDPS225.C1 275.13,330.2 ; CSDPS225.C1 273.51,330.2 ; DPS2.C05 337.82,411.02 ; DPS2.C05 338.63,410.21 ; DPS2.C05 337.01,410.21 ; DPS2.C05 337.82,409.4 ; 180.34,67.87 D318.B9 ; D318.B9 179.63,68.58 ; D318.B9 180.34,69.29 ; D318.B9 181.05,68.58 ; 48.26,52.53 D127.A15 ; D127.A15 49.07,53.34 ; D127.A15 48.26,54.15 ; D127.A15 47.45,53.34 ; D130.A7 102.41,73.66 ; D130.A7 100.79,73.66 ; D130.A7 101.6,72.85 ; D130.A7 101.6,74.47 ; D104.B2 309.88,41.45 ; D104.B2 309.88,39.83 ; D104.B2 310.69,40.64 ; D104.B2 309.07,40.64 ; D102.B8 325.93,81.28 ; D102.B8 324.31,81.28 ; D102.B8 325.12,82.09 ; D102.B8 325.12,80.47 ; 335.28,39.83 D104.B12 ; D104.B12 335.28,41.45 ; D104.B12 336.09,40.64 ; D104.B12 334.47,40.64 ; 386.08,52.53 D107.A3 ; D107.A3 386.08,54.15 ; D107.A3 386.89,53.34 ; D107.A3 385.27,53.34 ; 19.51,35.56 D128.A4 ; D128.A4 20.32,36.37 ; D128.A4 21.13,35.56 ; D128.A4 20.32,34.75 ; D102.B5 317.5,79.55 ; D102.B5 317.5,77.93 ; D102.B5 318.31,78.74 ; D102.B5 316.69,78.74 ; 415.85,68.58 D306.B15 ; D306.B15 416.56,69.29 ; D306.B15 416.56,67.87 ; D306.B15 417.27,68.58 ; 246.38,85.65 D321.A6 ; D321.A6 245.67,86.36 ; D321.A6 247.09,86.36 ; D321.A6 246.38,87.07 ; D231.A17 160.83,375.92 ; D231.A17 159.21,375.92 ; D231.A17 160.02,375.11 ; D231.A17 160.02,376.73 ; D114.A8 330.2,353.87 ; D114.A8 329.39,353.06 ; D114.A8 331.01,353.06 ; D114.A8 330.2,352.25 ; D113.B12 320.04,328.47 ; D113.B12 319.23,327.66 ; D113.B12 320.04,326.85 ; D113.B12 320.85,327.66 ; D306.B6 393.7,71.83 ; D306.B6 393.7,70.41 ; D306.B6 392.99,71.12 ; D306.B6 394.41,71.12 ; D106.A12 409.75,76.2 ; D106.A12 408.94,75.39 ; D106.A12 408.94,77.01 ; D106.A12 408.13,76.2 ; D322.A13 264.16,64.21 ; D322.A13 263.45,63.5 ; D322.A13 264.87,63.5 ; D322.A13 264.16,62.79 ; DPS2.A11 322.58,416.1 ; DPS2.A11 322.58,414.48 ; DPS2.A11 323.39,415.29 ; DPS2.A11 321.77,415.29 ; 27.13,73.66 D126.A7 ; D126.A7 28.75,73.66 ; D126.A7 27.94,72.85 ; D126.A7 27.94,74.47 ; D317.B16 198.12,92.15 ; D317.B16 197.41,91.44 ; D317.B16 198.83,91.44 ; D317.B16 198.12,90.73 ; 405.59,53.34 D107.A11 ; D107.A11 406.4,52.53 ; D107.A11 406.4,54.15 ; D107.A11 407.21,53.34 ; 252.63,182.35 SITE3.G16 ; SITE3.G16 252.63,183.31 ; SITE3.G16 252.15,182.83 ; SITE3.G16 253.11,182.83 ; 342.09,370.84 D115.B3 ; D115.B3 343.71,370.84 ; D115.B3 342.9,371.65 ; D115.B3 342.9,370.03 ; 337.01,38.1 D104.B13 ; D104.B13 337.82,37.29 ; D104.B13 338.63,38.1 ; D104.B13 337.82,38.91 ; D114.B8 331.01,347.98 ; D114.B8 330.2,348.79 ; D114.B8 329.39,347.98 ; D114.B8 330.2,347.17 ; D305.B5 391.16,89.61 ; D305.B5 390.45,88.9 ; D305.B5 391.87,88.9 ; D305.B5 391.16,88.19 ; CSDPS225.B8 256.54,333.55 ; CSDPS225.B8 257.35,332.74 ; CSDPS225.B8 256.54,331.93 ; CSDPS225.B8 255.73,332.74 ; D302.A6 320.75,66.04 ; D302.A6 320.04,65.33 ; D302.A6 320.04,66.75 ; D302.A6 319.33,66.04 ; 37.29,38.1 D128.B11 ; D128.B11 38.1,37.29 ; D128.B11 38.1,38.91 ; D128.B11 38.91,38.1 ; 403.86,392.89 D112.A8 ; D112.A8 403.05,393.7 ; D112.A8 403.86,394.51 ; D112.A8 404.67,393.7 ; D318.A6 172.72,66.75 ; D318.A6 172.01,66.04 ; D318.A6 173.43,66.04 ; D318.A6 172.72,65.33 ; 324.31,35.56 D104.A8 ; D104.A8 325.12,34.75 ; D104.A8 325.12,36.37 ; D104.A8 325.93,35.56 ; 99.06,55.07 D131.A6 ; D131.A6 98.25,55.88 ; D131.A6 99.06,56.69 ; D131.A6 99.87,55.88 ; UNK2U1.4 482.59,229.49 ; UNK2U1.4 482.59,227.61 ; UNK2U1.4 481.65,228.55 ; UNK2U1.4 483.53,228.55 ; D119.A11 186.23,53.34 ; D119.A11 185.42,52.53 ; D119.A11 185.42,54.15 ; D119.A11 184.61,53.34 ; 401.32,390.35 D112.B9 ; D112.B9 402.13,391.16 ; D112.B9 400.51,391.16 ; D112.B9 401.32,391.97 ; 387.91,71.12 D306.B4 ; D306.B4 388.62,71.83 ; D306.B4 389.33,71.12 ; D306.B4 388.62,70.41 ; D131.B4 94.79,60.96 ; D131.B4 93.98,60.15 ; D131.B4 93.17,60.96 ; D131.B4 93.98,61.77 ; D112.A3 416.56,397.05 ; D112.A3 416.56,395.43 ; D112.A3 417.37,396.24 ; D112.A3 415.75,396.24 ; CSDPS425.B16 236.22,343.71 ; CSDPS425.B16 235.41,342.9 ; CSDPS425.B16 236.22,342.09 ; CSDPS425.B16 237.03,342.9 ; DPS3.C15 269.24,19.86 ; DPS3.C15 270.05,19.05 ; DPS3.C15 268.43,19.05 ; DPS3.C15 269.24,18.24 ; CSDPS425.C11 249.73,340.36 ; CSDPS425.C11 248.11,340.36 ; CSDPS425.C11 248.92,339.55 ; CSDPS425.C11 248.92,341.17 ; D131.B9 106.68,59.23 ; D131.B9 107.49,58.42 ; D131.B9 106.68,57.61 ; D131.B9 105.87,58.42 ; D126.A14 46.53,76.2 ; D126.A14 45.72,75.39 ; D126.A14 45.72,77.01 ; D126.A14 44.91,76.2 ; 405.59,330.2 D109.B7 ; D109.B7 406.4,331.01 ; D109.B7 407.21,330.2 ; D109.B7 406.4,329.39 ; 312.42,414.48 DPS2.A15 ; DPS2.A15 312.42,416.1 ; DPS2.A15 313.23,415.29 ; DPS2.A15 311.61,415.29 ; 420.83,375.92 D111.A1 ; D111.A1 421.64,375.11 ; D111.A1 422.45,375.92 ; D111.A1 421.64,376.73 ; D302.A5 317.5,64.21 ; D302.A5 318.21,63.5 ; D302.A5 316.79,63.5 ; D302.A5 317.5,62.79 ; D318.A12 187.96,66.75 ; D318.A12 187.96,65.33 ; D318.A12 188.67,66.04 ; D318.A12 187.25,66.04 ; D102.B15 342.9,79.55 ; D102.B15 342.09,78.74 ; D102.B15 342.9,77.93 ; D102.B15 343.71,78.74 ; 232.87,73.66 D122.A1 ; D122.A1 233.68,74.47 ; D122.A1 233.68,72.85 ; D122.A1 234.49,73.66 ; D305.A1 381.71,83.82 ; D305.A1 381,84.53 ; D305.A1 381,83.11 ; D305.A1 380.29,83.82 ; 198.12,377.65 D431.B2 ; D431.B2 198.12,379.27 ; D431.B2 198.93,378.46 ; D431.B2 197.31,378.46 ; D114.B4 340.36,348.79 ; D114.B4 340.36,347.17 ; D114.B4 341.17,347.98 ; D114.B4 339.55,347.98 ; 330.23,245.95 SITE2.G18 ; SITE2.G18 330.71,246.43 ; SITE2.G18 329.75,246.43 ; SITE2.G18 330.23,246.91 ; D306.A3 386.08,64.21 ; D306.A3 386.08,62.79 ; D306.A3 386.79,63.5 ; D306.A3 385.37,63.5 ; 309.88,34.75 D104.A2 ; D104.A2 309.88,36.37 ; D104.A2 310.69,35.56 ; D104.A2 309.07,35.56 ; DPS3.A05 243.84,14.78 ; DPS3.A05 243.03,13.97 ; DPS3.A05 244.65,13.97 ; DPS3.A05 243.84,13.16 ; CSDPS429.C3 196.39,340.36 ; CSDPS429.C3 194.77,340.36 ; CSDPS429.C3 195.58,341.17 ; CSDPS429.C3 195.58,339.55 ; D321.A1 234.39,83.82 ; D321.A1 233.68,84.53 ; D321.A1 232.97,83.82 ; D321.A1 233.68,83.11 ; D107.A5 391.16,54.15 ; D107.A5 390.35,53.34 ; D107.A5 391.16,52.53 ; D107.A5 391.97,53.34 ; 339.55,76.2 D102.A14 ; D102.A14 341.17,76.2 ; D102.A14 340.36,77.01 ; D102.A14 340.36,75.39 ; 381,88.19 D305.B1 ; D305.B1 381,89.61 ; D305.B1 381.71,88.9 ; D305.B1 380.29,88.9 ; 347.98,354.79 D114.A1 ; D114.A1 347.98,356.41 ; D114.A1 347.17,355.6 ; D114.A1 348.79,355.6 ; SITE1.G4 251.33,241.81 ; SITE1.G4 250.85,241.33 ; SITE1.G4 251.33,240.85 ; SITE1.G4 251.81,241.33 ; D126.A11 38.1,74.47 ; D126.A11 38.1,72.85 ; D126.A11 37.29,73.66 ; D126.A11 38.91,73.66 ; D321.B14 267.41,91.44 ; D321.B14 266.7,92.15 ; D321.B14 266.7,90.73 ; D321.B14 265.99,91.44 ; 101.6,32.21 D132.A7 ; D132.A7 102.41,33.02 ; D132.A7 100.79,33.02 ; D132.A7 101.6,33.83 ; D124.B11 259.08,38.91 ; D124.B11 258.27,38.1 ; D124.B11 259.08,37.29 ; D124.B11 259.89,38.1 ; 165.1,62.79 D318.A3 ; D318.A3 164.39,63.5 ; D318.A3 165.1,64.21 ; D318.A3 165.81,63.5 ; 255.83,71.12 D322.B10 ; D322.B10 256.54,70.41 ; D322.B10 257.25,71.12 ; D322.B10 256.54,71.83 ; D119.B1 160.02,59.23 ; D119.B1 159.21,58.42 ; D119.B1 160.83,58.42 ; D119.B1 160.02,57.61 ; D108.B13 411.48,38.91 ; D108.B13 410.67,38.1 ; D108.B13 412.29,38.1 ; D108.B13 411.48,37.29 ; D112.A4 414.02,394.51 ; D112.A4 413.21,393.7 ; D112.A4 414.02,392.89 ; D112.A4 414.83,393.7 ; 312.42,390.35 D116.B15 ; D116.B15 312.42,391.97 ; D116.B15 313.23,391.16 ; D116.B15 311.61,391.16 ; D431.A15 165.91,386.08 ; D431.A15 165.1,385.27 ; D431.A15 164.29,386.08 ; D431.A15 165.1,386.89 ; D317.A15 195.58,84.53 ; D317.A15 195.58,83.11 ; D317.A15 196.29,83.82 ; D317.A15 194.87,83.82 ; D111.B4 414.83,368.3 ; D111.B4 414.02,367.49 ; D111.B4 414.02,369.11 ; D111.B4 413.21,368.3 ; 250.65,81.28 D122.B8 ; D122.B8 251.46,80.47 ; D122.B8 252.27,81.28 ; D122.B8 251.46,82.09 ; D129.B7 102.41,99.06 ; D129.B7 101.6,99.87 ; D129.B7 101.6,98.25 ; D129.B7 100.79,99.06 ; D125.B10 36.37,101.6 ; D125.B10 34.75,101.6 ; D125.B10 35.56,102.41 ; D125.B10 35.56,100.79 ; 337.01,330.2 D113.B5 ; D113.B5 337.82,329.39 ; D113.B5 338.63,330.2 ; D113.B5 337.82,331.01 ; 170.18,339.55 CSDPS429.C13 ; CSDPS429.C13 169.37,340.36 ; CSDPS429.C13 170.18,341.17 ; CSDPS429.C13 170.99,340.36 ; 45.72,80.47 D126.B14 ; D126.B14 45.72,82.09 ; D126.B14 46.53,81.28 ; D126.B14 44.91,81.28 ; D128.A5 22.86,33.83 ; D128.A5 22.86,32.21 ; D128.A5 23.67,33.02 ; D128.A5 22.05,33.02 ; D129.B1 87.17,99.06 ; D129.B1 85.55,99.06 ; D129.B1 86.36,99.87 ; D129.B1 86.36,98.25 ; 324.41,86.36 D301.A8 ; D301.A8 325.12,85.65 ; D301.A8 325.12,87.07 ; D301.A8 325.83,86.36 ; D125.A5 23.67,93.98 ; D125.A5 22.86,94.79 ; D125.A5 22.86,93.17 ; D125.A5 22.05,93.98 ; 184.61,340.36 CSDPS429.C7 ; CSDPS429.C7 185.42,341.17 ; CSDPS429.C7 185.42,339.55 ; CSDPS429.C7 186.23,340.36 ; D115.A8 330.2,374.19 ; D115.A8 331.01,373.38 ; D115.A8 330.2,372.57 ; D115.A8 329.39,373.38 ; D301.B11 332.74,89.61 ; D301.B11 332.03,88.9 ; D301.B11 333.45,88.9 ; D301.B11 332.74,88.19 ; D120.A2 162.56,36.37 ; D120.A2 161.75,35.56 ; D120.A2 163.37,35.56 ; D120.A2 162.56,34.75 ; 416.56,32.21 D108.A15 ; D108.A15 416.56,33.83 ; D108.A15 415.75,33.02 ; D108.A15 417.37,33.02 ; D318.B8 177.8,71.83 ; D318.B8 177.8,70.41 ; D318.B8 178.51,71.12 ; D318.B8 177.09,71.12 ; D125.B8 30.48,102.41 ; D125.B8 31.29,101.6 ; D125.B8 30.48,100.79 ; D125.B8 29.67,101.6 ; D431.B6 187.96,379.27 ; D431.B6 187.96,377.65 ; D431.B6 187.15,378.46 ; D431.B6 188.77,378.46 ; DPS8.A11 176.07,415.29 ; DPS8.A11 174.45,415.29 ; DPS8.A11 175.26,416.1 ; DPS8.A11 175.26,414.48 ; D231.B16 162.56,369.11 ; D231.B16 162.56,367.49 ; D231.B16 163.37,368.3 ; D231.B16 161.75,368.3 ; 327.66,354.79 D114.A9 ; D114.A9 327.66,356.41 ; D114.A9 328.47,355.6 ; D114.A9 326.85,355.6 ; 311.71,63.5 D302.A3 ; D302.A3 313.13,63.5 ; D302.A3 312.42,64.21 ; D302.A3 312.42,62.79 ; D109.B15 386.89,330.2 ; D109.B15 385.27,330.2 ; D109.B15 386.08,331.01 ; D109.B15 386.08,329.39 ; D118.A7 175.26,74.47 ; D118.A7 176.07,73.66 ; D118.A7 174.45,73.66 ; D118.A7 175.26,72.85 ; 177.8,55.07 D119.A8 ; D119.A8 177.8,56.69 ; D119.A8 178.61,55.88 ; D119.A8 176.99,55.88 ; 388.62,55.07 D107.A4 ; D107.A4 387.81,55.88 ; D107.A4 389.43,55.88 ; D107.A4 388.62,56.69 ; D322.A14 267.41,66.04 ; D322.A14 265.99,66.04 ; D322.A14 266.7,66.75 ; D322.A14 266.7,65.33 ; D112.B7 406.4,391.97 ; D112.B7 405.59,391.16 ; D112.B7 407.21,391.16 ; D112.B7 406.4,390.35 ; 400.51,370.84 D111.B9 ; D111.B9 401.32,370.03 ; D111.B9 402.13,370.84 ; D111.B9 401.32,371.65 ; 335.28,331.93 D113.A6 ; D113.A6 336.09,332.74 ; D113.A6 335.28,333.55 ; D113.A6 334.47,332.74 ; D111.A10 398.78,374.19 ; D111.A10 397.97,373.38 ; D111.A10 399.59,373.38 ; D111.A10 398.78,372.57 ; 403.86,60.15 D107.B10 ; D107.B10 404.67,60.96 ; D107.B10 403.86,61.77 ; D107.B10 403.05,60.96 ; D119.A7 175.26,54.15 ; D119.A7 176.07,53.34 ; D119.A7 175.26,52.53 ; D119.A7 174.45,53.34 ; D231.A12 172.72,374.19 ; D231.A12 172.72,372.57 ; D231.A12 171.91,373.38 ; D231.A12 173.53,373.38 ; D111.A7 406.4,376.73 ; D111.A7 406.4,375.11 ; D111.A7 405.59,375.92 ; D111.A7 407.21,375.92 ; 327.66,62.79 D302.A9 ; D302.A9 327.66,64.21 ; D302.A9 326.95,63.5 ; D302.A9 328.37,63.5 ; 342.19,63.5 D302.A15 ; D302.A15 342.9,62.79 ; D302.A15 343.61,63.5 ; D302.A15 342.9,64.21 ; 337.82,32.21 D104.A13 ; D104.A13 337.82,33.83 ; D104.A13 338.63,33.02 ; D104.A13 337.01,33.02 ; 266.7,55.07 D123.A14 ; D123.A14 265.89,55.88 ; D123.A14 266.7,56.69 ; D123.A14 267.51,55.88 ; D318.B6 172.72,71.83 ; D318.B6 172.01,71.12 ; D318.B6 172.72,70.41 ; D318.B6 173.43,71.12 ; D318.A10 183.59,66.04 ; D318.A10 182.17,66.04 ; D318.A10 182.88,65.33 ; D318.A10 182.88,66.75 ; D126.B8 30.48,82.09 ; D126.B8 31.29,81.28 ; D126.B8 30.48,80.47 ; D126.B8 29.67,81.28 ; D102.B13 337.82,79.55 ; D102.B13 338.63,78.74 ; D102.B13 337.82,77.93 ; D102.B13 337.01,78.74 ; 165.1,83.11 D317.A3 ; D317.A3 164.39,83.82 ; D317.A3 165.81,83.82 ; D317.A3 165.1,84.53 ; 332.33,247.45 SITE2.G11 ; SITE2.G11 332.81,247.93 ; SITE2.G11 332.33,248.41 ; SITE2.G11 331.85,247.93 ; 200.66,339.55 CSDPS429.C1 ; CSDPS429.C1 200.66,341.17 ; CSDPS429.C1 201.47,340.36 ; CSDPS429.C1 199.85,340.36 ; 332.74,67.87 D302.B11 ; D302.B11 333.45,68.58 ; D302.B11 332.74,69.29 ; D302.B11 332.03,68.58 ; D322.B14 266.7,71.83 ; D322.B14 267.41,71.12 ; D322.B14 266.7,70.41 ; D322.B14 265.99,71.12 ; 104.14,75.39 D130.A8 ; D130.A8 104.95,76.2 ; D130.A8 103.33,76.2 ; D130.A8 104.14,77.01 ; D114.B10 325.93,347.98 ; D114.B10 325.12,347.17 ; D114.B10 324.31,347.98 ; D114.B10 325.12,348.79 ; 317.5,83.11 D301.A5 ; D301.A5 318.21,83.82 ; D301.A5 317.5,84.53 ; D301.A5 316.79,83.82 ; 342.9,395.43 D116.A3 ; D116.A3 342.9,397.05 ; D116.A3 342.09,396.24 ; D116.A3 343.71,396.24 ; 258.27,73.66 D122.A11 ; D122.A11 259.89,73.66 ; D122.A11 259.08,74.47 ; D122.A11 259.08,72.85 ; 337.82,395.43 D116.A5 ; D116.A5 337.01,396.24 ; D116.A5 337.82,397.05 ; D116.A5 338.63,396.24 ; CSDPS429.B14 167.64,343.71 ; CSDPS429.B14 168.45,342.9 ; CSDPS429.B14 167.64,342.09 ; CSDPS429.B14 166.83,342.9 ; 382.73,76.2 D106.A2 ; D106.A2 384.35,76.2 ; D106.A2 383.54,75.39 ; D106.A2 383.54,77.01 ; 198.12,382.73 D431.A2 ; D431.A2 198.12,384.35 ; D431.A2 197.31,383.54 ; D431.A2 198.93,383.54 ; 270.97,342.9 CSDPS425.B2 ; CSDPS425.B2 272.59,342.9 ; CSDPS425.B2 271.78,343.71 ; CSDPS425.B2 271.78,342.09 ; 166.83,373.38 D231.A14 ; D231.A14 167.64,372.57 ; D231.A14 168.45,373.38 ; D231.A14 167.64,374.19 ; 248.11,78.74 D122.B7 ; D122.B7 248.92,77.93 ; D122.B7 249.73,78.74 ; D122.B7 248.92,79.55 ; 165.1,409.4 DPS8.C15 ; DPS8.C15 164.29,410.21 ; DPS8.C15 165.91,410.21 ; DPS8.C15 165.1,411.02 ; D306.B8 398.78,71.83 ; D306.B8 399.49,71.12 ; D306.B8 398.07,71.12 ; D306.B8 398.78,70.41 ; D124.B12 262.43,40.64 ; D124.B12 261.62,39.83 ; D124.B12 261.62,41.45 ; D124.B12 260.81,40.64 ; D131.A12 115.11,55.88 ; D131.A12 113.49,55.88 ; D131.A12 114.3,55.07 ; D131.A12 114.3,56.69 ; D302.B4 315.67,71.12 ; D302.B4 314.25,71.12 ; D302.B4 314.96,70.41 ; D302.B4 314.96,71.83 ; 327.85,241.33 SITE2.G1 ; SITE2.G1 328.33,240.85 ; SITE2.G1 328.33,241.81 ; SITE2.G1 328.81,241.33 ; 124.46,60.15 D131.B16 ; D131.B16 123.65,60.96 ; D131.B16 125.27,60.96 ; D131.B16 124.46,61.77 ; D120.A10 183.69,35.56 ; D120.A10 182.88,34.75 ; D120.A10 182.07,35.56 ; D120.A10 182.88,36.37 ; 322.58,57.61 D103.B7 ; D103.B7 323.39,58.42 ; D103.B7 322.58,59.23 ; D103.B7 321.77,58.42 ; 113.49,76.2 D130.A12 ; D130.A12 114.3,75.39 ; D130.A12 114.3,77.01 ; D130.A12 115.11,76.2 ; DPS2.A05 338.63,415.29 ; DPS2.A05 337.82,416.1 ; DPS2.A05 337.82,414.48 ; DPS2.A05 337.01,415.29 ; 347.17,335.28 D113.A1 ; D113.A1 347.98,334.47 ; D113.A1 347.98,336.09 ; D113.A1 348.79,335.28 ; D131.A3 91.44,54.15 ; D131.A3 91.44,52.53 ; D131.A3 90.63,53.34 ; D131.A3 92.25,53.34 ; D321.B16 271.78,92.15 ; D321.B16 272.49,91.44 ; D321.B16 271.07,91.44 ; D321.B16 271.78,90.73 ; 387.81,76.2 D106.A4 ; D106.A4 388.62,77.01 ; D106.A4 388.62,75.39 ; D106.A4 389.43,76.2 ; 86.36,37.29 D132.B1 ; D132.B1 87.17,38.1 ; D132.B1 85.55,38.1 ; D132.B1 86.36,38.91 ; DPS1.A11 406.4,14.78 ; DPS1.A11 407.21,13.97 ; DPS1.A11 405.59,13.97 ; DPS1.A11 406.4,13.16 ; 347.98,390.35 D116.B1 ; D116.B1 348.79,391.16 ; D116.B1 347.98,391.97 ; D116.B1 347.17,391.16 ; D106.B7 396.24,79.55 ; D106.B7 395.43,78.74 ; D106.B7 396.24,77.93 ; D106.B7 397.05,78.74 ; 332.74,62.79 D302.A11 ; D302.A11 332.74,64.21 ; D302.A11 333.45,63.5 ; D302.A11 332.03,63.5 ; CSDPS425.B14 242.11,342.9 ; CSDPS425.B14 241.3,343.71 ; CSDPS425.B14 241.3,342.09 ; CSDPS425.B14 240.49,342.9 ; 415.85,88.9 D305.B15 ; D305.B15 416.56,89.61 ; D305.B15 416.56,88.19 ; D305.B15 417.27,88.9 ; 306.53,33.02 D104.A1 ; D104.A1 307.34,33.83 ; D104.A1 307.34,32.21 ; D104.A1 308.15,33.02 ; D130.B12 115.11,81.28 ; D130.B12 114.3,82.09 ; D130.B12 114.3,80.47 ; D130.B12 113.49,81.28 ; 319.23,347.98 D114.B12 ; D114.B12 320.04,347.17 ; D114.B12 320.85,347.98 ; D114.B12 320.04,348.79 ; D431.A4 193.85,383.54 ; D431.A4 192.23,383.54 ; D431.A4 193.04,382.73 ; D431.A4 193.04,384.35 ; 403.86,331.93 D109.A8 ; D109.A8 403.86,333.55 ; D109.A8 403.05,332.74 ; D109.A8 404.67,332.74 ; D112.B14 388.62,389.43 ; D112.B14 389.43,388.62 ; D112.B14 388.62,387.81 ; D112.B14 387.81,388.62 ; 197.31,368.3 D231.B2 ; D231.B2 198.12,367.49 ; D231.B2 198.93,368.3 ; D231.B2 198.12,369.11 ; 174.55,63.5 D318.A7 ; D318.A7 175.26,64.21 ; D318.A7 175.26,62.79 ; D318.A7 175.97,63.5 ; D127.A4 20.32,56.69 ; D127.A4 19.51,55.88 ; D127.A4 20.32,55.07 ; D127.A4 21.13,55.88 ; 110.95,93.98 D129.A11 ; D129.A11 112.57,93.98 ; D129.A11 111.76,93.17 ; D129.A11 111.76,94.79 ; 116.03,93.98 D129.A13 ; D129.A13 116.84,93.17 ; D129.A13 116.84,94.79 ; D129.A13 117.65,93.98 ; 97.04,204.6 U1.4 ; U1.4 96.1,205.54 ; U1.4 97.98,205.54 ; U1.4 97.04,206.48 ; 103.33,40.64 D132.B8 ; D132.B8 104.14,41.45 ; D132.B8 104.14,39.83 ; D132.B8 104.95,40.64 ; 243.84,77.93 D122.B5 ; D122.B5 243.03,78.74 ; D122.B5 244.65,78.74 ; D122.B5 243.84,79.55 ; D108.B2 384.35,40.64 ; D108.B2 383.54,41.45 ; D108.B2 383.54,39.83 ; D108.B2 382.73,40.64 ; 322.58,349.71 D114.B11 ; D114.B11 323.39,350.52 ; D114.B11 322.58,351.33 ; D114.B11 321.77,350.52 ; 311.61,350.52 D114.B15 ; D114.B15 312.42,351.33 ; D114.B15 313.23,350.52 ; D114.B15 312.42,349.71 ; D302.B3 312.42,69.29 ; D302.B3 312.42,67.87 ; D302.B3 313.13,68.58 ; D302.B3 311.71,68.58 ; 260.81,81.28 D122.B12 ; D122.B12 261.62,80.47 ; D122.B12 262.43,81.28 ; D122.B12 261.62,82.09 ; 189.79,88.9 D317.B13 ; D317.B13 190.5,88.19 ; D317.B13 190.5,89.61 ; D317.B13 191.21,88.9 ; 161.75,378.46 D431.B16 ; D431.B16 163.37,378.46 ; D431.B16 162.56,377.65 ; D431.B16 162.56,379.27 ; 32.21,99.06 D125.B9 ; D125.B9 33.02,99.87 ; D125.B9 33.02,98.25 ; D125.B9 33.83,99.06 ; 34.75,60.96 D127.B10 ; D127.B10 36.37,60.96 ; D127.B10 35.56,60.15 ; D127.B10 35.56,61.77 ; 405.59,350.52 D110.B7 ; D110.B7 406.4,349.71 ; D110.B7 407.21,350.52 ; D110.B7 406.4,351.33 ; D132.A1 87.17,33.02 ; D132.A1 86.36,33.83 ; D132.A1 85.55,33.02 ; D132.A1 86.36,32.21 ; 166.93,66.04 D318.A4 ; D318.A4 167.64,66.75 ; D318.A4 167.64,65.33 ; D318.A4 168.35,66.04 ; D107.B7 397.05,58.42 ; D107.B7 396.24,57.61 ; D107.B7 395.43,58.42 ; D107.B7 396.24,59.23 ; 182.88,331.93 CSDPS229.B8 ; CSDPS229.B8 182.88,333.55 ; CSDPS229.B8 183.69,332.74 ; CSDPS229.B8 182.07,332.74 ; 233.68,77.93 D122.B1 ; D122.B1 234.49,78.74 ; D122.B1 233.68,79.55 ; D122.B1 232.87,78.74 ; D321.A16 272.49,86.36 ; D321.A16 271.78,87.07 ; D321.A16 271.07,86.36 ; D321.A16 271.78,85.65 ; CSDPS229.B4 193.85,332.74 ; CSDPS229.B4 193.04,333.55 ; CSDPS229.B4 192.23,332.74 ; CSDPS229.B4 193.04,331.93 ; 309.88,326.85 D113.B16 ; D113.B16 309.07,327.66 ; D113.B16 309.88,328.47 ; D113.B16 310.69,327.66 ; 17.78,77.93 D126.B3 ; D126.B3 18.59,78.74 ; D126.B3 16.97,78.74 ; D126.B3 17.78,79.55 ; 96.2,219.15 U2.4 ; U2.4 97.14,220.09 ; U2.4 98.08,219.15 ; U2.4 97.14,218.21 ; D108.B3 386.89,38.1 ; D108.B3 386.08,38.91 ; D108.B3 386.08,37.29 ; D108.B3 385.27,38.1 ; D124.B15 270.05,38.1 ; D124.B15 269.24,38.91 ; D124.B15 268.43,38.1 ; D124.B15 269.24,37.29 ; 249.85,187.93 SITE3.G9 ; SITE3.G9 250.33,188.41 ; SITE3.G9 250.81,187.93 ; SITE3.G9 250.33,187.45 ; SITE2.G6 333.81,241.33 ; SITE2.G6 333.33,240.85 ; SITE2.G6 333.33,241.81 ; SITE2.G6 332.85,241.33 ; D124.A14 266.7,36.37 ; D124.A14 267.51,35.56 ; D124.A14 265.89,35.56 ; D124.A14 266.7,34.75 ; D116.A14 315.77,393.7 ; D116.A14 314.96,394.51 ; D116.A14 314.15,393.7 ; D116.A14 314.96,392.89 ; 88.09,40.64 D132.B2 ; D132.B2 88.9,39.83 ; D132.B2 89.71,40.64 ; D132.B2 88.9,41.45 ; D130.B14 119.38,82.09 ; D130.B14 118.57,81.28 ; D130.B14 120.19,81.28 ; D130.B14 119.38,80.47 ; D231.B10 178.61,368.3 ; D231.B10 177.8,367.49 ; D231.B10 177.8,369.11 ; D231.B10 176.99,368.3 ; D301.A12 335.99,86.36 ; D301.A12 334.57,86.36 ; D301.A12 335.28,85.65 ; D301.A12 335.28,87.07 ; D108.A4 389.43,35.56 ; D108.A4 388.62,36.37 ; D108.A4 387.81,35.56 ; D108.A4 388.62,34.75 ; D124.B9 254,38.91 ; D124.B9 254,37.29 ; D124.B9 253.19,38.1 ; D124.B9 254.81,38.1 ; 332.63,242.35 SITE2.G16 ; SITE2.G16 332.63,243.31 ; SITE2.G16 333.11,242.83 ; SITE2.G16 332.15,242.83 ; D114.A2 345.44,353.87 ; D114.A2 346.25,353.06 ; D114.A2 345.44,352.25 ; D114.A2 344.63,353.06 ; D115.B14 314.96,369.11 ; D115.B14 314.15,368.3 ; D115.B14 315.77,368.3 ; D115.B14 314.96,367.49 ; 418.29,327.66 D109.B2 ; D109.B2 419.91,327.66 ; D109.B2 419.1,328.47 ; D109.B2 419.1,326.85 ; D102.B6 320.85,81.28 ; D102.B6 320.04,80.47 ; D102.B6 320.04,82.09 ; D102.B6 319.23,81.28 ; D109.A13 391.97,335.28 ; D109.A13 390.35,335.28 ; D109.A13 391.16,336.09 ; D109.A13 391.16,334.47 ; D305.A5 391.16,84.53 ; D305.A5 391.16,83.11 ; D305.A5 391.87,83.82 ; D305.A5 390.45,83.82 ; D132.B3 91.44,38.91 ; D132.B3 91.44,37.29 ; D132.B3 90.63,38.1 ; D132.B3 92.25,38.1 ; D126.A3 18.59,73.66 ; D126.A3 17.78,74.47 ; D126.A3 17.78,72.85 ; D126.A3 16.97,73.66 ; 263.35,38.1 D124.B13 ; D124.B13 264.16,37.29 ; D124.B13 264.16,38.91 ; D124.B13 264.97,38.1 ; 175.26,329.39 CSDPS229.C11 ; CSDPS229.C11 176.07,330.2 ; CSDPS229.C11 174.45,330.2 ; CSDPS229.C11 175.26,331.01 ; D317.A9 181.05,83.82 ; D317.A9 180.34,84.53 ; D317.A9 179.63,83.82 ; D317.A9 180.34,83.11 ; D123.B2 237.03,60.96 ; D123.B2 236.22,61.77 ; D123.B2 235.41,60.96 ; D123.B2 236.22,60.15 ; 190.5,375.11 D231.A5 ; D231.A5 191.31,375.92 ; D231.A5 190.5,376.73 ; D231.A5 189.69,375.92 ; 398.78,85.65 D305.A8 ; D305.A8 398.78,87.07 ; D305.A8 399.49,86.36 ; D305.A8 398.07,86.36 ; D116.B6 336.09,388.62 ; D116.B6 335.28,387.81 ; D116.B6 334.47,388.62 ; D116.B6 335.28,389.43 ; D127.B11 38.1,59.23 ; D127.B11 38.91,58.42 ; D127.B11 38.1,57.61 ; D127.B11 37.29,58.42 ; 111.76,98.25 D129.B11 ; D129.B11 111.76,99.87 ; D129.B11 112.57,99.06 ; D129.B11 110.95,99.06 ; D113.B8 330.2,328.47 ; D113.B8 330.2,326.85 ; D113.B8 329.39,327.66 ; D113.B8 331.01,327.66 ; D125.A8 31.29,96.52 ; D125.A8 29.67,96.52 ; D125.A8 30.48,97.33 ; D125.A8 30.48,95.71 ; 22.05,73.66 D126.A5 ; D126.A5 22.86,74.47 ; D126.A5 22.86,72.85 ; D126.A5 23.67,73.66 ; 337.82,57.61 D103.B13 ; D103.B13 337.82,59.23 ; D103.B13 337.01,58.42 ; D103.B13 338.63,58.42 ; CSDPS425.C3 270.05,340.36 ; CSDPS425.C3 268.43,340.36 ; CSDPS425.C3 269.24,339.55 ; CSDPS425.C3 269.24,341.17 ; D114.B9 328.47,350.52 ; D114.B9 326.85,350.52 ; D114.B9 327.66,349.71 ; D114.B9 327.66,351.33 ; D431.B4 193.04,379.27 ; D431.B4 193.04,377.65 ; D431.B4 193.85,378.46 ; D431.B4 192.23,378.46 ; D431.B9 181.15,381 ; D431.B9 180.34,381.81 ; D431.B9 180.34,380.19 ; D431.B9 179.53,381 ; D104.A12 336.09,35.56 ; D104.A12 334.47,35.56 ; D104.A12 335.28,36.37 ; D104.A12 335.28,34.75 ; D123.B4 241.3,61.77 ; D123.B4 241.3,60.15 ; D123.B4 242.11,60.96 ; D123.B4 240.49,60.96 ; 411.48,88.19 D305.B13 ; D305.B13 412.19,88.9 ; D305.B13 411.48,89.61 ; D305.B13 410.77,88.9 ; 395.43,350.52 D110.B11 ; D110.B11 396.24,351.33 ; D110.B11 397.05,350.52 ; D110.B11 396.24,349.71 ; D301.B14 340.36,92.15 ; D301.B14 339.65,91.44 ; D301.B14 340.36,90.73 ; D301.B14 341.07,91.44 ; 35.56,95.71 D125.A10 ; D125.A10 34.75,96.52 ; D125.A10 36.37,96.52 ; D125.A10 35.56,97.33 ; SITE3.G13 249.51,182.83 ; SITE3.G13 249.03,182.35 ; SITE3.G13 248.55,182.83 ; SITE3.G13 249.03,183.31 ; D123.B6 246.38,61.77 ; D123.B6 246.38,60.15 ; D123.B6 245.57,60.96 ; D123.B6 247.19,60.96 ; 195.58,380.19 D431.B3 ; D431.B3 196.39,381 ; D431.B3 194.77,381 ; D431.B3 195.58,381.81 ; D114.A4 341.17,353.06 ; D114.A4 339.55,353.06 ; D114.A4 340.36,353.87 ; D114.A4 340.36,352.25 ; 185.42,385.27 D431.A7 ; D431.A7 184.61,386.08 ; D431.A7 185.42,386.89 ; D431.A7 186.23,386.08 ; D109.A11 397.05,335.28 ; D109.A11 395.43,335.28 ; D109.A11 396.24,336.09 ; D109.A11 396.24,334.47 ; 12.7,93.17 D125.A1 ; D125.A1 12.7,94.79 ; D125.A1 13.51,93.98 ; D125.A1 11.89,93.98 ; D123.B8 252.27,60.96 ; D123.B8 250.65,60.96 ; D123.B8 251.46,61.77 ; D123.B8 251.46,60.15 ; 172.72,342.09 CSDPS429.B12 ; CSDPS429.B12 171.91,342.9 ; CSDPS429.B12 172.72,343.71 ; CSDPS429.B12 173.53,342.9 ; D321.B13 264.16,89.61 ; D321.B13 264.87,88.9 ; D321.B13 264.16,88.19 ; D321.B13 263.45,88.9 ; 254,72.85 D122.A9 ; D122.A9 253.19,73.66 ; D122.A9 254.81,73.66 ; D122.A9 254,74.47 ; 99.06,100.79 D129.B6 ; D129.B6 99.87,101.6 ; D129.B6 99.06,102.41 ; D129.B6 98.25,101.6 ; D110.A12 393.7,353.87 ; D110.A12 394.51,353.06 ; D110.A12 393.7,352.25 ; D110.A12 392.89,353.06 ; 411.48,370.03 D111.B5 ; D111.B5 411.48,371.65 ; D111.B5 412.29,370.84 ; D111.B5 410.67,370.84 ; 271.78,65.33 D322.A16 ; D322.A16 272.49,66.04 ; D322.A16 271.07,66.04 ; D322.A16 271.78,66.75 ; D317.B14 193.75,91.44 ; D317.B14 193.04,90.73 ; D317.B14 193.04,92.15 ; D317.B14 192.33,91.44 ; D103.A3 313.23,53.34 ; D103.A3 312.42,54.15 ; D103.A3 312.42,52.53 ; D103.A3 311.61,53.34 ; D118.B2 163.37,81.28 ; D118.B2 162.56,80.47 ; D118.B2 161.75,81.28 ; D118.B2 162.56,82.09 ; 380.19,58.42 D107.B1 ; D107.B1 381,59.23 ; D107.B1 381.81,58.42 ; D107.B1 381,57.61 ; 397.97,347.98 D110.B10 ; D110.B10 399.59,347.98 ; D110.B10 398.78,347.17 ; D110.B10 398.78,348.79 ; 326.85,335.28 D113.A9 ; D113.A9 328.47,335.28 ; D113.A9 327.66,336.09 ; D113.A9 327.66,334.47 ; 251.46,39.83 D124.B8 ; D124.B8 250.65,40.64 ; D124.B8 251.46,41.45 ; D124.B8 252.27,40.64 ; 197.41,86.36 D317.A16 ; D317.A16 198.12,87.07 ; D317.A16 198.83,86.36 ; D317.A16 198.12,85.65 ; 233.68,52.53 D123.A1 ; D123.A1 233.68,54.15 ; D123.A1 232.87,53.34 ; D123.A1 234.49,53.34 ; 22.05,53.34 D127.A5 ; D127.A5 22.86,52.53 ; D127.A5 23.67,53.34 ; D127.A5 22.86,54.15 ; D130.A15 122.73,73.66 ; D130.A15 121.11,73.66 ; D130.A15 121.92,72.85 ; D130.A15 121.92,74.47 ; 344.63,81.28 D102.B16 ; D102.B16 345.44,80.47 ; D102.B16 345.44,82.09 ; D102.B16 346.25,81.28 ; 187.96,39.83 D120.B12 ; D120.B12 188.77,40.64 ; D120.B12 187.96,41.45 ; D120.B12 187.15,40.64 ; 395.43,38.1 D108.B7 ; D108.B7 396.24,38.91 ; D108.B7 396.24,37.29 ; D108.B7 397.05,38.1 ; 317.5,72.85 D102.A5 ; D102.A5 317.5,74.47 ; D102.A5 318.31,73.66 ; D102.A5 316.69,73.66 ; 185.42,62.79 D318.A11 ; D318.A11 186.13,63.5 ; D318.A11 184.71,63.5 ; D318.A11 185.42,64.21 ; 414.02,65.33 D306.A14 ; D306.A14 414.02,66.75 ; D306.A14 414.73,66.04 ; D306.A14 413.31,66.04 ; 37.29,99.06 D125.B11 ; D125.B11 38.1,99.87 ; D125.B11 38.1,98.25 ; D125.B11 38.91,99.06 ; D116.A7 333.55,396.24 ; D116.A7 331.93,396.24 ; D116.A7 332.74,397.05 ; D116.A7 332.74,395.43 ; D113.A14 315.77,332.74 ; D113.A14 314.96,331.93 ; D113.A14 314.15,332.74 ; D113.A14 314.96,333.55 ; D231.A2 198.12,374.19 ; D231.A2 197.31,373.38 ; D231.A2 198.93,373.38 ; D231.A2 198.12,372.57 ; 405.59,78.74 D106.B11 ; D106.B11 407.21,78.74 ; D106.B11 406.4,77.93 ; D106.B11 406.4,79.55 ; 331.43,242.35 SITE2.G15 ; SITE2.G15 330.95,242.83 ; SITE2.G15 331.43,243.31 ; SITE2.G15 331.91,242.83 ; 166.93,71.12 D318.B4 ; D318.B4 167.64,71.83 ; D318.B4 168.35,71.12 ; D318.B4 167.64,70.41 ; 410.67,396.24 D112.A5 ; D112.A5 412.29,396.24 ; D112.A5 411.48,395.43 ; D112.A5 411.48,397.05 ; SITE3.G5 252.81,181.33 ; SITE3.G5 252.33,181.81 ; SITE3.G5 252.33,180.85 ; SITE3.G5 251.85,181.33 ; 187.96,90.73 D317.B12 ; D317.B12 187.96,92.15 ; D317.B12 187.25,91.44 ; D317.B12 188.67,91.44 ; D130.A6 99.87,76.2 ; D130.A6 99.06,75.39 ; D130.A6 98.25,76.2 ; D130.A6 99.06,77.01 ; 324.41,91.44 D301.B8 ; D301.B8 325.12,92.15 ; D301.B8 325.12,90.73 ; D301.B8 325.83,91.44 ; 108.41,35.56 D132.A10 ; D132.A10 109.22,36.37 ; D132.A10 109.22,34.75 ; D132.A10 110.03,35.56 ; 420.83,370.84 D111.B1 ; D111.B1 421.64,370.03 ; D111.B1 421.64,371.65 ; D111.B1 422.45,370.84 ; 391.16,18.24 DPS1.C05 ; DPS1.C05 391.97,19.05 ; DPS1.C05 390.35,19.05 ; DPS1.C05 391.16,19.86 ; 339.55,373.38 D115.A4 ; D115.A4 340.36,372.57 ; D115.A4 341.17,373.38 ; D115.A4 340.36,374.19 ; 320.04,392.89 D116.A12 ; D116.A12 319.23,393.7 ; D116.A12 320.04,394.51 ; D116.A12 320.85,393.7 ; 180.34,339.55 CSDPS429.C9 ; CSDPS429.C9 181.15,340.36 ; CSDPS429.C9 180.34,341.17 ; CSDPS429.C9 179.53,340.36 ; 414.02,39.83 D108.B14 ; D108.B14 413.21,40.64 ; D108.B14 414.02,41.45 ; D108.B14 414.83,40.64 ; 342.09,355.6 D114.A3 ; D114.A3 343.71,355.6 ; D114.A3 342.9,356.41 ; D114.A3 342.9,354.79 ; D104.B11 333.55,38.1 ; D104.B11 332.74,37.29 ; D104.B11 331.93,38.1 ; D104.B11 332.74,38.91 ; CSDPS425.B8 257.35,342.9 ; CSDPS425.B8 256.54,342.09 ; CSDPS425.B8 256.54,343.71 ; CSDPS425.B8 255.73,342.9 ; 390.45,63.5 D306.A5 ; D306.A5 391.16,62.79 ; D306.A5 391.87,63.5 ; D306.A5 391.16,64.21 ; D103.B1 307.34,59.23 ; D103.B1 307.34,57.61 ; D103.B1 306.53,58.42 ; D103.B1 308.15,58.42 ; 347.98,329.39 D113.B1 ; D113.B1 347.98,331.01 ; D113.B1 348.79,330.2 ; D113.B1 347.17,330.2 ; D127.B4 20.32,61.77 ; D127.B4 20.32,60.15 ; D127.B4 21.13,60.96 ; D127.B4 19.51,60.96 ; D431.A14 167.64,384.35 ; D431.A14 168.45,383.54 ; D431.A14 167.64,382.73 ; D431.A14 166.83,383.54 ; 17.78,57.61 D127.B3 ; D127.B3 17.78,59.23 ; D127.B3 18.59,58.42 ; D127.B3 16.97,58.42 ; SITE4.G2 329.33,181.81 ; SITE4.G2 329.81,181.33 ; SITE4.G2 329.33,180.85 ; SITE4.G2 328.85,181.33 ; D322.A5 243.84,64.21 ; D322.A5 243.13,63.5 ; D322.A5 243.84,62.79 ; D322.A5 244.55,63.5 ; 416.56,18.24 DPS1.C15 ; DPS1.C15 417.37,19.05 ; DPS1.C15 415.75,19.05 ; DPS1.C15 416.56,19.86 ; 408.94,80.47 D106.B12 ; D106.B12 409.75,81.28 ; D106.B12 408.13,81.28 ; D106.B12 408.94,82.09 ; 91.44,93.17 D129.A3 ; D129.A3 91.44,94.79 ; D129.A3 92.25,93.98 ; D129.A3 90.63,93.98 ; 269.24,57.61 D123.B15 ; D123.B15 269.24,59.23 ; D123.B15 268.43,58.42 ; D123.B15 270.05,58.42 ; 184.61,370.84 D231.B7 ; D231.B7 186.23,370.84 ; D231.B7 185.42,371.65 ; D231.B7 185.42,370.03 ; 264.16,67.87 D322.B13 ; D322.B13 263.45,68.58 ; D322.B13 264.87,68.58 ; D322.B13 264.16,69.29 ; DPS3.A11 259.08,14.78 ; DPS3.A11 259.08,13.16 ; DPS3.A11 259.89,13.97 ; DPS3.A11 258.27,13.97 ; D321.B9 254,89.61 ; D321.B9 254,88.19 ; D321.B9 254.71,88.9 ; D321.B9 253.29,88.9 ; D114.B3 342.9,351.33 ; D114.B3 342.09,350.52 ; D114.B3 342.9,349.71 ; D114.B3 343.71,350.52 ; 250.23,242.35 SITE1.G14 ; SITE1.G14 250.23,243.31 ; SITE1.G14 249.75,242.83 ; SITE1.G14 250.71,242.83 ; D131.A2 89.71,55.88 ; D131.A2 88.9,56.69 ; D131.A2 88.9,55.07 ; D131.A2 88.09,55.88 ; D115.A3 343.71,375.92 ; D115.A3 342.9,376.73 ; D115.A3 342.09,375.92 ; D115.A3 342.9,375.11 ; 391.16,37.29 D108.B5 ; D108.B5 391.97,38.1 ; D108.B5 391.16,38.91 ; D108.B5 390.35,38.1 ; 251.46,331.93 CSDPS225.B10 ; CSDPS225.B10 252.27,332.74 ; CSDPS225.B10 251.46,333.55 ; CSDPS225.B10 250.65,332.74 ; 251.46,75.39 D122.A8 ; D122.A8 251.46,77.01 ; D122.A8 250.65,76.2 ; D122.A8 252.27,76.2 ; D128.B14 45.72,41.45 ; D128.B14 46.53,40.64 ; D128.B14 44.91,40.64 ; D128.B14 45.72,39.83 ; 347.17,410.21 DPS2.C01 ; DPS2.C01 348.79,410.21 ; DPS2.C01 347.98,409.4 ; DPS2.C01 347.98,411.02 ; 269.24,83.11 D321.A15 ; D321.A15 269.24,84.53 ; D321.A15 268.53,83.82 ; D321.A15 269.95,83.82 ; CSDPS425.B6 262.43,342.9 ; CSDPS425.B6 260.81,342.9 ; CSDPS425.B6 261.62,343.71 ; CSDPS425.B6 261.62,342.09 ; 328.85,241.33 SITE2.G2 ; SITE2.G2 329.33,241.81 ; SITE2.G2 329.81,241.33 ; SITE2.G2 329.33,240.85 ; D110.B8 403.86,348.79 ; D110.B8 404.67,347.98 ; D110.B8 403.86,347.17 ; D110.B8 403.05,347.98 ; D131.B1 87.17,58.42 ; D131.B1 86.36,59.23 ; D131.B1 86.36,57.61 ; D131.B1 85.55,58.42 ; 250.75,86.36 D321.A8 ; D321.A8 251.46,87.07 ; D321.A8 252.17,86.36 ; D321.A8 251.46,85.65 ; 96.52,52.53 D131.A5 ; D131.A5 97.33,53.34 ; D131.A5 95.71,53.34 ; D131.A5 96.52,54.15 ; 322.58,395.43 D116.A11 ; D116.A11 322.58,397.05 ; D116.A11 323.39,396.24 ; D116.A11 321.77,396.24 ; D306.A1 381.71,63.5 ; D306.A1 381,64.21 ; D306.A1 380.29,63.5 ; D306.A1 381,62.79 ; 236.22,65.33 D322.A2 ; D322.A2 235.51,66.04 ; D322.A2 236.93,66.04 ; D322.A2 236.22,66.75 ; D125.B2 15.24,102.41 ; D125.B2 15.24,100.79 ; D125.B2 14.43,101.6 ; D125.B2 16.05,101.6 ; 193.04,65.33 D318.A14 ; D318.A14 193.75,66.04 ; D318.A14 193.04,66.75 ; D318.A14 192.33,66.04 ; 182.88,80.47 D118.B10 ; D118.B10 183.69,81.28 ; D118.B10 182.88,82.09 ; D118.B10 182.07,81.28 ; D103.A7 323.39,53.34 ; D103.A7 322.58,52.53 ; D103.A7 321.77,53.34 ; D103.A7 322.58,54.15 ; D322.B3 238.76,69.29 ; D322.B3 238.76,67.87 ; D322.B3 239.47,68.58 ; D322.B3 238.05,68.58 ; D122.A4 241.3,77.01 ; D122.A4 241.3,75.39 ; D122.A4 242.11,76.2 ; D122.A4 240.49,76.2 ; 322.58,77.93 D102.B7 ; D102.B7 323.39,78.74 ; D102.B7 321.77,78.74 ; D102.B7 322.58,79.55 ; D113.A5 337.82,336.09 ; D113.A5 337.01,335.28 ; D113.A5 337.82,334.47 ; D113.A5 338.63,335.28 ; D115.A5 337.82,376.73 ; D115.A5 337.01,375.92 ; D115.A5 337.82,375.11 ; D115.A5 338.63,375.92 ; D109.A9 401.32,336.09 ; D109.A9 402.13,335.28 ; D109.A9 401.32,334.47 ; D109.A9 400.51,335.28 ; 392.89,393.7 D112.A12 ; D112.A12 393.7,392.89 ; D112.A12 393.7,394.51 ; D112.A12 394.51,393.7 ; D128.B1 13.51,38.1 ; D128.B1 11.89,38.1 ; D128.B1 12.7,38.91 ; D128.B1 12.7,37.29 ; D126.B11 38.91,78.74 ; D126.B11 38.1,79.55 ; D126.B11 37.29,78.74 ; D126.B11 38.1,77.93 ; D106.A9 402.13,73.66 ; D106.A9 400.51,73.66 ; D106.A9 401.32,72.85 ; D106.A9 401.32,74.47 ; D317.B1 160.02,89.61 ; D317.B1 159.31,88.9 ; D317.B1 160.73,88.9 ; D317.B1 160.02,88.19 ; D110.B15 386.08,351.33 ; D110.B15 386.89,350.52 ; D110.B15 386.08,349.71 ; D110.B15 385.27,350.52 ; 385.37,88.9 D305.B3 ; D305.B3 386.08,88.19 ; D305.B3 386.08,89.61 ; D305.B3 386.79,88.9 ; D123.A3 239.57,53.34 ; D123.A3 237.95,53.34 ; D123.A3 238.76,52.53 ; D123.A3 238.76,54.15 ; D317.B7 175.26,89.61 ; D317.B7 175.26,88.19 ; D317.B7 174.55,88.9 ; D317.B7 175.97,88.9 ; 232.87,58.42 D123.B1 ; D123.B1 233.68,59.23 ; D123.B1 234.49,58.42 ; D123.B1 233.68,57.61 ; D120.A1 160.83,33.02 ; D120.A1 160.02,33.83 ; D120.A1 159.21,33.02 ; D120.A1 160.02,32.21 ; 109.22,100.79 D129.B10 ; D129.B10 110.03,101.6 ; D129.B10 109.22,102.41 ; D129.B10 108.41,101.6 ; 96.52,57.61 D131.B5 ; D131.B5 97.33,58.42 ; D131.B5 95.71,58.42 ; D131.B5 96.52,59.23 ; 193.04,342.09 CSDPS429.B4 ; CSDPS429.B4 193.85,342.9 ; CSDPS429.B4 192.23,342.9 ; CSDPS429.B4 193.04,343.71 ; D126.B10 35.56,82.09 ; D126.B10 34.75,81.28 ; D126.B10 36.37,81.28 ; D126.B10 35.56,80.47 ; 387.81,327.66 D109.B14 ; D109.B14 388.62,326.85 ; D109.B14 389.43,327.66 ; D109.B14 388.62,328.47 ; 123.65,96.52 D129.A16 ; D129.A16 124.46,95.71 ; D129.A16 124.46,97.33 ; D129.A16 125.27,96.52 ; 167.64,331.93 CSDPS229.B14 ; CSDPS229.B14 168.45,332.74 ; CSDPS229.B14 166.83,332.74 ; CSDPS229.B14 167.64,333.55 ; D130.B6 99.87,81.28 ; D130.B6 99.06,80.47 ; D130.B6 99.06,82.09 ; D130.B6 98.25,81.28 ; 330.95,186.43 SITE4.G19 ; SITE4.G19 331.43,186.91 ; SITE4.G19 331.91,186.43 ; SITE4.G19 331.43,185.95 ; 162.56,60.15 D119.B2 ; D119.B2 161.75,60.96 ; D119.B2 163.37,60.96 ; D119.B2 162.56,61.77 ; D431.B1 200.66,381.81 ; D431.B1 199.85,381 ; D431.B1 200.66,380.19 ; D431.B1 201.47,381 ; 236.22,80.47 D122.B2 ; D122.B2 236.22,82.09 ; D122.B2 235.41,81.28 ; D122.B2 237.03,81.28 ; 121.11,38.1 D132.B15 ; D132.B15 121.92,38.91 ; D132.B15 122.73,38.1 ; D132.B15 121.92,37.29 ; D125.A12 40.64,97.33 ; D125.A12 40.64,95.71 ; D125.A12 39.83,96.52 ; D125.A12 41.45,96.52 ; 325.12,352.25 D114.A10 ; D114.A10 324.31,353.06 ; D114.A10 325.12,353.87 ; D114.A10 325.93,353.06 ; D112.B12 394.51,388.62 ; D112.B12 392.89,388.62 ; D112.B12 393.7,389.43 ; D112.B12 393.7,387.81 ; D124.B7 249.73,38.1 ; D124.B7 248.11,38.1 ; D124.B7 248.92,38.91 ; D124.B7 248.92,37.29 ; D129.A10 109.22,97.33 ; D129.A10 109.22,95.71 ; D129.A10 110.03,96.52 ; D129.A10 108.41,96.52 ; CSDPS229.B16 163.37,332.74 ; CSDPS229.B16 162.56,333.55 ; CSDPS229.B16 162.56,331.93 ; CSDPS229.B16 161.75,332.74 ; 176.99,40.64 D120.B8 ; D120.B8 177.8,41.45 ; D120.B8 177.8,39.83 ; D120.B8 178.61,40.64 ; D318.A5 170.89,63.5 ; D318.A5 170.18,62.79 ; D318.A5 170.18,64.21 ; D318.A5 169.47,63.5 ; 342.19,83.82 D301.A15 ; D301.A15 342.9,83.11 ; D301.A15 343.61,83.82 ; D301.A15 342.9,84.53 ; 261.62,65.33 D322.A12 ; D322.A12 260.91,66.04 ; D322.A12 262.33,66.04 ; D322.A12 261.62,66.75 ; 25.4,34.75 D128.A6 ; D128.A6 26.21,35.56 ; D128.A6 25.4,36.37 ; D128.A6 24.59,35.56 ; D123.A13 264.16,54.15 ; D123.A13 264.97,53.34 ; D123.A13 264.16,52.53 ; D123.A13 263.35,53.34 ; D116.B14 315.77,388.62 ; D116.B14 314.15,388.62 ; D116.B14 314.96,389.43 ; D116.B14 314.96,387.81 ; D123.A5 244.65,53.34 ; D123.A5 243.84,52.53 ; D123.A5 243.03,53.34 ; D123.A5 243.84,54.15 ; D318.A9 180.34,64.21 ; D318.A9 181.05,63.5 ; D318.A9 179.63,63.5 ; D318.A9 180.34,62.79 ; 418.39,66.04 D306.A16 ; D306.A16 419.81,66.04 ; D306.A16 419.1,65.33 ; D306.A16 419.1,66.75 ; D107.B3 386.08,59.23 ; D107.B3 385.27,58.42 ; D107.B3 386.08,57.61 ; D107.B3 386.89,58.42 ; 405.59,38.1 D108.B11 ; D108.B11 407.21,38.1 ; D108.B11 406.4,38.91 ; D108.B11 406.4,37.29 ; 345.44,331.93 D113.A2 ; D113.A2 346.25,332.74 ; D113.A2 344.63,332.74 ; D113.A2 345.44,333.55 ; D103.B2 310.69,60.96 ; D103.B2 309.88,61.77 ; D103.B2 309.88,60.15 ; D103.B2 309.07,60.96 ; 339.55,368.3 D115.B4 ; D115.B4 340.36,369.11 ; D115.B4 341.17,368.3 ; D115.B4 340.36,367.49 ; D301.A4 314.96,87.07 ; D301.A4 314.96,85.65 ; D301.A4 315.67,86.36 ; D301.A4 314.25,86.36 ; 93.17,81.28 D130.B4 ; D130.B4 93.98,80.47 ; D130.B4 94.79,81.28 ; D130.B4 93.98,82.09 ; SITE2.G12 333.81,247.93 ; SITE2.G12 333.33,248.41 ; SITE2.G12 332.85,247.93 ; SITE2.G12 333.33,247.45 ; D114.A16 310.69,353.06 ; D114.A16 309.88,353.87 ; D114.A16 309.07,353.06 ; D114.A16 309.88,352.25 ; D106.A5 391.16,74.47 ; D106.A5 391.97,73.66 ; D106.A5 391.16,72.85 ; D106.A5 390.35,73.66 ; 482.49,214 UNK2U2.4 ; UNK2U2.4 481.55,214.94 ; UNK2U2.4 483.43,214.94 ; UNK2U2.4 482.49,215.88 ; 169.37,78.74 D118.B5 ; D118.B5 170.99,78.74 ; D118.B5 170.18,77.93 ; D118.B5 170.18,79.55 ; 248.21,88.9 D321.B7 ; D321.B7 248.92,88.19 ; D321.B7 249.63,88.9 ; D321.B7 248.92,89.61 ; 307.34,77.93 D102.B1 ; D102.B1 306.53,78.74 ; D102.B1 307.34,79.55 ; D102.B1 308.15,78.74 ; 388.62,39.83 D108.B4 ; D108.B4 389.43,40.64 ; D108.B4 388.62,41.45 ; D108.B4 387.81,40.64 ; 88.09,35.56 D132.A2 ; D132.A2 89.71,35.56 ; D132.A2 88.9,36.37 ; D132.A2 88.9,34.75 ; D124.B10 256.54,41.45 ; D124.B10 256.54,39.83 ; D124.B10 255.73,40.64 ; D124.B10 257.35,40.64 ; D431.B15 165.1,381.81 ; D431.B15 165.91,381 ; D431.B15 164.29,381 ; D431.B15 165.1,380.19 ; 406.4,32.21 D108.A11 ; D108.A11 406.4,33.83 ; D108.A11 405.59,33.02 ; D108.A11 407.21,33.02 ; D116.A15 312.42,397.05 ; D116.A15 313.23,396.24 ; D116.A15 312.42,395.43 ; D116.A15 311.61,396.24 ; 187.25,71.12 D318.B12 ; D318.B12 187.96,71.83 ; D318.B12 187.96,70.41 ; D318.B12 188.67,71.12 ; 393.7,80.47 D106.B6 ; D106.B6 393.7,82.09 ; D106.B6 392.89,81.28 ; D106.B6 394.51,81.28 ; 33.02,72.85 D126.A9 ; D126.A9 32.21,73.66 ; D126.A9 33.83,73.66 ; D126.A9 33.02,74.47 ; 250.95,182.83 SITE3.G15 ; SITE3.G15 251.43,183.31 ; SITE3.G15 251.43,182.35 ; SITE3.G15 251.91,182.83 ; D125.B13 43.99,99.06 ; D125.B13 43.18,99.87 ; D125.B13 43.18,98.25 ; D125.B13 42.37,99.06 ; D109.B16 383.54,328.47 ; D109.B16 382.73,327.66 ; D109.B16 383.54,326.85 ; D109.B16 384.35,327.66 ; D109.B9 402.13,330.2 ; D109.B9 400.51,330.2 ; D109.B9 401.32,331.01 ; D109.B9 401.32,329.39 ; CSDPS229.B6 187.96,333.55 ; CSDPS229.B6 188.77,332.74 ; CSDPS229.B6 187.96,331.93 ; CSDPS229.B6 187.15,332.74 ; 271.78,80.47 D122.B16 ; D122.B16 270.97,81.28 ; D122.B16 272.59,81.28 ; D122.B16 271.78,82.09 ; D112.A6 409.75,393.7 ; D112.A6 408.13,393.7 ; D112.A6 408.94,392.89 ; D112.A6 408.94,394.51 ; 388.62,85.65 D305.A4 ; D305.A4 388.62,87.07 ; D305.A4 389.33,86.36 ; D305.A4 387.91,86.36 ; D119.B12 187.96,61.77 ; D119.B12 187.96,60.15 ; D119.B12 187.15,60.96 ; D119.B12 188.77,60.96 ; D120.A7 176.07,33.02 ; D120.A7 175.26,33.83 ; D120.A7 174.45,33.02 ; D120.A7 175.26,32.21 ; D317.A11 185.42,84.53 ; D317.A11 184.71,83.82 ; D317.A11 186.13,83.82 ; D317.A11 185.42,83.11 ; D118.B6 172.72,82.09 ; D118.B6 173.53,81.28 ; D118.B6 172.72,80.47 ; D118.B6 171.91,81.28 ; D126.B4 20.32,82.09 ; D126.B4 19.51,81.28 ; D126.B4 21.13,81.28 ; D126.B4 20.32,80.47 ; D132.A14 120.19,35.56 ; D132.A14 119.38,34.75 ; D132.A14 118.57,35.56 ; D132.A14 119.38,36.37 ; D115.A7 332.74,376.73 ; D115.A7 333.55,375.92 ; D115.A7 332.74,375.11 ; D115.A7 331.93,375.92 ; 245.57,76.2 D122.A6 ; D122.A6 247.19,76.2 ; D122.A6 246.38,75.39 ; D122.A6 246.38,77.01 ; 118.57,60.96 D131.B14 ; D131.B14 120.19,60.96 ; D131.B14 119.38,60.15 ; D131.B14 119.38,61.77 ; 398.78,367.49 D111.B10 ; D111.B10 398.78,369.11 ; D111.B10 397.97,368.3 ; D111.B10 399.59,368.3 ; 159.31,68.58 D318.B1 ; D318.B1 160.73,68.58 ; D318.B1 160.02,67.87 ; D318.B1 160.02,69.29 ; 194.77,58.42 D119.B15 ; D119.B15 196.39,58.42 ; D119.B15 195.58,59.23 ; D119.B15 195.58,57.61 ; 105.87,73.66 D130.A9 ; D130.A9 107.49,73.66 ; D130.A9 106.68,72.85 ; D130.A9 106.68,74.47 ; 339.55,60.96 D103.B14 ; D103.B14 340.36,61.77 ; D103.B14 340.36,60.15 ; D103.B14 341.17,60.96 ; CSDPS429.C5 191.31,340.36 ; CSDPS429.C5 189.69,340.36 ; CSDPS429.C5 190.5,339.55 ; CSDPS429.C5 190.5,341.17 ; D120.B10 183.69,40.64 ; D120.B10 182.88,41.45 ; D120.B10 182.88,39.83 ; D120.B10 182.07,40.64 ; D104.B10 330.2,41.45 ; D104.B10 330.2,39.83 ; D104.B10 331.01,40.64 ; D104.B10 329.39,40.64 ; 320.04,34.75 D104.A6 ; D104.A6 320.04,36.37 ; D104.A6 320.85,35.56 ; D104.A6 319.23,35.56 ; D131.B7 102.41,58.42 ; D131.B7 100.79,58.42 ; D131.B7 101.6,57.61 ; D131.B7 101.6,59.23 ; 184.61,381 D431.B7 ; D431.B7 186.23,381 ; D431.B7 185.42,381.81 ; D431.B7 185.42,380.19 ; 393.7,85.65 D305.A6 ; D305.A6 392.99,86.36 ; D305.A6 394.41,86.36 ; D305.A6 393.7,87.07 ; 171.91,368.3 D231.B12 ; D231.B12 172.72,369.11 ; D231.B12 172.72,367.49 ; D231.B12 173.53,368.3 ; D302.A16 346.15,66.04 ; D302.A16 344.73,66.04 ; D302.A16 345.44,66.75 ; D302.A16 345.44,65.33 ; UNK3U2.4 97.4,176.4 ; UNK3U2.4 96.46,175.46 ; UNK3U2.4 97.4,174.52 ; UNK3U2.4 98.34,175.46 ; 170.18,72.85 D118.A5 ; D118.A5 170.99,73.66 ; D118.A5 170.18,74.47 ; D118.A5 169.37,73.66 ; D129.A9 107.49,93.98 ; D129.A9 105.87,93.98 ; D129.A9 106.68,94.79 ; D129.A9 106.68,93.17 ; 103.33,96.52 D129.A8 ; D129.A8 104.95,96.52 ; D129.A8 104.14,97.33 ; D129.A8 104.14,95.71 ; 261.62,34.75 D124.A12 ; D124.A12 260.81,35.56 ; D124.A12 261.62,36.37 ; D124.A12 262.43,35.56 ; D123.B14 266.7,61.77 ; D123.B14 267.51,60.96 ; D123.B14 265.89,60.96 ; D123.B14 266.7,60.15 ; D318.A2 163.27,66.04 ; D318.A2 161.85,66.04 ; D318.A2 162.56,65.33 ; D318.A2 162.56,66.75 ; D115.B13 317.5,371.65 ; D115.B13 316.69,370.84 ; D115.B13 318.31,370.84 ; D115.B13 317.5,370.03 ; SITE3.G14 250.71,182.83 ; SITE3.G14 250.23,183.31 ; SITE3.G14 250.23,182.35 ; SITE3.G14 249.75,182.83 ; D123.A16 272.59,55.88 ; D123.A16 270.97,55.88 ; D123.A16 271.78,56.69 ; D123.A16 271.78,55.07 ; D120.A3 165.91,33.02 ; D120.A3 165.1,32.21 ; D120.A3 165.1,33.83 ; D120.A3 164.29,33.02 ; 398.78,80.47 D106.B8 ; D106.B8 399.59,81.28 ; D106.B8 398.78,82.09 ; D106.B8 397.97,81.28 ; 307.34,52.53 D103.A1 ; D103.A1 306.53,53.34 ; D103.A1 307.34,54.15 ; D103.A1 308.15,53.34 ; 164.39,88.9 D317.B3 ; D317.B3 165.1,88.19 ; D317.B3 165.1,89.61 ; D317.B3 165.81,88.9 ; 413.31,91.44 D305.B14 ; D305.B14 414.02,90.73 ; D305.B14 414.73,91.44 ; D305.B14 414.02,92.15 ; 327.66,395.43 D116.A9 ; D116.A9 327.66,397.05 ; D116.A9 326.85,396.24 ; D116.A9 328.47,396.24 ; 169.37,330.2 CSDPS229.C13 ; CSDPS229.C13 170.18,329.39 ; CSDPS229.C13 170.99,330.2 ; CSDPS229.C13 170.18,331.01 ; 236.22,331.93 CSDPS225.B16 ; CSDPS225.B16 236.22,333.55 ; CSDPS225.B16 235.41,332.74 ; CSDPS225.B16 237.03,332.74 ; 396.24,390.35 D112.B11 ; D112.B11 397.05,391.16 ; D112.B11 395.43,391.16 ; D112.B11 396.24,391.97 ; 340.36,34.75 D104.A14 ; D104.A14 339.55,35.56 ; D104.A14 340.36,36.37 ; D104.A14 341.17,35.56 ; 408.23,66.04 D306.A12 ; D306.A12 408.94,66.75 ; D306.A12 408.94,65.33 ; D306.A12 409.65,66.04 ; D103.A2 309.88,56.69 ; D103.A2 309.07,55.88 ; D103.A2 310.69,55.88 ; D103.A2 309.88,55.07 ; D118.A12 188.77,76.2 ; D118.A12 187.15,76.2 ; D118.A12 187.96,75.39 ; D118.A12 187.96,77.01 ; D112.A10 398.78,394.51 ; D112.A10 399.59,393.7 ; D112.A10 397.97,393.7 ; D112.A10 398.78,392.89 ; D120.B6 173.53,40.64 ; D120.B6 172.72,39.83 ; D120.B6 172.72,41.45 ; D120.B6 171.91,40.64 ; D125.B1 12.7,99.87 ; D125.B1 13.51,99.06 ; D125.B1 11.89,99.06 ; D125.B1 12.7,98.25 ; D104.B7 322.58,38.91 ; D104.B7 323.39,38.1 ; D104.B7 321.77,38.1 ; D104.B7 322.58,37.29 ; SITE4.G17 329.51,186.43 ; SITE4.G17 329.03,186.91 ; SITE4.G17 329.03,185.95 ; SITE4.G17 328.55,186.43 ; D107.A15 417.37,53.34 ; D107.A15 415.75,53.34 ; D107.A15 416.56,54.15 ; D107.A15 416.56,52.53 ; 232.97,68.58 D322.B1 ; D322.B1 233.68,67.87 ; D322.B1 234.39,68.58 ; D322.B1 233.68,69.29 ; 405.59,396.24 D112.A7 ; D112.A7 406.4,395.43 ; D112.A7 407.21,396.24 ; D112.A7 406.4,397.05 ; D116.B13 318.31,391.16 ; D116.B13 316.69,391.16 ; D116.B13 317.5,391.97 ; D116.B13 317.5,390.35 ; D102.B11 333.55,78.74 ; D102.B11 331.93,78.74 ; D102.B11 332.74,77.93 ; D102.B11 332.74,79.55 ; D127.A14 45.72,56.69 ; D127.A14 46.53,55.88 ; D127.A14 44.91,55.88 ; D127.A14 45.72,55.07 ; D114.A12 320.04,353.87 ; D114.A12 320.85,353.06 ; D114.A12 320.04,352.25 ; D114.A12 319.23,353.06 ; 269.24,88.19 D321.B15 ; D321.B15 268.53,88.9 ; D321.B15 269.24,89.61 ; D321.B15 269.95,88.9 ; CSDPS429.C15 165.1,341.17 ; CSDPS429.C15 164.29,340.36 ; CSDPS429.C15 165.1,339.55 ; CSDPS429.C15 165.91,340.36 ; D112.A14 389.43,393.7 ; D112.A14 387.81,393.7 ; D112.A14 388.62,394.51 ; D112.A14 388.62,392.89 ; D127.A8 30.48,56.69 ; D127.A8 30.48,55.07 ; D127.A8 31.29,55.88 ; D127.A8 29.67,55.88 ; 332.74,32.21 D104.A11 ; D104.A11 332.74,33.83 ; D104.A11 331.93,33.02 ; D104.A11 333.55,33.02 ; D114.A11 323.39,355.6 ; D114.A11 322.58,354.79 ; D114.A11 322.58,356.41 ; D114.A11 321.77,355.6 ; 319.23,76.2 D102.A6 ; D102.A6 320.85,76.2 ; D102.A6 320.04,77.01 ; D102.A6 320.04,75.39 ; D120.B5 170.99,38.1 ; D120.B5 170.18,38.91 ; D120.B5 170.18,37.29 ; D120.B5 169.37,38.1 ; SITE4.G20 333.11,186.43 ; SITE4.G20 332.63,185.95 ; SITE4.G20 332.63,186.91 ; SITE4.G20 332.15,186.43 ; 398.78,326.85 D109.B10 ; D109.B10 397.97,327.66 ; D109.B10 399.59,327.66 ; D109.B10 398.78,328.47 ; 17.78,93.17 D125.A3 ; D125.A3 17.78,94.79 ; D125.A3 18.59,93.98 ; D125.A3 16.97,93.98 ; 419.1,70.41 D306.B16 ; D306.B16 419.81,71.12 ; D306.B16 418.39,71.12 ; D306.B16 419.1,71.83 ; SITE1.G7 248.33,248.41 ; SITE1.G7 247.85,247.93 ; SITE1.G7 248.33,247.45 ; SITE1.G7 248.81,247.93 ; CSDPS225.B4 267.51,332.74 ; CSDPS225.B4 266.7,331.93 ; CSDPS225.B4 266.7,333.55 ; CSDPS225.B4 265.89,332.74 ; 12.7,52.53 D127.A1 ; D127.A1 12.7,54.15 ; D127.A1 11.89,53.34 ; D127.A1 13.51,53.34 ; D130.B7 101.6,79.55 ; D130.B7 102.41,78.74 ; D130.B7 100.79,78.74 ; D130.B7 101.6,77.93 ; 49.99,35.56 D128.A16 ; D128.A16 51.61,35.56 ; D128.A16 50.8,36.37 ; D128.A16 50.8,34.75 ; 169.37,375.92 D231.A13 ; D231.A13 170.18,375.11 ; D231.A13 170.99,375.92 ; D231.A13 170.18,376.73 ; D317.A10 183.59,86.36 ; D317.A10 182.88,87.07 ; D317.A10 182.17,86.36 ; D317.A10 182.88,85.65 ; D106.B3 386.89,78.74 ; D106.B3 386.08,77.93 ; D106.B3 385.27,78.74 ; D106.B3 386.08,79.55 ; 332.74,354.79 D114.A7 ; D114.A7 332.74,356.41 ; D114.A7 333.55,355.6 ; D114.A7 331.93,355.6 ; D120.A16 198.12,36.37 ; D120.A16 198.93,35.56 ; D120.A16 198.12,34.75 ; D120.A16 197.31,35.56 ; S3_I2C.4 84.25,209.04 ; S3_I2C.4 82.37,209.04 ; S3_I2C.4 83.31,209.98 ; S3_I2C.4 83.31,208.1 ; D115.B12 320.04,369.11 ; D115.B12 320.04,367.49 ; D115.B12 319.23,368.3 ; D115.B12 320.85,368.3 ; 314.96,347.17 D114.B14 ; D114.B14 314.96,348.79 ; D114.B14 314.15,347.98 ; D114.B14 315.77,347.98 ; D322.B7 248.92,69.29 ; D322.B7 248.92,67.87 ; D322.B7 248.21,68.58 ; D322.B7 249.63,68.58 ; 314.15,353.06 D114.A14 ; D114.A14 315.77,353.06 ; D114.A14 314.96,352.25 ; D114.A14 314.96,353.87 ; 174.45,370.84 D231.B11 ; D231.B11 175.26,371.65 ; D231.B11 176.07,370.84 ; D231.B11 175.26,370.03 ; D132.A11 112.57,33.02 ; D132.A11 111.76,32.21 ; D132.A11 110.95,33.02 ; D132.A11 111.76,33.83 ; 311.61,370.84 D115.B15 ; D115.B15 312.42,370.03 ; D115.B15 312.42,371.65 ; D115.B15 313.23,370.84 ; D321.A12 261.62,87.07 ; D321.A12 262.33,86.36 ; D321.A12 261.62,85.65 ; D321.A12 260.91,86.36 ; D305.A11 406.4,84.53 ; D305.A11 405.69,83.82 ; D305.A11 407.11,83.82 ; D305.A11 406.4,83.11 ; D305.B10 404.57,91.44 ; D305.B10 403.86,90.73 ; D305.B10 403.86,92.15 ; D305.B10 403.15,91.44 ; 406.4,57.61 D107.B11 ; D107.B11 407.21,58.42 ; D107.B11 405.59,58.42 ; D107.B11 406.4,59.23 ; D106.A15 416.56,74.47 ; D106.A15 416.56,72.85 ; D106.A15 417.37,73.66 ; D106.A15 415.75,73.66 ; D129.A12 115.11,96.52 ; D129.A12 114.3,95.71 ; D129.A12 113.49,96.52 ; D129.A12 114.3,97.33 ; 119.38,95.71 D129.A14 ; D129.A14 119.38,97.33 ; D129.A14 118.57,96.52 ; D129.A14 120.19,96.52 ; 240.59,86.36 D321.A4 ; D321.A4 242.01,86.36 ; D321.A4 241.3,87.07 ; D321.A4 241.3,85.65 ; D113.B15 312.42,331.01 ; D113.B15 312.42,329.39 ; D113.B15 311.61,330.2 ; D113.B15 313.23,330.2 ; D130.B3 91.44,79.55 ; D130.B3 90.63,78.74 ; D130.B3 92.25,78.74 ; D130.B3 91.44,77.93 ; CSDPS429.C11 176.07,340.36 ; CSDPS429.C11 175.26,339.55 ; CSDPS429.C11 175.26,341.17 ; CSDPS429.C11 174.45,340.36 ; 413.21,81.28 D106.B14 ; D106.B14 414.02,82.09 ; D106.B14 414.83,81.28 ; D106.B14 414.02,80.47 ; D102.A3 313.23,73.66 ; D102.A3 311.61,73.66 ; D102.A3 312.42,72.85 ; D102.A3 312.42,74.47 ; D107.B14 414.83,60.96 ; D107.B14 413.21,60.96 ; D107.B14 414.02,61.77 ; D107.B14 414.02,60.15 ; 164.39,68.58 D318.B3 ; D318.B3 165.1,69.29 ; D318.B3 165.81,68.58 ; D318.B3 165.1,67.87 ; D125.A2 15.24,97.33 ; D125.A2 14.43,96.52 ; D125.A2 16.05,96.52 ; D125.A2 15.24,95.71 ; D106.A11 406.4,74.47 ; D106.A11 407.21,73.66 ; D106.A11 405.59,73.66 ; D106.A11 406.4,72.85 ; D302.B12 335.99,71.12 ; D302.B12 335.28,71.83 ; D302.B12 334.57,71.12 ; D302.B12 335.28,70.41 ; 37.29,93.98 D125.A11 ; D125.A11 38.1,94.79 ; D125.A11 38.1,93.17 ; D125.A11 38.91,93.98 ; 235.51,91.44 D321.B2 ; D321.B2 236.22,92.15 ; D321.B2 236.93,91.44 ; D321.B2 236.22,90.73 ; 309.88,331.93 D113.A16 ; D113.A16 309.88,333.55 ; D113.A16 310.69,332.74 ; D113.A16 309.07,332.74 ; D127.B14 46.53,60.96 ; D127.B14 45.72,61.77 ; D127.B14 44.91,60.96 ; D127.B14 45.72,60.15 ; CSDPS225.C13 244.65,330.2 ; CSDPS225.C13 243.84,329.39 ; CSDPS225.C13 243.03,330.2 ; CSDPS225.C13 243.84,331.01 ; CSDPS429.B10 178.61,342.9 ; CSDPS429.B10 177.8,342.09 ; CSDPS429.B10 176.99,342.9 ; CSDPS429.B10 177.8,343.71 ; 380.19,53.34 D107.A1 ; D107.A1 381.81,53.34 ; D107.A1 381,54.15 ; D107.A1 381,52.53 ; 328.55,182.83 SITE4.G13 ; SITE4.G13 329.03,182.35 ; SITE4.G13 329.51,182.83 ; SITE4.G13 329.03,183.31 ; 325.12,387.81 D116.B10 ; D116.B10 325.93,388.62 ; D116.B10 325.12,389.43 ; D116.B10 324.31,388.62 ; 331.93,370.84 D115.B7 ; D115.B7 333.55,370.84 ; D115.B7 332.74,370.03 ; D115.B7 332.74,371.65 ; D124.B16 272.59,40.64 ; D124.B16 271.78,41.45 ; D124.B16 271.78,39.83 ; D124.B16 270.97,40.64 ; D112.B5 411.48,391.97 ; D112.B5 410.67,391.16 ; D112.B5 411.48,390.35 ; D112.B5 412.29,391.16 ; 182.17,71.12 D318.B10 ; D318.B10 183.59,71.12 ; D318.B10 182.88,70.41 ; D318.B10 182.88,71.83 ; D128.B15 48.26,38.91 ; D128.B15 47.45,38.1 ; D128.B15 48.26,37.29 ; D128.B15 49.07,38.1 ; 413.21,35.56 D108.A14 ; D108.A14 414.83,35.56 ; D108.A14 414.02,36.37 ; D108.A14 414.02,34.75 ; 312.42,88.19 D301.B3 ; D301.B3 312.42,89.61 ; D301.B3 311.71,88.9 ; D301.B3 313.13,88.9 ; 414.02,331.93 D109.A4 ; D109.A4 413.21,332.74 ; D109.A4 414.83,332.74 ; D109.A4 414.02,333.55 ; D103.A10 330.2,56.69 ; D103.A10 331.01,55.88 ; D103.A10 330.2,55.07 ; D103.A10 329.39,55.88 ; 104.14,55.07 D131.A8 ; D131.A8 104.95,55.88 ; D131.A8 103.33,55.88 ; D131.A8 104.14,56.69 ; 243.13,88.9 D321.B5 ; D321.B5 243.84,89.61 ; D321.B5 243.84,88.19 ; D321.B5 244.55,88.9 ; 334.47,76.2 D102.A12 ; D102.A12 335.28,77.01 ; D102.A12 335.28,75.39 ; D102.A12 336.09,76.2 ; 179.53,33.02 D120.A9 ; D120.A9 181.15,33.02 ; D120.A9 180.34,33.83 ; D120.A9 180.34,32.21 ; D129.B4 94.79,101.6 ; D129.B4 93.98,102.41 ; D129.B4 93.17,101.6 ; D129.B4 93.98,100.79 ; 391.16,370.03 D111.B13 ; D111.B13 391.97,370.84 ; D111.B13 390.35,370.84 ; D111.B13 391.16,371.65 ; D106.A6 394.51,76.2 ; D106.A6 392.89,76.2 ; D106.A6 393.7,75.39 ; D106.A6 393.7,77.01 ; 330.85,241.33 SITE2.G4 ; SITE2.G4 331.33,241.81 ; SITE2.G4 331.33,240.85 ; SITE2.G4 331.81,241.33 ; 235.51,86.36 D321.A2 ; D321.A2 236.22,85.65 ; D321.A2 236.22,87.07 ; D321.A2 236.93,86.36 ; 383.54,331.93 D109.A16 ; D109.A16 383.54,333.55 ; D109.A16 384.35,332.74 ; D109.A16 382.73,332.74 ; 390.35,396.24 D112.A13 ; D112.A13 391.97,396.24 ; D112.A13 391.16,397.05 ; D112.A13 391.16,395.43 ; 309.07,368.3 D115.B16 ; D115.B16 309.88,369.11 ; D115.B16 310.69,368.3 ; D115.B16 309.88,367.49 ; SITE1.G5 252.81,241.33 ; SITE1.G5 252.33,241.81 ; SITE1.G5 252.33,240.85 ; SITE1.G5 251.85,241.33 ; D109.A12 393.7,333.55 ; D109.A12 393.7,331.93 ; D109.A12 392.89,332.74 ; D109.A12 394.51,332.74 ; 27.94,52.53 D127.A7 ; D127.A7 28.75,53.34 ; D127.A7 27.94,54.15 ; D127.A7 27.13,53.34 ; 319.23,60.96 D103.B6 ; D103.B6 320.04,61.77 ; D103.B6 320.85,60.96 ; D103.B6 320.04,60.15 ; D127.A6 25.4,56.69 ; D127.A6 25.4,55.07 ; D127.A6 26.21,55.88 ; D127.A6 24.59,55.88 ; D317.A1 160.02,84.53 ; D317.A1 160.02,83.11 ; D317.A1 160.73,83.82 ; D317.A1 159.31,83.82 ; D301.B7 322.58,89.61 ; D301.B7 321.87,88.9 ; D301.B7 323.29,88.9 ; D301.B7 322.58,88.19 ; D129.B9 106.68,99.87 ; D129.B9 106.68,98.25 ; D129.B9 107.49,99.06 ; D129.B9 105.87,99.06 ; D132.A15 121.92,33.83 ; D132.A15 121.11,33.02 ; D132.A15 121.92,32.21 ; D132.A15 122.73,33.02 ; 118.57,40.64 D132.B14 ; D132.B14 119.38,41.45 ; D132.B14 120.19,40.64 ; D132.B14 119.38,39.83 ; D103.A16 346.25,55.88 ; D103.A16 344.63,55.88 ; D103.A16 345.44,56.69 ; D103.A16 345.44,55.07 ; D111.B16 383.54,369.11 ; D111.B16 383.54,367.49 ; D111.B16 384.35,368.3 ; D111.B16 382.73,368.3 ; 387.81,81.28 D106.B4 ; D106.B4 388.62,80.47 ; D106.B4 388.62,82.09 ; D106.B4 389.43,81.28 ; 329.49,71.12 D302.B10 ; D302.B10 330.2,71.83 ; D302.B10 330.2,70.41 ; D302.B10 330.91,71.12 ; 25.4,60.15 D127.B6 ; D127.B6 24.59,60.96 ; D127.B6 25.4,61.77 ; D127.B6 26.21,60.96 ; 269.24,32.21 D124.A15 ; D124.A15 269.24,33.83 ; D124.A15 270.05,33.02 ; D124.A15 268.43,33.02 ; 159.21,73.66 D118.A1 ; D118.A1 160.02,74.47 ; D118.A1 160.83,73.66 ; D118.A1 160.02,72.85 ; 190.5,409.4 DPS8.C05 ; DPS8.C05 191.31,410.21 ; DPS8.C05 190.5,411.02 ; DPS8.C05 189.69,410.21 ; SITE1.G11 252.81,247.93 ; SITE1.G11 252.33,248.41 ; SITE1.G11 251.85,247.93 ; SITE1.G11 252.33,247.45 ; 342.9,72.85 D102.A15 ; D102.A15 343.71,73.66 ; D102.A15 342.09,73.66 ; D102.A15 342.9,74.47 ; D123.A11 259.89,53.34 ; D123.A11 258.27,53.34 ; D123.A11 259.08,54.15 ; D123.A11 259.08,52.53 ; D108.A10 403.86,36.37 ; D108.A10 403.05,35.56 ; D108.A10 403.86,34.75 ; D108.A10 404.67,35.56 ; 411.48,329.39 D109.B5 ; D109.B5 411.48,331.01 ; D109.B5 412.29,330.2 ; D109.B5 410.67,330.2 ; D113.B6 335.28,328.47 ; D113.B6 334.47,327.66 ; D113.B6 335.28,326.85 ; D113.B6 336.09,327.66 ; D131.B15 122.73,58.42 ; D131.B15 121.11,58.42 ; D131.B15 121.92,59.23 ; D131.B15 121.92,57.61 ; 405.59,370.84 D111.B7 ; D111.B7 406.4,371.65 ; D111.B7 407.21,370.84 ; D111.B7 406.4,370.03 ; D130.B11 112.57,78.74 ; D130.B11 111.76,79.55 ; D130.B11 110.95,78.74 ; D130.B11 111.76,77.93 ; D110.A14 388.62,353.87 ; D110.A14 387.81,353.06 ; D110.A14 389.43,353.06 ; D110.A14 388.62,352.25 ; D301.B2 310.59,91.44 ; D301.B2 309.17,91.44 ; D301.B2 309.88,90.73 ; D301.B2 309.88,92.15 ; D110.B6 408.94,348.79 ; D110.B6 408.94,347.17 ; D110.B6 409.75,347.98 ; D110.B6 408.13,347.98 ; SITE3.G3 250.81,181.33 ; SITE3.G3 249.85,181.33 ; SITE3.G3 250.33,180.85 ; SITE3.G3 250.33,181.81 ; 337.11,88.9 D301.B13 ; D301.B13 337.82,89.61 ; D301.B13 337.82,88.19 ; D301.B13 338.53,88.9 ; 309.17,66.04 D302.A2 ; D302.A2 309.88,66.75 ; D302.A2 309.88,65.33 ; D302.A2 310.59,66.04 ; D130.A11 111.76,74.47 ; D130.A11 111.76,72.85 ; D130.A11 110.95,73.66 ; D130.A11 112.57,73.66 ; DPS1.A01 381,14.78 ; DPS1.A01 381,13.16 ; DPS1.A01 380.19,13.97 ; DPS1.A01 381.81,13.97 ; 258.27,58.42 D123.B11 ; D123.B11 259.89,58.42 ; D123.B11 259.08,57.61 ; D123.B11 259.08,59.23 ; D306.B12 409.65,71.12 ; D306.B12 408.23,71.12 ; D306.B12 408.94,70.41 ; D306.B12 408.94,71.83 ; 391.16,390.35 D112.B13 ; D112.B13 390.35,391.16 ; D112.B13 391.16,391.97 ; D112.B13 391.97,391.16 ; 268.43,330.2 CSDPS225.C3 ; CSDPS225.C3 270.05,330.2 ; CSDPS225.C3 269.24,329.39 ; CSDPS225.C3 269.24,331.01 ; 248.92,62.79 D322.A7 ; D322.A7 249.63,63.5 ; D322.A7 248.21,63.5 ; D322.A7 248.92,64.21 ; 408.13,60.96 D107.B12 ; D107.B12 408.94,60.15 ; D107.B12 409.75,60.96 ; D107.B12 408.94,61.77 ; D123.B9 254,59.23 ; D123.B9 254,57.61 ; D123.B9 254.81,58.42 ; D123.B9 253.19,58.42 ; 255.73,76.2 D122.A10 ; D122.A10 256.54,75.39 ; D122.A10 256.54,77.01 ; D122.A10 257.35,76.2 ; 416.56,334.47 D109.A3 ; D109.A3 415.75,335.28 ; D109.A3 416.56,336.09 ; D109.A3 417.37,335.28 ; 238.76,339.55 CSDPS425.C15 ; CSDPS425.C15 237.95,340.36 ; CSDPS425.C15 238.76,341.17 ; CSDPS425.C15 239.57,340.36 ; 243.03,19.05 DPS3.C05 ; DPS3.C05 243.84,19.86 ; DPS3.C05 243.84,18.24 ; DPS3.C05 244.65,19.05 ; D321.A5 243.84,84.53 ; D321.A5 243.84,83.11 ; D321.A5 244.55,83.82 ; D321.A5 243.13,83.82 ; 518.92,202.51 S4_I2C.4 ; S4_I2C.4 519.86,203.45 ; S4_I2C.4 518.92,204.39 ; S4_I2C.4 517.98,203.45 ; 93.17,96.52 D129.A4 ; D129.A4 93.98,95.71 ; D129.A4 94.79,96.52 ; D129.A4 93.98,97.33 ; SITE4.G16 333.11,182.83 ; SITE4.G16 332.63,182.35 ; SITE4.G16 332.63,183.31 ; SITE4.G16 332.15,182.83 ; 177.8,382.73 D431.A10 ; D431.A10 176.99,383.54 ; D431.A10 178.61,383.54 ; D431.A10 177.8,384.35 ; 481.65,185.11 UNK4U1.4 ; UNK4U1.4 482.59,186.05 ; UNK4U1.4 482.59,184.17 ; UNK4U1.4 483.53,185.11 ; D102.A7 322.58,74.47 ; D102.A7 321.77,73.66 ; D102.A7 322.58,72.85 ; D102.A7 323.39,73.66 ; D107.A7 396.24,54.15 ; D107.A7 397.05,53.34 ; D107.A7 396.24,52.53 ; D107.A7 395.43,53.34 ; D120.A13 190.5,33.83 ; D120.A13 189.69,33.02 ; D120.A13 190.5,32.21 ; D120.A13 191.31,33.02 ; D124.B14 267.51,40.64 ; D124.B14 265.89,40.64 ; D124.B14 266.7,39.83 ; D124.B14 266.7,41.45 ; 334.47,353.06 D114.A6 ; D114.A6 335.28,353.87 ; D114.A6 336.09,353.06 ; D114.A6 335.28,352.25 ; 268.53,68.58 D322.B15 ; D322.B15 269.95,68.58 ; D322.B15 269.24,67.87 ; D322.B15 269.24,69.29 ; DPS8.A05 190.5,416.1 ; DPS8.A05 190.5,414.48 ; DPS8.A05 191.31,415.29 ; DPS8.A05 189.69,415.29 ; 387.81,368.3 D111.B14 ; D111.B14 388.62,369.11 ; D111.B14 389.43,368.3 ; D111.B14 388.62,367.49 ; D108.B12 408.94,41.45 ; D108.B12 409.75,40.64 ; D108.B12 408.94,39.83 ; D108.B12 408.13,40.64 ; 329.85,181.33 SITE4.G3 ; SITE4.G3 330.33,180.85 ; SITE4.G3 330.33,181.81 ; SITE4.G3 330.81,181.33 ; D321.A7 248.92,84.53 ; D321.A7 249.63,83.82 ; D321.A7 248.21,83.82 ; D321.A7 248.92,83.11 ; D122.B6 247.19,81.28 ; D122.B6 246.38,82.09 ; D122.B6 245.57,81.28 ; D122.B6 246.38,80.47 ; D231.A11 175.26,376.73 ; D231.A11 176.07,375.92 ; D231.A11 175.26,375.11 ; D231.A11 174.45,375.92 ; 253.19,53.34 D123.A9 ; D123.A9 254,52.53 ; D123.A9 254,54.15 ; D123.A9 254.81,53.34 ; D119.B7 175.26,59.23 ; D119.B7 175.26,57.61 ; D119.B7 176.07,58.42 ; D119.B7 174.45,58.42 ; D104.B4 314.96,41.45 ; D104.B4 314.96,39.83 ; D104.B4 315.77,40.64 ; D104.B4 314.15,40.64 ; SITE2.G17 329.51,246.43 ; SITE2.G17 329.03,245.95 ; SITE2.G17 329.03,246.91 ; SITE2.G17 328.55,246.43 ; D431.A16 162.56,384.35 ; D431.A16 162.56,382.73 ; D431.A16 163.37,383.54 ; D431.A16 161.75,383.54 ; D231.A6 187.96,374.19 ; D231.A6 187.15,373.38 ; D231.A6 187.96,372.57 ; D231.A6 188.77,373.38 ; 416.56,349.71 D110.B3 ; D110.B3 415.75,350.52 ; D110.B3 417.37,350.52 ; D110.B3 416.56,351.33 ; 344.63,327.66 D113.B2 ; D113.B2 346.25,327.66 ; D113.B2 345.44,328.47 ; D113.B2 345.44,326.85 ; 252.63,245.95 SITE1.G20 ; SITE1.G20 252.63,246.91 ; SITE1.G20 253.11,246.43 ; SITE1.G20 252.15,246.43 ; 182.88,90.73 D317.B10 ; D317.B10 183.59,91.44 ; D317.B10 182.17,91.44 ; D317.B10 182.88,92.15 ; D125.B6 26.21,101.6 ; D125.B6 25.4,102.41 ; D125.B6 25.4,100.79 ; D125.B6 24.59,101.6 ; 253.19,330.2 CSDPS225.C9 ; CSDPS225.C9 254,329.39 ; CSDPS225.C9 254.81,330.2 ; CSDPS225.C9 254,331.01 ; 116.84,57.61 D131.B13 ; D131.B13 116.84,59.23 ; D131.B13 117.65,58.42 ; D131.B13 116.03,58.42 ; 50.8,39.83 D128.B16 ; D128.B16 50.8,41.45 ; D128.B16 49.99,40.64 ; D128.B16 51.61,40.64 ; D110.A1 422.45,355.6 ; D110.A1 420.83,355.6 ; D110.A1 421.64,356.41 ; D110.A1 421.64,354.79 ; D122.B9 254,79.55 ; D122.B9 254.81,78.74 ; D122.B9 254,77.93 ; D122.B9 253.19,78.74 ; D113.B9 327.66,331.01 ; D113.B9 328.47,330.2 ; D113.B9 326.85,330.2 ; D113.B9 327.66,329.39 ; D322.A6 247.09,66.04 ; D322.A6 246.38,66.75 ; D322.A6 245.67,66.04 ; D322.A6 246.38,65.33 ; D322.A11 259.08,64.21 ; D322.A11 259.08,62.79 ; D322.A11 258.37,63.5 ; D322.A11 259.79,63.5 ; 340.36,392.89 D116.A4 ; D116.A4 339.55,393.7 ; D116.A4 340.36,394.51 ; D116.A4 341.17,393.7 ; D127.B1 13.51,58.42 ; D127.B1 12.7,57.61 ; D127.B1 12.7,59.23 ; D127.B1 11.89,58.42 ; 311.61,78.74 D102.B3 ; D102.B3 312.42,79.55 ; D102.B3 312.42,77.93 ; D102.B3 313.23,78.74 ; 332.85,181.33 SITE4.G6 ; SITE4.G6 333.33,181.81 ; SITE4.G6 333.81,181.33 ; SITE4.G6 333.33,180.85 ; 328.33,187.45 SITE4.G7 ; SITE4.G7 328.33,188.41 ; SITE4.G7 328.81,187.93 ; SITE4.G7 327.85,187.93 ; 171.91,378.46 D431.B12 ; D431.B12 172.72,377.65 ; D431.B12 172.72,379.27 ; D431.B12 173.53,378.46 ; D111.A5 412.29,375.92 ; D111.A5 411.48,376.73 ; D111.A5 411.48,375.11 ; D111.A5 410.67,375.92 ; SITE2.G5 332.33,241.81 ; SITE2.G5 332.33,240.85 ; SITE2.G5 331.85,241.33 ; SITE2.G5 332.81,241.33 ; D128.A13 43.18,33.83 ; D128.A13 42.37,33.02 ; D128.A13 43.18,32.21 ; D128.A13 43.99,33.02 ; 172.72,34.75 D120.A6 ; D120.A6 172.72,36.37 ; D120.A6 173.53,35.56 ; D120.A6 171.91,35.56 ; D110.B13 391.97,350.52 ; D110.B13 391.16,349.71 ; D110.B13 390.35,350.52 ; D110.B13 391.16,351.33 ; D122.A15 270.05,73.66 ; D122.A15 269.24,72.85 ; D122.A15 268.43,73.66 ; D122.A15 269.24,74.47 ; 250.33,247.45 SITE1.G9 ; SITE1.G9 250.81,247.93 ; SITE1.G9 250.33,248.41 ; SITE1.G9 249.85,247.93 ; 164.29,78.74 D118.B3 ; D118.B3 165.1,77.93 ; D118.B3 165.91,78.74 ; D118.B3 165.1,79.55 ; D129.A1 87.17,93.98 ; D129.A1 86.36,94.79 ; D129.A1 85.55,93.98 ; D129.A1 86.36,93.17 ; SITE3.G17 249.51,186.43 ; SITE3.G17 248.55,186.43 ; SITE3.G17 249.03,186.91 ; SITE3.G17 249.03,185.95 ; 396.24,329.39 D109.B11 ; D109.B11 397.05,330.2 ; D109.B11 396.24,331.01 ; D109.B11 395.43,330.2 ; 393.7,326.85 D109.B12 ; D109.B12 394.51,327.66 ; D109.B12 393.7,328.47 ; D109.B12 392.89,327.66 ; D301.A14 341.07,86.36 ; D301.A14 339.65,86.36 ; D301.A14 340.36,87.07 ; D301.A14 340.36,85.65 ; 339.65,71.12 D302.B14 ; D302.B14 341.07,71.12 ; D302.B14 340.36,70.41 ; D302.B14 340.36,71.83 ; 180.34,72.85 D118.A9 ; D118.A9 180.34,74.47 ; D118.A9 179.53,73.66 ; D118.A9 181.15,73.66 ; 194.77,330.2 CSDPS229.C3 ; CSDPS229.C3 195.58,331.01 ; CSDPS229.C3 196.39,330.2 ; CSDPS229.C3 195.58,329.39 ; 344.73,86.36 D301.A16 ; D301.A16 345.44,87.07 ; D301.A16 346.15,86.36 ; D301.A16 345.44,85.65 ; 408.94,331.93 D109.A6 ; D109.A6 409.75,332.74 ; D109.A6 408.94,333.55 ; D109.A6 408.13,332.74 ; D132.B7 101.6,38.91 ; D132.B7 102.41,38.1 ; D132.B7 100.79,38.1 ; D132.B7 101.6,37.29 ; D111.B11 396.24,371.65 ; D111.B11 397.05,370.84 ; D111.B11 396.24,370.03 ; D111.B11 395.43,370.84 ; DPS1.A15 416.56,14.78 ; DPS1.A15 415.75,13.97 ; DPS1.A15 417.37,13.97 ; DPS1.A15 416.56,13.16 ; 408.23,86.36 D305.A12 ; D305.A12 408.94,87.07 ; D305.A12 409.65,86.36 ; D305.A12 408.94,85.65 ; D116.A1 348.79,396.24 ; D116.A1 347.17,396.24 ; D116.A1 347.98,395.43 ; D116.A1 347.98,397.05 ; 397.97,353.06 D110.A10 ; D110.A10 398.78,352.25 ; D110.A10 398.78,353.87 ; D110.A10 399.59,353.06 ; 198.12,70.41 D318.B16 ; D318.B16 197.41,71.12 ; D318.B16 198.12,71.83 ; D318.B16 198.83,71.12 ; 388.62,60.15 D107.B4 ; D107.B4 388.62,61.77 ; D107.B4 389.43,60.96 ; D107.B4 387.81,60.96 ; SITE3.G1 248.81,181.33 ; SITE3.G1 247.85,181.33 ; SITE3.G1 248.33,180.85 ; SITE3.G1 248.33,181.81 ; 319.33,71.12 D302.B6 ; D302.B6 320.04,71.83 ; D302.B6 320.75,71.12 ; D302.B6 320.04,70.41 ; 345.44,60.15 D103.B16 ; D103.B16 345.44,61.77 ; D103.B16 346.25,60.96 ; D103.B16 344.63,60.96 ; D113.B14 314.96,328.47 ; D113.B14 314.15,327.66 ; D113.B14 314.96,326.85 ; D113.B14 315.77,327.66 ; D317.A13 191.21,83.82 ; D317.A13 190.5,84.53 ; D317.A13 190.5,83.11 ; D317.A13 189.79,83.82 ; 159.21,78.74 D118.B1 ; D118.B1 160.83,78.74 ; D118.B1 160.02,79.55 ; D118.B1 160.02,77.93 ; D107.B15 417.37,58.42 ; D107.B15 416.56,59.23 ; D107.B15 416.56,57.61 ; D107.B15 415.75,58.42 ; 307.34,37.29 D104.B1 ; D104.B1 306.53,38.1 ; D104.B1 308.15,38.1 ; D104.B1 307.34,38.91 ; 314.15,373.38 D115.A14 ; D115.A14 314.96,374.19 ; D115.A14 314.96,372.57 ; D115.A14 315.77,373.38 ; 309.88,372.57 D115.A16 ; D115.A16 310.69,373.38 ; D115.A16 309.88,374.19 ; D115.A16 309.07,373.38 ; D116.B4 340.36,389.43 ; D116.B4 341.17,388.62 ; D116.B4 339.55,388.62 ; D116.B4 340.36,387.81 ; 30.48,34.75 D128.A8 ; D128.A8 29.67,35.56 ; D128.A8 30.48,36.37 ; D128.A8 31.29,35.56 ; D231.A3 195.58,376.73 ; D231.A3 195.58,375.11 ; D231.A3 196.39,375.92 ; D231.A3 194.77,375.92 ; 319.23,373.38 D115.A12 ; D115.A12 320.04,372.57 ; D115.A12 320.85,373.38 ; D115.A12 320.04,374.19 ; 344.63,347.98 D114.B2 ; D114.B2 345.44,348.79 ; D114.B2 346.25,347.98 ; D114.B2 345.44,347.17 ; D103.B9 328.47,58.42 ; D103.B9 327.66,59.23 ; D103.B9 326.85,58.42 ; D103.B9 327.66,57.61 ; 14.43,55.88 D127.A2 ; D127.A2 15.24,55.07 ; D127.A2 16.05,55.88 ; D127.A2 15.24,56.69 ; D110.B9 402.13,350.52 ; D110.B9 401.32,349.71 ; D110.B9 401.32,351.33 ; D110.B9 400.51,350.52 ; D132.B13 117.65,38.1 ; D132.B13 116.84,37.29 ; D132.B13 116.84,38.91 ; D132.B13 116.03,38.1 ; 312.42,57.61 D103.B3 ; D103.B3 311.61,58.42 ; D103.B3 313.23,58.42 ; D103.B3 312.42,59.23 ; 395.43,355.6 D110.A11 ; D110.A11 397.05,355.6 ; D110.A11 396.24,354.79 ; D110.A11 396.24,356.41 ; 15.24,60.15 D127.B2 ; D127.B2 16.05,60.96 ; D127.B2 14.43,60.96 ; D127.B2 15.24,61.77 ; D131.B12 114.3,61.77 ; D131.B12 115.11,60.96 ; D131.B12 113.49,60.96 ; D131.B12 114.3,60.15 ; D125.A14 45.72,97.33 ; D125.A14 45.72,95.71 ; D125.A14 46.53,96.52 ; D125.A14 44.91,96.52 ; D116.B16 310.69,388.62 ; D116.B16 309.88,389.43 ; D116.B16 309.07,388.62 ; D116.B16 309.88,387.81 ; 192.33,71.12 D318.B14 ; D318.B14 193.75,71.12 ; D318.B14 193.04,71.83 ; D318.B14 193.04,70.41 ; 253.19,33.02 D124.A9 ; D124.A9 254,32.21 ; D124.A9 254,33.83 ; D124.A9 254.81,33.02 ; 340.36,65.33 D302.A14 ; D302.A14 340.36,66.75 ; D302.A14 339.65,66.04 ; D302.A14 341.07,66.04 ; 197.31,81.28 D118.B16 ; D118.B16 198.93,81.28 ; D118.B16 198.12,82.09 ; D118.B16 198.12,80.47 ; D124.A10 256.54,36.37 ; D124.A10 255.73,35.56 ; D124.A10 257.35,35.56 ; D124.A10 256.54,34.75 ; 413.31,86.36 D305.A14 ; D305.A14 414.02,85.65 ; D305.A14 414.02,87.07 ; D305.A14 414.73,86.36 ; 317.5,88.19 D301.B5 ; D301.B5 317.5,89.61 ; D301.B5 316.79,88.9 ; D301.B5 318.21,88.9 ; D113.A4 340.36,333.55 ; D113.A4 339.55,332.74 ; D113.A4 340.36,331.93 ; D113.A4 341.17,332.74 ; 327.66,370.03 D115.B9 ; D115.B9 328.47,370.84 ; D115.B9 326.85,370.84 ; D115.B9 327.66,371.65 ; 184.61,33.02 D120.A11 ; D120.A11 186.23,33.02 ; D120.A11 185.42,33.83 ; D120.A11 185.42,32.21 ; 170.18,88.19 D317.B5 ; D317.B5 170.18,89.61 ; D317.B5 170.89,88.9 ; D317.B5 169.47,88.9 ; D231.A9 181.15,375.92 ; D231.A9 180.34,375.11 ; D231.A9 180.34,376.73 ; D231.A9 179.53,375.92 ; D114.B5 337.82,351.33 ; D114.B5 337.82,349.71 ; D114.B5 338.63,350.52 ; D114.B5 337.01,350.52 ; 403.05,55.88 D107.A10 ; D107.A10 403.86,55.07 ; D107.A10 404.67,55.88 ; D107.A10 403.86,56.69 ; D305.B8 398.78,92.15 ; D305.B8 398.07,91.44 ; D305.B8 398.78,90.73 ; D305.B8 399.49,91.44 ; 161.75,55.88 D119.A2 ; D119.A2 162.56,56.69 ; D119.A2 163.37,55.88 ; D119.A2 162.56,55.07 ; 193.04,55.07 D119.A14 ; D119.A14 192.23,55.88 ; D119.A14 193.04,56.69 ; D119.A14 193.85,55.88 ; 176.99,81.28 D118.B8 ; D118.B8 177.8,82.09 ; D118.B8 177.8,80.47 ; D118.B8 178.61,81.28 ; D131.A14 120.19,55.88 ; D131.A14 119.38,56.69 ; D131.A14 119.38,55.07 ; D131.A14 118.57,55.88 ; 385.27,355.6 D110.A15 ; D110.A15 386.08,354.79 ; D110.A15 386.89,355.6 ; D110.A15 386.08,356.41 ; 166.83,55.88 D119.A4 ; D119.A4 168.45,55.88 ; D119.A4 167.64,55.07 ; D119.A4 167.64,56.69 ; D130.A2 88.9,77.01 ; D130.A2 89.71,76.2 ; D130.A2 88.09,76.2 ; D130.A2 88.9,75.39 ; 269.24,13.16 DPS3.A15 ; DPS3.A15 268.43,13.97 ; DPS3.A15 270.05,13.97 ; DPS3.A15 269.24,14.78 ; D112.B6 409.75,388.62 ; D112.B6 408.94,387.81 ; D112.B6 408.13,388.62 ; D112.B6 408.94,389.43 ; D318.B15 195.58,69.29 ; D318.B15 194.87,68.58 ; D318.B15 195.58,67.87 ; D318.B15 196.29,68.58 ; 110.95,53.34 D131.A11 ; D131.A11 111.76,54.15 ; D131.A11 112.57,53.34 ; D131.A11 111.76,52.53 ; 258.27,19.05 DPS3.C11 ; DPS3.C11 259.08,18.24 ; DPS3.C11 259.08,19.86 ; DPS3.C11 259.89,19.05 ; D126.A15 49.07,73.66 ; D126.A15 47.45,73.66 ; D126.A15 48.26,72.85 ; D126.A15 48.26,74.47 ; D124.A13 264.97,33.02 ; D124.A13 263.35,33.02 ; D124.A13 264.16,33.83 ; D124.A13 264.16,32.21 ; D103.A9 328.47,53.34 ; D103.A9 326.85,53.34 ; D103.A9 327.66,52.53 ; D103.A9 327.66,54.15 ; 251.43,242.35 SITE1.G15 ; SITE1.G15 251.43,243.31 ; SITE1.G15 250.95,242.83 ; SITE1.G15 251.91,242.83 ; 320.04,55.07 D103.A6 ; D103.A6 320.85,55.88 ; D103.A6 320.04,56.69 ; D103.A6 319.23,55.88 ; D111.B8 403.86,369.11 ; D111.B8 404.67,368.3 ; D111.B8 403.05,368.3 ; D111.B8 403.86,367.49 ; 40.64,100.79 D125.B12 ; D125.B12 40.64,102.41 ; D125.B12 41.45,101.6 ; D125.B12 39.83,101.6 ; 189.69,53.34 D119.A13 ; D119.A13 190.5,52.53 ; D119.A13 190.5,54.15 ; D119.A13 191.31,53.34 ; 199.85,386.08 D431.A1 ; D431.A1 200.66,386.89 ; D431.A1 200.66,385.27 ; D431.A1 201.47,386.08 ; D128.B3 17.78,38.91 ; D128.B3 17.78,37.29 ; D128.B3 16.97,38.1 ; D128.B3 18.59,38.1 ; 416.56,370.03 D111.B3 ; D111.B3 415.75,370.84 ; D111.B3 416.56,371.65 ; D111.B3 417.37,370.84 ; 11.89,73.66 D126.A1 ; D126.A1 12.7,74.47 ; D126.A1 13.51,73.66 ; D126.A1 12.7,72.85 ; D112.B16 383.54,389.43 ; D112.B16 383.54,387.81 ; D112.B16 382.73,388.62 ; D112.B16 384.35,388.62 ; D132.A13 116.84,33.83 ; D132.A13 116.84,32.21 ; D132.A13 116.03,33.02 ; D132.A13 117.65,33.02 ; 386.08,370.03 D111.B15 ; D111.B15 385.27,370.84 ; D111.B15 386.89,370.84 ; D111.B15 386.08,371.65 ; D301.A2 309.88,87.07 ; D301.A2 309.17,86.36 ; D301.A2 310.59,86.36 ; D301.A2 309.88,85.65 ; D305.B7 396.24,89.61 ; D305.B7 396.24,88.19 ; D305.B7 396.95,88.9 ; D305.B7 395.53,88.9 ; 199.85,375.92 D231.A1 ; D231.A1 200.66,375.11 ; D231.A1 200.66,376.73 ; D231.A1 201.47,375.92 ; 90.63,58.42 D131.B3 ; D131.B3 91.44,57.61 ; D131.B3 92.25,58.42 ; D131.B3 91.44,59.23 ; 175.26,37.29 D120.B7 ; D120.B7 176.07,38.1 ; D120.B7 175.26,38.91 ; D120.B7 174.45,38.1 ; SITE4.G8 329.33,188.41 ; SITE4.G8 329.81,187.93 ; SITE4.G8 329.33,187.45 ; SITE4.G8 328.85,187.93 ; 161.85,71.12 D318.B2 ; D318.B2 162.56,71.83 ; D318.B2 163.27,71.12 ; D318.B2 162.56,70.41 ; 419.1,60.15 D107.B16 ; D107.B16 419.91,60.96 ; D107.B16 419.1,61.77 ; D107.B16 418.29,60.96 ; D130.A1 86.36,74.47 ; D130.A1 85.55,73.66 ; D130.A1 87.17,73.66 ; D130.A1 86.36,72.85 ; D115.B6 336.09,368.3 ; D115.B6 334.47,368.3 ; D115.B6 335.28,367.49 ; D115.B6 335.28,369.11 ; 401.32,83.11 D305.A9 ; D305.A9 400.61,83.82 ; D305.A9 401.32,84.53 ; D305.A9 402.03,83.82 ; 335.28,347.17 D114.B6 ; D114.B6 336.09,347.98 ; D114.B6 334.47,347.98 ; D114.B6 335.28,348.79 ; DPS1.A05 391.16,14.78 ; DPS1.A05 390.35,13.97 ; DPS1.A05 391.16,13.16 ; DPS1.A05 391.97,13.97 ; 248.92,32.21 D124.A7 ; D124.A7 248.92,33.83 ; D124.A7 248.11,33.02 ; D124.A7 249.73,33.02 ; CSDPS229.B12 172.72,333.55 ; CSDPS229.B12 173.53,332.74 ; CSDPS229.B12 172.72,331.93 ; CSDPS229.B12 171.91,332.74 ; 270.97,332.74 CSDPS225.B2 ; CSDPS225.B2 272.59,332.74 ; CSDPS225.B2 271.78,331.93 ; CSDPS225.B2 271.78,333.55 ; 324.31,327.66 D113.B10 ; D113.B10 325.12,328.47 ; D113.B10 325.12,326.85 ; D113.B10 325.93,327.66 ; 414.02,387.81 D112.B4 ; D112.B4 414.83,388.62 ; D112.B4 413.21,388.62 ; D112.B4 414.02,389.43 ; 93.17,76.2 D130.A4 ; D130.A4 93.98,75.39 ; D130.A4 93.98,77.01 ; D130.A4 94.79,76.2 ; S2_I2C.4 505.89,203.45 ; S2_I2C.4 504.01,203.45 ; S2_I2C.4 504.95,204.39 ; S2_I2C.4 504.95,202.51 ; DPS1.C01 381.81,19.05 ; DPS1.C01 381,19.86 ; DPS1.C01 380.19,19.05 ; DPS1.C01 381,18.24 ; D119.A1 160.02,54.15 ; D119.A1 159.21,53.34 ; D119.A1 160.02,52.53 ; D119.A1 160.83,53.34 ; D126.B15 49.07,78.74 ; D126.B15 48.26,79.55 ; D126.B15 48.26,77.93 ; D126.B15 47.45,78.74 ; 383.54,90.73 D305.B2 ; D305.B2 382.83,91.44 ; D305.B2 384.25,91.44 ; D305.B2 383.54,92.15 ; 329.03,242.35 SITE2.G13 ; SITE2.G13 329.03,243.31 ; SITE2.G13 328.55,242.83 ; SITE2.G13 329.51,242.83 ; 330.2,85.65 D301.A10 ; D301.A10 330.2,87.07 ; D301.A10 330.91,86.36 ; D301.A10 329.49,86.36 ; D126.A2 16.05,76.2 ; D126.A2 15.24,75.39 ; D126.A2 14.43,76.2 ; D126.A2 15.24,77.01 ; 20.32,100.79 D125.B4 ; D125.B4 20.32,102.41 ; D125.B4 21.13,101.6 ; D125.B4 19.51,101.6 ; D107.A6 393.7,56.69 ; D107.A6 394.51,55.88 ; D107.A6 393.7,55.07 ; D107.A6 392.89,55.88 ; D127.B8 30.48,61.77 ; D127.B8 29.67,60.96 ; D127.B8 31.29,60.96 ; D127.B8 30.48,60.15 ; D120.A15 195.58,33.83 ; D120.A15 195.58,32.21 ; D120.A15 196.39,33.02 ; D120.A15 194.77,33.02 ; 329.75,186.43 SITE4.G18 ; SITE4.G18 330.71,186.43 ; SITE4.G18 330.23,185.95 ; SITE4.G18 330.23,186.91 ; D126.B9 33.83,78.74 ; D126.B9 33.02,77.93 ; D126.B9 32.21,78.74 ; D126.B9 33.02,79.55 ; D123.A4 241.3,56.69 ; D123.A4 240.49,55.88 ; D123.A4 242.11,55.88 ; D123.A4 241.3,55.07 ; D114.B1 347.98,351.33 ; D114.B1 348.79,350.52 ; D114.B1 347.17,350.52 ; D114.B1 347.98,349.71 ; 392.89,40.64 D108.B6 ; D108.B6 393.7,41.45 ; D108.B6 394.51,40.64 ; D108.B6 393.7,39.83 ; 169.47,68.58 D318.B5 ; D318.B5 170.89,68.58 ; D318.B5 170.18,69.29 ; D318.B5 170.18,67.87 ; D318.A13 190.5,64.21 ; D318.A13 190.5,62.79 ; D318.A13 189.79,63.5 ; D318.A13 191.21,63.5 ; 198.12,65.33 D318.A16 ; D318.A16 197.41,66.04 ; D318.A16 198.12,66.75 ; D318.A16 198.83,66.04 ; 180.34,77.93 D118.B9 ; D118.B9 180.34,79.55 ; D118.B9 181.15,78.74 ; D118.B9 179.53,78.74 ; D107.A13 412.29,53.34 ; D107.A13 411.48,52.53 ; D107.A13 411.48,54.15 ; D107.A13 410.67,53.34 ; D110.B12 393.7,348.79 ; D110.B12 394.51,347.98 ; D110.B12 393.7,347.17 ; D110.B12 392.89,347.98 ; CSDPS425.C13 244.65,340.36 ; CSDPS425.C13 243.03,340.36 ; CSDPS425.C13 243.84,341.17 ; CSDPS425.C13 243.84,339.55 ; 334.57,91.44 D301.B12 ; D301.B12 335.28,90.73 ; D301.B12 335.28,92.15 ; D301.B12 335.99,91.44 ; 121.11,93.98 D129.A15 ; D129.A15 121.92,93.17 ; D129.A15 122.73,93.98 ; D129.A15 121.92,94.79 ; 248.85,247.93 SITE1.G8 ; SITE1.G8 249.33,248.41 ; SITE1.G8 249.81,247.93 ; SITE1.G8 249.33,247.45 ; D128.B12 40.64,41.45 ; D128.B12 40.64,39.83 ; D128.B12 39.83,40.64 ; D128.B12 41.45,40.64 ; 259.08,329.39 CSDPS225.C7 ; CSDPS225.C7 258.27,330.2 ; CSDPS225.C7 259.89,330.2 ; CSDPS225.C7 259.08,331.01 ; 382.73,55.88 D107.A2 ; D107.A2 383.54,56.69 ; D107.A2 384.35,55.88 ; D107.A2 383.54,55.07 ; 165.1,414.48 DPS8.A15 ; DPS8.A15 165.91,415.29 ; DPS8.A15 164.29,415.29 ; DPS8.A15 165.1,416.1 ; D129.B15 122.73,99.06 ; D129.B15 121.92,99.87 ; D129.B15 121.11,99.06 ; D129.B15 121.92,98.25 ; 248.55,246.43 SITE1.G17 ; SITE1.G17 249.51,246.43 ; SITE1.G17 249.03,245.95 ; SITE1.G17 249.03,246.91 ; D431.B14 167.64,379.27 ; D431.B14 168.45,378.46 ; D431.B14 166.83,378.46 ; D431.B14 167.64,377.65 ; D131.A7 102.41,53.34 ; D131.A7 101.6,54.15 ; D131.A7 100.79,53.34 ; D131.A7 101.6,52.53 ; 386.08,67.87 D306.B3 ; D306.B3 386.08,69.29 ; D306.B3 386.79,68.58 ; D306.B3 385.37,68.58 ; 252.15,242.83 SITE1.G16 ; SITE1.G16 252.63,243.31 ; SITE1.G16 252.63,242.35 ; SITE1.G16 253.11,242.83 ; 413.21,353.06 D110.A4 ; D110.A4 414.02,352.25 ; D110.A4 414.83,353.06 ; D110.A4 414.02,353.87 ; D114.A13 318.31,355.6 ; D114.A13 317.5,354.79 ; D114.A13 316.69,355.6 ; D114.A13 317.5,356.41 ; 332.15,246.43 SITE2.G20 ; SITE2.G20 332.63,245.95 ; SITE2.G20 332.63,246.91 ; SITE2.G20 333.11,246.43 ; D110.A2 419.1,353.87 ; D110.A2 419.91,353.06 ; D110.A2 418.29,353.06 ; D110.A2 419.1,352.25 ; 421.64,390.35 D112.B1 ; D112.B1 420.83,391.16 ; D112.B1 421.64,391.97 ; D112.B1 422.45,391.16 ; D322.B6 247.09,71.12 ; D322.B6 245.67,71.12 ; D322.B6 246.38,71.83 ; D322.B6 246.38,70.41 ; 179.53,330.2 CSDPS229.C9 ; CSDPS229.C9 181.15,330.2 ; CSDPS229.C9 180.34,329.39 ; CSDPS229.C9 180.34,331.01 ; D107.A12 409.75,55.88 ; D107.A12 408.94,56.69 ; D107.A12 408.13,55.88 ; D107.A12 408.94,55.07 ; SITE4.G4 331.33,181.81 ; SITE4.G4 331.33,180.85 ; SITE4.G4 331.81,181.33 ; SITE4.G4 330.85,181.33 ; 400.51,38.1 D108.B9 ; D108.B9 402.13,38.1 ; D108.B9 401.32,38.91 ; D108.B9 401.32,37.29 ; 331.93,391.16 D116.B7 ; D116.B7 333.55,391.16 ; D116.B7 332.74,391.97 ; D116.B7 332.74,390.35 ; D132.B11 111.76,38.91 ; D132.B11 111.76,37.29 ; D132.B11 112.57,38.1 ; D132.B11 110.95,38.1 ; D122.B14 267.51,81.28 ; D122.B14 266.7,82.09 ; D122.B14 266.7,80.47 ; D122.B14 265.89,81.28 ; 39.83,55.88 D127.A12 ; D127.A12 40.64,55.07 ; D127.A12 41.45,55.88 ; D127.A12 40.64,56.69 ; D111.A3 417.37,375.92 ; D111.A3 415.75,375.92 ; D111.A3 416.56,376.73 ; D111.A3 416.56,375.11 ; 418.29,373.38 D111.A2 ; D111.A2 419.1,372.57 ; D111.A2 419.91,373.38 ; D111.A2 419.1,374.19 ; D108.A9 401.32,33.83 ; D108.A9 402.13,33.02 ; D108.A9 400.51,33.02 ; D108.A9 401.32,32.21 ; 162.56,85.65 D317.A2 ; D317.A2 161.85,86.36 ; D317.A2 162.56,87.07 ; D317.A2 163.27,86.36 ; 124.46,100.79 D129.B16 ; D129.B16 125.27,101.6 ; D129.B16 123.65,101.6 ; D129.B16 124.46,102.41 ; 22.86,57.61 D127.B5 ; D127.B5 22.86,59.23 ; D127.B5 23.67,58.42 ; D127.B5 22.05,58.42 ; D115.B5 338.63,370.84 ; D115.B5 337.82,371.65 ; D115.B5 337.82,370.03 ; D115.B5 337.01,370.84 ; 331.85,181.33 SITE4.G5 ; SITE4.G5 332.33,181.81 ; SITE4.G5 332.33,180.85 ; SITE4.G5 332.81,181.33 ; D103.A4 315.77,55.88 ; D103.A4 314.15,55.88 ; D103.A4 314.96,55.07 ; D103.A4 314.96,56.69 ; D108.B15 416.56,38.91 ; D108.B15 416.56,37.29 ; D108.B15 417.37,38.1 ; D108.B15 415.75,38.1 ; 403.86,80.47 D106.B10 ; D106.B10 403.05,81.28 ; D106.B10 404.67,81.28 ; D106.B10 403.86,82.09 ; D109.A2 419.91,332.74 ; D109.A2 419.1,331.93 ; D109.A2 418.29,332.74 ; D109.A2 419.1,333.55 ; D128.B10 35.56,41.45 ; D128.B10 35.56,39.83 ; D128.B10 36.37,40.64 ; D128.B10 34.75,40.64 ; D132.B10 110.03,40.64 ; D132.B10 109.22,41.45 ; D132.B10 109.22,39.83 ; D132.B10 108.41,40.64 ; 324.41,71.12 D302.B8 ; D302.B8 325.12,70.41 ; D302.B8 325.12,71.83 ; D302.B8 325.83,71.12 ; D113.A15 312.42,336.09 ; D113.A15 312.42,334.47 ; D113.A15 311.61,335.28 ; D113.A15 313.23,335.28 ; D102.A16 346.25,76.2 ; D102.A16 345.44,77.01 ; D102.A16 345.44,75.39 ; D102.A16 344.63,76.2 ; D132.A6 99.06,36.37 ; D132.A6 99.87,35.56 ; D132.A6 99.06,34.75 ; D132.A6 98.25,35.56 ; 32.21,38.1 D128.B9 ; D128.B9 33.83,38.1 ; D128.B9 33.02,38.91 ; D128.B9 33.02,37.29 ; 319.23,332.74 D113.A12 ; D113.A12 320.85,332.74 ; D113.A12 320.04,331.93 ; D113.A12 320.04,333.55 ; 179.53,53.34 D119.A9 ; D119.A9 180.34,52.53 ; D119.A9 181.15,53.34 ; D119.A9 180.34,54.15 ; D115.A2 346.25,373.38 ; D115.A2 345.44,374.19 ; D115.A2 345.44,372.57 ; D115.A2 344.63,373.38 ; 390.45,68.58 D306.B5 ; D306.B5 391.87,68.58 ; D306.B5 391.16,67.87 ; D306.B5 391.16,69.29 ; D115.A9 327.66,376.73 ; D115.A9 328.47,375.92 ; D115.A9 327.66,375.11 ; D115.A9 326.85,375.92 ; D305.B16 419.1,92.15 ; D305.B16 419.81,91.44 ; D305.B16 419.1,90.73 ; D305.B16 418.39,91.44 ; 331.93,335.28 D113.A7 ; D113.A7 332.74,336.09 ; D113.A7 333.55,335.28 ; D113.A7 332.74,334.47 ; 414.02,372.57 D111.A4 ; D111.A4 413.21,373.38 ; D111.A4 414.83,373.38 ; D111.A4 414.02,374.19 ; D123.A10 256.54,56.69 ; D123.A10 255.73,55.88 ; D123.A10 256.54,55.07 ; D123.A10 257.35,55.88 ; 330.33,187.45 SITE4.G9 ; SITE4.G9 330.33,188.41 ; SITE4.G9 330.81,187.93 ; SITE4.G9 329.85,187.93 ; D118.B4 168.45,81.28 ; D118.B4 167.64,82.09 ; D118.B4 167.64,80.47 ; D118.B4 166.83,81.28 ; 261.62,90.73 D321.B12 ; D321.B12 261.62,92.15 ; D321.B12 262.33,91.44 ; D321.B12 260.91,91.44 ; D120.B11 185.42,38.91 ; D120.B11 184.61,38.1 ; D120.B11 186.23,38.1 ; D120.B11 185.42,37.29 ; 403.86,326.85 D109.B8 ; D109.B8 404.67,327.66 ; D109.B8 403.05,327.66 ; D109.B8 403.86,328.47 ; SITE3.G18 250.23,186.91 ; SITE3.G18 249.75,186.43 ; SITE3.G18 250.23,185.95 ; SITE3.G18 250.71,186.43 ; D114.A5 338.63,355.6 ; D114.A5 337.82,356.41 ; D114.A5 337.01,355.6 ; D114.A5 337.82,354.79 ; D106.B9 402.13,78.74 ; D106.B9 400.51,78.74 ; D106.B9 401.32,79.55 ; D106.B9 401.32,77.93 ; D322.A9 254.71,63.5 ; D322.A9 254,64.21 ; D322.A9 253.29,63.5 ; D322.A9 254,62.79 ; D110.A7 407.21,355.6 ; D110.A7 406.4,354.79 ; D110.A7 406.4,356.41 ; D110.A7 405.59,355.6 ; D124.B6 246.38,41.45 ; D124.B6 247.19,40.64 ; D124.B6 245.57,40.64 ; D124.B6 246.38,39.83 ; 390.35,375.92 D111.A13 ; D111.A13 391.97,375.92 ; D111.A13 391.16,376.73 ; D111.A13 391.16,375.11 ; 312.42,409.4 DPS2.C15 ; DPS2.C15 312.42,411.02 ; DPS2.C15 313.23,410.21 ; DPS2.C15 311.61,410.21 ; 340.36,326.85 D113.B4 ; D113.B4 340.36,328.47 ; D113.B4 341.17,327.66 ; D113.B4 339.55,327.66 ; 251.46,70.41 D322.B8 ; D322.B8 251.46,71.83 ; D322.B8 252.17,71.12 ; D322.B8 250.75,71.12 ; D103.A11 333.55,53.34 ; D103.A11 331.93,53.34 ; D103.A11 332.74,54.15 ; D103.A11 332.74,52.53 ; 232.87,19.05 DPS3.C01 ; DPS3.C01 233.68,19.86 ; DPS3.C01 233.68,18.24 ; DPS3.C01 234.49,19.05 ; 238.76,62.79 D322.A3 ; D322.A3 238.76,64.21 ; D322.A3 239.47,63.5 ; D322.A3 238.05,63.5 ; 314.96,34.75 D104.A4 ; D104.A4 314.15,35.56 ; D104.A4 315.77,35.56 ; D104.A4 314.96,36.37 ; 194.87,88.9 D317.B15 ; D317.B15 196.29,88.9 ; D317.B15 195.58,89.61 ; D317.B15 195.58,88.19 ; D118.A10 182.88,77.01 ; D118.A10 182.88,75.39 ; D118.A10 183.69,76.2 ; D118.A10 182.07,76.2 ; D119.B3 165.1,59.23 ; D119.B3 164.29,58.42 ; D119.B3 165.1,57.61 ; D119.B3 165.91,58.42 ; D113.A3 343.71,335.28 ; D113.A3 342.9,334.47 ; D113.A3 342.9,336.09 ; D113.A3 342.09,335.28 ; D124.A4 241.3,36.37 ; D124.A4 241.3,34.75 ; D124.A4 242.11,35.56 ; D124.A4 240.49,35.56 ; 169.37,370.84 D231.B13 ; D231.B13 170.99,370.84 ; D231.B13 170.18,370.03 ; D231.B13 170.18,371.65 ; 166.83,368.3 D231.B14 ; D231.B14 167.64,369.11 ; D231.B14 168.45,368.3 ; D231.B14 167.64,367.49 ; 27.94,32.21 D128.A7 ; D128.A7 27.13,33.02 ; D128.A7 28.75,33.02 ; D128.A7 27.94,33.83 ; 395.43,73.66 D106.A7 ; D106.A7 396.24,72.85 ; D106.A7 396.24,74.47 ; D106.A7 397.05,73.66 ; 184.61,78.74 D118.B11 ; D118.B11 185.42,79.55 ; D118.B11 185.42,77.93 ; D118.B11 186.23,78.74 ; D106.B15 416.56,79.55 ; D106.B15 416.56,77.93 ; D106.B15 417.37,78.74 ; D106.B15 415.75,78.74 ; 232.87,13.97 DPS3.A01 ; DPS3.A01 233.68,13.16 ; DPS3.A01 234.49,13.97 ; DPS3.A01 233.68,14.78 ; D123.A7 249.73,53.34 ; D123.A7 248.92,54.15 ; D123.A7 248.11,53.34 ; D123.A7 248.92,52.53 ; 382.83,71.12 D306.B2 ; D306.B2 384.25,71.12 ; D306.B2 383.54,70.41 ; D306.B2 383.54,71.83 ; D231.A16 163.37,373.38 ; D231.A16 162.56,374.19 ; D231.A16 162.56,372.57 ; D231.A16 161.75,373.38 ; 319.23,388.62 D116.B12 ; D116.B12 320.04,389.43 ; D116.B12 320.85,388.62 ; D116.B12 320.04,387.81 ; D431.A17 160.83,386.08 ; D431.A17 160.02,386.89 ; D431.A17 159.21,386.08 ; D431.A17 160.02,385.27 ; 189.69,78.74 D118.B13 ; D118.B13 191.31,78.74 ; D118.B13 190.5,77.93 ; D118.B13 190.5,79.55 ; 420.83,330.2 D109.B1 ; D109.B1 421.64,329.39 ; D109.B1 421.64,331.01 ; D109.B1 422.45,330.2 ; 50.8,100.79 D125.B16 ; D125.B16 49.99,101.6 ; D125.B16 51.61,101.6 ; D125.B16 50.8,102.41 ; D431.A5 191.31,386.08 ; D431.A5 190.5,385.27 ; D431.A5 189.69,386.08 ; D431.A5 190.5,386.89 ; D305.A15 416.56,84.53 ; D305.A15 416.56,83.11 ; D305.A15 415.85,83.82 ; D305.A15 417.27,83.82 ; D103.B10 331.01,60.96 ; D103.B10 330.2,61.77 ; D103.B10 330.2,60.15 ; D103.B10 329.39,60.96 ; D132.B5 97.33,38.1 ; D132.B5 96.52,37.29 ; D132.B5 95.71,38.1 ; D132.B5 96.52,38.91 ; 253.29,83.82 D321.A9 ; D321.A9 254,84.53 ; D321.A9 254.71,83.82 ; D321.A9 254,83.11 ; 184.61,330.2 CSDPS229.C7 ; CSDPS229.C7 185.42,331.01 ; CSDPS229.C7 186.23,330.2 ; CSDPS229.C7 185.42,329.39 ; D124.B4 242.11,40.64 ; D124.B4 241.3,39.83 ; D124.B4 241.3,41.45 ; D124.B4 240.49,40.64 ; 312.42,37.29 D104.B3 ; D104.B3 313.23,38.1 ; D104.B3 311.61,38.1 ; D104.B3 312.42,38.91 ; 177.09,86.36 D317.A8 ; D317.A8 178.51,86.36 ; D317.A8 177.8,85.65 ; D317.A8 177.8,87.07 ; D120.A4 168.45,35.56 ; D120.A4 166.83,35.56 ; D120.A4 167.64,36.37 ; D120.A4 167.64,34.75 ; D111.A8 404.67,373.38 ; D111.A8 403.05,373.38 ; D111.A8 403.86,372.57 ; D111.A8 403.86,374.19 ; 408.94,326.85 D109.B6 ; D109.B6 408.13,327.66 ; D109.B6 409.75,327.66 ; D109.B6 408.94,328.47 ; 159.31,63.5 D318.A1 ; D318.A1 160.02,62.79 ; D318.A1 160.02,64.21 ; D318.A1 160.73,63.5 ; 20.32,75.39 D126.A4 ; D126.A4 20.32,77.01 ; D126.A4 21.13,76.2 ; D126.A4 19.51,76.2 ; 179.53,58.42 D119.B9 ; D119.B9 180.34,59.23 ; D119.B9 180.34,57.61 ; D119.B9 181.15,58.42 ; 340.36,80.47 D102.B14 ; D102.B14 341.17,81.28 ; D102.B14 340.36,82.09 ; D102.B14 339.55,81.28 ; DPS2.A01 347.98,416.1 ; DPS2.A01 347.98,414.48 ; DPS2.A01 348.79,415.29 ; DPS2.A01 347.17,415.29 ; 264.16,339.55 CSDPS425.C5 ; CSDPS425.C5 263.35,340.36 ; CSDPS425.C5 264.16,341.17 ; CSDPS425.C5 264.97,340.36 ; D321.B11 259.08,89.61 ; D321.B11 258.37,88.9 ; D321.B11 259.79,88.9 ; D321.B11 259.08,88.19 ; 324.41,66.04 D302.A8 ; D302.A8 325.12,66.75 ; D302.A8 325.83,66.04 ; D302.A8 325.12,65.33 ; 250.33,240.85 SITE1.G3 ; SITE1.G3 249.85,241.33 ; SITE1.G3 250.33,241.81 ; SITE1.G3 250.81,241.33 ; 32.21,33.02 D128.A9 ; D128.A9 33.02,33.83 ; D128.A9 33.02,32.21 ; D128.A9 33.83,33.02 ; D129.B13 116.84,99.87 ; D129.B13 117.65,99.06 ; D129.B13 116.03,99.06 ; D129.B13 116.84,98.25 ; D125.A16 51.61,96.52 ; D125.A16 49.99,96.52 ; D125.A16 50.8,95.71 ; D125.A16 50.8,97.33 ; D113.B7 332.74,331.01 ; D113.B7 332.74,329.39 ; D113.B7 333.55,330.2 ; D113.B7 331.93,330.2 ; 193.04,372.57 D231.A4 ; D231.A4 193.85,373.38 ; D231.A4 193.04,374.19 ; D231.A4 192.23,373.38 ; 268.53,63.5 D322.A15 ; D322.A15 269.24,64.21 ; D322.A15 269.95,63.5 ; D322.A15 269.24,62.79 ; 189.69,58.42 D119.B13 ; D119.B13 191.31,58.42 ; D119.B13 190.5,59.23 ; D119.B13 190.5,57.61 ; D317.B8 177.8,92.15 ; D317.B8 178.51,91.44 ; D317.B8 177.09,91.44 ; D317.B8 177.8,90.73 ; 264.16,72.85 D122.A13 ; D122.A13 264.16,74.47 ; D122.A13 263.35,73.66 ; D122.A13 264.97,73.66 ; D126.B12 41.45,81.28 ; D126.B12 40.64,82.09 ; D126.B12 40.64,80.47 ; D126.B12 39.83,81.28 ; 20.32,39.83 D128.B4 ; D128.B4 20.32,41.45 ; D128.B4 21.13,40.64 ; D128.B4 19.51,40.64 ; 383.54,347.17 D110.B16 ; D110.B16 382.73,347.98 ; D110.B16 384.35,347.98 ; D110.B16 383.54,348.79 ; 195.58,370.03 D231.B3 ; D231.B3 194.77,370.84 ; D231.B3 195.58,371.65 ; D231.B3 196.39,370.84 ; 334.47,373.38 D115.A6 ; D115.A6 336.09,373.38 ; D115.A6 335.28,372.57 ; D115.A6 335.28,374.19 ; 38.1,52.53 D127.A11 ; D127.A11 38.91,53.34 ; D127.A11 37.29,53.34 ; D127.A11 38.1,54.15 ; 250.75,66.04 D322.A8 ; D322.A8 252.17,66.04 ; D322.A8 251.46,65.33 ; D322.A8 251.46,66.75 ; D322.B12 262.33,71.12 ; D322.B12 261.62,70.41 ; D322.B12 260.91,71.12 ; D322.B12 261.62,71.83 ; 47.45,99.06 D125.B15 ; D125.B15 48.26,99.87 ; D125.B15 48.26,98.25 ; D125.B15 49.07,99.06 ; 383.54,352.25 D110.A16 ; D110.A16 383.54,353.87 ; D110.A16 384.35,353.06 ; D110.A16 382.73,353.06 ; 170.18,57.61 D119.B5 ; D119.B5 169.37,58.42 ; D119.B5 170.99,58.42 ; D119.B5 170.18,59.23 ; D115.B1 348.79,370.84 ; D115.B1 347.17,370.84 ; D115.B1 347.98,370.03 ; D115.B1 347.98,371.65 ; D301.B15 342.9,89.61 ; D301.B15 343.61,88.9 ; D301.B15 342.19,88.9 ; D301.B15 342.9,88.19 ; D114.B16 310.69,347.98 ; D114.B16 309.88,348.79 ; D114.B16 309.07,347.98 ; D114.B16 309.88,347.17 ; D322.B5 244.55,68.58 ; D322.B5 243.13,68.58 ; D322.B5 243.84,69.29 ; D322.B5 243.84,67.87 ; D305.B9 402.03,88.9 ; D305.B9 401.32,88.19 ; D305.B9 400.61,88.9 ; D305.B9 401.32,89.61 ; 385.37,83.82 D305.A3 ; D305.A3 386.79,83.82 ; D305.A3 386.08,83.11 ; D305.A3 386.08,84.53 ; D120.B14 193.04,41.45 ; D120.B14 193.85,40.64 ; D120.B14 193.04,39.83 ; D120.B14 192.23,40.64 ; SITE3.G2 249.33,181.81 ; SITE3.G2 249.33,180.85 ; SITE3.G2 248.85,181.33 ; SITE3.G2 249.81,181.33 ; D112.A15 386.08,397.05 ; D112.A15 386.08,395.43 ; D112.A15 385.27,396.24 ; D112.A15 386.89,396.24 ; D106.B5 391.16,79.55 ; D106.B5 391.97,78.74 ; D106.B5 391.16,77.93 ; D106.B5 390.35,78.74 ; D106.B13 412.29,78.74 ; D106.B13 411.48,79.55 ; D106.B13 410.67,78.74 ; D106.B13 411.48,77.93 ; 43.18,37.29 D128.B13 ; D128.B13 43.99,38.1 ; D128.B13 43.18,38.91 ; D128.B13 42.37,38.1 ; 403.15,86.36 D305.A10 ; D305.A10 404.57,86.36 ; D305.A10 403.86,87.07 ; D305.A10 403.86,85.65 ; 241.3,70.41 D322.B4 ; D322.B4 242.01,71.12 ; D322.B4 240.59,71.12 ; D322.B4 241.3,71.83 ; 344.73,71.12 D302.B16 ; D302.B16 346.15,71.12 ; D302.B16 345.44,70.41 ; D302.B16 345.44,71.83 ; 182.07,60.96 D119.B10 ; D119.B10 182.88,61.77 ; D119.B10 183.69,60.96 ; D119.B10 182.88,60.15 ; CSDPS425.B10 251.46,343.71 ; CSDPS425.B10 252.27,342.9 ; CSDPS425.B10 250.65,342.9 ; CSDPS425.B10 251.46,342.09 ; D119.B8 177.8,61.77 ; D119.B8 176.99,60.96 ; D119.B8 177.8,60.15 ; D119.B8 178.61,60.96 ; 324.31,332.74 D113.A10 ; D113.A10 325.93,332.74 ; D113.A10 325.12,331.93 ; D113.A10 325.12,333.55 ; 248.92,329.39 CSDPS225.C11 ; CSDPS225.C11 248.92,331.01 ; CSDPS225.C11 248.11,330.2 ; CSDPS225.C11 249.73,330.2 ; D305.A16 419.1,87.07 ; D305.A16 419.81,86.36 ; D305.A16 418.39,86.36 ; D305.A16 419.1,85.65 ; 124.46,34.75 D132.A16 ; D132.A16 124.46,36.37 ; D132.A16 125.27,35.56 ; D132.A16 123.65,35.56 ; 339.55,40.64 D104.B14 ; D104.B14 340.36,39.83 ; D104.B14 340.36,41.45 ; D104.B14 341.17,40.64 ; D130.B10 110.03,81.28 ; D130.B10 109.22,80.47 ; D130.B10 108.41,81.28 ; D130.B10 109.22,82.09 ; D108.B10 403.86,41.45 ; D108.B10 403.86,39.83 ; D108.B10 404.67,40.64 ; D108.B10 403.05,40.64 ; 414.02,75.39 D106.A14 ; D106.A14 413.21,76.2 ; D106.A14 414.83,76.2 ; D106.A14 414.02,77.01 ; D322.B11 259.08,69.29 ; D322.B11 258.37,68.58 ; D322.B11 259.79,68.58 ; D322.B11 259.08,67.87 ; 109.22,75.39 D130.A10 ; D130.A10 108.41,76.2 ; D130.A10 110.03,76.2 ; D130.A10 109.22,77.01 ; 175.26,409.4 DPS8.C11 ; DPS8.C11 176.07,410.21 ; DPS8.C11 175.26,411.02 ; DPS8.C11 174.45,410.21 ; 322.58,375.11 D115.A11 ; D115.A11 321.77,375.92 ; D115.A11 323.39,375.92 ; D115.A11 322.58,376.73 ; 249.03,242.35 SITE1.G13 ; SITE1.G13 249.51,242.83 ; SITE1.G13 248.55,242.83 ; SITE1.G13 249.03,243.31 ; 385.27,391.16 D112.B15 ; D112.B15 386.08,391.97 ; D112.B15 386.08,390.35 ; D112.B15 386.89,391.16 ; 238.05,83.82 D321.A3 ; D321.A3 239.47,83.82 ; D321.A3 238.76,83.11 ; D321.A3 238.76,84.53 ; D107.B2 383.54,61.77 ; D107.B2 383.54,60.15 ; D107.B2 382.73,60.96 ; D107.B2 384.35,60.96 ; 182.07,342.9 CSDPS429.B8 ; CSDPS429.B8 182.88,343.71 ; CSDPS429.B8 182.88,342.09 ; CSDPS429.B8 183.69,342.9 ; 113.49,35.56 D132.A12 ; D132.A12 114.3,36.37 ; D132.A12 114.3,34.75 ; D132.A12 115.11,35.56 ; 414.02,347.17 D110.B4 ; D110.B4 414.83,347.98 ; D110.B4 414.02,348.79 ; D110.B4 413.21,347.98 ; D123.A15 269.24,54.15 ; D123.A15 270.05,53.34 ; D123.A15 269.24,52.53 ; D123.A15 268.43,53.34 ; 91.44,32.21 D132.A3 ; D132.A3 91.44,33.83 ; D132.A3 90.63,33.02 ; D132.A3 92.25,33.02 ; SITE1.G1 248.81,241.33 ; SITE1.G1 248.33,240.85 ; SITE1.G1 248.33,241.81 ; SITE1.G1 247.85,241.33 ; D113.B13 318.31,330.2 ; D113.B13 317.5,331.01 ; D113.B13 317.5,329.39 ; D113.B13 316.69,330.2 ; D132.B6 99.87,40.64 ; D132.B6 98.25,40.64 ; D132.B6 99.06,39.83 ; D132.B6 99.06,41.45 ; 265.99,86.36 D321.A14 ; D321.A14 267.41,86.36 ; D321.A14 266.7,85.65 ; D321.A14 266.7,87.07 ; D301.A6 320.04,87.07 ; D301.A6 320.04,85.65 ; D301.A6 320.75,86.36 ; D301.A6 319.33,86.36 ; D231.B4 193.04,369.11 ; D231.B4 192.23,368.3 ; D231.B4 193.85,368.3 ; D231.B4 193.04,367.49 ; 194.77,53.34 D119.A15 ; D119.A15 196.39,53.34 ; D119.A15 195.58,52.53 ; D119.A15 195.58,54.15 ; D231.B5 190.5,371.65 ; D231.B5 189.69,370.84 ; D231.B5 190.5,370.03 ; D231.B5 191.31,370.84 ; D127.B9 33.02,59.23 ; D127.B9 33.02,57.61 ; D127.B9 32.21,58.42 ; D127.B9 33.83,58.42 ; 321.77,370.84 D115.B11 ; D115.B11 322.58,370.03 ; D115.B11 323.39,370.84 ; D115.B11 322.58,371.65 ; D123.B5 243.84,59.23 ; D123.B5 244.65,58.42 ; D123.B5 243.84,57.61 ; D123.B5 243.03,58.42 ; SITE2.G14 330.23,243.31 ; SITE2.G14 330.23,242.35 ; SITE2.G14 329.75,242.83 ; SITE2.G14 330.71,242.83 ; 248.92,72.85 D122.A7 ; D122.A7 248.92,74.47 ; D122.A7 248.11,73.66 ; D122.A7 249.73,73.66 ; 124.46,39.83 D132.B16 ; D132.B16 125.27,40.64 ; D132.B16 123.65,40.64 ; D132.B16 124.46,41.45 ; D129.A7 102.41,93.98 ; D129.A7 100.79,93.98 ; D129.A7 101.6,93.17 ; D129.A7 101.6,94.79 ; 198.12,75.39 D118.A16 ; D118.A16 197.31,76.2 ; D118.A16 198.93,76.2 ; D118.A16 198.12,77.01 ; 395.53,68.58 D306.B7 ; D306.B7 396.24,69.29 ; D306.B7 396.24,67.87 ; D306.B7 396.95,68.58 ; 240.59,66.04 D322.A4 ; D322.A4 241.3,66.75 ; D322.A4 241.3,65.33 ; D322.A4 242.01,66.04 ; 396.24,83.11 D305.A7 ; D305.A7 396.95,83.82 ; D305.A7 395.53,83.82 ; D305.A7 396.24,84.53 ; D318.A15 196.29,63.5 ; D318.A15 194.87,63.5 ; D318.A15 195.58,64.21 ; D318.A15 195.58,62.79 ; CSDPS229.B2 198.12,333.55 ; CSDPS229.B2 198.12,331.93 ; CSDPS229.B2 198.93,332.74 ; CSDPS229.B2 197.31,332.74 ; 342.09,330.2 D113.B3 ; D113.B3 342.9,329.39 ; D113.B3 342.9,331.01 ; D113.B3 343.71,330.2 ; 88.9,100.79 D129.B2 ; D129.B2 89.71,101.6 ; D129.B2 88.9,102.41 ; D129.B2 88.09,101.6 ; 35.56,55.07 D127.A10 ; D127.A10 36.37,55.88 ; D127.A10 34.75,55.88 ; D127.A10 35.56,56.69 ; SITE3.G10 251.33,188.41 ; SITE3.G10 250.85,187.93 ; SITE3.G10 251.33,187.45 ; SITE3.G10 251.81,187.93 ; D115.A10 325.12,374.19 ; D115.A10 324.31,373.38 ; D115.A10 325.93,373.38 ; D115.A10 325.12,372.57 ; D106.A3 386.89,73.66 ; D106.A3 386.08,72.85 ; D106.A3 385.27,73.66 ; D106.A3 386.08,74.47 ; 403.86,75.39 D106.A10 ; D106.A10 404.67,76.2 ; D106.A10 403.86,77.01 ; D106.A10 403.05,76.2 ; 187.96,55.07 D119.A12 ; D119.A12 188.77,55.88 ; D119.A12 187.96,56.69 ; D119.A12 187.15,55.88 ; D119.B14 193.85,60.96 ; D119.B14 193.04,60.15 ; D119.B14 193.04,61.77 ; D119.B14 192.23,60.96 ; D122.A3 238.76,74.47 ; D122.A3 239.57,73.66 ; D122.A3 237.95,73.66 ; D122.A3 238.76,72.85 ; 187.15,368.3 D231.B6 ; D231.B6 187.96,369.11 ; D231.B6 187.96,367.49 ; D231.B6 188.77,368.3 ; 327.66,67.87 D302.B9 ; D302.B9 328.37,68.58 ; D302.B9 327.66,69.29 ; D302.B9 326.95,68.58 ; 380.19,73.66 D106.A1 ; D106.A1 381,72.85 ; D106.A1 381,74.47 ; D106.A1 381.81,73.66 ; D112.B3 417.37,391.16 ; D112.B3 416.56,391.97 ; D112.B3 415.75,391.16 ; D112.B3 416.56,390.35 ; 95.71,93.98 D129.A5 ; D129.A5 96.52,93.17 ; D129.A5 97.33,93.98 ; D129.A5 96.52,94.79 ; 238.76,37.29 D124.B3 ; D124.B3 239.57,38.1 ; D124.B3 237.95,38.1 ; D124.B3 238.76,38.91 ; 189.69,38.1 D120.B13 ; D120.B13 190.5,38.91 ; D120.B13 190.5,37.29 ; D120.B13 191.31,38.1 ; D302.A10 330.2,66.75 ; D302.A10 330.2,65.33 ; D302.A10 329.49,66.04 ; D302.A10 330.91,66.04 ; D124.B5 244.65,38.1 ; D124.B5 243.84,38.91 ; D124.B5 243.03,38.1 ; D124.B5 243.84,37.29 ; 164.29,330.2 CSDPS229.C15 ; CSDPS229.C15 165.91,330.2 ; CSDPS229.C15 165.1,329.39 ; CSDPS229.C15 165.1,331.01 ; 324.31,40.64 D104.B8 ; D104.B8 325.93,40.64 ; D104.B8 325.12,39.83 ; D104.B8 325.12,41.45 ; D126.B7 27.94,79.55 ; D126.B7 28.75,78.74 ; D126.B7 27.94,77.93 ; D126.B7 27.13,78.74 ; D128.A1 13.51,33.02 ; D128.A1 12.7,33.83 ; D128.A1 12.7,32.21 ; D128.A1 11.89,33.02 ; D131.A4 94.79,55.88 ; D131.A4 93.17,55.88 ; D131.A4 93.98,55.07 ; D131.A4 93.98,56.69 ; 34.75,76.2 D126.A10 ; D126.A10 36.37,76.2 ; D126.A10 35.56,75.39 ; D126.A10 35.56,77.01 ; 93.98,39.83 D132.B4 ; D132.B4 93.17,40.64 ; D132.B4 94.79,40.64 ; D132.B4 93.98,41.45 ; 390.35,58.42 D107.B5 ; D107.B5 391.16,57.61 ; D107.B5 391.97,58.42 ; D107.B5 391.16,59.23 ; D124.A1 233.68,33.83 ; D124.A1 234.49,33.02 ; D124.A1 233.68,32.21 ; D124.A1 232.87,33.02 ; D118.A8 177.8,77.01 ; D118.A8 177.8,75.39 ; D118.A8 178.61,76.2 ; D118.A8 176.99,76.2 ; 329.39,76.2 D102.A10 ; D102.A10 330.2,75.39 ; D102.A10 330.2,77.01 ; D102.A10 331.01,76.2 ; D305.A13 411.48,84.53 ; D305.A13 410.77,83.82 ; D305.A13 411.48,83.11 ; D305.A13 412.19,83.82 ; 380.19,78.74 D106.B1 ; D106.B1 381.81,78.74 ; D106.B1 381,77.93 ; D106.B1 381,79.55 ; D122.B13 264.16,79.55 ; D122.B13 264.97,78.74 ; D122.B13 263.35,78.74 ; D122.B13 264.16,77.93 ; D130.B9 107.49,78.74 ; D130.B9 106.68,77.93 ; D130.B9 105.87,78.74 ; D130.B9 106.68,79.55 ; 408.94,372.57 D111.A6 ; D111.A6 408.13,373.38 ; D111.A6 409.75,373.38 ; D111.A6 408.94,374.19 ; D108.A7 397.05,33.02 ; D108.A7 396.24,33.83 ; D108.A7 396.24,32.21 ; D108.A7 395.43,33.02 ; D431.B17 160.02,381.81 ; D431.B17 160.83,381 ; D431.B17 159.21,381 ; D431.B17 160.02,380.19 ; 396.24,62.79 D306.A7 ; D306.A7 396.95,63.5 ; D306.A7 396.24,64.21 ; D306.A7 395.53,63.5 ; D109.A15 386.89,335.28 ; D109.A15 386.08,334.47 ; D109.A15 386.08,336.09 ; D109.A15 385.27,335.28 ; 332.33,187.45 SITE4.G11 ; SITE4.G11 331.85,187.93 ; SITE4.G11 332.81,187.93 ; SITE4.G11 332.33,188.41 ; 265.89,342.9 CSDPS425.B4 ; CSDPS425.B4 266.7,343.71 ; CSDPS425.B4 267.51,342.9 ; CSDPS425.B4 266.7,342.09 ; D122.A5 243.84,74.47 ; D122.A5 244.65,73.66 ; D122.A5 243.03,73.66 ; D122.A5 243.84,72.85 ; D108.A13 411.48,33.83 ; D108.A13 410.67,33.02 ; D108.A13 412.29,33.02 ; D108.A13 411.48,32.21 ; 322.58,334.47 D113.A11 ; D113.A11 323.39,335.28 ; D113.A11 322.58,336.09 ; D113.A11 321.77,335.28 ; D116.B5 338.63,391.16 ; D116.B5 337.82,390.35 ; D116.B5 337.82,391.97 ; D116.B5 337.01,391.16 ; 187.25,86.36 D317.A12 ; D317.A12 187.96,85.65 ; D317.A12 187.96,87.07 ; D317.A12 188.67,86.36 ; D128.B7 27.94,38.91 ; D128.B7 27.94,37.29 ; D128.B7 27.13,38.1 ; D128.B7 28.75,38.1 ; 324.31,55.88 D103.A8 ; D103.A8 325.93,55.88 ; D103.A8 325.12,55.07 ; D103.A8 325.12,56.69 ; D131.A16 125.27,55.88 ; D131.A16 124.46,55.07 ; D131.A16 124.46,56.69 ; D131.A16 123.65,55.88 ; D104.B9 327.66,38.91 ; D104.B9 327.66,37.29 ; D104.B9 328.47,38.1 ; D104.B9 326.85,38.1 ; D115.B10 325.93,368.3 ; D115.B10 325.12,369.11 ; D115.B10 324.31,368.3 ; D115.B10 325.12,367.49 ; 419.1,347.17 D110.B2 ; D110.B2 418.29,347.98 ; D110.B2 419.1,348.79 ; D110.B2 419.91,347.98 ; D302.B5 318.21,68.58 ; D302.B5 316.79,68.58 ; D302.B5 317.5,69.29 ; D302.B5 317.5,67.87 ; D322.A1 233.68,64.21 ; D322.A1 234.39,63.5 ; D322.A1 232.97,63.5 ; D322.A1 233.68,62.79 ; D124.B1 234.49,38.1 ; D124.B1 233.68,38.91 ; D124.B1 233.68,37.29 ; D124.B1 232.87,38.1 ; D306.B9 401.32,69.29 ; D306.B9 401.32,67.87 ; D306.B9 402.03,68.58 ; D306.B9 400.61,68.58 ; 50.8,75.39 D126.A16 ; D126.A16 50.8,77.01 ; D126.A16 51.61,76.2 ; D126.A16 49.99,76.2 ; D131.B8 104.95,60.96 ; D131.B8 104.14,60.15 ; D131.B8 104.14,61.77 ; D131.B8 103.33,60.96 ; D123.B16 271.78,61.77 ; D123.B16 272.59,60.96 ; D123.B16 271.78,60.15 ; D123.B16 270.97,60.96 ; D125.A7 28.75,93.98 ; D125.A7 27.94,94.79 ; D125.A7 27.13,93.98 ; D125.A7 27.94,93.17 ; 337.82,67.87 D302.B13 ; D302.B13 338.53,68.58 ; D302.B13 337.11,68.58 ; D302.B13 337.82,69.29 ; D111.A16 383.54,374.19 ; D111.A16 384.35,373.38 ; D111.A16 382.73,373.38 ; D111.A16 383.54,372.57 ; 185.42,67.87 D318.B11 ; D318.B11 186.13,68.58 ; D318.B11 185.42,69.29 ; D318.B11 184.71,68.58 ; D128.A2 15.24,36.37 ; D128.A2 15.24,34.75 ; D128.A2 16.05,35.56 ; D128.A2 14.43,35.56 ; D131.B6 99.06,61.77 ; D131.B6 99.87,60.96 ; D131.B6 99.06,60.15 ; D131.B6 98.25,60.96 ; 322.58,409.4 DPS2.C11 ; DPS2.C11 322.58,411.02 ; DPS2.C11 321.77,410.21 ; DPS2.C11 323.39,410.21 ; 248.92,57.61 D123.B7 ; D123.B7 249.73,58.42 ; D123.B7 248.92,59.23 ; D123.B7 248.11,58.42 ; D127.A13 43.18,54.15 ; D127.A13 42.37,53.34 ; D127.A13 43.99,53.34 ; D127.A13 43.18,52.53 ; 268.43,78.74 D122.B15 ; D122.B15 269.24,77.93 ; D122.B15 270.05,78.74 ; D122.B15 269.24,79.55 ; D130.A16 125.27,76.2 ; D130.A16 123.65,76.2 ; D130.A16 124.46,75.39 ; D130.A16 124.46,77.01
  L03_SIGNAL w0.074: 381,52.53 D107.A1 ; D107.A1 381.81,53.34 ; D107.A1 381,54.15 ; D107.A1 380.19,53.34 ; D317.A7 175.26,84.53 ; D317.A7 175.97,83.82 ; D317.A7 174.55,83.82 ; D317.A7 175.26,83.11 ; D116.B2 345.44,389.43 ; D116.B2 346.25,388.62 ; D116.B2 345.44,387.81 ; D116.B2 344.63,388.62 ; D118.A11 186.23,73.66 ; D118.A11 185.42,74.47 ; D118.A11 184.61,73.66 ; D118.A11 185.42,72.85 ; D305.A5 391.16,84.53 ; D305.A5 390.45,83.82 ; D305.A5 391.16,83.11 ; D305.A5 391.87,83.82 ; 105.87,58.42 D131.B9 ; D131.B9 106.68,57.61 ; D131.B9 107.49,58.42 ; D131.B9 106.68,59.23 ; 316.69,396.24 D116.A13 ; D116.A13 317.5,397.05 ; D116.A13 318.31,396.24 ; D116.A13 317.5,395.43 ; 414.02,372.57 D111.A4 ; D111.A4 414.83,373.38 ; D111.A4 413.21,373.38 ; D111.A4 414.02,374.19 ; SITE2.G3 330.33,241.81 ; SITE2.G3 330.81,241.33 ; SITE2.G3 329.85,241.33 ; SITE2.G3 330.33,240.85 ; CSDPS225.B14 242.11,332.74 ; CSDPS225.B14 240.49,332.74 ; CSDPS225.B14 241.3,333.55 ; CSDPS225.B14 241.3,331.93 ; SITE3.G16 252.63,183.31 ; SITE3.G16 252.15,182.83 ; SITE3.G16 252.63,182.35 ; SITE3.G16 253.11,182.83 ; 45.72,95.71 D125.A14 ; D125.A14 46.53,96.52 ; D125.A14 45.72,97.33 ; D125.A14 44.91,96.52 ; 238.76,329.39 CSDPS225.C15 ; CSDPS225.C15 239.57,330.2 ; CSDPS225.C15 237.95,330.2 ; CSDPS225.C15 238.76,331.01 ; D122.A8 252.27,76.2 ; D122.A8 251.46,75.39 ; D122.A8 251.46,77.01 ; D122.A8 250.65,76.2 ; 116.03,93.98 D129.A13 ; D129.A13 116.84,93.17 ; D129.A13 117.65,93.98 ; D129.A13 116.84,94.79 ; D132.A7 102.41,33.02 ; D132.A7 100.79,33.02 ; D132.A7 101.6,32.21 ; D132.A7 101.6,33.83 ; D125.B15 49.07,99.06 ; D125.B15 47.45,99.06 ; D125.B15 48.26,98.25 ; D125.B15 48.26,99.87 ; D306.A14 414.73,66.04 ; D306.A14 414.02,66.75 ; D306.A14 414.02,65.33 ; D306.A14 413.31,66.04 ; D113.B12 320.85,327.66 ; D113.B12 319.23,327.66 ; D113.B12 320.04,328.47 ; D113.B12 320.04,326.85 ; D102.A16 345.44,77.01 ; D102.A16 345.44,75.39 ; D102.A16 344.63,76.2 ; D102.A16 346.25,76.2 ; DPS1.C15 417.37,19.05 ; DPS1.C15 415.75,19.05 ; DPS1.C15 416.56,18.24 ; DPS1.C15 416.56,19.86 ; 317.5,329.39 D113.B13 ; D113.B13 318.31,330.2 ; D113.B13 316.69,330.2 ; D113.B13 317.5,331.01 ; D119.B9 180.34,59.23 ; D119.B9 179.53,58.42 ; D119.B9 181.15,58.42 ; D119.B9 180.34,57.61 ; D114.B9 327.66,351.33 ; D114.B9 326.85,350.52 ; D114.B9 327.66,349.71 ; D114.B9 328.47,350.52 ; D431.A11 175.26,386.89 ; D431.A11 175.26,385.27 ; D431.A11 174.45,386.08 ; D431.A11 176.07,386.08 ; 164.39,68.58 D318.B3 ; D318.B3 165.1,67.87 ; D318.B3 165.1,69.29 ; D318.B3 165.81,68.58 ; D123.A13 264.16,54.15 ; D123.A13 264.16,52.53 ; D123.A13 264.97,53.34 ; D123.A13 263.35,53.34 ; D130.B7 102.41,78.74 ; D130.B7 101.6,77.93 ; D130.B7 101.6,79.55 ; D130.B7 100.79,78.74 ; 382.73,388.62 D112.B16 ; D112.B16 383.54,387.81 ; D112.B16 384.35,388.62 ; D112.B16 383.54,389.43 ; D103.B5 317.5,59.23 ; D103.B5 316.69,58.42 ; D103.B5 318.31,58.42 ; D103.B5 317.5,57.61 ; 347.98,354.79 D114.A1 ; D114.A1 348.79,355.6 ; D114.A1 347.98,356.41 ; D114.A1 347.17,355.6 ; 101.6,98.25 D129.B7 ; D129.B7 102.41,99.06 ; D129.B7 101.6,99.87 ; D129.B7 100.79,99.06 ; 324.31,327.66 D113.B10 ; D113.B10 325.12,328.47 ; D113.B10 325.93,327.66 ; D113.B10 325.12,326.85 ; 317.5,88.19 D301.B5 ; D301.B5 318.21,88.9 ; D301.B5 316.79,88.9 ; D301.B5 317.5,89.61 ; 405.69,88.9 D305.B11 ; D305.B11 406.4,89.61 ; D305.B11 407.11,88.9 ; D305.B11 406.4,88.19 ; 22.05,99.06 D125.B5 ; D125.B5 23.67,99.06 ; D125.B5 22.86,98.25 ; D125.B5 22.86,99.87 ; 337.82,88.19 D301.B13 ; D301.B13 338.53,88.9 ; D301.B13 337.82,89.61 ; D301.B13 337.11,88.9 ; 99.06,100.79 D129.B6 ; D129.B6 98.25,101.6 ; D129.B6 99.87,101.6 ; D129.B6 99.06,102.41 ; 332.63,185.95 SITE4.G20 ; SITE4.G20 333.11,186.43 ; SITE4.G20 332.63,186.91 ; SITE4.G20 332.15,186.43 ; D126.B4 20.32,82.09 ; D126.B4 20.32,80.47 ; D126.B4 19.51,81.28 ; D126.B4 21.13,81.28 ; D321.A11 259.79,83.82 ; D321.A11 258.37,83.82 ; D321.A11 259.08,84.53 ; D321.A11 259.08,83.11 ; D104.A15 343.71,33.02 ; D104.A15 342.09,33.02 ; D104.A15 342.9,33.83 ; D104.A15 342.9,32.21 ; D322.B6 246.38,71.83 ; D322.B6 247.09,71.12 ; D322.B6 246.38,70.41 ; D322.B6 245.67,71.12 ; D115.A15 313.23,375.92 ; D115.A15 311.61,375.92 ; D115.A15 312.42,376.73 ; D115.A15 312.42,375.11 ; 238.05,83.82 D321.A3 ; D321.A3 238.76,83.11 ; D321.A3 238.76,84.53 ; D321.A3 239.47,83.82 ; 385.27,53.34 D107.A3 ; D107.A3 386.08,54.15 ; D107.A3 386.08,52.53 ; D107.A3 386.89,53.34 ; 419.1,85.65 D305.A16 ; D305.A16 418.39,86.36 ; D305.A16 419.1,87.07 ; D305.A16 419.81,86.36 ; 385.37,68.58 D306.B3 ; D306.B3 386.08,67.87 ; D306.B3 386.08,69.29 ; D306.B3 386.79,68.58 ; 249.75,246.43 SITE1.G18 ; SITE1.G18 250.23,245.95 ; SITE1.G18 250.23,246.91 ; SITE1.G18 250.71,246.43 ; 185.42,380.19 D431.B7 ; D431.B7 186.23,381 ; D431.B7 184.61,381 ; D431.B7 185.42,381.81 ; UNK4U2.4 483.43,171.51 ; UNK4U2.4 482.49,172.45 ; UNK4U2.4 481.55,171.51 ; UNK4U2.4 482.49,170.56 ; 329.49,91.44 D301.B10 ; D301.B10 330.91,91.44 ; D301.B10 330.2,90.73 ; D301.B10 330.2,92.15 ; 172.72,55.07 D119.A6 ; D119.A6 173.53,55.88 ; D119.A6 171.91,55.88 ; D119.A6 172.72,56.69 ; 400.61,63.5 D306.A9 ; D306.A9 401.32,64.21 ; D306.A9 401.32,62.79 ; D306.A9 402.03,63.5 ; SITE2.G8 329.81,247.93 ; SITE2.G8 329.33,247.45 ; SITE2.G8 328.85,247.93 ; SITE2.G8 329.33,248.41 ; D114.B15 312.42,351.33 ; D114.B15 311.61,350.52 ; D114.B15 312.42,349.71 ; D114.B15 313.23,350.52 ; 419.1,352.25 D110.A2 ; D110.A2 419.1,353.87 ; D110.A2 419.91,353.06 ; D110.A2 418.29,353.06 ; 90.63,93.98 D129.A3 ; D129.A3 91.44,93.17 ; D129.A3 92.25,93.98 ; D129.A3 91.44,94.79 ; D118.A10 182.88,77.01 ; D118.A10 183.69,76.2 ; D118.A10 182.07,76.2 ; D118.A10 182.88,75.39 ; D129.B14 119.38,102.41 ; D129.B14 119.38,100.79 ; D129.B14 118.57,101.6 ; D129.B14 120.19,101.6 ; D124.A13 264.97,33.02 ; D124.A13 264.16,33.83 ; D124.A13 263.35,33.02 ; D124.A13 264.16,32.21 ; 32.21,33.02 D128.A9 ; D128.A9 33.02,33.83 ; D128.A9 33.83,33.02 ; D128.A9 33.02,32.21 ; D131.B3 92.25,58.42 ; D131.B3 91.44,59.23 ; D131.B3 90.63,58.42 ; D131.B3 91.44,57.61 ; D106.A13 412.29,73.66 ; D106.A13 411.48,74.47 ; D106.A13 411.48,72.85 ; D106.A13 410.67,73.66 ; D104.A10 331.01,35.56 ; D104.A10 329.39,35.56 ; D104.A10 330.2,34.75 ; D104.A10 330.2,36.37 ; 245.57,76.2 D122.A6 ; D122.A6 246.38,77.01 ; D122.A6 246.38,75.39 ; D122.A6 247.19,76.2 ; D126.B10 35.56,82.09 ; D126.B10 34.75,81.28 ; D126.B10 35.56,80.47 ; D126.B10 36.37,81.28 ; D112.B11 397.05,391.16 ; D112.B11 396.24,391.97 ; D112.B11 396.24,390.35 ; D112.B11 395.43,391.16 ; D124.A15 269.24,33.83 ; D124.A15 268.43,33.02 ; D124.A15 269.24,32.21 ; D124.A15 270.05,33.02 ; D306.A12 408.94,66.75 ; D306.A12 408.23,66.04 ; D306.A12 409.65,66.04 ; D306.A12 408.94,65.33 ; 263.35,38.1 D124.B13 ; D124.B13 264.16,38.91 ; D124.B13 264.16,37.29 ; D124.B13 264.97,38.1 ; D111.A15 386.08,376.73 ; D111.A15 385.27,375.92 ; D111.A15 386.89,375.92 ; D111.A15 386.08,375.11 ; 177.8,75.39 D118.A8 ; D118.A8 178.61,76.2 ; D118.A8 176.99,76.2 ; D118.A8 177.8,77.01 ; D113.A10 325.12,333.55 ; D113.A10 325.93,332.74 ; D113.A10 324.31,332.74 ; D113.A10 325.12,331.93 ; 261.62,34.75 D124.A12 ; D124.A12 261.62,36.37 ; D124.A12 262.43,35.56 ; D124.A12 260.81,35.56 ; D104.B15 342.9,38.91 ; D104.B15 343.71,38.1 ; D104.B15 342.09,38.1 ; D104.B15 342.9,37.29 ; D103.B11 332.74,59.23 ; D103.B11 332.74,57.61 ; D103.B11 331.93,58.42 ; D103.B11 333.55,58.42 ; 27.13,53.34 D127.A7 ; D127.A7 27.94,52.53 ; D127.A7 27.94,54.15 ; D127.A7 28.75,53.34 ; D301.A5 318.21,83.82 ; D301.A5 317.5,84.53 ; D301.A5 317.5,83.11 ; D301.A5 316.79,83.82 ; D104.A12 336.09,35.56 ; D104.A12 335.28,36.37 ; D104.A12 335.28,34.75 ; D104.A12 334.47,35.56 ; DPS3.A01 234.49,13.97 ; DPS3.A01 232.87,13.97 ; DPS3.A01 233.68,13.16 ; DPS3.A01 233.68,14.78 ; CSDPS429.B8 183.69,342.9 ; CSDPS429.B8 182.07,342.9 ; CSDPS429.B8 182.88,342.09 ; CSDPS429.B8 182.88,343.71 ; 17.78,32.21 D128.A3 ; D128.A3 16.97,33.02 ; D128.A3 18.59,33.02 ; D128.A3 17.78,33.83 ; D317.B13 191.21,88.9 ; D317.B13 190.5,89.61 ; D317.B13 189.79,88.9 ; D317.B13 190.5,88.19 ; 22.05,58.42 D127.B5 ; D127.B5 22.86,57.61 ; D127.B5 22.86,59.23 ; D127.B5 23.67,58.42 ; 114.3,34.75 D132.A12 ; D132.A12 115.11,35.56 ; D132.A12 114.3,36.37 ; D132.A12 113.49,35.56 ; 311.61,58.42 D103.B3 ; D103.B3 312.42,57.61 ; D103.B3 312.42,59.23 ; D103.B3 313.23,58.42 ; 197.31,342.9 CSDPS429.B2 ; CSDPS429.B2 198.93,342.9 ; CSDPS429.B2 198.12,342.09 ; CSDPS429.B2 198.12,343.71 ; 420.83,335.28 D109.A1 ; D109.A1 422.45,335.28 ; D109.A1 421.64,334.47 ; D109.A1 421.64,336.09 ; CSDPS429.B12 173.53,342.9 ; CSDPS429.B12 171.91,342.9 ; CSDPS429.B12 172.72,342.09 ; CSDPS429.B12 172.72,343.71 ; 334.47,327.66 D113.B6 ; D113.B6 335.28,328.47 ; D113.B6 336.09,327.66 ; D113.B6 335.28,326.85 ; D110.A6 409.75,353.06 ; D110.A6 408.94,352.25 ; D110.A6 408.94,353.87 ; D110.A6 408.13,353.06 ; D109.B11 396.24,331.01 ; D109.B11 397.05,330.2 ; D109.B11 395.43,330.2 ; D109.B11 396.24,329.39 ; 330.2,70.41 D302.B10 ; D302.B10 330.91,71.12 ; D302.B10 330.2,71.83 ; D302.B10 329.49,71.12 ; 258.27,19.05 DPS3.C11 ; DPS3.C11 259.08,19.86 ; DPS3.C11 259.08,18.24 ; DPS3.C11 259.89,19.05 ; 397.97,388.62 D112.B10 ; D112.B10 399.59,388.62 ; D112.B10 398.78,387.81 ; D112.B10 398.78,389.43 ; SITE1.G11 252.81,247.93 ; SITE1.G11 252.33,248.41 ; SITE1.G11 252.33,247.45 ; SITE1.G11 251.85,247.93 ; CSDPS225.C5 264.16,331.01 ; CSDPS225.C5 263.35,330.2 ; CSDPS225.C5 264.16,329.39 ; CSDPS225.C5 264.97,330.2 ; D113.B8 330.2,328.47 ; D113.B8 329.39,327.66 ; D113.B8 330.2,326.85 ; D113.B8 331.01,327.66 ; D116.B12 320.85,388.62 ; D116.B12 319.23,388.62 ; D116.B12 320.04,389.43 ; D116.B12 320.04,387.81 ; 314.96,331.93 D113.A14 ; D113.A14 314.96,333.55 ; D113.A14 315.77,332.74 ; D113.A14 314.15,332.74 ; 383.54,331.93 D109.A16 ; D109.A16 383.54,333.55 ; D109.A16 382.73,332.74 ; D109.A16 384.35,332.74 ; D305.B12 408.94,92.15 ; D305.B12 409.65,91.44 ; D305.B12 408.23,91.44 ; D305.B12 408.94,90.73 ; 316.69,335.28 D113.A13 ; D113.A13 317.5,334.47 ; D113.A13 318.31,335.28 ; D113.A13 317.5,336.09 ; D131.A7 102.41,53.34 ; D131.A7 100.79,53.34 ; D131.A7 101.6,52.53 ; D131.A7 101.6,54.15 ; 189.69,33.02 D120.A13 ; D120.A13 190.5,32.21 ; D120.A13 191.31,33.02 ; D120.A13 190.5,33.83 ; 241.3,70.41 D322.B4 ; D322.B4 242.01,71.12 ; D322.B4 240.59,71.12 ; D322.B4 241.3,71.83 ; 195.58,380.19 D431.B3 ; D431.B3 195.58,381.81 ; D431.B3 196.39,381 ; D431.B3 194.77,381 ; 200.66,375.11 D231.A1 ; D231.A1 200.66,376.73 ; D231.A1 199.85,375.92 ; D231.A1 201.47,375.92 ; 400.51,350.52 D110.B9 ; D110.B9 401.32,349.71 ; D110.B9 401.32,351.33 ; D110.B9 402.13,350.52 ; 390.35,38.1 D108.B5 ; D108.B5 391.97,38.1 ; D108.B5 391.16,37.29 ; D108.B5 391.16,38.91 ; D114.A2 346.25,353.06 ; D114.A2 345.44,352.25 ; D114.A2 344.63,353.06 ; D114.A2 345.44,353.87 ; DPS2.A05 337.82,416.1 ; DPS2.A05 337.82,414.48 ; DPS2.A05 337.01,415.29 ; DPS2.A05 338.63,415.29 ; 411.48,57.61 D107.B13 ; D107.B13 410.67,58.42 ; D107.B13 411.48,59.23 ; D107.B13 412.29,58.42 ; 174.55,68.58 D318.B7 ; D318.B7 175.97,68.58 ; D318.B7 175.26,67.87 ; D318.B7 175.26,69.29 ; D118.B1 160.02,79.55 ; D118.B1 159.21,78.74 ; D118.B1 160.83,78.74 ; D118.B1 160.02,77.93 ; D106.A3 386.08,74.47 ; D106.A3 386.89,73.66 ; D106.A3 385.27,73.66 ; D106.A3 386.08,72.85 ; D102.B7 322.58,79.55 ; D102.B7 323.39,78.74 ; D102.B7 321.77,78.74 ; D102.B7 322.58,77.93 ; D302.A1 308.05,63.5 ; D302.A1 307.34,64.21 ; D302.A1 306.63,63.5 ; D302.A1 307.34,62.79 ; 385.27,330.2 D109.B15 ; D109.B15 386.08,331.01 ; D109.B15 386.89,330.2 ; D109.B15 386.08,329.39 ; 261.62,90.73 D321.B12 ; D321.B12 262.33,91.44 ; D321.B12 260.91,91.44 ; D321.B12 261.62,92.15 ; D305.A15 417.27,83.82 ; D305.A15 416.56,84.53 ; D305.A15 415.85,83.82 ; D305.A15 416.56,83.11 ; D132.B3 91.44,38.91 ; D132.B3 92.25,38.1 ; D132.B3 91.44,37.29 ; D132.B3 90.63,38.1 ; CSDPS425.B2 271.78,343.71 ; CSDPS425.B2 272.59,342.9 ; CSDPS425.B2 271.78,342.09 ; CSDPS425.B2 270.97,342.9 ; 327.85,187.93 SITE4.G7 ; SITE4.G7 328.33,187.45 ; SITE4.G7 328.81,187.93 ; SITE4.G7 328.33,188.41 ; 401.32,395.43 D112.A9 ; D112.A9 400.51,396.24 ; D112.A9 402.13,396.24 ; D112.A9 401.32,397.05 ; 396.24,395.43 D112.A11 ; D112.A11 396.24,397.05 ; D112.A11 395.43,396.24 ; D112.A11 397.05,396.24 ; D113.A2 345.44,333.55 ; D113.A2 345.44,331.93 ; D113.A2 346.25,332.74 ; D113.A2 344.63,332.74 ; 248.92,37.29 D124.B7 ; D124.B7 249.73,38.1 ; D124.B7 248.11,38.1 ; D124.B7 248.92,38.91 ; 88.9,95.71 D129.A2 ; D129.A2 88.09,96.52 ; D129.A2 89.71,96.52 ; D129.A2 88.9,97.33 ; 391.16,390.35 D112.B13 ; D112.B13 391.97,391.16 ; D112.B13 390.35,391.16 ; D112.B13 391.16,391.97 ; D305.A3 386.79,83.82 ; D305.A3 385.37,83.82 ; D305.A3 386.08,83.11 ; D305.A3 386.08,84.53 ; 90.63,53.34 D131.A3 ; D131.A3 92.25,53.34 ; D131.A3 91.44,54.15 ; D131.A3 91.44,52.53 ; 517.98,203.45 S4_I2C.4 ; S4_I2C.4 518.92,204.39 ; S4_I2C.4 519.86,203.45 ; S4_I2C.4 518.92,202.51 ; D120.B10 183.69,40.64 ; D120.B10 182.88,39.83 ; D120.B10 182.88,41.45 ; D120.B10 182.07,40.64 ; D126.B3 17.78,79.55 ; D126.B3 16.97,78.74 ; D126.B3 18.59,78.74 ; D126.B3 17.78,77.93 ; D114.B10 325.93,347.98 ; D114.B10 324.31,347.98 ; D114.B10 325.12,347.17 ; D114.B10 325.12,348.79 ; 160.02,370.03 D231.B17 ; D231.B17 160.02,371.65 ; D231.B17 159.21,370.84 ; D231.B17 160.83,370.84 ; 254,88.19 D321.B9 ; D321.B9 254.71,88.9 ; D321.B9 254,89.61 ; D321.B9 253.29,88.9 ; 243.03,78.74 D122.B5 ; D122.B5 244.65,78.74 ; D122.B5 243.84,77.93 ; D122.B5 243.84,79.55 ; 116.84,37.29 D132.B13 ; D132.B13 117.65,38.1 ; D132.B13 116.84,38.91 ; D132.B13 116.03,38.1 ; D131.A12 114.3,56.69 ; D131.A12 115.11,55.88 ; D131.A12 114.3,55.07 ; D131.A12 113.49,55.88 ; 259.08,37.29 D124.B11 ; D124.B11 259.08,38.91 ; D124.B11 258.27,38.1 ; D124.B11 259.89,38.1 ; 44.91,60.96 D127.B14 ; D127.B14 45.72,61.77 ; D127.B14 45.72,60.15 ; D127.B14 46.53,60.96 ; SITE3.G8 249.33,188.41 ; SITE3.G8 249.81,187.93 ; SITE3.G8 248.85,187.93 ; SITE3.G8 249.33,187.45 ; CSDPS229.B6 187.96,333.55 ; CSDPS229.B6 187.15,332.74 ; CSDPS229.B6 187.96,331.93 ; CSDPS229.B6 188.77,332.74 ; D231.A17 160.02,376.73 ; D231.A17 159.21,375.92 ; D231.A17 160.02,375.11 ; D231.A17 160.83,375.92 ; 250.65,81.28 D122.B8 ; D122.B8 252.27,81.28 ; D122.B8 251.46,80.47 ; D122.B8 251.46,82.09 ; 418.29,347.98 D110.B2 ; D110.B2 419.1,348.79 ; D110.B2 419.1,347.17 ; D110.B2 419.91,347.98 ; D120.A1 160.83,33.02 ; D120.A1 160.02,33.83 ; D120.A1 160.02,32.21 ; D120.A1 159.21,33.02 ; 192.33,91.44 D317.B14 ; D317.B14 193.04,90.73 ; D317.B14 193.04,92.15 ; D317.B14 193.75,91.44 ; D123.A10 257.35,55.88 ; D123.A10 256.54,56.69 ; D123.A10 256.54,55.07 ; D123.A10 255.73,55.88 ; 340.36,65.33 D302.A14 ; D302.A14 340.36,66.75 ; D302.A14 339.65,66.04 ; D302.A14 341.07,66.04 ; 245.67,91.44 D321.B6 ; D321.B6 246.38,92.15 ; D321.B6 247.09,91.44 ; D321.B6 246.38,90.73 ; SITE3.G6 253.81,181.33 ; SITE3.G6 253.33,181.81 ; SITE3.G6 252.85,181.33 ; SITE3.G6 253.33,180.85 ; 248.21,83.82 D321.A7 ; D321.A7 248.92,84.53 ; D321.A7 248.92,83.11 ; D321.A7 249.63,83.82 ; 413.21,35.56 D108.A14 ; D108.A14 414.02,34.75 ; D108.A14 414.83,35.56 ; D108.A14 414.02,36.37 ; 309.88,60.15 D103.B2 ; D103.B2 309.88,61.77 ; D103.B2 310.69,60.96 ; D103.B2 309.07,60.96 ; D120.A9 180.34,33.83 ; D120.A9 179.53,33.02 ; D120.A9 180.34,32.21 ; D120.A9 181.15,33.02 ; CSDPS229.B14 167.64,333.55 ; CSDPS229.B14 167.64,331.93 ; CSDPS229.B14 166.83,332.74 ; CSDPS229.B14 168.45,332.74 ; SITE4.G14 330.23,183.31 ; SITE4.G14 330.23,182.35 ; SITE4.G14 330.71,182.83 ; SITE4.G14 329.75,182.83 ; 14.43,101.6 D125.B2 ; D125.B2 16.05,101.6 ; D125.B2 15.24,102.41 ; D125.B2 15.24,100.79 ; 312.42,390.35 D116.B15 ; D116.B15 313.23,391.16 ; D116.B15 312.42,391.97 ; D116.B15 311.61,391.16 ; 340.36,90.73 D301.B14 ; D301.B14 341.07,91.44 ; D301.B14 340.36,92.15 ; D301.B14 339.65,91.44 ; D108.B7 396.24,38.91 ; D108.B7 396.24,37.29 ; D108.B7 397.05,38.1 ; D108.B7 395.43,38.1 ; 159.21,73.66 D118.A1 ; D118.A1 160.02,72.85 ; D118.A1 160.83,73.66 ; D118.A1 160.02,74.47 ; 121.92,93.17 D129.A15 ; D129.A15 121.11,93.98 ; D129.A15 122.73,93.98 ; D129.A15 121.92,94.79 ; D119.B1 160.83,58.42 ; D119.B1 160.02,57.61 ; D119.B1 160.02,59.23 ; D119.B1 159.21,58.42 ; D119.A3 165.91,53.34 ; D119.A3 165.1,54.15 ; D119.A3 164.29,53.34 ; D119.A3 165.1,52.53 ; 271.07,71.12 D322.B16 ; D322.B16 271.78,70.41 ; D322.B16 271.78,71.83 ; D322.B16 272.49,71.12 ; D104.A13 338.63,33.02 ; D104.A13 337.01,33.02 ; D104.A13 337.82,33.83 ; D104.A13 337.82,32.21 ; D306.B12 408.94,71.83 ; D306.B12 408.94,70.41 ; D306.B12 409.65,71.12 ; D306.B12 408.23,71.12 ; D127.A11 38.91,53.34 ; D127.A11 38.1,52.53 ; D127.A11 37.29,53.34 ; D127.A11 38.1,54.15 ; 165.1,370.03 D231.B15 ; D231.B15 164.29,370.84 ; D231.B15 165.1,371.65 ; D231.B15 165.91,370.84 ; D123.A1 234.49,53.34 ; D123.A1 233.68,54.15 ; D123.A1 233.68,52.53 ; D123.A1 232.87,53.34 ; 255.73,35.56 D124.A10 ; D124.A10 257.35,35.56 ; D124.A10 256.54,36.37 ; D124.A10 256.54,34.75 ; D431.A4 193.85,383.54 ; D431.A4 192.23,383.54 ; D431.A4 193.04,384.35 ; D431.A4 193.04,382.73 ; D120.B14 193.04,41.45 ; D120.B14 192.23,40.64 ; D120.B14 193.85,40.64 ; D120.B14 193.04,39.83 ; D129.A8 104.95,96.52 ; D129.A8 103.33,96.52 ; D129.A8 104.14,95.71 ; D129.A8 104.14,97.33 ; D119.B10 182.88,61.77 ; D119.B10 182.88,60.15 ; D119.B10 182.07,60.96 ; D119.B10 183.69,60.96 ; D122.B2 236.22,82.09 ; D122.B2 237.03,81.28 ; D122.B2 236.22,80.47 ; D122.B2 235.41,81.28 ; 324.31,40.64 D104.B8 ; D104.B8 325.12,39.83 ; D104.B8 325.93,40.64 ; D104.B8 325.12,41.45 ; 326.85,38.1 D104.B9 ; D104.B9 327.66,37.29 ; D104.B9 328.47,38.1 ; D104.B9 327.66,38.91 ; 238.05,68.58 D322.B3 ; D322.B3 238.76,69.29 ; D322.B3 238.76,67.87 ; D322.B3 239.47,68.58 ; 236.22,70.41 D322.B2 ; D322.B2 236.93,71.12 ; D322.B2 236.22,71.83 ; D322.B2 235.51,71.12 ; 27.13,73.66 D126.A7 ; D126.A7 28.75,73.66 ; D126.A7 27.94,72.85 ; D126.A7 27.94,74.47 ; 243.84,13.16 DPS3.A05 ; DPS3.A05 243.03,13.97 ; DPS3.A05 244.65,13.97 ; DPS3.A05 243.84,14.78 ; 259.08,32.21 D124.A11 ; D124.A11 259.89,33.02 ; D124.A11 259.08,33.83 ; D124.A11 258.27,33.02 ; D132.A3 91.44,33.83 ; D132.A3 90.63,33.02 ; D132.A3 91.44,32.21 ; D132.A3 92.25,33.02 ; 322.58,349.71 D114.B11 ; D114.B11 321.77,350.52 ; D114.B11 322.58,351.33 ; D114.B11 323.39,350.52 ; 393.7,70.41 D306.B6 ; D306.B6 392.99,71.12 ; D306.B6 394.41,71.12 ; D306.B6 393.7,71.83 ; D129.B13 116.84,99.87 ; D129.B13 116.03,99.06 ; D129.B13 117.65,99.06 ; D129.B13 116.84,98.25 ; D115.B8 330.2,369.11 ; D115.B8 329.39,368.3 ; D115.B8 330.2,367.49 ; D115.B8 331.01,368.3 ; 329.39,388.62 D116.B8 ; D116.B8 330.2,387.81 ; D116.B8 331.01,388.62 ; D116.B8 330.2,389.43 ; D111.B11 396.24,371.65 ; D111.B11 396.24,370.03 ; D111.B11 395.43,370.84 ; D111.B11 397.05,370.84 ; D301.B1 307.34,89.61 ; D301.B1 306.63,88.9 ; D301.B1 308.05,88.9 ; D301.B1 307.34,88.19 ; 42.37,99.06 D125.B13 ; D125.B13 43.18,99.87 ; D125.B13 43.99,99.06 ; D125.B13 43.18,98.25 ; 320.04,352.25 D114.A12 ; D114.A12 320.04,353.87 ; D114.A12 320.85,353.06 ; D114.A12 319.23,353.06 ; 182.88,55.07 D119.A10 ; D119.A10 182.88,56.69 ; D119.A10 182.07,55.88 ; D119.A10 183.69,55.88 ; 22.05,53.34 D127.A5 ; D127.A5 23.67,53.34 ; D127.A5 22.86,54.15 ; D127.A5 22.86,52.53 ; 250.95,242.83 SITE1.G15 ; SITE1.G15 251.91,242.83 ; SITE1.G15 251.43,243.31 ; SITE1.G15 251.43,242.35 ; SITE3.G18 250.23,186.91 ; SITE3.G18 250.71,186.43 ; SITE3.G18 250.23,185.95 ; SITE3.G18 249.75,186.43 ; 314.96,372.57 D115.A14 ; D115.A14 314.96,374.19 ; D115.A14 314.15,373.38 ; D115.A14 315.77,373.38 ; D116.B16 309.88,389.43 ; D116.B16 310.69,388.62 ; D116.B16 309.88,387.81 ; D116.B16 309.07,388.62 ; D102.B10 331.01,81.28 ; D102.B10 329.39,81.28 ; D102.B10 330.2,82.09 ; D102.B10 330.2,80.47 ; D120.A12 187.96,36.37 ; D120.A12 187.96,34.75 ; D120.A12 188.77,35.56 ; D120.A12 187.15,35.56 ; 251.33,180.85 SITE3.G4 ; SITE3.G4 251.81,181.33 ; SITE3.G4 250.85,181.33 ; SITE3.G4 251.33,181.81 ; D109.A5 411.48,336.09 ; D109.A5 412.29,335.28 ; D109.A5 410.67,335.28 ; D109.A5 411.48,334.47 ; D317.A13 191.21,83.82 ; D317.A13 190.5,84.53 ; D317.A13 189.79,83.82 ; D317.A13 190.5,83.11 ; D102.B2 309.88,82.09 ; D102.B2 309.07,81.28 ; D102.B2 309.88,80.47 ; D102.B2 310.69,81.28 ; D129.A7 102.41,93.98 ; D129.A7 101.6,94.79 ; D129.A7 101.6,93.17 ; D129.A7 100.79,93.98 ; 38.1,72.85 D126.A11 ; D126.A11 38.1,74.47 ; D126.A11 37.29,73.66 ; D126.A11 38.91,73.66 ; 347.17,410.21 DPS2.C01 ; DPS2.C01 347.98,411.02 ; DPS2.C01 348.79,410.21 ; DPS2.C01 347.98,409.4 ; 385.27,33.02 D108.A3 ; D108.A3 386.08,33.83 ; D108.A3 386.08,32.21 ; D108.A3 386.89,33.02 ; 189.69,375.92 D231.A5 ; D231.A5 191.31,375.92 ; D231.A5 190.5,375.11 ; D231.A5 190.5,376.73 ; D318.B16 198.83,71.12 ; D318.B16 198.12,71.83 ; D318.B16 198.12,70.41 ; D318.B16 197.41,71.12 ; D321.B7 248.92,89.61 ; D321.B7 248.21,88.9 ; D321.B7 249.63,88.9 ; D321.B7 248.92,88.19 ; D301.A6 320.04,87.07 ; D301.A6 319.33,86.36 ; D301.A6 320.75,86.36 ; D301.A6 320.04,85.65 ; D102.B9 328.47,78.74 ; D102.B9 326.85,78.74 ; D102.B9 327.66,77.93 ; D102.B9 327.66,79.55 ; 410.67,330.2 D109.B5 ; D109.B5 412.29,330.2 ; D109.B5 411.48,331.01 ; D109.B5 411.48,329.39 ; 398.78,392.89 D112.A10 ; D112.A10 397.97,393.7 ; D112.A10 398.78,394.51 ; D112.A10 399.59,393.7 ; 39.83,101.6 D125.B12 ; D125.B12 40.64,102.41 ; D125.B12 41.45,101.6 ; D125.B12 40.64,100.79 ; 393.7,367.49 D111.B12 ; D111.B12 392.89,368.3 ; D111.B12 394.51,368.3 ; D111.B12 393.7,369.11 ; 263.35,78.74 D122.B13 ; D122.B13 264.16,79.55 ; D122.B13 264.97,78.74 ; D122.B13 264.16,77.93 ; 481.65,228.55 UNK2U1.4 ; UNK2U1.4 482.59,229.49 ; UNK2U1.4 482.59,227.61 ; UNK2U1.4 483.53,228.55 ; 265.89,332.74 CSDPS225.B4 ; CSDPS225.B4 267.51,332.74 ; CSDPS225.B4 266.7,331.93 ; CSDPS225.B4 266.7,333.55 ; D130.B4 94.79,81.28 ; D130.B4 93.98,82.09 ; D130.B4 93.98,80.47 ; D130.B4 93.17,81.28 ; D112.A8 403.86,394.51 ; D112.A8 403.86,392.89 ; D112.A8 403.05,393.7 ; D112.A8 404.67,393.7 ; CSDPS425.C3 269.24,341.17 ; CSDPS425.C3 268.43,340.36 ; CSDPS425.C3 270.05,340.36 ; CSDPS425.C3 269.24,339.55 ; D109.A10 399.59,332.74 ; D109.A10 398.78,333.55 ; D109.A10 397.97,332.74 ; D109.A10 398.78,331.93 ; 24.59,81.28 D126.B6 ; D126.B6 26.21,81.28 ; D126.B6 25.4,80.47 ; D126.B6 25.4,82.09 ; CSDPS429.C13 170.99,340.36 ; CSDPS429.C13 170.18,339.55 ; CSDPS429.C13 170.18,341.17 ; CSDPS429.C13 169.37,340.36 ; D127.B16 50.8,61.77 ; D127.B16 51.61,60.96 ; D127.B16 49.99,60.96 ; D127.B16 50.8,60.15 ; 413.31,91.44 D305.B14 ; D305.B14 414.02,92.15 ; D305.B14 414.73,91.44 ; D305.B14 414.02,90.73 ; D128.A16 51.61,35.56 ; D128.A16 50.8,34.75 ; D128.A16 50.8,36.37 ; D128.A16 49.99,35.56 ; D127.B1 12.7,59.23 ; D127.B1 12.7,57.61 ; D127.B1 11.89,58.42 ; D127.B1 13.51,58.42 ; 47.45,73.66 D126.A15 ; D126.A15 49.07,73.66 ; D126.A15 48.26,72.85 ; D126.A15 48.26,74.47 ; 411.48,370.03 D111.B5 ; D111.B5 410.67,370.84 ; D111.B5 411.48,371.65 ; D111.B5 412.29,370.84 ; 237.95,33.02 D124.A3 ; D124.A3 238.76,33.83 ; D124.A3 239.57,33.02 ; D124.A3 238.76,32.21 ; 344.63,35.56 D104.A16 ; D104.A16 345.44,34.75 ; D104.A16 346.25,35.56 ; D104.A16 345.44,36.37 ; 345.44,367.49 D115.B2 ; D115.B2 345.44,369.11 ; D115.B2 344.63,368.3 ; D115.B2 346.25,368.3 ; 380.29,88.9 D305.B1 ; D305.B1 381,88.19 ; D305.B1 381,89.61 ; D305.B1 381.71,88.9 ; 118.57,55.88 D131.A14 ; D131.A14 120.19,55.88 ; D131.A14 119.38,55.07 ; D131.A14 119.38,56.69 ; 236.22,60.15 D123.B2 ; D123.B2 236.22,61.77 ; D123.B2 237.03,60.96 ; D123.B2 235.41,60.96 ; 408.13,373.38 D111.A6 ; D111.A6 409.75,373.38 ; D111.A6 408.94,374.19 ; D111.A6 408.94,372.57 ; 307.34,77.93 D102.B1 ; D102.B1 307.34,79.55 ; D102.B1 306.53,78.74 ; D102.B1 308.15,78.74 ; D305.A4 389.33,86.36 ; D305.A4 388.62,87.07 ; D305.A4 388.62,85.65 ; D305.A4 387.91,86.36 ; D104.A2 309.88,36.37 ; D104.A2 309.07,35.56 ; D104.A2 310.69,35.56 ; D104.A2 309.88,34.75 ; D109.A12 394.51,332.74 ; D109.A12 393.7,331.93 ; D109.A12 392.89,332.74 ; D109.A12 393.7,333.55 ; D111.A12 393.7,374.19 ; D111.A12 393.7,372.57 ; D111.A12 394.51,373.38 ; D111.A12 392.89,373.38 ; D302.A13 338.53,63.5 ; D302.A13 337.11,63.5 ; D302.A13 337.82,62.79 ; D302.A13 337.82,64.21 ; D108.A10 404.67,35.56 ; D108.A10 403.05,35.56 ; D108.A10 403.86,36.37 ; D108.A10 403.86,34.75 ; 271.78,331.93 CSDPS225.B2 ; CSDPS225.B2 271.78,333.55 ; CSDPS225.B2 270.97,332.74 ; CSDPS225.B2 272.59,332.74 ; 391.16,334.47 D109.A13 ; D109.A13 391.16,336.09 ; D109.A13 390.35,335.28 ; D109.A13 391.97,335.28 ; D321.B4 242.01,91.44 ; D321.B4 241.3,90.73 ; D321.B4 241.3,92.15 ; D321.B4 240.59,91.44 ; D124.B16 271.78,41.45 ; D124.B16 271.78,39.83 ; D124.B16 270.97,40.64 ; D124.B16 272.59,40.64 ; 324.31,81.28 D102.B8 ; D102.B8 325.12,80.47 ; D102.B8 325.93,81.28 ; D102.B8 325.12,82.09 ; CSDPS225.C1 274.32,331.01 ; CSDPS225.C1 275.13,330.2 ; CSDPS225.C1 274.32,329.39 ; CSDPS225.C1 273.51,330.2 ; D322.A7 248.92,64.21 ; D322.A7 248.92,62.79 ; D322.A7 249.63,63.5 ; D322.A7 248.21,63.5 ; D118.B7 175.26,79.55 ; D118.B7 176.07,78.74 ; D118.B7 175.26,77.93 ; D118.B7 174.45,78.74 ; 109.22,100.79 D129.B10 ; D129.B10 109.22,102.41 ; D129.B10 110.03,101.6 ; D129.B10 108.41,101.6 ; 95.71,73.66 D130.A5 ; D130.A5 97.33,73.66 ; D130.A5 96.52,74.47 ; D130.A5 96.52,72.85 ; 29.67,76.2 D126.A8 ; D126.A8 31.29,76.2 ; D126.A8 30.48,77.01 ; D126.A8 30.48,75.39 ; D126.B16 51.61,81.28 ; D126.B16 50.8,82.09 ; D126.B16 50.8,80.47 ; D126.B16 49.99,81.28 ; 253.19,78.74 D122.B9 ; D122.B9 254,79.55 ; D122.B9 254,77.93 ; D122.B9 254.81,78.74 ; 86.36,37.29 D132.B1 ; D132.B1 86.36,38.91 ; D132.B1 87.17,38.1 ; D132.B1 85.55,38.1 ; 393.7,34.75 D108.A6 ; D108.A6 393.7,36.37 ; D108.A6 394.51,35.56 ; D108.A6 392.89,35.56 ; 390.35,330.2 D109.B13 ; D109.B13 391.16,329.39 ; D109.B13 391.97,330.2 ; D109.B13 391.16,331.01 ; 240.49,76.2 D122.A4 ; D122.A4 242.11,76.2 ; D122.A4 241.3,77.01 ; D122.A4 241.3,75.39 ; 388.62,331.93 D109.A14 ; D109.A14 388.62,333.55 ; D109.A14 387.81,332.74 ; D109.A14 389.43,332.74 ; 20.32,75.39 D126.A4 ; D126.A4 19.51,76.2 ; D126.A4 20.32,77.01 ; D126.A4 21.13,76.2 ; D127.A6 26.21,55.88 ; D127.A6 24.59,55.88 ; D127.A6 25.4,56.69 ; D127.A6 25.4,55.07 ; 390.35,19.05 DPS1.C05 ; DPS1.C05 391.97,19.05 ; DPS1.C05 391.16,19.86 ; DPS1.C05 391.16,18.24 ; D114.A4 340.36,353.87 ; D114.A4 341.17,353.06 ; D114.A4 340.36,352.25 ; D114.A4 339.55,353.06 ; D115.B5 338.63,370.84 ; D115.B5 337.82,370.03 ; D115.B5 337.82,371.65 ; D115.B5 337.01,370.84 ; D111.A13 391.16,376.73 ; D111.A13 391.16,375.11 ; D111.A13 390.35,375.92 ; D111.A13 391.97,375.92 ; D130.A10 109.22,77.01 ; D130.A10 108.41,76.2 ; D130.A10 109.22,75.39 ; D130.A10 110.03,76.2 ; D301.A10 330.2,87.07 ; D301.A10 330.91,86.36 ; D301.A10 329.49,86.36 ; D301.A10 330.2,85.65 ; D125.B10 36.37,101.6 ; D125.B10 34.75,101.6 ; D125.B10 35.56,102.41 ; D125.B10 35.56,100.79 ; D127.A1 13.51,53.34 ; D127.A1 12.7,52.53 ; D127.A1 11.89,53.34 ; D127.A1 12.7,54.15 ; D231.B1 201.47,370.84 ; D231.B1 200.66,370.03 ; D231.B1 199.85,370.84 ; D231.B1 200.66,371.65 ; D118.B15 196.39,78.74 ; D118.B15 195.58,77.93 ; D118.B15 194.77,78.74 ; D118.B15 195.58,79.55 ; D116.A16 310.69,393.7 ; D116.A16 309.88,394.51 ; D116.A16 309.07,393.7 ; D116.A16 309.88,392.89 ; 398.78,55.07 D107.A8 ; D107.A8 398.78,56.69 ; D107.A8 399.59,55.88 ; D107.A8 397.97,55.88 ; D318.B6 172.72,71.83 ; D318.B6 172.72,70.41 ; D318.B6 173.43,71.12 ; D318.B6 172.01,71.12 ; 345.44,392.89 D116.A2 ; D116.A2 345.44,394.51 ; D116.A2 346.25,393.7 ; D116.A2 344.63,393.7 ; 184.61,58.42 D119.B11 ; D119.B11 185.42,57.61 ; D119.B11 185.42,59.23 ; D119.B11 186.23,58.42 ; 392.89,40.64 D108.B6 ; D108.B6 394.51,40.64 ; D108.B6 393.7,41.45 ; D108.B6 393.7,39.83 ; 345.44,55.07 D103.A16 ; D103.A16 346.25,55.88 ; D103.A16 345.44,56.69 ; D103.A16 344.63,55.88 ; 176.99,60.96 D119.B8 ; D119.B8 177.8,60.15 ; D119.B8 177.8,61.77 ; D119.B8 178.61,60.96 ; SITE4.G2 329.33,181.81 ; SITE4.G2 328.85,181.33 ; SITE4.G2 329.81,181.33 ; SITE4.G2 329.33,180.85 ; 161.75,332.74 CSDPS229.B16 ; CSDPS229.B16 162.56,333.55 ; CSDPS229.B16 162.56,331.93 ; CSDPS229.B16 163.37,332.74 ; 254,62.79 D322.A9 ; D322.A9 254,64.21 ; D322.A9 253.29,63.5 ; D322.A9 254.71,63.5 ; 240.49,342.9 CSDPS425.B14 ; CSDPS425.B14 241.3,343.71 ; CSDPS425.B14 241.3,342.09 ; CSDPS425.B14 242.11,342.9 ; 86.36,93.17 D129.A1 ; D129.A1 86.36,94.79 ; D129.A1 85.55,93.98 ; D129.A1 87.17,93.98 ; D125.B7 27.94,99.87 ; D125.B7 28.75,99.06 ; D125.B7 27.13,99.06 ; D125.B7 27.94,98.25 ; D306.B13 412.19,68.58 ; D306.B13 410.77,68.58 ; D306.B13 411.48,69.29 ; D306.B13 411.48,67.87 ; 415.75,58.42 D107.B15 ; D107.B15 417.37,58.42 ; D107.B15 416.56,59.23 ; D107.B15 416.56,57.61 ; 314.25,86.36 D301.A4 ; D301.A4 314.96,87.07 ; D301.A4 315.67,86.36 ; D301.A4 314.96,85.65 ; 236.22,65.33 D322.A2 ; D322.A2 236.93,66.04 ; D322.A2 235.51,66.04 ; D322.A2 236.22,66.75 ; D109.A8 404.67,332.74 ; D109.A8 403.86,331.93 ; D109.A8 403.86,333.55 ; D109.A8 403.05,332.74 ; 193.04,34.75 D120.A14 ; D120.A14 193.04,36.37 ; D120.A14 193.85,35.56 ; D120.A14 192.23,35.56 ; 121.11,99.06 D129.B15 ; D129.B15 121.92,98.25 ; D129.B15 121.92,99.87 ; D129.B15 122.73,99.06 ; 241.3,60.15 D123.B4 ; D123.B4 240.49,60.96 ; D123.B4 242.11,60.96 ; D123.B4 241.3,61.77 ; D116.B7 333.55,391.16 ; D116.B7 331.93,391.16 ; D116.B7 332.74,391.97 ; D116.B7 332.74,390.35 ; 177.8,372.57 D231.A10 ; D231.A10 178.61,373.38 ; D231.A10 176.99,373.38 ; D231.A10 177.8,374.19 ; 179.53,340.36 CSDPS429.C9 ; CSDPS429.C9 180.34,341.17 ; CSDPS429.C9 181.15,340.36 ; CSDPS429.C9 180.34,339.55 ; 170.18,370.03 D231.B13 ; D231.B13 170.18,371.65 ; D231.B13 169.37,370.84 ; D231.B13 170.99,370.84 ; 164.29,73.66 D118.A3 ; D118.A3 165.1,72.85 ; D118.A3 165.91,73.66 ; D118.A3 165.1,74.47 ; 118.57,76.2 D130.A14 ; D130.A14 119.38,77.01 ; D130.A14 119.38,75.39 ; D130.A14 120.19,76.2 ; 177.8,331.93 CSDPS229.B10 ; CSDPS229.B10 177.8,333.55 ; CSDPS229.B10 178.61,332.74 ; CSDPS229.B10 176.99,332.74 ; D231.B2 198.12,369.11 ; D231.B2 197.31,368.3 ; D231.B2 198.12,367.49 ; D231.B2 198.93,368.3 ; DPS2.C05 338.63,410.21 ; DPS2.C05 337.82,409.4 ; DPS2.C05 337.01,410.21 ; DPS2.C05 337.82,411.02 ; 198.12,65.33 D318.A16 ; D318.A16 198.83,66.04 ; D318.A16 197.41,66.04 ; D318.A16 198.12,66.75 ; D124.A14 266.7,36.37 ; D124.A14 267.51,35.56 ; D124.A14 265.89,35.56 ; D124.A14 266.7,34.75 ; D431.B17 160.02,381.81 ; D431.B17 160.83,381 ; D431.B17 160.02,380.19 ; D431.B17 159.21,381 ; SITE1.G4 251.81,241.33 ; SITE1.G4 251.33,241.81 ; SITE1.G4 251.33,240.85 ; SITE1.G4 250.85,241.33 ; CSDPS229.B12 173.53,332.74 ; CSDPS229.B12 172.72,331.93 ; CSDPS229.B12 172.72,333.55 ; CSDPS229.B12 171.91,332.74 ; D129.A4 93.98,97.33 ; D129.A4 93.98,95.71 ; D129.A4 94.79,96.52 ; D129.A4 93.17,96.52 ; D318.A3 165.1,64.21 ; D318.A3 165.1,62.79 ; D318.A3 165.81,63.5 ; D318.A3 164.39,63.5 ; 408.94,387.81 D112.B6 ; D112.B6 408.94,389.43 ; D112.B6 408.13,388.62 ; D112.B6 409.75,388.62 ; 400.51,78.74 D106.B9 ; D106.B9 401.32,79.55 ; D106.B9 402.13,78.74 ; D106.B9 401.32,77.93 ; D107.B1 381.81,58.42 ; D107.B1 381,57.61 ; D107.B1 380.19,58.42 ; D107.B1 381,59.23 ; 337.82,349.71 D114.B5 ; D114.B5 337.01,350.52 ; D114.B5 337.82,351.33 ; D114.B5 338.63,350.52 ; 248.92,77.93 D122.B7 ; D122.B7 248.92,79.55 ; D122.B7 248.11,78.74 ; D122.B7 249.73,78.74 ; 98.25,96.52 D129.A6 ; D129.A6 99.06,97.33 ; D129.A6 99.06,95.71 ; D129.A6 99.87,96.52 ; 27.13,78.74 D126.B7 ; D126.B7 28.75,78.74 ; D126.B7 27.94,77.93 ; D126.B7 27.94,79.55 ; 392.89,81.28 D106.B6 ; D106.B6 394.51,81.28 ; D106.B6 393.7,82.09 ; D106.B6 393.7,80.47 ; D108.A13 411.48,33.83 ; D108.A13 410.67,33.02 ; D108.A13 411.48,32.21 ; D108.A13 412.29,33.02 ; 38.1,77.93 D126.B11 ; D126.B11 37.29,78.74 ; D126.B11 38.1,79.55 ; D126.B11 38.91,78.74 ; D431.A16 162.56,384.35 ; D431.A16 161.75,383.54 ; D431.A16 163.37,383.54 ; D431.A16 162.56,382.73 ; 415.75,330.2 D109.B3 ; D109.B3 417.37,330.2 ; D109.B3 416.56,329.39 ; D109.B3 416.56,331.01 ; D113.B5 338.63,330.2 ; D113.B5 337.82,329.39 ; D113.B5 337.82,331.01 ; D113.B5 337.01,330.2 ; D116.B9 328.47,391.16 ; D116.B9 327.66,390.35 ; D116.B9 326.85,391.16 ; D116.B9 327.66,391.97 ; 264.16,57.61 D123.B13 ; D123.B13 264.16,59.23 ; D123.B13 264.97,58.42 ; D123.B13 263.35,58.42 ; D110.B16 383.54,348.79 ; D110.B16 383.54,347.17 ; D110.B16 384.35,347.98 ; D110.B16 382.73,347.98 ; D114.B6 336.09,347.98 ; D114.B6 334.47,347.98 ; D114.B6 335.28,347.17 ; D114.B6 335.28,348.79 ; 321.77,330.2 D113.B11 ; D113.B11 322.58,329.39 ; D113.B11 322.58,331.01 ; D113.B11 323.39,330.2 ; 124.46,39.83 D132.B16 ; D132.B16 124.46,41.45 ; D132.B16 125.27,40.64 ; D132.B16 123.65,40.64 ; 330.2,392.89 D116.A8 ; D116.A8 330.2,394.51 ; D116.A8 331.01,393.7 ; D116.A8 329.39,393.7 ; 258.27,13.97 DPS3.A11 ; DPS3.A11 259.08,13.16 ; DPS3.A11 259.89,13.97 ; DPS3.A11 259.08,14.78 ; SITE2.G16 332.63,243.31 ; SITE2.G16 332.15,242.83 ; SITE2.G16 332.63,242.35 ; SITE2.G16 333.11,242.83 ; D124.B6 247.19,40.64 ; D124.B6 245.57,40.64 ; D124.B6 246.38,39.83 ; D124.B6 246.38,41.45 ; D306.A8 398.78,66.75 ; D306.A8 398.07,66.04 ; D306.A8 399.49,66.04 ; D306.A8 398.78,65.33 ; 160.02,67.87 D318.B1 ; D318.B1 160.73,68.58 ; D318.B1 160.02,69.29 ; D318.B1 159.31,68.58 ; D306.A7 396.95,63.5 ; D306.A7 396.24,64.21 ; D306.A7 396.24,62.79 ; D306.A7 395.53,63.5 ; D301.A3 313.13,83.82 ; D301.A3 311.71,83.82 ; D301.A3 312.42,84.53 ; D301.A3 312.42,83.11 ; D107.B12 409.75,60.96 ; D107.B12 408.94,60.15 ; D107.B12 408.13,60.96 ; D107.B12 408.94,61.77 ; CSDPS229.C9 181.15,330.2 ; CSDPS229.C9 179.53,330.2 ; CSDPS229.C9 180.34,331.01 ; CSDPS229.C9 180.34,329.39 ; 39.83,40.64 D128.B12 ; D128.B12 41.45,40.64 ; D128.B12 40.64,39.83 ; D128.B12 40.64,41.45 ; D103.B9 328.47,58.42 ; D103.B9 326.85,58.42 ; D103.B9 327.66,59.23 ; D103.B9 327.66,57.61 ; 260.91,66.04 D322.A12 ; D322.A12 262.33,66.04 ; D322.A12 261.62,65.33 ; D322.A12 261.62,66.75 ; 232.87,33.02 D124.A1 ; D124.A1 233.68,33.83 ; D124.A1 234.49,33.02 ; D124.A1 233.68,32.21 ; D112.A3 416.56,397.05 ; D112.A3 417.37,396.24 ; D112.A3 416.56,395.43 ; D112.A3 415.75,396.24 ; D318.A7 175.26,64.21 ; D318.A7 175.26,62.79 ; D318.A7 175.97,63.5 ; D318.A7 174.55,63.5 ; D318.A8 178.51,66.04 ; D318.A8 177.09,66.04 ; D318.A8 177.8,65.33 ; D318.A8 177.8,66.75 ; D130.A2 88.9,77.01 ; D130.A2 88.9,75.39 ; D130.A2 88.09,76.2 ; D130.A2 89.71,76.2 ; D231.B3 195.58,371.65 ; D231.B3 195.58,370.03 ; D231.B3 196.39,370.84 ; D231.B3 194.77,370.84 ; 314.15,388.62 D116.B14 ; D116.B14 314.96,389.43 ; D116.B14 314.96,387.81 ; D116.B14 315.77,388.62 ; D114.B8 330.2,348.79 ; D114.B8 330.2,347.17 ; D114.B8 331.01,347.98 ; D114.B8 329.39,347.98 ; 198.12,55.07 D119.A16 ; D119.A16 198.12,56.69 ; D119.A16 197.31,55.88 ; D119.A16 198.93,55.88 ; 326.85,73.66 D102.A9 ; D102.A9 327.66,74.47 ; D102.A9 328.47,73.66 ; D102.A9 327.66,72.85 ; 320.04,75.39 D102.A6 ; D102.A6 320.85,76.2 ; D102.A6 319.23,76.2 ; D102.A6 320.04,77.01 ; D125.A13 43.18,94.79 ; D125.A13 42.37,93.98 ; D125.A13 43.99,93.98 ; D125.A13 43.18,93.17 ; D116.B5 337.82,391.97 ; D116.B5 338.63,391.16 ; D116.B5 337.01,391.16 ; D116.B5 337.82,390.35 ; D305.B4 388.62,92.15 ; D305.B4 388.62,90.73 ; D305.B4 389.33,91.44 ; D305.B4 387.91,91.44 ; 340.36,39.83 D104.B14 ; D104.B14 340.36,41.45 ; D104.B14 339.55,40.64 ; D104.B14 341.17,40.64 ; 260.91,71.12 D322.B12 ; D322.B12 261.62,71.83 ; D322.B12 262.33,71.12 ; D322.B12 261.62,70.41 ; 182.17,66.04 D318.A10 ; D318.A10 182.88,65.33 ; D318.A10 182.88,66.75 ; D318.A10 183.59,66.04 ; D131.B14 120.19,60.96 ; D131.B14 118.57,60.96 ; D131.B14 119.38,60.15 ; D131.B14 119.38,61.77 ; SITE1.G1 248.33,241.81 ; SITE1.G1 248.81,241.33 ; SITE1.G1 247.85,241.33 ; SITE1.G1 248.33,240.85 ; D122.A10 257.35,76.2 ; D122.A10 256.54,75.39 ; D122.A10 255.73,76.2 ; D122.A10 256.54,77.01 ; D302.B15 342.9,69.29 ; D302.B15 342.9,67.87 ; D302.B15 342.19,68.58 ; D302.B15 343.61,68.58 ; 47.45,78.74 D126.B15 ; D126.B15 48.26,77.93 ; D126.B15 48.26,79.55 ; D126.B15 49.07,78.74 ; 49.99,101.6 D125.B16 ; D125.B16 51.61,101.6 ; D125.B16 50.8,100.79 ; D125.B16 50.8,102.41 ; 35.56,39.83 D128.B10 ; D128.B10 34.75,40.64 ; D128.B10 35.56,41.45 ; D128.B10 36.37,40.64 ; D302.A12 335.28,66.75 ; D302.A12 335.28,65.33 ; D302.A12 334.57,66.04 ; D302.A12 335.99,66.04 ; 268.53,83.82 D321.A15 ; D321.A15 269.24,83.11 ; D321.A15 269.95,83.82 ; D321.A15 269.24,84.53 ; 261.62,55.07 D123.A12 ; D123.A12 262.43,55.88 ; D123.A12 260.81,55.88 ; D123.A12 261.62,56.69 ; 187.96,367.49 D231.B6 ; D231.B6 187.96,369.11 ; D231.B6 187.15,368.3 ; D231.B6 188.77,368.3 ; 316.69,78.74 D102.B5 ; D102.B5 317.5,77.93 ; D102.B5 317.5,79.55 ; D102.B5 318.31,78.74 ; 331.93,73.66 D102.A11 ; D102.A11 333.55,73.66 ; D102.A11 332.74,72.85 ; D102.A11 332.74,74.47 ; D127.B11 38.91,58.42 ; D127.B11 38.1,57.61 ; D127.B11 37.29,58.42 ; D127.B11 38.1,59.23 ; 337.01,58.42 D103.B13 ; D103.B13 337.82,59.23 ; D103.B13 338.63,58.42 ; D103.B13 337.82,57.61 ; D321.A13 264.87,83.82 ; D321.A13 263.45,83.82 ; D321.A13 264.16,83.11 ; D321.A13 264.16,84.53 ; 104.14,39.83 D132.B8 ; D132.B8 104.14,41.45 ; D132.B8 103.33,40.64 ; D132.B8 104.95,40.64 ; D122.A3 239.57,73.66 ; D122.A3 238.76,72.85 ; D122.A3 237.95,73.66 ; D122.A3 238.76,74.47 ; 172.01,86.36 D317.A6 ; D317.A6 172.72,87.07 ; D317.A6 173.43,86.36 ; D317.A6 172.72,85.65 ; 113.49,40.64 D132.B12 ; D132.B12 114.3,39.83 ; D132.B12 114.3,41.45 ; D132.B12 115.11,40.64 ; 248.33,187.45 SITE3.G7 ; SITE3.G7 248.81,187.93 ; SITE3.G7 248.33,188.41 ; SITE3.G7 247.85,187.93 ; D132.A13 116.84,33.83 ; D132.A13 116.03,33.02 ; D132.A13 116.84,32.21 ; D132.A13 117.65,33.02 ; D231.B11 176.07,370.84 ; D231.B11 175.26,371.65 ; D231.B11 175.26,370.03 ; D231.B11 174.45,370.84 ; 99.06,80.47 D130.B6 ; D130.B6 99.06,82.09 ; D130.B6 99.87,81.28 ; D130.B6 98.25,81.28 ; D106.B10 403.86,82.09 ; D106.B10 404.67,81.28 ; D106.B10 403.86,80.47 ; D106.B10 403.05,81.28 ; D115.B10 325.12,369.11 ; D115.B10 324.31,368.3 ; D115.B10 325.93,368.3 ; D115.B10 325.12,367.49 ; 40.64,95.71 D125.A12 ; D125.A12 40.64,97.33 ; D125.A12 39.83,96.52 ; D125.A12 41.45,96.52 ; 164.29,415.29 DPS8.A15 ; DPS8.A15 165.1,416.1 ; DPS8.A15 165.1,414.48 ; DPS8.A15 165.91,415.29 ; 20.32,34.75 D128.A4 ; D128.A4 19.51,35.56 ; D128.A4 20.32,36.37 ; D128.A4 21.13,35.56 ; D103.A3 313.23,53.34 ; D103.A3 312.42,54.15 ; D103.A3 311.61,53.34 ; D103.A3 312.42,52.53 ; 160.02,52.53 D119.A1 ; D119.A1 159.21,53.34 ; D119.A1 160.83,53.34 ; D119.A1 160.02,54.15 ; SITE2.G11 332.81,247.93 ; SITE2.G11 331.85,247.93 ; SITE2.G11 332.33,248.41 ; SITE2.G11 332.33,247.45 ; 306.53,58.42 D103.B1 ; D103.B1 307.34,57.61 ; D103.B1 307.34,59.23 ; D103.B1 308.15,58.42 ; 177.09,71.12 D318.B8 ; D318.B8 177.8,70.41 ; D318.B8 177.8,71.83 ; D318.B8 178.51,71.12 ; 44.91,55.88 D127.A14 ; D127.A14 45.72,55.07 ; D127.A14 46.53,55.88 ; D127.A14 45.72,56.69 ; D109.B6 408.94,328.47 ; D109.B6 408.94,326.85 ; D109.B6 408.13,327.66 ; D109.B6 409.75,327.66 ; 14.43,40.64 D128.B2 ; D128.B2 15.24,41.45 ; D128.B2 16.05,40.64 ; D128.B2 15.24,39.83 ; D102.A3 312.42,74.47 ; D102.A3 313.23,73.66 ; D102.A3 311.61,73.66 ; D102.A3 312.42,72.85 ; D130.A6 99.06,77.01 ; D130.A6 99.06,75.39 ; D130.A6 98.25,76.2 ; D130.A6 99.87,76.2 ; 416.56,354.79 D110.A3 ; D110.A3 417.37,355.6 ; D110.A3 416.56,356.41 ; D110.A3 415.75,355.6 ; SITE4.G6 333.33,181.81 ; SITE4.G6 333.81,181.33 ; SITE4.G6 333.33,180.85 ; SITE4.G6 332.85,181.33 ; 22.86,37.29 D128.B5 ; D128.B5 22.05,38.1 ; D128.B5 23.67,38.1 ; D128.B5 22.86,38.91 ; D128.B15 48.26,38.91 ; D128.B15 48.26,37.29 ; D128.B15 49.07,38.1 ; D128.B15 47.45,38.1 ; 332.03,63.5 D302.A11 ; D302.A11 332.74,62.79 ; D302.A11 333.45,63.5 ; D302.A11 332.74,64.21 ; D318.A12 188.67,66.04 ; D318.A12 187.96,66.75 ; D318.A12 187.96,65.33 ; D318.A12 187.25,66.04 ; D128.A13 43.99,33.02 ; D128.A13 43.18,33.83 ; D128.A13 42.37,33.02 ; D128.A13 43.18,32.21 ; D305.A1 381.71,83.82 ; D305.A1 381,83.11 ; D305.A1 381,84.53 ; D305.A1 380.29,83.82 ; 111.76,72.85 D130.A11 ; D130.A11 112.57,73.66 ; D130.A11 111.76,74.47 ; D130.A11 110.95,73.66 ; 232.97,63.5 D322.A1 ; D322.A1 233.68,62.79 ; D322.A1 233.68,64.21 ; D322.A1 234.39,63.5 ; 328.33,180.85 SITE4.G1 ; SITE4.G1 328.33,181.81 ; SITE4.G1 327.85,181.33 ; SITE4.G1 328.81,181.33 ; D431.A7 185.42,386.89 ; D431.A7 184.61,386.08 ; D431.A7 186.23,386.08 ; D431.A7 185.42,385.27 ; 187.96,80.47 D118.B12 ; D118.B12 187.96,82.09 ; D118.B12 188.77,81.28 ; D118.B12 187.15,81.28 ; 109.22,34.75 D132.A10 ; D132.A10 110.03,35.56 ; D132.A10 108.41,35.56 ; D132.A10 109.22,36.37 ; D321.A4 241.3,87.07 ; D321.A4 242.01,86.36 ; D321.A4 241.3,85.65 ; D321.A4 240.59,86.36 ; D110.B7 407.21,350.52 ; D110.B7 405.59,350.52 ; D110.B7 406.4,351.33 ; D110.B7 406.4,349.71 ; D321.B13 264.87,88.9 ; D321.B13 264.16,88.19 ; D321.B13 264.16,89.61 ; D321.B13 263.45,88.9 ; D127.A3 18.59,53.34 ; D127.A3 16.97,53.34 ; D127.A3 17.78,52.53 ; D127.A3 17.78,54.15 ; D131.B1 86.36,59.23 ; D131.B1 87.17,58.42 ; D131.B1 86.36,57.61 ; D131.B1 85.55,58.42 ; D127.B9 33.02,59.23 ; D127.B9 32.21,58.42 ; D127.B9 33.02,57.61 ; D127.B9 33.83,58.42 ; 334.47,60.96 D103.B12 ; D103.B12 335.28,61.77 ; D103.B12 336.09,60.96 ; D103.B12 335.28,60.15 ; D114.A13 317.5,356.41 ; D114.A13 316.69,355.6 ; D114.A13 317.5,354.79 ; D114.A13 318.31,355.6 ; D125.A16 51.61,96.52 ; D125.A16 50.8,97.33 ; D125.A16 50.8,95.71 ; D125.A16 49.99,96.52 ; 331.93,33.02 D104.A11 ; D104.A11 332.74,33.83 ; D104.A11 333.55,33.02 ; D104.A11 332.74,32.21 ; 261.62,85.65 D321.A12 ; D321.A12 260.91,86.36 ; D321.A12 262.33,86.36 ; D321.A12 261.62,87.07 ; D122.A11 259.08,74.47 ; D122.A11 259.08,72.85 ; D122.A11 258.27,73.66 ; D122.A11 259.89,73.66 ; SITE2.G10 331.33,248.41 ; SITE2.G10 331.33,247.45 ; SITE2.G10 330.85,247.93 ; SITE2.G10 331.81,247.93 ; SITE2.G19 331.43,246.91 ; SITE2.G19 331.91,246.43 ; SITE2.G19 331.43,245.95 ; SITE2.G19 330.95,246.43 ; 172.72,372.57 D231.A12 ; D231.A12 172.72,374.19 ; D231.A12 171.91,373.38 ; D231.A12 173.53,373.38 ; 335.28,85.65 D301.A12 ; D301.A12 334.57,86.36 ; D301.A12 335.99,86.36 ; D301.A12 335.28,87.07 ; 328.85,241.33 SITE2.G2 ; SITE2.G2 329.81,241.33 ; SITE2.G2 329.33,241.81 ; SITE2.G2 329.33,240.85 ; 386.08,88.19 D305.B3 ; D305.B3 386.08,89.61 ; D305.B3 385.37,88.9 ; D305.B3 386.79,88.9 ; DPS2.A01 348.79,415.29 ; DPS2.A01 347.17,415.29 ; DPS2.A01 347.98,416.1 ; DPS2.A01 347.98,414.48 ; 177.8,342.09 CSDPS429.B10 ; CSDPS429.B10 176.99,342.9 ; CSDPS429.B10 178.61,342.9 ; CSDPS429.B10 177.8,343.71 ; CSDPS429.B16 163.37,342.9 ; CSDPS429.B16 161.75,342.9 ; CSDPS429.B16 162.56,343.71 ; CSDPS429.B16 162.56,342.09 ; 48.26,93.17 D125.A15 ; D125.A15 48.26,94.79 ; D125.A15 47.45,93.98 ; D125.A15 49.07,93.98 ; D131.A13 117.65,53.34 ; D131.A13 116.84,54.15 ; D131.A13 116.84,52.53 ; D131.A13 116.03,53.34 ; D108.A11 407.21,33.02 ; D108.A11 405.59,33.02 ; D108.A11 406.4,32.21 ; D108.A11 406.4,33.83 ; D127.B2 16.05,60.96 ; D127.B2 15.24,61.77 ; D127.B2 14.43,60.96 ; D127.B2 15.24,60.15 ; D321.A8 251.46,87.07 ; D321.A8 250.75,86.36 ; D321.A8 252.17,86.36 ; D321.A8 251.46,85.65 ; D118.A16 198.12,77.01 ; D118.A16 197.31,76.2 ; D118.A16 198.12,75.39 ; D118.A16 198.93,76.2 ; 414.02,39.83 D108.B14 ; D108.B14 413.21,40.64 ; D108.B14 414.83,40.64 ; D108.B14 414.02,41.45 ; D132.A4 94.79,35.56 ; D132.A4 93.98,34.75 ; D132.A4 93.98,36.37 ; D132.A4 93.17,35.56 ; 320.04,39.83 D104.B6 ; D104.B6 319.23,40.64 ; D104.B6 320.85,40.64 ; D104.B6 320.04,41.45 ; 388.62,75.39 D106.A4 ; D106.A4 389.43,76.2 ; D106.A4 387.81,76.2 ; D106.A4 388.62,77.01 ; 93.17,40.64 D132.B4 ; D132.B4 93.98,41.45 ; D132.B4 93.98,39.83 ; D132.B4 94.79,40.64 ; 194.77,53.34 D119.A15 ; D119.A15 195.58,54.15 ; D119.A15 196.39,53.34 ; D119.A15 195.58,52.53 ; D132.A2 88.9,36.37 ; D132.A2 88.9,34.75 ; D132.A2 88.09,35.56 ; D132.A2 89.71,35.56 ; 327.66,88.19 D301.B9 ; D301.B9 328.37,88.9 ; D301.B9 327.66,89.61 ; D301.B9 326.95,88.9 ; SITE3.G19 251.43,186.91 ; SITE3.G19 250.95,186.43 ; SITE3.G19 251.43,185.95 ; SITE3.G19 251.91,186.43 ; D321.B3 239.47,88.9 ; D321.B3 238.05,88.9 ; D321.B3 238.76,89.61 ; D321.B3 238.76,88.19 ; DPS8.A01 200.66,416.1 ; DPS8.A01 200.66,414.48 ; DPS8.A01 201.47,415.29 ; DPS8.A01 199.85,415.29 ; D103.A4 314.96,56.69 ; D103.A4 314.15,55.88 ; D103.A4 314.96,55.07 ; D103.A4 315.77,55.88 ; D116.A15 313.23,396.24 ; D116.A15 312.42,395.43 ; D116.A15 311.61,396.24 ; D116.A15 312.42,397.05 ; D306.B14 414.02,71.83 ; D306.B14 414.73,71.12 ; D306.B14 413.31,71.12 ; D306.B14 414.02,70.41 ; D103.A9 327.66,54.15 ; D103.A9 328.47,53.34 ; D103.A9 326.85,53.34 ; D103.A9 327.66,52.53 ; SITE1.G20 252.63,246.91 ; SITE1.G20 253.11,246.43 ; SITE1.G20 252.63,245.95 ; SITE1.G20 252.15,246.43 ; 197.31,60.96 D119.B16 ; D119.B16 198.12,61.77 ; D119.B16 198.93,60.96 ; D119.B16 198.12,60.15 ; 398.07,86.36 D305.A8 ; D305.A8 399.49,86.36 ; D305.A8 398.78,85.65 ; D305.A8 398.78,87.07 ; D431.A9 180.34,386.89 ; D431.A9 180.34,385.27 ; D431.A9 179.53,386.08 ; D431.A9 181.15,386.08 ; 251.46,65.33 D322.A8 ; D322.A8 251.46,66.75 ; D322.A8 252.17,66.04 ; D322.A8 250.75,66.04 ; 33.02,72.85 D126.A9 ; D126.A9 33.83,73.66 ; D126.A9 33.02,74.47 ; D126.A9 32.21,73.66 ; 317.5,390.35 D116.B13 ; D116.B13 316.69,391.16 ; D116.B13 317.5,391.97 ; D116.B13 318.31,391.16 ; 40.64,55.07 D127.A12 ; D127.A12 40.64,56.69 ; D127.A12 41.45,55.88 ; D127.A12 39.83,55.88 ; 162.56,377.65 D431.B16 ; D431.B16 162.56,379.27 ; D431.B16 163.37,378.46 ; D431.B16 161.75,378.46 ; 393.7,387.81 D112.B12 ; D112.B12 393.7,389.43 ; D112.B12 392.89,388.62 ; D112.B12 394.51,388.62 ; 396.24,57.61 D107.B7 ; D107.B7 395.43,58.42 ; D107.B7 397.05,58.42 ; D107.B7 396.24,59.23 ; CSDPS425.C13 243.84,341.17 ; CSDPS425.C13 243.84,339.55 ; CSDPS425.C13 243.03,340.36 ; CSDPS425.C13 244.65,340.36 ; D107.B5 391.16,59.23 ; D107.B5 390.35,58.42 ; D107.B5 391.16,57.61 ; D107.B5 391.97,58.42 ; D128.A1 13.51,33.02 ; D128.A1 12.7,33.83 ; D128.A1 11.89,33.02 ; D128.A1 12.7,32.21 ; D124.A9 254.81,33.02 ; D124.A9 253.19,33.02 ; D124.A9 254,32.21 ; D124.A9 254,33.83 ; 309.88,55.07 D103.A2 ; D103.A2 310.69,55.88 ; D103.A2 309.88,56.69 ; D103.A2 309.07,55.88 ; D128.A10 36.37,35.56 ; D128.A10 35.56,34.75 ; D128.A10 35.56,36.37 ; D128.A10 34.75,35.56 ; 187.15,342.9 CSDPS429.B6 ; CSDPS429.B6 187.96,342.09 ; CSDPS429.B6 188.77,342.9 ; CSDPS429.B6 187.96,343.71 ; D231.B9 181.15,370.84 ; D231.B9 180.34,370.03 ; D231.B9 180.34,371.65 ; D231.B9 179.53,370.84 ; D119.B5 170.18,59.23 ; D119.B5 169.37,58.42 ; D119.B5 170.99,58.42 ; D119.B5 170.18,57.61 ; 172.72,60.15 D119.B6 ; D119.B6 173.53,60.96 ; D119.B6 171.91,60.96 ; D119.B6 172.72,61.77 ; D115.B16 309.88,369.11 ; D115.B16 309.07,368.3 ; D115.B16 310.69,368.3 ; D115.B16 309.88,367.49 ; 182.88,70.41 D318.B10 ; D318.B10 182.88,71.83 ; D318.B10 182.17,71.12 ; D318.B10 183.59,71.12 ; 38.1,98.25 D125.B11 ; D125.B11 38.91,99.06 ; D125.B11 37.29,99.06 ; D125.B11 38.1,99.87 ; D431.B4 193.04,379.27 ; D431.B4 193.85,378.46 ; D431.B4 192.23,378.46 ; D431.B4 193.04,377.65 ; 124.46,100.79 D129.B16 ; D129.B16 125.27,101.6 ; D129.B16 123.65,101.6 ; D129.B16 124.46,102.41 ; D124.B9 254.81,38.1 ; D124.B9 254,37.29 ; D124.B9 253.19,38.1 ; D124.B9 254,38.91 ; D114.A5 337.82,356.41 ; D114.A5 337.01,355.6 ; D114.A5 338.63,355.6 ; D114.A5 337.82,354.79 ; D110.A12 393.7,353.87 ; D110.A12 393.7,352.25 ; D110.A12 394.51,353.06 ; D110.A12 392.89,353.06 ; 309.88,331.93 D113.A16 ; D113.A16 309.07,332.74 ; D113.A16 310.69,332.74 ; D113.A16 309.88,333.55 ; 383.54,34.75 D108.A2 ; D108.A2 383.54,36.37 ; D108.A2 384.35,35.56 ; D108.A2 382.73,35.56 ; D123.A15 270.05,53.34 ; D123.A15 268.43,53.34 ; D123.A15 269.24,52.53 ; D123.A15 269.24,54.15 ; D129.A9 107.49,93.98 ; D129.A9 106.68,93.17 ; D129.A9 106.68,94.79 ; D129.A9 105.87,93.98 ; D114.B14 315.77,347.98 ; D114.B14 314.96,347.17 ; D114.B14 314.96,348.79 ; D114.B14 314.15,347.98 ; 27.13,38.1 D128.B7 ; D128.B7 28.75,38.1 ; D128.B7 27.94,38.91 ; D128.B7 27.94,37.29 ; 167.64,367.49 D231.B14 ; D231.B14 168.45,368.3 ; D231.B14 167.64,369.11 ; D231.B14 166.83,368.3 ; 340.36,387.81 D116.B4 ; D116.B4 340.36,389.43 ; D116.B4 341.17,388.62 ; D116.B4 339.55,388.62 ; D106.A15 416.56,74.47 ; D106.A15 417.37,73.66 ; D106.A15 416.56,72.85 ; D106.A15 415.75,73.66 ; 322.58,32.21 D104.A7 ; D104.A7 322.58,33.83 ; D104.A7 323.39,33.02 ; D104.A7 321.77,33.02 ; 418.29,76.2 D106.A16 ; D106.A16 419.91,76.2 ; D106.A16 419.1,75.39 ; D106.A16 419.1,77.01 ; 164.29,58.42 D119.B3 ; D119.B3 165.91,58.42 ; D119.B3 165.1,57.61 ; D119.B3 165.1,59.23 ; 410.77,88.9 D305.B13 ; D305.B13 411.48,88.19 ; D305.B13 411.48,89.61 ; D305.B13 412.19,88.9 ; SITE1.G12 253.33,248.41 ; SITE1.G12 253.33,247.45 ; SITE1.G12 252.85,247.93 ; SITE1.G12 253.81,247.93 ; S1_I2C.4 70.61,209.98 ; S1_I2C.4 69.67,209.04 ; S1_I2C.4 70.61,208.1 ; S1_I2C.4 71.55,209.04 ; D124.A4 242.11,35.56 ; D124.A4 241.3,36.37 ; D124.A4 240.49,35.56 ; D124.A4 241.3,34.75 ; D322.A3 238.76,64.21 ; D322.A3 238.05,63.5 ; D322.A3 238.76,62.79 ; D322.A3 239.47,63.5 ; D322.B14 266.7,71.83 ; D322.B14 266.7,70.41 ; D322.B14 267.41,71.12 ; D322.B14 265.99,71.12 ; D113.B15 313.23,330.2 ; D113.B15 312.42,329.39 ; D113.B15 311.61,330.2 ; D113.B15 312.42,331.01 ; 263.35,340.36 CSDPS425.C5 ; CSDPS425.C5 264.16,341.17 ; CSDPS425.C5 264.97,340.36 ; CSDPS425.C5 264.16,339.55 ; D104.B4 315.77,40.64 ; D104.B4 314.96,41.45 ; D104.B4 314.96,39.83 ; D104.B4 314.15,40.64 ; D305.B15 417.27,88.9 ; D305.B15 415.85,88.9 ; D305.B15 416.56,89.61 ; D305.B15 416.56,88.19 ; SITE2.G17 329.51,246.43 ; SITE2.G17 329.03,246.91 ; SITE2.G17 329.03,245.95 ; SITE2.G17 328.55,246.43 ; D108.B10 403.86,41.45 ; D108.B10 404.67,40.64 ; D108.B10 403.05,40.64 ; D108.B10 403.86,39.83 ; D102.A1 308.15,73.66 ; D102.A1 307.34,72.85 ; D102.A1 307.34,74.47 ; D102.A1 306.53,73.66 ; D127.B12 40.64,61.77 ; D127.B12 40.64,60.15 ; D127.B12 39.83,60.96 ; D127.B12 41.45,60.96 ; 17.78,57.61 D127.B3 ; D127.B3 17.78,59.23 ; D127.B3 18.59,58.42 ; D127.B3 16.97,58.42 ; D102.B11 332.74,79.55 ; D102.B11 332.74,77.93 ; D102.B11 333.55,78.74 ; D102.B11 331.93,78.74 ; D120.B3 165.91,38.1 ; D120.B3 165.1,37.29 ; D120.B3 164.29,38.1 ; D120.B3 165.1,38.91 ; D103.A8 325.93,55.88 ; D103.A8 325.12,55.07 ; D103.A8 324.31,55.88 ; D103.A8 325.12,56.69 ; D128.A12 41.45,35.56 ; D128.A12 39.83,35.56 ; D128.A12 40.64,34.75 ; D128.A12 40.64,36.37 ; D317.B2 162.56,92.15 ; D317.B2 162.56,90.73 ; D317.B2 161.85,91.44 ; D317.B2 163.27,91.44 ; D130.B3 92.25,78.74 ; D130.B3 90.63,78.74 ; D130.B3 91.44,77.93 ; D130.B3 91.44,79.55 ; D302.A10 330.91,66.04 ; D302.A10 329.49,66.04 ; D302.A10 330.2,66.75 ; D302.A10 330.2,65.33 ; D126.A3 18.59,73.66 ; D126.A3 16.97,73.66 ; D126.A3 17.78,74.47 ; D126.A3 17.78,72.85 ; 344.73,86.36 D301.A16 ; D301.A16 345.44,87.07 ; D301.A16 345.44,85.65 ; D301.A16 346.15,86.36 ; 406.4,334.47 D109.A7 ; D109.A7 405.59,335.28 ; D109.A7 407.21,335.28 ; D109.A7 406.4,336.09 ; SITE1.G13 249.51,242.83 ; SITE1.G13 248.55,242.83 ; SITE1.G13 249.03,243.31 ; SITE1.G13 249.03,242.35 ; 331.85,187.93 SITE4.G11 ; SITE4.G11 332.81,187.93 ; SITE4.G11 332.33,187.45 ; SITE4.G11 332.33,188.41 ; 419.1,34.75 D108.A16 ; D108.A16 419.1,36.37 ; D108.A16 419.91,35.56 ; D108.A16 418.29,35.56 ; D123.B5 244.65,58.42 ; D123.B5 243.03,58.42 ; D123.B5 243.84,57.61 ; D123.B5 243.84,59.23 ; 30.48,80.47 D126.B8 ; D126.B8 29.67,81.28 ; D126.B8 31.29,81.28 ; D126.B8 30.48,82.09 ; 179.63,88.9 D317.B9 ; D317.B9 180.34,89.61 ; D317.B9 181.05,88.9 ; D317.B9 180.34,88.19 ; D301.B2 310.59,91.44 ; D301.B2 309.17,91.44 ; D301.B2 309.88,92.15 ; D301.B2 309.88,90.73 ; D113.B9 327.66,331.01 ; D113.B9 327.66,329.39 ; D113.B9 326.85,330.2 ; D113.B9 328.47,330.2 ; D302.A9 328.37,63.5 ; D302.A9 327.66,62.79 ; D302.A9 326.95,63.5 ; D302.A9 327.66,64.21 ; 411.48,390.35 D112.B5 ; D112.B5 412.29,391.16 ; D112.B5 410.67,391.16 ; D112.B5 411.48,391.97 ; D110.B1 422.45,350.52 ; D110.B1 421.64,351.33 ; D110.B1 420.83,350.52 ; D110.B1 421.64,349.71 ; 255.73,40.64 D124.B10 ; D124.B10 257.35,40.64 ; D124.B10 256.54,39.83 ; D124.B10 256.54,41.45 ; 252.33,240.85 SITE1.G5 ; SITE1.G5 251.85,241.33 ; SITE1.G5 252.33,241.81 ; SITE1.G5 252.81,241.33 ; D115.A6 335.28,374.19 ; D115.A6 335.28,372.57 ; D115.A6 336.09,373.38 ; D115.A6 334.47,373.38 ; 249.33,180.85 SITE3.G2 ; SITE3.G2 248.85,181.33 ; SITE3.G2 249.81,181.33 ; SITE3.G2 249.33,181.81 ; D106.A8 398.78,77.01 ; D106.A8 398.78,75.39 ; D106.A8 397.97,76.2 ; D106.A8 399.59,76.2 ; D118.B14 193.85,81.28 ; D118.B14 193.04,82.09 ; D118.B14 192.23,81.28 ; D118.B14 193.04,80.47 ; 254,339.55 CSDPS425.C9 ; CSDPS425.C9 254,341.17 ; CSDPS425.C9 253.19,340.36 ; CSDPS425.C9 254.81,340.36 ; 406.4,370.03 D111.B7 ; D111.B7 406.4,371.65 ; D111.B7 407.21,370.84 ; D111.B7 405.59,370.84 ; D128.B8 31.29,40.64 ; D128.B8 30.48,41.45 ; D128.B8 29.67,40.64 ; D128.B8 30.48,39.83 ; D123.A9 254,54.15 ; D123.A9 254.81,53.34 ; D123.A9 254,52.53 ; D123.A9 253.19,53.34 ; D110.B4 414.02,348.79 ; D110.B4 414.83,347.98 ; D110.B4 413.21,347.98 ; D110.B4 414.02,347.17 ; D118.A12 188.77,76.2 ; D118.A12 187.15,76.2 ; D118.A12 187.96,77.01 ; D118.A12 187.96,75.39 ; D122.B12 262.43,81.28 ; D122.B12 261.62,82.09 ; D122.B12 261.62,80.47 ; D122.B12 260.81,81.28 ; D118.A5 170.18,74.47 ; D118.A5 170.99,73.66 ; D118.A5 170.18,72.85 ; D118.A5 169.37,73.66 ; D113.B7 332.74,331.01 ; D113.B7 331.93,330.2 ; D113.B7 332.74,329.39 ; D113.B7 333.55,330.2 ; 340.36,367.49 D115.B4 ; D115.B4 341.17,368.3 ; D115.B4 339.55,368.3 ; D115.B4 340.36,369.11 ; D231.A8 183.69,373.38 ; D231.A8 182.88,372.57 ; D231.A8 182.88,374.19 ; D231.A8 182.07,373.38 ; 166.93,71.12 D318.B4 ; D318.B4 167.64,71.83 ; D318.B4 168.35,71.12 ; D318.B4 167.64,70.41 ; 309.88,65.33 D302.A2 ; D302.A2 309.88,66.75 ; D302.A2 309.17,66.04 ; D302.A2 310.59,66.04 ; D113.A15 313.23,335.28 ; D113.A15 312.42,334.47 ; D113.A15 311.61,335.28 ; D113.A15 312.42,336.09 ; D123.A14 267.51,55.88 ; D123.A14 266.7,55.07 ; D123.A14 265.89,55.88 ; D123.A14 266.7,56.69 ; 406.4,67.87 D306.B11 ; D306.B11 405.69,68.58 ; D306.B11 406.4,69.29 ; D306.B11 407.11,68.58 ; 180.34,83.11 D317.A9 ; D317.A9 179.63,83.82 ; D317.A9 181.05,83.82 ; D317.A9 180.34,84.53 ; 324.31,393.7 D116.A10 ; D116.A10 325.12,394.51 ; D116.A10 325.93,393.7 ; D116.A10 325.12,392.89 ; D321.A6 247.09,86.36 ; D321.A6 246.38,87.07 ; D321.A6 245.67,86.36 ; D321.A6 246.38,85.65 ; D317.A11 185.42,84.53 ; D317.A11 184.71,83.82 ; D317.A11 186.13,83.82 ; D317.A11 185.42,83.11 ; D110.A7 406.4,356.41 ; D110.A7 406.4,354.79 ; D110.A7 405.59,355.6 ; D110.A7 407.21,355.6 ; D111.B14 389.43,368.3 ; D111.B14 388.62,367.49 ; D111.B14 388.62,369.11 ; D111.B14 387.81,368.3 ; 111.76,98.25 D129.B11 ; D129.B11 111.76,99.87 ; D129.B11 110.95,99.06 ; D129.B11 112.57,99.06 ; 403.86,85.65 D305.A10 ; D305.A10 403.15,86.36 ; D305.A10 403.86,87.07 ; D305.A10 404.57,86.36 ; 20.32,55.07 D127.A4 ; D127.A4 20.32,56.69 ; D127.A4 19.51,55.88 ; D127.A4 21.13,55.88 ; 340.36,331.93 D113.A4 ; D113.A4 340.36,333.55 ; D113.A4 341.17,332.74 ; D113.A4 339.55,332.74 ; 245.57,35.56 D124.A6 ; D124.A6 247.19,35.56 ; D124.A6 246.38,36.37 ; D124.A6 246.38,34.75 ; 161.85,66.04 D318.A2 ; D318.A2 162.56,65.33 ; D318.A2 163.27,66.04 ; D318.A2 162.56,66.75 ; CSDPS429.B4 193.04,343.71 ; CSDPS429.B4 193.85,342.9 ; CSDPS429.B4 192.23,342.9 ; CSDPS429.B4 193.04,342.09 ; D126.B1 13.51,78.74 ; D126.B1 12.7,79.55 ; D126.B1 12.7,77.93 ; D126.B1 11.89,78.74 ; 326.85,355.6 D114.A9 ; D114.A9 327.66,354.79 ; D114.A9 328.47,355.6 ; D114.A9 327.66,356.41 ; 319.23,393.7 D116.A12 ; D116.A12 320.04,394.51 ; D116.A12 320.85,393.7 ; D116.A12 320.04,392.89 ; D124.B3 238.76,38.91 ; D124.B3 237.95,38.1 ; D124.B3 238.76,37.29 ; D124.B3 239.57,38.1 ; D322.A15 269.95,63.5 ; D322.A15 268.53,63.5 ; D322.A15 269.24,64.21 ; D322.A15 269.24,62.79 ; 415.75,38.1 D108.B15 ; D108.B15 416.56,37.29 ; D108.B15 417.37,38.1 ; D108.B15 416.56,38.91 ; D118.A15 195.58,74.47 ; D118.A15 196.39,73.66 ; D118.A15 194.77,73.66 ; D118.A15 195.58,72.85 ; D132.B15 121.92,38.91 ; D132.B15 122.73,38.1 ; D132.B15 121.92,37.29 ; D132.B15 121.11,38.1 ; 232.87,78.74 D122.B1 ; D122.B1 233.68,77.93 ; D122.B1 233.68,79.55 ; D122.B1 234.49,78.74 ; D321.B16 272.49,91.44 ; D321.B16 271.07,91.44 ; D321.B16 271.78,92.15 ; D321.B16 271.78,90.73 ; 119.38,39.83 D132.B14 ; D132.B14 119.38,41.45 ; D132.B14 120.19,40.64 ; D132.B14 118.57,40.64 ; D111.A1 421.64,376.73 ; D111.A1 421.64,375.11 ; D111.A1 422.45,375.92 ; D111.A1 420.83,375.92 ; 192.23,332.74 CSDPS229.B4 ; CSDPS229.B4 193.04,331.93 ; CSDPS229.B4 193.04,333.55 ; CSDPS229.B4 193.85,332.74 ; D317.B3 165.1,89.61 ; D317.B3 164.39,88.9 ; D317.B3 165.1,88.19 ; D317.B3 165.81,88.9 ; 166.93,91.44 D317.B4 ; D317.B4 168.35,91.44 ; D317.B4 167.64,90.73 ; D317.B4 167.64,92.15 ; 414.02,331.93 D109.A4 ; D109.A4 413.21,332.74 ; D109.A4 414.02,333.55 ; D109.A4 414.83,332.74 ; UNK2U2.4 483.43,214.94 ; UNK2U2.4 481.55,214.94 ; UNK2U2.4 482.49,214 ; UNK2U2.4 482.49,215.88 ; D110.A16 383.54,353.87 ; D110.A16 384.35,353.06 ; D110.A16 383.54,352.25 ; D110.A16 382.73,353.06 ; D306.B10 404.57,71.12 ; D306.B10 403.86,70.41 ; D306.B10 403.86,71.83 ; D306.B10 403.15,71.12 ; D128.A8 30.48,36.37 ; D128.A8 30.48,34.75 ; D128.A8 29.67,35.56 ; D128.A8 31.29,35.56 ; D129.A12 114.3,97.33 ; D129.A12 115.11,96.52 ; D129.A12 114.3,95.71 ; D129.A12 113.49,96.52 ; D131.A10 110.03,55.88 ; D131.A10 108.41,55.88 ; D131.A10 109.22,56.69 ; D131.A10 109.22,55.07 ; 410.67,78.74 D106.B13 ; D106.B13 411.48,77.93 ; D106.B13 411.48,79.55 ; D106.B13 412.29,78.74 ; D124.A5 244.65,33.02 ; D124.A5 243.03,33.02 ; D124.A5 243.84,33.83 ; D124.A5 243.84,32.21 ; 326.85,33.02 D104.A9 ; D104.A9 328.47,33.02 ; D104.A9 327.66,33.83 ; D104.A9 327.66,32.21 ; 326.95,68.58 D302.B9 ; D302.B9 327.66,69.29 ; D302.B9 328.37,68.58 ; D302.B9 327.66,67.87 ; D305.A6 393.7,87.07 ; D305.A6 394.41,86.36 ; D305.A6 392.99,86.36 ; D305.A6 393.7,85.65 ; D317.A14 193.04,87.07 ; D317.A14 193.75,86.36 ; D317.A14 192.33,86.36 ; D317.A14 193.04,85.65 ; 109.22,60.15 D131.B10 ; D131.B10 108.41,60.96 ; D131.B10 109.22,61.77 ; D131.B10 110.03,60.96 ; 103.33,76.2 D130.A8 ; D130.A8 104.14,75.39 ; D130.A8 104.14,77.01 ; D130.A8 104.95,76.2 ; 382.73,40.64 D108.B2 ; D108.B2 383.54,39.83 ; D108.B2 384.35,40.64 ; D108.B2 383.54,41.45 ; 314.15,327.66 D113.B14 ; D113.B14 314.96,328.47 ; D113.B14 314.96,326.85 ; D113.B14 315.77,327.66 ; D111.B15 386.89,370.84 ; D111.B15 386.08,371.65 ; D111.B15 385.27,370.84 ; D111.B15 386.08,370.03 ; 248.85,241.33 SITE1.G2 ; SITE1.G2 249.33,241.81 ; SITE1.G2 249.33,240.85 ; SITE1.G2 249.81,241.33 ; CSDPS425.B16 237.03,342.9 ; CSDPS425.B16 236.22,343.71 ; CSDPS425.B16 235.41,342.9 ; CSDPS425.B16 236.22,342.09 ; 160.02,62.79 D318.A1 ; D318.A1 159.31,63.5 ; D318.A1 160.73,63.5 ; D318.A1 160.02,64.21 ; 106.68,77.93 D130.B9 ; D130.B9 105.87,78.74 ; D130.B9 106.68,79.55 ; D130.B9 107.49,78.74 ; D122.B11 259.08,79.55 ; D122.B11 259.08,77.93 ; D122.B11 259.89,78.74 ; D122.B11 258.27,78.74 ; 268.43,330.2 CSDPS225.C3 ; CSDPS225.C3 269.24,329.39 ; CSDPS225.C3 269.24,331.01 ; CSDPS225.C3 270.05,330.2 ; D317.A1 160.02,84.53 ; D317.A1 159.31,83.82 ; D317.A1 160.02,83.11 ; D317.A1 160.73,83.82 ; 330.33,180.85 SITE4.G3 ; SITE4.G3 329.85,181.33 ; SITE4.G3 330.81,181.33 ; SITE4.G3 330.33,181.81 ; D114.B2 346.25,347.98 ; D114.B2 345.44,348.79 ; D114.B2 344.63,347.98 ; D114.B2 345.44,347.17 ; D301.B12 335.99,91.44 ; D301.B12 335.28,90.73 ; D301.B12 334.57,91.44 ; D301.B12 335.28,92.15 ; 392.89,55.88 D107.A6 ; D107.A6 393.7,55.07 ; D107.A6 394.51,55.88 ; D107.A6 393.7,56.69 ; D106.B15 417.37,78.74 ; D106.B15 416.56,79.55 ; D106.B15 415.75,78.74 ; D106.B15 416.56,77.93 ; 182.88,85.65 D317.A10 ; D317.A10 183.59,86.36 ; D317.A10 182.17,86.36 ; D317.A10 182.88,87.07 ; 246.38,65.33 D322.A6 ; D322.A6 247.09,66.04 ; D322.A6 245.67,66.04 ; D322.A6 246.38,66.75 ; D123.A6 246.38,56.69 ; D123.A6 246.38,55.07 ; D123.A6 247.19,55.88 ; D123.A6 245.57,55.88 ; 187.25,71.12 D318.B12 ; D318.B12 188.67,71.12 ; D318.B12 187.96,70.41 ; D318.B12 187.96,71.83 ; CSDPS429.C15 165.1,341.17 ; CSDPS429.C15 165.1,339.55 ; CSDPS429.C15 164.29,340.36 ; CSDPS429.C15 165.91,340.36 ; D110.B13 391.97,350.52 ; D110.B13 391.16,349.71 ; D110.B13 390.35,350.52 ; D110.B13 391.16,351.33 ; D131.B4 94.79,60.96 ; D131.B4 93.17,60.96 ; D131.B4 93.98,60.15 ; D131.B4 93.98,61.77 ; 171.91,368.3 D231.B12 ; D231.B12 172.72,369.11 ; D231.B12 173.53,368.3 ; D231.B12 172.72,367.49 ; 197.41,86.36 D317.A16 ; D317.A16 198.12,87.07 ; D317.A16 198.12,85.65 ; D317.A16 198.83,86.36 ; 50.8,75.39 D126.A16 ; D126.A16 50.8,77.01 ; D126.A16 49.99,76.2 ; D126.A16 51.61,76.2 ; D129.B1 86.36,99.87 ; D129.B1 87.17,99.06 ; D129.B1 85.55,99.06 ; D129.B1 86.36,98.25 ; 93.17,55.88 D131.A4 ; D131.A4 94.79,55.88 ; D131.A4 93.98,55.07 ; D131.A4 93.98,56.69 ; 382.83,91.44 D305.B2 ; D305.B2 384.25,91.44 ; D305.B2 383.54,90.73 ; D305.B2 383.54,92.15 ; SITE1.G7 248.33,248.41 ; SITE1.G7 248.81,247.93 ; SITE1.G7 248.33,247.45 ; SITE1.G7 247.85,247.93 ; 381,77.93 D106.B1 ; D106.B1 380.19,78.74 ; D106.B1 381.81,78.74 ; D106.B1 381,79.55 ; 385.37,63.5 D306.A3 ; D306.A3 386.79,63.5 ; D306.A3 386.08,64.21 ; D306.A3 386.08,62.79 ; CSDPS425.C7 259.89,340.36 ; CSDPS425.C7 258.27,340.36 ; CSDPS425.C7 259.08,341.17 ; CSDPS425.C7 259.08,339.55 ; D107.B2 384.35,60.96 ; D107.B2 383.54,61.77 ; D107.B2 382.73,60.96 ; D107.B2 383.54,60.15 ; 337.82,52.53 D103.A13 ; D103.A13 337.01,53.34 ; D103.A13 337.82,54.15 ; D103.A13 338.63,53.34 ; D128.A15 48.26,33.83 ; D128.A15 48.26,32.21 ; D128.A15 47.45,33.02 ; D128.A15 49.07,33.02 ; 29.67,96.52 D125.A8 ; D125.A8 30.48,97.33 ; D125.A8 30.48,95.71 ; D125.A8 31.29,96.52 ; D119.A14 193.04,56.69 ; D119.A14 193.04,55.07 ; D119.A14 193.85,55.88 ; D119.A14 192.23,55.88 ; D106.B4 388.62,82.09 ; D106.B4 388.62,80.47 ; D106.B4 389.43,81.28 ; D106.B4 387.81,81.28 ; 408.13,368.3 D111.B6 ; D111.B6 409.75,368.3 ; D111.B6 408.94,367.49 ; D111.B6 408.94,369.11 ; 411.48,83.11 D305.A13 ; D305.A13 410.77,83.82 ; D305.A13 411.48,84.53 ; D305.A13 412.19,83.82 ; D322.B9 254,69.29 ; D322.B9 254.71,68.58 ; D322.B9 253.29,68.58 ; D322.B9 254,67.87 ; 415.85,63.5 D306.A15 ; D306.A15 416.56,64.21 ; D306.A15 416.56,62.79 ; D306.A15 417.27,63.5 ; 397.97,35.56 D108.A8 ; D108.A8 398.78,36.37 ; D108.A8 398.78,34.75 ; D108.A8 399.59,35.56 ; 388.62,387.81 D112.B14 ; D112.B14 388.62,389.43 ; D112.B14 389.43,388.62 ; D112.B14 387.81,388.62 ; 330.85,181.33 SITE4.G4 ; SITE4.G4 331.33,180.85 ; SITE4.G4 331.33,181.81 ; SITE4.G4 331.81,181.33 ; D127.A13 43.18,54.15 ; D127.A13 43.18,52.53 ; D127.A13 42.37,53.34 ; D127.A13 43.99,53.34 ; D132.B5 96.52,38.91 ; D132.B5 95.71,38.1 ; D132.B5 97.33,38.1 ; D132.B5 96.52,37.29 ; D108.A5 391.16,33.83 ; D108.A5 391.97,33.02 ; D108.A5 390.35,33.02 ; D108.A5 391.16,32.21 ; D119.B4 168.45,60.96 ; D119.B4 167.64,61.77 ; D119.B4 167.64,60.15 ; D119.B4 166.83,60.96 ; D318.A9 181.05,63.5 ; D318.A9 179.63,63.5 ; D318.A9 180.34,64.21 ; D318.A9 180.34,62.79 ; D110.B11 396.24,351.33 ; D110.B11 395.43,350.52 ; D110.B11 396.24,349.71 ; D110.B11 397.05,350.52 ; D111.B10 398.78,369.11 ; D111.B10 397.97,368.3 ; D111.B10 399.59,368.3 ; D111.B10 398.78,367.49 ; D317.B5 170.18,89.61 ; D317.B5 170.18,88.19 ; D317.B5 169.47,88.9 ; D317.B5 170.89,88.9 ; 169.37,386.08 D431.A13 ; D431.A13 170.18,385.27 ; D431.A13 170.18,386.89 ; D431.A13 170.99,386.08 ; 175.26,57.61 D119.B7 ; D119.B7 176.07,58.42 ; D119.B7 175.26,59.23 ; D119.B7 174.45,58.42 ; D115.B13 318.31,370.84 ; D115.B13 317.5,371.65 ; D115.B13 317.5,370.03 ; D115.B13 316.69,370.84 ; 410.77,63.5 D306.A13 ; D306.A13 411.48,62.79 ; D306.A13 411.48,64.21 ; D306.A13 412.19,63.5 ; D318.B5 170.89,68.58 ; D318.B5 169.47,68.58 ; D318.B5 170.18,67.87 ; D318.B5 170.18,69.29 ; 314.96,65.33 D302.A4 ; D302.A4 314.96,66.75 ; D302.A4 314.25,66.04 ; D302.A4 315.67,66.04 ; 198.12,382.73 D431.A2 ; D431.A2 198.12,384.35 ; D431.A2 198.93,383.54 ; D431.A2 197.31,383.54 ; 179.63,68.58 D318.B9 ; D318.B9 180.34,69.29 ; D318.B9 181.05,68.58 ; D318.B9 180.34,67.87 ; D110.A8 404.67,353.06 ; D110.A8 403.86,352.25 ; D110.A8 403.05,353.06 ; D110.A8 403.86,353.87 ; 403.05,388.62 D112.B8 ; D112.B8 404.67,388.62 ; D112.B8 403.86,389.43 ; D112.B8 403.86,387.81 ; 320.04,34.75 D104.A6 ; D104.A6 320.85,35.56 ; D104.A6 320.04,36.37 ; D104.A6 319.23,35.56 ; 237.95,340.36 CSDPS425.C15 ; CSDPS425.C15 238.76,341.17 ; CSDPS425.C15 238.76,339.55 ; CSDPS425.C15 239.57,340.36 ; 24.59,40.64 D128.B6 ; D128.B6 25.4,41.45 ; D128.B6 26.21,40.64 ; D128.B6 25.4,39.83 ; 396.24,354.79 D110.A11 ; D110.A11 397.05,355.6 ; D110.A11 395.43,355.6 ; D110.A11 396.24,356.41 ; D127.B15 49.07,58.42 ; D127.B15 47.45,58.42 ; D127.B15 48.26,59.23 ; D127.B15 48.26,57.61 ; 331.85,181.33 SITE4.G5 ; SITE4.G5 332.33,180.85 ; SITE4.G5 332.81,181.33 ; SITE4.G5 332.33,181.81 ; 387.81,373.38 D111.A14 ; D111.A14 388.62,372.57 ; D111.A14 389.43,373.38 ; D111.A14 388.62,374.19 ; 169.37,375.92 D231.A13 ; D231.A13 170.18,375.11 ; D231.A13 170.18,376.73 ; D231.A13 170.99,375.92 ; 187.15,373.38 D231.A6 ; D231.A6 188.77,373.38 ; D231.A6 187.96,372.57 ; D231.A6 187.96,374.19 ; 172.72,90.73 D317.B6 ; D317.B6 172.72,92.15 ; D317.B6 172.01,91.44 ; D317.B6 173.43,91.44 ; D122.B3 239.57,78.74 ; D122.B3 238.76,77.93 ; D122.B3 237.95,78.74 ; D122.B3 238.76,79.55 ; D111.B4 414.83,368.3 ; D111.B4 414.02,369.11 ; D111.B4 414.02,367.49 ; D111.B4 413.21,368.3 ; 385.27,78.74 D106.B3 ; D106.B3 386.08,79.55 ; D106.B3 386.89,78.74 ; D106.B3 386.08,77.93 ; 419.1,65.33 D306.A16 ; D306.A16 418.39,66.04 ; D306.A16 419.81,66.04 ; D306.A16 419.1,66.75 ; 420.83,370.84 D111.B1 ; D111.B1 422.45,370.84 ; D111.B1 421.64,370.03 ; D111.B1 421.64,371.65 ; D131.B13 117.65,58.42 ; D131.B13 116.03,58.42 ; D131.B13 116.84,59.23 ; D131.B13 116.84,57.61 ; 325.12,387.81 D116.B10 ; D116.B10 325.93,388.62 ; D116.B10 325.12,389.43 ; D116.B10 324.31,388.62 ; D305.A7 396.24,84.53 ; D305.A7 396.95,83.82 ; D305.A7 396.24,83.11 ; D305.A7 395.53,83.82 ; 419.1,39.83 D108.B16 ; D108.B16 419.91,40.64 ; D108.B16 419.1,41.45 ; D108.B16 418.29,40.64 ; 256.54,80.47 D122.B10 ; D122.B10 257.35,81.28 ; D122.B10 255.73,81.28 ; D122.B10 256.54,82.09 ; 309.07,347.98 D114.B16 ; D114.B16 310.69,347.98 ; D114.B16 309.88,347.17 ; D114.B16 309.88,348.79 ; SITE3.G20 253.11,186.43 ; SITE3.G20 252.63,186.91 ; SITE3.G20 252.15,186.43 ; SITE3.G20 252.63,185.95 ; 232.87,38.1 D124.B1 ; D124.B1 234.49,38.1 ; D124.B1 233.68,37.29 ; D124.B1 233.68,38.91 ; 321.77,391.16 D116.B11 ; D116.B11 322.58,391.97 ; D116.B11 323.39,391.16 ; D116.B11 322.58,390.35 ; 309.07,76.2 D102.A2 ; D102.A2 309.88,75.39 ; D102.A2 309.88,77.01 ; D102.A2 310.69,76.2 ; 335.28,387.81 D116.B6 ; D116.B6 335.28,389.43 ; D116.B6 336.09,388.62 ; D116.B6 334.47,388.62 ; D321.B5 243.84,89.61 ; D321.B5 244.55,88.9 ; D321.B5 243.84,88.19 ; D321.B5 243.13,88.9 ; 347.17,396.24 D116.A1 ; D116.A1 347.98,395.43 ; D116.A1 348.79,396.24 ; D116.A1 347.98,397.05 ; D321.B11 259.79,88.9 ; D321.B11 259.08,89.61 ; D321.B11 259.08,88.19 ; D321.B11 258.37,88.9 ; 420.83,355.6 D110.A1 ; D110.A1 422.45,355.6 ; D110.A1 421.64,354.79 ; D110.A1 421.64,356.41 ; D109.A15 386.89,335.28 ; D109.A15 386.08,334.47 ; D109.A15 386.08,336.09 ; D109.A15 385.27,335.28 ; 314.15,35.56 D104.A4 ; D104.A4 314.96,36.37 ; D104.A4 315.77,35.56 ; D104.A4 314.96,34.75 ; D130.B15 121.92,79.55 ; D130.B15 122.73,78.74 ; D130.B15 121.92,77.93 ; D130.B15 121.11,78.74 ; U2.4 98.08,219.15 ; U2.4 97.14,218.21 ; U2.4 97.14,220.09 ; U2.4 96.2,219.15 ; 265.99,66.04 D322.A14 ; D322.A14 267.41,66.04 ; D322.A14 266.7,65.33 ; D322.A14 266.7,66.75 ; 185.42,67.87 D318.B11 ; D318.B11 185.42,69.29 ; D318.B11 184.71,68.58 ; D318.B11 186.13,68.58 ; 184.71,63.5 D318.A11 ; D318.A11 186.13,63.5 ; D318.A11 185.42,62.79 ; D318.A11 185.42,64.21 ; D108.A9 402.13,33.02 ; D108.A9 401.32,33.83 ; D108.A9 400.51,33.02 ; D108.A9 401.32,32.21 ; 321.87,88.9 D301.B7 ; D301.B7 322.58,88.19 ; D301.B7 322.58,89.61 ; D301.B7 323.29,88.9 ; D321.A2 236.93,86.36 ; D321.A2 236.22,85.65 ; D321.A2 235.51,86.36 ; D321.A2 236.22,87.07 ; 24.59,35.56 D128.A6 ; D128.A6 25.4,34.75 ; D128.A6 26.21,35.56 ; D128.A6 25.4,36.37 ; 330.23,245.95 SITE2.G18 ; SITE2.G18 329.75,246.43 ; SITE2.G18 330.71,246.43 ; SITE2.G18 330.23,246.91 ; 253.33,187.45 SITE3.G12 ; SITE3.G12 253.81,187.93 ; SITE3.G12 253.33,188.41 ; SITE3.G12 252.85,187.93 ; D113.A6 336.09,332.74 ; D113.A6 334.47,332.74 ; D113.A6 335.28,331.93 ; D113.A6 335.28,333.55 ; D108.A4 389.43,35.56 ; D108.A4 388.62,36.37 ; D108.A4 387.81,35.56 ; D108.A4 388.62,34.75 ; 337.01,38.1 D104.B13 ; D104.B13 337.82,38.91 ; D104.B13 337.82,37.29 ; D104.B13 338.63,38.1 ; D108.A12 408.94,36.37 ; D108.A12 408.13,35.56 ; D108.A12 409.75,35.56 ; D108.A12 408.94,34.75 ; 325.12,372.57 D115.A10 ; D115.A10 324.31,373.38 ; D115.A10 325.12,374.19 ; D115.A10 325.93,373.38 ; D321.A1 233.68,84.53 ; D321.A1 233.68,83.11 ; D321.A1 232.97,83.82 ; D321.A1 234.39,83.82 ; D131.A8 104.14,56.69 ; D131.A8 104.95,55.88 ; D131.A8 103.33,55.88 ; D131.A8 104.14,55.07 ; 194.77,38.1 D120.B15 ; D120.B15 195.58,37.29 ; D120.B15 195.58,38.91 ; D120.B15 196.39,38.1 ; D301.A9 327.66,84.53 ; D301.A9 328.37,83.82 ; D301.A9 327.66,83.11 ; D301.A9 326.95,83.82 ; 405.69,63.5 D306.A11 ; D306.A11 406.4,64.21 ; D306.A11 406.4,62.79 ; D306.A11 407.11,63.5 ; D107.B6 393.7,61.77 ; D107.B6 394.51,60.96 ; D107.B6 392.89,60.96 ; D107.B6 393.7,60.15 ; 345.44,90.73 D301.B16 ; D301.B16 344.73,91.44 ; D301.B16 346.15,91.44 ; D301.B16 345.44,92.15 ; D102.B15 342.9,79.55 ; D102.B15 343.71,78.74 ; D102.B15 342.9,77.93 ; D102.B15 342.09,78.74 ; SITE1.G6 253.33,241.81 ; SITE1.G6 253.33,240.85 ; SITE1.G6 253.81,241.33 ; SITE1.G6 252.85,241.33 ; SITE2.G7 328.33,248.41 ; SITE2.G7 327.85,247.93 ; SITE2.G7 328.33,247.45 ; SITE2.G7 328.81,247.93 ; D107.A14 414.83,55.88 ; D107.A14 414.02,55.07 ; D107.A14 413.21,55.88 ; D107.A14 414.02,56.69 ; 177.8,367.49 D231.B10 ; D231.B10 178.61,368.3 ; D231.B10 177.8,369.11 ; D231.B10 176.99,368.3 ; D118.B16 198.93,81.28 ; D118.B16 198.12,82.09 ; D118.B16 198.12,80.47 ; D118.B16 197.31,81.28 ; D231.A2 198.93,373.38 ; D231.A2 198.12,374.19 ; D231.A2 197.31,373.38 ; D231.A2 198.12,372.57 ; 260.81,76.2 D122.A12 ; D122.A12 261.62,77.01 ; D122.A12 261.62,75.39 ; D122.A12 262.43,76.2 ; SITE4.G12 333.33,188.41 ; SITE4.G12 333.33,187.45 ; SITE4.G12 332.85,187.93 ; SITE4.G12 333.81,187.93 ; D231.A15 165.91,375.92 ; D231.A15 164.29,375.92 ; D231.A15 165.1,376.73 ; D231.A15 165.1,375.11 ; 403.86,55.07 D107.A10 ; D107.A10 404.67,55.88 ; D107.A10 403.05,55.88 ; D107.A10 403.86,56.69 ; 184.61,370.84 D231.B7 ; D231.B7 185.42,371.65 ; D231.B7 186.23,370.84 ; D231.B7 185.42,370.03 ; 342.09,73.66 D102.A15 ; D102.A15 342.9,74.47 ; D102.A15 343.71,73.66 ; D102.A15 342.9,72.85 ; D231.A16 162.56,374.19 ; D231.A16 161.75,373.38 ; D231.A16 163.37,373.38 ; D231.A16 162.56,372.57 ; 240.49,55.88 D123.A4 ; D123.A4 241.3,56.69 ; D123.A4 241.3,55.07 ; D123.A4 242.11,55.88 ; D302.B13 337.82,69.29 ; D302.B13 337.82,67.87 ; D302.B13 337.11,68.58 ; D302.B13 338.53,68.58 ; 248.11,58.42 D123.B7 ; D123.B7 248.92,57.61 ; D123.B7 249.73,58.42 ; D123.B7 248.92,59.23 ; D130.B12 115.11,81.28 ; D130.B12 114.3,80.47 ; D130.B12 113.49,81.28 ; D130.B12 114.3,82.09 ; 83.31,208.1 S3_I2C.4 ; S3_I2C.4 84.25,209.04 ; S3_I2C.4 82.37,209.04 ; S3_I2C.4 83.31,209.98 ; D301.A1 308.05,83.82 ; D301.A1 307.34,83.11 ; D301.A1 307.34,84.53 ; D301.A1 306.63,83.82 ; D132.A8 104.14,36.37 ; D132.A8 104.14,34.75 ; D132.A8 104.95,35.56 ; D132.A8 103.33,35.56 ; 340.36,70.41 D302.B14 ; D302.B14 339.65,71.12 ; D302.B14 340.36,71.83 ; D302.B14 341.07,71.12 ; 395.43,78.74 D106.B7 ; D106.B7 396.24,77.93 ; D106.B7 397.05,78.74 ; D106.B7 396.24,79.55 ; D112.A5 412.29,396.24 ; D112.A5 410.67,396.24 ; D112.A5 411.48,395.43 ; D112.A5 411.48,397.05 ; D431.B2 198.93,378.46 ; D431.B2 197.31,378.46 ; D431.B2 198.12,377.65 ; D431.B2 198.12,379.27 ; 328.55,242.83 SITE2.G13 ; SITE2.G13 329.51,242.83 ; SITE2.G13 329.03,242.35 ; SITE2.G13 329.03,243.31 ; D109.B9 401.32,331.01 ; D109.B9 401.32,329.39 ; D109.B9 402.13,330.2 ; D109.B9 400.51,330.2 ; D131.B15 122.73,58.42 ; D131.B15 121.92,57.61 ; D131.B15 121.11,58.42 ; D131.B15 121.92,59.23 ; 388.62,392.89 D112.A14 ; D112.A14 387.81,393.7 ; D112.A14 389.43,393.7 ; D112.A14 388.62,394.51 ; D103.A15 343.71,53.34 ; D103.A15 342.9,54.15 ; D103.A15 342.9,52.53 ; D103.A15 342.09,53.34 ; CSDPS425.B6 262.43,342.9 ; CSDPS425.B6 261.62,342.09 ; CSDPS425.B6 261.62,343.71 ; CSDPS425.B6 260.81,342.9 ; SITE4.G13 329.03,183.31 ; SITE4.G13 328.55,182.83 ; SITE4.G13 329.51,182.83 ; SITE4.G13 329.03,182.35 ; 29.67,60.96 D127.B8 ; D127.B8 30.48,60.15 ; D127.B8 31.29,60.96 ; D127.B8 30.48,61.77 ; D305.B8 398.78,92.15 ; D305.B8 398.78,90.73 ; D305.B8 399.49,91.44 ; D305.B8 398.07,91.44 ; 45.72,39.83 D128.B14 ; D128.B14 45.72,41.45 ; D128.B14 44.91,40.64 ; D128.B14 46.53,40.64 ; 397.97,353.06 D110.A10 ; D110.A10 398.78,353.87 ; D110.A10 399.59,353.06 ; D110.A10 398.78,352.25 ; D103.A5 317.5,54.15 ; D103.A5 318.31,53.34 ; D103.A5 317.5,52.53 ; D103.A5 316.69,53.34 ; 95.71,99.06 D129.B5 ; D129.B5 97.33,99.06 ; D129.B5 96.52,99.87 ; D129.B5 96.52,98.25 ; D231.A14 168.45,373.38 ; D231.A14 166.83,373.38 ; D231.A14 167.64,372.57 ; D231.A14 167.64,374.19 ; 329.39,76.2 D102.A10 ; D102.A10 331.01,76.2 ; D102.A10 330.2,75.39 ; D102.A10 330.2,77.01 ; D306.A2 384.25,66.04 ; D306.A2 383.54,66.75 ; D306.A2 383.54,65.33 ; D306.A2 382.83,66.04 ; SITE4.G19 331.43,186.91 ; SITE4.G19 330.95,186.43 ; SITE4.G19 331.91,186.43 ; SITE4.G19 331.43,185.95 ; D122.A15 270.05,73.66 ; D122.A15 269.24,74.47 ; D122.A15 269.24,72.85 ; D122.A15 268.43,73.66 ; 250.85,247.93 SITE1.G10 ; SITE1.G10 251.33,247.45 ; SITE1.G10 251.33,248.41 ; SITE1.G10 251.81,247.93 ; D132.B7 102.41,38.1 ; D132.B7 101.6,37.29 ; D132.B7 101.6,38.91 ; D132.B7 100.79,38.1 ; D123.A11 259.08,54.15 ; D123.A11 258.27,53.34 ; D123.A11 259.89,53.34 ; D123.A11 259.08,52.53 ; D123.A3 239.57,53.34 ; D123.A3 238.76,54.15 ; D123.A3 238.76,52.53 ; D123.A3 237.95,53.34 ; 116.84,72.85 D130.A13 ; D130.A13 116.03,73.66 ; D130.A13 116.84,74.47 ; D130.A13 117.65,73.66 ; 386.08,354.79 D110.A15 ; D110.A15 386.89,355.6 ; D110.A15 385.27,355.6 ; D110.A15 386.08,356.41 ; D127.A8 30.48,56.69 ; D127.A8 29.67,55.88 ; D127.A8 31.29,55.88 ; D127.A8 30.48,55.07 ; D321.B1 233.68,89.61 ; D321.B1 233.68,88.19 ; D321.B1 232.97,88.9 ; D321.B1 234.39,88.9 ; D119.B14 193.85,60.96 ; D119.B14 192.23,60.96 ; D119.B14 193.04,61.77 ; D119.B14 193.04,60.15 ; 187.96,60.15 D119.B12 ; D119.B12 187.96,61.77 ; D119.B12 187.15,60.96 ; D119.B12 188.77,60.96 ; D305.B7 396.95,88.9 ; D305.B7 395.53,88.9 ; D305.B7 396.24,89.61 ; D305.B7 396.24,88.19 ; SITE1.G16 252.63,243.31 ; SITE1.G16 252.63,242.35 ; SITE1.G16 252.15,242.83 ; SITE1.G16 253.11,242.83 ; 380.19,33.02 D108.A1 ; D108.A1 381,33.83 ; D108.A1 381,32.21 ; D108.A1 381.81,33.02 ; 86.36,77.93 D130.B1 ; D130.B1 86.36,79.55 ; D130.B1 87.17,78.74 ; D130.B1 85.55,78.74 ; 88.09,40.64 D132.B2 ; D132.B2 88.9,39.83 ; D132.B2 89.71,40.64 ; D132.B2 88.9,41.45 ; 236.22,90.73 D321.B2 ; D321.B2 236.22,92.15 ; D321.B2 235.51,91.44 ; D321.B2 236.93,91.44 ; 49.99,55.88 D127.A16 ; D127.A16 50.8,55.07 ; D127.A16 51.61,55.88 ; D127.A16 50.8,56.69 ; D120.A10 182.88,36.37 ; D120.A10 182.07,35.56 ; D120.A10 183.69,35.56 ; D120.A10 182.88,34.75 ; 243.84,52.53 D123.A5 ; D123.A5 244.65,53.34 ; D123.A5 243.03,53.34 ; D123.A5 243.84,54.15 ; 162.56,85.65 D317.A2 ; D317.A2 161.85,86.36 ; D317.A2 162.56,87.07 ; D317.A2 163.27,86.36 ; DPS2.A15 312.42,416.1 ; DPS2.A15 311.61,415.29 ; DPS2.A15 313.23,415.29 ; DPS2.A15 312.42,414.48 ; 342.9,62.79 D302.A15 ; D302.A15 342.19,63.5 ; D302.A15 342.9,64.21 ; D302.A15 343.61,63.5 ; D108.B13 412.29,38.1 ; D108.B13 411.48,38.91 ; D108.B13 411.48,37.29 ; D108.B13 410.67,38.1 ; 249.75,242.83 SITE1.G14 ; SITE1.G14 250.23,243.31 ; SITE1.G14 250.23,242.35 ; SITE1.G14 250.71,242.83 ; 340.36,392.89 D116.A4 ; D116.A4 341.17,393.7 ; D116.A4 339.55,393.7 ; D116.A4 340.36,394.51 ; 232.87,73.66 D122.A1 ; D122.A1 233.68,72.85 ; D122.A1 234.49,73.66 ; D122.A1 233.68,74.47 ; 24.59,96.52 D125.A6 ; D125.A6 26.21,96.52 ; D125.A6 25.4,95.71 ; D125.A6 25.4,97.33 ; 419.1,392.89 D112.A2 ; D112.A2 418.29,393.7 ; D112.A2 419.1,394.51 ; D112.A2 419.91,393.7 ; 167.64,85.65 D317.A4 ; D317.A4 167.64,87.07 ; D317.A4 168.35,86.36 ; D317.A4 166.93,86.36 ; 398.78,80.47 D106.B8 ; D106.B8 397.97,81.28 ; D106.B8 399.59,81.28 ; D106.B8 398.78,82.09 ; 330.23,185.95 SITE4.G18 ; SITE4.G18 329.75,186.43 ; SITE4.G18 330.71,186.43 ; SITE4.G18 330.23,186.91 ; D125.A10 36.37,96.52 ; D125.A10 34.75,96.52 ; D125.A10 35.56,95.71 ; D125.A10 35.56,97.33 ; D102.B14 341.17,81.28 ; D102.B14 340.36,82.09 ; D102.B14 340.36,80.47 ; D102.B14 339.55,81.28 ; 345.44,39.83 D104.B16 ; D104.B16 346.25,40.64 ; D104.B16 345.44,41.45 ; D104.B16 344.63,40.64 ; 387.81,347.98 D110.B14 ; D110.B14 388.62,347.17 ; D110.B14 389.43,347.98 ; D110.B14 388.62,348.79 ; D127.A9 33.83,53.34 ; D127.A9 33.02,52.53 ; D127.A9 32.21,53.34 ; D127.A9 33.02,54.15 ; D322.B15 269.95,68.58 ; D322.B15 268.53,68.58 ; D322.B15 269.24,69.29 ; D322.B15 269.24,67.87 ; 309.88,39.83 D104.B2 ; D104.B2 310.69,40.64 ; D104.B2 309.07,40.64 ; D104.B2 309.88,41.45 ; 269.24,77.93 D122.B15 ; D122.B15 270.05,78.74 ; D122.B15 269.24,79.55 ; D122.B15 268.43,78.74 ; 256.54,65.33 D322.A10 ; D322.A10 255.83,66.04 ; D322.A10 257.25,66.04 ; D322.A10 256.54,66.75 ; CSDPS429.C3 195.58,341.17 ; CSDPS429.C3 194.77,340.36 ; CSDPS429.C3 195.58,339.55 ; CSDPS429.C3 196.39,340.36 ; 42.37,58.42 D127.B13 ; D127.B13 43.99,58.42 ; D127.B13 43.18,59.23 ; D127.B13 43.18,57.61 ; 316.69,33.02 D104.A5 ; D104.A5 317.5,33.83 ; D104.A5 317.5,32.21 ; D104.A5 318.31,33.02 ; D123.B12 262.43,60.96 ; D123.B12 261.62,60.15 ; D123.B12 261.62,61.77 ; D123.B12 260.81,60.96 ; D317.B16 198.12,92.15 ; D317.B16 198.83,91.44 ; D317.B16 198.12,90.73 ; D317.B16 197.41,91.44 ; 243.03,73.66 D122.A5 ; D122.A5 243.84,74.47 ; D122.A5 243.84,72.85 ; D122.A5 244.65,73.66 ; D111.B13 391.97,370.84 ; D111.B13 391.16,371.65 ; D111.B13 391.16,370.03 ; D111.B13 390.35,370.84 ; 403.86,90.73 D305.B10 ; D305.B10 403.86,92.15 ; D305.B10 403.15,91.44 ; D305.B10 404.57,91.44 ; 403.86,60.15 D107.B10 ; D107.B10 404.67,60.96 ; D107.B10 403.05,60.96 ; D107.B10 403.86,61.77 ; D118.A6 172.72,77.01 ; D118.A6 173.53,76.2 ; D118.A6 171.91,76.2 ; D118.A6 172.72,75.39 ; D119.A4 168.45,55.88 ; D119.A4 167.64,56.69 ; D119.A4 167.64,55.07 ; D119.A4 166.83,55.88 ; D123.B14 267.51,60.96 ; D123.B14 266.7,61.77 ; D123.B14 265.89,60.96 ; D123.B14 266.7,60.15 ; 332.15,182.83 SITE4.G16 ; SITE4.G16 332.63,183.31 ; SITE4.G16 332.63,182.35 ; SITE4.G16 333.11,182.83 ; 321.77,410.21 DPS2.C11 ; DPS2.C11 322.58,411.02 ; DPS2.C11 323.39,410.21 ; DPS2.C11 322.58,409.4 ; D130.B14 120.19,81.28 ; D130.B14 119.38,80.47 ; D130.B14 118.57,81.28 ; D130.B14 119.38,82.09 ; 331.93,375.92 D115.A7 ; D115.A7 332.74,376.73 ; D115.A7 333.55,375.92 ; D115.A7 332.74,375.11 ; 193.04,70.41 D318.B14 ; D318.B14 193.75,71.12 ; D318.B14 193.04,71.83 ; D318.B14 192.33,71.12 ; D130.B16 125.27,81.28 ; D130.B16 124.46,82.09 ; D130.B16 123.65,81.28 ; D130.B16 124.46,80.47 ; D102.B3 312.42,79.55 ; D102.B3 311.61,78.74 ; D102.B3 313.23,78.74 ; D102.B3 312.42,77.93 ; SITE2.G15 331.91,242.83 ; SITE2.G15 331.43,243.31 ; SITE2.G15 331.43,242.35 ; SITE2.G15 330.95,242.83 ; D305.A11 406.4,84.53 ; D305.A11 407.11,83.82 ; D305.A11 406.4,83.11 ; D305.A11 405.69,83.82 ; 193.04,75.39 D118.A14 ; D118.A14 192.23,76.2 ; D118.A14 193.85,76.2 ; D118.A14 193.04,77.01 ; 37.29,33.02 D128.A11 ; D128.A11 38.1,33.83 ; D128.A11 38.91,33.02 ; D128.A11 38.1,32.21 ; D107.A4 389.43,55.88 ; D107.A4 388.62,55.07 ; D107.A4 387.81,55.88 ; D107.A4 388.62,56.69 ; 320.04,90.73 D301.B6 ; D301.B6 320.75,91.44 ; D301.B6 319.33,91.44 ; D301.B6 320.04,92.15 ; D132.A11 112.57,33.02 ; D132.A11 110.95,33.02 ; D132.A11 111.76,33.83 ; D132.A11 111.76,32.21 ; 27.13,58.42 D127.B7 ; D127.B7 28.75,58.42 ; D127.B7 27.94,59.23 ; D127.B7 27.94,57.61 ; 184.61,78.74 D118.B11 ; D118.B11 185.42,77.93 ; D118.B11 185.42,79.55 ; D118.B11 186.23,78.74 ; 320.04,70.41 D302.B6 ; D302.B6 320.04,71.83 ; D302.B6 320.75,71.12 ; D302.B6 319.33,71.12 ; 330.23,242.35 SITE2.G14 ; SITE2.G14 330.23,243.31 ; SITE2.G14 330.71,242.83 ; SITE2.G14 329.75,242.83 ; DPS8.C15 165.1,411.02 ; DPS8.C15 165.91,410.21 ; DPS8.C15 165.1,409.4 ; DPS8.C15 164.29,410.21 ; D231.A11 176.07,375.92 ; D231.A11 175.26,376.73 ; D231.A11 174.45,375.92 ; D231.A11 175.26,375.11 ; 19.51,101.6 D125.B4 ; D125.B4 20.32,102.41 ; D125.B4 20.32,100.79 ; D125.B4 21.13,101.6 ; D107.A12 408.94,56.69 ; D107.A12 408.94,55.07 ; D107.A12 409.75,55.88 ; D107.A12 408.13,55.88 ; D123.B6 247.19,60.96 ; D123.B6 245.57,60.96 ; D123.B6 246.38,60.15 ; D123.B6 246.38,61.77 ; 415.75,350.52 D110.B3 ; D110.B3 417.37,350.52 ; D110.B3 416.56,351.33 ; D110.B3 416.56,349.71 ; D103.A7 323.39,53.34 ; D103.A7 321.77,53.34 ; D103.A7 322.58,52.53 ; D103.A7 322.58,54.15 ; 14.43,76.2 D126.A2 ; D126.A2 15.24,75.39 ; D126.A2 15.24,77.01 ; D126.A2 16.05,76.2 ; 330.2,39.83 D104.B10 ; D104.B10 329.39,40.64 ; D104.B10 330.2,41.45 ; D104.B10 331.01,40.64 ; D114.B3 343.71,350.52 ; D114.B3 342.9,351.33 ; D114.B3 342.9,349.71 ; D114.B3 342.09,350.52 ; 167.64,382.73 D431.A14 ; D431.A14 166.83,383.54 ; D431.A14 167.64,384.35 ; D431.A14 168.45,383.54 ; D109.B12 394.51,327.66 ; D109.B12 392.89,327.66 ; D109.B12 393.7,326.85 ; D109.B12 393.7,328.47 ; D305.A2 384.25,86.36 ; D305.A2 383.54,87.07 ; D305.A2 383.54,85.65 ; D305.A2 382.83,86.36 ; D431.A6 188.77,383.54 ; D431.A6 187.15,383.54 ; D431.A6 187.96,382.73 ; D431.A6 187.96,384.35 ; D115.A2 345.44,374.19 ; D115.A2 346.25,373.38 ; D115.A2 344.63,373.38 ; D115.A2 345.44,372.57 ; CSDPS429.C11 176.07,340.36 ; CSDPS429.C11 175.26,339.55 ; CSDPS429.C11 175.26,341.17 ; CSDPS429.C11 174.45,340.36 ; 271.78,80.47 D122.B16 ; D122.B16 271.78,82.09 ; D122.B16 272.59,81.28 ; D122.B16 270.97,81.28 ; 88.09,101.6 D129.B2 ; D129.B2 88.9,100.79 ; D129.B2 88.9,102.41 ; D129.B2 89.71,101.6 ; 413.21,327.66 D109.B4 ; D109.B4 414.02,326.85 ; D109.B4 414.83,327.66 ; D109.B4 414.02,328.47 ; 265.89,342.9 CSDPS425.B4 ; CSDPS425.B4 266.7,342.09 ; CSDPS425.B4 267.51,342.9 ; CSDPS425.B4 266.7,343.71 ; D116.A3 343.71,396.24 ; D116.A3 342.9,395.43 ; D116.A3 342.09,396.24 ; D116.A3 342.9,397.05 ; 187.25,86.36 D317.A12 ; D317.A12 187.96,87.07 ; D317.A12 188.67,86.36 ; D317.A12 187.96,85.65 ; D130.B2 88.9,82.09 ; D130.B2 89.71,81.28 ; D130.B2 88.09,81.28 ; D130.B2 88.9,80.47 ; D128.A2 16.05,35.56 ; D128.A2 15.24,36.37 ; D128.A2 14.43,35.56 ; D128.A2 15.24,34.75 ; 248.92,339.55 CSDPS425.C11 ; CSDPS425.C11 248.11,340.36 ; CSDPS425.C11 248.92,341.17 ; CSDPS425.C11 249.73,340.36 ; D132.A14 119.38,36.37 ; D132.A14 119.38,34.75 ; D132.A14 120.19,35.56 ; D132.A14 118.57,35.56 ; 397.97,347.98 D110.B10 ; D110.B10 399.59,347.98 ; D110.B10 398.78,348.79 ; D110.B10 398.78,347.17 ; D123.A7 249.73,53.34 ; D123.A7 248.92,52.53 ; D123.A7 248.92,54.15 ; D123.A7 248.11,53.34 ; 91.44,72.85 D130.A3 ; D130.A3 92.25,73.66 ; D130.A3 90.63,73.66 ; D130.A3 91.44,74.47 ; 190.5,339.55 CSDPS429.C5 ; CSDPS429.C5 189.69,340.36 ; CSDPS429.C5 190.5,341.17 ; CSDPS429.C5 191.31,340.36 ; SITE3.G5 252.33,181.81 ; SITE3.G5 251.85,181.33 ; SITE3.G5 252.33,180.85 ; SITE3.G5 252.81,181.33 ; 98.25,55.88 D131.A6 ; D131.A6 99.06,55.07 ; D131.A6 99.06,56.69 ; D131.A6 99.87,55.88 ; 195.58,57.61 D119.B15 ; D119.B15 194.77,58.42 ; D119.B15 196.39,58.42 ; D119.B15 195.58,59.23 ; D126.A12 41.45,76.2 ; D126.A12 39.83,76.2 ; D126.A12 40.64,75.39 ; D126.A12 40.64,77.01 ; 320.04,367.49 D115.B12 ; D115.B12 320.85,368.3 ; D115.B12 319.23,368.3 ; D115.B12 320.04,369.11 ; D114.A3 342.9,356.41 ; D114.A3 342.9,354.79 ; D114.A3 343.71,355.6 ; D114.A3 342.09,355.6 ; D130.A12 115.11,76.2 ; D130.A12 114.3,77.01 ; D130.A12 114.3,75.39 ; D130.A12 113.49,76.2 ; D132.B11 112.57,38.1 ; D132.B11 110.95,38.1 ; D132.B11 111.76,38.91 ; D132.B11 111.76,37.29 ; D102.A4 315.77,76.2 ; D102.A4 314.96,77.01 ; D102.A4 314.96,75.39 ; D102.A4 314.15,76.2 ; 401.32,57.61 D107.B9 ; D107.B9 400.51,58.42 ; D107.B9 402.13,58.42 ; D107.B9 401.32,59.23 ; 167.64,80.47 D118.B4 ; D118.B4 167.64,82.09 ; D118.B4 168.45,81.28 ; D118.B4 166.83,81.28 ; D123.A16 272.59,55.88 ; D123.A16 271.78,55.07 ; D123.A16 270.97,55.88 ; D123.A16 271.78,56.69 ; 37.29,93.98 D125.A11 ; D125.A11 38.1,93.17 ; D125.A11 38.91,93.98 ; D125.A11 38.1,94.79 ; D115.A3 343.71,375.92 ; D115.A3 342.09,375.92 ; D115.A3 342.9,375.11 ; D115.A3 342.9,376.73 ; DPS1.C01 381,19.86 ; DPS1.C01 381.81,19.05 ; DPS1.C01 380.19,19.05 ; DPS1.C01 381,18.24 ; 398.78,60.15 D107.B8 ; D107.B8 397.97,60.96 ; D107.B8 399.59,60.96 ; D107.B8 398.78,61.77 ; D127.A2 16.05,55.88 ; D127.A2 14.43,55.88 ; D127.A2 15.24,55.07 ; D127.A2 15.24,56.69 ; D431.A1 201.47,386.08 ; D431.A1 199.85,386.08 ; D431.A1 200.66,386.89 ; D431.A1 200.66,385.27 ; D231.B5 190.5,371.65 ; D231.B5 190.5,370.03 ; D231.B5 191.31,370.84 ; D231.B5 189.69,370.84 ; 172.72,80.47 D118.B6 ; D118.B6 171.91,81.28 ; D118.B6 172.72,82.09 ; D118.B6 173.53,81.28 ; D120.A2 162.56,36.37 ; D120.A2 161.75,35.56 ; D120.A2 162.56,34.75 ; D120.A2 163.37,35.56 ; CSDPS229.C3 196.39,330.2 ; CSDPS229.C3 195.58,331.01 ; CSDPS229.C3 195.58,329.39 ; CSDPS229.C3 194.77,330.2 ; D104.A3 313.23,33.02 ; D104.A3 312.42,33.83 ; D104.A3 312.42,32.21 ; D104.A3 311.61,33.02 ; D112.A12 394.51,393.7 ; D112.A12 393.7,392.89 ; D112.A12 393.7,394.51 ; D112.A12 392.89,393.7 ; 162.56,75.39 D118.A2 ; D118.A2 163.37,76.2 ; D118.A2 162.56,77.01 ; D118.A2 161.75,76.2 ; 324.31,35.56 D104.A8 ; D104.A8 325.12,34.75 ; D104.A8 325.12,36.37 ; D104.A8 325.93,35.56 ; D106.A6 394.51,76.2 ; D106.A6 393.7,75.39 ; D106.A6 392.89,76.2 ; D106.A6 393.7,77.01 ; 159.21,38.1 D120.B1 ; D120.B1 160.02,37.29 ; D120.B1 160.83,38.1 ; D120.B1 160.02,38.91 ; D131.A9 106.68,54.15 ; D131.A9 105.87,53.34 ; D131.A9 107.49,53.34 ; D131.A9 106.68,52.53 ; D119.A2 162.56,56.69 ; D119.A2 161.75,55.88 ; D119.A2 162.56,55.07 ; D119.A2 163.37,55.88 ; D127.B10 36.37,60.96 ; D127.B10 35.56,61.77 ; D127.B10 34.75,60.96 ; D127.B10 35.56,60.15 ; 324.41,71.12 D302.B8 ; D302.B8 325.83,71.12 ; D302.B8 325.12,71.83 ; D302.B8 325.12,70.41 ; 111.76,77.93 D130.B11 ; D130.B11 111.76,79.55 ; D130.B11 110.95,78.74 ; D130.B11 112.57,78.74 ; 169.47,83.82 D317.A5 ; D317.A5 170.89,83.82 ; D317.A5 170.18,83.11 ; D317.A5 170.18,84.53 ; 172.72,377.65 D431.B12 ; D431.B12 173.53,378.46 ; D431.B12 171.91,378.46 ; D431.B12 172.72,379.27 ; 311.61,370.84 D115.B15 ; D115.B15 312.42,371.65 ; D115.B15 312.42,370.03 ; D115.B15 313.23,370.84 ; U1.4 97.98,205.54 ; U1.4 97.04,206.48 ; U1.4 97.04,204.6 ; U1.4 96.1,205.54 ; 12.7,72.85 D126.A1 ; D126.A1 12.7,74.47 ; D126.A1 13.51,73.66 ; D126.A1 11.89,73.66 ; D110.B15 386.08,351.33 ; D110.B15 386.08,349.71 ; D110.B15 386.89,350.52 ; D110.B15 385.27,350.52 ; 240.49,40.64 D124.B4 ; D124.B4 241.3,39.83 ; D124.B4 242.11,40.64 ; D124.B4 241.3,41.45 ; D122.B4 241.3,82.09 ; D122.B4 240.49,81.28 ; D122.B4 242.11,81.28 ; D122.B4 241.3,80.47 ; SITE3.G15 251.91,182.83 ; SITE3.G15 250.95,182.83 ; SITE3.G15 251.43,182.35 ; SITE3.G15 251.43,183.31 ; D120.B13 191.31,38.1 ; D120.B13 189.69,38.1 ; D120.B13 190.5,37.29 ; D120.B13 190.5,38.91 ; CSDPS425.C1 275.13,340.36 ; CSDPS425.C1 273.51,340.36 ; CSDPS425.C1 274.32,341.17 ; CSDPS425.C1 274.32,339.55 ; D321.A16 272.49,86.36 ; D321.A16 271.07,86.36 ; D321.A16 271.78,85.65 ; D321.A16 271.78,87.07 ; SITE3.G9 250.81,187.93 ; SITE3.G9 249.85,187.93 ; SITE3.G9 250.33,188.41 ; SITE3.G9 250.33,187.45 ; D122.B14 266.7,82.09 ; D122.B14 267.51,81.28 ; D122.B14 265.89,81.28 ; D122.B14 266.7,80.47 ; D302.B2 310.59,71.12 ; D302.B2 309.88,70.41 ; D302.B2 309.88,71.83 ; D302.B2 309.17,71.12 ; 85.55,33.02 D132.A1 ; D132.A1 87.17,33.02 ; D132.A1 86.36,32.21 ; D132.A1 86.36,33.83 ; 411.48,349.71 D110.B5 ; D110.B5 410.67,350.52 ; D110.B5 412.29,350.52 ; D110.B5 411.48,351.33 ; 175.26,72.85 D118.A7 ; D118.A7 174.45,73.66 ; D118.A7 176.07,73.66 ; D118.A7 175.26,74.47 ; 236.22,55.07 D123.A2 ; D123.A2 237.03,55.88 ; D123.A2 235.41,55.88 ; D123.A2 236.22,56.69 ; 250.75,71.12 D322.B8 ; D322.B8 251.46,70.41 ; D322.B8 252.17,71.12 ; D322.B8 251.46,71.83 ; 381,67.87 D306.B1 ; D306.B1 381,69.29 ; D306.B1 380.29,68.58 ; D306.B1 381.71,68.58 ; D301.A8 325.12,87.07 ; D301.A8 325.83,86.36 ; D301.A8 324.41,86.36 ; D301.A8 325.12,85.65 ; D322.A11 259.08,64.21 ; D322.A11 259.79,63.5 ; D322.A11 259.08,62.79 ; D322.A11 258.37,63.5 ; D122.A14 266.7,77.01 ; D122.A14 265.89,76.2 ; D122.A14 267.51,76.2 ; D122.A14 266.7,75.39 ; 321.77,370.84 D115.B11 ; D115.B11 322.58,370.03 ; D115.B11 323.39,370.84 ; D115.B11 322.58,371.65 ; 233.68,57.61 D123.B1 ; D123.B1 233.68,59.23 ; D123.B1 232.87,58.42 ; D123.B1 234.49,58.42 ; 416.56,67.87 D306.B15 ; D306.B15 417.27,68.58 ; D306.B15 416.56,69.29 ; D306.B15 415.85,68.58 ; 97.29,160.91 UNK3U1.4 ; UNK3U1.4 96.35,161.85 ; UNK3U1.4 98.23,161.85 ; UNK3U1.4 97.29,162.79 ; D106.B16 419.91,81.28 ; D106.B16 419.1,82.09 ; D106.B16 419.1,80.47 ; D106.B16 418.29,81.28 ; 24.59,76.2 D126.A6 ; D126.A6 25.4,77.01 ; D126.A6 25.4,75.39 ; D126.A6 26.21,76.2 ; D318.B15 196.29,68.58 ; D318.B15 195.58,67.87 ; D318.B15 194.87,68.58 ; D318.B15 195.58,69.29 ; 385.27,38.1 D108.B3 ; D108.B3 386.08,37.29 ; D108.B3 386.08,38.91 ; D108.B3 386.89,38.1 ; D122.A2 237.03,76.2 ; D122.A2 235.41,76.2 ; D122.A2 236.22,77.01 ; D122.A2 236.22,75.39 ; 17.78,98.25 D125.B3 ; D125.B3 16.97,99.06 ; D125.B3 17.78,99.87 ; D125.B3 18.59,99.06 ; 113.49,101.6 D129.B12 ; D129.B12 115.11,101.6 ; D129.B12 114.3,102.41 ; D129.B12 114.3,100.79 ; D301.A13 337.82,84.53 ; D301.A13 337.82,83.11 ; D301.A13 337.11,83.82 ; D301.A13 338.53,83.82 ; D431.A12 173.53,383.54 ; D431.A12 171.91,383.54 ; D431.A12 172.72,382.73 ; D431.A12 172.72,384.35 ; 182.88,367.49 D231.B8 ; D231.B8 183.69,368.3 ; D231.B8 182.07,368.3 ; D231.B8 182.88,369.11 ; D131.B2 88.9,61.77 ; D131.B2 88.09,60.96 ; D131.B2 88.9,60.15 ; D131.B2 89.71,60.96 ; D120.A3 165.91,33.02 ; D120.A3 165.1,32.21 ; D120.A3 164.29,33.02 ; D120.A3 165.1,33.83 ; 248.55,186.43 SITE3.G17 ; SITE3.G17 249.51,186.43 ; SITE3.G17 249.03,185.95 ; SITE3.G17 249.03,186.91 ; 250.75,91.44 D321.B8 ; D321.B8 252.17,91.44 ; D321.B8 251.46,92.15 ; D321.B8 251.46,90.73 ; D110.B6 409.75,347.98 ; D110.B6 408.13,347.98 ; D110.B6 408.94,348.79 ; D110.B6 408.94,347.17 ; D302.A16 345.44,66.75 ; D302.A16 346.15,66.04 ; D302.A16 345.44,65.33 ; D302.A16 344.73,66.04 ; 177.8,39.83 D120.B8 ; D120.B8 178.61,40.64 ; D120.B8 176.99,40.64 ; D120.B8 177.8,41.45 ; CSDPS229.B2 198.93,332.74 ; CSDPS229.B2 198.12,331.93 ; CSDPS229.B2 198.12,333.55 ; CSDPS229.B2 197.31,332.74 ; D129.B9 106.68,99.87 ; D129.B9 107.49,99.06 ; D129.B9 106.68,98.25 ; D129.B9 105.87,99.06 ; D112.B2 419.1,389.43 ; D112.B2 419.91,388.62 ; D112.B2 418.29,388.62 ; D112.B2 419.1,387.81 ; 398.78,326.85 D109.B10 ; D109.B10 398.78,328.47 ; D109.B10 397.97,327.66 ; D109.B10 399.59,327.66 ; 258.27,330.2 CSDPS225.C7 ; CSDPS225.C7 259.08,331.01 ; CSDPS225.C7 259.08,329.39 ; CSDPS225.C7 259.89,330.2 ; D431.B13 170.18,381.81 ; D431.B13 170.99,381 ; D431.B13 169.37,381 ; D431.B13 170.18,380.19 ; D114.B1 347.98,351.33 ; D114.B1 347.17,350.52 ; D114.B1 347.98,349.71 ; D114.B1 348.79,350.52 ; D128.B4 21.13,40.64 ; D128.B4 20.32,39.83 ; D128.B4 19.51,40.64 ; D128.B4 20.32,41.45 ; D102.A8 325.12,77.01 ; D102.A8 324.31,76.2 ; D102.A8 325.12,75.39 ; D102.A8 325.93,76.2 ; D431.B15 165.91,381 ; D431.B15 164.29,381 ; D431.B15 165.1,381.81 ; D431.B15 165.1,380.19 ; D112.A7 406.4,397.05 ; D112.A7 406.4,395.43 ; D112.A7 405.59,396.24 ; D112.A7 407.21,396.24 ; D115.B1 347.98,371.65 ; D115.B1 348.79,370.84 ; D115.B1 347.17,370.84 ; D115.B1 347.98,370.03 ; 255.83,71.12 D322.B10 ; D322.B10 257.25,71.12 ; D322.B10 256.54,71.83 ; D322.B10 256.54,70.41 ; 320.04,80.47 D102.B6 ; D102.B6 320.85,81.28 ; D102.B6 319.23,81.28 ; D102.B6 320.04,82.09 ; D306.B16 419.81,71.12 ; D306.B16 419.1,70.41 ; D306.B16 418.39,71.12 ; D306.B16 419.1,71.83 ; D129.B4 94.79,101.6 ; D129.B4 93.17,101.6 ; D129.B4 93.98,100.79 ; D129.B4 93.98,102.41 ; 44.91,101.6 D125.B14 ; D125.B14 45.72,102.41 ; D125.B14 46.53,101.6 ; D125.B14 45.72,100.79 ; D114.B7 333.55,350.52 ; D114.B7 332.74,351.33 ; D114.B7 332.74,349.71 ; D114.B7 331.93,350.52 ; SITE1.G3 250.33,241.81 ; SITE1.G3 250.81,241.33 ; SITE1.G3 249.85,241.33 ; SITE1.G3 250.33,240.85 ; 263.35,73.66 D122.A13 ; D122.A13 264.97,73.66 ; D122.A13 264.16,74.47 ; D122.A13 264.16,72.85 ; 321.77,73.66 D102.A7 ; D102.A7 322.58,72.85 ; D102.A7 322.58,74.47 ; D102.A7 323.39,73.66 ; 340.36,34.75 D104.A14 ; D104.A14 339.55,35.56 ; D104.A14 340.36,36.37 ; D104.A14 341.17,35.56 ; D102.B12 335.28,82.09 ; D102.B12 334.47,81.28 ; D102.B12 335.28,80.47 ; D102.B12 336.09,81.28 ; 309.17,86.36 D301.A2 ; D301.A2 309.88,85.65 ; D301.A2 309.88,87.07 ; D301.A2 310.59,86.36 ; 182.88,331.93 CSDPS229.B8 ; CSDPS229.B8 182.88,333.55 ; CSDPS229.B8 183.69,332.74 ; CSDPS229.B8 182.07,332.74 ; 331.93,355.6 D114.A7 ; D114.A7 332.74,356.41 ; D114.A7 332.74,354.79 ; D114.A7 333.55,355.6 ; D118.A9 180.34,74.47 ; D118.A9 181.15,73.66 ; D118.A9 179.53,73.66 ; D118.A9 180.34,72.85 ; 177.09,91.44 D317.B8 ; D317.B8 177.8,92.15 ; D317.B8 177.8,90.73 ; D317.B8 178.51,91.44 ; 243.03,330.2 CSDPS225.C13 ; CSDPS225.C13 244.65,330.2 ; CSDPS225.C13 243.84,329.39 ; CSDPS225.C13 243.84,331.01 ; D125.A2 15.24,97.33 ; D125.A2 15.24,95.71 ; D125.A2 16.05,96.52 ; D125.A2 14.43,96.52 ; D106.A9 402.13,73.66 ; D106.A9 400.51,73.66 ; D106.A9 401.32,72.85 ; D106.A9 401.32,74.47 ; 333.33,247.45 SITE2.G12 ; SITE2.G12 333.33,248.41 ; SITE2.G12 333.81,247.93 ; SITE2.G12 332.85,247.93 ; D302.B16 345.44,71.83 ; D302.B16 345.44,70.41 ; D302.B16 344.73,71.12 ; D302.B16 346.15,71.12 ; DPS1.A11 406.4,14.78 ; DPS1.A11 406.4,13.16 ; DPS1.A11 405.59,13.97 ; DPS1.A11 407.21,13.97 ; D125.A1 12.7,94.79 ; D125.A1 13.51,93.98 ; D125.A1 12.7,93.17 ; D125.A1 11.89,93.98 ; DPS3.C01 234.49,19.05 ; DPS3.C01 233.68,18.24 ; DPS3.C01 233.68,19.86 ; DPS3.C01 232.87,19.05 ; 166.83,378.46 D431.B14 ; D431.B14 167.64,379.27 ; D431.B14 168.45,378.46 ; D431.B14 167.64,377.65 ; 179.53,78.74 D118.B9 ; D118.B9 180.34,79.55 ; D118.B9 181.15,78.74 ; D118.B9 180.34,77.93 ; D110.A14 389.43,353.06 ; D110.A14 388.62,353.87 ; D110.A14 388.62,352.25 ; D110.A14 387.81,353.06 ; 413.21,60.96 D107.B14 ; D107.B14 414.83,60.96 ; D107.B14 414.02,61.77 ; D107.B14 414.02,60.15 ; D114.A11 323.39,355.6 ; D114.A11 322.58,356.41 ; D114.A11 322.58,354.79 ; D114.A11 321.77,355.6 ; D305.B9 402.03,88.9 ; D305.B9 401.32,88.19 ; D305.B9 400.61,88.9 ; D305.B9 401.32,89.61 ; D114.B4 340.36,348.79 ; D114.B4 340.36,347.17 ; D114.B4 339.55,347.98 ; D114.B4 341.17,347.98 ; 314.15,393.7 D116.A14 ; D116.A14 314.96,392.89 ; D116.A14 314.96,394.51 ; D116.A14 315.77,393.7 ; 390.45,63.5 D306.A5 ; D306.A5 391.87,63.5 ; D306.A5 391.16,62.79 ; D306.A5 391.16,64.21 ; D306.B4 389.33,71.12 ; D306.B4 387.91,71.12 ; D306.B4 388.62,71.83 ; D306.B4 388.62,70.41 ; D231.B4 193.04,369.11 ; D231.B4 193.04,367.49 ; D231.B4 192.23,368.3 ; D231.B4 193.85,368.3 ; 342.9,370.03 D115.B3 ; D115.B3 343.71,370.84 ; D115.B3 342.9,371.65 ; D115.B3 342.09,370.84 ; 403.05,327.66 D109.B8 ; D109.B8 403.86,328.47 ; D109.B8 403.86,326.85 ; D109.B8 404.67,327.66 ; DPS3.C05 244.65,19.05 ; DPS3.C05 243.84,19.86 ; DPS3.C05 243.84,18.24 ; DPS3.C05 243.03,19.05 ; 387.91,66.04 D306.A4 ; D306.A4 388.62,65.33 ; D306.A4 389.33,66.04 ; D306.A4 388.62,66.75 ; D108.A15 416.56,33.83 ; D108.A15 415.75,33.02 ; D108.A15 417.37,33.02 ; D108.A15 416.56,32.21 ; D112.B1 421.64,391.97 ; D112.B1 420.83,391.16 ; D112.B1 421.64,390.35 ; D112.B1 422.45,391.16 ; D103.A1 307.34,54.15 ; D103.A1 308.15,53.34 ; D103.A1 306.53,53.34 ; D103.A1 307.34,52.53 ; 334.57,71.12 D302.B12 ; D302.B12 335.28,70.41 ; D302.B12 335.99,71.12 ; D302.B12 335.28,71.83 ; D114.B12 320.04,348.79 ; D114.B12 320.04,347.17 ; D114.B12 320.85,347.98 ; D114.B12 319.23,347.98 ; D122.A9 254.81,73.66 ; D122.A9 253.19,73.66 ; D122.A9 254,74.47 ; D122.A9 254,72.85 ; 330.85,187.93 SITE4.G10 ; SITE4.G10 331.33,188.41 ; SITE4.G10 331.81,187.93 ; SITE4.G10 331.33,187.45 ; D302.A7 322.58,64.21 ; D302.A7 322.58,62.79 ; D302.A7 321.87,63.5 ; D302.A7 323.29,63.5 ; D111.A16 383.54,374.19 ; D111.A16 382.73,373.38 ; D111.A16 383.54,372.57 ; D111.A16 384.35,373.38 ; 243.13,68.58 D322.B5 ; D322.B5 244.55,68.58 ; D322.B5 243.84,67.87 ; D322.B5 243.84,69.29 ; 12.7,37.29 D128.B1 ; D128.B1 13.51,38.1 ; D128.B1 11.89,38.1 ; D128.B1 12.7,38.91 ; 321.77,58.42 D103.B7 ; D103.B7 323.39,58.42 ; D103.B7 322.58,57.61 ; D103.B7 322.58,59.23 ; 382.73,81.28 D106.B2 ; D106.B2 384.35,81.28 ; D106.B2 383.54,82.09 ; D106.B2 383.54,80.47 ; D317.B11 185.42,89.61 ; D317.B11 184.71,88.9 ; D317.B11 185.42,88.19 ; D317.B11 186.13,88.9 ; D131.B7 101.6,59.23 ; D131.B7 101.6,57.61 ; D131.B7 102.41,58.42 ; D131.B7 100.79,58.42 ; UNK3U2.4 97.4,176.4 ; UNK3U2.4 96.46,175.46 ; UNK3U2.4 97.4,174.52 ; UNK3U2.4 98.34,175.46 ; D301.A7 322.58,84.53 ; D301.A7 323.29,83.82 ; D301.A7 321.87,83.82 ; D301.A7 322.58,83.11 ; 339.55,60.96 D103.B14 ; D103.B14 340.36,60.15 ; D103.B14 340.36,61.77 ; D103.B14 341.17,60.96 ; D115.A5 337.82,376.73 ; D115.A5 337.82,375.11 ; D115.A5 337.01,375.92 ; D115.A5 338.63,375.92 ; D129.A11 112.57,93.98 ; D129.A11 111.76,93.17 ; D129.A11 110.95,93.98 ; D129.A11 111.76,94.79 ; D126.A10 36.37,76.2 ; D126.A10 35.56,77.01 ; D126.A10 35.56,75.39 ; D126.A10 34.75,76.2 ; D110.A4 414.02,353.87 ; D110.A4 413.21,353.06 ; D110.A4 414.83,353.06 ; D110.A4 414.02,352.25 ; 251.46,55.07 D123.A8 ; D123.A8 252.27,55.88 ; D123.A8 250.65,55.88 ; D123.A8 251.46,56.69 ; D124.B12 262.43,40.64 ; D124.B12 260.81,40.64 ; D124.B12 261.62,39.83 ; D124.B12 261.62,41.45 ; 403.05,76.2 D106.A10 ; D106.A10 404.67,76.2 ; D106.A10 403.86,77.01 ; D106.A10 403.86,75.39 ; 190.5,77.93 D118.B13 ; D118.B13 191.31,78.74 ; D118.B13 190.5,79.55 ; D118.B13 189.69,78.74 ; SITE3.G1 248.33,181.81 ; SITE3.G1 248.33,180.85 ; SITE3.G1 247.85,181.33 ; SITE3.G1 248.81,181.33 ; 327.66,395.43 D116.A9 ; D116.A9 327.66,397.05 ; D116.A9 328.47,396.24 ; D116.A9 326.85,396.24 ; 390.35,13.97 DPS1.A05 ; DPS1.A05 391.16,14.78 ; DPS1.A05 391.97,13.97 ; DPS1.A05 391.16,13.16 ; 344.63,81.28 D102.B16 ; D102.B16 345.44,82.09 ; D102.B16 346.25,81.28 ; D102.B16 345.44,80.47 ; D126.B9 33.83,78.74 ; D126.B9 33.02,77.93 ; D126.B9 32.21,78.74 ; D126.B9 33.02,79.55 ; 411.48,354.79 D110.A5 ; D110.A5 410.67,355.6 ; D110.A5 411.48,356.41 ; D110.A5 412.29,355.6 ; D113.A11 323.39,335.28 ; D113.A11 322.58,334.47 ; D113.A11 322.58,336.09 ; D113.A11 321.77,335.28 ; 124.46,60.15 D131.B16 ; D131.B16 123.65,60.96 ; D131.B16 124.46,61.77 ; D131.B16 125.27,60.96 ; CSDPS229.C1 201.47,330.2 ; CSDPS229.C1 200.66,329.39 ; CSDPS229.C1 199.85,330.2 ; CSDPS229.C1 200.66,331.01 ; D111.A5 412.29,375.92 ; D111.A5 411.48,375.11 ; D111.A5 411.48,376.73 ; D111.A5 410.67,375.92 ; D103.A11 333.55,53.34 ; D103.A11 332.74,54.15 ; D103.A11 332.74,52.53 ; D103.A11 331.93,53.34 ; 309.07,353.06 D114.A16 ; D114.A16 310.69,353.06 ; D114.A16 309.88,352.25 ; D114.A16 309.88,353.87 ; 393.7,65.33 D306.A6 ; D306.A6 394.41,66.04 ; D306.A6 393.7,66.75 ; D306.A6 392.99,66.04 ; 16.97,38.1 D128.B3 ; D128.B3 17.78,38.91 ; D128.B3 18.59,38.1 ; D128.B3 17.78,37.29 ; D321.B10 257.25,91.44 ; D321.B10 256.54,92.15 ; D321.B10 256.54,90.73 ; D321.B10 255.83,91.44 ; D126.B13 43.18,79.55 ; D126.B13 42.37,78.74 ; D126.B13 43.99,78.74 ; D126.B13 43.18,77.93 ; 328.33,240.85 SITE2.G1 ; SITE2.G1 328.33,241.81 ; SITE2.G1 327.85,241.33 ; SITE2.G1 328.81,241.33 ; 415.75,53.34 D107.A15 ; D107.A15 417.37,53.34 ; D107.A15 416.56,52.53 ; D107.A15 416.56,54.15 ; 405.59,38.1 D108.B11 ; D108.B11 407.21,38.1 ; D108.B11 406.4,38.91 ; D108.B11 406.4,37.29 ; D126.B2 15.24,82.09 ; D126.B2 16.05,81.28 ; D126.B2 15.24,80.47 ; D126.B2 14.43,81.28 ; D116.A6 336.09,393.7 ; D116.A6 335.28,394.51 ; D116.A6 334.47,393.7 ; D116.A6 335.28,392.89 ; 331.93,38.1 D104.B11 ; D104.B11 332.74,38.91 ; D104.B11 333.55,38.1 ; D104.B11 332.74,37.29 ; D116.A11 322.58,397.05 ; D116.A11 322.58,395.43 ; D116.A11 321.77,396.24 ; D116.A11 323.39,396.24 ; 240.59,66.04 D322.A4 ; D322.A4 241.3,65.33 ; D322.A4 241.3,66.75 ; D322.A4 242.01,66.04 ; D431.A3 195.58,386.89 ; D431.A3 194.77,386.08 ; D431.A3 195.58,385.27 ; D431.A3 196.39,386.08 ; D118.B8 178.61,81.28 ; D118.B8 176.99,81.28 ; D118.B8 177.8,80.47 ; D118.B8 177.8,82.09 ; D306.B9 402.03,68.58 ; D306.B9 401.32,67.87 ; D306.B9 400.61,68.58 ; D306.B9 401.32,69.29 ; CSDPS429.C7 185.42,341.17 ; CSDPS429.C7 185.42,339.55 ; CSDPS429.C7 184.61,340.36 ; CSDPS429.C7 186.23,340.36 ; CSDPS229.C7 185.42,331.01 ; CSDPS229.C7 185.42,329.39 ; CSDPS229.C7 184.61,330.2 ; CSDPS229.C7 186.23,330.2 ; DPS8.A05 190.5,416.1 ; DPS8.A05 190.5,414.48 ; DPS8.A05 189.69,415.29 ; DPS8.A05 191.31,415.29 ; 170.18,32.21 D120.A5 ; D120.A5 170.18,33.83 ; D120.A5 170.99,33.02 ; D120.A5 169.37,33.02 ; UNK4U1.4 482.59,186.05 ; UNK4U1.4 482.59,184.17 ; UNK4U1.4 481.65,185.11 ; UNK4U1.4 483.53,185.11 ; 248.11,33.02 D124.A7 ; D124.A7 248.92,33.83 ; D124.A7 248.92,32.21 ; D124.A7 249.73,33.02 ; 245.57,342.9 CSDPS425.B12 ; CSDPS425.B12 246.38,342.09 ; CSDPS425.B12 247.19,342.9 ; CSDPS425.B12 246.38,343.71 ; D125.A5 22.86,94.79 ; D125.A5 23.67,93.98 ; D125.A5 22.86,93.17 ; D125.A5 22.05,93.98 ; D231.B16 162.56,369.11 ; D231.B16 162.56,367.49 ; D231.B16 161.75,368.3 ; D231.B16 163.37,368.3 ; D322.A16 271.78,66.75 ; D322.A16 272.49,66.04 ; D322.A16 271.07,66.04 ; D322.A16 271.78,65.33 ; D318.A5 170.89,63.5 ; D318.A5 170.18,62.79 ; D318.A5 169.47,63.5 ; D318.A5 170.18,64.21 ; D318.A6 172.72,66.75 ; D318.A6 172.01,66.04 ; D318.A6 173.43,66.04 ; D318.A6 172.72,65.33 ; 330.33,187.45 SITE4.G9 ; SITE4.G9 330.33,188.41 ; SITE4.G9 329.85,187.93 ; SITE4.G9 330.81,187.93 ; DPS1.A15 416.56,14.78 ; DPS1.A15 415.75,13.97 ; DPS1.A15 417.37,13.97 ; DPS1.A15 416.56,13.16 ; 388.62,39.83 D108.B4 ; D108.B4 389.43,40.64 ; D108.B4 387.81,40.64 ; D108.B4 388.62,41.45 ; D302.B5 318.21,68.58 ; D302.B5 317.5,69.29 ; D302.B5 316.79,68.58 ; D302.B5 317.5,67.87 ; 391.16,395.43 D112.A13 ; D112.A13 391.97,396.24 ; D112.A13 390.35,396.24 ; D112.A13 391.16,397.05 ; D115.B7 332.74,371.65 ; D115.B7 332.74,370.03 ; D115.B7 331.93,370.84 ; D115.B7 333.55,370.84 ; 268.43,58.42 D123.B15 ; D123.B15 269.24,57.61 ; D123.B15 270.05,58.42 ; D123.B15 269.24,59.23 ; D109.B2 419.91,327.66 ; D109.B2 418.29,327.66 ; D109.B2 419.1,326.85 ; D109.B2 419.1,328.47 ; 243.84,83.11 D321.A5 ; D321.A5 244.55,83.82 ; D321.A5 243.13,83.82 ; D321.A5 243.84,84.53 ; 175.26,32.21 D120.A7 ; D120.A7 175.26,33.83 ; D120.A7 174.45,33.02 ; D120.A7 176.07,33.02 ; 264.16,67.87 D322.B13 ; D322.B13 264.87,68.58 ; D322.B13 264.16,69.29 ; D322.B13 263.45,68.58 ; 405.59,73.66 D106.A11 ; D106.A11 406.4,72.85 ; D106.A11 407.21,73.66 ; D106.A11 406.4,74.47 ; D128.B16 50.8,41.45 ; D128.B16 50.8,39.83 ; D128.B16 51.61,40.64 ; D128.B16 49.99,40.64 ; 124.46,75.39 D130.A16 ; D130.A16 125.27,76.2 ; D130.A16 124.46,77.01 ; D130.A16 123.65,76.2 ; D119.A8 177.8,56.69 ; D119.A8 178.61,55.88 ; D119.A8 177.8,55.07 ; D119.A8 176.99,55.88 ; 390.45,88.9 D305.B5 ; D305.B5 391.16,89.61 ; D305.B5 391.87,88.9 ; D305.B5 391.16,88.19 ; SITE2.G6 333.81,241.33 ; SITE2.G6 333.33,241.81 ; SITE2.G6 332.85,241.33 ; SITE2.G6 333.33,240.85 ; 330.85,241.33 SITE2.G4 ; SITE2.G4 331.33,241.81 ; SITE2.G4 331.33,240.85 ; SITE2.G4 331.81,241.33 ; D120.A6 172.72,36.37 ; D120.A6 171.91,35.56 ; D120.A6 173.53,35.56 ; D120.A6 172.72,34.75 ; D118.A4 168.45,76.2 ; D118.A4 167.64,75.39 ; D118.A4 166.83,76.2 ; D118.A4 167.64,77.01 ; 309.07,373.38 D115.A16 ; D115.A16 310.69,373.38 ; D115.A16 309.88,374.19 ; D115.A16 309.88,372.57 ; D301.A11 332.74,84.53 ; D301.A11 332.03,83.82 ; D301.A11 332.74,83.11 ; D301.A11 333.45,83.82 ; 238.76,57.61 D123.B3 ; D123.B3 239.57,58.42 ; D123.B3 238.76,59.23 ; D123.B3 237.95,58.42 ; D119.B2 163.37,60.96 ; D119.B2 162.56,61.77 ; D119.B2 161.75,60.96 ; D119.B2 162.56,60.15 ; 400.51,391.16 D112.B9 ; D112.B9 401.32,390.35 ; D112.B9 401.32,391.97 ; D112.B9 402.13,391.16 ; 403.15,66.04 D306.A10 ; D306.A10 403.86,65.33 ; D306.A10 403.86,66.75 ; D306.A10 404.57,66.04 ; 258.37,68.58 D322.B11 ; D322.B11 259.79,68.58 ; D322.B11 259.08,69.29 ; D322.B11 259.08,67.87 ; 166.93,66.04 D318.A4 ; D318.A4 168.35,66.04 ; D318.A4 167.64,66.75 ; D318.A4 167.64,65.33 ; 329.39,353.06 D114.A8 ; D114.A8 330.2,352.25 ; D114.A8 331.01,353.06 ; D114.A8 330.2,353.87 ; D111.A10 398.78,374.19 ; D111.A10 398.78,372.57 ; D111.A10 399.59,373.38 ; D111.A10 397.97,373.38 ; D431.A5 190.5,386.89 ; D431.A5 190.5,385.27 ; D431.A5 189.69,386.08 ; D431.A5 191.31,386.08 ; D130.B5 97.33,78.74 ; D130.B5 96.52,77.93 ; D130.B5 96.52,79.55 ; D130.B5 95.71,78.74 ; 270.97,76.2 D122.A16 ; D122.A16 271.78,75.39 ; D122.A16 271.78,77.01 ; D122.A16 272.59,76.2 ; 43.18,37.29 D128.B13 ; D128.B13 42.37,38.1 ; D128.B13 43.99,38.1 ; D128.B13 43.18,38.91 ; 180.34,380.19 D431.B9 ; D431.B9 181.15,381 ; D431.B9 179.53,381 ; D431.B9 180.34,381.81 ; D120.B11 186.23,38.1 ; D120.B11 185.42,37.29 ; D120.B11 185.42,38.91 ; D120.B11 184.61,38.1 ; 22.86,77.93 D126.B5 ; D126.B5 22.86,79.55 ; D126.B5 23.67,78.74 ; D126.B5 22.05,78.74 ; 174.45,410.21 DPS8.C11 ; DPS8.C11 175.26,409.4 ; DPS8.C11 176.07,410.21 ; DPS8.C11 175.26,411.02 ; D114.A14 314.96,353.87 ; D114.A14 314.15,353.06 ; D114.A14 314.96,352.25 ; D114.A14 315.77,353.06 ; D131.B11 112.57,58.42 ; D131.B11 111.76,59.23 ; D131.B11 111.76,57.61 ; D131.B11 110.95,58.42 ; 314.96,60.15 D103.B4 ; D103.B4 315.77,60.96 ; D103.B4 314.15,60.96 ; D103.B4 314.96,61.77 ; 114.3,60.15 D131.B12 ; D131.B12 114.3,61.77 ; D131.B12 113.49,60.96 ; D131.B12 115.11,60.96 ; D106.A12 408.94,77.01 ; D106.A12 408.13,76.2 ; D106.A12 409.75,76.2 ; D106.A12 408.94,75.39 ; D113.A1 348.79,335.28 ; D113.A1 347.98,336.09 ; D113.A1 347.98,334.47 ; D113.A1 347.17,335.28 ; 329.33,187.45 SITE4.G8 ; SITE4.G8 328.85,187.93 ; SITE4.G8 329.81,187.93 ; SITE4.G8 329.33,188.41 ; 266.7,90.73 D321.B14 ; D321.B14 267.41,91.44 ; D321.B14 265.99,91.44 ; D321.B14 266.7,92.15 ; 124.46,55.07 D131.A16 ; D131.A16 125.27,55.88 ; D131.A16 124.46,56.69 ; D131.A16 123.65,55.88 ; D131.A5 96.52,54.15 ; D131.A5 97.33,53.34 ; D131.A5 96.52,52.53 ; D131.A5 95.71,53.34 ; D128.B11 38.91,38.1 ; D128.B11 37.29,38.1 ; D128.B11 38.1,37.29 ; D128.B11 38.1,38.91 ; 190.5,67.87 D318.B13 ; D318.B13 189.79,68.58 ; D318.B13 190.5,69.29 ; D318.B13 191.21,68.58 ; 316.69,73.66 D102.A5 ; D102.A5 318.31,73.66 ; D102.A5 317.5,74.47 ; D102.A5 317.5,72.85 ; CSDPS229.C11 175.26,331.01 ; CSDPS229.C11 176.07,330.2 ; CSDPS229.C11 174.45,330.2 ; CSDPS229.C11 175.26,329.39 ; 414.02,387.81 D112.B4 ; D112.B4 413.21,388.62 ; D112.B4 414.83,388.62 ; D112.B4 414.02,389.43 ; 408.13,332.74 D109.A6 ; D109.A6 408.94,331.93 ; D109.A6 409.75,332.74 ; D109.A6 408.94,333.55 ; D111.A8 404.67,373.38 ; D111.A8 403.86,372.57 ; D111.A8 403.05,373.38 ; D111.A8 403.86,374.19 ; 380.19,73.66 D106.A1 ; D106.A1 381,72.85 ; D106.A1 381.81,73.66 ; D106.A1 381,74.47 ; 418.39,91.44 D305.B16 ; D305.B16 419.81,91.44 ; D305.B16 419.1,92.15 ; D305.B16 419.1,90.73 ; 177.8,85.65 D317.A8 ; D317.A8 177.09,86.36 ; D317.A8 178.51,86.36 ; D317.A8 177.8,87.07 ; 251.85,187.93 SITE3.G11 ; SITE3.G11 252.81,187.93 ; SITE3.G11 252.33,187.45 ; SITE3.G11 252.33,188.41 ; 174.45,381 D431.B11 ; D431.B11 175.26,380.19 ; D431.B11 175.26,381.81 ; D431.B11 176.07,381 ; 249.85,181.33 SITE3.G3 ; SITE3.G3 250.33,181.81 ; SITE3.G3 250.81,181.33 ; SITE3.G3 250.33,180.85 ; D130.B13 116.84,79.55 ; D130.B13 116.03,78.74 ; D130.B13 117.65,78.74 ; D130.B13 116.84,77.93 ; D119.A13 190.5,54.15 ; D119.A13 190.5,52.53 ; D119.A13 189.69,53.34 ; D119.A13 191.31,53.34 ; D102.B13 338.63,78.74 ; D102.B13 337.82,79.55 ; D102.B13 337.01,78.74 ; D102.B13 337.82,77.93 ; 321.87,68.58 D302.B7 ; D302.B7 322.58,67.87 ; D302.B7 323.29,68.58 ; D302.B7 322.58,69.29 ; 248.92,329.39 CSDPS225.C11 ; CSDPS225.C11 248.11,330.2 ; CSDPS225.C11 249.73,330.2 ; CSDPS225.C11 248.92,331.01 ; D126.B12 41.45,81.28 ; D126.B12 40.64,80.47 ; D126.B12 40.64,82.09 ; D126.B12 39.83,81.28 ; D301.B8 325.83,91.44 ; D301.B8 325.12,92.15 ; D301.B8 325.12,90.73 ; D301.B8 324.41,91.44 ; 307.34,37.29 D104.B1 ; D104.B1 307.34,38.91 ; D104.B1 308.15,38.1 ; D104.B1 306.53,38.1 ; 85.55,73.66 D130.A1 ; D130.A1 86.36,74.47 ; D130.A1 87.17,73.66 ; D130.A1 86.36,72.85 ; D115.A11 322.58,376.73 ; D115.A11 322.58,375.11 ; D115.A11 321.77,375.92 ; D115.A11 323.39,375.92 ; D132.A9 106.68,33.83 ; D132.A9 107.49,33.02 ; D132.A9 105.87,33.02 ; D132.A9 106.68,32.21 ; D104.B12 336.09,40.64 ; D104.B12 335.28,39.83 ; D104.B12 334.47,40.64 ; D104.B12 335.28,41.45 ; D112.A16 383.54,394.51 ; D112.A16 384.35,393.7 ; D112.A16 383.54,392.89 ; D112.A16 382.73,393.7 ; D127.B4 21.13,60.96 ; D127.B4 20.32,61.77 ; D127.B4 19.51,60.96 ; D127.B4 20.32,60.15 ; D103.B15 343.71,58.42 ; D103.B15 342.9,59.23 ; D103.B15 342.09,58.42 ; D103.B15 342.9,57.61 ; 250.33,247.45 SITE1.G9 ; SITE1.G9 250.33,248.41 ; SITE1.G9 249.85,247.93 ; SITE1.G9 250.81,247.93 ; D113.A3 342.9,336.09 ; D113.A3 342.09,335.28 ; D113.A3 343.71,335.28 ; D113.A3 342.9,334.47 ; 332.74,395.43 D116.A7 ; D116.A7 333.55,396.24 ; D116.A7 331.93,396.24 ; D116.A7 332.74,397.05 ; D112.A1 421.64,397.05 ; D112.A1 422.45,396.24 ; D112.A1 420.83,396.24 ; D112.A1 421.64,395.43 ; 193.04,65.33 D318.A14 ; D318.A14 192.33,66.04 ; D318.A14 193.75,66.04 ; D318.A14 193.04,66.75 ; D306.A1 381,64.21 ; D306.A1 380.29,63.5 ; D306.A1 381,62.79 ; D306.A1 381.71,63.5 ; 187.15,40.64 D120.B12 ; D120.B12 188.77,40.64 ; D120.B12 187.96,39.83 ; D120.B12 187.96,41.45 ; D118.A13 191.31,73.66 ; D118.A13 190.5,74.47 ; D118.A13 190.5,72.85 ; D118.A13 189.69,73.66 ; CSDPS425.B8 256.54,343.71 ; CSDPS425.B8 255.73,342.9 ; CSDPS425.B8 257.35,342.9 ; CSDPS425.B8 256.54,342.09 ; D107.B16 419.1,61.77 ; D107.B16 418.29,60.96 ; D107.B16 419.91,60.96 ; D107.B16 419.1,60.15 ; 395.43,335.28 D109.A11 ; D109.A11 396.24,336.09 ; D109.A11 397.05,335.28 ; D109.A11 396.24,334.47 ; 270.97,60.96 D123.B16 ; D123.B16 271.78,61.77 ; D123.B16 272.59,60.96 ; D123.B16 271.78,60.15 ; D301.B15 343.61,88.9 ; D301.B15 342.9,88.19 ; D301.B15 342.9,89.61 ; D301.B15 342.19,88.9 ; D124.A16 271.78,36.37 ; D124.A16 270.97,35.56 ; D124.A16 271.78,34.75 ; D124.A16 272.59,35.56 ; 268.43,13.97 DPS3.A15 ; DPS3.A15 269.24,13.16 ; DPS3.A15 270.05,13.97 ; DPS3.A15 269.24,14.78 ; 199.85,340.36 CSDPS429.C1 ; CSDPS429.C1 200.66,339.55 ; CSDPS429.C1 200.66,341.17 ; CSDPS429.C1 201.47,340.36 ; D115.A13 317.5,376.73 ; D115.A13 317.5,375.11 ; D115.A13 316.69,375.92 ; D115.A13 318.31,375.92 ; 100.79,73.66 D130.A7 ; D130.A7 101.6,74.47 ; D130.A7 102.41,73.66 ; D130.A7 101.6,72.85 ; D431.A10 178.61,383.54 ; D431.A10 177.8,384.35 ; D431.A10 176.99,383.54 ; D431.A10 177.8,382.73 ; 251.43,245.95 SITE1.G19 ; SITE1.G19 251.43,246.91 ; SITE1.G19 250.95,246.43 ; SITE1.G19 251.91,246.43 ; 124.46,34.75 D132.A16 ; D132.A16 124.46,36.37 ; D132.A16 125.27,35.56 ; D132.A16 123.65,35.56 ; D131.A15 122.73,53.34 ; D131.A15 121.11,53.34 ; D131.A15 121.92,54.15 ; D131.A15 121.92,52.53 ; D109.B16 383.54,328.47 ; D109.B16 383.54,326.85 ; D109.B16 384.35,327.66 ; D109.B16 382.73,327.66 ; 184.61,33.02 D120.A11 ; D120.A11 186.23,33.02 ; D120.A11 185.42,33.83 ; D120.A11 185.42,32.21 ; D107.A7 397.05,53.34 ; D107.A7 395.43,53.34 ; D107.A7 396.24,52.53 ; D107.A7 396.24,54.15 ; 317.5,62.79 D302.A5 ; D302.A5 318.21,63.5 ; D302.A5 317.5,64.21 ; D302.A5 316.79,63.5 ; 185.42,375.11 D231.A7 ; D231.A7 186.23,375.92 ; D231.A7 185.42,376.73 ; D231.A7 184.61,375.92 ; D119.A12 188.77,55.88 ; D119.A12 187.15,55.88 ; D119.A12 187.96,56.69 ; D119.A12 187.96,55.07 ; 504.01,203.45 S2_I2C.4 ; S2_I2C.4 504.95,202.51 ; S2_I2C.4 504.95,204.39 ; S2_I2C.4 505.89,203.45 ; 266.7,39.83 D124.B14 ; D124.B14 267.51,40.64 ; D124.B14 265.89,40.64 ; D124.B14 266.7,41.45 ; 103.33,81.28 D130.B8 ; D130.B8 104.95,81.28 ; D130.B8 104.14,80.47 ; D130.B8 104.14,82.09 ; CSDPS225.B12 247.19,332.74 ; CSDPS225.B12 246.38,333.55 ; CSDPS225.B12 245.57,332.74 ; CSDPS225.B12 246.38,331.93 ; 243.03,38.1 D124.B5 ; D124.B5 244.65,38.1 ; D124.B5 243.84,38.91 ; D124.B5 243.84,37.29 ; D302.A6 320.75,66.04 ; D302.A6 320.04,65.33 ; D302.A6 319.33,66.04 ; D302.A6 320.04,66.75 ; D318.A13 191.21,63.5 ; D318.A13 190.5,64.21 ; D318.A13 190.5,62.79 ; D318.A13 189.79,63.5 ; 416.56,370.03 D111.B3 ; D111.B3 417.37,370.84 ; D111.B3 416.56,371.65 ; D111.B3 415.75,370.84 ; 330.2,55.07 D103.A10 ; D103.A10 330.2,56.69 ; D103.A10 331.01,55.88 ; D103.A10 329.39,55.88 ; SITE4.G17 329.51,186.43 ; SITE4.G17 329.03,186.91 ; SITE4.G17 328.55,186.43 ; SITE4.G17 329.03,185.95 ; 194.87,83.82 D317.A15 ; D317.A15 196.29,83.82 ; D317.A15 195.58,83.11 ; D317.A15 195.58,84.53 ; D306.B2 384.25,71.12 ; D306.B2 383.54,71.83 ; D306.B2 382.83,71.12 ; D306.B2 383.54,70.41 ; 413.21,393.7 D112.A4 ; D112.A4 414.83,393.7 ; D112.A4 414.02,394.51 ; D112.A4 414.02,392.89 ; D131.A2 89.71,55.88 ; D131.A2 88.9,55.07 ; D131.A2 88.9,56.69 ; D131.A2 88.09,55.88 ; D109.B7 406.4,331.01 ; D109.B7 407.21,330.2 ; D109.B7 405.59,330.2 ; D109.B7 406.4,329.39 ; 386.08,395.43 D112.A15 ; D112.A15 385.27,396.24 ; D112.A15 386.89,396.24 ; D112.A15 386.08,397.05 ; D115.B14 314.96,369.11 ; D115.B14 314.96,367.49 ; D115.B14 314.15,368.3 ; D115.B14 315.77,368.3 ; D125.A7 27.94,94.79 ; D125.A7 27.13,93.98 ; D125.A7 28.75,93.98 ; D125.A7 27.94,93.17 ; 386.08,390.35 D112.B15 ; D112.B15 385.27,391.16 ; D112.B15 386.08,391.97 ; D112.B15 386.89,391.16 ; D301.B11 333.45,88.9 ; D301.B11 332.74,89.61 ; D301.B11 332.74,88.19 ; D301.B11 332.03,88.9 ; D301.A15 342.9,84.53 ; D301.A15 342.19,83.82 ; D301.A15 343.61,83.82 ; D301.A15 342.9,83.11 ; D115.A4 340.36,374.19 ; D115.A4 340.36,372.57 ; D115.A4 341.17,373.38 ; D115.A4 339.55,373.38 ; 12.7,98.25 D125.B1 ; D125.B1 13.51,99.06 ; D125.B1 11.89,99.06 ; D125.B1 12.7,99.87 ; 251.33,187.45 SITE3.G10 ; SITE3.G10 250.85,187.93 ; SITE3.G10 251.33,188.41 ; SITE3.G10 251.81,187.93 ; 388.62,326.85 D109.B14 ; D109.B14 387.81,327.66 ; D109.B14 389.43,327.66 ; D109.B14 388.62,328.47 ; D120.B7 175.26,38.91 ; D120.B7 174.45,38.1 ; D120.B7 175.26,37.29 ; D120.B7 176.07,38.1 ; D306.B7 396.95,68.58 ; D306.B7 396.24,67.87 ; D306.B7 395.53,68.58 ; D306.B7 396.24,69.29 ; D322.B1 233.68,69.29 ; D322.B1 232.97,68.58 ; D322.B1 233.68,67.87 ; D322.B1 234.39,68.58 ; 22.86,72.85 D126.A5 ; D126.A5 22.86,74.47 ; D126.A5 23.67,73.66 ; D126.A5 22.05,73.66 ; D126.B14 45.72,82.09 ; D126.B14 45.72,80.47 ; D126.B14 46.53,81.28 ; D126.B14 44.91,81.28 ; 320.04,60.15 D103.B6 ; D103.B6 320.04,61.77 ; D103.B6 319.23,60.96 ; D103.B6 320.85,60.96 ; D116.A5 338.63,396.24 ; D116.A5 337.01,396.24 ; D116.A5 337.82,395.43 ; D116.A5 337.82,397.05 ; 182.88,90.73 D317.B10 ; D317.B10 182.88,92.15 ; D317.B10 183.59,91.44 ; D317.B10 182.17,91.44 ; 169.37,53.34 D119.A5 ; D119.A5 170.18,52.53 ; D119.A5 170.18,54.15 ; D119.A5 170.99,53.34 ; D120.B2 163.37,40.64 ; D120.B2 162.56,41.45 ; D120.B2 162.56,39.83 ; D120.B2 161.75,40.64 ; D112.B7 406.4,391.97 ; D112.B7 406.4,390.35 ; D112.B7 405.59,391.16 ; D112.B7 407.21,391.16 ; D113.B2 345.44,328.47 ; D113.B2 346.25,327.66 ; D113.B2 345.44,326.85 ; D113.B2 344.63,327.66 ; 169.37,78.74 D118.B5 ; D118.B5 170.18,79.55 ; D118.B5 170.99,78.74 ; D118.B5 170.18,77.93 ; D114.A10 325.93,353.06 ; D114.A10 325.12,353.87 ; D114.A10 325.12,352.25 ; D114.A10 324.31,353.06 ; D317.B12 187.96,92.15 ; D317.B12 187.25,91.44 ; D317.B12 187.96,90.73 ; D317.B12 188.67,91.44 ; 199.85,381 D431.B1 ; D431.B1 201.47,381 ; D431.B1 200.66,380.19 ; D431.B1 200.66,381.81 ; D124.A2 237.03,35.56 ; D124.A2 236.22,36.37 ; D124.A2 236.22,34.75 ; D124.A2 235.41,35.56 ; D317.B15 195.58,89.61 ; D317.B15 196.29,88.9 ; D317.B15 194.87,88.9 ; D317.B15 195.58,88.19 ; 44.91,35.56 D128.A14 ; D128.A14 45.72,36.37 ; D128.A14 45.72,34.75 ; D128.A14 46.53,35.56 ; 311.71,68.58 D302.B3 ; D302.B3 312.42,67.87 ; D302.B3 313.13,68.58 ; D302.B3 312.42,69.29 ; 392.99,91.44 D305.B6 ; D305.B6 393.7,90.73 ; D305.B6 393.7,92.15 ; D305.B6 394.41,91.44 ; D107.B3 386.08,59.23 ; D107.B3 386.89,58.42 ; D107.B3 386.08,57.61 ; D107.B3 385.27,58.42 ; DPS8.C05 191.31,410.21 ; DPS8.C05 190.5,411.02 ; DPS8.C05 189.69,410.21 ; DPS8.C05 190.5,409.4 ; 198.12,39.83 D120.B16 ; D120.B16 198.93,40.64 ; D120.B16 198.12,41.45 ; D120.B16 197.31,40.64 ; 248.92,67.87 D322.B7 ; D322.B7 248.21,68.58 ; D322.B7 248.92,69.29 ; D322.B7 249.63,68.58 ; D306.B5 391.87,68.58 ; D306.B5 391.16,67.87 ; D306.B5 391.16,69.29 ; D306.B5 390.45,68.58 ; CSDPS429.B14 168.45,342.9 ; CSDPS429.B14 167.64,343.71 ; CSDPS429.B14 166.83,342.9 ; CSDPS429.B14 167.64,342.09 ; 340.36,75.39 D102.A14 ; D102.A14 341.17,76.2 ; D102.A14 339.55,76.2 ; D102.A14 340.36,77.01 ; 403.05,347.98 D110.B8 ; D110.B8 404.67,347.98 ; D110.B8 403.86,347.17 ; D110.B8 403.86,348.79 ; D115.B9 328.47,370.84 ; D115.B9 327.66,370.03 ; D115.B9 327.66,371.65 ; D115.B9 326.85,370.84 ; 314.15,81.28 D102.B4 ; D102.B4 314.96,80.47 ; D102.B4 314.96,82.09 ; D102.B4 315.77,81.28 ; D321.A14 267.41,86.36 ; D321.A14 265.99,86.36 ; D321.A14 266.7,85.65 ; D321.A14 266.7,87.07 ; 408.94,80.47 D106.B12 ; D106.B12 408.13,81.28 ; D106.B12 409.75,81.28 ; D106.B12 408.94,82.09 ; 326.85,375.92 D115.A9 ; D115.A9 327.66,376.73 ; D115.A9 327.66,375.11 ; D115.A9 328.47,375.92 ; D111.A11 397.05,375.92 ; D111.A11 396.24,376.73 ; D111.A11 395.43,375.92 ; D111.A11 396.24,375.11 ; CSDPS225.C9 254,331.01 ; CSDPS225.C9 253.19,330.2 ; CSDPS225.C9 254.81,330.2 ; CSDPS225.C9 254,329.39 ; D127.A10 36.37,55.88 ; D127.A10 34.75,55.88 ; D127.A10 35.56,55.07 ; D127.A10 35.56,56.69 ; D109.A3 417.37,335.28 ; D109.A3 416.56,336.09 ; D109.A3 416.56,334.47 ; D109.A3 415.75,335.28 ; 319.23,373.38 D115.A12 ; D115.A12 320.04,374.19 ; D115.A12 320.85,373.38 ; D115.A12 320.04,372.57 ; D118.B2 162.56,82.09 ; D118.B2 161.75,81.28 ; D118.B2 163.37,81.28 ; D118.B2 162.56,80.47 ; 165.1,329.39 CSDPS229.C15 ; CSDPS229.C15 164.29,330.2 ; CSDPS229.C15 165.91,330.2 ; CSDPS229.C15 165.1,331.01 ; D322.A13 264.16,64.21 ; D322.A13 264.16,62.79 ; D322.A13 263.45,63.5 ; D322.A13 264.87,63.5 ; 187.96,377.65 D431.B6 ; D431.B6 188.77,378.46 ; D431.B6 187.96,379.27 ; D431.B6 187.15,378.46 ; 95.71,93.98 D129.A5 ; D129.A5 96.52,93.17 ; D129.A5 96.52,94.79 ; D129.A5 97.33,93.98 ; 393.7,347.17 D110.B12 ; D110.B12 392.89,347.98 ; D110.B12 393.7,348.79 ; D110.B12 394.51,347.98 ; 330.2,60.15 D103.B10 ; D103.B10 329.39,60.96 ; D103.B10 331.01,60.96 ; D103.B10 330.2,61.77 ; 169.37,330.2 CSDPS229.C13 ; CSDPS229.C13 170.18,331.01 ; CSDPS229.C13 170.99,330.2 ; CSDPS229.C13 170.18,329.39 ; D113.A5 338.63,335.28 ; D113.A5 337.82,336.09 ; D113.A5 337.82,334.47 ; D113.A5 337.01,335.28 ; D109.A9 401.32,336.09 ; D109.A9 401.32,334.47 ; D109.A9 400.51,335.28 ; D109.A9 402.13,335.28 ; D116.B1 348.79,391.16 ; D116.B1 347.98,390.35 ; D116.B1 347.98,391.97 ; D116.B1 347.17,391.16 ; D131.B8 104.14,61.77 ; D131.B8 103.33,60.96 ; D131.B8 104.14,60.15 ; D131.B8 104.95,60.96 ; 194.77,375.92 D231.A3 ; D231.A3 195.58,375.11 ; D231.A3 196.39,375.92 ; D231.A3 195.58,376.73 ; DPS1.A01 381.81,13.97 ; DPS1.A01 380.19,13.97 ; DPS1.A01 381,14.78 ; DPS1.A01 381,13.16 ; SITE1.G17 249.51,246.43 ; SITE1.G17 249.03,246.91 ; SITE1.G17 248.55,246.43 ; SITE1.G17 249.03,245.95 ; D112.A6 409.75,393.7 ; D112.A6 408.94,392.89 ; D112.A6 408.13,393.7 ; D112.A6 408.94,394.51 ; D120.A16 198.12,36.37 ; D120.A16 198.93,35.56 ; D120.A16 197.31,35.56 ; D120.A16 198.12,34.75 ; 108.41,81.28 D130.B10 ; D130.B10 109.22,82.09 ; D130.B10 109.22,80.47 ; D130.B10 110.03,81.28 ; 96.52,57.61 D131.B5 ; D131.B5 95.71,58.42 ; D131.B5 96.52,59.23 ; D131.B5 97.33,58.42 ; D120.A4 167.64,36.37 ; D120.A4 167.64,34.75 ; D120.A4 168.45,35.56 ; D120.A4 166.83,35.56 ; 182.88,80.47 D118.B10 ; D118.B10 182.88,82.09 ; D118.B10 182.07,81.28 ; D118.B10 183.69,81.28 ; 166.83,40.64 D120.B4 ; D120.B4 168.45,40.64 ; D120.B4 167.64,41.45 ; D120.B4 167.64,39.83 ; SITE3.G13 249.51,182.83 ; SITE3.G13 249.03,182.35 ; SITE3.G13 249.03,183.31 ; SITE3.G13 248.55,182.83 ; D119.A7 176.07,53.34 ; D119.A7 175.26,52.53 ; D119.A7 175.26,54.15 ; D119.A7 174.45,53.34 ; D130.A15 122.73,73.66 ; D130.A15 121.11,73.66 ; D130.A15 121.92,74.47 ; D130.A15 121.92,72.85 ; 382.73,368.3 D111.B16 ; D111.B16 383.54,367.49 ; D111.B16 384.35,368.3 ; D111.B16 383.54,369.11 ; 398.07,71.12 D306.B8 ; D306.B8 398.78,71.83 ; D306.B8 399.49,71.12 ; D306.B8 398.78,70.41 ; 104.14,100.79 D129.B8 ; D129.B8 104.14,102.41 ; D129.B8 103.33,101.6 ; D129.B8 104.95,101.6 ; D111.B8 404.67,368.3 ; D111.B8 403.86,369.11 ; D111.B8 403.05,368.3 ; D111.B8 403.86,367.49 ; 337.82,72.85 D102.A13 ; D102.A13 338.63,73.66 ; D102.A13 337.82,74.47 ; D102.A13 337.01,73.66 ; 269.24,18.24 DPS3.C15 ; DPS3.C15 269.24,19.86 ; DPS3.C15 268.43,19.05 ; DPS3.C15 270.05,19.05 ; 325.12,60.15 D103.B8 ; D103.B8 325.12,61.77 ; D103.B8 324.31,60.96 ; D103.B8 325.93,60.96 ; 118.57,96.52 D129.A14 ; D129.A14 119.38,95.71 ; D129.A14 119.38,97.33 ; D129.A14 120.19,96.52 ; 174.55,88.9 D317.B7 ; D317.B7 175.26,88.19 ; D317.B7 175.26,89.61 ; D317.B7 175.97,88.9 ; D431.B8 182.88,379.27 ; D431.B8 183.69,378.46 ; D431.B8 182.88,377.65 ; D431.B8 182.07,378.46 ; 33.02,93.17 D125.A9 ; D125.A9 33.02,94.79 ; D125.A9 32.21,93.98 ; D125.A9 33.83,93.98 ; D108.A7 397.05,33.02 ; D108.A7 396.24,32.21 ; D108.A7 396.24,33.83 ; D108.A7 395.43,33.02 ; 195.58,32.21 D120.A15 ; D120.A15 196.39,33.02 ; D120.A15 195.58,33.83 ; D120.A15 194.77,33.02 ; D103.A14 341.17,55.88 ; D103.A14 340.36,56.69 ; D103.A14 339.55,55.88 ; D103.A14 340.36,55.07 ; 415.75,391.16 D112.B3 ; D112.B3 416.56,390.35 ; D112.B3 416.56,391.97 ; D112.B3 417.37,391.16 ; SITE4.G15 331.91,182.83 ; SITE4.G15 331.43,183.31 ; SITE4.G15 330.95,182.83 ; SITE4.G15 331.43,182.35 ; D125.B8 30.48,102.41 ; D125.B8 30.48,100.79 ; D125.B8 31.29,101.6 ; D125.B8 29.67,101.6 ; 401.32,375.11 D111.A9 ; D111.A9 402.13,375.92 ; D111.A9 400.51,375.92 ; D111.A9 401.32,376.73 ; 307.34,32.21 D104.A1 ; D104.A1 306.53,33.02 ; D104.A1 307.34,33.83 ; D104.A1 308.15,33.02 ; D318.B2 163.27,71.12 ; D318.B2 162.56,70.41 ; D318.B2 161.85,71.12 ; D318.B2 162.56,71.83 ; 334.47,55.88 D103.A12 ; D103.A12 336.09,55.88 ; D103.A12 335.28,55.07 ; D103.A12 335.28,56.69 ; D104.B7 323.39,38.1 ; D104.B7 322.58,37.29 ; D104.B7 321.77,38.1 ; D104.B7 322.58,38.91 ; D113.A12 320.85,332.74 ; D113.A12 320.04,333.55 ; D113.A12 320.04,331.93 ; D113.A12 319.23,332.74 ; D115.A1 348.79,375.92 ; D115.A1 347.17,375.92 ; D115.A1 347.98,375.11 ; D115.A1 347.98,376.73 ; D113.B1 347.98,331.01 ; D113.B1 347.17,330.2 ; D113.B1 347.98,329.39 ; D113.B1 348.79,330.2 ; 307.34,67.87 D302.B1 ; D302.B1 306.63,68.58 ; D302.B1 307.34,69.29 ; D302.B1 308.05,68.58 ; D127.B6 26.21,60.96 ; D127.B6 25.4,60.15 ; D127.B6 25.4,61.77 ; D127.B6 24.59,60.96 ; 382.73,76.2 D106.A2 ; D106.A2 383.54,77.01 ; D106.A2 384.35,76.2 ; D106.A2 383.54,75.39 ; 342.9,390.35 D116.B3 ; D116.B3 342.9,391.97 ; D116.B3 342.09,391.16 ; D116.B3 343.71,391.16 ; 249.33,247.45 SITE1.G8 ; SITE1.G8 249.81,247.93 ; SITE1.G8 248.85,247.93 ; SITE1.G8 249.33,248.41 ; 332.33,240.85 SITE2.G5 ; SITE2.G5 332.33,241.81 ; SITE2.G5 331.85,241.33 ; SITE2.G5 332.81,241.33 ; 311.71,63.5 D302.A3 ; D302.A3 313.13,63.5 ; D302.A3 312.42,62.79 ; D302.A3 312.42,64.21 ; 325.12,65.33 D302.A8 ; D302.A8 324.41,66.04 ; D302.A8 325.83,66.04 ; D302.A8 325.12,66.75 ; D132.B9 107.49,38.1 ; D132.B9 105.87,38.1 ; D132.B9 106.68,37.29 ; D132.B9 106.68,38.91 ; D113.B3 342.9,331.01 ; D113.B3 342.09,330.2 ; D113.B3 342.9,329.39 ; D113.B3 343.71,330.2 ; 121.11,33.02 D132.A15 ; D132.A15 121.92,32.21 ; D132.A15 121.92,33.83 ; D132.A15 122.73,33.02 ; D122.B6 247.19,81.28 ; D122.B6 246.38,82.09 ; D122.B6 246.38,80.47 ; D122.B6 245.57,81.28 ; 33.02,37.29 D128.B9 ; D128.B9 33.83,38.1 ; D128.B9 33.02,38.91 ; D128.B9 32.21,38.1 ; D125.B9 33.02,99.87 ; D125.B9 32.21,99.06 ; D125.B9 33.02,98.25 ; D125.B9 33.83,99.06 ; 254,57.61 D123.B9 ; D123.B9 254,59.23 ; D123.B9 253.19,58.42 ; D123.B9 254.81,58.42 ; 330.33,247.45 SITE2.G9 ; SITE2.G9 330.33,248.41 ; SITE2.G9 329.85,247.93 ; SITE2.G9 330.81,247.93 ; D131.A1 86.36,54.15 ; D131.A1 86.36,52.53 ; D131.A1 85.55,53.34 ; D131.A1 87.17,53.34 ; D111.B9 401.32,371.65 ; D111.B9 400.51,370.84 ; D111.B9 402.13,370.84 ; D111.B9 401.32,370.03 ; DPS1.C11 407.21,19.05 ; DPS1.C11 406.4,18.24 ; DPS1.C11 405.59,19.05 ; DPS1.C11 406.4,19.86 ; 340.36,326.85 D113.B4 ; D113.B4 340.36,328.47 ; D113.B4 339.55,327.66 ; D113.B4 341.17,327.66 ; D132.A6 99.06,36.37 ; D132.A6 98.25,35.56 ; D132.A6 99.06,34.75 ; D132.A6 99.87,35.56 ; 311.71,88.9 D301.B3 ; D301.B3 312.42,88.19 ; D301.B3 313.13,88.9 ; D301.B3 312.42,89.61 ; 27.94,32.21 D128.A7 ; D128.A7 27.13,33.02 ; D128.A7 27.94,33.83 ; D128.A7 28.75,33.02 ; 319.23,55.88 D103.A6 ; D103.A6 320.04,56.69 ; D103.A6 320.04,55.07 ; D103.A6 320.85,55.88 ; 317.5,349.71 D114.B13 ; D114.B13 316.69,350.52 ; D114.B13 317.5,351.33 ; D114.B13 318.31,350.52 ; 401.32,37.29 D108.B9 ; D108.B9 400.51,38.1 ; D108.B9 402.13,38.1 ; D108.B9 401.32,38.91 ; 243.13,63.5 D322.A5 ; D322.A5 244.55,63.5 ; D322.A5 243.84,62.79 ; D322.A5 243.84,64.21 ; 420.83,330.2 D109.B1 ; D109.B1 421.64,331.01 ; D109.B1 422.45,330.2 ; D109.B1 421.64,329.39 ; D111.A7 406.4,376.73 ; D111.A7 407.21,375.92 ; D111.A7 406.4,375.11 ; D111.A7 405.59,375.92 ; 256.54,331.93 CSDPS225.B8 ; CSDPS225.B8 257.35,332.74 ; CSDPS225.B8 255.73,332.74 ; CSDPS225.B8 256.54,333.55 ; CSDPS229.C5 190.5,331.01 ; CSDPS229.C5 189.69,330.2 ; CSDPS229.C5 191.31,330.2 ; CSDPS229.C5 190.5,329.39 ; 108.41,40.64 D132.B10 ; D132.B10 110.03,40.64 ; D132.B10 109.22,41.45 ; D132.B10 109.22,39.83 ; D106.A5 391.16,74.47 ; D106.A5 390.35,73.66 ; D106.A5 391.16,72.85 ; D106.A5 391.97,73.66 ; 250.65,40.64 D124.B8 ; D124.B8 252.27,40.64 ; D124.B8 251.46,41.45 ; D124.B8 251.46,39.83 ; DPS2.C15 313.23,410.21 ; DPS2.C15 312.42,409.4 ; DPS2.C15 312.42,411.02 ; DPS2.C15 311.61,410.21 ; 311.61,355.6 D114.A15 ; D114.A15 312.42,356.41 ; D114.A15 312.42,354.79 ; D114.A15 313.23,355.6 ; 235.41,332.74 CSDPS225.B16 ; CSDPS225.B16 236.22,331.93 ; CSDPS225.B16 237.03,332.74 ; CSDPS225.B16 236.22,333.55 ; D130.A9 107.49,73.66 ; D130.A9 105.87,73.66 ; D130.A9 106.68,72.85 ; D130.A9 106.68,74.47 ; 19.51,96.52 D125.A4 ; D125.A4 21.13,96.52 ; D125.A4 20.32,95.71 ; D125.A4 20.32,97.33 ; D108.B12 409.75,40.64 ; D108.B12 408.94,39.83 ; D108.B12 408.13,40.64 ; D108.B12 408.94,41.45 ; D119.B13 190.5,59.23 ; D119.B13 190.5,57.61 ; D119.B13 189.69,58.42 ; D119.B13 191.31,58.42 ; D118.B3 165.1,79.55 ; D118.B3 164.29,78.74 ; D118.B3 165.91,78.74 ; D118.B3 165.1,77.93 ; 334.47,76.2 D102.A12 ; D102.A12 335.28,77.01 ; D102.A12 336.09,76.2 ; D102.A12 335.28,75.39 ; D123.B11 259.08,59.23 ; D123.B11 259.89,58.42 ; D123.B11 258.27,58.42 ; D123.B11 259.08,57.61 ; 45.72,75.39 D126.A14 ; D126.A14 45.72,77.01 ; D126.A14 44.91,76.2 ; D126.A14 46.53,76.2 ; D119.A9 181.15,53.34 ; D119.A9 180.34,54.15 ; D119.A9 179.53,53.34 ; D119.A9 180.34,52.53 ; 192.23,373.38 D231.A4 ; D231.A4 193.04,372.57 ; D231.A4 193.85,373.38 ; D231.A4 193.04,374.19 ; 260.81,332.74 CSDPS225.B6 ; CSDPS225.B6 261.62,333.55 ; CSDPS225.B6 261.62,331.93 ; CSDPS225.B6 262.43,332.74 ; 390.35,53.34 D107.A5 ; D107.A5 391.16,52.53 ; D107.A5 391.16,54.15 ; D107.A5 391.97,53.34 ; 250.65,342.9 CSDPS425.B10 ; CSDPS425.B10 251.46,343.71 ; CSDPS425.B10 252.27,342.9 ; CSDPS425.B10 251.46,342.09 ; 96.52,32.21 D132.A5 ; D132.A5 96.52,33.83 ; D132.A5 97.33,33.02 ; D132.A5 95.71,33.02 ; 391.16,354.79 D110.A13 ; D110.A13 390.35,355.6 ; D110.A13 391.97,355.6 ; D110.A13 391.16,356.41 ; D431.B10 177.8,379.27 ; D431.B10 177.8,377.65 ; D431.B10 178.61,378.46 ; D431.B10 176.99,378.46 ; DPS8.A11 175.26,416.1 ; DPS8.A11 174.45,415.29 ; DPS8.A11 175.26,414.48 ; DPS8.A11 176.07,415.29 ; 180.34,37.29 D120.B9 ; D120.B9 180.34,38.91 ; D120.B9 181.15,38.1 ; D120.B9 179.53,38.1 ; D132.B6 99.06,41.45 ; D132.B6 99.87,40.64 ; D132.B6 98.25,40.64 ; D132.B6 99.06,39.83 ; D302.B11 332.74,69.29 ; D302.B11 333.45,68.58 ; D302.B11 332.03,68.58 ; D302.B11 332.74,67.87 ; 406.4,57.61 D107.B11 ; D107.B11 406.4,59.23 ; D107.B11 407.21,58.42 ; D107.B11 405.59,58.42 ; 251.46,60.15 D123.B8 ; D123.B8 251.46,61.77 ; D123.B8 252.27,60.96 ; D123.B8 250.65,60.96 ; D107.A2 384.35,55.88 ; D107.A2 383.54,55.07 ; D107.A2 382.73,55.88 ; D107.A2 383.54,56.69 ; 90.63,99.06 D129.B3 ; D129.B3 92.25,99.06 ; D129.B3 91.44,99.87 ; D129.B3 91.44,98.25 ; D113.B16 309.88,328.47 ; D113.B16 309.88,326.85 ; D113.B16 310.69,327.66 ; D113.B16 309.07,327.66 ; 419.1,331.93 D109.A2 ; D109.A2 419.1,333.55 ; D109.A2 419.91,332.74 ; D109.A2 418.29,332.74 ; 397.97,40.64 D108.B8 ; D108.B8 398.78,41.45 ; D108.B8 399.59,40.64 ; D108.B8 398.78,39.83 ; D107.A11 406.4,54.15 ; D107.A11 405.59,53.34 ; D107.A11 407.21,53.34 ; D107.A11 406.4,52.53 ; 416.56,375.11 D111.A3 ; D111.A3 417.37,375.92 ; D111.A3 415.75,375.92 ; D111.A3 416.56,376.73 ; 405.59,78.74 D106.B11 ; D106.B11 406.4,77.93 ; D106.B11 407.21,78.74 ; D106.B11 406.4,79.55 ; D120.A8 177.8,36.37 ; D120.A8 176.99,35.56 ; D120.A8 177.8,34.75 ; D120.A8 178.61,35.56 ; 249.75,182.83 SITE3.G14 ; SITE3.G14 250.23,182.35 ; SITE3.G14 250.71,182.83 ; SITE3.G14 250.23,183.31 ; D125.A3 18.59,93.98 ; D125.A3 17.78,94.79 ; D125.A3 17.78,93.17 ; D125.A3 16.97,93.98 ; 250.65,332.74 CSDPS225.B10 ; CSDPS225.B10 251.46,333.55 ; CSDPS225.B10 251.46,331.93 ; CSDPS225.B10 252.27,332.74 ; D321.A9 254.71,83.82 ; D321.A9 254,83.11 ; D321.A9 253.29,83.82 ; D321.A9 254,84.53 ; D103.B16 346.25,60.96 ; D103.B16 345.44,61.77 ; D103.B16 344.63,60.96 ; D103.B16 345.44,60.15 ; 172.72,39.83 D120.B6 ; D120.B6 173.53,40.64 ; D120.B6 171.91,40.64 ; D120.B6 172.72,41.45 ; D115.A8 330.2,374.19 ; D115.A8 331.01,373.38 ; D115.A8 329.39,373.38 ; D115.A8 330.2,372.57 ; D317.A3 165.81,83.82 ; D317.A3 165.1,84.53 ; D317.A3 165.1,83.11 ; D317.A3 164.39,83.82 ; 419.1,372.57 D111.A2 ; D111.A2 418.29,373.38 ; D111.A2 419.1,374.19 ; D111.A2 419.91,373.38 ; 268.43,38.1 D124.B15 ; D124.B15 269.24,38.91 ; D124.B15 269.24,37.29 ; D124.B15 270.05,38.1 ; D126.A13 43.18,74.47 ; D126.A13 43.99,73.66 ; D126.A13 42.37,73.66 ; D126.A13 43.18,72.85 ; 339.65,86.36 D301.A14 ; D301.A14 340.36,85.65 ; D301.A14 341.07,86.36 ; D301.A14 340.36,87.07 ; D111.B2 419.1,369.11 ; D111.B2 418.29,368.3 ; D111.B2 419.91,368.3 ; D111.B2 419.1,367.49 ; 413.21,76.2 D106.A14 ; D106.A14 414.83,76.2 ; D106.A14 414.02,77.01 ; D106.A14 414.02,75.39 ; D113.A7 332.74,336.09 ; D113.A7 333.55,335.28 ; D113.A7 331.93,335.28 ; D113.A7 332.74,334.47 ; D125.B6 25.4,102.41 ; D125.B6 25.4,100.79 ; D125.B6 26.21,101.6 ; D125.B6 24.59,101.6 ; D127.A15 48.26,54.15 ; D127.A15 49.07,53.34 ; D127.A15 48.26,52.53 ; D127.A15 47.45,53.34 ; D305.A9 402.03,83.82 ; D305.A9 401.32,84.53 ; D305.A9 400.61,83.82 ; D305.A9 401.32,83.11 ; D104.B3 312.42,38.91 ; D104.B3 312.42,37.29 ; D104.B3 313.23,38.1 ; D104.B3 311.61,38.1 ; D317.B1 160.02,89.61 ; D317.B1 160.02,88.19 ; D317.B1 159.31,88.9 ; D317.B1 160.73,88.9 ; 160.02,385.27 D431.A17 ; D431.A17 160.02,386.89 ; D431.A17 159.21,386.08 ; D431.A17 160.83,386.08 ; 408.94,85.65 D305.A12 ; D305.A12 409.65,86.36 ; D305.A12 408.94,87.07 ; D305.A12 408.23,86.36 ; 414.02,85.65 D305.A14 ; D305.A14 413.31,86.36 ; D305.A14 414.02,87.07 ; D305.A14 414.73,86.36 ; D124.B2 236.22,41.45 ; D124.B2 237.03,40.64 ; D124.B2 235.41,40.64 ; D124.B2 236.22,39.83 ; 184.61,53.34 D119.A11 ; D119.A11 185.42,52.53 ; D119.A11 185.42,54.15 ; D119.A11 186.23,53.34 ; 317.5,37.29 D104.B5 ; D104.B5 317.5,38.91 ; D104.B5 318.31,38.1 ; D104.B5 316.69,38.1 ; D131.B6 99.87,60.96 ; D131.B6 99.06,61.77 ; D131.B6 99.06,60.15 ; D131.B6 98.25,60.96 ; 256.54,85.65 D321.A10 ; D321.A10 257.25,86.36 ; D321.A10 255.83,86.36 ; D321.A10 256.54,87.07 ; 195.58,62.79 D318.A15 ; D318.A15 195.58,64.21 ; D318.A15 196.29,63.5 ; D318.A15 194.87,63.5 ; D431.A15 165.91,386.08 ; D431.A15 164.29,386.08 ; D431.A15 165.1,386.89 ; D431.A15 165.1,385.27 ; D302.B4 315.67,71.12 ; D302.B4 314.96,71.83 ; D302.B4 314.25,71.12 ; D302.B4 314.96,70.41 ; 335.28,352.25 D114.A6 ; D114.A6 336.09,353.06 ; D114.A6 335.28,353.87 ; D114.A6 334.47,353.06 ; 332.63,245.95 SITE2.G20 ; SITE2.G20 332.63,246.91 ; SITE2.G20 333.11,246.43 ; SITE2.G20 332.15,246.43 ; 380.19,38.1 D108.B1 ; D108.B1 381.81,38.1 ; D108.B1 381,37.29 ; D108.B1 381,38.91 ; D107.B4 389.43,60.96 ; D107.B4 388.62,61.77 ; D107.B4 387.81,60.96 ; D107.B4 388.62,60.15 ; D113.A9 327.66,336.09 ; D113.A9 328.47,335.28 ; D113.A9 327.66,334.47 ; D113.A9 326.85,335.28 ; D129.A16 124.46,97.33 ; D129.A16 123.65,96.52 ; D129.A16 124.46,95.71 ; D129.A16 125.27,96.52 ; 22.05,33.02 D128.A5 ; D128.A5 22.86,33.83 ; D128.A5 23.67,33.02 ; D128.A5 22.86,32.21 ; D122.A7 249.73,73.66 ; D122.A7 248.11,73.66 ; D122.A7 248.92,72.85 ; D122.A7 248.92,74.47 ; 329.39,332.74 D113.A8 ; D113.A8 331.01,332.74 ; D113.A8 330.2,333.55 ; D113.A8 330.2,331.93 ; 391.16,77.93 D106.B5 ; D106.B5 391.16,79.55 ; D106.B5 391.97,78.74 ; D106.B5 390.35,78.74 ; D120.B5 170.99,38.1 ; D120.B5 170.18,38.91 ; D120.B5 170.18,37.29 ; D120.B5 169.37,38.1 ; 180.34,375.11 D231.A9 ; D231.A9 179.53,375.92 ; D231.A9 180.34,376.73 ; D231.A9 181.15,375.92 ; D110.A9 401.32,356.41 ; D110.A9 402.13,355.6 ; D110.A9 401.32,354.79 ; D110.A9 400.51,355.6 ; D124.A8 251.46,36.37 ; D124.A8 250.65,35.56 ; D124.A8 251.46,34.75 ; D124.A8 252.27,35.56 ; 419.1,55.07 D107.A16 ; D107.A16 419.1,56.69 ; D107.A16 418.29,55.88 ; D107.A16 419.91,55.88 ; 400.51,53.34 D107.A9 ; D107.A9 401.32,54.15 ; D107.A9 401.32,52.53 ; D107.A9 402.13,53.34 ; D131.A11 112.57,53.34 ; D131.A11 111.76,52.53 ; D131.A11 110.95,53.34 ; D131.A11 111.76,54.15 ; D115.B6 336.09,368.3 ; D115.B6 335.28,369.11 ; D115.B6 335.28,367.49 ; D115.B6 334.47,368.3 ; 322.58,414.48 DPS2.A11 ; DPS2.A11 323.39,415.29 ; DPS2.A11 321.77,415.29 ; DPS2.A11 322.58,416.1 ; 108.41,96.52 D129.A10 ; D129.A10 109.22,95.71 ; D129.A10 110.03,96.52 ; D129.A10 109.22,97.33 ; D106.A7 396.24,74.47 ; D106.A7 395.43,73.66 ; D106.A7 396.24,72.85 ; D106.A7 397.05,73.66 ; 200.66,409.4 DPS8.C01 ; DPS8.C01 201.47,410.21 ; DPS8.C01 200.66,411.02 ; DPS8.C01 199.85,410.21 ; 314.96,90.73 D301.B4 ; D301.B4 314.25,91.44 ; D301.B4 315.67,91.44 ; D301.B4 314.96,92.15 ; 182.88,382.73 D431.A8 ; D431.A8 182.07,383.54 ; D431.A8 182.88,384.35 ; D431.A8 183.69,383.54 ; D431.B5 191.31,381 ; D431.B5 190.5,380.19 ; D431.B5 190.5,381.81 ; D431.B5 189.69,381 ; D107.A13 412.29,53.34 ; D107.A13 411.48,52.53 ; D107.A13 411.48,54.15 ; D107.A13 410.67,53.34 ; 268.53,88.9 D321.B15 ; D321.B15 269.24,88.19 ; D321.B15 269.95,88.9 ; D321.B15 269.24,89.61 ; 256.54,60.15 D123.B10 ; D123.B10 255.73,60.96 ; D123.B10 256.54,61.77 ; D123.B10 257.35,60.96 ; 93.98,75.39 D130.A4 ; D130.A4 93.98,77.01 ; D130.A4 93.17,76.2 ; D130.A4 94.79,76.2 ; 413.21,81.28 D106.B14 ; D106.B14 414.02,82.09 ; D106.B14 414.83,81.28 ; D106.B14 414.02,80.47
  L04_DGND w0.203: 250.85,241.33 SITE1.G4 ; SITE1.G4 251.33,240.85 ; SITE1.G4 251.33,241.81 ; SITE1.G4 251.81,241.33 ; D231.B10 177.8,369.11 ; D231.B10 177.8,367.49 ; D231.B10 176.99,368.3 ; D231.B10 178.61,368.3 ; D106.A12 409.75,76.2 ; D106.A12 408.13,76.2 ; D106.A12 408.94,75.39 ; D106.A12 408.94,77.01 ; D126.B7 27.94,79.55 ; D126.B7 27.94,77.93 ; D126.B7 28.75,78.74 ; D126.B7 27.13,78.74 ; D431.A4 193.85,383.54 ; D431.A4 192.23,383.54 ; D431.A4 193.04,384.35 ; D431.A4 193.04,382.73 ; 251.46,80.47 D122.B8 ; D122.B8 251.46,82.09 ; D122.B8 252.27,81.28 ; D122.B8 250.65,81.28 ; D322.A4 241.3,66.75 ; D322.A4 240.59,66.04 ; D322.A4 242.01,66.04 ; D322.A4 241.3,65.33 ; 398.07,86.36 D305.A8 ; D305.A8 399.49,86.36 ; D305.A8 398.78,85.65 ; D305.A8 398.78,87.07 ; D321.B1 233.68,89.61 ; D321.B1 234.39,88.9 ; D321.B1 232.97,88.9 ; D321.B1 233.68,88.19 ; D231.A4 193.85,373.38 ; D231.A4 193.04,372.57 ; D231.A4 192.23,373.38 ; D231.A4 193.04,374.19 ; 15.24,100.79 D125.B2 ; D125.B2 15.24,102.41 ; D125.B2 14.43,101.6 ; D125.B2 16.05,101.6 ; SITE2.G17 329.03,246.91 ; SITE2.G17 329.51,246.43 ; SITE2.G17 328.55,246.43 ; SITE2.G17 329.03,245.95 ; D128.A9 33.02,33.83 ; D128.A9 33.83,33.02 ; D128.A9 32.21,33.02 ; D128.A9 33.02,32.21 ; D112.B12 394.51,388.62 ; D112.B12 393.7,387.81 ; D112.B12 393.7,389.43 ; D112.B12 392.89,388.62 ; 187.96,80.47 D118.B12 ; D118.B12 187.15,81.28 ; D118.B12 188.77,81.28 ; D118.B12 187.96,82.09 ; 403.05,81.28 D106.B10 ; D106.B10 403.86,80.47 ; D106.B10 404.67,81.28 ; D106.B10 403.86,82.09 ; 40.64,80.47 D126.B12 ; D126.B12 40.64,82.09 ; D126.B12 41.45,81.28 ; D126.B12 39.83,81.28 ; 119.38,95.71 D129.A14 ; D129.A14 118.57,96.52 ; D129.A14 119.38,97.33 ; D129.A14 120.19,96.52 ; DPS3.C01 233.68,19.86 ; DPS3.C01 232.87,19.05 ; DPS3.C01 233.68,18.24 ; DPS3.C01 234.49,19.05 ; CSDPS225.B8 256.54,333.55 ; CSDPS225.B8 255.73,332.74 ; CSDPS225.B8 257.35,332.74 ; CSDPS225.B8 256.54,331.93 ; 269.24,13.16 DPS3.A15 ; DPS3.A15 270.05,13.97 ; DPS3.A15 269.24,14.78 ; DPS3.A15 268.43,13.97 ; D131.A6 99.87,55.88 ; D131.A6 99.06,55.07 ; D131.A6 99.06,56.69 ; D131.A6 98.25,55.88 ; 312.42,334.47 D113.A15 ; D113.A15 311.61,335.28 ; D113.A15 313.23,335.28 ; D113.A15 312.42,336.09 ; 177.09,86.36 D317.A8 ; D317.A8 177.8,87.07 ; D317.A8 177.8,85.65 ; D317.A8 178.51,86.36 ; 261.62,75.39 D122.A12 ; D122.A12 262.43,76.2 ; D122.A12 260.81,76.2 ; D122.A12 261.62,77.01 ; 170.18,83.11 D317.A5 ; D317.A5 170.89,83.82 ; D317.A5 170.18,84.53 ; D317.A5 169.47,83.82 ; D116.A14 315.77,393.7 ; D116.A14 314.96,394.51 ; D116.A14 314.15,393.7 ; D116.A14 314.96,392.89 ; D111.B4 414.02,369.11 ; D111.B4 414.02,367.49 ; D111.B4 413.21,368.3 ; D111.B4 414.83,368.3 ; D112.A16 384.35,393.7 ; D112.A16 383.54,394.51 ; D112.A16 382.73,393.7 ; D112.A16 383.54,392.89 ; 421.64,334.47 D109.A1 ; D109.A1 422.45,335.28 ; D109.A1 420.83,335.28 ; D109.A1 421.64,336.09 ; 411.48,375.11 D111.A5 ; D111.A5 410.67,375.92 ; D111.A5 411.48,376.73 ; D111.A5 412.29,375.92 ; D120.B16 198.12,41.45 ; D120.B16 197.31,40.64 ; D120.B16 198.93,40.64 ; D120.B16 198.12,39.83 ; D122.B13 264.16,79.55 ; D122.B13 264.16,77.93 ; D122.B13 264.97,78.74 ; D122.B13 263.35,78.74 ; 253.29,63.5 D322.A9 ; D322.A9 254.71,63.5 ; D322.A9 254,64.21 ; D322.A9 254,62.79 ; D124.A10 257.35,35.56 ; D124.A10 256.54,36.37 ; D124.A10 255.73,35.56 ; D124.A10 256.54,34.75 ; 258.37,88.9 D321.B11 ; D321.B11 259.08,88.19 ; D321.B11 259.79,88.9 ; D321.B11 259.08,89.61 ; D120.A5 170.99,33.02 ; D120.A5 170.18,33.83 ; D120.A5 169.37,33.02 ; D120.A5 170.18,32.21 ; 167.64,372.57 D231.A14 ; D231.A14 168.45,373.38 ; D231.A14 167.64,374.19 ; D231.A14 166.83,373.38 ; 175.26,88.19 D317.B7 ; D317.B7 174.55,88.9 ; D317.B7 175.97,88.9 ; D317.B7 175.26,89.61 ; 182.88,382.73 D431.A8 ; D431.A8 183.69,383.54 ; D431.A8 182.88,384.35 ; D431.A8 182.07,383.54 ; 393.7,60.15 D107.B6 ; D107.B6 392.89,60.96 ; D107.B6 393.7,61.77 ; D107.B6 394.51,60.96 ; 187.15,342.9 CSDPS429.B6 ; CSDPS429.B6 187.96,343.71 ; CSDPS429.B6 187.96,342.09 ; CSDPS429.B6 188.77,342.9 ; D119.B13 191.31,58.42 ; D119.B13 189.69,58.42 ; D119.B13 190.5,59.23 ; D119.B13 190.5,57.61 ; D131.B11 111.76,59.23 ; D131.B11 110.95,58.42 ; D131.B11 112.57,58.42 ; D131.B11 111.76,57.61 ; S3_I2C.4 83.31,209.98 ; S3_I2C.4 82.37,209.04 ; S3_I2C.4 84.25,209.04 ; S3_I2C.4 83.31,208.1 ; 250.65,60.96 D123.B8 ; D123.B8 252.27,60.96 ; D123.B8 251.46,61.77 ; D123.B8 251.46,60.15 ; D114.A10 325.93,353.06 ; D114.A10 325.12,352.25 ; D114.A10 324.31,353.06 ; D114.A10 325.12,353.87 ; 403.05,76.2 D106.A10 ; D106.A10 404.67,76.2 ; D106.A10 403.86,75.39 ; D106.A10 403.86,77.01 ; 180.34,385.27 D431.A9 ; D431.A9 180.34,386.89 ; D431.A9 181.15,386.08 ; D431.A9 179.53,386.08 ; 321.77,370.84 D115.B11 ; D115.B11 322.58,371.65 ; D115.B11 323.39,370.84 ; D115.B11 322.58,370.03 ; 162.56,90.73 D317.B2 ; D317.B2 161.85,91.44 ; D317.B2 163.27,91.44 ; D317.B2 162.56,92.15 ; D119.A13 191.31,53.34 ; D119.A13 190.5,52.53 ; D119.A13 189.69,53.34 ; D119.A13 190.5,54.15 ; DPS2.A11 323.39,415.29 ; DPS2.A11 322.58,416.1 ; DPS2.A11 321.77,415.29 ; DPS2.A11 322.58,414.48 ; D113.B14 315.77,327.66 ; D113.B14 314.15,327.66 ; D113.B14 314.96,326.85 ; D113.B14 314.96,328.47 ; 162.56,372.57 D231.A16 ; D231.A16 162.56,374.19 ; D231.A16 163.37,373.38 ; D231.A16 161.75,373.38 ; CSDPS425.C15 238.76,341.17 ; CSDPS425.C15 237.95,340.36 ; CSDPS425.C15 239.57,340.36 ; CSDPS425.C15 238.76,339.55 ; D107.A10 404.67,55.88 ; D107.A10 403.86,55.07 ; D107.A10 403.86,56.69 ; D107.A10 403.05,55.88 ; 47.45,93.98 D125.A15 ; D125.A15 48.26,93.17 ; D125.A15 48.26,94.79 ; D125.A15 49.07,93.98 ; 254,83.11 D321.A9 ; D321.A9 254,84.53 ; D321.A9 254.71,83.82 ; D321.A9 253.29,83.82 ; 403.86,60.15 D107.B10 ; D107.B10 403.86,61.77 ; D107.B10 403.05,60.96 ; D107.B10 404.67,60.96 ; 306.53,33.02 D104.A1 ; D104.A1 307.34,33.83 ; D104.A1 307.34,32.21 ; D104.A1 308.15,33.02 ; 325.12,60.15 D103.B8 ; D103.B8 325.93,60.96 ; D103.B8 324.31,60.96 ; D103.B8 325.12,61.77 ; D120.A6 172.72,36.37 ; D120.A6 172.72,34.75 ; D120.A6 173.53,35.56 ; D120.A6 171.91,35.56 ; D114.B5 337.82,351.33 ; D114.B5 337.82,349.71 ; D114.B5 337.01,350.52 ; D114.B5 338.63,350.52 ; 387.91,66.04 D306.A4 ; D306.A4 388.62,65.33 ; D306.A4 389.33,66.04 ; D306.A4 388.62,66.75 ; D116.B6 336.09,388.62 ; D116.B6 334.47,388.62 ; D116.B6 335.28,389.43 ; D116.B6 335.28,387.81 ; 312.42,390.35 D116.B15 ; D116.B15 311.61,391.16 ; D116.B15 313.23,391.16 ; D116.B15 312.42,391.97 ; SITE2.G20 333.11,246.43 ; SITE2.G20 332.63,245.95 ; SITE2.G20 332.63,246.91 ; SITE2.G20 332.15,246.43 ; 195.58,385.27 D431.A3 ; D431.A3 195.58,386.89 ; D431.A3 194.77,386.08 ; D431.A3 196.39,386.08 ; D112.A10 398.78,394.51 ; D112.A10 399.59,393.7 ; D112.A10 398.78,392.89 ; D112.A10 397.97,393.7 ; D102.A13 338.63,73.66 ; D102.A13 337.82,72.85 ; D102.A13 337.01,73.66 ; D102.A13 337.82,74.47 ; 190.5,385.27 D431.A5 ; D431.A5 191.31,386.08 ; D431.A5 189.69,386.08 ; D431.A5 190.5,386.89 ; D128.A8 30.48,36.37 ; D128.A8 30.48,34.75 ; D128.A8 29.67,35.56 ; D128.A8 31.29,35.56 ; D106.B6 394.51,81.28 ; D106.B6 392.89,81.28 ; D106.B6 393.7,82.09 ; D106.B6 393.7,80.47 ; 243.84,329.39 CSDPS225.C13 ; CSDPS225.C13 243.84,331.01 ; CSDPS225.C13 243.03,330.2 ; CSDPS225.C13 244.65,330.2 ; D125.B16 51.61,101.6 ; D125.B16 49.99,101.6 ; D125.B16 50.8,102.41 ; D125.B16 50.8,100.79 ; D111.B12 394.51,368.3 ; D111.B12 392.89,368.3 ; D111.B12 393.7,367.49 ; D111.B12 393.7,369.11 ; 180.34,57.61 D119.B9 ; D119.B9 180.34,59.23 ; D119.B9 179.53,58.42 ; D119.B9 181.15,58.42 ; 251.85,247.93 SITE1.G11 ; SITE1.G11 252.81,247.93 ; SITE1.G11 252.33,247.45 ; SITE1.G11 252.33,248.41 ; 44.91,40.64 D128.B14 ; D128.B14 45.72,41.45 ; D128.B14 46.53,40.64 ; D128.B14 45.72,39.83 ; 169.37,53.34 D119.A5 ; D119.A5 170.18,54.15 ; D119.A5 170.18,52.53 ; D119.A5 170.99,53.34 ; 39.83,55.88 D127.A12 ; D127.A12 40.64,56.69 ; D127.A12 40.64,55.07 ; D127.A12 41.45,55.88 ; 90.63,33.02 D132.A3 ; D132.A3 91.44,33.83 ; D132.A3 91.44,32.21 ; D132.A3 92.25,33.02 ; D116.B2 345.44,389.43 ; D116.B2 344.63,388.62 ; D116.B2 345.44,387.81 ; D116.B2 346.25,388.62 ; 180.34,37.29 D120.B9 ; D120.B9 179.53,38.1 ; D120.B9 180.34,38.91 ; D120.B9 181.15,38.1 ; D132.A10 110.03,35.56 ; D132.A10 109.22,36.37 ; D132.A10 109.22,34.75 ; D132.A10 108.41,35.56 ; 393.7,372.57 D111.A12 ; D111.A12 394.51,373.38 ; D111.A12 393.7,374.19 ; D111.A12 392.89,373.38 ; D431.A12 172.72,384.35 ; D431.A12 171.91,383.54 ; D431.A12 172.72,382.73 ; D431.A12 173.53,383.54 ; 194.77,33.02 D120.A15 ; D120.A15 195.58,32.21 ; D120.A15 196.39,33.02 ; D120.A15 195.58,33.83 ; D132.B1 86.36,38.91 ; D132.B1 85.55,38.1 ; D132.B1 87.17,38.1 ; D132.B1 86.36,37.29 ; D129.B9 107.49,99.06 ; D129.B9 105.87,99.06 ; D129.B9 106.68,99.87 ; D129.B9 106.68,98.25 ; D116.A6 335.28,394.51 ; D116.A6 335.28,392.89 ; D116.A6 336.09,393.7 ; D116.A6 334.47,393.7 ; D125.B12 40.64,102.41 ; D125.B12 41.45,101.6 ; D125.B12 40.64,100.79 ; D125.B12 39.83,101.6 ; 44.91,81.28 D126.B14 ; D126.B14 46.53,81.28 ; D126.B14 45.72,82.09 ; D126.B14 45.72,80.47 ; D112.B7 407.21,391.16 ; D112.B7 405.59,391.16 ; D112.B7 406.4,390.35 ; D112.B7 406.4,391.97 ; D109.A2 419.91,332.74 ; D109.A2 419.1,333.55 ; D109.A2 418.29,332.74 ; D109.A2 419.1,331.93 ; D103.B3 313.23,58.42 ; D103.B3 312.42,57.61 ; D103.B3 312.42,59.23 ; D103.B3 311.61,58.42 ; 88.09,55.88 D131.A2 ; D131.A2 89.71,55.88 ; D131.A2 88.9,56.69 ; D131.A2 88.9,55.07 ; SITE2.G7 328.33,248.41 ; SITE2.G7 328.81,247.93 ; SITE2.G7 327.85,247.93 ; SITE2.G7 328.33,247.45 ; D322.A16 272.49,66.04 ; D322.A16 271.07,66.04 ; D322.A16 271.78,66.75 ; D322.A16 271.78,65.33 ; 235.51,91.44 D321.B2 ; D321.B2 236.22,90.73 ; D321.B2 236.93,91.44 ; D321.B2 236.22,92.15 ; 232.87,38.1 D124.B1 ; D124.B1 234.49,38.1 ; D124.B1 233.68,37.29 ; D124.B1 233.68,38.91 ; 482.49,170.56 UNK4U2.4 ; UNK4U2.4 483.43,171.51 ; UNK4U2.4 481.55,171.51 ; UNK4U2.4 482.49,172.45 ; D110.A16 384.35,353.06 ; D110.A16 382.73,353.06 ; D110.A16 383.54,352.25 ; D110.A16 383.54,353.87 ; D112.B6 409.75,388.62 ; D112.B6 408.94,387.81 ; D112.B6 408.94,389.43 ; D112.B6 408.13,388.62 ; D111.B3 417.37,370.84 ; D111.B3 415.75,370.84 ; D111.B3 416.56,370.03 ; D111.B3 416.56,371.65 ; 103.33,60.96 D131.B8 ; D131.B8 104.14,60.15 ; D131.B8 104.14,61.77 ; D131.B8 104.95,60.96 ; D102.B7 323.39,78.74 ; D102.B7 321.77,78.74 ; D102.B7 322.58,77.93 ; D102.B7 322.58,79.55 ; DPS8.A01 200.66,416.1 ; DPS8.A01 200.66,414.48 ; DPS8.A01 199.85,415.29 ; DPS8.A01 201.47,415.29 ; 383.54,326.85 D109.B16 ; D109.B16 382.73,327.66 ; D109.B16 384.35,327.66 ; D109.B16 383.54,328.47 ; 114.3,60.15 D131.B12 ; D131.B12 113.49,60.96 ; D131.B12 114.3,61.77 ; D131.B12 115.11,60.96 ; 170.18,67.87 D318.B5 ; D318.B5 169.47,68.58 ; D318.B5 170.89,68.58 ; D318.B5 170.18,69.29 ; 415.85,88.9 D305.B15 ; D305.B15 416.56,88.19 ; D305.B15 416.56,89.61 ; D305.B15 417.27,88.9 ; 108.41,101.6 D129.B10 ; D129.B10 110.03,101.6 ; D129.B10 109.22,102.41 ; D129.B10 109.22,100.79 ; D115.B9 327.66,371.65 ; D115.B9 327.66,370.03 ; D115.B9 328.47,370.84 ; D115.B9 326.85,370.84 ; 193.04,377.65 D431.B4 ; D431.B4 192.23,378.46 ; D431.B4 193.04,379.27 ; D431.B4 193.85,378.46 ; SITE4.G15 331.43,183.31 ; SITE4.G15 331.43,182.35 ; SITE4.G15 331.91,182.83 ; SITE4.G15 330.95,182.83 ; 165.1,385.27 D431.A15 ; D431.A15 165.1,386.89 ; D431.A15 165.91,386.08 ; D431.A15 164.29,386.08 ; 482.59,227.61 UNK2U1.4 ; UNK2U1.4 481.65,228.55 ; UNK2U1.4 483.53,228.55 ; UNK2U1.4 482.59,229.49 ; D318.B9 180.34,69.29 ; D318.B9 179.63,68.58 ; D318.B9 180.34,67.87 ; D318.B9 181.05,68.58 ; 27.13,93.98 D125.A7 ; D125.A7 27.94,93.17 ; D125.A7 28.75,93.98 ; D125.A7 27.94,94.79 ; D107.A8 399.59,55.88 ; D107.A8 397.97,55.88 ; D107.A8 398.78,55.07 ; D107.A8 398.78,56.69 ; D109.B6 408.94,328.47 ; D109.B6 409.75,327.66 ; D109.B6 408.94,326.85 ; D109.B6 408.13,327.66 ; 25.4,39.83 D128.B6 ; D128.B6 24.59,40.64 ; D128.B6 25.4,41.45 ; D128.B6 26.21,40.64 ; D118.A5 170.99,73.66 ; D118.A5 170.18,74.47 ; D118.A5 169.37,73.66 ; D118.A5 170.18,72.85 ; 167.64,85.65 D317.A4 ; D317.A4 168.35,86.36 ; D317.A4 166.93,86.36 ; D317.A4 167.64,87.07 ; D110.A5 412.29,355.6 ; D110.A5 411.48,356.41 ; D110.A5 411.48,354.79 ; D110.A5 410.67,355.6 ; 187.15,383.54 D431.A6 ; D431.A6 187.96,382.73 ; D431.A6 188.77,383.54 ; D431.A6 187.96,384.35 ; D123.A2 237.03,55.88 ; D123.A2 236.22,56.69 ; D123.A2 235.41,55.88 ; D123.A2 236.22,55.07 ; D306.A1 381,64.21 ; D306.A1 381.71,63.5 ; D306.A1 381,62.79 ; D306.A1 380.29,63.5 ; 319.23,373.38 D115.A12 ; D115.A12 320.04,374.19 ; D115.A12 320.85,373.38 ; D115.A12 320.04,372.57 ; 161.75,76.2 D118.A2 ; D118.A2 163.37,76.2 ; D118.A2 162.56,77.01 ; D118.A2 162.56,75.39 ; D302.A3 312.42,64.21 ; D302.A3 311.71,63.5 ; D302.A3 313.13,63.5 ; D302.A3 312.42,62.79 ; D125.B3 18.59,99.06 ; D125.B3 16.97,99.06 ; D125.B3 17.78,99.87 ; D125.B3 17.78,98.25 ; 189.79,83.82 D317.A13 ; D317.A13 190.5,84.53 ; D317.A13 190.5,83.11 ; D317.A13 191.21,83.82 ; D305.A12 408.94,87.07 ; D305.A12 408.23,86.36 ; D305.A12 409.65,86.36 ; D305.A12 408.94,85.65 ; 339.55,388.62 D116.B4 ; D116.B4 340.36,389.43 ; D116.B4 341.17,388.62 ; D116.B4 340.36,387.81 ; D123.A9 254,54.15 ; D123.A9 254.81,53.34 ; D123.A9 253.19,53.34 ; D123.A9 254,52.53 ; 243.13,63.5 D322.A5 ; D322.A5 243.84,62.79 ; D322.A5 244.55,63.5 ; D322.A5 243.84,64.21 ; 334.57,91.44 D301.B12 ; D301.B12 335.99,91.44 ; D301.B12 335.28,92.15 ; D301.B12 335.28,90.73 ; 241.3,75.39 D122.A4 ; D122.A4 242.11,76.2 ; D122.A4 241.3,77.01 ; D122.A4 240.49,76.2 ; D306.B15 416.56,69.29 ; D306.B15 417.27,68.58 ; D306.B15 416.56,67.87 ; D306.B15 415.85,68.58 ; 416.56,52.53 D107.A15 ; D107.A15 415.75,53.34 ; D107.A15 417.37,53.34 ; D107.A15 416.56,54.15 ; 174.45,73.66 D118.A7 ; D118.A7 176.07,73.66 ; D118.A7 175.26,72.85 ; D118.A7 175.26,74.47 ; 166.83,55.88 D119.A4 ; D119.A4 167.64,55.07 ; D119.A4 167.64,56.69 ; D119.A4 168.45,55.88 ; 253.33,240.85 SITE1.G6 ; SITE1.G6 252.85,241.33 ; SITE1.G6 253.81,241.33 ; SITE1.G6 253.33,241.81 ; 335.28,326.85 D113.B6 ; D113.B6 334.47,327.66 ; D113.B6 335.28,328.47 ; D113.B6 336.09,327.66 ; D318.A2 163.27,66.04 ; D318.A2 161.85,66.04 ; D318.A2 162.56,65.33 ; D318.A2 162.56,66.75 ; CSDPS229.C11 176.07,330.2 ; CSDPS229.C11 175.26,329.39 ; CSDPS229.C11 175.26,331.01 ; CSDPS229.C11 174.45,330.2 ; D115.B10 325.93,368.3 ; D115.B10 325.12,369.11 ; D115.B10 325.12,367.49 ; D115.B10 324.31,368.3 ; 174.45,33.02 D120.A7 ; D120.A7 175.26,32.21 ; D120.A7 175.26,33.83 ; D120.A7 176.07,33.02 ; SITE2.G8 329.81,247.93 ; SITE2.G8 328.85,247.93 ; SITE2.G8 329.33,248.41 ; SITE2.G8 329.33,247.45 ; D114.A6 335.28,353.87 ; D114.A6 335.28,352.25 ; D114.A6 336.09,353.06 ; D114.A6 334.47,353.06 ; D125.A6 25.4,97.33 ; D125.A6 26.21,96.52 ; D125.A6 25.4,95.71 ; D125.A6 24.59,96.52 ; D106.A5 391.16,74.47 ; D106.A5 390.35,73.66 ; D106.A5 391.97,73.66 ; D106.A5 391.16,72.85 ; D132.B5 97.33,38.1 ; D132.B5 96.52,38.91 ; D132.B5 95.71,38.1 ; D132.B5 96.52,37.29 ; 268.53,83.82 D321.A15 ; D321.A15 269.24,84.53 ; D321.A15 269.24,83.11 ; D321.A15 269.95,83.82 ; 390.35,350.52 D110.B13 ; D110.B13 391.97,350.52 ; D110.B13 391.16,351.33 ; D110.B13 391.16,349.71 ; SITE3.G16 252.63,183.31 ; SITE3.G16 252.15,182.83 ; SITE3.G16 252.63,182.35 ; SITE3.G16 253.11,182.83 ; D317.B16 198.83,91.44 ; D317.B16 198.12,90.73 ; D317.B16 197.41,91.44 ; D317.B16 198.12,92.15 ; D113.A9 328.47,335.28 ; D113.A9 326.85,335.28 ; D113.A9 327.66,336.09 ; D113.A9 327.66,334.47 ; 159.21,381 D431.B17 ; D431.B17 160.02,381.81 ; D431.B17 160.83,381 ; D431.B17 160.02,380.19 ; D110.A1 422.45,355.6 ; D110.A1 421.64,356.41 ; D110.A1 421.64,354.79 ; D110.A1 420.83,355.6 ; D321.B4 241.3,92.15 ; D321.B4 241.3,90.73 ; D321.B4 240.59,91.44 ; D321.B4 242.01,91.44 ; 255.73,81.28 D122.B10 ; D122.B10 256.54,80.47 ; D122.B10 256.54,82.09 ; D122.B10 257.35,81.28 ; 252.33,240.85 SITE1.G5 ; SITE1.G5 251.85,241.33 ; SITE1.G5 252.33,241.81 ; SITE1.G5 252.81,241.33 ; 401.32,83.11 D305.A9 ; D305.A9 401.32,84.53 ; D305.A9 400.61,83.82 ; D305.A9 402.03,83.82 ; D104.B6 320.04,41.45 ; D104.B6 320.85,40.64 ; D104.B6 319.23,40.64 ; D104.B6 320.04,39.83 ; 192.23,342.9 CSDPS429.B4 ; CSDPS429.B4 193.04,343.71 ; CSDPS429.B4 193.04,342.09 ; CSDPS429.B4 193.85,342.9 ; 327.85,181.33 SITE4.G1 ; SITE4.G1 328.33,181.81 ; SITE4.G1 328.33,180.85 ; SITE4.G1 328.81,181.33 ; 91.44,37.29 D132.B3 ; D132.B3 90.63,38.1 ; D132.B3 92.25,38.1 ; D132.B3 91.44,38.91 ; 236.22,331.93 CSDPS225.B16 ; CSDPS225.B16 235.41,332.74 ; CSDPS225.B16 237.03,332.74 ; CSDPS225.B16 236.22,333.55 ; 410.77,68.58 D306.B13 ; D306.B13 411.48,69.29 ; D306.B13 412.19,68.58 ; D306.B13 411.48,67.87 ; D118.B10 183.69,81.28 ; D118.B10 182.88,80.47 ; D118.B10 182.07,81.28 ; D118.B10 182.88,82.09 ; SITE2.G4 331.33,241.81 ; SITE2.G4 330.85,241.33 ; SITE2.G4 331.81,241.33 ; SITE2.G4 331.33,240.85 ; 174.45,381 D431.B11 ; D431.B11 175.26,380.19 ; D431.B11 175.26,381.81 ; D431.B11 176.07,381 ; 309.88,372.57 D115.A16 ; D115.A16 310.69,373.38 ; D115.A16 309.07,373.38 ; D115.A16 309.88,374.19 ; 232.97,83.82 D321.A1 ; D321.A1 234.39,83.82 ; D321.A1 233.68,83.11 ; D321.A1 233.68,84.53 ; D122.A14 267.51,76.2 ; D122.A14 265.89,76.2 ; D122.A14 266.7,77.01 ; D122.A14 266.7,75.39 ; 246.38,342.09 CSDPS425.B12 ; CSDPS425.B12 245.57,342.9 ; CSDPS425.B12 246.38,343.71 ; CSDPS425.B12 247.19,342.9 ; 116.03,33.02 D132.A13 ; D132.A13 116.84,32.21 ; D132.A13 116.84,33.83 ; D132.A13 117.65,33.02 ; D103.B5 318.31,58.42 ; D103.B5 316.69,58.42 ; D103.B5 317.5,59.23 ; D103.B5 317.5,57.61 ; D318.A7 175.26,64.21 ; D318.A7 175.26,62.79 ; D318.A7 174.55,63.5 ; D318.A7 175.97,63.5 ; D318.A13 190.5,64.21 ; D318.A13 190.5,62.79 ; D318.A13 191.21,63.5 ; D318.A13 189.79,63.5 ; D130.B8 104.14,82.09 ; D130.B8 104.95,81.28 ; D130.B8 103.33,81.28 ; D130.B8 104.14,80.47 ; DPS1.A01 381.81,13.97 ; DPS1.A01 381,13.16 ; DPS1.A01 381,14.78 ; DPS1.A01 380.19,13.97 ; D124.B15 270.05,38.1 ; D124.B15 268.43,38.1 ; D124.B15 269.24,38.91 ; D124.B15 269.24,37.29 ; D305.B9 401.32,89.61 ; D305.B9 400.61,88.9 ; D305.B9 402.03,88.9 ; D305.B9 401.32,88.19 ; 184.61,386.08 D431.A7 ; D431.A7 185.42,385.27 ; D431.A7 186.23,386.08 ; D431.A7 185.42,386.89 ; D111.A13 391.97,375.92 ; D111.A13 391.16,376.73 ; D111.A13 391.16,375.11 ; D111.A13 390.35,375.92 ; D131.A5 97.33,53.34 ; D131.A5 96.52,54.15 ; D131.A5 96.52,52.53 ; D131.A5 95.71,53.34 ; 93.17,40.64 D132.B4 ; D132.B4 93.98,41.45 ; D132.B4 93.98,39.83 ; D132.B4 94.79,40.64 ; D302.B7 323.29,68.58 ; D302.B7 321.87,68.58 ; D302.B7 322.58,67.87 ; D302.B7 322.58,69.29 ; D132.A1 87.17,33.02 ; D132.A1 86.36,33.83 ; D132.A1 85.55,33.02 ; D132.A1 86.36,32.21 ; 414.02,39.83 D108.B14 ; D108.B14 413.21,40.64 ; D108.B14 414.83,40.64 ; D108.B14 414.02,41.45 ; 193.04,70.41 D318.B14 ; D318.B14 193.75,71.12 ; D318.B14 192.33,71.12 ; D318.B14 193.04,71.83 ; D113.A8 331.01,332.74 ; D113.A8 330.2,331.93 ; D113.A8 330.2,333.55 ; D113.A8 329.39,332.74 ; D131.A10 109.22,56.69 ; D131.A10 108.41,55.88 ; D131.A10 109.22,55.07 ; D131.A10 110.03,55.88 ; D317.A3 165.1,84.53 ; D317.A3 165.81,83.82 ; D317.A3 164.39,83.82 ; D317.A3 165.1,83.11 ; 264.16,67.87 D322.B13 ; D322.B13 264.16,69.29 ; D322.B13 264.87,68.58 ; D322.B13 263.45,68.58 ; D302.B5 317.5,69.29 ; D302.B5 317.5,67.87 ; D302.B5 316.79,68.58 ; D302.B5 318.21,68.58 ; D108.A7 397.05,33.02 ; D108.A7 395.43,33.02 ; D108.A7 396.24,33.83 ; D108.A7 396.24,32.21 ; 176.99,60.96 D119.B8 ; D119.B8 177.8,61.77 ; D119.B8 177.8,60.15 ; D119.B8 178.61,60.96 ; 416.56,57.61 D107.B15 ; D107.B15 415.75,58.42 ; D107.B15 416.56,59.23 ; D107.B15 417.37,58.42 ; S4_I2C.4 518.92,204.39 ; S4_I2C.4 519.86,203.45 ; S4_I2C.4 518.92,202.51 ; S4_I2C.4 517.98,203.45 ; SITE1.G12 253.81,247.93 ; SITE1.G12 253.33,247.45 ; SITE1.G12 253.33,248.41 ; SITE1.G12 252.85,247.93 ; D125.A9 33.02,94.79 ; D125.A9 33.83,93.98 ; D125.A9 33.02,93.17 ; D125.A9 32.21,93.98 ; D116.B1 348.79,391.16 ; D116.B1 347.17,391.16 ; D116.B1 347.98,390.35 ; D116.B1 347.98,391.97 ; 20.32,60.15 D127.B4 ; D127.B4 21.13,60.96 ; D127.B4 20.32,61.77 ; D127.B4 19.51,60.96 ; D130.B7 102.41,78.74 ; D130.B7 101.6,77.93 ; D130.B7 100.79,78.74 ; D130.B7 101.6,79.55 ; SITE3.G4 251.81,181.33 ; SITE3.G4 251.33,180.85 ; SITE3.G4 250.85,181.33 ; SITE3.G4 251.33,181.81 ; D322.B9 254.71,68.58 ; D322.B9 254,67.87 ; D322.B9 253.29,68.58 ; D322.B9 254,69.29 ; D110.A10 398.78,353.87 ; D110.A10 398.78,352.25 ; D110.A10 397.97,353.06 ; D110.A10 399.59,353.06 ; SITE3.G17 249.51,186.43 ; SITE3.G17 249.03,185.95 ; SITE3.G17 248.55,186.43 ; SITE3.G17 249.03,186.91 ; D318.A9 181.05,63.5 ; D318.A9 180.34,64.21 ; D318.A9 180.34,62.79 ; D318.A9 179.63,63.5 ; 116.03,73.66 D130.A13 ; D130.A13 116.84,72.85 ; D130.A13 117.65,73.66 ; D130.A13 116.84,74.47 ; 110.95,53.34 D131.A11 ; D131.A11 111.76,52.53 ; D131.A11 112.57,53.34 ; D131.A11 111.76,54.15 ; 22.86,93.17 D125.A5 ; D125.A5 22.05,93.98 ; D125.A5 22.86,94.79 ; D125.A5 23.67,93.98 ; D127.A16 51.61,55.88 ; D127.A16 50.8,56.69 ; D127.A16 50.8,55.07 ; D127.A16 49.99,55.88 ; 329.39,393.7 D116.A8 ; D116.A8 330.2,392.89 ; D116.A8 331.01,393.7 ; D116.A8 330.2,394.51 ; SITE2.G2 329.33,241.81 ; SITE2.G2 329.81,241.33 ; SITE2.G2 328.85,241.33 ; SITE2.G2 329.33,240.85 ; D127.B3 17.78,59.23 ; D127.B3 17.78,57.61 ; D127.B3 18.59,58.42 ; D127.B3 16.97,58.42 ; 344.63,393.7 D116.A2 ; D116.A2 345.44,392.89 ; D116.A2 346.25,393.7 ; D116.A2 345.44,394.51 ; D122.B9 254,79.55 ; D122.B9 253.19,78.74 ; D122.B9 254.81,78.74 ; D122.B9 254,77.93 ; 27.94,57.61 D127.B7 ; D127.B7 27.94,59.23 ; D127.B7 27.13,58.42 ; D127.B7 28.75,58.42 ; DPS8.A11 175.26,416.1 ; DPS8.A11 174.45,415.29 ; DPS8.A11 175.26,414.48 ; DPS8.A11 176.07,415.29 ; D122.B5 244.65,78.74 ; D122.B5 243.03,78.74 ; D122.B5 243.84,77.93 ; D122.B5 243.84,79.55 ; D122.B3 239.57,78.74 ; D122.B3 238.76,77.93 ; D122.B3 237.95,78.74 ; D122.B3 238.76,79.55 ; 121.11,33.02 D132.A15 ; D132.A15 122.73,33.02 ; D132.A15 121.92,32.21 ; D132.A15 121.92,33.83 ; 418.29,55.88 D107.A16 ; D107.A16 419.1,56.69 ; D107.A16 419.91,55.88 ; D107.A16 419.1,55.07 ; 406.4,37.29 D108.B11 ; D108.B11 407.21,38.1 ; D108.B11 406.4,38.91 ; D108.B11 405.59,38.1 ; 91.44,57.61 D131.B3 ; D131.B3 92.25,58.42 ; D131.B3 91.44,59.23 ; D131.B3 90.63,58.42 ; D302.B6 320.04,71.83 ; D302.B6 319.33,71.12 ; D302.B6 320.75,71.12 ; D302.B6 320.04,70.41 ; D126.A7 28.75,73.66 ; D126.A7 27.94,72.85 ; D126.A7 27.94,74.47 ; D126.A7 27.13,73.66 ; 335.28,70.41 D302.B12 ; D302.B12 335.99,71.12 ; D302.B12 334.57,71.12 ; D302.B12 335.28,71.83 ; 311.61,33.02 D104.A3 ; D104.A3 312.42,33.83 ; D104.A3 312.42,32.21 ; D104.A3 313.23,33.02 ; D127.A13 43.99,53.34 ; D127.A13 43.18,52.53 ; D127.A13 43.18,54.15 ; D127.A13 42.37,53.34 ; 344.63,55.88 D103.A16 ; D103.A16 345.44,56.69 ; D103.A16 346.25,55.88 ; D103.A16 345.44,55.07 ; D231.B2 198.12,369.11 ; D231.B2 197.31,368.3 ; D231.B2 198.12,367.49 ; D231.B2 198.93,368.3 ; D306.B9 402.03,68.58 ; D306.B9 401.32,69.29 ; D306.B9 400.61,68.58 ; D306.B9 401.32,67.87 ; 393.7,39.83 D108.B6 ; D108.B6 392.89,40.64 ; D108.B6 394.51,40.64 ; D108.B6 393.7,41.45 ; 175.26,67.87 D318.B7 ; D318.B7 174.55,68.58 ; D318.B7 175.26,69.29 ; D318.B7 175.97,68.58 ; D301.A3 313.13,83.82 ; D301.A3 311.71,83.82 ; D301.A3 312.42,84.53 ; D301.A3 312.42,83.11 ; D132.A7 102.41,33.02 ; D132.A7 101.6,32.21 ; D132.A7 101.6,33.83 ; D132.A7 100.79,33.02 ; 259.08,32.21 D124.A11 ; D124.A11 259.08,33.83 ; D124.A11 258.27,33.02 ; D124.A11 259.89,33.02 ; D110.A6 409.75,353.06 ; D110.A6 408.94,353.87 ; D110.A6 408.13,353.06 ; D110.A6 408.94,352.25 ; D132.B15 122.73,38.1 ; D132.B15 121.92,38.91 ; D132.B15 121.11,38.1 ; D132.B15 121.92,37.29 ; 330.2,39.83 D104.B10 ; D104.B10 331.01,40.64 ; D104.B10 329.39,40.64 ; D104.B10 330.2,41.45 ; 184.71,88.9 D317.B11 ; D317.B11 185.42,88.19 ; D317.B11 186.13,88.9 ; D317.B11 185.42,89.61 ; 314.25,71.12 D302.B4 ; D302.B4 314.96,70.41 ; D302.B4 314.96,71.83 ; D302.B4 315.67,71.12 ; 103.33,35.56 D132.A8 ; D132.A8 104.14,36.37 ; D132.A8 104.14,34.75 ; D132.A8 104.95,35.56 ; 398.78,65.33 D306.A8 ; D306.A8 398.07,66.04 ; D306.A8 398.78,66.75 ; D306.A8 399.49,66.04 ; 332.74,37.29 D104.B11 ; D104.B11 333.55,38.1 ; D104.B11 331.93,38.1 ; D104.B11 332.74,38.91 ; 243.03,58.42 D123.B5 ; D123.B5 244.65,58.42 ; D123.B5 243.84,59.23 ; D123.B5 243.84,57.61 ; D132.A4 94.79,35.56 ; D132.A4 93.98,34.75 ; D132.A4 93.98,36.37 ; D132.A4 93.17,35.56 ; D305.B12 409.65,91.44 ; D305.B12 408.94,90.73 ; D305.B12 408.23,91.44 ; D305.B12 408.94,92.15 ; 42.37,33.02 D128.A13 ; D128.A13 43.18,33.83 ; D128.A13 43.99,33.02 ; D128.A13 43.18,32.21 ; 320.04,75.39 D102.A6 ; D102.A6 320.85,76.2 ; D102.A6 320.04,77.01 ; D102.A6 319.23,76.2 ; CSDPS425.B10 252.27,342.9 ; CSDPS425.B10 250.65,342.9 ; CSDPS425.B10 251.46,343.71 ; CSDPS425.B10 251.46,342.09 ; D102.B6 320.04,82.09 ; D102.B6 319.23,81.28 ; D102.B6 320.04,80.47 ; D102.B6 320.85,81.28 ; D306.B6 394.41,71.12 ; D306.B6 392.99,71.12 ; D306.B6 393.7,70.41 ; D306.B6 393.7,71.83 ; D128.A15 49.07,33.02 ; D128.A15 47.45,33.02 ; D128.A15 48.26,33.83 ; D128.A15 48.26,32.21 ; D112.B9 401.32,391.97 ; D112.B9 402.13,391.16 ; D112.B9 400.51,391.16 ; D112.B9 401.32,390.35 ; D102.B8 325.12,82.09 ; D102.B8 325.12,80.47 ; D102.B8 325.93,81.28 ; D102.B8 324.31,81.28 ; 329.03,242.35 SITE2.G13 ; SITE2.G13 329.51,242.83 ; SITE2.G13 328.55,242.83 ; SITE2.G13 329.03,243.31 ; 164.29,73.66 D118.A3 ; D118.A3 165.91,73.66 ; D118.A3 165.1,74.47 ; D118.A3 165.1,72.85 ; 314.15,60.96 D103.B4 ; D103.B4 315.77,60.96 ; D103.B4 314.96,61.77 ; D103.B4 314.96,60.15 ; 325.12,331.93 D113.A10 ; D113.A10 325.93,332.74 ; D113.A10 325.12,333.55 ; D113.A10 324.31,332.74 ; 415.75,73.66 D106.A15 ; D106.A15 416.56,74.47 ; D106.A15 416.56,72.85 ; D106.A15 417.37,73.66 ; 113.49,81.28 D130.B12 ; D130.B12 115.11,81.28 ; D130.B12 114.3,82.09 ; D130.B12 114.3,80.47 ; 255.73,55.88 D123.A10 ; D123.A10 256.54,55.07 ; D123.A10 257.35,55.88 ; D123.A10 256.54,56.69 ; D103.B12 336.09,60.96 ; D103.B12 335.28,60.15 ; D103.B12 334.47,60.96 ; D103.B12 335.28,61.77 ; DPS1.C11 407.21,19.05 ; DPS1.C11 406.4,19.86 ; DPS1.C11 405.59,19.05 ; DPS1.C11 406.4,18.24 ; D120.B8 177.8,41.45 ; D120.B8 177.8,39.83 ; D120.B8 176.99,40.64 ; D120.B8 178.61,40.64 ; 270.97,332.74 CSDPS225.B2 ; CSDPS225.B2 271.78,333.55 ; CSDPS225.B2 271.78,331.93 ; CSDPS225.B2 272.59,332.74 ; 387.81,332.74 D109.A14 ; D109.A14 389.43,332.74 ; D109.A14 388.62,331.93 ; D109.A14 388.62,333.55 ; SITE4.G5 332.33,181.81 ; SITE4.G5 331.85,181.33 ; SITE4.G5 332.81,181.33 ; SITE4.G5 332.33,180.85 ; 387.81,76.2 D106.A4 ; D106.A4 389.43,76.2 ; D106.A4 388.62,75.39 ; D106.A4 388.62,77.01 ; D306.A13 411.48,64.21 ; D306.A13 412.19,63.5 ; D306.A13 411.48,62.79 ; D306.A13 410.77,63.5 ; 347.98,375.11 D115.A1 ; D115.A1 347.98,376.73 ; D115.A1 347.17,375.92 ; D115.A1 348.79,375.92 ; D110.B11 397.05,350.52 ; D110.B11 396.24,349.71 ; D110.B11 396.24,351.33 ; D110.B11 395.43,350.52 ; 164.29,415.29 DPS8.A15 ; DPS8.A15 165.1,416.1 ; DPS8.A15 165.1,414.48 ; DPS8.A15 165.91,415.29 ; D122.B6 246.38,82.09 ; D122.B6 246.38,80.47 ; D122.B6 247.19,81.28 ; D122.B6 245.57,81.28 ; 342.09,391.16 D116.B3 ; D116.B3 343.71,391.16 ; D116.B3 342.9,391.97 ; D116.B3 342.9,390.35 ; 421.64,390.35 D112.B1 ; D112.B1 420.83,391.16 ; D112.B1 421.64,391.97 ; D112.B1 422.45,391.16 ; D112.B4 414.02,389.43 ; D112.B4 413.21,388.62 ; D112.B4 414.83,388.62 ; D112.B4 414.02,387.81 ; 312.42,409.4 DPS2.C15 ; DPS2.C15 312.42,411.02 ; DPS2.C15 313.23,410.21 ; DPS2.C15 311.61,410.21 ; 245.57,60.96 D123.B6 ; D123.B6 246.38,61.77 ; D123.B6 246.38,60.15 ; D123.B6 247.19,60.96 ; 321.77,375.92 D115.A11 ; D115.A11 323.39,375.92 ; D115.A11 322.58,376.73 ; D115.A11 322.58,375.11 ; 410.67,350.52 D110.B5 ; D110.B5 411.48,351.33 ; D110.B5 411.48,349.71 ; D110.B5 412.29,350.52 ; 410.67,330.2 D109.B5 ; D109.B5 411.48,331.01 ; D109.B5 411.48,329.39 ; D109.B5 412.29,330.2 ; D123.B9 254.81,58.42 ; D123.B9 254,57.61 ; D123.B9 253.19,58.42 ; D123.B9 254,59.23 ; D106.A16 419.1,77.01 ; D106.A16 418.29,76.2 ; D106.A16 419.1,75.39 ; D106.A16 419.91,76.2 ; D306.A6 394.41,66.04 ; D306.A6 393.7,66.75 ; D306.A6 393.7,65.33 ; D306.A6 392.99,66.04 ; D431.A10 177.8,384.35 ; D431.A10 176.99,383.54 ; D431.A10 178.61,383.54 ; D431.A10 177.8,382.73 ; D113.B16 309.88,328.47 ; D113.B16 309.07,327.66 ; D113.B16 310.69,327.66 ; D113.B16 309.88,326.85 ; D321.B7 248.92,89.61 ; D321.B7 249.63,88.9 ; D321.B7 248.92,88.19 ; D321.B7 248.21,88.9 ; D111.A9 402.13,375.92 ; D111.A9 401.32,375.11 ; D111.A9 401.32,376.73 ; D111.A9 400.51,375.92 ; 248.55,182.83 SITE3.G13 ; SITE3.G13 249.03,183.31 ; SITE3.G13 249.03,182.35 ; SITE3.G13 249.51,182.83 ; 413.21,35.56 D108.A14 ; D108.A14 414.02,36.37 ; D108.A14 414.02,34.75 ; D108.A14 414.83,35.56 ; 116.84,98.25 D129.B13 ; D129.B13 116.03,99.06 ; D129.B13 117.65,99.06 ; D129.B13 116.84,99.87 ; 241.3,39.83 D124.B4 ; D124.B4 241.3,41.45 ; D124.B4 240.49,40.64 ; D124.B4 242.11,40.64 ; 314.15,347.98 D114.B14 ; D114.B14 314.96,348.79 ; D114.B14 315.77,347.98 ; D114.B14 314.96,347.17 ; D124.B8 251.46,41.45 ; D124.B8 251.46,39.83 ; D124.B8 250.65,40.64 ; D124.B8 252.27,40.64 ; 264.16,339.55 CSDPS425.C5 ; CSDPS425.C5 264.97,340.36 ; CSDPS425.C5 264.16,341.17 ; CSDPS425.C5 263.35,340.36 ; 34.75,60.96 D127.B10 ; D127.B10 36.37,60.96 ; D127.B10 35.56,61.77 ; D127.B10 35.56,60.15 ; 111.76,98.25 D129.B11 ; D129.B11 110.95,99.06 ; D129.B11 111.76,99.87 ; D129.B11 112.57,99.06 ; D431.B3 196.39,381 ; D431.B3 194.77,381 ; D431.B3 195.58,380.19 ; D431.B3 195.58,381.81 ; 200.66,339.55 CSDPS429.C1 ; CSDPS429.C1 199.85,340.36 ; CSDPS429.C1 201.47,340.36 ; CSDPS429.C1 200.66,341.17 ; 393.7,55.07 D107.A6 ; D107.A6 393.7,56.69 ; D107.A6 392.89,55.88 ; D107.A6 394.51,55.88 ; 187.96,55.07 D119.A12 ; D119.A12 188.77,55.88 ; D119.A12 187.15,55.88 ; D119.A12 187.96,56.69 ; D112.A1 421.64,397.05 ; D112.A1 422.45,396.24 ; D112.A1 421.64,395.43 ; D112.A1 420.83,396.24 ; 416.56,77.93 D106.B15 ; D106.B15 417.37,78.74 ; D106.B15 415.75,78.74 ; D106.B15 416.56,79.55 ; D113.B11 323.39,330.2 ; D113.B11 322.58,331.01 ; D113.B11 321.77,330.2 ; D113.B11 322.58,329.39 ; D318.A15 196.29,63.5 ; D318.A15 195.58,62.79 ; D318.A15 194.87,63.5 ; D318.A15 195.58,64.21 ; 252.63,245.95 SITE1.G20 ; SITE1.G20 252.63,246.91 ; SITE1.G20 253.11,246.43 ; SITE1.G20 252.15,246.43 ; D114.A8 330.2,353.87 ; D114.A8 329.39,353.06 ; D114.A8 330.2,352.25 ; D114.A8 331.01,353.06 ; D302.A9 328.37,63.5 ; D302.A9 326.95,63.5 ; D302.A9 327.66,64.21 ; D302.A9 327.66,62.79 ; 386.08,83.11 D305.A3 ; D305.A3 386.79,83.82 ; D305.A3 386.08,84.53 ; D305.A3 385.37,83.82 ; SITE4.G14 330.23,183.31 ; SITE4.G14 330.71,182.83 ; SITE4.G14 330.23,182.35 ; SITE4.G14 329.75,182.83 ; D111.B8 403.86,369.11 ; D111.B8 403.86,367.49 ; D111.B8 403.05,368.3 ; D111.B8 404.67,368.3 ; 88.09,76.2 D130.A2 ; D130.A2 89.71,76.2 ; D130.A2 88.9,75.39 ; D130.A2 88.9,77.01 ; 124.46,75.39 D130.A16 ; D130.A16 124.46,77.01 ; D130.A16 123.65,76.2 ; D130.A16 125.27,76.2 ; D318.B8 177.8,71.83 ; D318.B8 178.51,71.12 ; D318.B8 177.8,70.41 ; D318.B8 177.09,71.12 ; 189.69,330.2 CSDPS229.C5 ; CSDPS229.C5 191.31,330.2 ; CSDPS229.C5 190.5,329.39 ; CSDPS229.C5 190.5,331.01 ; D132.A12 115.11,35.56 ; D132.A12 113.49,35.56 ; D132.A12 114.3,34.75 ; D132.A12 114.3,36.37 ; 339.55,60.96 D103.B14 ; D103.B14 340.36,61.77 ; D103.B14 341.17,60.96 ; D103.B14 340.36,60.15 ; D103.A12 336.09,55.88 ; D103.A12 335.28,56.69 ; D103.A12 334.47,55.88 ; D103.A12 335.28,55.07 ; 410.67,391.16 D112.B5 ; D112.B5 411.48,390.35 ; D112.B5 411.48,391.97 ; D112.B5 412.29,391.16 ; 172.72,75.39 D118.A6 ; D118.A6 171.91,76.2 ; D118.A6 173.53,76.2 ; D118.A6 172.72,77.01 ; 14.43,35.56 D128.A2 ; D128.A2 15.24,36.37 ; D128.A2 15.24,34.75 ; D128.A2 16.05,35.56 ; D104.B1 308.15,38.1 ; D104.B1 307.34,37.29 ; D104.B1 306.53,38.1 ; D104.B1 307.34,38.91 ; 347.17,396.24 D116.A1 ; D116.A1 347.98,397.05 ; D116.A1 348.79,396.24 ; D116.A1 347.98,395.43 ; 159.31,88.9 D317.B1 ; D317.B1 160.02,88.19 ; D317.B1 160.02,89.61 ; D317.B1 160.73,88.9 ; D107.B2 384.35,60.96 ; D107.B2 383.54,60.15 ; D107.B2 382.73,60.96 ; D107.B2 383.54,61.77 ; D120.B15 196.39,38.1 ; D120.B15 195.58,37.29 ; D120.B15 194.77,38.1 ; D120.B15 195.58,38.91 ; D322.A2 236.93,66.04 ; D322.A2 235.51,66.04 ; D322.A2 236.22,66.75 ; D322.A2 236.22,65.33 ; D127.A5 22.86,54.15 ; D127.A5 22.05,53.34 ; D127.A5 22.86,52.53 ; D127.A5 23.67,53.34 ; D102.A12 335.28,77.01 ; D102.A12 335.28,75.39 ; D102.A12 334.47,76.2 ; D102.A12 336.09,76.2 ; 327.66,349.71 D114.B9 ; D114.B9 327.66,351.33 ; D114.B9 328.47,350.52 ; D114.B9 326.85,350.52 ; D126.B1 13.51,78.74 ; D126.B1 12.7,79.55 ; D126.B1 11.89,78.74 ; D126.B1 12.7,77.93 ; D131.B16 124.46,61.77 ; D131.B16 125.27,60.96 ; D131.B16 123.65,60.96 ; D131.B16 124.46,60.15 ; D322.B1 234.39,68.58 ; D322.B1 233.68,69.29 ; D322.B1 233.68,67.87 ; D322.B1 232.97,68.58 ; 388.62,352.25 D110.A14 ; D110.A14 387.81,353.06 ; D110.A14 389.43,353.06 ; D110.A14 388.62,353.87 ; 390.35,78.74 D106.B5 ; D106.B5 391.16,77.93 ; D106.B5 391.16,79.55 ; D106.B5 391.97,78.74 ; 174.45,340.36 CSDPS429.C11 ; CSDPS429.C11 175.26,339.55 ; CSDPS429.C11 175.26,341.17 ; CSDPS429.C11 176.07,340.36 ; 90.63,53.34 D131.A3 ; D131.A3 92.25,53.34 ; D131.A3 91.44,52.53 ; D131.A3 91.44,54.15 ; 314.96,387.81 D116.B14 ; D116.B14 314.96,389.43 ; D116.B14 314.15,388.62 ; D116.B14 315.77,388.62 ; D106.A7 397.05,73.66 ; D106.A7 396.24,74.47 ; D106.A7 395.43,73.66 ; D106.A7 396.24,72.85 ; 198.12,382.73 D431.A2 ; D431.A2 197.31,383.54 ; D431.A2 198.93,383.54 ; D431.A2 198.12,384.35 ; 309.17,91.44 D301.B2 ; D301.B2 310.59,91.44 ; D301.B2 309.88,90.73 ; D301.B2 309.88,92.15 ; CSDPS429.C5 190.5,341.17 ; CSDPS429.C5 191.31,340.36 ; CSDPS429.C5 190.5,339.55 ; CSDPS429.C5 189.69,340.36 ; 317.5,390.35 D116.B13 ; D116.B13 316.69,391.16 ; D116.B13 317.5,391.97 ; D116.B13 318.31,391.16 ; D118.B16 198.93,81.28 ; D118.B16 198.12,82.09 ; D118.B16 197.31,81.28 ; D118.B16 198.12,80.47 ; D124.A16 272.59,35.56 ; D124.A16 271.78,36.37 ; D124.A16 270.97,35.56 ; D124.A16 271.78,34.75 ; 96.52,98.25 D129.B5 ; D129.B5 97.33,99.06 ; D129.B5 96.52,99.87 ; D129.B5 95.71,99.06 ; D106.B16 419.91,81.28 ; D106.B16 419.1,82.09 ; D106.B16 418.29,81.28 ; D106.B16 419.1,80.47 ; D107.B5 391.97,58.42 ; D107.B5 391.16,57.61 ; D107.B5 391.16,59.23 ; D107.B5 390.35,58.42 ; D115.A10 325.12,374.19 ; D115.A10 325.12,372.57 ; D115.A10 325.93,373.38 ; D115.A10 324.31,373.38 ; 416.56,354.79 D110.A3 ; D110.A3 416.56,356.41 ; D110.A3 415.75,355.6 ; D110.A3 417.37,355.6 ; D112.B15 386.89,391.16 ; D112.B15 386.08,391.97 ; D112.B15 385.27,391.16 ; D112.B15 386.08,390.35 ; D108.B8 398.78,41.45 ; D108.B8 398.78,39.83 ; D108.B8 397.97,40.64 ; D108.B8 399.59,40.64 ; D301.A11 333.45,83.82 ; D301.A11 332.74,83.11 ; D301.A11 332.74,84.53 ; D301.A11 332.03,83.82 ; D129.B14 120.19,101.6 ; D129.B14 119.38,100.79 ; D129.B14 118.57,101.6 ; D129.B14 119.38,102.41 ; D119.A9 180.34,54.15 ; D119.A9 181.15,53.34 ; D119.A9 180.34,52.53 ; D119.A9 179.53,53.34 ; 322.58,83.11 D301.A7 ; D301.A7 321.87,83.82 ; D301.A7 322.58,84.53 ; D301.A7 323.29,83.82 ; 106.68,93.17 D129.A9 ; D129.A9 105.87,93.98 ; D129.A9 106.68,94.79 ; D129.A9 107.49,93.98 ; 335.28,34.75 D104.A12 ; D104.A12 335.28,36.37 ; D104.A12 336.09,35.56 ; D104.A12 334.47,35.56 ; D123.A13 264.16,54.15 ; D123.A13 264.97,53.34 ; D123.A13 263.35,53.34 ; D123.A13 264.16,52.53 ; 189.69,78.74 D118.B13 ; D118.B13 190.5,77.93 ; D118.B13 190.5,79.55 ; D118.B13 191.31,78.74 ; D126.A13 43.99,73.66 ; D126.A13 43.18,74.47 ; D126.A13 43.18,72.85 ; D126.A13 42.37,73.66 ; D301.B4 315.67,91.44 ; D301.B4 314.96,90.73 ; D301.B4 314.96,92.15 ; D301.B4 314.25,91.44 ; U2.4 97.14,220.09 ; U2.4 97.14,218.21 ; U2.4 96.2,219.15 ; U2.4 98.08,219.15 ; 165.1,67.87 D318.B3 ; D318.B3 164.39,68.58 ; D318.B3 165.1,69.29 ; D318.B3 165.81,68.58 ; D119.A11 185.42,54.15 ; D119.A11 185.42,52.53 ; D119.A11 184.61,53.34 ; D119.A11 186.23,53.34 ; DPS1.C15 417.37,19.05 ; DPS1.C15 416.56,19.86 ; DPS1.C15 415.75,19.05 ; DPS1.C15 416.56,18.24 ; CSDPS425.C13 243.84,341.17 ; CSDPS425.C13 243.84,339.55 ; CSDPS425.C13 244.65,340.36 ; CSDPS425.C13 243.03,340.36 ; D231.B17 160.02,371.65 ; D231.B17 160.02,370.03 ; D231.B17 160.83,370.84 ; D231.B17 159.21,370.84 ; D132.B2 89.71,40.64 ; D132.B2 88.9,39.83 ; D132.B2 88.9,41.45 ; D132.B2 88.09,40.64 ; 119.38,55.07 D131.A14 ; D131.A14 120.19,55.88 ; D131.A14 119.38,56.69 ; D131.A14 118.57,55.88 ; 330.85,181.33 SITE4.G4 ; SITE4.G4 331.81,181.33 ; SITE4.G4 331.33,181.81 ; SITE4.G4 331.33,180.85 ; D317.B3 165.81,88.9 ; D317.B3 164.39,88.9 ; D317.B3 165.1,89.61 ; D317.B3 165.1,88.19 ; 326.85,78.74 D102.B9 ; D102.B9 327.66,79.55 ; D102.B9 328.47,78.74 ; D102.B9 327.66,77.93 ; 190.5,414.48 DPS8.A05 ; DPS8.A05 189.69,415.29 ; DPS8.A05 191.31,415.29 ; DPS8.A05 190.5,416.1 ; 419.1,34.75 D108.A16 ; D108.A16 419.1,36.37 ; D108.A16 418.29,35.56 ; D108.A16 419.91,35.56 ; D123.A8 251.46,56.69 ; D123.A8 251.46,55.07 ; D123.A8 250.65,55.88 ; D123.A8 252.27,55.88 ; D111.B15 386.89,370.84 ; D111.B15 386.08,371.65 ; D111.B15 385.27,370.84 ; D111.B15 386.08,370.03 ; CSDPS429.B16 162.56,343.71 ; CSDPS429.B16 161.75,342.9 ; CSDPS429.B16 162.56,342.09 ; CSDPS429.B16 163.37,342.9 ; 416.56,395.43 D112.A3 ; D112.A3 417.37,396.24 ; D112.A3 416.56,397.05 ; D112.A3 415.75,396.24 ; 393.7,331.93 D109.A12 ; D109.A12 392.89,332.74 ; D109.A12 393.7,333.55 ; D109.A12 394.51,332.74 ; D127.B9 33.02,59.23 ; D127.B9 33.83,58.42 ; D127.B9 32.21,58.42 ; D127.B9 33.02,57.61 ; D129.B15 121.92,99.87 ; D129.B15 121.92,98.25 ; D129.B15 121.11,99.06 ; D129.B15 122.73,99.06 ; 42.37,38.1 D128.B13 ; D128.B13 43.99,38.1 ; D128.B13 43.18,37.29 ; D128.B13 43.18,38.91 ; 380.19,33.02 D108.A1 ; D108.A1 381.81,33.02 ; D108.A1 381,32.21 ; D108.A1 381,33.83 ; 330.33,187.45 SITE4.G9 ; SITE4.G9 330.33,188.41 ; SITE4.G9 330.81,187.93 ; SITE4.G9 329.85,187.93 ; D116.B9 327.66,391.97 ; D116.B9 327.66,390.35 ; D116.B9 328.47,391.16 ; D116.B9 326.85,391.16 ; 401.32,37.29 D108.B9 ; D108.B9 401.32,38.91 ; D108.B9 402.13,38.1 ; D108.B9 400.51,38.1 ; D116.A16 310.69,393.7 ; D116.A16 309.88,394.51 ; D116.A16 309.07,393.7 ; D116.A16 309.88,392.89 ; D317.B6 172.72,92.15 ; D317.B6 173.43,91.44 ; D317.B6 172.72,90.73 ; D317.B6 172.01,91.44 ; D127.A2 16.05,55.88 ; D127.A2 15.24,55.07 ; D127.A2 15.24,56.69 ; D127.A2 14.43,55.88 ; 91.44,77.93 D130.B3 ; D130.B3 91.44,79.55 ; D130.B3 92.25,78.74 ; D130.B3 90.63,78.74 ; D301.B13 337.82,89.61 ; D301.B13 337.82,88.19 ; D301.B13 337.11,88.9 ; D301.B13 338.53,88.9 ; 332.63,185.95 SITE4.G20 ; SITE4.G20 333.11,186.43 ; SITE4.G20 332.15,186.43 ; SITE4.G20 332.63,186.91 ; 340.36,392.89 D116.A4 ; D116.A4 339.55,393.7 ; D116.A4 340.36,394.51 ; D116.A4 341.17,393.7 ; D112.B16 384.35,388.62 ; D112.B16 383.54,387.81 ; D112.B16 382.73,388.62 ; D112.B16 383.54,389.43 ; CSDPS229.C9 180.34,331.01 ; CSDPS229.C9 181.15,330.2 ; CSDPS229.C9 179.53,330.2 ; CSDPS229.C9 180.34,329.39 ; D128.B1 13.51,38.1 ; D128.B1 12.7,38.91 ; D128.B1 12.7,37.29 ; D128.B1 11.89,38.1 ; D306.B12 408.94,71.83 ; D306.B12 408.94,70.41 ; D306.B12 409.65,71.12 ; D306.B12 408.23,71.12 ; D106.B9 402.13,78.74 ; D106.B9 401.32,77.93 ; D106.B9 401.32,79.55 ; D106.B9 400.51,78.74 ; 330.2,65.33 D302.A10 ; D302.A10 330.2,66.75 ; D302.A10 330.91,66.04 ; D302.A10 329.49,66.04 ; 400.51,58.42 D107.B9 ; D107.B9 401.32,59.23 ; D107.B9 401.32,57.61 ; D107.B9 402.13,58.42 ; 345.44,34.75 D104.A16 ; D104.A16 346.25,35.56 ; D104.A16 345.44,36.37 ; D104.A16 344.63,35.56 ; 329.75,246.43 SITE2.G18 ; SITE2.G18 330.23,246.91 ; SITE2.G18 330.71,246.43 ; SITE2.G18 330.23,245.95 ; D318.B11 186.13,68.58 ; D318.B11 185.42,67.87 ; D318.B11 184.71,68.58 ; D318.B11 185.42,69.29 ; 253.19,340.36 CSDPS425.C9 ; CSDPS425.C9 254,339.55 ; CSDPS425.C9 254.81,340.36 ; CSDPS425.C9 254,341.17 ; D102.B13 338.63,78.74 ; D102.B13 337.82,77.93 ; D102.B13 337.01,78.74 ; D102.B13 337.82,79.55 ; D123.A3 239.57,53.34 ; D123.A3 237.95,53.34 ; D123.A3 238.76,52.53 ; D123.A3 238.76,54.15 ; DPS8.C05 191.31,410.21 ; DPS8.C05 190.5,409.4 ; DPS8.C05 190.5,411.02 ; DPS8.C05 189.69,410.21 ; D124.B5 244.65,38.1 ; D124.B5 243.84,38.91 ; D124.B5 243.84,37.29 ; D124.B5 243.03,38.1 ; D123.B3 238.76,59.23 ; D123.B3 239.57,58.42 ; D123.B3 238.76,57.61 ; D123.B3 237.95,58.42 ; D127.A4 20.32,56.69 ; D127.A4 19.51,55.88 ; D127.A4 21.13,55.88 ; D127.A4 20.32,55.07 ; D431.A14 167.64,384.35 ; D431.A14 168.45,383.54 ; D431.A14 166.83,383.54 ; D431.A14 167.64,382.73 ; 164.29,38.1 D120.B3 ; D120.B3 165.1,38.91 ; D120.B3 165.91,38.1 ; D120.B3 165.1,37.29 ; SITE4.G19 331.91,186.43 ; SITE4.G19 330.95,186.43 ; SITE4.G19 331.43,185.95 ; SITE4.G19 331.43,186.91 ; D130.B2 89.71,81.28 ; D130.B2 88.9,80.47 ; D130.B2 88.09,81.28 ; D130.B2 88.9,82.09 ; D302.B13 338.53,68.58 ; D302.B13 337.11,68.58 ; D302.B13 337.82,67.87 ; D302.B13 337.82,69.29 ; D124.B11 259.89,38.1 ; D124.B11 259.08,38.91 ; D124.B11 258.27,38.1 ; D124.B11 259.08,37.29 ; D130.A12 114.3,77.01 ; D130.A12 113.49,76.2 ; D130.A12 115.11,76.2 ; D130.A12 114.3,75.39 ; D103.A9 327.66,54.15 ; D103.A9 328.47,53.34 ; D103.A9 327.66,52.53 ; D103.A9 326.85,53.34 ; D130.A3 92.25,73.66 ; D130.A3 91.44,72.85 ; D130.A3 91.44,74.47 ; D130.A3 90.63,73.66 ; D131.A16 124.46,56.69 ; D131.A16 123.65,55.88 ; D131.A16 124.46,55.07 ; D131.A16 125.27,55.88 ; D122.A11 259.89,73.66 ; D122.A11 259.08,74.47 ; D122.A11 259.08,72.85 ; D122.A11 258.27,73.66 ; D114.B15 313.23,350.52 ; D114.B15 311.61,350.52 ; D114.B15 312.42,349.71 ; D114.B15 312.42,351.33 ; 118.57,40.64 D132.B14 ; D132.B14 119.38,41.45 ; D132.B14 119.38,39.83 ; D132.B14 120.19,40.64 ; D109.A3 417.37,335.28 ; D109.A3 416.56,336.09 ; D109.A3 416.56,334.47 ; D109.A3 415.75,335.28 ; D116.B11 322.58,391.97 ; D116.B11 321.77,391.16 ; D116.B11 323.39,391.16 ; D116.B11 322.58,390.35 ; D109.B11 396.24,331.01 ; D109.B11 395.43,330.2 ; D109.B11 397.05,330.2 ; D109.B11 396.24,329.39 ; D318.A10 182.88,66.75 ; D318.A10 182.88,65.33 ; D318.A10 182.17,66.04 ; D318.A10 183.59,66.04 ; 263.35,58.42 D123.B13 ; D123.B13 264.97,58.42 ; D123.B13 264.16,57.61 ; D123.B13 264.16,59.23 ; D127.B14 46.53,60.96 ; D127.B14 45.72,61.77 ; D127.B14 44.91,60.96 ; D127.B14 45.72,60.15 ; 200.66,370.03 D231.B1 ; D231.B1 201.47,370.84 ; D231.B1 199.85,370.84 ; D231.B1 200.66,371.65 ; 396.24,395.43 D112.A11 ; D112.A11 397.05,396.24 ; D112.A11 396.24,397.05 ; D112.A11 395.43,396.24 ; D102.B5 318.31,78.74 ; D102.B5 316.69,78.74 ; D102.B5 317.5,79.55 ; D102.B5 317.5,77.93 ; 258.37,63.5 D322.A11 ; D322.A11 259.08,64.21 ; D322.A11 259.79,63.5 ; D322.A11 259.08,62.79 ; 187.25,66.04 D318.A12 ; D318.A12 187.96,66.75 ; D318.A12 187.96,65.33 ; D318.A12 188.67,66.04 ; D129.A6 99.06,97.33 ; D129.A6 99.06,95.71 ; D129.A6 99.87,96.52 ; D129.A6 98.25,96.52 ; D111.A15 386.08,376.73 ; D111.A15 386.08,375.11 ; D111.A15 385.27,375.92 ; D111.A15 386.89,375.92 ; 255.83,86.36 D321.A10 ; D321.A10 256.54,85.65 ; D321.A10 256.54,87.07 ; D321.A10 257.25,86.36 ; 109.22,39.83 D132.B10 ; D132.B10 108.41,40.64 ; D132.B10 110.03,40.64 ; D132.B10 109.22,41.45 ; D124.A12 261.62,36.37 ; D124.A12 260.81,35.56 ; D124.A12 262.43,35.56 ; D124.A12 261.62,34.75 ; D321.A11 259.08,84.53 ; D321.A11 259.79,83.82 ; D321.A11 259.08,83.11 ; D321.A11 258.37,83.82 ; D131.A12 114.3,56.69 ; D131.A12 113.49,55.88 ; D131.A12 114.3,55.07 ; D131.A12 115.11,55.88 ; D106.B14 414.02,82.09 ; D106.B14 414.83,81.28 ; D106.B14 414.02,80.47 ; D106.B14 413.21,81.28 ; 398.78,75.39 D106.A8 ; D106.A8 398.78,77.01 ; D106.A8 399.59,76.2 ; D106.A8 397.97,76.2 ; 380.19,53.34 D107.A1 ; D107.A1 381.81,53.34 ; D107.A1 381,54.15 ; D107.A1 381,52.53 ; 96.52,93.17 D129.A5 ; D129.A5 95.71,93.98 ; D129.A5 97.33,93.98 ; D129.A5 96.52,94.79 ; SITE2.G11 332.81,247.93 ; SITE2.G11 332.33,247.45 ; SITE2.G11 332.33,248.41 ; SITE2.G11 331.85,247.93 ; 162.56,39.83 D120.B2 ; D120.B2 161.75,40.64 ; D120.B2 162.56,41.45 ; D120.B2 163.37,40.64 ; 327.66,395.43 D116.A9 ; D116.A9 327.66,397.05 ; D116.A9 328.47,396.24 ; D116.A9 326.85,396.24 ; D108.A15 417.37,33.02 ; D108.A15 415.75,33.02 ; D108.A15 416.56,33.83 ; D108.A15 416.56,32.21 ; D130.A1 86.36,74.47 ; D130.A1 87.17,73.66 ; D130.A1 85.55,73.66 ; D130.A1 86.36,72.85 ; D318.A4 168.35,66.04 ; D318.A4 166.93,66.04 ; D318.A4 167.64,66.75 ; D318.A4 167.64,65.33 ; 254,32.21 D124.A9 ; D124.A9 253.19,33.02 ; D124.A9 254.81,33.02 ; D124.A9 254,33.83 ; CSDPS429.C3 196.39,340.36 ; CSDPS429.C3 195.58,339.55 ; CSDPS429.C3 195.58,341.17 ; CSDPS429.C3 194.77,340.36 ; 385.27,38.1 D108.B3 ; D108.B3 386.08,37.29 ; D108.B3 386.08,38.91 ; D108.B3 386.89,38.1 ; 329.03,185.95 SITE4.G17 ; SITE4.G17 329.51,186.43 ; SITE4.G17 329.03,186.91 ; SITE4.G17 328.55,186.43 ; 401.32,370.03 D111.B9 ; D111.B9 402.13,370.84 ; D111.B9 400.51,370.84 ; D111.B9 401.32,371.65 ; D317.B15 195.58,89.61 ; D317.B15 195.58,88.19 ; D317.B15 194.87,88.9 ; D317.B15 196.29,88.9 ; 193.04,75.39 D118.A14 ; D118.A14 193.04,77.01 ; D118.A14 193.85,76.2 ; D118.A14 192.23,76.2 ; 345.44,372.57 D115.A2 ; D115.A2 344.63,373.38 ; D115.A2 346.25,373.38 ; D115.A2 345.44,374.19 ; 105.87,78.74 D130.B9 ; D130.B9 107.49,78.74 ; D130.B9 106.68,77.93 ; D130.B9 106.68,79.55 ; 189.69,381 D431.B5 ; D431.B5 190.5,381.81 ; D431.B5 191.31,381 ; D431.B5 190.5,380.19 ; 88.9,60.15 D131.B2 ; D131.B2 88.9,61.77 ; D131.B2 89.71,60.96 ; D131.B2 88.09,60.96 ; 175.26,385.27 D431.A11 ; D431.A11 174.45,386.08 ; D431.A11 176.07,386.08 ; D431.A11 175.26,386.89 ; 165.1,409.4 DPS8.C15 ; DPS8.C15 165.91,410.21 ; DPS8.C15 164.29,410.21 ; DPS8.C15 165.1,411.02 ; D132.B7 101.6,38.91 ; D132.B7 100.79,38.1 ; D132.B7 101.6,37.29 ; D132.B7 102.41,38.1 ; 258.27,53.34 D123.A11 ; D123.A11 259.08,54.15 ; D123.A11 259.08,52.53 ; D123.A11 259.89,53.34 ; 264.16,32.21 D124.A13 ; D124.A13 263.35,33.02 ; D124.A13 264.97,33.02 ; D124.A13 264.16,33.83 ; D116.B5 338.63,391.16 ; D116.B5 337.01,391.16 ; D116.B5 337.82,390.35 ; D116.B5 337.82,391.97 ; 243.84,32.21 D124.A5 ; D124.A5 244.65,33.02 ; D124.A5 243.84,33.83 ; D124.A5 243.03,33.02 ; 250.65,332.74 CSDPS225.B10 ; CSDPS225.B10 251.46,333.55 ; CSDPS225.B10 252.27,332.74 ; CSDPS225.B10 251.46,331.93 ; D130.B4 93.98,82.09 ; D130.B4 93.98,80.47 ; D130.B4 93.17,81.28 ; D130.B4 94.79,81.28 ; D113.B7 332.74,331.01 ; D113.B7 333.55,330.2 ; D113.B7 331.93,330.2 ; D113.B7 332.74,329.39 ; 12.7,98.25 D125.B1 ; D125.B1 11.89,99.06 ; D125.B1 12.7,99.87 ; D125.B1 13.51,99.06 ; 410.67,58.42 D107.B13 ; D107.B13 411.48,57.61 ; D107.B13 412.29,58.42 ; D107.B13 411.48,59.23 ; D102.A15 343.71,73.66 ; D102.A15 342.09,73.66 ; D102.A15 342.9,72.85 ; D102.A15 342.9,74.47 ; D114.B13 318.31,350.52 ; D114.B13 316.69,350.52 ; D114.B13 317.5,351.33 ; D114.B13 317.5,349.71 ; 240.59,86.36 D321.A4 ; D321.A4 242.01,86.36 ; D321.A4 241.3,87.07 ; D321.A4 241.3,85.65 ; SITE1.G19 251.43,246.91 ; SITE1.G19 250.95,246.43 ; SITE1.G19 251.43,245.95 ; SITE1.G19 251.91,246.43 ; D113.B13 317.5,331.01 ; D113.B13 318.31,330.2 ; D113.B13 317.5,329.39 ; D113.B13 316.69,330.2 ; 314.96,367.49 D115.B14 ; D115.B14 314.15,368.3 ; D115.B14 314.96,369.11 ; D115.B14 315.77,368.3 ; D301.B3 313.13,88.9 ; D301.B3 311.71,88.9 ; D301.B3 312.42,89.61 ; D301.B3 312.42,88.19 ; 322.58,88.19 D301.B7 ; D301.B7 323.29,88.9 ; D301.B7 321.87,88.9 ; D301.B7 322.58,89.61 ; 342.19,63.5 D302.A15 ; D302.A15 342.9,62.79 ; D302.A15 343.61,63.5 ; D302.A15 342.9,64.21 ; D111.B10 399.59,368.3 ; D111.B10 398.78,367.49 ; D111.B10 397.97,368.3 ; D111.B10 398.78,369.11 ; 34.75,55.88 D127.A10 ; D127.A10 35.56,55.07 ; D127.A10 36.37,55.88 ; D127.A10 35.56,56.69 ; 403.05,353.06 D110.A8 ; D110.A8 403.86,352.25 ; D110.A8 403.86,353.87 ; D110.A8 404.67,353.06 ; CSDPS429.C7 186.23,340.36 ; CSDPS429.C7 185.42,341.17 ; CSDPS429.C7 184.61,340.36 ; CSDPS429.C7 185.42,339.55 ; D302.B10 330.91,71.12 ; D302.B10 330.2,70.41 ; D302.B10 329.49,71.12 ; D302.B10 330.2,71.83 ; CSDPS429.C9 181.15,340.36 ; CSDPS429.C9 180.34,339.55 ; CSDPS429.C9 180.34,341.17 ; CSDPS429.C9 179.53,340.36 ; 32.21,73.66 D126.A9 ; D126.A9 33.02,74.47 ; D126.A9 33.02,72.85 ; D126.A9 33.83,73.66 ; D129.A10 109.22,97.33 ; D129.A10 109.22,95.71 ; D129.A10 110.03,96.52 ; D129.A10 108.41,96.52 ; 314.96,75.39 D102.A4 ; D102.A4 314.96,77.01 ; D102.A4 315.77,76.2 ; D102.A4 314.15,76.2 ; SITE4.G13 329.51,182.83 ; SITE4.G13 329.03,183.31 ; SITE4.G13 328.55,182.83 ; SITE4.G13 329.03,182.35 ; 105.87,33.02 D132.A9 ; D132.A9 106.68,32.21 ; D132.A9 106.68,33.83 ; D132.A9 107.49,33.02 ; D125.A4 20.32,97.33 ; D125.A4 19.51,96.52 ; D125.A4 21.13,96.52 ; D125.A4 20.32,95.71 ; 403.05,40.64 D108.B10 ; D108.B10 403.86,39.83 ; D108.B10 404.67,40.64 ; D108.B10 403.86,41.45 ; D301.A14 340.36,87.07 ; D301.A14 340.36,85.65 ; D301.A14 341.07,86.36 ; D301.A14 339.65,86.36 ; D305.B13 411.48,89.61 ; D305.B13 410.77,88.9 ; D305.B13 412.19,88.9 ; D305.B13 411.48,88.19 ; D124.B9 254.81,38.1 ; D124.B9 254,37.29 ; D124.B9 253.19,38.1 ; D124.B9 254,38.91 ; 264.16,83.11 D321.A13 ; D321.A13 264.87,83.82 ; D321.A13 264.16,84.53 ; D321.A13 263.45,83.82 ; D123.B2 237.03,60.96 ; D123.B2 236.22,61.77 ; D123.B2 235.41,60.96 ; D123.B2 236.22,60.15 ; D131.A4 94.79,55.88 ; D131.A4 93.98,55.07 ; D131.A4 93.98,56.69 ; D131.A4 93.17,55.88 ; D129.B8 104.14,102.41 ; D129.B8 104.95,101.6 ; D129.B8 103.33,101.6 ; D129.B8 104.14,100.79 ; 19.51,81.28 D126.B4 ; D126.B4 21.13,81.28 ; D126.B4 20.32,82.09 ; D126.B4 20.32,80.47 ; D112.B14 388.62,389.43 ; D112.B14 388.62,387.81 ; D112.B14 387.81,388.62 ; D112.B14 389.43,388.62 ; 309.88,39.83 D104.B2 ; D104.B2 310.69,40.64 ; D104.B2 309.88,41.45 ; D104.B2 309.07,40.64 ; D104.B15 342.9,38.91 ; D104.B15 342.09,38.1 ; D104.B15 343.71,38.1 ; D104.B15 342.9,37.29 ; D113.A4 340.36,333.55 ; D113.A4 341.17,332.74 ; D113.A4 340.36,331.93 ; D113.A4 339.55,332.74 ; 317.5,32.21 D104.A5 ; D104.A5 317.5,33.83 ; D104.A5 318.31,33.02 ; D104.A5 316.69,33.02 ; D305.A11 407.11,83.82 ; D305.A11 406.4,84.53 ; D305.A11 405.69,83.82 ; D305.A11 406.4,83.11 ; D112.B13 391.16,391.97 ; D112.B13 390.35,391.16 ; D112.B13 391.16,390.35 ; D112.B13 391.97,391.16 ; 324.31,347.98 D114.B10 ; D114.B10 325.12,347.17 ; D114.B10 325.12,348.79 ; D114.B10 325.93,347.98 ; D231.A8 182.88,374.19 ; D231.A8 182.88,372.57 ; D231.A8 182.07,373.38 ; D231.A8 183.69,373.38 ; 403.86,347.17 D110.B8 ; D110.B8 403.05,347.98 ; D110.B8 403.86,348.79 ; D110.B8 404.67,347.98 ; D322.A10 256.54,66.75 ; D322.A10 256.54,65.33 ; D322.A10 255.83,66.04 ; D322.A10 257.25,66.04 ; D126.B3 18.59,78.74 ; D126.B3 17.78,77.93 ; D126.B3 17.78,79.55 ; D126.B3 16.97,78.74 ; D132.A5 97.33,33.02 ; D132.A5 96.52,32.21 ; D132.A5 95.71,33.02 ; D132.A5 96.52,33.83 ; D113.B9 327.66,331.01 ; D113.B9 327.66,329.39 ; D113.B9 328.47,330.2 ; D113.B9 326.85,330.2 ; 340.36,75.39 D102.A14 ; D102.A14 340.36,77.01 ; D102.A14 339.55,76.2 ; D102.A14 341.17,76.2 ; 248.33,180.85 SITE3.G1 ; SITE3.G1 248.33,181.81 ; SITE3.G1 247.85,181.33 ; SITE3.G1 248.81,181.33 ; 261.62,90.73 D321.B12 ; D321.B12 261.62,92.15 ; D321.B12 262.33,91.44 ; D321.B12 260.91,91.44 ; 96.35,161.85 UNK3U1.4 ; UNK3U1.4 98.23,161.85 ; UNK3U1.4 97.29,160.91 ; UNK3U1.4 97.29,162.79 ; D119.A2 163.37,55.88 ; D119.A2 161.75,55.88 ; D119.A2 162.56,55.07 ; D119.A2 162.56,56.69 ; D130.B1 86.36,79.55 ; D130.B1 85.55,78.74 ; D130.B1 87.17,78.74 ; D130.B1 86.36,77.93 ; 167.64,60.15 D119.B4 ; D119.B4 166.83,60.96 ; D119.B4 168.45,60.96 ; D119.B4 167.64,61.77 ; CSDPS229.B2 198.12,333.55 ; CSDPS229.B2 198.12,331.93 ; CSDPS229.B2 198.93,332.74 ; CSDPS229.B2 197.31,332.74 ; D126.B6 26.21,81.28 ; D126.B6 24.59,81.28 ; D126.B6 25.4,80.47 ; D126.B6 25.4,82.09 ; D128.A6 26.21,35.56 ; D128.A6 24.59,35.56 ; D128.A6 25.4,34.75 ; D128.A6 25.4,36.37 ; D111.A3 417.37,375.92 ; D111.A3 416.56,375.11 ; D111.A3 416.56,376.73 ; D111.A3 415.75,375.92 ; 233.68,13.16 DPS3.A01 ; DPS3.A01 232.87,13.97 ; DPS3.A01 234.49,13.97 ; DPS3.A01 233.68,14.78 ; 317.5,375.11 D115.A13 ; D115.A13 316.69,375.92 ; D115.A13 317.5,376.73 ; D115.A13 318.31,375.92 ; 321.77,350.52 D114.B11 ; D114.B11 322.58,351.33 ; D114.B11 322.58,349.71 ; D114.B11 323.39,350.52 ; D301.B8 325.83,91.44 ; D301.B8 324.41,91.44 ; D301.B8 325.12,90.73 ; D301.B8 325.12,92.15 ; D115.B12 320.85,368.3 ; D115.B12 320.04,367.49 ; D115.B12 319.23,368.3 ; D115.B12 320.04,369.11 ; D112.B8 403.86,389.43 ; D112.B8 403.05,388.62 ; D112.B8 404.67,388.62 ; D112.B8 403.86,387.81 ; D104.A8 325.12,36.37 ; D104.A8 324.31,35.56 ; D104.A8 325.12,34.75 ; D104.A8 325.93,35.56 ; 252.15,242.83 SITE1.G16 ; SITE1.G16 253.11,242.83 ; SITE1.G16 252.63,242.35 ; SITE1.G16 252.63,243.31 ; 311.61,330.2 D113.B15 ; D113.B15 313.23,330.2 ; D113.B15 312.42,331.01 ; D113.B15 312.42,329.39 ; D123.B4 242.11,60.96 ; D123.B4 241.3,60.15 ; D123.B4 241.3,61.77 ; D123.B4 240.49,60.96 ; 391.16,395.43 D112.A13 ; D112.A13 391.16,397.05 ; D112.A13 391.97,396.24 ; D112.A13 390.35,396.24 ; D118.A10 182.88,77.01 ; D118.A10 182.88,75.39 ; D118.A10 182.07,76.2 ; D118.A10 183.69,76.2 ; D317.A10 183.59,86.36 ; D317.A10 182.88,87.07 ; D317.A10 182.17,86.36 ; D317.A10 182.88,85.65 ; D129.A2 89.71,96.52 ; D129.A2 88.09,96.52 ; D129.A2 88.9,95.71 ; D129.A2 88.9,97.33 ; D106.A14 414.83,76.2 ; D106.A14 413.21,76.2 ; D106.A14 414.02,75.39 ; D106.A14 414.02,77.01 ; 383.54,372.57 D111.A16 ; D111.A16 384.35,373.38 ; D111.A16 383.54,374.19 ; D111.A16 382.73,373.38 ; D108.B7 396.24,38.91 ; D108.B7 397.05,38.1 ; D108.B7 396.24,37.29 ; D108.B7 395.43,38.1 ; 260.91,71.12 D322.B12 ; D322.B12 261.62,71.83 ; D322.B12 262.33,71.12 ; D322.B12 261.62,70.41 ; D302.A8 325.83,66.04 ; D302.A8 324.41,66.04 ; D302.A8 325.12,65.33 ; D302.A8 325.12,66.75 ; D130.B11 112.57,78.74 ; D130.B11 111.76,79.55 ; D130.B11 111.76,77.93 ; D130.B11 110.95,78.74 ; D116.A7 332.74,397.05 ; D116.A7 333.55,396.24 ; D116.A7 332.74,395.43 ; D116.A7 331.93,396.24 ; 332.33,240.85 SITE2.G5 ; SITE2.G5 331.85,241.33 ; SITE2.G5 332.33,241.81 ; SITE2.G5 332.81,241.33 ; 22.86,57.61 D127.B5 ; D127.B5 22.86,59.23 ; D127.B5 22.05,58.42 ; D127.B5 23.67,58.42 ; D129.A8 104.14,97.33 ; D129.A8 104.14,95.71 ; D129.A8 104.95,96.52 ; D129.A8 103.33,96.52 ; 314.15,81.28 D102.B4 ; D102.B4 314.96,80.47 ; D102.B4 314.96,82.09 ; D102.B4 315.77,81.28 ; 187.15,60.96 D119.B12 ; D119.B12 187.96,61.77 ; D119.B12 188.77,60.96 ; D119.B12 187.96,60.15 ; D306.A5 391.16,64.21 ; D306.A5 391.87,63.5 ; D306.A5 391.16,62.79 ; D306.A5 390.45,63.5 ; SITE3.G19 251.43,186.91 ; SITE3.G19 251.91,186.43 ; SITE3.G19 250.95,186.43 ; SITE3.G19 251.43,185.95 ; 235.41,76.2 D122.A2 ; D122.A2 237.03,76.2 ; D122.A2 236.22,77.01 ; D122.A2 236.22,75.39 ; SITE3.G5 252.81,181.33 ; SITE3.G5 251.85,181.33 ; SITE3.G5 252.33,180.85 ; SITE3.G5 252.33,181.81 ; 268.43,78.74 D122.B15 ; D122.B15 270.05,78.74 ; D122.B15 269.24,77.93 ; D122.B15 269.24,79.55 ; 316.69,355.6 D114.A13 ; D114.A13 317.5,356.41 ; D114.A13 318.31,355.6 ; D114.A13 317.5,354.79 ; 233.68,52.53 D123.A1 ; D123.A1 234.49,53.34 ; D123.A1 233.68,54.15 ; D123.A1 232.87,53.34 ; 238.76,329.39 CSDPS225.C15 ; CSDPS225.C15 239.57,330.2 ; CSDPS225.C15 238.76,331.01 ; CSDPS225.C15 237.95,330.2 ; 24.59,101.6 D125.B6 ; D125.B6 25.4,100.79 ; D125.B6 26.21,101.6 ; D125.B6 25.4,102.41 ; 197.31,76.2 D118.A16 ; D118.A16 198.12,77.01 ; D118.A16 198.93,76.2 ; D118.A16 198.12,75.39 ; D106.B13 411.48,79.55 ; D106.B13 411.48,77.93 ; D106.B13 412.29,78.74 ; D106.B13 410.67,78.74 ; D125.B13 43.18,99.87 ; D125.B13 43.18,98.25 ; D125.B13 42.37,99.06 ; D125.B13 43.99,99.06 ; D317.A9 180.34,84.53 ; D317.A9 181.05,83.82 ; D317.A9 180.34,83.11 ; D317.A9 179.63,83.82 ; SITE3.G2 249.33,181.81 ; SITE3.G2 249.81,181.33 ; SITE3.G2 248.85,181.33 ; SITE3.G2 249.33,180.85 ; 322.58,354.79 D114.A11 ; D114.A11 321.77,355.6 ; D114.A11 322.58,356.41 ; D114.A11 323.39,355.6 ; D231.A12 173.53,373.38 ; D231.A12 172.72,372.57 ; D231.A12 172.72,374.19 ; D231.A12 171.91,373.38 ; D103.A6 320.04,56.69 ; D103.A6 320.04,55.07 ; D103.A6 320.85,55.88 ; D103.A6 319.23,55.88 ; 174.45,370.84 D231.B11 ; D231.B11 175.26,371.65 ; D231.B11 176.07,370.84 ; D231.B11 175.26,370.03 ; D125.B15 49.07,99.06 ; D125.B15 48.26,98.25 ; D125.B15 47.45,99.06 ; D125.B15 48.26,99.87 ; D125.B9 33.83,99.06 ; D125.B9 32.21,99.06 ; D125.B9 33.02,98.25 ; D125.B9 33.02,99.87 ; D107.A4 389.43,55.88 ; D107.A4 388.62,56.69 ; D107.A4 387.81,55.88 ; D107.A4 388.62,55.07 ; 189.69,38.1 D120.B13 ; D120.B13 191.31,38.1 ; D120.B13 190.5,37.29 ; D120.B13 190.5,38.91 ; 118.57,76.2 D130.A14 ; D130.A14 119.38,75.39 ; D130.A14 119.38,77.01 ; D130.A14 120.19,76.2 ; 347.17,415.29 DPS2.A01 ; DPS2.A01 347.98,416.1 ; DPS2.A01 348.79,415.29 ; DPS2.A01 347.98,414.48 ; D113.A1 348.79,335.28 ; D113.A1 347.98,334.47 ; D113.A1 347.98,336.09 ; D113.A1 347.17,335.28 ; 250.65,76.2 D122.A8 ; D122.A8 252.27,76.2 ; D122.A8 251.46,75.39 ; D122.A8 251.46,77.01 ; D318.B10 183.59,71.12 ; D318.B10 182.17,71.12 ; D318.B10 182.88,70.41 ; D318.B10 182.88,71.83 ; D318.A8 178.51,66.04 ; D318.A8 177.8,65.33 ; D318.A8 177.8,66.75 ; D318.A8 177.09,66.04 ; D118.A4 168.45,76.2 ; D118.A4 167.64,75.39 ; D118.A4 167.64,77.01 ; D118.A4 166.83,76.2 ; D231.B15 165.1,371.65 ; D231.B15 165.1,370.03 ; D231.B15 164.29,370.84 ; D231.B15 165.91,370.84 ; 200.66,375.11 D231.A1 ; D231.A1 199.85,375.92 ; D231.A1 200.66,376.73 ; D231.A1 201.47,375.92 ; 396.24,52.53 D107.A7 ; D107.A7 396.24,54.15 ; D107.A7 395.43,53.34 ; D107.A7 397.05,53.34 ; 415.75,38.1 D108.B15 ; D108.B15 416.56,38.91 ; D108.B15 416.56,37.29 ; D108.B15 417.37,38.1 ; D231.A2 198.93,373.38 ; D231.A2 198.12,374.19 ; D231.A2 198.12,372.57 ; D231.A2 197.31,373.38 ; 98.25,40.64 D132.B6 ; D132.B6 99.06,41.45 ; D132.B6 99.06,39.83 ; D132.B6 99.87,40.64 ; D103.B2 309.88,61.77 ; D103.B2 309.07,60.96 ; D103.B2 310.69,60.96 ; D103.B2 309.88,60.15 ; 182.88,90.73 D317.B10 ; D317.B10 182.88,92.15 ; D317.B10 183.59,91.44 ; D317.B10 182.17,91.44 ; 340.36,34.75 D104.A14 ; D104.A14 340.36,36.37 ; D104.A14 341.17,35.56 ; D104.A14 339.55,35.56 ; 187.96,85.65 D317.A12 ; D317.A12 187.25,86.36 ; D317.A12 187.96,87.07 ; D317.A12 188.67,86.36 ; 331.93,53.34 D103.A11 ; D103.A11 333.55,53.34 ; D103.A11 332.74,54.15 ; D103.A11 332.74,52.53 ; D431.B1 200.66,381.81 ; D431.B1 201.47,381 ; D431.B1 199.85,381 ; D431.B1 200.66,380.19 ; D118.B11 185.42,79.55 ; D118.B11 186.23,78.74 ; D118.B11 184.61,78.74 ; D118.B11 185.42,77.93 ; D120.A3 165.1,33.83 ; D120.A3 165.1,32.21 ; D120.A3 165.91,33.02 ; D120.A3 164.29,33.02 ; D127.A14 46.53,55.88 ; D127.A14 45.72,56.69 ; D127.A14 44.91,55.88 ; D127.A14 45.72,55.07 ; D102.A3 312.42,74.47 ; D102.A3 312.42,72.85 ; D102.A3 311.61,73.66 ; D102.A3 313.23,73.66 ; D118.B14 193.85,81.28 ; D118.B14 192.23,81.28 ; D118.B14 193.04,80.47 ; D118.B14 193.04,82.09 ; D317.A11 185.42,84.53 ; D317.A11 184.71,83.82 ; D317.A11 186.13,83.82 ; D317.A11 185.42,83.11 ; D431.B12 173.53,378.46 ; D431.B12 171.91,378.46 ; D431.B12 172.72,377.65 ; D431.B12 172.72,379.27 ; D128.B5 22.86,38.91 ; D128.B5 22.05,38.1 ; D128.B5 22.86,37.29 ; D128.B5 23.67,38.1 ; D302.A6 320.04,66.75 ; D302.A6 320.75,66.04 ; D302.A6 320.04,65.33 ; D302.A6 319.33,66.04 ; 167.64,39.83 D120.B4 ; D120.B4 167.64,41.45 ; D120.B4 168.45,40.64 ; D120.B4 166.83,40.64 ; D114.B12 320.04,348.79 ; D114.B12 320.04,347.17 ; D114.B12 319.23,347.98 ; D114.B12 320.85,347.98 ; D122.B16 272.59,81.28 ; D122.B16 271.78,82.09 ; D122.B16 271.78,80.47 ; D122.B16 270.97,81.28 ; D132.B8 104.14,41.45 ; D132.B8 104.95,40.64 ; D132.B8 104.14,39.83 ; D132.B8 103.33,40.64 ; D126.A2 16.05,76.2 ; D126.A2 14.43,76.2 ; D126.A2 15.24,75.39 ; D126.A2 15.24,77.01 ; 307.34,57.61 D103.B1 ; D103.B1 306.53,58.42 ; D103.B1 308.15,58.42 ; D103.B1 307.34,59.23 ; D130.A5 96.52,74.47 ; D130.A5 96.52,72.85 ; D130.A5 97.33,73.66 ; D130.A5 95.71,73.66 ; D120.B12 187.96,41.45 ; D120.B12 187.15,40.64 ; D120.B12 187.96,39.83 ; D120.B12 188.77,40.64 ; 418.39,71.12 D306.B16 ; D306.B16 419.1,70.41 ; D306.B16 419.1,71.83 ; D306.B16 419.81,71.12 ; 240.49,81.28 D122.B4 ; D122.B4 241.3,82.09 ; D122.B4 242.11,81.28 ; D122.B4 241.3,80.47 ; 243.84,72.85 D122.A5 ; D122.A5 243.84,74.47 ; D122.A5 244.65,73.66 ; D122.A5 243.03,73.66 ; DPS8.C01 200.66,411.02 ; DPS8.C01 201.47,410.21 ; DPS8.C01 199.85,410.21 ; DPS8.C01 200.66,409.4 ; SITE4.G2 329.33,181.81 ; SITE4.G2 329.81,181.33 ; SITE4.G2 328.85,181.33 ; SITE4.G2 329.33,180.85 ; D124.A1 234.49,33.02 ; D124.A1 233.68,33.83 ; D124.A1 233.68,32.21 ; D124.A1 232.87,33.02 ; 256.54,342.09 CSDPS425.B8 ; CSDPS425.B8 255.73,342.9 ; CSDPS425.B8 257.35,342.9 ; CSDPS425.B8 256.54,343.71 ; D301.A15 343.61,83.82 ; D301.A15 342.19,83.82 ; D301.A15 342.9,83.11 ; D301.A15 342.9,84.53 ; DPS3.C11 259.08,19.86 ; DPS3.C11 258.27,19.05 ; DPS3.C11 259.89,19.05 ; DPS3.C11 259.08,18.24 ; D113.B5 338.63,330.2 ; D113.B5 337.82,331.01 ; D113.B5 337.82,329.39 ; D113.B5 337.01,330.2 ; 314.96,372.57 D115.A14 ; D115.A14 314.15,373.38 ; D115.A14 314.96,374.19 ; D115.A14 315.77,373.38 ; D130.B13 117.65,78.74 ; D130.B13 116.84,79.55 ; D130.B13 116.84,77.93 ; D130.B13 116.03,78.74 ; 387.91,86.36 D305.A4 ; D305.A4 388.62,85.65 ; D305.A4 388.62,87.07 ; D305.A4 389.33,86.36 ; 34.75,101.6 D125.B10 ; D125.B10 35.56,100.79 ; D125.B10 36.37,101.6 ; D125.B10 35.56,102.41 ; D321.A16 272.49,86.36 ; D321.A16 271.78,87.07 ; D321.A16 271.78,85.65 ; D321.A16 271.07,86.36 ; D127.A9 33.02,54.15 ; D127.A9 33.83,53.34 ; D127.A9 33.02,52.53 ; D127.A9 32.21,53.34 ; D108.B12 409.75,40.64 ; D108.B12 408.94,39.83 ; D108.B12 408.13,40.64 ; D108.B12 408.94,41.45 ; 11.89,93.98 D125.A1 ; D125.A1 12.7,94.79 ; D125.A1 13.51,93.98 ; D125.A1 12.7,93.17 ; 334.47,347.98 D114.B6 ; D114.B6 335.28,348.79 ; D114.B6 336.09,347.98 ; D114.B6 335.28,347.17 ; D322.B7 249.63,68.58 ; D322.B7 248.21,68.58 ; D322.B7 248.92,69.29 ; D322.B7 248.92,67.87 ; D305.B6 393.7,92.15 ; D305.B6 393.7,90.73 ; D305.B6 392.99,91.44 ; D305.B6 394.41,91.44 ; D305.A2 383.54,87.07 ; D305.A2 384.25,86.36 ; D305.A2 382.83,86.36 ; D305.A2 383.54,85.65 ; D126.B10 36.37,81.28 ; D126.B10 35.56,82.09 ; D126.B10 34.75,81.28 ; D126.B10 35.56,80.47 ; 116.84,57.61 D131.B13 ; D131.B13 116.03,58.42 ; D131.B13 117.65,58.42 ; D131.B13 116.84,59.23 ; 97.4,174.52 UNK3U2.4 ; UNK3U2.4 96.46,175.46 ; UNK3U2.4 98.34,175.46 ; UNK3U2.4 97.4,176.4 ; 381,57.61 D107.B1 ; D107.B1 381.81,58.42 ; D107.B1 380.19,58.42 ; D107.B1 381,59.23 ; D128.B12 40.64,41.45 ; D128.B12 40.64,39.83 ; D128.B12 41.45,40.64 ; D128.B12 39.83,40.64 ; 180.34,72.85 D118.A9 ; D118.A9 181.15,73.66 ; D118.A9 180.34,74.47 ; D118.A9 179.53,73.66 ; 481.65,185.11 UNK4U1.4 ; UNK4U1.4 482.59,186.05 ; UNK4U1.4 483.53,185.11 ; UNK4U1.4 482.59,184.17 ; 250.75,91.44 D321.B8 ; D321.B8 251.46,90.73 ; D321.B8 251.46,92.15 ; D321.B8 252.17,91.44 ; D322.B8 252.17,71.12 ; D322.B8 250.75,71.12 ; D322.B8 251.46,71.83 ; D322.B8 251.46,70.41 ; D306.B10 404.57,71.12 ; D306.B10 403.86,71.83 ; D306.B10 403.15,71.12 ; D306.B10 403.86,70.41 ; 69.67,209.04 S1_I2C.4 ; S1_I2C.4 70.61,208.1 ; S1_I2C.4 70.61,209.98 ; S1_I2C.4 71.55,209.04 ; D113.A14 314.96,333.55 ; D113.A14 314.96,331.93 ; D113.A14 315.77,332.74 ; D113.A14 314.15,332.74 ; 184.61,38.1 D120.B11 ; D120.B11 185.42,38.91 ; D120.B11 186.23,38.1 ; D120.B11 185.42,37.29 ; 392.89,327.66 D109.B12 ; D109.B12 393.7,328.47 ; D109.B12 394.51,327.66 ; D109.B12 393.7,326.85 ; D115.B6 336.09,368.3 ; D115.B6 334.47,368.3 ; D115.B6 335.28,367.49 ; D115.B6 335.28,369.11 ; D123.A5 243.84,54.15 ; D123.A5 243.03,53.34 ; D123.A5 244.65,53.34 ; D123.A5 243.84,52.53 ; 314.96,352.25 D114.A14 ; D114.A14 314.15,353.06 ; D114.A14 315.77,353.06 ; D114.A14 314.96,353.87 ; 387.81,327.66 D109.B14 ; D109.B14 389.43,327.66 ; D109.B14 388.62,326.85 ; D109.B14 388.62,328.47 ; 235.51,71.12 D322.B2 ; D322.B2 236.22,70.41 ; D322.B2 236.22,71.83 ; D322.B2 236.93,71.12 ; 345.44,75.39 D102.A16 ; D102.A16 345.44,77.01 ; D102.A16 346.25,76.2 ; D102.A16 344.63,76.2 ; SITE1.G3 250.81,241.33 ; SITE1.G3 249.85,241.33 ; SITE1.G3 250.33,240.85 ; SITE1.G3 250.33,241.81 ; D115.A4 340.36,374.19 ; D115.A4 341.17,373.38 ; D115.A4 339.55,373.38 ; D115.A4 340.36,372.57 ; 85.55,58.42 D131.B1 ; D131.B1 86.36,59.23 ; D131.B1 87.17,58.42 ; D131.B1 86.36,57.61 ; SITE3.G11 252.81,187.93 ; SITE3.G11 252.33,188.41 ; SITE3.G11 252.33,187.45 ; SITE3.G11 251.85,187.93 ; D318.B12 187.96,71.83 ; D318.B12 187.25,71.12 ; D318.B12 187.96,70.41 ; D318.B12 188.67,71.12 ; 410.67,73.66 D106.A13 ; D106.A13 411.48,74.47 ; D106.A13 412.29,73.66 ; D106.A13 411.48,72.85 ; SITE2.G6 333.33,241.81 ; SITE2.G6 332.85,241.33 ; SITE2.G6 333.33,240.85 ; SITE2.G6 333.81,241.33 ; D231.A6 188.77,373.38 ; D231.A6 187.96,372.57 ; D231.A6 187.96,374.19 ; D231.A6 187.15,373.38 ; D126.A15 49.07,73.66 ; D126.A15 48.26,72.85 ; D126.A15 48.26,74.47 ; D126.A15 47.45,73.66 ; 50.8,39.83 D128.B16 ; D128.B16 50.8,41.45 ; D128.B16 51.61,40.64 ; D128.B16 49.99,40.64 ; 381,72.85 D106.A1 ; D106.A1 380.19,73.66 ; D106.A1 381.81,73.66 ; D106.A1 381,74.47 ; 250.95,182.83 SITE3.G15 ; SITE3.G15 251.43,183.31 ; SITE3.G15 251.43,182.35 ; SITE3.G15 251.91,182.83 ; 345.44,367.49 D115.B2 ; D115.B2 346.25,368.3 ; D115.B2 345.44,369.11 ; D115.B2 344.63,368.3 ; SITE1.G14 250.23,243.31 ; SITE1.G14 250.23,242.35 ; SITE1.G14 250.71,242.83 ; SITE1.G14 249.75,242.83 ; 311.61,53.34 D103.A3 ; D103.A3 312.42,54.15 ; D103.A3 312.42,52.53 ; D103.A3 313.23,53.34 ; 314.96,85.65 D301.A4 ; D301.A4 314.96,87.07 ; D301.A4 314.25,86.36 ; D301.A4 315.67,86.36 ; 182.88,377.65 D431.B8 ; D431.B8 182.07,378.46 ; D431.B8 183.69,378.46 ; D431.B8 182.88,379.27 ; 37.29,93.98 D125.A11 ; D125.A11 38.1,94.79 ; D125.A11 38.1,93.17 ; D125.A11 38.91,93.98 ; 32.21,78.74 D126.B9 ; D126.B9 33.83,78.74 ; D126.B9 33.02,77.93 ; D126.B9 33.02,79.55 ; D119.A10 182.88,56.69 ; D119.A10 183.69,55.88 ; D119.A10 182.88,55.07 ; D119.A10 182.07,55.88 ; 248.92,32.21 D124.A7 ; D124.A7 248.92,33.83 ; D124.A7 248.11,33.02 ; D124.A7 249.73,33.02 ; D123.A6 246.38,56.69 ; D123.A6 245.57,55.88 ; D123.A6 246.38,55.07 ; D123.A6 247.19,55.88 ; D108.A2 384.35,35.56 ; D108.A2 383.54,34.75 ; D108.A2 382.73,35.56 ; D108.A2 383.54,36.37 ; D128.A4 21.13,35.56 ; D128.A4 20.32,34.75 ; D128.A4 19.51,35.56 ; D128.A4 20.32,36.37 ; 248.11,58.42 D123.B7 ; D123.B7 249.73,58.42 ; D123.B7 248.92,59.23 ; D123.B7 248.92,57.61 ; 160.02,57.61 D119.B1 ; D119.B1 159.21,58.42 ; D119.B1 160.02,59.23 ; D119.B1 160.83,58.42 ; D111.B1 422.45,370.84 ; D111.B1 421.64,370.03 ; D111.B1 420.83,370.84 ; D111.B1 421.64,371.65 ; D113.A7 333.55,335.28 ; D113.A7 332.74,334.47 ; D113.A7 332.74,336.09 ; D113.A7 331.93,335.28 ; 395.43,355.6 D110.A11 ; D110.A11 396.24,356.41 ; D110.A11 397.05,355.6 ; D110.A11 396.24,354.79 ; 383.54,55.07 D107.A2 ; D107.A2 382.73,55.88 ; D107.A2 384.35,55.88 ; D107.A2 383.54,56.69 ; UNK2U2.4 483.43,214.94 ; UNK2U2.4 481.55,214.94 ; UNK2U2.4 482.49,214 ; UNK2U2.4 482.49,215.88 ; SITE2.G16 333.11,242.83 ; SITE2.G16 332.63,243.31 ; SITE2.G16 332.63,242.35 ; SITE2.G16 332.15,242.83 ; 324.31,55.88 D103.A8 ; D103.A8 325.12,55.07 ; D103.A8 325.12,56.69 ; D103.A8 325.93,55.88 ; 337.01,335.28 D113.A5 ; D113.A5 337.82,336.09 ; D113.A5 337.82,334.47 ; D113.A5 338.63,335.28 ; 335.28,331.93 D113.A6 ; D113.A6 335.28,333.55 ; D113.A6 336.09,332.74 ; D113.A6 334.47,332.74 ; 190.5,67.87 D318.B13 ; D318.B13 190.5,69.29 ; D318.B13 191.21,68.58 ; D318.B13 189.79,68.58 ; 327.66,375.11 D115.A9 ; D115.A9 328.47,375.92 ; D115.A9 327.66,376.73 ; D115.A9 326.85,375.92 ; 172.01,66.04 D318.A6 ; D318.A6 173.43,66.04 ; D318.A6 172.72,65.33 ; D318.A6 172.72,66.75 ; 248.33,187.45 SITE3.G7 ; SITE3.G7 247.85,187.93 ; SITE3.G7 248.81,187.93 ; SITE3.G7 248.33,188.41 ; D305.A16 419.81,86.36 ; D305.A16 419.1,87.07 ; D305.A16 419.1,85.65 ; D305.A16 418.39,86.36 ; D118.A11 185.42,74.47 ; D118.A11 184.61,73.66 ; D118.A11 186.23,73.66 ; D118.A11 185.42,72.85 ; 248.55,242.83 SITE1.G13 ; SITE1.G13 249.03,242.35 ; SITE1.G13 249.03,243.31 ; SITE1.G13 249.51,242.83 ; 198.12,34.75 D120.A16 ; D120.A16 198.12,36.37 ; D120.A16 198.93,35.56 ; D120.A16 197.31,35.56 ; 93.98,95.71 D129.A4 ; D129.A4 94.79,96.52 ; D129.A4 93.98,97.33 ; D129.A4 93.17,96.52 ; SITE2.G19 331.91,246.43 ; SITE2.G19 331.43,246.91 ; SITE2.G19 330.95,246.43 ; SITE2.G19 331.43,245.95 ; D305.A7 396.95,83.82 ; D305.A7 396.24,83.11 ; D305.A7 395.53,83.82 ; D305.A7 396.24,84.53 ; 246.38,65.33 D322.A6 ; D322.A6 245.67,66.04 ; D322.A6 246.38,66.75 ; D322.A6 247.09,66.04 ; 160.02,375.11 D231.A17 ; D231.A17 160.83,375.92 ; D231.A17 160.02,376.73 ; D231.A17 159.21,375.92 ; 19.51,101.6 D125.B4 ; D125.B4 20.32,102.41 ; D125.B4 20.32,100.79 ; D125.B4 21.13,101.6 ; D306.B1 381,69.29 ; D306.B1 380.29,68.58 ; D306.B1 381,67.87 ; D306.B1 381.71,68.58 ; 11.89,33.02 D128.A1 ; D128.A1 12.7,33.83 ; D128.A1 13.51,33.02 ; D128.A1 12.7,32.21 ; D119.B3 165.1,59.23 ; D119.B3 164.29,58.42 ; D119.B3 165.1,57.61 ; D119.B3 165.91,58.42 ; D125.A13 43.18,94.79 ; D125.A13 42.37,93.98 ; D125.A13 43.99,93.98 ; D125.A13 43.18,93.17 ; 329.39,373.38 D115.A8 ; D115.A8 331.01,373.38 ; D115.A8 330.2,374.19 ; D115.A8 330.2,372.57 ; D120.B6 172.72,41.45 ; D120.B6 172.72,39.83 ; D120.B6 171.91,40.64 ; D120.B6 173.53,40.64 ; 170.18,62.79 D318.A5 ; D318.A5 170.89,63.5 ; D318.A5 169.47,63.5 ; D318.A5 170.18,64.21 ; D118.A13 190.5,74.47 ; D118.A13 189.69,73.66 ; D118.A13 191.31,73.66 ; D118.A13 190.5,72.85 ; D114.B16 310.69,347.98 ; D114.B16 309.88,347.17 ; D114.B16 309.88,348.79 ; D114.B16 309.07,347.98 ; 388.62,34.75 D108.A4 ; D108.A4 389.43,35.56 ; D108.A4 388.62,36.37 ; D108.A4 387.81,35.56 ; 340.36,367.49 D115.B4 ; D115.B4 340.36,369.11 ; D115.B4 339.55,368.3 ; D115.B4 341.17,368.3 ; 337.01,53.34 D103.A13 ; D103.A13 337.82,54.15 ; D103.A13 337.82,52.53 ; D103.A13 338.63,53.34 ; 248.21,63.5 D322.A7 ; D322.A7 249.63,63.5 ; D322.A7 248.92,62.79 ; D322.A7 248.92,64.21 ; D302.A1 308.05,63.5 ; D302.A1 306.63,63.5 ; D302.A1 307.34,64.21 ; D302.A1 307.34,62.79 ; D110.B6 409.75,347.98 ; D110.B6 408.94,348.79 ; D110.B6 408.13,347.98 ; D110.B6 408.94,347.17 ; D128.B11 38.91,38.1 ; D128.B11 37.29,38.1 ; D128.B11 38.1,38.91 ; D128.B11 38.1,37.29 ; 182.88,342.09 CSDPS429.B8 ; CSDPS429.B8 182.88,343.71 ; CSDPS429.B8 182.07,342.9 ; CSDPS429.B8 183.69,342.9 ; D116.A12 320.85,393.7 ; D116.A12 319.23,393.7 ; D116.A12 320.04,392.89 ; D116.A12 320.04,394.51 ; 413.31,91.44 D305.B14 ; D305.B14 414.73,91.44 ; D305.B14 414.02,92.15 ; D305.B14 414.02,90.73 ; 418.29,347.98 D110.B2 ; D110.B2 419.1,348.79 ; D110.B2 419.1,347.17 ; D110.B2 419.91,347.98 ; D123.B16 272.59,60.96 ; D123.B16 271.78,61.77 ; D123.B16 271.78,60.15 ; D123.B16 270.97,60.96 ; D107.B7 396.24,59.23 ; D107.B7 395.43,58.42 ; D107.B7 397.05,58.42 ; D107.B7 396.24,57.61 ; D305.B2 383.54,92.15 ; D305.B2 383.54,90.73 ; D305.B2 382.83,91.44 ; D305.B2 384.25,91.44 ; 265.89,342.9 CSDPS425.B4 ; CSDPS425.B4 266.7,342.09 ; CSDPS425.B4 267.51,342.9 ; CSDPS425.B4 266.7,343.71 ; D118.B4 167.64,82.09 ; D118.B4 167.64,80.47 ; D118.B4 168.45,81.28 ; D118.B4 166.83,81.28 ; D322.A8 251.46,66.75 ; D322.A8 251.46,65.33 ; D322.A8 250.75,66.04 ; D322.A8 252.17,66.04 ; D321.B6 247.09,91.44 ; D321.B6 246.38,92.15 ; D321.B6 245.67,91.44 ; D321.B6 246.38,90.73 ; 347.98,370.03 D115.B1 ; D115.B1 347.17,370.84 ; D115.B1 347.98,371.65 ; D115.B1 348.79,370.84 ; D301.B16 346.15,91.44 ; D301.B16 345.44,92.15 ; D301.B16 344.73,91.44 ; D301.B16 345.44,90.73 ; 309.17,71.12 D302.B2 ; D302.B2 310.59,71.12 ; D302.B2 309.88,70.41 ; D302.B2 309.88,71.83 ; D103.B16 345.44,61.77 ; D103.B16 345.44,60.15 ; D103.B16 344.63,60.96 ; D103.B16 346.25,60.96 ; 247.85,241.33 SITE1.G1 ; SITE1.G1 248.33,240.85 ; SITE1.G1 248.81,241.33 ; SITE1.G1 248.33,241.81 ; D116.B12 320.85,388.62 ; D116.B12 320.04,389.43 ; D116.B12 320.04,387.81 ; D116.B12 319.23,388.62 ; D302.A12 335.99,66.04 ; D302.A12 335.28,65.33 ; D302.A12 335.28,66.75 ; D302.A12 334.57,66.04 ; 332.74,32.21 D104.A11 ; D104.A11 333.55,33.02 ; D104.A11 332.74,33.83 ; D104.A11 331.93,33.02 ; D102.A2 310.69,76.2 ; D102.A2 309.88,77.01 ; D102.A2 309.07,76.2 ; D102.A2 309.88,75.39 ; D108.A12 408.94,36.37 ; D108.A12 408.94,34.75 ; D108.A12 408.13,35.56 ; D108.A12 409.75,35.56 ; D431.B15 165.91,381 ; D431.B15 165.1,380.19 ; D431.B15 165.1,381.81 ; D431.B15 164.29,381 ; 401.32,329.39 D109.B9 ; D109.B9 400.51,330.2 ; D109.B9 402.13,330.2 ; D109.B9 401.32,331.01 ; 320.04,34.75 D104.A6 ; D104.A6 320.04,36.37 ; D104.A6 320.85,35.56 ; D104.A6 319.23,35.56 ; 250.75,86.36 D321.A8 ; D321.A8 251.46,85.65 ; D321.A8 252.17,86.36 ; D321.A8 251.46,87.07 ; 411.48,395.43 D112.A5 ; D112.A5 410.67,396.24 ; D112.A5 411.48,397.05 ; D112.A5 412.29,396.24 ; D131.B4 93.98,61.77 ; D131.B4 94.79,60.96 ; D131.B4 93.98,60.15 ; D131.B4 93.17,60.96 ; 121.11,78.74 D130.B15 ; D130.B15 122.73,78.74 ; D130.B15 121.92,79.55 ; D130.B15 121.92,77.93 ; 327.66,72.85 D102.A9 ; D102.A9 327.66,74.47 ; D102.A9 326.85,73.66 ; D102.A9 328.47,73.66 ; 236.22,80.47 D122.B2 ; D122.B2 237.03,81.28 ; D122.B2 236.22,82.09 ; D122.B2 235.41,81.28 ; 238.76,88.19 D321.B3 ; D321.B3 239.47,88.9 ; D321.B3 238.05,88.9 ; D321.B3 238.76,89.61 ; 337.82,375.11 D115.A5 ; D115.A5 338.63,375.92 ; D115.A5 337.82,376.73 ; D115.A5 337.01,375.92 ; 189.79,88.9 D317.B13 ; D317.B13 190.5,88.19 ; D317.B13 191.21,88.9 ; D317.B13 190.5,89.61 ; D110.A15 386.89,355.6 ; D110.A15 386.08,356.41 ; D110.A15 386.08,354.79 ; D110.A15 385.27,355.6 ; D106.B11 407.21,78.74 ; D106.B11 406.4,79.55 ; D106.B11 405.59,78.74 ; D106.B11 406.4,77.93 ; D110.A12 393.7,353.87 ; D110.A12 393.7,352.25 ; D110.A12 394.51,353.06 ; D110.A12 392.89,353.06 ; 106.68,52.53 D131.A9 ; D131.A9 106.68,54.15 ; D131.A9 105.87,53.34 ; D131.A9 107.49,53.34 ; D110.B16 384.35,347.98 ; D110.B16 383.54,347.17 ; D110.B16 383.54,348.79 ; D110.B16 382.73,347.98 ; D132.A16 125.27,35.56 ; D132.A16 124.46,34.75 ; D132.A16 124.46,36.37 ; D132.A16 123.65,35.56 ; 195.58,57.61 D119.B15 ; D119.B15 195.58,59.23 ; D119.B15 196.39,58.42 ; D119.B15 194.77,58.42 ; 96.1,205.54 U1.4 ; U1.4 97.04,206.48 ; U1.4 97.98,205.54 ; U1.4 97.04,204.6 ; D102.A8 325.12,77.01 ; D102.A8 325.12,75.39 ; D102.A8 325.93,76.2 ; D102.A8 324.31,76.2 ; D306.A12 408.94,66.75 ; D306.A12 408.94,65.33 ; D306.A12 408.23,66.04 ; D306.A12 409.65,66.04 ; 166.93,91.44 D317.B4 ; D317.B4 168.35,91.44 ; D317.B4 167.64,90.73 ; D317.B4 167.64,92.15 ; 197.41,66.04 D318.A16 ; D318.A16 198.12,66.75 ; D318.A16 198.83,66.04 ; D318.A16 198.12,65.33 ; 44.91,96.52 D125.A14 ; D125.A14 45.72,97.33 ; D125.A14 45.72,95.71 ; D125.A14 46.53,96.52 ; 237.95,33.02 D124.A3 ; D124.A3 239.57,33.02 ; D124.A3 238.76,32.21 ; D124.A3 238.76,33.83 ; 306.63,83.82 D301.A1 ; D301.A1 308.05,83.82 ; D301.A1 307.34,83.11 ; D301.A1 307.34,84.53 ; D321.B14 266.7,92.15 ; D321.B14 267.41,91.44 ; D321.B14 266.7,90.73 ; D321.B14 265.99,91.44 ; D131.B7 101.6,59.23 ; D131.B7 100.79,58.42 ; D131.B7 102.41,58.42 ; D131.B7 101.6,57.61 ; D120.A8 177.8,36.37 ; D120.A8 177.8,34.75 ; D120.A8 178.61,35.56 ; D120.A8 176.99,35.56 ; 321.77,335.28 D113.A11 ; D113.A11 322.58,334.47 ; D113.A11 322.58,336.09 ; D113.A11 323.39,335.28 ; 415.85,63.5 D306.A15 ; D306.A15 417.27,63.5 ; D306.A15 416.56,62.79 ; D306.A15 416.56,64.21 ; D231.B6 188.77,368.3 ; D231.B6 187.96,369.11 ; D231.B6 187.96,367.49 ; D231.B6 187.15,368.3 ; 387.91,71.12 D306.B4 ; D306.B4 389.33,71.12 ; D306.B4 388.62,70.41 ; D306.B4 388.62,71.83 ; 322.58,409.4 DPS2.C11 ; DPS2.C11 323.39,410.21 ; DPS2.C11 322.58,411.02 ; DPS2.C11 321.77,410.21 ; D127.A6 25.4,56.69 ; D127.A6 25.4,55.07 ; D127.A6 24.59,55.88 ; D127.A6 26.21,55.88 ; 121.11,93.98 D129.A15 ; D129.A15 121.92,94.79 ; D129.A15 122.73,93.98 ; D129.A15 121.92,93.17 ; 391.16,52.53 D107.A5 ; D107.A5 391.97,53.34 ; D107.A5 391.16,54.15 ; D107.A5 390.35,53.34 ; 268.53,63.5 D322.A15 ; D322.A15 269.95,63.5 ; D322.A15 269.24,64.21 ; D322.A15 269.24,62.79 ; 164.29,53.34 D119.A3 ; D119.A3 165.91,53.34 ; D119.A3 165.1,52.53 ; D119.A3 165.1,54.15 ; D128.A7 28.75,33.02 ; D128.A7 27.94,32.21 ; D128.A7 27.13,33.02 ; D128.A7 27.94,33.83 ; D109.A4 414.83,332.74 ; D109.A4 413.21,332.74 ; D109.A4 414.02,333.55 ; D109.A4 414.02,331.93 ; 187.15,378.46 D431.B6 ; D431.B6 188.77,378.46 ; D431.B6 187.96,377.65 ; D431.B6 187.96,379.27 ; 249.85,181.33 SITE3.G3 ; SITE3.G3 250.33,181.81 ; SITE3.G3 250.33,180.85 ; SITE3.G3 250.81,181.33 ; 405.59,396.24 D112.A7 ; D112.A7 406.4,397.05 ; D112.A7 407.21,396.24 ; D112.A7 406.4,395.43 ; D107.B16 419.91,60.96 ; D107.B16 419.1,60.15 ; D107.B16 418.29,60.96 ; D107.B16 419.1,61.77 ; SITE1.G18 250.23,246.91 ; SITE1.G18 250.71,246.43 ; SITE1.G18 250.23,245.95 ; SITE1.G18 249.75,246.43 ; 174.45,53.34 D119.A7 ; D119.A7 175.26,54.15 ; D119.A7 175.26,52.53 ; D119.A7 176.07,53.34 ; 401.32,395.43 D112.A9 ; D112.A9 400.51,396.24 ; D112.A9 402.13,396.24 ; D112.A9 401.32,397.05 ; 118.57,81.28 D130.B14 ; D130.B14 120.19,81.28 ; D130.B14 119.38,80.47 ; D130.B14 119.38,82.09 ; 37.29,99.06 D125.B11 ; D125.B11 38.1,99.87 ; D125.B11 38.91,99.06 ; D125.B11 38.1,98.25 ; 403.05,35.56 D108.A10 ; D108.A10 403.86,34.75 ; D108.A10 404.67,35.56 ; D108.A10 403.86,36.37 ; 170.18,37.29 D120.B5 ; D120.B5 170.18,38.91 ; D120.B5 169.37,38.1 ; D120.B5 170.99,38.1 ; 395.43,78.74 D106.B7 ; D106.B7 396.24,79.55 ; D106.B7 397.05,78.74 ; D106.B7 396.24,77.93 ; D130.A11 112.57,73.66 ; D130.A11 110.95,73.66 ; D130.A11 111.76,72.85 ; D130.A11 111.76,74.47 ; 184.61,375.92 D231.A7 ; D231.A7 185.42,376.73 ; D231.A7 186.23,375.92 ; D231.A7 185.42,375.11 ; 27.94,37.29 D128.B7 ; D128.B7 27.94,38.91 ; D128.B7 28.75,38.1 ; D128.B7 27.13,38.1 ; 172.01,71.12 D318.B6 ; D318.B6 172.72,71.83 ; D318.B6 172.72,70.41 ; D318.B6 173.43,71.12 ; D119.A15 196.39,53.34 ; D119.A15 194.77,53.34 ; D119.A15 195.58,52.53 ; D119.A15 195.58,54.15 ; D116.A10 325.12,394.51 ; D116.A10 325.12,392.89 ; D116.A10 324.31,393.7 ; D116.A10 325.93,393.7 ; 401.32,349.71 D110.B9 ; D110.B9 401.32,351.33 ; D110.B9 400.51,350.52 ; D110.B9 402.13,350.52 ; SITE4.G10 331.81,187.93 ; SITE4.G10 331.33,187.45 ; SITE4.G10 330.85,187.93 ; SITE4.G10 331.33,188.41 ; D302.B8 325.83,71.12 ; D302.B8 325.12,71.83 ; D302.B8 325.12,70.41 ; D302.B8 324.41,71.12 ; D132.B9 107.49,38.1 ; D132.B9 106.68,37.29 ; D132.B9 105.87,38.1 ; D132.B9 106.68,38.91 ; CSDPS225.C11 249.73,330.2 ; CSDPS225.C11 248.92,329.39 ; CSDPS225.C11 248.92,331.01 ; CSDPS225.C11 248.11,330.2 ; D103.B7 323.39,58.42 ; D103.B7 321.77,58.42 ; D103.B7 322.58,57.61 ; D103.B7 322.58,59.23 ; D321.A7 249.63,83.82 ; D321.A7 248.92,84.53 ; D321.A7 248.92,83.11 ; D321.A7 248.21,83.82 ; 332.03,88.9 D301.B11 ; D301.B11 332.74,89.61 ; D301.B11 332.74,88.19 ; D301.B11 333.45,88.9 ; 184.61,381 D431.B7 ; D431.B7 185.42,381.81 ; D431.B7 185.42,380.19 ; D431.B7 186.23,381 ; 408.94,392.89 D112.A6 ; D112.A6 408.94,394.51 ; D112.A6 408.13,393.7 ; D112.A6 409.75,393.7 ; 182.07,368.3 D231.B8 ; D231.B8 182.88,369.11 ; D231.B8 183.69,368.3 ; D231.B8 182.88,367.49 ; 177.8,377.65 D431.B10 ; D431.B10 177.8,379.27 ; D431.B10 178.61,378.46 ; D431.B10 176.99,378.46 ; 255.83,71.12 D322.B10 ; D322.B10 256.54,70.41 ; D322.B10 257.25,71.12 ; D322.B10 256.54,71.83 ; D322.B11 259.08,69.29 ; D322.B11 258.37,68.58 ; D322.B11 259.08,67.87 ; D322.B11 259.79,68.58 ; D127.A1 12.7,54.15 ; D127.A1 13.51,53.34 ; D127.A1 12.7,52.53 ; D127.A1 11.89,53.34 ; D302.A16 346.15,66.04 ; D302.A16 345.44,65.33 ; D302.A16 344.73,66.04 ; D302.A16 345.44,66.75 ; D104.A2 310.69,35.56 ; D104.A2 309.88,34.75 ; D104.A2 309.88,36.37 ; D104.A2 309.07,35.56 ; D126.A10 35.56,77.01 ; D126.A10 36.37,76.2 ; D126.A10 35.56,75.39 ; D126.A10 34.75,76.2 ; D128.A11 38.91,33.02 ; D128.A11 37.29,33.02 ; D128.A11 38.1,32.21 ; D128.A11 38.1,33.83 ; D123.B10 257.35,60.96 ; D123.B10 256.54,60.15 ; D123.B10 255.73,60.96 ; D123.B10 256.54,61.77 ; D104.B7 322.58,38.91 ; D104.B7 321.77,38.1 ; D104.B7 322.58,37.29 ; D104.B7 323.39,38.1 ; CSDPS229.B14 167.64,333.55 ; CSDPS229.B14 167.64,331.93 ; CSDPS229.B14 168.45,332.74 ; CSDPS229.B14 166.83,332.74 ; 332.15,182.83 SITE4.G16 ; SITE4.G16 332.63,183.31 ; SITE4.G16 332.63,182.35 ; SITE4.G16 333.11,182.83 ; 266.7,331.93 CSDPS225.B4 ; CSDPS225.B4 265.89,332.74 ; CSDPS225.B4 266.7,333.55 ; CSDPS225.B4 267.51,332.74 ; D111.A7 406.4,376.73 ; D111.A7 405.59,375.92 ; D111.A7 406.4,375.11 ; D111.A7 407.21,375.92 ; 311.61,78.74 D102.B3 ; D102.B3 313.23,78.74 ; D102.B3 312.42,79.55 ; D102.B3 312.42,77.93 ; D106.B8 398.78,82.09 ; D106.B8 399.59,81.28 ; D106.B8 398.78,80.47 ; D106.B8 397.97,81.28 ; 333.33,187.45 SITE4.G12 ; SITE4.G12 333.81,187.93 ; SITE4.G12 333.33,188.41 ; SITE4.G12 332.85,187.93 ; D119.B5 170.18,59.23 ; D119.B5 169.37,58.42 ; D119.B5 170.99,58.42 ; D119.B5 170.18,57.61 ; 329.85,181.33 SITE4.G3 ; SITE4.G3 330.33,181.81 ; SITE4.G3 330.33,180.85 ; SITE4.G3 330.81,181.33 ; 170.18,385.27 D431.A13 ; D431.A13 170.18,386.89 ; D431.A13 170.99,386.08 ; D431.A13 169.37,386.08 ; 167.64,377.65 D431.B14 ; D431.B14 168.45,378.46 ; D431.B14 166.83,378.46 ; D431.B14 167.64,379.27 ; 45.72,100.79 D125.B14 ; D125.B14 44.91,101.6 ; D125.B14 45.72,102.41 ; D125.B14 46.53,101.6 ; 390.45,88.9 D305.B5 ; D305.B5 391.16,89.61 ; D305.B5 391.16,88.19 ; D305.B5 391.87,88.9 ; 325.12,387.81 D116.B10 ; D116.B10 325.93,388.62 ; D116.B10 325.12,389.43 ; D116.B10 324.31,388.62 ; D122.A13 264.16,74.47 ; D122.A13 264.16,72.85 ; D122.A13 263.35,73.66 ; D122.A13 264.97,73.66 ; 269.24,67.87 D322.B15 ; D322.B15 269.24,69.29 ; D322.B15 268.53,68.58 ; D322.B15 269.95,68.58 ; D321.A12 261.62,87.07 ; D321.A12 262.33,86.36 ; D321.A12 260.91,86.36 ; D321.A12 261.62,85.65 ; D111.B7 406.4,371.65 ; D111.B7 407.21,370.84 ; D111.B7 406.4,370.03 ; D111.B7 405.59,370.84 ; 309.88,367.49 D115.B16 ; D115.B16 310.69,368.3 ; D115.B16 309.07,368.3 ; D115.B16 309.88,369.11 ; 184.61,370.84 D231.B7 ; D231.B7 185.42,371.65 ; D231.B7 185.42,370.03 ; D231.B7 186.23,370.84 ; 388.62,392.89 D112.A14 ; D112.A14 389.43,393.7 ; D112.A14 388.62,394.51 ; D112.A14 387.81,393.7 ; 37.29,78.74 D126.B11 ; D126.B11 38.91,78.74 ; D126.B11 38.1,79.55 ; D126.B11 38.1,77.93 ; D112.A4 414.02,394.51 ; D112.A4 414.02,392.89 ; D112.A4 414.83,393.7 ; D112.A4 413.21,393.7 ; D104.B4 314.96,41.45 ; D104.B4 315.77,40.64 ; D104.B4 314.15,40.64 ; D104.B4 314.96,39.83 ; D110.A2 419.1,353.87 ; D110.A2 419.1,352.25 ; D110.A2 419.91,353.06 ; D110.A2 418.29,353.06 ; 192.23,368.3 D231.B4 ; D231.B4 193.85,368.3 ; D231.B4 193.04,367.49 ; D231.B4 193.04,369.11 ; 413.31,66.04 D306.A14 ; D306.A14 414.02,66.75 ; D306.A14 414.73,66.04 ; D306.A14 414.02,65.33 ; D120.A1 160.83,33.02 ; D120.A1 159.21,33.02 ; D120.A1 160.02,33.83 ; D120.A1 160.02,32.21 ; D116.A15 313.23,396.24 ; D116.A15 311.61,396.24 ; D116.A15 312.42,397.05 ; D116.A15 312.42,395.43 ; DPS1.C05 391.16,19.86 ; DPS1.C05 391.97,19.05 ; DPS1.C05 390.35,19.05 ; DPS1.C05 391.16,18.24 ; 85.55,93.98 D129.A1 ; D129.A1 86.36,93.17 ; D129.A1 87.17,93.98 ; D129.A1 86.36,94.79 ; 388.62,90.73 D305.B4 ; D305.B4 387.91,91.44 ; D305.B4 388.62,92.15 ; D305.B4 389.33,91.44 ; 406.4,72.85 D106.A11 ; D106.A11 407.21,73.66 ; D106.A11 405.59,73.66 ; D106.A11 406.4,74.47 ; D129.B16 125.27,101.6 ; D129.B16 124.46,102.41 ; D129.B16 123.65,101.6 ; D129.B16 124.46,100.79 ; D130.B10 109.22,82.09 ; D130.B10 110.03,81.28 ; D130.B10 108.41,81.28 ; D130.B10 109.22,80.47 ; D301.A5 318.21,83.82 ; D301.A5 317.5,84.53 ; D301.A5 317.5,83.11 ; D301.A5 316.79,83.82 ; 269.24,18.24 DPS3.C15 ; DPS3.C15 269.24,19.86 ; DPS3.C15 268.43,19.05 ; DPS3.C15 270.05,19.05 ; D115.B8 331.01,368.3 ; D115.B8 330.2,367.49 ; D115.B8 329.39,368.3 ; D115.B8 330.2,369.11 ; 273.51,340.36 CSDPS425.C1 ; CSDPS425.C1 275.13,340.36 ; CSDPS425.C1 274.32,339.55 ; CSDPS425.C1 274.32,341.17 ; 160.02,62.79 D318.A1 ; D318.A1 160.73,63.5 ; D318.A1 159.31,63.5 ; D318.A1 160.02,64.21 ; D129.A7 101.6,94.79 ; D129.A7 100.79,93.98 ; D129.A7 101.6,93.17 ; D129.A7 102.41,93.98 ; 160.02,385.27 D431.A17 ; D431.A17 160.83,386.08 ; D431.A17 160.02,386.89 ; D431.A17 159.21,386.08 ; D115.B7 332.74,371.65 ; D115.B7 332.74,370.03 ; D115.B7 331.93,370.84 ; D115.B7 333.55,370.84 ; D120.A14 193.85,35.56 ; D120.A14 193.04,34.75 ; D120.A14 192.23,35.56 ; D120.A14 193.04,36.37 ; D126.A4 20.32,77.01 ; D126.A4 19.51,76.2 ; D126.A4 20.32,75.39 ; D126.A4 21.13,76.2 ; 390.35,355.6 D110.A13 ; D110.A13 391.16,356.41 ; D110.A13 391.97,355.6 ; D110.A13 391.16,354.79 ; SITE4.G6 333.81,181.33 ; SITE4.G6 332.85,181.33 ; SITE4.G6 333.33,181.81 ; SITE4.G6 333.33,180.85 ; 246.38,75.39 D122.A6 ; D122.A6 246.38,77.01 ; D122.A6 245.57,76.2 ; D122.A6 247.19,76.2 ; 101.6,98.25 D129.B7 ; D129.B7 101.6,99.87 ; D129.B7 100.79,99.06 ; D129.B7 102.41,99.06 ; 414.02,326.85 D109.B4 ; D109.B4 414.02,328.47 ; D109.B4 414.83,327.66 ; D109.B4 413.21,327.66 ; 118.57,60.96 D131.B14 ; D131.B14 119.38,60.15 ; D131.B14 119.38,61.77 ; D131.B14 120.19,60.96 ; D318.B15 195.58,69.29 ; D318.B15 194.87,68.58 ; D318.B15 195.58,67.87 ; D318.B15 196.29,68.58 ; D109.B7 406.4,331.01 ; D109.B7 405.59,330.2 ; D109.B7 406.4,329.39 ; D109.B7 407.21,330.2 ; D110.B14 388.62,348.79 ; D110.B14 387.81,347.98 ; D110.B14 389.43,347.98 ; D110.B14 388.62,347.17 ; D125.B8 30.48,102.41 ; D125.B8 30.48,100.79 ; D125.B8 29.67,101.6 ; D125.B8 31.29,101.6 ; D127.B6 26.21,60.96 ; D127.B6 24.59,60.96 ; D127.B6 25.4,61.77 ; D127.B6 25.4,60.15 ; D322.A13 264.16,64.21 ; D322.A13 263.45,63.5 ; D322.A13 264.16,62.79 ; D322.A13 264.87,63.5 ; 27.13,99.06 D125.B7 ; D125.B7 27.94,98.25 ; D125.B7 27.94,99.87 ; D125.B7 28.75,99.06 ; D103.A14 340.36,56.69 ; D103.A14 340.36,55.07 ; D103.A14 339.55,55.88 ; D103.A14 341.17,55.88 ; D108.A3 386.89,33.02 ; D108.A3 386.08,32.21 ; D108.A3 385.27,33.02 ; D108.A3 386.08,33.83 ; D107.A14 414.83,55.88 ; D107.A14 414.02,55.07 ; D107.A14 413.21,55.88 ; D107.A14 414.02,56.69 ; D116.A11 322.58,397.05 ; D116.A11 321.77,396.24 ; D116.A11 322.58,395.43 ; D116.A11 323.39,396.24 ; 167.64,34.75 D120.A4 ; D120.A4 167.64,36.37 ; D120.A4 166.83,35.56 ; D120.A4 168.45,35.56 ; 329.39,347.98 D114.B8 ; D114.B8 330.2,348.79 ; D114.B8 330.2,347.17 ; D114.B8 331.01,347.98 ; 195.58,370.03 D231.B3 ; D231.B3 196.39,370.84 ; D231.B3 195.58,371.65 ; D231.B3 194.77,370.84 ; D118.B3 165.91,78.74 ; D118.B3 165.1,77.93 ; D118.B3 165.1,79.55 ; D118.B3 164.29,78.74 ; 39.83,35.56 D128.A12 ; D128.A12 40.64,34.75 ; D128.A12 41.45,35.56 ; D128.A12 40.64,36.37 ; 182.88,39.83 D120.B10 ; D120.B10 183.69,40.64 ; D120.B10 182.88,41.45 ; D120.B10 182.07,40.64 ; 330.2,34.75 D104.A10 ; D104.A10 329.39,35.56 ; D104.A10 330.2,36.37 ; D104.A10 331.01,35.56 ; D110.B3 416.56,351.33 ; D110.B3 416.56,349.71 ; D110.B3 417.37,350.52 ; D110.B3 415.75,350.52 ; 386.08,77.93 D106.B3 ; D106.B3 386.89,78.74 ; D106.B3 386.08,79.55 ; D106.B3 385.27,78.74 ; 403.05,393.7 D112.A8 ; D112.A8 403.86,394.51 ; D112.A8 403.86,392.89 ; D112.A8 404.67,393.7 ; 264.16,37.29 D124.B13 ; D124.B13 263.35,38.1 ; D124.B13 264.16,38.91 ; D124.B13 264.97,38.1 ; D118.B15 196.39,78.74 ; D118.B15 195.58,79.55 ; D118.B15 195.58,77.93 ; D118.B15 194.77,78.74 ; 116.03,38.1 D132.B13 ; D132.B13 116.84,38.91 ; D132.B13 116.84,37.29 ; D132.B13 117.65,38.1 ; 406.4,334.47 D109.A7 ; D109.A7 405.59,335.28 ; D109.A7 407.21,335.28 ; D109.A7 406.4,336.09 ; D301.B15 342.9,89.61 ; D301.B15 343.61,88.9 ; D301.B15 342.19,88.9 ; D301.B15 342.9,88.19 ; D112.B11 396.24,391.97 ; D112.B11 397.05,391.16 ; D112.B11 396.24,390.35 ; D112.B11 395.43,391.16 ; D231.B13 170.18,371.65 ; D231.B13 170.18,370.03 ; D231.B13 169.37,370.84 ; D231.B13 170.99,370.84 ; D104.B8 325.93,40.64 ; D104.B8 325.12,39.83 ; D104.B8 324.31,40.64 ; D104.B8 325.12,41.45 ; D109.A16 384.35,332.74 ; D109.A16 383.54,331.93 ; D109.A16 383.54,333.55 ; D109.A16 382.73,332.74 ; D119.A6 172.72,56.69 ; D119.A6 173.53,55.88 ; D119.A6 171.91,55.88 ; D119.A6 172.72,55.07 ; 175.26,37.29 D120.B7 ; D120.B7 176.07,38.1 ; D120.B7 174.45,38.1 ; D120.B7 175.26,38.91 ; D110.A9 401.32,356.41 ; D110.A9 400.51,355.6 ; D110.A9 402.13,355.6 ; D110.A9 401.32,354.79 ; D108.A13 411.48,33.83 ; D108.A13 410.67,33.02 ; D108.A13 412.29,33.02 ; D108.A13 411.48,32.21 ; 306.63,88.9 D301.B1 ; D301.B1 308.05,88.9 ; D301.B1 307.34,88.19 ; D301.B1 307.34,89.61 ; 385.37,88.9 D305.B3 ; D305.B3 386.79,88.9 ; D305.B3 386.08,88.19 ; D305.B3 386.08,89.61 ; D126.B5 23.67,78.74 ; D126.B5 22.86,77.93 ; D126.B5 22.86,79.55 ; D126.B5 22.05,78.74 ; 403.86,331.93 D109.A8 ; D109.A8 403.05,332.74 ; D109.A8 403.86,333.55 ; D109.A8 404.67,332.74 ; 103.33,55.88 D131.A8 ; D131.A8 104.14,56.69 ; D131.A8 104.14,55.07 ; D131.A8 104.95,55.88 ; D114.A2 346.25,353.06 ; D114.A2 345.44,352.25 ; D114.A2 344.63,353.06 ; D114.A2 345.44,353.87 ; 49.99,76.2 D126.A16 ; D126.A16 50.8,75.39 ; D126.A16 51.61,76.2 ; D126.A16 50.8,77.01 ; 414.02,372.57 D111.A4 ; D111.A4 413.21,373.38 ; D111.A4 414.02,374.19 ; D111.A4 414.83,373.38 ; 345.44,347.17 D114.B2 ; D114.B2 346.25,347.98 ; D114.B2 345.44,348.79 ; D114.B2 344.63,347.98 ; 99.06,100.79 D129.B6 ; D129.B6 98.25,101.6 ; D129.B6 99.06,102.41 ; D129.B6 99.87,101.6 ; D104.B13 338.63,38.1 ; D104.B13 337.01,38.1 ; D104.B13 337.82,37.29 ; D104.B13 337.82,38.91 ; 187.96,331.93 CSDPS229.B6 ; CSDPS229.B6 187.96,333.55 ; CSDPS229.B6 187.15,332.74 ; CSDPS229.B6 188.77,332.74 ; 39.83,96.52 D125.A12 ; D125.A12 41.45,96.52 ; D125.A12 40.64,97.33 ; D125.A12 40.64,95.71 ; 420.83,330.2 D109.B1 ; D109.B1 421.64,331.01 ; D109.B1 421.64,329.39 ; D109.B1 422.45,330.2 ; 238.76,62.79 D322.A3 ; D322.A3 238.76,64.21 ; D322.A3 239.47,63.5 ; D322.A3 238.05,63.5 ; 165.1,375.11 D231.A15 ; D231.A15 165.1,376.73 ; D231.A15 165.91,375.92 ; D231.A15 164.29,375.92 ; D127.A11 38.91,53.34 ; D127.A11 38.1,52.53 ; D127.A11 38.1,54.15 ; D127.A11 37.29,53.34 ; D129.B2 88.9,102.41 ; D129.B2 88.9,100.79 ; D129.B2 89.71,101.6 ; D129.B2 88.09,101.6 ; 334.47,373.38 D115.A6 ; D115.A6 336.09,373.38 ; D115.A6 335.28,372.57 ; D115.A6 335.28,374.19 ; 252.15,186.43 SITE3.G20 ; SITE3.G20 253.11,186.43 ; SITE3.G20 252.63,186.91 ; SITE3.G20 252.63,185.95 ; DPS3.C05 244.65,19.05 ; DPS3.C05 243.84,19.86 ; DPS3.C05 243.03,19.05 ; DPS3.C05 243.84,18.24 ; D317.B12 188.67,91.44 ; D317.B12 187.96,92.15 ; D317.B12 187.25,91.44 ; D317.B12 187.96,90.73 ; 197.31,60.96 D119.B16 ; D119.B16 198.12,61.77 ; D119.B16 198.93,60.96 ; D119.B16 198.12,60.15 ; 114.3,39.83 D132.B12 ; D132.B12 115.11,40.64 ; D132.B12 113.49,40.64 ; D132.B12 114.3,41.45 ; 29.67,40.64 D128.B8 ; D128.B8 31.29,40.64 ; D128.B8 30.48,39.83 ; D128.B8 30.48,41.45 ; 347.17,355.6 D114.A1 ; D114.A1 347.98,354.79 ; D114.A1 348.79,355.6 ; D114.A1 347.98,356.41 ; D131.B15 122.73,58.42 ; D131.B15 121.11,58.42 ; D131.B15 121.92,57.61 ; D131.B15 121.92,59.23 ; D131.A13 117.65,53.34 ; D131.A13 116.84,52.53 ; D131.A13 116.03,53.34 ; D131.A13 116.84,54.15 ; D321.B16 271.78,92.15 ; D321.B16 272.49,91.44 ; D321.B16 271.07,91.44 ; D321.B16 271.78,90.73 ; 179.53,370.84 D231.B9 ; D231.B9 180.34,371.65 ; D231.B9 181.15,370.84 ; D231.B9 180.34,370.03 ; D104.B3 312.42,38.91 ; D104.B3 311.61,38.1 ; D104.B3 312.42,37.29 ; D104.B3 313.23,38.1 ; D231.A5 191.31,375.92 ; D231.A5 189.69,375.92 ; D231.A5 190.5,375.11 ; D231.A5 190.5,376.73 ; 326.85,355.6 D114.A9 ; D114.A9 327.66,356.41 ; D114.A9 328.47,355.6 ; D114.A9 327.66,354.79 ; D104.B12 336.09,40.64 ; D104.B12 335.28,41.45 ; D104.B12 334.47,40.64 ; D104.B12 335.28,39.83 ; 182.07,35.56 D120.A10 ; D120.A10 183.69,35.56 ; D120.A10 182.88,36.37 ; D120.A10 182.88,34.75 ; 93.98,75.39 D130.A4 ; D130.A4 93.98,77.01 ; D130.A4 93.17,76.2 ; D130.A4 94.79,76.2 ; 85.55,99.06 D129.B1 ; D129.B1 86.36,99.87 ; D129.B1 86.36,98.25 ; D129.B1 87.17,99.06 ; D120.B14 193.04,41.45 ; D120.B14 192.23,40.64 ; D120.B14 193.04,39.83 ; D120.B14 193.85,40.64 ; CSDPS425.B6 262.43,342.9 ; CSDPS425.B6 261.62,342.09 ; CSDPS425.B6 260.81,342.9 ; CSDPS425.B6 261.62,343.71 ; 311.61,355.6 D114.A15 ; D114.A15 313.23,355.6 ; D114.A15 312.42,354.79 ; D114.A15 312.42,356.41 ; 311.61,415.29 DPS2.A15 ; DPS2.A15 312.42,416.1 ; DPS2.A15 313.23,415.29 ; DPS2.A15 312.42,414.48 ; 411.48,52.53 D107.A13 ; D107.A13 411.48,54.15 ; D107.A13 412.29,53.34 ; D107.A13 410.67,53.34 ; 344.63,332.74 D113.A2 ; D113.A2 345.44,331.93 ; D113.A2 346.25,332.74 ; D113.A2 345.44,333.55 ; D306.A3 386.08,64.21 ; D306.A3 386.08,62.79 ; D306.A3 386.79,63.5 ; D306.A3 385.37,63.5 ; 392.89,76.2 D106.A6 ; D106.A6 394.51,76.2 ; D106.A6 393.7,75.39 ; D106.A6 393.7,77.01 ; D321.B15 269.24,89.61 ; D321.B15 269.95,88.9 ; D321.B15 268.53,88.9 ; D321.B15 269.24,88.19 ; D111.B2 419.91,368.3 ; D111.B2 418.29,368.3 ; D111.B2 419.1,367.49 ; D111.B2 419.1,369.11 ; SITE1.G2 249.33,241.81 ; SITE1.G2 249.33,240.85 ; SITE1.G2 248.85,241.33 ; SITE1.G2 249.81,241.33 ; 249.85,187.93 SITE3.G9 ; SITE3.G9 250.33,187.45 ; SITE3.G9 250.81,187.93 ; SITE3.G9 250.33,188.41 ; D102.B16 345.44,82.09 ; D102.B16 345.44,80.47 ; D102.B16 344.63,81.28 ; D102.B16 346.25,81.28 ; D125.A16 51.61,96.52 ; D125.A16 50.8,95.71 ; D125.A16 50.8,97.33 ; D125.A16 49.99,96.52 ; D231.B5 190.5,371.65 ; D231.B5 190.5,370.03 ; D231.B5 189.69,370.84 ; D231.B5 191.31,370.84 ; 50.8,34.75 D128.A16 ; D128.A16 49.99,35.56 ; D128.A16 51.61,35.56 ; D128.A16 50.8,36.37 ; 419.1,65.33 D306.A16 ; D306.A16 419.81,66.04 ; D306.A16 418.39,66.04 ; D306.A16 419.1,66.75 ; D301.A6 320.75,86.36 ; D301.A6 320.04,87.07 ; D301.A6 320.04,85.65 ; D301.A6 319.33,86.36 ; 314.96,34.75 D104.A4 ; D104.A4 315.77,35.56 ; D104.A4 314.15,35.56 ; D104.A4 314.96,36.37 ; D124.B7 249.73,38.1 ; D124.B7 248.92,37.29 ; D124.B7 248.11,38.1 ; D124.B7 248.92,38.91 ; D120.A2 163.37,35.56 ; D120.A2 161.75,35.56 ; D120.A2 162.56,36.37 ; D120.A2 162.56,34.75 ; D125.A2 16.05,96.52 ; D125.A2 15.24,95.71 ; D125.A2 15.24,97.33 ; D125.A2 14.43,96.52 ; D305.B16 419.81,91.44 ; D305.B16 419.1,90.73 ; D305.B16 418.39,91.44 ; D305.B16 419.1,92.15 ; D122.B1 233.68,79.55 ; D122.B1 232.87,78.74 ; D122.B1 234.49,78.74 ; D122.B1 233.68,77.93 ; 48.26,52.53 D127.A15 ; D127.A15 47.45,53.34 ; D127.A15 48.26,54.15 ; D127.A15 49.07,53.34 ; 418.29,327.66 D109.B2 ; D109.B2 419.1,326.85 ; D109.B2 419.1,328.47 ; D109.B2 419.91,327.66 ; 342.09,350.52 D114.B3 ; D114.B3 343.71,350.52 ; D114.B3 342.9,349.71 ; D114.B3 342.9,351.33 ; 332.74,375.11 D115.A7 ; D115.A7 331.93,375.92 ; D115.A7 332.74,376.73 ; D115.A7 333.55,375.92 ; D115.B3 343.71,370.84 ; D115.B3 342.09,370.84 ; D115.B3 342.9,371.65 ; D115.B3 342.9,370.03 ; 309.07,353.06 D114.A16 ; D114.A16 310.69,353.06 ; D114.A16 309.88,352.25 ; D114.A16 309.88,353.87 ; 161.75,60.96 D119.B2 ; D119.B2 162.56,61.77 ; D119.B2 163.37,60.96 ; D119.B2 162.56,60.15 ; D318.B1 160.02,69.29 ; D318.B1 159.31,68.58 ; D318.B1 160.73,68.58 ; D318.B1 160.02,67.87 ; DPS3.A11 259.08,14.78 ; DPS3.A11 258.27,13.97 ; DPS3.A11 259.89,13.97 ; DPS3.A11 259.08,13.16 ; 176.99,342.9 CSDPS429.B10 ; CSDPS429.B10 178.61,342.9 ; CSDPS429.B10 177.8,343.71 ; CSDPS429.B10 177.8,342.09 ; 332.03,63.5 D302.A11 ; D302.A11 333.45,63.5 ; D302.A11 332.74,62.79 ; D302.A11 332.74,64.21 ; 253.19,73.66 D122.A9 ; D122.A9 254.81,73.66 ; D122.A9 254,72.85 ; D122.A9 254,74.47 ; D301.B10 330.2,92.15 ; D301.B10 330.91,91.44 ; D301.B10 330.2,90.73 ; D301.B10 329.49,91.44 ; D106.A3 386.08,74.47 ; D106.A3 386.08,72.85 ; D106.A3 385.27,73.66 ; D106.A3 386.89,73.66 ; 311.61,370.84 D115.B15 ; D115.B15 312.42,371.65 ; D115.B15 312.42,370.03 ; D115.B15 313.23,370.84 ; D126.A14 46.53,76.2 ; D126.A14 44.91,76.2 ; D126.A14 45.72,77.01 ; D126.A14 45.72,75.39 ; D114.A5 338.63,355.6 ; D114.A5 337.01,355.6 ; D114.A5 337.82,356.41 ; D114.A5 337.82,354.79 ; D109.A6 408.94,333.55 ; D109.A6 408.13,332.74 ; D109.A6 408.94,331.93 ; D109.A6 409.75,332.74 ; D120.A13 190.5,33.83 ; D120.A13 191.31,33.02 ; D120.A13 189.69,33.02 ; D120.A13 190.5,32.21 ; D111.A1 421.64,376.73 ; D111.A1 420.83,375.92 ; D111.A1 422.45,375.92 ; D111.A1 421.64,375.11 ; D302.B11 333.45,68.58 ; D302.B11 332.03,68.58 ; D302.B11 332.74,69.29 ; D302.B11 332.74,67.87 ; D115.A3 343.71,375.92 ; D115.A3 342.09,375.92 ; D115.A3 342.9,375.11 ; D115.A3 342.9,376.73 ; 334.57,86.36 D301.A12 ; D301.A12 335.28,85.65 ; D301.A12 335.28,87.07 ; D301.A12 335.99,86.36 ; D128.A14 46.53,35.56 ; D128.A14 44.91,35.56 ; D128.A14 45.72,34.75 ; D128.A14 45.72,36.37 ; D317.A15 196.29,83.82 ; D317.A15 194.87,83.82 ; D317.A15 195.58,84.53 ; D317.A15 195.58,83.11 ; D103.B11 333.55,58.42 ; D103.B11 332.74,57.61 ; D103.B11 332.74,59.23 ; D103.B11 331.93,58.42 ; D112.B2 419.1,389.43 ; D112.B2 419.1,387.81 ; D112.B2 418.29,388.62 ; D112.B2 419.91,388.62 ; 383.54,65.33 D306.A2 ; D306.A2 383.54,66.75 ; D306.A2 384.25,66.04 ; D306.A2 382.83,66.04 ; 265.89,35.56 D124.A14 ; D124.A14 267.51,35.56 ; D124.A14 266.7,34.75 ; D124.A14 266.7,36.37 ; D106.B1 381.81,78.74 ; D106.B1 380.19,78.74 ; D106.B1 381,79.55 ; D106.B1 381,77.93 ; 408.13,368.3 D111.B6 ; D111.B6 408.94,369.11 ; D111.B6 409.75,368.3 ; D111.B6 408.94,367.49 ; 398.78,34.75 D108.A8 ; D108.A8 398.78,36.37 ; D108.A8 399.59,35.56 ; D108.A8 397.97,35.56 ; 332.85,247.93 SITE2.G12 ; SITE2.G12 333.81,247.93 ; SITE2.G12 333.33,247.45 ; SITE2.G12 333.33,248.41 ; D107.A9 402.13,53.34 ; D107.A9 401.32,54.15 ; D107.A9 400.51,53.34 ; D107.A9 401.32,52.53 ; 110.95,38.1 D132.B11 ; D132.B11 111.76,38.91 ; D132.B11 111.76,37.29 ; D132.B11 112.57,38.1 ; 261.62,65.33 D322.A12 ; D322.A12 262.33,66.04 ; D322.A12 261.62,66.75 ; D322.A12 260.91,66.04 ; 269.24,329.39 CSDPS225.C3 ; CSDPS225.C3 269.24,331.01 ; CSDPS225.C3 270.05,330.2 ; CSDPS225.C3 268.43,330.2 ; D120.A11 185.42,33.83 ; D120.A11 186.23,33.02 ; D120.A11 185.42,32.21 ; D120.A11 184.61,33.02 ; 337.82,32.21 D104.A13 ; D104.A13 337.82,33.83 ; D104.A13 338.63,33.02 ; D104.A13 337.01,33.02 ; D115.A15 312.42,376.73 ; D115.A15 311.61,375.92 ; D115.A15 312.42,375.11 ; D115.A15 313.23,375.92 ; SITE2.G15 331.43,243.31 ; SITE2.G15 330.95,242.83 ; SITE2.G15 331.91,242.83 ; SITE2.G15 331.43,242.35 ; D322.B6 246.38,71.83 ; D322.B6 247.09,71.12 ; D322.B6 245.67,71.12 ; D322.B6 246.38,70.41 ; 185.42,62.79 D318.A11 ; D318.A11 184.71,63.5 ; D318.A11 185.42,64.21 ; D318.A11 186.13,63.5 ; 403.05,373.38 D111.A8 ; D111.A8 404.67,373.38 ; D111.A8 403.86,372.57 ; D111.A8 403.86,374.19 ; 385.27,396.24 D112.A15 ; D112.A15 386.08,395.43 ; D112.A15 386.08,397.05 ; D112.A15 386.89,396.24 ; 332.74,349.71 D114.B7 ; D114.B7 331.93,350.52 ; D114.B7 333.55,350.52 ; D114.B7 332.74,351.33 ; D102.A10 330.2,77.01 ; D102.A10 331.01,76.2 ; D102.A10 330.2,75.39 ; D102.A10 329.39,76.2 ; 49.99,81.28 D126.B16 ; D126.B16 51.61,81.28 ; D126.B16 50.8,82.09 ; D126.B16 50.8,80.47 ; 306.53,53.34 D103.A1 ; D103.A1 307.34,54.15 ; D103.A1 308.15,53.34 ; D103.A1 307.34,52.53 ; 396.24,67.87 D306.B7 ; D306.B7 396.24,69.29 ; D306.B7 396.95,68.58 ; D306.B7 395.53,68.58 ; 380.29,88.9 D305.B1 ; D305.B1 381,89.61 ; D305.B1 381,88.19 ; D305.B1 381.71,88.9 ; D111.A2 419.1,374.19 ; D111.A2 418.29,373.38 ; D111.A2 419.91,373.38 ; D111.A2 419.1,372.57 ; 316.69,38.1 D104.B5 ; D104.B5 317.5,38.91 ; D104.B5 317.5,37.29 ; D104.B5 318.31,38.1 ; 327.85,187.93 SITE4.G7 ; SITE4.G7 328.33,187.45 ; SITE4.G7 328.81,187.93 ; SITE4.G7 328.33,188.41 ; 172.72,331.93 CSDPS229.B12 ; CSDPS229.B12 171.91,332.74 ; CSDPS229.B12 172.72,333.55 ; CSDPS229.B12 173.53,332.74 ; D130.A6 99.87,76.2 ; D130.A6 99.06,77.01 ; D130.A6 99.06,75.39 ; D130.A6 98.25,76.2 ; 96.52,57.61 D131.B5 ; D131.B5 96.52,59.23 ; D131.B5 97.33,58.42 ; D131.B5 95.71,58.42 ; 179.63,88.9 D317.B9 ; D317.B9 180.34,88.19 ; D317.B9 181.05,88.9 ; D317.B9 180.34,89.61 ; D120.A9 180.34,33.83 ; D120.A9 179.53,33.02 ; D120.A9 180.34,32.21 ; D120.A9 181.15,33.02 ; 387.81,81.28 D106.B4 ; D106.B4 389.43,81.28 ; D106.B4 388.62,80.47 ; D106.B4 388.62,82.09 ; 271.78,55.07 D123.A16 ; D123.A16 271.78,56.69 ; D123.A16 270.97,55.88 ; D123.A16 272.59,55.88 ; D306.A11 407.11,63.5 ; D306.A11 406.4,64.21 ; D306.A11 405.69,63.5 ; D306.A11 406.4,62.79 ; 270.97,76.2 D122.A16 ; D122.A16 271.78,77.01 ; D122.A16 272.59,76.2 ; D122.A16 271.78,75.39 ; 406.4,88.19 D305.B11 ; D305.B11 407.11,88.9 ; D305.B11 406.4,89.61 ; D305.B11 405.69,88.9 ; D108.A9 402.13,33.02 ; D108.A9 401.32,32.21 ; D108.A9 401.32,33.83 ; D108.A9 400.51,33.02 ; 405.59,13.97 DPS1.A11 ; DPS1.A11 406.4,14.78 ; DPS1.A11 406.4,13.16 ; DPS1.A11 407.21,13.97 ; 256.54,39.83 D124.B10 ; D124.B10 256.54,41.45 ; D124.B10 255.73,40.64 ; D124.B10 257.35,40.64 ; D127.A8 30.48,56.69 ; D127.A8 30.48,55.07 ; D127.A8 31.29,55.88 ; D127.A8 29.67,55.88 ; 342.9,77.93 D102.B15 ; D102.B15 342.9,79.55 ; D102.B15 343.71,78.74 ; D102.B15 342.09,78.74 ; 401.32,334.47 D109.A9 ; D109.A9 401.32,336.09 ; D109.A9 400.51,335.28 ; D109.A9 402.13,335.28 ; 193.04,331.93 CSDPS229.B4 ; CSDPS229.B4 193.85,332.74 ; CSDPS229.B4 192.23,332.74 ; CSDPS229.B4 193.04,333.55 ; 185.42,329.39 CSDPS229.C7 ; CSDPS229.C7 184.61,330.2 ; CSDPS229.C7 186.23,330.2 ; CSDPS229.C7 185.42,331.01 ; 184.61,58.42 D119.B11 ; D119.B11 185.42,59.23 ; D119.B11 186.23,58.42 ; D119.B11 185.42,57.61 ; D119.A16 198.12,56.69 ; D119.A16 197.31,55.88 ; D119.A16 198.93,55.88 ; D119.A16 198.12,55.07 ; 403.15,66.04 D306.A10 ; D306.A10 403.86,65.33 ; D306.A10 404.57,66.04 ; D306.A10 403.86,66.75 ; D103.B9 328.47,58.42 ; D103.B9 327.66,57.61 ; D103.B9 326.85,58.42 ; D103.B9 327.66,59.23 ; D124.A8 252.27,35.56 ; D124.A8 251.46,34.75 ; D124.A8 250.65,35.56 ; D124.A8 251.46,36.37 ; DPS2.C05 337.82,411.02 ; DPS2.C05 338.63,410.21 ; DPS2.C05 337.82,409.4 ; DPS2.C05 337.01,410.21 ; 176.99,81.28 D118.B8 ; D118.B8 177.8,82.09 ; D118.B8 177.8,80.47 ; D118.B8 178.61,81.28 ; 385.27,53.34 D107.A3 ; D107.A3 386.08,52.53 ; D107.A3 386.89,53.34 ; D107.A3 386.08,54.15 ; 22.86,72.85 D126.A5 ; D126.A5 22.86,74.47 ; D126.A5 23.67,73.66 ; D126.A5 22.05,73.66 ; D119.B7 176.07,58.42 ; D119.B7 175.26,59.23 ; D119.B7 174.45,58.42 ; D119.B7 175.26,57.61 ; D103.B6 320.04,61.77 ; D103.B6 319.23,60.96 ; D103.B6 320.04,60.15 ; D103.B6 320.85,60.96 ; D120.B1 160.02,38.91 ; D120.B1 160.02,37.29 ; D120.B1 159.21,38.1 ; D120.B1 160.83,38.1 ; D102.B10 330.2,82.09 ; D102.B10 331.01,81.28 ; D102.B10 329.39,81.28 ; D102.B10 330.2,80.47 ; 248.92,339.55 CSDPS425.C11 ; CSDPS425.C11 249.73,340.36 ; CSDPS425.C11 248.92,341.17 ; CSDPS425.C11 248.11,340.36 ; 332.74,77.93 D102.B11 ; D102.B11 333.55,78.74 ; D102.B11 332.74,79.55 ; D102.B11 331.93,78.74 ; 337.01,415.29 DPS2.A05 ; DPS2.A05 337.82,416.1 ; DPS2.A05 337.82,414.48 ; DPS2.A05 338.63,415.29 ; CSDPS229.C15 165.91,330.2 ; CSDPS229.C15 164.29,330.2 ; CSDPS229.C15 165.1,331.01 ; CSDPS229.C15 165.1,329.39 ; D111.B16 384.35,368.3 ; D111.B16 383.54,367.49 ; D111.B16 383.54,369.11 ; D111.B16 382.73,368.3 ; 332.74,354.79 D114.A7 ; D114.A7 333.55,355.6 ; D114.A7 331.93,355.6 ; D114.A7 332.74,356.41 ; D306.A9 402.03,63.5 ; D306.A9 401.32,62.79 ; D306.A9 400.61,63.5 ; D306.A9 401.32,64.21 ; D127.A7 28.75,53.34 ; D127.A7 27.13,53.34 ; D127.A7 27.94,54.15 ; D127.A7 27.94,52.53 ; SITE2.G3 330.33,241.81 ; SITE2.G3 330.81,241.33 ; SITE2.G3 330.33,240.85 ; SITE2.G3 329.85,241.33 ; D125.A10 36.37,96.52 ; D125.A10 35.56,97.33 ; D125.A10 34.75,96.52 ; D125.A10 35.56,95.71 ; D123.B11 259.89,58.42 ; D123.B11 258.27,58.42 ; D123.B11 259.08,59.23 ; D123.B11 259.08,57.61 ; D301.B9 327.66,89.61 ; D301.B9 328.37,88.9 ; D301.B9 327.66,88.19 ; D301.B9 326.95,88.9 ; 93.98,100.79 D129.B4 ; D129.B4 93.98,102.41 ; D129.B4 94.79,101.6 ; D129.B4 93.17,101.6 ; 398.78,326.85 D109.B10 ; D109.B10 398.78,328.47 ; D109.B10 397.97,327.66 ; D109.B10 399.59,327.66 ; D131.A1 86.36,54.15 ; D131.A1 87.17,53.34 ; D131.A1 86.36,52.53 ; D131.A1 85.55,53.34 ; D110.B15 386.08,351.33 ; D110.B15 386.08,349.71 ; D110.B15 386.89,350.52 ; D110.B15 385.27,350.52 ; CSDPS229.C1 200.66,331.01 ; CSDPS229.C1 199.85,330.2 ; CSDPS229.C1 200.66,329.39 ; CSDPS229.C1 201.47,330.2 ; D118.A1 160.02,74.47 ; D118.A1 160.02,72.85 ; D118.A1 160.83,73.66 ; D118.A1 159.21,73.66 ; SITE1.G8 249.33,248.41 ; SITE1.G8 249.33,247.45 ; SITE1.G8 249.81,247.93 ; SITE1.G8 248.85,247.93 ; D119.A14 193.04,56.69 ; D119.A14 192.23,55.88 ; D119.A14 193.04,55.07 ; D119.A14 193.85,55.88 ; D107.B8 398.78,61.77 ; D107.B8 397.97,60.96 ; D107.B8 398.78,60.15 ; D107.B8 399.59,60.96 ; D322.B4 241.3,71.83 ; D322.B4 240.59,71.12 ; D322.B4 242.01,71.12 ; D322.B4 241.3,70.41 ; 237.95,38.1 D124.B3 ; D124.B3 238.76,37.29 ; D124.B3 238.76,38.91 ; D124.B3 239.57,38.1 ; 123.65,96.52 D129.A16 ; D129.A16 125.27,96.52 ; D129.A16 124.46,95.71 ; D129.A16 124.46,97.33 ; 327.66,32.21 D104.A9 ; D104.A9 328.47,33.02 ; D104.A9 326.85,33.02 ; D104.A9 327.66,33.83 ; 408.13,55.88 D107.A12 ; D107.A12 408.94,56.69 ; D107.A12 409.75,55.88 ; D107.A12 408.94,55.07 ; D322.B16 272.49,71.12 ; D322.B16 271.78,71.83 ; D322.B16 271.78,70.41 ; D322.B16 271.07,71.12 ; 388.62,39.83 D108.B4 ; D108.B4 388.62,41.45 ; D108.B4 387.81,40.64 ; D108.B4 389.43,40.64 ; CSDPS225.C9 254,331.01 ; CSDPS225.C9 254,329.39 ; CSDPS225.C9 254.81,330.2 ; CSDPS225.C9 253.19,330.2 ; CSDPS425.B2 271.78,343.71 ; CSDPS425.B2 271.78,342.09 ; CSDPS425.B2 272.59,342.9 ; CSDPS425.B2 270.97,342.9 ; 12.7,57.61 D127.B1 ; D127.B1 11.89,58.42 ; D127.B1 12.7,59.23 ; D127.B1 13.51,58.42 ; D126.B2 16.05,81.28 ; D126.B2 15.24,80.47 ; D126.B2 14.43,81.28 ; D126.B2 15.24,82.09 ; D113.B1 348.79,330.2 ; D113.B1 347.98,329.39 ; D113.B1 347.17,330.2 ; D113.B1 347.98,331.01 ; D321.A14 266.7,87.07 ; D321.A14 266.7,85.65 ; D321.A14 265.99,86.36 ; D321.A14 267.41,86.36 ; 330.2,55.07 D103.A10 ; D103.A10 329.39,55.88 ; D103.A10 331.01,55.88 ; D103.A10 330.2,56.69 ; 268.43,33.02 D124.A15 ; D124.A15 269.24,33.83 ; D124.A15 270.05,33.02 ; D124.A15 269.24,32.21 ; 169.37,340.36 CSDPS429.C13 ; CSDPS429.C13 170.99,340.36 ; CSDPS429.C13 170.18,341.17 ; CSDPS429.C13 170.18,339.55 ; D131.B9 106.68,59.23 ; D131.B9 106.68,57.61 ; D131.B9 105.87,58.42 ; D131.B9 107.49,58.42 ; D231.A11 176.07,375.92 ; D231.A11 175.26,376.73 ; D231.A11 175.26,375.11 ; D231.A11 174.45,375.92 ; D107.B3 386.08,59.23 ; D107.B3 385.27,58.42 ; D107.B3 386.08,57.61 ; D107.B3 386.89,58.42 ; 104.14,75.39 D130.A8 ; D130.A8 104.14,77.01 ; D130.A8 104.95,76.2 ; D130.A8 103.33,76.2 ; D127.B15 48.26,59.23 ; D127.B15 47.45,58.42 ; D127.B15 49.07,58.42 ; D127.B15 48.26,57.61 ; D102.A1 307.34,74.47 ; D102.A1 306.53,73.66 ; D102.A1 308.15,73.66 ; D102.A1 307.34,72.85 ; 248.11,53.34 D123.A7 ; D123.A7 248.92,52.53 ; D123.A7 248.92,54.15 ; D123.A7 249.73,53.34 ; 388.62,372.57 D111.A14 ; D111.A14 388.62,374.19 ; D111.A14 387.81,373.38 ; D111.A14 389.43,373.38 ; D317.A7 175.26,84.53 ; D317.A7 175.26,83.11 ; D317.A7 175.97,83.82 ; D317.A7 174.55,83.82 ; D126.B8 30.48,82.09 ; D126.B8 31.29,81.28 ; D126.B8 30.48,80.47 ; D126.B8 29.67,81.28 ; D231.A9 180.34,376.73 ; D231.A9 180.34,375.11 ; D231.A9 179.53,375.92 ; D231.A9 181.15,375.92 ; D305.A14 414.73,86.36 ; D305.A14 413.31,86.36 ; D305.A14 414.02,87.07 ; D305.A14 414.02,85.65 ; D114.A12 320.85,353.06 ; D114.A12 319.23,353.06 ; D114.A12 320.04,353.87 ; D114.A12 320.04,352.25 ; D124.B14 267.51,40.64 ; D124.B14 265.89,40.64 ; D124.B14 266.7,41.45 ; D124.B14 266.7,39.83 ; D109.B3 417.37,330.2 ; D109.B3 416.56,331.01 ; D109.B3 416.56,329.39 ; D109.B3 415.75,330.2 ; D113.A3 343.71,335.28 ; D113.A3 342.9,336.09 ; D113.A3 342.09,335.28 ; D113.A3 342.9,334.47 ; CSDPS229.C3 195.58,331.01 ; CSDPS229.C3 195.58,329.39 ; CSDPS229.C3 196.39,330.2 ; CSDPS229.C3 194.77,330.2 ; D125.A3 17.78,94.79 ; D125.A3 18.59,93.98 ; D125.A3 17.78,93.17 ; D125.A3 16.97,93.98 ; D114.A4 341.17,353.06 ; D114.A4 340.36,353.87 ; D114.A4 339.55,353.06 ; D114.A4 340.36,352.25 ; D302.B14 340.36,71.83 ; D302.B14 339.65,71.12 ; D302.B14 341.07,71.12 ; D302.B14 340.36,70.41 ; SITE3.G8 249.33,188.41 ; SITE3.G8 248.85,187.93 ; SITE3.G8 249.33,187.45 ; SITE3.G8 249.81,187.93 ; 347.17,350.52 D114.B1 ; D114.B1 347.98,349.71 ; D114.B1 347.98,351.33 ; D114.B1 348.79,350.52 ; D103.B13 338.63,58.42 ; D103.B13 337.82,57.61 ; D103.B13 337.82,59.23 ; D103.B13 337.01,58.42 ; 330.85,247.93 SITE2.G10 ; SITE2.G10 331.33,247.45 ; SITE2.G10 331.81,247.93 ; SITE2.G10 331.33,248.41 ; D305.A6 394.41,86.36 ; D305.A6 393.7,87.07 ; D305.A6 393.7,85.65 ; D305.A6 392.99,86.36 ; 330.2,85.65 D301.A10 ; D301.A10 330.91,86.36 ; D301.A10 329.49,86.36 ; D301.A10 330.2,87.07 ; D124.B16 272.59,40.64 ; D124.B16 270.97,40.64 ; D124.B16 271.78,39.83 ; D124.B16 271.78,41.45 ; 408.13,81.28 D106.B12 ; D106.B12 409.75,81.28 ; D106.B12 408.94,82.09 ; D106.B12 408.94,80.47 ; 250.33,247.45 SITE1.G9 ; SITE1.G9 249.85,247.93 ; SITE1.G9 250.81,247.93 ; SITE1.G9 250.33,248.41 ; 113.49,101.6 D129.B12 ; D129.B12 114.3,102.41 ; D129.B12 115.11,101.6 ; D129.B12 114.3,100.79 ; 265.99,71.12 D322.B14 ; D322.B14 266.7,71.83 ; D322.B14 266.7,70.41 ; D322.B14 267.41,71.12 ; 38.1,72.85 D126.A11 ; D126.A11 37.29,73.66 ; D126.A11 38.91,73.66 ; D126.A11 38.1,74.47 ; 391.16,67.87 D306.B5 ; D306.B5 390.45,68.58 ; D306.B5 391.87,68.58 ; D306.B5 391.16,69.29 ; 164.29,340.36 CSDPS429.C15 ; CSDPS429.C15 165.1,339.55 ; CSDPS429.C15 165.1,341.17 ; CSDPS429.C15 165.91,340.36 ; 382.73,81.28 D106.B2 ; D106.B2 383.54,80.47 ; D106.B2 383.54,82.09 ; D106.B2 384.35,81.28 ; 32.21,38.1 D128.B9 ; D128.B9 33.83,38.1 ; D128.B9 33.02,37.29 ; D128.B9 33.02,38.91 ; 414.02,347.17 D110.B4 ; D110.B4 414.02,348.79 ; D110.B4 414.83,347.98 ; D110.B4 413.21,347.98 ; D102.B12 336.09,81.28 ; D102.B12 334.47,81.28 ; D102.B12 335.28,82.09 ; D102.B12 335.28,80.47 ; D126.B15 49.07,78.74 ; D126.B15 48.26,79.55 ; D126.B15 48.26,77.93 ; D126.B15 47.45,78.74 ; CSDPS429.B12 172.72,343.71 ; CSDPS429.B12 173.53,342.9 ; CSDPS429.B12 171.91,342.9 ; CSDPS429.B12 172.72,342.09 ; D113.A16 309.88,333.55 ; D113.A16 310.69,332.74 ; D113.A16 309.88,331.93 ; D113.A16 309.07,332.74 ; CSDPS225.B6 261.62,333.55 ; CSDPS225.B6 260.81,332.74 ; CSDPS225.B6 261.62,331.93 ; CSDPS225.B6 262.43,332.74 ; 342.09,58.42 D103.B15 ; D103.B15 343.71,58.42 ; D103.B15 342.9,57.61 ; D103.B15 342.9,59.23 ; D120.A12 188.77,35.56 ; D120.A12 187.15,35.56 ; D120.A12 187.96,36.37 ; D120.A12 187.96,34.75 ; 123.65,81.28 D130.B16 ; D130.B16 125.27,81.28 ; D130.B16 124.46,80.47 ; D130.B16 124.46,82.09 ; D306.B14 414.73,71.12 ; D306.B14 414.02,70.41 ; D306.B14 414.02,71.83 ; D306.B14 413.31,71.12 ; DPS1.A15 416.56,14.78 ; DPS1.A15 415.75,13.97 ; DPS1.A15 417.37,13.97 ; DPS1.A15 416.56,13.16 ; 410.77,83.82 D305.A13 ; D305.A13 411.48,84.53 ; D305.A13 412.19,83.82 ; D305.A13 411.48,83.11 ; 193.04,85.65 D317.A14 ; D317.A14 193.75,86.36 ; D317.A14 193.04,87.07 ; D317.A14 192.33,86.36 ; 329.85,247.93 SITE2.G9 ; SITE2.G9 330.33,247.45 ; SITE2.G9 330.33,248.41 ; SITE2.G9 330.81,247.93 ; 325.12,85.65 D301.A8 ; D301.A8 325.83,86.36 ; D301.A8 324.41,86.36 ; D301.A8 325.12,87.07 ; 307.34,77.93 D102.B1 ; D102.B1 307.34,79.55 ; D102.B1 306.53,78.74 ; D102.B1 308.15,78.74 ; 388.62,60.15 D107.B4 ; D107.B4 388.62,61.77 ; D107.B4 389.43,60.96 ; D107.B4 387.81,60.96 ; D109.B8 403.86,328.47 ; D109.B8 404.67,327.66 ; D109.B8 403.86,326.85 ; D109.B8 403.05,327.66 ; D119.B6 172.72,61.77 ; D119.B6 172.72,60.15 ; D119.B6 173.53,60.96 ; D119.B6 171.91,60.96 ; D125.A8 30.48,97.33 ; D125.A8 29.67,96.52 ; D125.A8 31.29,96.52 ; D125.A8 30.48,95.71 ; D431.A1 200.66,386.89 ; D431.A1 200.66,385.27 ; D431.A1 201.47,386.08 ; D431.A1 199.85,386.08 ; 170.18,380.19 D431.B13 ; D431.B13 170.18,381.81 ; D431.B13 169.37,381 ; D431.B13 170.99,381 ; 266.7,55.07 D123.A14 ; D123.A14 265.89,55.88 ; D123.A14 267.51,55.88 ; D123.A14 266.7,56.69 ; 321.77,53.34 D103.A7 ; D103.A7 322.58,54.15 ; D103.A7 322.58,52.53 ; D103.A7 323.39,53.34 ; 309.07,388.62 D116.B16 ; D116.B16 309.88,387.81 ; D116.B16 309.88,389.43 ; D116.B16 310.69,388.62 ; SITE2.G14 330.23,243.31 ; SITE2.G14 330.23,242.35 ; SITE2.G14 329.75,242.83 ; SITE2.G14 330.71,242.83 ; 309.88,80.47 D102.B2 ; D102.B2 309.07,81.28 ; D102.B2 309.88,82.09 ; D102.B2 310.69,81.28 ; 264.16,329.39 CSDPS225.C5 ; CSDPS225.C5 263.35,330.2 ; CSDPS225.C5 264.16,331.01 ; CSDPS225.C5 264.97,330.2 ; 342.09,33.02 D104.A15 ; D104.A15 342.9,32.21 ; D104.A15 343.71,33.02 ; D104.A15 342.9,33.83 ; 194.77,73.66 D118.A15 ; D118.A15 195.58,74.47 ; D118.A15 196.39,73.66 ; D118.A15 195.58,72.85 ; 238.76,83.11 D321.A3 ; D321.A3 238.05,83.82 ; D321.A3 238.76,84.53 ; D321.A3 239.47,83.82 ; D122.B7 249.73,78.74 ; D122.B7 248.92,79.55 ; D122.B7 248.11,78.74 ; D122.B7 248.92,77.93 ; 172.72,80.47 D118.B6 ; D118.B6 173.53,81.28 ; D118.B6 172.72,82.09 ; D118.B6 171.91,81.28 ; D122.A3 238.76,74.47 ; D122.A3 238.76,72.85 ; D122.A3 239.57,73.66 ; D122.A3 237.95,73.66 ; D118.A8 178.61,76.2 ; D118.A8 177.8,77.01 ; D118.A8 176.99,76.2 ; D118.A8 177.8,75.39 ; 330.23,185.95 SITE4.G18 ; SITE4.G18 329.75,186.43 ; SITE4.G18 330.71,186.43 ; SITE4.G18 330.23,186.91 ; D119.B10 183.69,60.96 ; D119.B10 182.07,60.96 ; D119.B10 182.88,60.15 ; D119.B10 182.88,61.77 ; D128.B15 49.07,38.1 ; D128.B15 48.26,37.29 ; D128.B15 47.45,38.1 ; D128.B15 48.26,38.91 ; 259.08,329.39 CSDPS225.C7 ; CSDPS225.C7 259.89,330.2 ; CSDPS225.C7 259.08,331.01 ; CSDPS225.C7 258.27,330.2 ; 260.81,55.88 D123.A12 ; D123.A12 261.62,55.07 ; D123.A12 262.43,55.88 ; D123.A12 261.62,56.69 ; D130.A7 101.6,74.47 ; D130.A7 101.6,72.85 ; D130.A7 102.41,73.66 ; D130.A7 100.79,73.66 ; 317.5,72.85 D102.A5 ; D102.A5 316.69,73.66 ; D102.A5 318.31,73.66 ; D102.A5 317.5,74.47 ; 337.82,370.03 D115.B5 ; D115.B5 338.63,370.84 ; D115.B5 337.01,370.84 ; D115.B5 337.82,371.65 ; 246.38,34.75 D124.A6 ; D124.A6 246.38,36.37 ; D124.A6 245.57,35.56 ; D124.A6 247.19,35.56 ; D317.A16 198.12,87.07 ; D317.A16 197.41,86.36 ; D317.A16 198.12,85.65 ; D317.A16 198.83,86.36 ; D231.A13 170.99,375.92 ; D231.A13 170.18,375.11 ; D231.A13 169.37,375.92 ; D231.A13 170.18,376.73 ; D321.B9 254,89.61 ; D321.B9 254.71,88.9 ; D321.B9 253.29,88.9 ; D321.B9 254,88.19 ; D128.A10 36.37,35.56 ; D128.A10 35.56,34.75 ; D128.A10 35.56,36.37 ; D128.A10 34.75,35.56 ; D109.B15 386.89,330.2 ; D109.B15 385.27,330.2 ; D109.B15 386.08,331.01 ; D109.B15 386.08,329.39 ; 170.18,88.19 D317.B5 ; D317.B5 170.18,89.61 ; D317.B5 170.89,88.9 ; D317.B5 169.47,88.9 ; D129.A3 92.25,93.98 ; D129.A3 90.63,93.98 ; D129.A3 91.44,94.79 ; D129.A3 91.44,93.17 ; 332.74,72.85 D102.A11 ; D102.A11 333.55,73.66 ; D102.A11 331.93,73.66 ; D102.A11 332.74,74.47 ; 339.65,66.04 D302.A14 ; D302.A14 341.07,66.04 ; D302.A14 340.36,65.33 ; D302.A14 340.36,66.75 ; 405.69,68.58 D306.B11 ; D306.B11 406.4,69.29 ; D306.B11 407.11,68.58 ; D306.B11 406.4,67.87 ; 317.5,52.53 D103.A5 ; D103.A5 318.31,53.34 ; D103.A5 317.5,54.15 ; D103.A5 316.69,53.34 ; D126.A3 18.59,73.66 ; D126.A3 17.78,74.47 ; D126.A3 16.97,73.66 ; D126.A3 17.78,72.85 ; 408.94,372.57 D111.A6 ; D111.A6 408.13,373.38 ; D111.A6 409.75,373.38 ; D111.A6 408.94,374.19 ; 329.39,388.62 D116.B8 ; D116.B8 331.01,388.62 ; D116.B8 330.2,387.81 ; D116.B8 330.2,389.43 ; 232.97,63.5 D322.A1 ; D322.A1 233.68,64.21 ; D322.A1 233.68,62.79 ; D322.A1 234.39,63.5 ; SITE3.G10 251.33,188.41 ; SITE3.G10 251.33,187.45 ; SITE3.G10 251.81,187.93 ; SITE3.G10 250.85,187.93 ; D116.B7 333.55,391.16 ; D116.B7 332.74,391.97 ; D116.B7 332.74,390.35 ; D116.B7 331.93,391.16 ; D113.B10 325.12,328.47 ; D113.B10 325.12,326.85 ; D113.B10 324.31,327.66 ; D113.B10 325.93,327.66 ; D102.A7 322.58,74.47 ; D102.A7 322.58,72.85 ; D102.A7 321.77,73.66 ; D102.A7 323.39,73.66 ; CSDPS429.B14 168.45,342.9 ; CSDPS429.B14 167.64,342.09 ; CSDPS429.B14 166.83,342.9 ; CSDPS429.B14 167.64,343.71 ; 258.27,340.36 CSDPS425.C7 ; CSDPS425.C7 259.89,340.36 ; CSDPS425.C7 259.08,339.55 ; CSDPS425.C7 259.08,341.17 ; D112.B3 417.37,391.16 ; D112.B3 416.56,391.97 ; D112.B3 416.56,390.35 ; D112.B3 415.75,391.16 ; D123.B1 233.68,59.23 ; D123.B1 233.68,57.61 ; D123.B1 234.49,58.42 ; D123.B1 232.87,58.42 ; D317.A1 160.02,84.53 ; D317.A1 160.02,83.11 ; D317.A1 159.31,83.82 ; D317.A1 160.73,83.82 ; 243.84,13.16 DPS3.A05 ; DPS3.A05 244.65,13.97 ; DPS3.A05 243.03,13.97 ; DPS3.A05 243.84,14.78 ; D301.A13 338.53,83.82 ; D301.A13 337.82,84.53 ; D301.A13 337.82,83.11 ; D301.A13 337.11,83.82 ; 39.83,76.2 D126.A12 ; D126.A12 41.45,76.2 ; D126.A12 40.64,75.39 ; D126.A12 40.64,77.01 ; D111.B11 397.05,370.84 ; D111.B11 396.24,370.03 ; D111.B11 395.43,370.84 ; D111.B11 396.24,371.65 ; DPS1.A05 391.16,14.78 ; DPS1.A05 390.35,13.97 ; DPS1.A05 391.16,13.16 ; DPS1.A05 391.97,13.97 ; 312.42,67.87 D302.B3 ; D302.B3 311.71,68.58 ; D302.B3 312.42,69.29 ; D302.B3 313.13,68.58 ; D302.B9 328.37,68.58 ; D302.B9 327.66,69.29 ; D302.B9 327.66,67.87 ; D302.B9 326.95,68.58 ; 236.22,342.09 CSDPS425.B16 ; CSDPS425.B16 236.22,343.71 ; CSDPS425.B16 235.41,342.9 ; CSDPS425.B16 237.03,342.9 ; D321.A6 247.09,86.36 ; D321.A6 246.38,87.07 ; D321.A6 245.67,86.36 ; D321.A6 246.38,85.65 ; 113.49,96.52 D129.A12 ; D129.A12 114.3,97.33 ; D129.A12 115.11,96.52 ; D129.A12 114.3,95.71 ; D113.A13 318.31,335.28 ; D113.A13 317.5,334.47 ; D113.A13 316.69,335.28 ; D113.A13 317.5,336.09 ; D127.B13 43.18,59.23 ; D127.B13 43.18,57.61 ; D127.B13 42.37,58.42 ; D127.B13 43.99,58.42 ; CSDPS229.B16 163.37,332.74 ; CSDPS229.B16 161.75,332.74 ; CSDPS229.B16 162.56,333.55 ; CSDPS229.B16 162.56,331.93 ; D114.A3 343.71,355.6 ; D114.A3 342.9,356.41 ; D114.A3 342.09,355.6 ; D114.A3 342.9,354.79 ; D132.A14 119.38,36.37 ; D132.A14 118.57,35.56 ; D132.A14 119.38,34.75 ; D132.A14 120.19,35.56 ; DPS8.C11 176.07,410.21 ; DPS8.C11 174.45,410.21 ; DPS8.C11 175.26,411.02 ; DPS8.C11 175.26,409.4 ; D122.B14 267.51,81.28 ; D122.B14 266.7,80.47 ; D122.B14 265.89,81.28 ; D122.B14 266.7,82.09 ; 250.23,182.35 SITE3.G14 ; SITE3.G14 250.71,182.83 ; SITE3.G14 250.23,183.31 ; SITE3.G14 249.75,182.83 ; DPS2.C01 347.98,411.02 ; DPS2.C01 348.79,410.21 ; DPS2.C01 347.17,410.21 ; DPS2.C01 347.98,409.4 ; D127.A3 18.59,53.34 ; D127.A3 16.97,53.34 ; D127.A3 17.78,52.53 ; D127.A3 17.78,54.15 ; 187.15,76.2 D118.A12 ; D118.A12 187.96,75.39 ; D118.A12 188.77,76.2 ; D118.A12 187.96,77.01 ; D109.A13 391.16,336.09 ; D109.A13 391.16,334.47 ; D109.A13 390.35,335.28 ; D109.A13 391.97,335.28 ; 170.18,77.93 D118.B5 ; D118.B5 170.99,78.74 ; D118.B5 170.18,79.55 ; D118.B5 169.37,78.74 ; SITE3.G18 250.23,186.91 ; SITE3.G18 249.75,186.43 ; SITE3.G18 250.23,185.95 ; SITE3.G18 250.71,186.43 ; 172.72,367.49 D231.B12 ; D231.B12 171.91,368.3 ; D231.B12 172.72,369.11 ; D231.B12 173.53,368.3 ; 337.82,62.79 D302.A13 ; D302.A13 338.53,63.5 ; D302.A13 337.82,64.21 ; D302.A13 337.11,63.5 ; D130.B5 97.33,78.74 ; D130.B5 96.52,79.55 ; D130.B5 95.71,78.74 ; D130.B5 96.52,77.93 ; 329.33,187.45 SITE4.G8 ; SITE4.G8 328.85,187.93 ; SITE4.G8 329.33,188.41 ; SITE4.G8 329.81,187.93 ; 395.43,375.92 D111.A11 ; D111.A11 397.05,375.92 ; D111.A11 396.24,375.11 ; D111.A11 396.24,376.73 ; D126.A6 26.21,76.2 ; D126.A6 24.59,76.2 ; D126.A6 25.4,75.39 ; D126.A6 25.4,77.01 ; CSDPS425.C3 270.05,340.36 ; CSDPS425.C3 269.24,339.55 ; CSDPS425.C3 269.24,341.17 ; CSDPS425.C3 268.43,340.36 ; D130.B6 99.87,81.28 ; D130.B6 98.25,81.28 ; D130.B6 99.06,82.09 ; D130.B6 99.06,80.47 ; 121.11,53.34 D131.A15 ; D131.A15 122.73,53.34 ; D131.A15 121.92,52.53 ; D131.A15 121.92,54.15 ; D122.B12 262.43,81.28 ; D122.B12 260.81,81.28 ; D122.B12 261.62,82.09 ; D122.B12 261.62,80.47 ; 243.13,68.58 D322.B5 ; D322.B5 243.84,69.29 ; D322.B5 243.84,67.87 ; D322.B5 244.55,68.58 ; 236.22,34.75 D124.A2 ; D124.A2 235.41,35.56 ; D124.A2 237.03,35.56 ; D124.A2 236.22,36.37 ; D107.B12 408.94,61.77 ; D107.B12 408.13,60.96 ; D107.B12 409.75,60.96 ; D107.B12 408.94,60.15 ; D112.A12 393.7,394.51 ; D112.A12 394.51,393.7 ; D112.A12 393.7,392.89 ; D112.A12 392.89,393.7 ; D302.B15 343.61,68.58 ; D302.B15 342.9,67.87 ; D302.B15 342.19,68.58 ; D302.B15 342.9,69.29 ; 255.83,91.44 D321.B10 ; D321.B10 257.25,91.44 ; D321.B10 256.54,90.73 ; D321.B10 256.54,92.15 ; D318.B4 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