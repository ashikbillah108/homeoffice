# Allegro board 8880F5-0830.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D12214: length 385
  TOP w0.086: v1(273.81,193.77) 273.35,194.22 269.53,194.22 266.61,191.31 264.06,191.31 263.98,191.23 SITE3.83
  L05_SIGNAL w0.071: D122.14 268.11,80.15 269.63,80.15 270.04,80.56 270.04,82.08 270.57,82.61 276.02,82.61 278.42,85.01 278.42,92.39 277.09,93.71 226.03,93.71 207.49,112.25 186.01,112.25 184.86,111.09 180.83,111.09 180.24,111.69 165.23,111.69 162.46,114.46 162.46,139.33 166.91,143.78 204.4,143.78 220.43,127.76 262.22,127.76 265.59,131.14 265.59,133.56 265.09,134.06 263.77,134.06 263.29,133.57 263.29,132.47 263.36,132.4 v1(263.76,132.4)
  L30_SIGNAL w0.071: v1(263.76,132.4) 263.36,132.4 263.29,132.33 263.29,130.97 263.66,130.61 264.48,130.61 265.3,131.42 265.3,151.51 279.57,165.79 279.57,193.54 278.86,194.24 273.88,194.24 273.81,194.17 v1(273.81,193.77)
D12215: length 385
  TOP w0.086: SITE3.86 263.98,192.43 264.06,192.35 265.64,192.35 270.02,196.73 277.07,196.73 v1(277.52,197.18)
  L05_SIGNAL w0.071: v1(262.62,145.99) 263.02,145.99 263.09,145.91 263.09,144.42 268.24,139.27 268.24,131.64 262.31,125.72 216.33,125.72 211.95,130.1 211.95,132.62 202.51,142.06 179.55,142.06 170.18,132.69 170.18,115.94 172.02,114.1 208.7,114.1 226.11,96.68 277.33,96.68 280.29,93.72 280.29,77.67 274.99,72.37 266.95,72.37 266.76,72.55 266.76,74.22 267.22,74.68 267.72,74.68 D122.15
  L28_SIGNAL w0.071: v1(277.52,197.18) 277.52,196.78 277.45,196.7 276.72,196.7 275.62,195.61 275.62,175.38 278.98,172.02 278.98,156.52 275.55,153.09 267.75,153.09 263.09,148.42 263.09,146.06 263.02,145.99 v1(262.62,145.99)
D12216: length 385
  TOP w0.086: v1(273.81,194.92) 273.35,194.46 269.43,194.46 266.51,191.55 264.06,191.55 263.98,191.63 SITE3.84
  L05_SIGNAL w0.071: D122.16 270.24,80.28 270.24,82 270.65,82.41 276.1,82.41 278.61,84.93 278.61,92.47 277.18,93.91 226.12,93.91 207.57,112.45 185.93,112.45 184.77,111.29 180.92,111.29 180.32,111.89 165.31,111.89 162.66,114.54 162.66,139.25 166.99,143.58 204.32,143.58 220.34,127.56 262.3,127.56 265.79,131.06 265.79,133.64 265.17,134.26 263.69,134.26 263.09,133.66 263.09,132.47 263.02,132.4 v1(262.62,132.4)
  L30_SIGNAL w0.071: v1(262.62,132.4) 263.02,132.4 263.09,132.33 263.09,130.89 263.57,130.41 264.57,130.41 265.49,131.33 265.49,151.43 279.77,165.7 279.77,193.62 278.94,194.44 273.88,194.44 273.81,194.51 v1(273.81,194.92)
D12301: length 385
  TOP w0.086: SITE3.95 257.03,197.78 256.95,197.86 256.95,199.72 260.9,203.67 260.9,207.1 v1(261.36,207.55)
  L07_SIGNAL w0.071: v1(195.26,217.02) 195.26,216.62 195.33,216.55 196.08,216.55 196.59,217.06 196.59,217.73 195.41,218.91 190.99,218.91 188.71,216.64 188.71,144.17 195.81,137.07 195.81,108.53 209.02,95.31 209.02,72.39 204.11,67.48 204.11,24.35 210.55,17.92 222.18,17.92 228.65,24.39 228.65,41.68 236.57,49.6 243.85,49.6 244.31,50.06 244.31,51.16 243.95,51.53 237.83,51.53 237.12,52.24 237.12,53.27 235.92,54.47 235.09,54.47 D123.01
  L28_SIGNAL w0.071: v1(195.26,217.02) 195.26,216.62 195.33,216.55 196.14,216.55 196.67,217.08 196.67,217.91 198.84,220.08 221.83,220.08 223.6,218.31 223.6,216.04 225.04,214.6 256.44,214.6 258.76,212.28 258.76,211.28 260.88,209.15 260.88,207.62 260.96,207.55 v1(261.36,207.55)
D12302: length 385
  TOP w0.086: SITE3.100 255.03,197.78 254.95,197.86 254.95,201.59 257.04,203.68 257.04,208.51 256.65,208.9 256.65,210.62 v1(257.1,211.08)
  L07_SIGNAL w0.071: v1(195.26,203.56) 195.26,203.16 195.19,203.09 194.36,203.09 193.63,203.81 193.63,212.81 192.7,213.74 191.4,213.74 190.41,212.75 190.41,182.41 191.41,181.4 191.41,142.85 198.51,135.76 198.51,124.11 197.23,122.82 197.23,108.79 210.14,95.88 210.14,71.62 205.4,66.88 205.4,25.2 210.86,19.74 222.22,19.74 227.3,24.82 227.3,43.55 231.53,47.78 231.53,60.44 233.32,62.23 237.45,62.23 237.74,61.94 237.74,59.94 D123.02
  L28_SIGNAL w0.071: v1(195.26,203.56) 195.26,203.16 195.19,203.09 193.67,203.09 192.92,202.34 192.92,201.06 193.61,200.37 213.53,200.37 215.19,202.03 225.34,202.03 228.39,198.97 237.08,198.97 239.64,201.54 254.11,201.54 256.63,204.05 256.63,211 256.7,211.08 v1(257.1,211.08)
D12303: length 385
  TOP w0.086: v1(260.21,207.55) 260.67,207.1 260.67,203.77 256.71,199.82 256.71,197.86 256.63,197.78 SITE3.96
  L07_SIGNAL w0.071: v1(195.26,215.88) 195.26,216.28 195.33,216.35 196.17,216.35 196.79,216.98 196.79,217.81 195.49,219.11 190.91,219.11 188.52,216.72 188.52,144.08 195.61,136.99 195.61,108.45 208.83,95.23 208.83,72.47 203.91,67.56 203.91,24.27 210.46,17.72 222.27,17.72 228.85,24.3 228.85,41.6 236.65,49.4 243.94,49.4 244.51,49.98 244.51,51.25 244.03,51.73 237.92,51.73 237.32,52.33 237.32,54.44 D123.03
  L28_SIGNAL w0.071: v1(260.21,207.55) 260.62,207.55 260.69,207.62 260.69,209.07 258.56,211.2 258.56,212.2 256.35,214.4 224.96,214.4 223.4,215.95 223.4,218.23 221.75,219.88 198.92,219.88 196.87,217.83 196.87,217 196.22,216.35 195.33,216.35 195.26,216.28 v1(195.26,215.88)
D12304: length 385
  TOP w0.086: SITE3.101 254.63,197.78 254.71,197.86 254.71,201.69 256.8,203.78 256.8,208.41 256.41,208.8 256.41,210.62 v1(255.96,211.08)
  L07_SIGNAL w0.071: D123.04 239.7,60.02 238.78,60.02 237.94,60.82 237.94,62.02 237.53,62.43 233.24,62.43 231.33,60.52 231.33,47.86 227.1,43.63 227.1,24.9 222.13,19.94 210.94,19.94 205.6,25.28 205.6,66.8 210.34,71.54 210.34,95.96 197.43,108.87 197.43,122.74 198.71,124.02 198.71,135.84 191.61,142.93 191.61,181.48 190.61,182.49 190.61,212.67 191.49,213.54 192.62,213.54 193.43,212.73 193.43,203.73 194.28,202.89 195.19,202.89 195.26,202.82 v1(195.26,202.42)
  L28_SIGNAL w0.071: v1(255.96,211.08) 256.36,211.08 256.43,211 256.43,204.13 254.03,201.73 239.56,201.73 237,199.17 228.47,199.17 225.42,202.23 215.1,202.23 213.45,200.57 193.69,200.57 193.12,201.14 193.12,202.26 193.75,202.89 195.19,202.89 195.26,202.82 v1(195.26,202.42)
D12305: length 385
  TOP w0.086: v1(258.99,208.83) 258.54,208.38 258.54,204.15 255.75,201.37 255.75,197.86 255.83,197.78 SITE3.98
  L07_SIGNAL w0.071: D123.05 246.28,53.44 246.28,50.59 244.06,48.37 240.94,48.37 229.92,37.35 229.92,23.73 222.64,16.46 210.32,16.46 202.41,24.37 202.41,68.66 207.79,74.05 207.79,94.33 192.58,109.55 192.58,124.42 193.88,125.72 193.88,134.83 185.68,143.04 185.68,203.08 183.39,205.37 183.39,216 182.84,216.55 181.75,216.55 181.67,216.62 v1(181.67,217.02)
  L32_SIGNAL w0.071: v1(258.99,208.83) 258.59,208.83 258.52,208.9 258.52,212.18 256.31,214.38 233.53,214.38 229.15,218.77 219.62,218.77 214.45,213.6 183.84,213.6 182.76,214.67 182.76,216.09 182.3,216.55 181.75,216.55 181.67,216.62 v1(181.67,217.02)
D12307: length 385
  TOP w0.086: SITE3.99 255.43,197.78 255.51,197.86 255.51,201.47 258.3,204.25 258.3,208.38 v1(257.84,208.83)
  L07_SIGNAL w0.071: v1(181.67,215.88) 181.67,216.28 181.75,216.35 182.76,216.35 183.19,215.92 183.19,205.28 185.48,202.99 185.48,142.95 193.69,134.75 193.69,125.81 192.38,124.5 192.38,109.46 207.6,94.24 207.6,74.13 202.21,68.74 202.21,24.29 210.24,16.26 222.73,16.26 230.12,23.65 230.12,37.27 241.02,48.17 244.14,48.17 246.48,50.51 246.48,53.44 D123.07
  L32_SIGNAL w0.071: v1(181.67,215.88) 181.67,216.28 181.75,216.35 182.21,216.35 182.56,216 182.56,214.59 183.76,213.4 214.53,213.4 219.7,218.57 229.07,218.57 233.45,214.19 256.23,214.19 258.32,212.1 258.32,208.9 258.25,208.83 v1(257.84,208.83)
D12309: length 385
  TOP w0.086: v1(266.32,208.6) 265.87,208.15 265.87,205.63 265.31,205.07 265.31,202.18 263.95,200.83 261.74,200.83 259.35,198.44 259.35,197.86 259.43,197.78 SITE3.89
  L07_SIGNAL w0.071: D123.09 256.04,53.84 256.04,51.28 259.58,47.73 277.25,47.73 282.88,53.36 282.88,97.67 275.41,105.14 219.92,105.14 219.27,105.79 219.27,106.68 220.16,107.57 243.2,107.57 243.92,108.29 243.92,110.49 242.99,111.42 217.77,111.42 216.44,112.75 216.44,115.69 217.53,116.78 263.96,116.78 265.08,117.9 275.79,117.9 280.74,122.85 280.74,135.63 279.58,136.79 279.58,153.95 276.5,157.04 276.5,158.11 276.57,158.18 v1(276.97,158.18)
  L28_SIGNAL w0.071: v1(276.97,158.18) 276.57,158.18 276.5,158.25 276.5,170.82 269.53,177.79 269.53,188.13 264.97,192.68 264.97,204.62 265.85,205.5 265.85,208.53 265.92,208.6 v1(266.32,208.6)
D12310: length 385
  TOP w0.086: v1(237.56,205.42) 237.11,204.97 237.11,203.7 242.55,198.26 242.55,197.86 242.63,197.78 SITE3.131
  L07_SIGNAL w0.071: v1(212.03,189.59) 212.03,189.19 211.95,189.12 210.46,189.12 207.98,191.6 207.98,204.95 211.51,208.47 211.51,210.08 209.9,211.69 207.67,211.69 206.12,210.13 206.12,145.73 215.68,136.17 215.68,127.49 207.28,119.09 207.28,111.24 217.58,100.94 217.58,66.68 218.56,65.7 222.19,65.7 223.42,66.93 223.42,90.47 232.49,99.54 275.23,99.54 279.04,95.73 279.04,64.66 276.72,62.34 259.48,62.34 258.98,61.84 258.98,60.86 D123.10
  L32_SIGNAL w0.071: v1(237.56,205.42) 237.16,205.42 237.09,205.35 237.09,200.78 231.34,195.02 228.28,195.02 225.98,192.72 212.78,192.72 211.17,191.11 211.17,189.6 211.65,189.12 211.95,189.12 212.03,189.19 v1(212.03,189.59)
D12311: length 385
  TOP w0.086: v1(265.18,208.6) 265.63,208.15 265.63,205.73 265.07,205.17 265.07,202.28 263.85,201.07 261.64,201.07 259.11,198.54 259.11,197.86 259.03,197.78 SITE3.90
  L07_SIGNAL w0.071: D123.11 257.76,54.56 257.22,54.56 256.24,53.6 256.24,51.36 259.67,47.93 277.17,47.93 282.68,53.44 282.68,97.59 275.33,104.95 219.84,104.95 219.07,105.71 219.07,106.76 220.08,107.76 243.12,107.76 243.73,108.37 243.73,110.41 242.91,111.22 217.69,111.22 216.24,112.67 216.24,115.77 217.45,116.98 263.87,116.98 265,118.1 275.71,118.1 280.54,122.93 280.54,135.55 279.39,136.71 279.39,153.87 276.3,156.96 276.3,158.11 276.23,158.18 v1(275.82,158.18)
  L28_SIGNAL w0.071: v1(265.18,208.6) 265.58,208.6 265.65,208.53 265.65,205.58 264.77,204.7 264.77,192.6 269.33,188.04 269.33,177.71 276.3,170.74 276.3,158.25 276.23,158.18 v1(275.82,158.18)
D12312: length 385
  TOP w0.086: SITE3.132 242.23,197.78 242.31,197.86 242.31,198.16 236.87,203.6 236.87,204.97 v1(236.42,205.42)
  L07_SIGNAL w0.071: v1(212.03,188.45) 212.03,188.85 211.95,188.92 210.38,188.92 207.78,191.51 207.78,205.03 211.31,208.56 211.31,209.99 209.81,211.49 207.76,211.49 206.31,210.05 206.31,145.81 215.88,136.25 215.88,127.4 207.48,119.01 207.48,111.33 217.78,101.02 217.78,66.76 218.64,65.9 222.11,65.9 223.22,67.01 223.22,90.55 232.41,99.74 275.32,99.74 279.24,95.81 279.24,64.58 276.8,62.14 259.56,62.14 259.18,61.76 259.18,60.86 D123.12
  L32_SIGNAL w0.071: v1(212.03,188.45) 212.03,188.85 211.95,188.92 211.57,188.92 210.97,189.52 210.97,191.19 212.7,192.92 225.9,192.92 228.2,195.22 231.25,195.22 236.89,200.86 236.89,205.35 236.82,205.42 v1(236.42,205.42)
D12313: length 385
  TOP w0.086: SITE3.135 237.68,192.43 237.6,192.35 236.53,192.35 231.68,197.2 229.02,197.2 v1(228.57,197.65)
  L07_SIGNAL w0.071: D123.13 265.98,54.06 265.98,51.16 267.35,49.79 273.67,49.79 281.22,57.34 281.22,96.88 276.75,101.34 230.88,101.34 221.76,92.22 221.76,68 221.26,67.5 220.06,67.5 219.59,67.97 219.59,102.06 209.8,111.85 209.8,118.72 219.08,127.99 219.08,129.15 230.8,140.87 230.8,147.23 216.26,161.78 216.26,179.93 217.3,180.97 222.91,180.97 224.77,182.83 224.77,187.81 223.2,189.38 223.2,192.86 221.08,194.98 216.83,194.98 214.72,192.87 214.72,175.91 214.47,175.66 212.35,175.66 212.28,175.73 v1(212.28,176.13)
  L30_SIGNAL w0.071: v1(228.57,197.65) 228.57,197.25 228.49,197.18 219.98,197.18 214.22,191.42 214.22,176.26 213.61,175.66 212.35,175.66 212.28,175.73 v1(212.28,176.13)
D12314: length 385
  TOP w0.086: v1(273.81,198.17) 273.35,198.62 270.67,198.62 264.96,192.91 264.06,192.91 263.98,192.83 SITE3.87
  L05_SIGNAL w0.071: D123.14 268.67,60.39 268.8,60.39 269.45,61.04 269.45,61.91 269.94,62.4 276,62.4 282.83,69.23 282.83,94.96 279.07,98.71 229.4,98.71 211.57,116.54 175.93,116.54 173.58,118.89 173.58,126.59 182.85,135.86 193.92,135.86 198.5,131.28 205.65,131.28 212.75,124.18 264.33,124.18 270.77,130.62 270.77,133.62 273.05,135.9 273.05,145.54 273.77,146.27 276.1,146.27 276.5,145.87 276.5,144.66 276.57,144.59 v1(276.97,144.59)
  L30_SIGNAL w0.071: v1(273.81,198.17) 273.81,198.57 273.88,198.64 278.43,198.64 281.68,195.39 281.68,146.34 278.09,142.75 277.16,142.75 276.5,143.42 276.5,144.52 276.57,144.59 v1(276.97,144.59)
D12315: length 385
  TOP w0.086: v1(228.57,196.51) 229.02,196.96 231.58,196.96 236.43,192.11 237.6,192.11 237.68,192.03 SITE3.136
  L07_SIGNAL w0.071: v1(212.28,174.99) 212.28,175.39 212.35,175.46 214.55,175.46 214.92,175.83 214.92,192.79 216.91,194.78 221,194.78 223,192.77 223,189.29 224.57,187.73 224.57,182.91 222.83,181.17 217.22,181.17 216.06,180.01 216.06,161.7 230.6,147.15 230.6,140.96 218.88,129.24 218.88,128.08 209.61,118.8 209.61,111.77 219.4,101.98 219.4,67.89 219.98,67.31 221.34,67.31 221.95,67.92 221.95,92.14 230.96,101.15 276.67,101.15 281.02,96.8 281.02,57.42 273.59,49.99 267.43,49.99 266.18,51.24 266.18,53.62 267.03,54.47 267.83,54.47 D123.15
  L30_SIGNAL w0.071: v1(212.28,174.99) 212.28,175.39 212.35,175.46 213.69,175.46 214.42,176.18 214.42,191.33 220.06,196.98 228.49,196.98 228.57,196.91 v1(228.57,196.51)
D12316: length 385
  TOP w0.086: SITE3.88 263.98,193.23 264.06,193.15 264.86,193.15 270.57,198.86 273.35,198.86 v1(273.81,199.31)
  L05_SIGNAL w0.071: D123.16 269.65,60.55 269.65,61.83 270.02,62.2 276.08,62.2 283.02,69.15 283.02,95.04 279.16,98.91 229.49,98.91 211.66,116.74 176.01,116.74 173.78,118.97 173.78,126.5 182.93,135.66 193.83,135.66 198.41,131.08 205.56,131.08 212.67,123.98 264.41,123.98 270.97,130.54 270.97,133.54 273.25,135.82 273.25,145.46 273.86,146.07 276.02,146.07 276.3,145.79 276.3,144.66 276.23,144.59 v1(275.82,144.59)
  L30_SIGNAL w0.071: v1(275.82,144.59) 276.23,144.59 276.3,144.52 276.3,143.33 277.08,142.56 278.17,142.56 281.87,146.26 281.87,195.47 278.51,198.84 273.88,198.84 273.81,198.91 v1(273.81,199.31)
D12901: length 385
  TOP w0.086: v1(228.57,257.65) 229.02,257.2 231.68,257.2 236.53,252.35 237.6,252.35 237.68,252.43 SITE1.135
  L07_SIGNAL w0.071: v1(178.5,258.17) 178.5,257.77 178.57,257.7 179.19,257.7 179.79,258.3 179.79,259.17 179.48,259.48 172.28,259.48 167.83,255.04 77.33,255.04 63.64,241.35 63.64,220.31 72.89,211.06 72.89,208.04 64.9,200.05 64.9,107.96 83.74,89.12 93.97,89.12 94.61,89.77 94.61,91.67 94.02,92.26 90.65,92.26 89.71,93.2 89.71,94.68 89.12,95.27 87.61,95.27 D129.01
  L30_SIGNAL w0.071: v1(178.5,258.17) 178.5,257.77 178.57,257.7 179.58,257.7 180.18,257.11 180.18,255.88 181.56,254.5 213.1,254.5 215.78,257.18 228.49,257.18 228.57,257.25 v1(228.57,257.65)
D12902: length 385
  TOP w0.086: SITE1.129 243.43,257.78 243.35,257.86 243.35,258.57 239.3,262.62 239.3,267.2 238.34,268.16 238.34,268.63 v1(238.79,269.08)
  L07_SIGNAL w0.071: D129.02 90.97,101.13 90.97,103.72 89.83,104.85 76.24,104.85 66.88,114.22 66.88,198.08 72.47,203.67 81.47,203.67 84.87,207.08 84.87,211.24 82.9,213.21 74.14,213.21 70.97,216.38 70.97,244.5 77.89,251.42 165.95,251.42 169.5,254.97 178.9,254.97 179.93,256 179.93,256.79 180.83,257.7 181.6,257.7 181.67,257.77 v1(181.67,258.17)
  L30_SIGNAL w0.071: v1(181.67,258.17) 181.67,257.77 181.75,257.7 183.4,257.7 185.88,260.18 216.2,260.18 226.39,270.37 233.38,270.37 234.31,271.3 237.47,271.3 238.32,270.46 238.32,269.16 238.39,269.08 v1(238.79,269.08)
D12903: length 385
  TOP w0.086: v1(228.57,256.51) 229.02,256.96 231.58,256.96 236.43,252.11 237.6,252.11 237.68,252.03 SITE1.136
  L07_SIGNAL w0.071: D129.03 89.91,94.99 89.91,93.28 90.74,92.46 94.1,92.46 94.81,91.75 94.81,89.68 94.05,88.92 83.66,88.92 64.7,107.88 64.7,200.14 72.69,208.12 72.69,210.98 63.44,220.23 63.44,241.43 77.25,255.23 167.75,255.23 172.2,259.68 179.56,259.68 179.99,259.25 179.99,258.22 179.27,257.5 178.57,257.5 178.5,257.43 v1(178.5,257.03)
  L30_SIGNAL w0.071: v1(228.57,256.51) 228.57,256.91 228.49,256.98 215.86,256.98 213.18,254.3 181.48,254.3 179.98,255.8 179.98,257.02 179.5,257.5 178.57,257.5 178.5,257.43 v1(178.5,257.03)
D12904: length 385
  TOP w0.086: v1(237.64,269.08) 238.1,268.63 238.1,268.06 239.06,267.1 239.06,262.52 243.11,258.47 243.11,257.86 243.03,257.78 SITE1.130
  L07_SIGNAL w0.071: D129.04 92.64,100.4 92.05,100.4 91.16,101.28 91.16,103.8 89.92,105.05 76.32,105.05 67.07,114.3 67.07,198 72.55,203.47 81.55,203.47 85.07,207 85.07,211.32 82.98,213.41 74.22,213.41 71.16,216.47 71.16,244.42 77.97,251.23 166.04,251.23 169.58,254.77 178.98,254.77 180.13,255.92 180.13,256.71 180.92,257.5 181.6,257.5 181.67,257.43 v1(181.67,257.03)
  L30_SIGNAL w0.071: v1(181.67,257.03) 181.67,257.43 181.75,257.5 183.48,257.5 185.96,259.98 216.28,259.98 226.47,270.17 233.46,270.17 234.4,271.11 237.39,271.11 238.12,270.37 238.12,269.16 238.05,269.08 v1(237.64,269.08)
D12905: length 385
  TOP w0.086: v1(225.81,255.53) 226.27,255.08 232.64,255.08 236.17,251.55 237.6,251.55 237.68,251.63 SITE1.137
  L07_SIGNAL w0.071: D129.05 98.11,94.93 99.43,94.93 100,94.37 100,92.21 95.78,88 79.67,88 61.25,106.42 61.25,242.29 79.17,260.22 165.7,260.22 166.56,259.36 166.56,258.35 165.9,257.7 164.98,257.7 164.91,257.77 v1(164.91,258.17)
  L28_SIGNAL w0.071: v1(225.81,255.53) 225.81,255.13 225.74,255.06 168.58,255.06 165.94,257.7 164.98,257.7 164.91,257.77 v1(164.91,258.17)
D12906: length 385
  TOP w0.086: SITE1.133 237.68,253.23 237.6,253.15 237.23,253.15 231.06,259.32 226.27,259.32 v1(225.81,259.77)
  L07_SIGNAL w0.071: v1(198.18,258.17) 198.18,257.77 198.11,257.7 197.21,257.7 196.6,257.09 196.6,255.84 194.18,253.42 186.49,253.42 186.06,253.85 186.06,261.87 185.09,262.84 183.8,262.84 182.86,261.9 182.86,254.7 181.57,253.42 172.11,253.42 167.91,249.22 126.41,249.22 122.96,245.77 77.05,245.77 74.73,243.45 74.73,216.9 76.13,215.5 83.39,215.5 86.53,212.37 86.53,203.44 83.82,200.74 73.93,200.74 70.55,197.35 70.55,114.49 77.72,107.32 97.1,107.32 101.32,103.09 101.32,101.32 D129.06
  L28_SIGNAL w0.071: v1(225.81,259.77) 225.81,259.37 225.74,259.3 220.05,259.3 218.37,260.97 202.51,260.97 199.23,257.7 198.26,257.7 198.18,257.77 v1(198.18,258.17)
D12907: length 385
  TOP w0.086: SITE1.138 237.68,251.23 237.6,251.31 236.07,251.31 232.55,254.84 226.27,254.84 v1(225.81,254.39)
  L07_SIGNAL w0.071: D129.07 100.2,95.12 100.2,92.13 95.87,87.8 79.59,87.8 61.05,106.34 61.05,242.38 79.09,260.41 165.78,260.41 166.76,259.44 166.76,258.27 165.98,257.5 164.98,257.5 164.91,257.43 v1(164.91,257.03)
  L28_SIGNAL w0.071: v1(164.91,257.03) 164.91,257.43 164.98,257.5 165.85,257.5 168.5,254.86 225.74,254.86 225.81,254.79 v1(225.81,254.39)
D12908: length 385
  TOP w0.086: SITE1.134 237.68,252.83 237.6,252.91 237.13,252.91 230.96,259.08 226.27,259.08 v1(225.81,258.63)
  L07_SIGNAL w0.071: v1(198.18,257.03) 198.18,257.43 198.11,257.5 197.29,257.5 196.8,257.01 196.8,255.76 194.26,253.22 186.41,253.22 185.86,253.77 185.86,261.79 185.01,262.64 183.88,262.64 183.05,261.81 183.05,254.62 181.65,253.22 172.19,253.22 167.99,249.02 126.49,249.02 123.05,245.57 77.13,245.57 74.93,243.37 74.93,216.98 76.21,215.7 83.47,215.7 86.72,212.45 86.72,203.36 83.9,200.54 74.02,200.54 70.74,197.27 70.74,114.57 77.8,107.52 97.18,107.52 101.52,103.17 101.52,101.37 102.14,100.75 102.45,100.75 D129.08
  L28_SIGNAL w0.071: v1(198.18,257.03) 198.18,257.43 198.26,257.5 199.31,257.5 202.59,260.78 218.29,260.78 219.97,259.1 225.74,259.1 225.81,259.03 v1(225.81,258.63)
D12909: length 385
  TOP w0.086: SITE1.140 237.68,250.43 237.6,250.35 233.96,250.35 232.03,252.28 229.02,252.28 v1(228.57,252.73)
  L07_SIGNAL w0.071: D129.09 108.36,94.84 108.36,94.74 108.36,89.6 110.26,87.71 130.97,87.71 134.98,91.72 134.98,105.11 124.77,115.31 88.47,115.31 84.97,118.81 84.97,186.24 92.2,193.47 104.91,193.47 106.13,194.69 106.13,198.92 110.08,202.87 110.08,226.77 111.77,228.46 116.21,228.46 117.79,230.04 117.79,236.53 118.37,237.12 129.11,237.12 131.73,239.74 177.93,239.74 180,241.81 180,243.56 179.58,243.98 178.57,243.98 178.5,244.05 v1(178.5,244.46)
  L30_SIGNAL w0.071: v1(178.5,244.46) 178.5,244.05 178.57,243.98 179.71,243.98 180.07,244.35 180.07,249.12 184.12,253.16 210.41,253.16 211.3,252.26 228.49,252.26 228.57,252.33 v1(228.57,252.73)
D12910: length 385
  TOP w0.086: v1(237.56,265.42) 237.11,264.97 237.11,263.7 242.55,258.26 242.55,257.86 242.63,257.78 SITE1.131
  L07_SIGNAL w0.071: D129.10 111.69,101.53 111.69,105.79 107.68,109.79 79.79,109.79 72.01,117.57 72.01,193.44 76.72,198.15 88.8,198.15 95.42,204.76 95.42,209.02 80.36,224.07 80.36,235.91 89.14,244.69 99.98,244.69 100.82,243.86 132.67,243.86 135.8,246.98 167.83,246.98 170.08,249.24 202.29,249.24 210.75,257.7 211.66,257.7 211.77,257.81 v1(211.77,258.17)
  L32_SIGNAL w0.071: v1(237.56,265.42) 237.16,265.42 237.09,265.35 237.09,259.82 235.89,258.62 228.7,258.62 225.58,261.74 212.93,261.74 210.82,259.63 210.82,258.01 211.14,257.7 211.7,257.7 211.77,257.77 v1(211.77,258.17)
D12911: length 385
  TOP w0.086: SITE1.141 237.68,250.03 237.6,250.11 233.86,250.11 231.93,252.04 229.02,252.04 v1(228.57,251.59)
  L07_SIGNAL w0.071: D129.11 110.51,95.27 109.9,95.27 108.56,93.93 108.56,89.69 110.34,87.91 130.89,87.91 134.78,91.8 134.78,105.03 124.69,115.11 88.39,115.11 84.77,118.73 84.77,186.32 92.12,193.67 104.82,193.67 105.93,194.78 105.93,199 109.89,202.96 109.89,226.85 111.69,228.66 116.12,228.66 117.59,230.12 117.59,236.61 118.29,237.31 129.02,237.31 131.64,239.93 177.84,239.93 179.8,241.89 179.8,243.48 179.5,243.78 178.57,243.78 178.5,243.71 v1(178.5,243.31)
  L30_SIGNAL w0.071: v1(178.5,243.31) 178.5,243.71 178.57,243.78 179.79,243.78 180.27,244.27 180.27,249.04 184.2,252.96 210.32,252.96 211.22,252.06 228.49,252.06 228.57,251.99 v1(228.57,251.59)
D12912: length 385
  TOP w0.086: SITE1.132 242.23,257.78 242.31,257.86 242.31,258.16 236.87,263.6 236.87,264.97 v1(236.42,265.42)
  L07_SIGNAL w0.071: v1(211.77,257.03) 211.77,257.43 211.7,257.5 210.83,257.5 202.37,249.04 170.16,249.04 167.91,246.79 135.88,246.79 132.75,243.66 100.74,243.66 99.9,244.49 89.23,244.49 80.56,235.83 80.56,224.16 95.61,209.1 95.61,204.68 88.88,197.95 76.8,197.95 72.21,193.36 72.21,117.65 79.87,109.99 107.77,109.99 111.89,105.87 111.89,101.47 D129.12
  L32_SIGNAL w0.071: v1(211.77,257.03) 211.77,257.43 211.7,257.5 211.06,257.5 210.62,257.93 210.62,259.72 212.85,261.94 225.66,261.94 228.78,258.82 235.81,258.82 236.89,259.9 236.89,265.35 236.82,265.42 v1(236.42,265.42)
D12913: length 385
  TOP w0.086: SITE1.142 237.68,249.63 237.6,249.55 233.04,249.55 232.4,250.19 226.27,250.19 v1(225.81,250.64)
  L07_SIGNAL w0.071: v1(164.91,244.46) 164.91,244.05 164.98,243.98 165.67,243.98 166.03,243.62 166.03,242.36 164.96,241.29 131.46,241.29 130.71,242.04 108.33,242.04 105.81,239.52 105.81,230.66 106.62,229.85 106.62,202.76 105.18,201.32 95.26,201.32 88.27,194.33 78.07,194.33 75.06,191.32 75.06,120.49 83.09,112.46 122.77,112.46 131.13,104.09 131.13,92.9 127.38,89.15 121.02,89.15 118.64,91.54 118.64,94.72 D129.13
  L28_SIGNAL w0.071: v1(164.91,244.46) 164.91,244.05 164.98,243.98 166.42,243.98 167.67,245.23 174.07,245.23 182.24,253.41 221.45,253.41 224.7,250.16 225.74,250.16 225.81,250.24 v1(225.81,250.64)
D12914: length 385
  TOP w0.086: v1(241.53,263.69) 241.08,263.24 241.08,262.2 244.55,258.72 244.55,257.86 244.63,257.78 SITE1.126
  L05_SIGNAL w0.071: D129.14 120.84,100.52 120.84,104.11 117.37,107.59 76.47,107.59 69.29,114.77 69.29,191.57 86.45,208.72 86.45,244.11 88.94,246.6 88.94,252.02 91.28,254.36 191.21,254.36 194.55,257.7 195.19,257.7 195.26,257.77 v1(195.26,258.17)
  L32_SIGNAL w0.071: v1(195.26,258.17) 195.26,257.77 195.19,257.7 194.85,257.7 194.09,256.95 194.09,255.42 196.84,252.67 211.35,252.67 215.45,256.78 225.92,256.78 227.63,255.06 235.4,255.06 241.06,260.72 241.06,263.62 241.13,263.69 v1(241.53,263.69)
D12915: length 385
  TOP w0.086: v1(225.81,249.49) 226.27,249.95 232.3,249.95 232.94,249.31 237.6,249.31 237.68,249.23 SITE1.143
  L07_SIGNAL w0.071: D129.15 120.23,94.83 119.42,94.83 118.83,94.24 118.83,91.62 121.1,89.35 127.3,89.35 130.93,92.98 130.93,104.01 122.68,112.26 83.01,112.26 74.86,120.41 74.86,191.4 77.99,194.53 88.19,194.53 95.17,201.52 105.09,201.52 106.42,202.85 106.42,229.77 105.61,230.58 105.61,239.61 108.25,242.24 130.79,242.24 131.54,241.49 164.88,241.49 165.84,242.45 165.84,243.54 165.59,243.78 165.01,243.78 164.91,243.68 v1(164.91,243.31)
  L28_SIGNAL w0.071: v1(164.91,243.31) 164.91,243.71 164.98,243.78 166.5,243.78 167.75,245.04 174.15,245.04 182.33,253.21 221.37,253.21 224.62,249.97 225.74,249.97 225.81,249.9 v1(225.81,249.49)
D12916: length 385
  TOP w0.086: v1(240.39,263.69) 240.84,263.24 240.84,262.1 244.31,258.63 244.31,257.86 244.23,257.78 SITE1.127
  L05_SIGNAL w0.071: D129.16 122.91,100.61 122.04,100.61 121.04,101.61 121.04,104.19 117.45,107.78 76.55,107.78 69.49,114.85 69.49,191.49 86.65,208.64 86.65,244.03 89.13,246.52 89.13,251.94 91.36,254.17 191.3,254.17 194.63,257.5 195.19,257.5 195.26,257.43 v1(195.26,257.03)
  L32_SIGNAL w0.071: v1(240.39,263.69) 240.79,263.69 240.86,263.62 240.86,260.81 235.31,255.26 227.71,255.26 226,256.97 215.37,256.97 211.27,252.87 196.92,252.87 194.29,255.5 194.29,256.86 194.93,257.5 195.19,257.5 195.26,257.43 v1(195.26,257.03)
D13101: length 353.4
  TOP w0.086: SITE1.16 248.23,231.48 248.15,231.4 248.15,223.49 249.52,222.12 249.52,219.77 v1(249.98,219.32)
  L03_SIGNAL w0.071: D131.01 87.76,54.48 88.67,54.48 88.97,54.18 88.97,51.95 87.72,50.7 84.51,50.7 79.98,55.22 79.98,184.96 96.07,201.04 144.96,201.04 160.27,216.35 164.84,216.35 164.91,216.28 v1(164.91,215.88)
  L28_SIGNAL w0.071: v1(164.91,215.88) 164.91,216.28 164.98,216.35 166.7,216.35 171.92,221.58 221.97,221.58 225.63,217.92 225.63,216.39 226.52,215.51 247.75,215.51 249.5,217.26 249.5,219.24 249.57,219.32 v1(249.98,219.32)
D13102: length 353.4
  TOP w0.086: SITE1.14 247.43,231.48 247.35,231.4 247.35,222.51 v1(247.8,222.06)
  L03_SIGNAL w0.071: v1(178.5,215.88) 178.5,216.28 178.57,216.35 179.23,216.35 179.84,215.74 179.84,214.75 177.71,212.62 159.73,212.62 146.15,199.04 121.54,199.04 116.2,193.7 93.31,193.7 86.27,186.67 86.27,167.41 85.8,166.94 85.16,166.94 84.63,167.48 84.63,177.18 83.99,177.82 82.9,177.82 82.27,177.19 82.27,73.31 91.32,64.25 91.32,60.84 D131.02
  L30_SIGNAL w0.071: v1(247.8,222.06) 247.4,222.06 247.33,221.99 247.33,218.29 246.84,217.8 226.17,217.8 224.15,219.82 182.11,219.82 180.27,217.98 180.27,217.07 179.56,216.35 178.57,216.35 178.5,216.28 v1(178.5,215.88)
D13103: length 353.4
  TOP w0.086: v1(248.83,219.32) 249.28,219.77 249.28,222.02 247.91,223.39 247.91,231.4 247.83,231.48 SITE1.15
  L03_SIGNAL w0.071: v1(164.91,217.02) 164.91,216.62 164.84,216.55 160.18,216.55 144.87,201.24 95.99,201.24 79.78,185.04 79.78,55.14 84.43,50.5 87.8,50.5 89.17,51.86 89.17,53.61 D131.03
  L28_SIGNAL w0.071: v1(248.83,219.32) 249.23,219.32 249.3,219.24 249.3,217.35 247.67,215.71 226.6,215.71 225.83,216.48 225.83,218.01 222.06,221.78 171.84,221.78 166.61,216.55 164.98,216.55 164.91,216.62 v1(164.91,217.02)
D13104: length 353.4
  TOP w0.086: v1(246.66,222.06) 247.11,222.51 247.11,231.4 247.03,231.48 SITE1.13
  L03_SIGNAL w0.071: v1(178.5,217.02) 178.5,216.62 178.57,216.55 179.31,216.55 180.04,215.82 180.04,214.67 177.79,212.42 159.81,212.42 146.24,198.85 121.62,198.85 116.28,193.51 93.39,193.51 86.47,186.58 86.47,167.33 85.89,166.74 85.08,166.74 84.43,167.39 84.43,177.1 83.91,177.62 82.98,177.62 82.46,177.1 82.46,73.39 91.52,64.33 91.52,60.88 D131.04
  L30_SIGNAL w0.071: v1(178.5,217.02) 178.5,216.62 178.57,216.55 179.48,216.55 180.08,217.15 180.08,218.07 182.03,220.02 224.23,220.02 226.26,217.99 246.75,217.99 247.13,218.37 247.13,221.99 247.06,222.06 v1(246.66,222.06)
D13113: length 439
  TOP w0.086: SITE1.170 237.68,238.43 237.6,238.51 228.05,238.51 v1(227.59,238.06)
  L03_SIGNAL w0.071: v1(198.44,243.31) 198.44,243.71 198.37,243.78 197.51,243.78 196.91,243.18 196.91,241.63 194.74,239.46 145.74,239.46 144.99,238.7 144.99,236.52 145.99,235.52 165.96,235.52 168.72,232.75 184.03,232.75 188.03,228.75 188.03,205.1 183.81,200.89 157.75,200.89 133.66,176.79 133.66,167.69 128.96,162.99 113.77,162.99 105.06,154.28 102.76,154.28 100.37,151.89 100.37,110.67 104.12,106.92 127.5,106.92 133.66,100.76 133.66,52.48 129.58,48.41 120.32,48.41 119.14,49.59 119.14,53.58 D131.13
  L28_SIGNAL w0.071: v1(198.44,243.31) 198.44,243.71 198.51,243.78 199.75,243.78 202.62,240.91 222.71,240.91 225.09,238.53 227.52,238.53 227.59,238.46 v1(227.59,238.06)
D13114: length 353.4
  TOP w0.086: v1(246.02,219.32) 245.57,219.77 245.57,226.86 246.55,227.84 246.55,231.4 246.63,231.48 SITE1.12
  L03_SIGNAL w0.071: D131.14 121.8,60.84 121.8,64.44 131.5,74.15 131.5,100.2 126.41,105.3 101.91,105.3 97.54,109.67 97.54,153.66 100.19,156.31 104.49,156.31 112.65,164.48 127.48,164.48 131.5,168.5 131.5,179.01 157.96,205.47 177.33,205.47 185.4,213.53 185.4,227.17 182.5,230.07 181.75,230.07 181.67,230 v1(181.67,229.6)
  L28_SIGNAL w0.071: v1(246.02,219.32) 245.62,219.32 245.55,219.24 245.55,217.71 244.32,216.48 236.38,216.48 234.85,218.01 227.47,218.01 220.21,225.27 187.44,225.27 182.64,230.07 181.75,230.07 181.67,230 v1(181.67,229.6)
D13115: length 439
  TOP w0.086: v1(227.59,239.2) 228.05,238.75 237.6,238.75 237.68,238.83 SITE1.169
  L03_SIGNAL w0.071: D131.15 120.28,54.24 119.93,54.24 119.34,53.64 119.34,49.67 120.4,48.61 129.5,48.61 133.46,52.56 133.46,100.68 127.41,106.72 104.04,106.72 100.17,110.59 100.17,151.97 102.68,154.48 104.98,154.48 113.69,163.19 128.88,163.19 133.46,167.77 133.46,176.88 157.67,201.09 183.73,201.09 187.83,205.19 187.83,228.67 183.95,232.55 168.64,232.55 165.87,235.32 145.9,235.32 144.79,236.43 144.79,238.79 145.66,239.66 194.66,239.66 196.71,241.71 196.71,243.26 197.43,243.98 198.37,243.98 198.44,244.05 v1(198.44,244.46)
  L28_SIGNAL w0.071: v1(198.44,244.46) 198.44,244.05 198.51,243.98 199.83,243.98 202.71,241.11 222.79,241.11 225.17,238.73 227.52,238.73 227.59,238.8 v1(227.59,239.2)
D13116: length 353.4
  TOP w0.086: v1(244.88,219.32) 245.33,219.77 245.33,226.96 246.31,227.94 246.31,231.4 246.23,231.48 SITE1.11
  L03_SIGNAL w0.071: D131.16 122,60.88 122,64.36 131.7,74.06 131.7,100.29 126.49,105.5 101.99,105.5 97.73,109.75 97.73,153.58 100.27,156.11 104.57,156.11 112.74,164.28 127.57,164.28 131.7,168.42 131.7,178.93 158.04,205.27 177.42,205.27 185.6,213.45 185.6,227.26 182.58,230.27 181.75,230.27 181.67,230.34 v1(181.67,230.74)
  L28_SIGNAL w0.071: v1(244.88,219.32) 245.28,219.32 245.35,219.24 245.35,217.8 244.23,216.68 236.46,216.68 234.93,218.21 227.56,218.21 220.3,225.47 187.52,225.47 182.72,230.27 181.75,230.27 181.67,230.34 v1(181.67,230.74)
D13201: length 439
  TOP w0.086: v1(230.98,236.32) 231.43,236.77 232.68,236.77 233.62,237.71 237.6,237.71 237.68,237.63 SITE1.172
  L03_SIGNAL w0.071: D132.01 87.79,34.13 88.33,34.13 89.58,32.88 89.58,31.1 86.59,28.11 73.9,28.11 60.14,41.88 60.14,212.49 92.14,244.5 127.04,244.5 130.35,241.19 181.9,241.19 183.32,242.61 183.32,246.26 180.25,249.33 178.33,249.33 176.64,251.03 176.64,252.99 178.35,254.7 183.22,254.7 194.14,243.78 195.19,243.78 195.26,243.71 v1(195.26,243.31)
  L30_SIGNAL w0.071: v1(195.26,243.31) 195.26,243.71 195.33,243.78 196.41,243.78 196.73,243.46 196.73,242.65 198.47,240.91 209.39,240.91 212.95,237.35 223.14,237.35 223.7,236.79 230.91,236.79 230.98,236.72 v1(230.98,236.32)
D13202: length 439
  TOP w0.086: v1(227.59,234.42) 228.05,234.88 232.6,234.88 234.63,236.91 237.6,236.91 237.68,236.83 SITE1.174
  L03_SIGNAL w0.071: D132.02 90.72,39.92 90.72,42.77 90.16,43.33 84.79,43.33 77.51,36.05 72.62,36.05 69.06,39.61 68.16,39.61 67.69,39.14 67.69,38.62 75.64,30.66 75.64,30.13 75.03,29.52 74.29,29.52 61.16,42.65 61.16,210.56 63.46,212.86 65.09,212.86 89.5,237.26 129.81,237.26 132.66,234.41 165.29,234.41 166.65,233.05 166.65,231.01 165.71,230.07 164.98,230.07 164.91,230 v1(164.91,229.6)
  L32_SIGNAL w0.071: v1(227.59,234.42) 227.59,234.83 227.52,234.9 226.14,234.9 224.29,233.05 224.29,231.78 222.45,229.94 215.27,229.94 212.46,232.75 166.85,232.75 166.02,231.91 166.02,230.33 165.76,230.07 164.98,230.07 164.91,230 v1(164.91,229.6)
D13203: length 439
  TOP w0.086: SITE1.171 237.68,238.03 237.6,237.95 233.52,237.95 232.58,237.01 231.43,237.01 v1(230.98,237.46)
  L03_SIGNAL w0.071: v1(195.26,244.46) 195.26,244.05 195.19,243.98 194.22,243.98 183.3,254.9 178.27,254.9 176.44,253.07 176.44,250.95 178.25,249.14 180.16,249.14 183.13,246.18 183.13,242.69 181.82,241.38 130.43,241.38 127.12,244.69 92.06,244.69 59.94,212.57 59.94,41.79 73.82,27.91 86.67,27.91 89.78,31.02 89.78,33.9 D132.03
  L30_SIGNAL w0.071: v1(230.98,237.46) 230.98,237.06 230.91,236.99 223.78,236.99 223.22,237.55 213.03,237.55 209.47,241.1 198.56,241.1 196.93,242.73 196.93,243.54 196.49,243.98 195.33,243.98 195.26,244.05 v1(195.26,244.46)
D13204: length 439
  TOP w0.086: SITE1.173 237.68,237.23 237.6,237.15 234.53,237.15 232.5,235.12 228.05,235.12 v1(227.59,235.57)
  L03_SIGNAL w0.071: D132.04 92.58,39.5 91.76,39.5 90.92,40.34 90.92,42.85 90.24,43.53 84.71,43.53 77.43,36.25 72.7,36.25 69.14,39.81 68.08,39.81 67.49,39.22 67.49,38.53 75.44,30.58 75.44,30.21 74.95,29.72 74.37,29.72 61.35,42.73 61.35,210.48 63.54,212.66 65.18,212.66 89.58,237.07 129.72,237.07 132.58,234.21 165.21,234.21 166.45,232.97 166.45,231.09 165.63,230.27 164.98,230.27 164.91,230.34 v1(164.91,230.74)
  L32_SIGNAL w0.071: v1(227.59,235.57) 227.59,235.17 227.52,235.1 226.05,235.1 224.09,233.13 224.09,231.86 222.37,230.14 215.35,230.14 212.55,232.94 166.77,232.94 165.82,231.99 165.82,230.41 165.68,230.27 164.98,230.27 164.91,230.34 v1(164.91,230.74)
D13205: length 439
  TOP w0.086: SITE1.176 237.68,236.03 237.6,236.11 236.22,236.11 232.94,232.83 231.43,232.83 v1(230.98,232.38)
  L03_SIGNAL w0.071: D132.05 98.06,34.02 99.06,34.02 99.44,33.64 99.44,28.42 96.7,25.67 74.3,25.67 56.47,43.5 56.47,214.24 88.22,245.98 129.99,245.98 130.7,246.69 179.16,246.69 180.13,245.71 180.13,244.36 180.71,243.78 181.6,243.78 181.67,243.71 v1(181.67,243.31)
  L32_SIGNAL w0.071: v1(181.67,243.31) 181.67,243.71 181.75,243.78 182.33,243.78 182.56,243.55 182.56,242.1 183.82,240.85 208.23,240.85 211.71,237.37 223.48,237.37 224.1,236.75 228.08,236.75 229,235.83 229,233.65 229.79,232.85 230.91,232.85 230.98,232.78 v1(230.98,232.38)
D13206: length 439
  TOP w0.086: SITE1.2 242.63,231.48 242.55,231.4 242.55,231.04 241.9,230.39 228.05,230.39 v1(227.59,229.94)
  L03_SIGNAL w0.071: D132.06 101.4,40.44 101.4,43.93 99.18,46.16 84.63,46.16 77.14,53.65 77.14,198.77 87,208.62 129.02,208.62 130.69,210.29 130.69,219.84 135.01,224.16 157.62,224.16 158.72,225.26 158.72,228 157.2,229.52 130.66,229.52 129.92,230.25 129.92,231.68 130.87,232.62 159.26,232.62 164.29,227.59 178.58,227.59 179.92,228.93 179.92,229.53 179.38,230.07 178.57,230.07 178.5,230 v1(178.5,229.6)
  L32_SIGNAL w0.071: v1(227.59,229.94) 227.59,230.34 227.52,230.41 226.49,230.41 222.68,226.6 182.07,226.6 179.96,228.71 179.96,229.63 179.52,230.07 178.57,230.07 178.5,230 v1(178.5,229.6)
D13207: length 439
  TOP w0.086: SITE1.175 237.68,236.43 237.6,236.35 236.12,236.35 232.84,233.07 231.43,233.07 v1(230.98,233.52)
  L03_SIGNAL w0.071: v1(181.67,244.46) 181.67,244.05 181.6,243.98 180.79,243.98 180.33,244.44 180.33,245.79 179.24,246.89 130.61,246.89 129.91,246.18 88.13,246.18 56.27,214.32 56.27,43.42 74.22,25.47 96.78,25.47 99.64,28.33 99.64,33.6 D132.07
  L32_SIGNAL w0.071: v1(181.67,244.46) 181.67,244.05 181.75,243.98 182.42,243.98 182.76,243.64 182.76,242.18 183.9,241.05 208.31,241.05 211.79,237.57 223.56,237.57 224.18,236.95 228.16,236.95 229.2,235.91 229.2,233.73 229.88,233.05 230.91,233.05 230.98,233.12 v1(230.98,233.52)
D13208: length 439
  TOP w0.086: SITE1.1 242.23,231.48 242.31,231.4 242.31,231.14 241.8,230.63 228.05,230.63 v1(227.59,231.08)
  L03_SIGNAL w0.071: v1(178.5,230.74) 178.5,230.34 178.57,230.27 179.47,230.27 180.12,229.61 180.12,228.85 178.66,227.39 164.2,227.39 159.17,232.42 130.95,232.42 130.12,231.6 130.12,230.33 130.74,229.72 157.28,229.72 158.92,228.09 158.92,225.17 157.7,223.96 135.09,223.96 130.89,219.75 130.89,210.21 129.11,208.43 87.08,208.43 77.34,198.68 77.34,53.73 84.72,46.36 99.26,46.36 101.6,44.01 101.6,40.64 D132.08
  L32_SIGNAL w0.071: v1(178.5,230.74) 178.5,230.34 178.57,230.27 179.6,230.27 180.15,229.71 180.15,228.8 182.15,226.8 222.6,226.8 226.41,230.61 227.52,230.61 227.59,230.68 v1(227.59,231.08)
D13209: length 353.4
  TOP w0.086: SITE1.6 244.23,231.48 244.15,231.4 244.15,230.57 239.24,225.66 239.24,222.51 v1(239.69,222.06)
  L03_SIGNAL w0.071: v1(212.03,229.6) 212.03,230 211.95,230.07 210.77,230.07 203.32,222.62 203.32,203.25 183.21,183.14 183.21,175.42 179.35,171.56 168.45,171.56 140.01,143.12 140.01,16.83 133.47,10.29 116.94,10.29 108.48,18.75 108.48,33.76 D132.09
  L30_SIGNAL w0.071: v1(212.03,229.6) 212.03,230 212.1,230.07 213.71,230.07 217.22,226.56 221.32,226.56 228.32,219.55 237.97,219.55 239.22,220.8 239.22,221.99 239.29,222.06 v1(239.69,222.06)
D13210: length 439
  TOP w0.086: SITE1.168 237.68,239.23 237.6,239.31 233.36,239.31 232.18,240.48 231.43,240.48 v1(230.98,240.03)
  L03_SIGNAL w0.071: v1(212.03,243.31) 212.03,243.71 212.1,243.78 213.1,243.78 213.66,244.35 213.66,245.45 213.12,245.99 207.22,245.99 189.34,228.11 189.34,205.35 175.29,191.3 162.02,191.3 129.59,158.87 115.11,158.87 111,154.76 111,113.96 109.59,112.56 107.2,112.56 105.88,113.88 105.88,151.43 104.73,152.58 102.99,152.58 101.92,151.52 101.92,111.78 105.51,108.2 129.24,108.2 135.16,102.28 135.16,50.8 130.83,46.47 113.61,46.47 111.19,44.05 111.19,40.07 D132.10
  L30_SIGNAL w0.071: v1(212.03,243.31) 212.03,243.71 212.1,243.78 213.85,243.78 217.13,240.51 230.91,240.51 230.98,240.43 v1(230.98,240.03)
D13211: length 353.4
  TOP w0.086: SITE1.5 243.83,231.48 243.91,231.4 243.91,230.67 239,225.76 239,222.51 v1(238.55,222.06)
  L03_SIGNAL w0.071: D132.11 110.39,34.19 110.19,34.19 108.68,32.68 108.68,18.83 117.03,10.48 133.39,10.48 139.81,16.91 139.81,143.2 168.37,171.76 179.27,171.76 183.01,175.5 183.01,183.22 203.13,203.34 203.13,222.7 210.69,230.27 211.95,230.27 212.03,230.34 v1(212.03,230.74)
  L30_SIGNAL w0.071: v1(212.03,230.74) 212.03,230.34 212.1,230.27 213.79,230.27 217.31,226.75 221.4,226.75 228.41,219.75 237.89,219.75 239.02,220.88 239.02,221.99 238.95,222.06 v1(238.55,222.06)
D13212: length 439
  TOP w0.086: v1(230.98,241.18) 231.43,240.72 232.28,240.72 233.45,239.55 237.6,239.55 237.68,239.63 SITE1.167
  L03_SIGNAL w0.071: D132.12 112.81,39.59 111.83,39.59 111.39,40.02 111.39,43.96 113.69,46.27 130.91,46.27 135.35,50.71 135.35,102.36 129.32,108.39 105.59,108.39 102.12,111.87 102.12,151.43 103.07,152.38 104.65,152.38 105.68,151.35 105.68,113.79 107.12,112.36 109.67,112.36 111.2,113.88 111.2,154.67 115.19,158.67 129.67,158.67 162.11,191.1 175.37,191.1 189.53,205.27 189.53,228.03 207.3,245.79 213.04,245.79 213.46,245.37 213.46,244.43 213.01,243.98 212.1,243.98 212.03,244.05 v1(212.03,244.46)
  L30_SIGNAL w0.071: v1(212.03,244.46) 212.03,244.05 212.1,243.98 213.93,243.98 217.21,240.7 230.91,240.7 230.98,240.77 v1(230.98,241.18)
D13213: length 353.4
  TOP w0.086: v1(241.88,219.32) 241.42,219.77 241.42,226.55 244.95,230.08 244.95,231.4 245.03,231.48 SITE1.8
  L03_SIGNAL w0.071: v1(198.44,229.6) 198.44,230 198.37,230.07 197.57,230.07 196.67,230.97 196.67,231.87 197.17,232.38 199.74,232.38 200.21,231.91 200.21,210.87 194.08,204.74 194.08,200.57 190.73,197.21 190.73,192.42 172.05,173.75 168.65,173.75 138.5,143.6 138.5,18.85 135.04,15.38 123.31,15.38 118.06,20.63 118.06,34.34 D132.13
  L28_SIGNAL w0.071: v1(198.44,229.6) 198.44,230 198.51,230.07 199.97,230.07 203.69,226.35 221.14,226.35 228.33,219.16 235.35,219.16 236.97,217.54 240.73,217.54 241.4,218.21 241.4,219.24 241.47,219.32 v1(241.88,219.32)
D13214: length 353.4
  TOP w0.086: v1(244.03,222.06) 243.58,222.51 243.58,226.78 245.75,228.95 245.75,231.4 245.83,231.48 SITE1.10
  L03_SIGNAL w0.071: D132.14 121.8,40.52 121.8,42.18 123.4,43.78 127.97,43.78 129.73,42.01 129.73,32.74 126.44,29.45 126.44,22.48 130.48,18.44 133.79,18.44 136.84,21.5 136.84,151.75 165.92,180.83 168.25,180.83 169.49,182.08 169.49,184.11 190.65,205.27 190.65,217.62 196.6,223.58 196.6,229.55 196.09,230.07 195.33,230.07 195.26,230 v1(195.26,229.6)
  L30_SIGNAL w0.071: v1(195.26,229.6) 195.26,230 195.33,230.07 196.45,230.07 196.65,229.86 196.65,228.9 200.38,225.16 221.09,225.16 227.55,218.69 238.71,218.69 240.23,220.21 242.73,220.21 243.56,221.03 243.56,221.99 243.63,222.06 v1(244.03,222.06)
D13215: length 353.4
  TOP w0.086: v1(240.73,219.32) 241.18,219.77 241.18,226.65 244.71,230.18 244.71,231.4 244.63,231.48 SITE1.7
  L03_SIGNAL w0.071: v1(198.44,230.74) 198.44,230.34 198.37,230.27 197.65,230.27 196.87,231.05 196.87,231.79 197.25,232.18 199.66,232.18 200.01,231.83 200.01,210.96 193.88,204.83 193.88,200.65 190.53,197.29 190.53,192.5 171.97,173.94 168.57,173.94 138.3,143.68 138.3,18.93 134.96,15.58 123.39,15.58 118.26,20.72 118.26,33.57 119.04,34.35 120.71,34.35 D132.15
  L28_SIGNAL w0.071: v1(240.73,219.32) 241.13,219.32 241.2,219.24 241.2,218.29 240.65,217.74 237.05,217.74 235.43,219.36 228.41,219.36 221.22,226.55 203.78,226.55 200.06,230.27 198.51,230.27 198.44,230.34 v1(198.44,230.74)
D13216: length 353.4
  TOP w0.086: v1(242.89,222.06) 243.34,222.51 243.34,226.88 245.51,229.05 245.51,231.4 245.43,231.48 SITE1.9
  L03_SIGNAL w0.071: v1(195.26,230.74) 195.26,230.34 195.33,230.27 196.17,230.27 196.8,229.63 196.8,223.49 190.85,217.54 190.85,205.19 169.69,184.03 169.69,181.99 168.33,180.63 166,180.63 137.04,151.67 137.04,21.42 133.87,18.25 130.4,18.25 126.24,22.4 126.24,29.53 129.54,32.83 129.54,41.93 127.88,43.58 123.48,43.58 122,42.1 122,40.56 D132.16
  L30_SIGNAL w0.071: v1(242.89,222.06) 243.29,222.06 243.36,221.99 243.36,221.12 242.65,220.4 240.14,220.4 238.63,218.89 227.64,218.89 221.17,225.36 200.47,225.36 196.85,228.98 196.85,229.95 196.53,230.27 195.33,230.27 195.26,230.34 v1(195.26,230.74)
D30102: length 192.4
  TOP w0.147: D301.02 312.01,91.03 arc(312.17,91.27) 312.23,91.55 312.23,121.52 arc(312.18,121.76) 312.04,121.97 arc(311.63,122.25) 311.14,122.34 arc(310.63,122.24) 310.2,121.95 arc(310.05,121.72) 309.99,121.45 309.99,97.48 arc(309.9,97.01) 309.63,96.61 arc(309.04,96.22) 308.34,96.08 arc(307.63,96.22) 307.03,96.62 307.03,96.62 arc(306.75,97.03) 306.66,97.52 306.66,125.17 arc(306.74,125.57) 306.96,125.91 307.69,126.63 arc(308.03,126.86) 308.43,126.94 328.08,126.94 arc(328.21,126.97) 328.32,127.04 333.1,131.82 arc(333.18,131.93) 333.2,132.06 333.2,142.3 arc(333.18,142.43) 333.1,142.54 331.36,144.29 arc(331.25,144.36) 331.11,144.39 317.99,144.39 arc(317.71,144.44) 317.47,144.6 316.41,145.66 arc(316.25,145.9) 316.2,146.19 316.2,150.19 arc(316.25,150.47) 316.41,150.71 317.76,152.05 arc(317.99,152.21) 318.28,152.27 329.95,152.27 arc(330.08,152.3) 330.19,152.37 332.13,154.31 arc(332.21,154.42) 332.23,154.55 332.23,171.32 332.23,171.33 SITE4.26
D30104: length 192.4
  TOP w0.147: D301.04 312.84,91.02 arc(312.68,91.26) 312.62,91.54 312.62,121.52 arc(312.55,121.92) 312.32,122.25 arc(311.78,122.61) 311.14,122.74 arc(310.48,122.61) 309.92,122.23 arc(309.68,121.88) 309.6,121.45 309.6,97.48 arc(309.53,97.16) 309.35,96.89 arc(308.89,96.58) 308.34,96.47 arc(307.78,96.59) 307.31,96.9 307.31,96.9 arc(307.12,97.18) 307.05,97.52 307.05,125.17 arc(307.1,125.42) 307.24,125.63 307.97,126.35 arc(308.18,126.49) 308.43,126.54 328.08,126.54 arc(328.36,126.6) 328.6,126.76 333.38,131.54 arc(333.54,131.78) 333.6,132.06 333.6,142.3 arc(333.54,142.58) 333.38,142.82 331.64,144.57 arc(331.4,144.73) 331.11,144.79 317.99,144.79 arc(317.86,144.81) 317.75,144.88 316.69,145.94 arc(316.62,146.06) 316.59,146.19 316.59,150.19 arc(316.62,150.32) 316.69,150.43 318.04,151.77 arc(318.15,151.85) 318.28,151.87 329.95,151.87 arc(330.23,151.93) 330.47,152.09 332.41,154.03 arc(332.57,154.27) 332.63,154.55 332.63,171.32 332.63,171.33 SITE4.27
D30106: length 192.4
  TOP w0.147: D301.06 322.18,91.04 arc(322.34,91.28) 322.4,91.57 322.4,95.07 arc(322.32,95.49) 322.08,95.84 arc(321.73,96.07) 321.32,96.15 316.66,96.15 arc(316.17,96.25) 315.76,96.53 315.75,96.53 arc(315.24,97.31) 315.05,98.22 arc(315.23,99.12) 315.74,99.88 arc(316.14,100.15) 316.62,100.24 321.27,100.24 arc(321.4,100.27) 321.51,100.34 322.3,101.13 arc(322.37,101.24) 322.4,101.37 322.4,122.89 arc(322.46,123.17) 322.62,123.41 323.15,123.95 arc(323.39,124.11) 323.67,124.16 324.64,124.16 arc(324.92,124.11) 325.16,123.95 325.83,123.28 arc(325.99,123.04) 326.05,122.75 326.05,95.92 arc(326.1,95.64) 326.26,95.41 arc(326.69,95.11) 327.21,95.01 327.43,95.01 arc(327.96,95.12) 328.4,95.41 arc(328.56,95.65) 328.61,95.93 328.61,123.08 arc(328.67,123.36) 328.83,123.6 335.73,130.5 arc(335.8,130.61) 335.83,130.74 335.83,145.03 arc(335.8,145.16) 335.73,145.27 334.69,146.31 arc(334.58,146.38) 334.45,146.41 319.65,146.41 arc(319.37,146.46) 319.13,146.62 318.65,147.11 arc(318.49,147.35) 318.43,147.63 318.43,148.81 arc(318.49,149.09) 318.65,149.33 318.99,149.67 arc(319.23,149.83) 319.51,149.89 330.73,149.89 arc(330.86,149.91) 330.97,149.99 334.49,153.51 arc(334.56,153.62) 334.59,153.75 334.59,165.93 arc(334.56,166.06) 334.49,166.17 333.65,167.01 arc(333.49,167.25) 333.43,167.53 333.43,171.32 333.43,171.33 SITE4.29
D30108: length 192.4
  TOP w0.147: SITE4.30 333.83,171.33 333.83,171.32 333.83,167.53 arc(333.85,167.4) 333.93,167.29 334.77,166.45 arc(334.93,166.21) 334.99,165.93 334.99,153.75 arc(334.93,153.47) 334.77,153.23 331.25,149.7 arc(331.01,149.55) 330.73,149.49 319.51,149.49 arc(319.38,149.46) 319.27,149.39 318.93,149.05 arc(318.85,148.94) 318.83,148.81 318.83,147.63 arc(318.85,147.5) 318.93,147.39 319.41,146.9 arc(319.52,146.83) 319.65,146.8 334.45,146.8 arc(334.73,146.75) 334.97,146.59 336.01,145.55 arc(336.17,145.31) 336.22,145.03 336.22,130.74 arc(336.17,130.46) 336.01,130.22 329.11,123.32 arc(329.04,123.21) 329.01,123.08 329.01,95.93 arc(328.92,95.5) 328.68,95.13 arc(328.11,94.75) 327.44,94.61 327.21,94.61 arc(326.54,94.75) 325.98,95.13 arc(325.73,95.49) 325.65,95.92 325.65,122.75 arc(325.62,122.88) 325.55,123 324.88,123.67 arc(324.77,123.74) 324.64,123.77 323.67,123.77 arc(323.54,123.74) 323.43,123.67 322.9,123.13 arc(322.82,123.02) 322.8,122.89 322.8,101.37 arc(322.74,101.09) 322.58,100.85 321.79,100.06 arc(321.55,99.9) 321.27,99.85 316.62,99.85 arc(316.3,99.78) 316.02,99.6 arc(315.6,98.97) 315.45,98.22 arc(315.6,97.46) 316.03,96.81 316.04,96.81 arc(316.32,96.62) 316.66,96.55 321.32,96.55 arc(321.88,96.44) 322.36,96.12 arc(322.68,95.64) 322.8,95.07 322.8,91.53 arc(322.85,91.25) 323.01,91.01 D301.08
D30110: length 192.4
  TOP w0.147: SITE4.32 334.63,171.33 334.63,171.32 334.63,169.65 arc(334.69,169.37) 334.85,169.13 338.31,165.66 arc(338.39,165.55) 338.41,165.42 338.41,161.32 arc(338.45,161.12) 338.57,160.94 343.71,155.8 arc(343.95,155.64) 344.23,155.58 352.97,155.58 arc(353.1,155.56) 353.21,155.48 353.54,155.16 arc(353.61,155.04) 353.64,154.91 353.64,154.22 arc(353.62,154.12) 353.56,154.03 353.28,153.75 arc(353.17,153.68) 353.04,153.65 339.37,153.65 arc(339.09,153.6) 338.85,153.44 338.47,153.06 arc(338.31,152.81) 338.25,152.52 338.25,151.88 arc(338.31,151.59) 338.47,151.34 338.84,150.97 arc(339.08,150.81) 339.36,150.76 346.77,150.76 arc(347.04,150.7) 347.27,150.55 347.27,150.55 arc(347.52,150.17) 347.61,149.73 arc(347.52,149.29) 347.28,148.92 347.23,148.87 arc(347,148.72) 346.73,148.67 340.97,148.67 arc(340.69,148.61) 340.45,148.45 338.39,146.4 arc(338.23,146.16) 338.18,145.87 338.18,95.57 arc(338.12,95.28) 337.95,95.03 arc(337.43,94.68) 336.81,94.56 arc(336.26,94.67) 335.8,94.98 arc(335.67,95.17) 335.62,95.4 335.62,123.36 arc(335.54,123.76) 335.32,124.1 335.31,124.1 arc(334.75,124.48) 334.09,124.61 arc(333.41,124.48) 332.84,124.09 arc(332.6,123.73) 332.52,123.31 332.52,91.52 arc(332.46,91.24) 332.3,91 D301.10
D30112: length 192.4
  TOP w0.147: SITE4.33 335.03,171.33 335.03,171.32 335.03,169.65 arc(335.05,169.52) 335.13,169.41 338.59,165.94 arc(338.75,165.71) 338.81,165.42 338.81,161.32 arc(338.82,161.27) 338.85,161.22 343.99,156.08 arc(344.1,156) 344.23,155.98 352.97,155.98 arc(353.25,155.92) 353.49,155.76 353.82,155.44 arc(353.98,155.2) 354.04,154.91 354.04,154.22 arc(353.99,153.97) 353.84,153.75 353.7,153.61 353.56,153.47 arc(353.32,153.31) 353.04,153.26 339.37,153.26 arc(339.24,153.23) 339.13,153.16 338.76,152.78 arc(338.67,152.66) 338.65,152.52 338.65,151.88 arc(338.67,151.74) 338.76,151.62 339.12,151.25 arc(339.23,151.18) 339.36,151.15 346.77,151.15 arc(347.2,151.07) 347.55,150.83 arc(347.89,150.33) 348.01,149.73 arc(347.89,149.14) 347.56,148.64 347.51,148.59 arc(347.15,148.35) 346.73,148.27 340.97,148.27 arc(340.84,148.24) 340.73,148.17 338.67,146.11 arc(338.6,146) 338.57,145.87 338.57,95.57 arc(338.49,95.13) 338.23,94.75 arc(337.58,94.31) 336.81,94.16 arc(336.11,94.3) 335.52,94.7 arc(335.3,95.02) 335.23,95.4 335.23,123.36 arc(335.18,123.61) 335.03,123.82 arc(334.6,124.11) 334.09,124.21 arc(333.57,124.11) 333.12,123.81 arc(332.97,123.58) 332.91,123.31 332.91,91.57 arc(332.97,91.29) 333.13,91.05 D301.12
D30114: length 192.4
  TOP w0.147: D301.14 342.47,91.01 arc(342.63,91.25) 342.69,91.53 342.69,123.33 arc(342.77,123.77) 343.03,124.15 arc(343.62,124.54) 344.32,124.68 344.49,124.68 arc(345.18,124.55) 345.77,124.15 345.77,124.15 arc(346.02,123.79) 346.1,123.35 346.1,94.29 arc(346.13,94.16) 346.2,94.05 346.55,93.71 arc(346.99,93.41) 347.5,93.31 arc(348.02,93.41) 348.46,93.71 348.75,93.99 348.75,94 arc(348.83,94.11) 348.85,94.24 348.85,126.09 arc(348.79,126.41) 348.61,126.68 348.61,126.68 arc(348.34,126.86) 348.02,126.92 342.13,126.92 arc(341.62,127.02) 341.19,127.31 341.19,127.31 arc(340.91,127.74) 340.81,128.25 340.81,141.92 arc(340.86,142.2) 341.02,142.44 341.88,143.3 arc(342.12,143.46) 342.4,143.52 348.48,143.52 arc(348.61,143.55) 348.72,143.62 357.43,152.33 arc(357.67,152.49) 357.95,152.54 360.91,152.54 arc(361.04,152.57) 361.15,152.64 361.66,153.15 arc(361.73,153.27) 361.76,153.4 361.76,156.72 arc(361.73,156.85) 361.66,156.96 360.89,157.73 arc(360.78,157.8) 360.65,157.83 346.49,157.83 arc(346.21,157.89) 345.97,158.05 341.02,162.99 arc(340.86,163.23) 340.81,163.51 340.81,165.84 arc(340.78,165.97) 340.71,166.08 335.83,170.95 335.83,171.32 335.83,171.33 SITE4.35
D30116: length 192.4
  TOP w0.147: D301.16 343.3,91.04 arc(343.14,91.28) 343.08,91.56 343.08,123.33 arc(343.14,123.62) 343.31,123.87 343.31,123.87 arc(343.77,124.18) 344.32,124.29 344.49,124.29 arc(345.03,124.18) 345.49,123.87 345.49,123.87 arc(345.65,123.63) 345.71,123.35 345.71,94.29 arc(345.76,94.01) 345.92,93.77 346.27,93.43 arc(346.83,93.05) 347.5,92.91 arc(348.17,93.05) 348.74,93.43 349.03,93.71 arc(349.19,93.95) 349.25,94.24 349.25,126.09 arc(349.15,126.56) 348.89,126.96 arc(348.49,127.23) 348.02,127.32 342.13,127.32 arc(341.77,127.39) 341.47,127.59 341.47,127.59 arc(341.27,127.89) 341.2,128.25 341.2,141.92 arc(341.23,142.05) 341.3,142.16 342.16,143.02 arc(342.27,143.1) 342.4,143.12 348.48,143.12 arc(348.77,143.18) 349.01,143.34 357.71,152.05 arc(357.82,152.12) 357.95,152.15 360.91,152.15 arc(361.19,152.2) 361.43,152.36 361.94,152.87 arc(362.1,153.11) 362.15,153.4 362.15,156.72 arc(362.1,157) 361.94,157.24 361.17,158.01 arc(360.93,158.17) 360.65,158.23 346.49,158.23 arc(346.36,158.25) 346.25,158.33 341.3,163.27 arc(341.23,163.38) 341.2,163.51 341.2,165.84 arc(341.15,166.12) 340.99,166.36 336.23,171.12 336.23,171.32 336.23,171.33 SITE4.36
