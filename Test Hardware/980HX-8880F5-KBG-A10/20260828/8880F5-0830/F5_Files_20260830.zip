# Allegro board 8880F5-0830.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D11611: length 385
  TOP w0.086: SITE2.90 339.03,257.78 339.11,257.86 339.11,258.53 341.64,261.07 343.85,261.07 345.07,262.28 345.07,265.17 345.63,265.73 345.63,268.15 v1(345.18,268.6)
  L07_SIGNAL w0.071: v1(376.45,254.32) 376.05,254.32 375.97,254.39 375.97,255.34 381.78,261.14 394.01,261.14 397.83,264.97 397.83,273.2 406.22,281.59 406.22,291.44 377.86,319.8 377.86,412.56 372.29,418.14 353.37,418.14 348.99,422.52 299.7,422.52 293.63,416.45 293.63,410.2 304.42,399.41 321.68,399.41 323.94,397.15 323.94,395.06 D116.11
  L28_SIGNAL w0.071: v1(376.45,254.32) 376.05,254.32 375.97,254.39 375.97,255.83 372.42,259.38 364.55,259.38 352.31,271.62 347.15,271.62 345.65,270.13 345.65,268.68 345.58,268.6 v1(345.18,268.6)
D11612: length 385
  TOP w0.086: SITE2.136 317.68,252.03 317.6,252.11 316.43,252.11 311.58,256.96 309.02,256.96 v1(308.57,256.51)
  L07_SIGNAL w0.071: v1(390.16,251.9) 389.76,251.9 389.69,251.83 389.69,250.92 388.81,250.03 374.4,250.03 370.73,253.7 370.73,298.78 368.87,300.65 368.87,399.2 367.07,401 356.15,401 355.64,400.48 355.64,399.64 356.12,399.16 367,399.16 367.55,398.61 367.55,397.9 367.14,397.49 356.43,397.49 355.91,396.97 355.91,396.11 356.4,395.63 366.64,395.63 367.72,394.55 367.72,389.05 362.48,383.81 323.87,383.81 321.67,386.01 321.67,389.53 D116.12
  L30_SIGNAL w0.071: v1(390.16,251.9) 389.76,251.9 389.69,251.83 389.69,250.44 385.46,246.21 357.39,246.21 355.29,248.32 349.41,248.32 340.75,256.98 308.64,256.98 308.57,256.91 v1(308.57,256.51)
D11613: length 385
  TOP w0.086: SITE2.102 334.23,257.78 334.15,257.86 334.15,261.95 335.98,263.78 335.98,268.13 334.78,269.33 v1(334.78,269.97)
  L07_SIGNAL w0.071: D116.13 316.05,395.15 314.94,395.15 314.3,395.79 314.3,397.02 312.87,398.45 301.37,398.45 292.8,407.02 292.8,418.4 297.76,423.37 349.52,423.37 353.63,419.26 374.08,419.26 379.36,413.98 379.36,326.33 407.89,297.8 407.89,276.54 402.95,271.6 402.95,270.39 402.88,270.32 v1(402.48,270.32)
  L32_SIGNAL w0.071: v1(402.48,270.32) 402.88,270.32 402.95,270.39 402.95,270.83 402.68,271.1 401.32,271.1 400.69,271.73 400.69,272.61 398.47,274.84 335.88,274.84 333.58,272.53 333.58,270.51 334.4,269.69 334.5,269.69 v1(334.78,269.97)
D11615: length 385
  TOP w0.086: v1(333.98,269.17) 334.61,269.17 335.74,268.03 335.74,263.88 333.91,262.05 333.91,257.86 333.83,257.78 SITE2.103
  L07_SIGNAL w0.071: D116.15 314.1,395.38 314.1,396.94 312.79,398.25 301.28,398.25 292.6,406.94 292.6,418.49 297.68,423.56 349.61,423.56 353.71,419.46 374.17,419.46 379.56,414.06 379.56,326.41 408.09,297.88 408.09,276.45 403.15,271.52 403.15,270.39 403.22,270.32 v1(403.63,270.32)
  L32_SIGNAL w0.071: v1(333.98,269.17) 334.26,269.45 334.26,269.55 333.38,270.43 333.38,272.62 335.8,275.04 398.55,275.04 400.89,272.7 400.89,271.81 401.41,271.3 402.77,271.3 403.15,270.91 403.15,270.39 403.22,270.32 v1(403.63,270.32)
D11801: length 385
  TOP w0.086: SITE3.116 248.63,197.78 248.55,197.86 248.55,206.82 246.96,208.41 246.96,210.72 v1(247.41,211.17)
  L05_SIGNAL w0.071: D118.01 162.46,73.76 162.46,73.24 152.12,62.9 152.12,34.52 147.26,29.66 138.43,29.66 135.37,32.71 135.37,164.08 136.76,165.47 148.18,165.47 148.75,166.04 148.75,166.91 148.13,167.53 138.67,167.53 138.23,167.97 138.23,168.47 138.82,169.05 165.67,169.05 170.37,173.76 170.37,186.07 180.08,195.78 180.08,202.48 179.47,203.09 178.57,203.09 178.5,203.16 v1(178.5,203.56)
  L28_SIGNAL w0.071: v1(247.41,211.17) 247.01,211.17 246.94,211.24 246.94,212.03 246.26,212.7 234.8,212.7 232.89,210.79 227.53,210.79 222.99,206.25 181.84,206.25 180.07,204.48 180.07,203.67 179.49,203.09 178.57,203.09 178.5,203.16 v1(178.5,203.56)
D11802: length 385
  TOP w0.086: v1(241.53,203.69) 241.08,203.24 241.08,202.2 244.55,198.73 244.55,197.86 244.63,197.78 SITE3.126
  L05_SIGNAL w0.071: D118.02 164.36,80.54 164.36,82.3 164.13,82.53 157.62,82.53 150.68,75.58 150.68,35.61 146.72,31.66 139.15,31.66 136.77,34.04 136.77,162.23 138.52,163.98 164.44,163.98 164.7,164.25 164.7,164.9 164.33,165.28 151.06,165.28 150.39,165.94 150.39,167.02 150.94,167.56 169.21,167.56 172.31,170.67 172.31,184.51 176.92,189.12 178.43,189.12 178.5,189.19 v1(178.5,189.59)
  L32_SIGNAL w0.071: v1(178.5,189.59) 178.5,189.19 178.43,189.12 178.06,189.12 177.33,188.38 177.33,187.27 178.71,185.89 214.81,185.89 217.71,188.79 222.83,188.79 223.8,187.82 226.43,187.82 228.99,190.38 233.22,190.38 241.06,198.23 241.06,203.62 241.13,203.69 v1(241.53,203.69)
D11803: length 385
  TOP w0.086: v1(246.26,211.17) 246.72,210.72 246.72,208.31 248.31,206.72 248.31,197.86 248.23,197.78 SITE3.117
  L05_SIGNAL w0.071: D118.03 162.66,73.76 162.66,73.16 152.32,62.82 152.32,34.44 147.34,29.46 138.34,29.46 135.17,32.63 135.17,164.16 136.68,165.67 148.1,165.67 148.56,166.12 148.56,166.83 148.05,167.33 138.59,167.33 138.03,167.89 138.03,168.55 138.74,169.25 165.58,169.25 170.17,173.84 170.17,186.15 179.88,195.86 179.88,202.4 179.39,202.89 178.57,202.89 178.5,202.82 v1(178.5,202.42)
  L28_SIGNAL w0.071: v1(178.5,202.42) 178.5,202.82 178.57,202.89 179.57,202.89 180.27,203.59 180.27,204.4 181.92,206.05 223.07,206.05 227.61,210.59 232.97,210.59 234.88,212.51 246.18,212.51 246.74,211.95 246.74,211.24 246.67,211.17 v1(246.26,211.17)
D11804: length 385
  TOP w0.086: v1(240.39,203.69) 240.84,203.24 240.84,202.1 244.31,198.63 244.31,197.86 244.23,197.78 SITE3.127
  L05_SIGNAL w0.071: D118.04 166.21,80.17 164.88,80.17 164.56,80.49 164.56,82.38 164.21,82.73 157.54,82.73 150.48,75.67 150.48,35.69 146.64,31.85 139.24,31.85 136.97,34.13 136.97,162.15 138.61,163.78 164.52,163.78 164.9,164.17 164.9,164.98 164.41,165.48 151.14,165.48 150.59,166.03 150.59,166.94 151.02,167.36 169.29,167.36 172.51,170.59 172.51,184.43 177,188.92 178.43,188.92 178.5,188.85 v1(178.5,188.45)
  L32_SIGNAL w0.071: v1(178.5,188.45) 178.5,188.85 178.43,188.92 178.15,188.92 177.52,188.3 177.52,187.35 178.79,186.08 214.73,186.08 217.63,188.98 222.92,188.98 223.88,188.02 226.34,188.02 228.91,190.58 233.13,190.58 240.86,198.31 240.86,203.62 240.79,203.69 v1(240.39,203.69)
D11805: length 385
  TOP w0.086: SITE3.142 237.68,189.63 237.6,189.55 233.04,189.55 232.4,190.19 226.27,190.19 v1(225.81,190.64)
  L07_SIGNAL w0.071: v1(164.91,162.67) 164.91,162.27 164.98,162.2 165.72,162.2 166.11,161.8 166.11,160.77 165.19,159.85 161.11,159.85 157.86,163.1 157.86,227.83 151.97,233.73 141.44,233.73 136.13,228.41 136.13,82.01 145.76,72.38 172.46,72.38 173.02,72.95 173.02,73.36 D118.05
  L28_SIGNAL w0.071: v1(164.91,162.67) 164.91,162.27 164.98,162.2 166.16,162.2 175.64,171.68 202.38,171.68 211.12,180.42 211.12,183.57 216.53,188.98 222.57,188.98 223.75,190.16 225.74,190.16 225.81,190.24 v1(225.81,190.64)
D11806: length 385
  TOP w0.086: v1(228.57,192.73) 229.02,192.28 232.03,192.28 233.96,190.35 237.6,190.35 237.68,190.43 SITE3.140
  L07_SIGNAL w0.071: D118.06 175.05,81.07 175.05,81.99 174.57,82.46 156.73,82.46 155.62,81.35 141.39,81.35 137.96,84.78 137.96,228.45 141.58,232.07 151.26,232.07 156.61,226.72 156.61,161.98 160.12,158.47 173.4,158.47 177.12,162.2 178.43,162.2 178.5,162.27 v1(178.5,162.67)
  L30_SIGNAL w0.071: v1(228.57,192.73) 228.57,192.33 228.49,192.26 227.45,192.26 226.64,191.45 226.64,184.63 223.1,181.08 216.31,181.08 215.37,180.15 215.37,174.43 213.08,172.14 184.31,172.14 179.93,167.76 179.93,162.51 179.62,162.2 178.57,162.2 178.5,162.27 v1(178.5,162.67)
D11807: length 385
  TOP w0.086: v1(225.81,189.49) 226.27,189.95 232.3,189.95 232.94,189.31 237.6,189.31 237.68,189.23 SITE3.143
  L07_SIGNAL w0.071: v1(164.91,161.52) 164.91,161.93 164.98,162 165.64,162 165.91,161.72 165.91,160.85 165.11,160.05 161.19,160.05 158.06,163.18 158.06,227.92 152.05,233.92 141.36,233.92 135.93,228.5 135.93,81.93 145.68,72.19 172.54,72.19 173.22,72.87 173.22,74.16 D118.07
  L28_SIGNAL w0.071: v1(225.81,189.49) 225.81,189.9 225.74,189.97 223.83,189.97 222.65,188.79 216.62,188.79 211.32,183.49 211.32,180.34 202.46,171.48 175.73,171.48 166.24,162 164.98,162 164.91,161.93 v1(164.91,161.52)
D11808: length 385
  TOP w0.086: SITE3.141 237.68,190.03 237.6,190.11 233.86,190.11 231.93,192.04 229.02,192.04 v1(228.57,191.59)
  L07_SIGNAL w0.071: D118.08 176.09,80.45 175.69,80.45 175.25,80.9 175.25,82.07 174.65,82.66 156.65,82.66 155.54,81.55 141.47,81.55 138.16,84.86 138.16,228.37 141.66,231.87 151.17,231.87 156.41,226.63 156.41,161.9 160.04,158.28 173.48,158.28 177.2,162 178.43,162 178.5,161.93 v1(178.5,161.52)
  L30_SIGNAL w0.071: v1(178.5,161.52) 178.5,161.93 178.57,162 179.7,162 180.13,162.43 180.13,167.67 184.4,171.94 213.16,171.94 215.57,174.35 215.57,180.07 216.39,180.89 223.18,180.89 226.84,184.54 226.84,191.37 227.53,192.06 228.49,192.06 228.57,191.99 v1(228.57,191.59)
D11809: length 385
  TOP w0.086: v1(254.78,209.97) 254.78,209.33 255.98,208.13 255.98,203.78 254.15,201.95 254.15,197.86 254.23,197.78 SITE3.102
  L07_SIGNAL w0.071: D118.09 182.01,74.53 182.01,72.92 182.81,72.12 201.38,72.12 206.32,77.05 206.32,92.47 201.09,97.7 192.78,97.7 191.35,96.26 146.62,96.26 142.03,100.85 142.03,170.35 144.69,173.01 151.29,173.01 153.63,170.68 153.63,159.62 159.66,153.59 176.53,153.59 183.57,160.63 183.57,202.03 182.52,203.09 181.75,203.09 181.67,203.16 v1(181.67,203.56)
  L32_SIGNAL w0.071: v1(181.67,203.56) 181.67,203.16 181.75,203.09 182.07,203.09 182.56,203.58 182.56,205.35 183.27,206.06 218.89,206.06 223.42,210.59 223.42,212.14 224.37,213.09 251,213.09 254.4,209.69 254.5,209.69 v1(254.78,209.97)
D11810: length 385
  TOP w0.086: v1(238.79,209.08) 238.34,208.63 238.34,207.86 239.3,206.9 239.3,202.62 243.35,198.57 243.35,197.86 243.43,197.78 SITE3.129
  L07_SIGNAL w0.071: v1(164.91,189.59) 164.91,189.19 164.84,189.12 163.84,189.12 163.15,188.43 163.15,173.18 165.02,171.31 178.34,171.31 180.1,169.55 180.1,160.82 176.54,157.26 159.87,157.26 155.54,161.59 155.54,177.2 153.09,179.66 143.94,179.66 140.15,175.87 140.15,98.17 144.18,94.15 200.89,94.15 203.75,91.29 203.75,84.02 202.41,82.68 185.85,82.68 184.86,81.69 184.86,80.72 D118.10
  L30_SIGNAL w0.071: v1(238.79,209.08) 238.39,209.08 238.32,209.16 238.32,211.1 236.12,213.29 226.59,213.29 225.68,212.38 225.68,210.27 215.03,199.62 176.85,199.62 166.35,189.12 164.98,189.12 164.91,189.19 v1(164.91,189.59)
D11811: length 385
  TOP w0.086: SITE3.103 253.83,197.78 253.91,197.86 253.91,202.05 255.74,203.88 255.74,208.03 254.61,209.17 v1(253.98,209.17)
  L07_SIGNAL w0.071: D118.11 184.05,74.83 182.82,74.83 182.21,74.22 182.21,73 182.89,72.32 201.3,72.32 206.12,77.14 206.12,92.39 201.01,97.5 192.86,97.5 191.43,96.07 146.54,96.07 141.83,100.77 141.83,170.43 144.61,173.21 151.38,173.21 153.83,170.76 153.83,159.71 159.74,153.79 176.45,153.79 183.37,160.72 183.37,201.95 182.43,202.89 181.75,202.89 181.67,202.82 v1(181.67,202.42)
  L32_SIGNAL w0.071: v1(181.67,202.42) 181.67,202.82 181.75,202.89 182.15,202.89 182.76,203.5 182.76,205.27 183.35,205.86 218.97,205.86 223.62,210.51 223.62,212.06 224.45,212.9 250.91,212.9 254.26,209.55 254.26,209.45 v1(253.98,209.17)
D11812: length 385
  TOP w0.086: v1(237.64,209.08) 238.1,208.63 238.1,207.76 239.06,206.8 239.06,202.52 243.11,198.47 243.11,197.86 243.03,197.78 SITE3.130
  L07_SIGNAL w0.071: v1(164.91,188.45) 164.91,188.85 164.84,188.92 163.92,188.92 163.35,188.35 163.35,173.27 165.11,171.51 178.42,171.51 180.3,169.63 180.3,160.73 176.62,157.06 159.79,157.06 155.35,161.51 155.35,177.12 153.01,179.46 144.03,179.46 140.35,175.79 140.35,98.26 144.26,94.35 200.97,94.35 203.95,91.37 203.95,83.93 202.49,82.48 185.94,82.48 185.06,81.61 185.06,81.17 185.94,80.29 186.41,80.29 D118.12
  L30_SIGNAL w0.071: v1(237.64,209.08) 238.05,209.08 238.12,209.16 238.12,211.02 236.04,213.09 226.68,213.09 225.88,212.3 225.88,210.19 215.11,199.42 176.93,199.42 166.43,188.92 164.98,188.92 164.91,188.85 v1(164.91,188.45)
D11813: length 385
  TOP w0.086: SITE3.114 249.43,197.78 249.35,197.86 249.35,207.66 v1(249.8,208.11)
  L05_SIGNAL w0.071: v1(181.67,189.59) 181.67,189.19 181.75,189.12 182.59,189.12 183.4,188.31 183.4,165.19 182.95,164.74 182.23,164.74 181.64,165.33 181.64,185.92 181.27,186.3 180.51,186.3 180.13,185.92 180.13,168.02 170.54,158.43 143.13,158.43 140.69,155.99 140.69,82.26 142.38,80.57 145.43,80.57 159.84,94.98 201.49,94.98 204.62,91.86 204.62,75 201.83,72.22 193.38,72.22 192.2,73.39 192.2,74.5 D118.13
  L30_SIGNAL w0.071: v1(181.67,189.59) 181.67,189.19 181.75,189.12 182.78,189.12 191.86,198.2 216.17,198.2 228.23,210.26 233.64,210.26 235.92,207.98 246,207.98 247.82,209.79 248.69,209.79 249.33,209.15 249.33,208.18 249.4,208.11 v1(249.8,208.11)
D11814: length 245.7
  L05_SIGNAL w0.071: v1(178.5,176.13) 178.5,175.73 178.43,175.66 177.62,175.66 174.12,172.16 174.12,165.58 168.56,160.02 163.45,160.02 160.86,162.61 140.13,162.61 138.23,160.71 138.23,78.08 140.61,75.69 145.79,75.69 148.18,78.08 148.18,80.81 160.18,92.81 200.64,92.81 202.32,91.13 202.32,83.74 201.26,82.69 196.16,82.69 195.48,82.02 195.48,81.18 D118.14
  L32_SIGNAL w0.071: v1(186.95,176.66) 188.3,176.66 188.37,176.59 188.37,175.52 187.78,174.93 186.19,174.93 184.7,176.43 181.27,176.43 180.5,175.66 178.57,175.66 178.5,175.73 v1(178.5,176.13)
  BOTTOM w0.119: v1(186.95,176.66) UNK3K43.6
D11815: length 385
  TOP w0.086: SITE3.115 249.03,197.78 249.11,197.86 249.11,207.66 v1(248.66,208.11)
  L05_SIGNAL w0.071: v1(181.67,188.45) 181.67,188.85 181.75,188.92 182.51,188.92 183.2,188.23 183.2,165.27 182.87,164.94 182.32,164.94 181.84,165.41 181.84,186 181.35,186.49 180.43,186.49 179.93,186 179.93,168.1 170.46,158.63 143.05,158.63 140.49,156.07 140.49,82.18 142.3,80.37 145.51,80.37 159.92,94.78 201.41,94.78 204.42,91.77 204.42,75.09 201.75,72.42 193.46,72.42 192.4,73.47 192.4,74.22 192.98,74.8 194.18,74.8 D118.15
  L30_SIGNAL w0.071: v1(181.67,188.45) 181.67,188.85 181.75,188.92 182.86,188.92 191.94,198 216.25,198 228.31,210.06 233.56,210.06 235.84,207.78 246.09,207.78 247.9,209.59 248.61,209.59 249.13,209.07 249.13,208.18 249.06,208.11 v1(248.66,208.11)
D11816: length 245.7
  L05_SIGNAL w0.071: D118.16 195.68,81.18 195.68,81.94 196.24,82.49 201.35,82.49 202.51,83.66 202.51,91.21 200.72,93 160.1,93 147.98,80.89 147.98,78.16 145.71,75.89 140.69,75.89 138.42,78.16 138.42,160.62 140.22,162.42 160.78,162.42 163.37,159.83 168.64,159.83 174.32,165.5 174.32,172.08 177.7,175.46 178.43,175.46 178.5,175.39 v1(178.5,174.99)
  L32_SIGNAL w0.071: v1(189.99,176.66) 188.64,176.66 188.57,176.59 188.57,175.44 187.86,174.74 186.11,174.74 184.62,176.23 181.35,176.23 180.59,175.46 178.57,175.46 178.5,175.39 v1(178.5,174.99)
  BOTTOM w0.119: v1(189.99,176.66) UNK3K43.3
D11901: length 353.4
  TOP w0.086: SITE3.8 245.03,171.48 244.95,171.4 244.95,170.08 241.42,166.55 241.42,159.77 v1(241.88,159.32)
  L03_SIGNAL w0.071: v1(164.91,134.6) 164.91,135 164.84,135.07 163.7,135.07 163.02,134.39 163.02,128.89 164.92,126.99 195.03,126.99 197.16,124.86 197.16,99.51 196.27,98.62 181.36,98.62 180.63,99.34 180.63,100.15 181.23,100.75 194.62,100.75 195.95,102.08 195.95,122.78 195.23,123.5 194.66,123.5 193.94,122.79 193.94,107.45 190.79,104.29 172.61,104.29 171.46,105.44 164.2,105.44 155.95,97.18 155.95,51.4 157.8,49.55 161.92,49.55 162.97,50.6 162.97,53.35 161.59,54.73 161.17,54.73 D119.01
  L28_SIGNAL w0.071: v1(164.91,134.6) 164.91,135 164.98,135.07 166.44,135.07 171.08,139.71 171.08,146.05 182.1,157.07 240.59,157.07 241.4,157.88 241.4,159.24 241.47,159.32 v1(241.88,159.32)
D11902: length 353.4
  TOP w0.086: SITE3.6 244.23,171.48 244.15,171.4 244.15,170.57 239.24,165.66 239.24,162.51 v1(239.69,162.06)
  L03_SIGNAL w0.071: v1(178.5,134.6) 178.5,135 178.57,135.07 179.78,135.07 180.31,134.54 180.31,133.76 178.22,131.66 178.22,130.07 178.83,129.46 194.85,129.46 199.32,124.99 199.32,94.59 198,93.28 162.1,93.28 161.56,93.81 161.56,94.46 162.24,95.14 197.12,95.14 197.53,95.55 197.53,96.43 197.06,96.89 162.17,96.89 161.63,97.43 161.63,98.6 162.33,99.29 177.52,99.29 178.35,100.13 178.35,101.01 177.53,101.84 161.81,101.84 157.35,97.38 157.35,63.45 158.68,62.13 164.73,62.13 164.98,61.88 164.98,60.84 D119.02
  L30_SIGNAL w0.071: v1(178.5,134.6) 178.5,135 178.57,135.07 181.1,135.07 183.45,137.41 183.45,142.72 194.58,153.85 202.07,153.85 207.22,159 237.49,159 239.22,160.73 239.22,161.99 239.29,162.06 v1(239.69,162.06)
D11903: length 353.4
  TOP w0.086: v1(240.73,159.32) 241.18,159.77 241.18,166.65 244.71,170.18 244.71,171.4 244.63,171.48 SITE3.7
  L03_SIGNAL w0.071: v1(164.91,135.74) 164.91,135.34 164.84,135.27 163.62,135.27 162.82,134.47 162.82,128.8 164.84,126.79 194.95,126.79 196.96,124.77 196.96,99.59 196.19,98.81 181.44,98.81 180.83,99.43 180.83,100.07 181.31,100.55 194.7,100.55 196.15,102 196.15,122.86 195.31,123.7 194.57,123.7 193.74,122.87 193.74,107.53 190.7,104.49 172.69,104.49 171.54,105.64 164.12,105.64 155.75,97.26 155.75,51.32 157.72,49.35 162,49.35 163.17,50.52 163.17,53.95 D119.03
  L28_SIGNAL w0.071: v1(164.91,135.74) 164.91,135.34 164.98,135.27 166.36,135.27 170.88,139.79 170.88,146.14 182.01,157.27 240.51,157.27 241.2,157.97 241.2,159.24 241.13,159.32 v1(240.73,159.32)
D11904: length 353.4
  TOP w0.086: v1(238.55,162.06) 239,162.51 239,165.76 243.91,170.67 243.91,171.4 243.83,171.48 SITE3.5
  L03_SIGNAL w0.071: v1(178.5,135.74) 178.5,135.34 178.57,135.27 179.86,135.27 180.51,134.63 180.51,133.68 178.42,131.58 178.42,130.16 178.92,129.65 194.93,129.65 199.52,125.07 199.52,94.51 198.08,93.08 162.02,93.08 161.36,93.73 161.36,94.54 162.16,95.34 197.04,95.34 197.33,95.63 197.33,96.35 196.98,96.7 162.09,96.7 161.44,97.35 161.44,98.68 162.25,99.49 177.44,99.49 178.16,100.21 178.16,100.93 177.45,101.64 161.89,101.64 157.55,97.29 157.55,63.54 158.76,62.33 164.82,62.33 165.18,61.96 165.18,60.88 D119.04
  L30_SIGNAL w0.071: v1(178.5,135.74) 178.5,135.34 178.57,135.27 181.02,135.27 183.25,137.5 183.25,142.8 194.49,154.05 201.99,154.05 207.14,159.19 237.41,159.19 239.02,160.81 239.02,161.99 238.95,162.06 v1(238.55,162.06)
D11905: length 385
  TOP w0.086: v1(277.52,187.66) 277.07,188.11 264.06,188.11 263.98,188.03 SITE3.75
  L05_SIGNAL w0.071: D119.05 171.53,54.53 172.33,54.53 173.24,53.63 173.24,52.11 167.72,46.59 161.37,46.59 155.64,40.86 155.64,33.66 148.1,26.12 136.97,26.12 132.45,30.64 132.45,166.28 138.88,172.7 165.52,172.7 166.47,173.65 166.47,174.97 165.79,175.66 164.98,175.66 164.91,175.73 v1(164.91,176.13)
  L32_SIGNAL w0.071: v1(277.52,187.66) 277.52,188.06 277.45,188.13 265.84,188.13 264.1,189.87 235.96,189.87 232.93,186.84 232.93,185.34 231.9,184.31 226.46,184.31 223.32,181.17 213.03,181.17 209.65,184.55 166.39,184.55 163.25,181.42 163.25,176.16 163.75,175.66 164.84,175.66 164.91,175.73 v1(164.91,176.13)
D11906: length 385
  TOP w0.086: SITE3.120 247.03,197.78 246.95,197.86 246.95,204.17 244.91,206.21 244.91,208.63 v1(245.36,209.08)
  L05_SIGNAL w0.071: v1(164.91,203.56) 164.91,203.16 164.84,203.09 163.68,203.09 163.13,202.53 163.13,181.8 168.58,176.35 168.58,173.54 165.67,170.63 138.45,170.63 133.98,166.15 133.98,31.59 137.79,27.78 147.47,27.78 153.68,33.98 153.68,58.11 157.8,62.24 173.95,62.24 175.1,61.09 175.1,60.8 D119.06
  L30_SIGNAL w0.071: v1(164.91,203.56) 164.91,203.16 164.98,203.09 166.34,203.09 169.82,206.56 219.02,206.56 223.38,210.92 223.38,212.39 225.79,214.8 240.78,214.8 244.89,210.69 244.89,209.16 244.96,209.08 v1(245.36,209.08)
D11907: length 385
  TOP w0.086: SITE3.76 263.98,188.43 264.06,188.35 277.07,188.35 v1(277.52,188.8)
  L05_SIGNAL w0.071: D119.07 173.44,54.06 173.44,52.02 167.8,46.39 161.45,46.39 155.84,40.78 155.84,33.57 148.19,25.92 136.89,25.92 132.25,30.56 132.25,166.36 138.8,172.9 165.44,172.9 166.27,173.74 166.27,174.89 165.7,175.46 164.98,175.46 164.91,175.39 v1(164.91,174.99)
  L32_SIGNAL w0.071: v1(164.91,174.99) 164.91,175.39 164.84,175.46 163.66,175.46 163.05,176.07 163.05,181.5 166.3,184.75 209.73,184.75 213.12,181.37 223.24,181.37 226.38,184.51 231.82,184.51 232.73,185.42 232.73,186.92 235.88,190.07 264.18,190.07 265.93,188.33 277.45,188.33 277.52,188.4 v1(277.52,188.8)
D11908: length 385
  TOP w0.086: v1(244.22,209.08) 244.67,208.63 244.67,206.11 246.71,204.07 246.71,197.86 246.63,197.78 SITE3.121
  L05_SIGNAL w0.071: v1(164.91,202.42) 164.91,202.82 164.84,202.89 163.77,202.89 163.32,202.45 163.32,181.88 168.78,176.43 168.78,173.46 165.75,170.43 138.54,170.43 134.17,166.07 134.17,31.67 137.87,27.97 147.39,27.97 153.48,34.06 153.48,58.2 157.72,62.43 174.03,62.43 175.3,61.17 175.3,59.89 175.39,59.79 176.43,59.79 D119.08
  L30_SIGNAL w0.071: v1(244.22,209.08) 244.62,209.08 244.69,209.16 244.69,210.61 240.69,214.61 225.87,214.61 223.57,212.31 223.57,210.84 219.1,206.36 169.9,206.36 166.42,202.89 164.98,202.89 164.91,202.82 v1(164.91,202.42)
D11909: length 385
  TOP w0.086: v1(245.11,203.69) 244.65,203.24 244.65,202.03 246.15,200.53 246.15,197.86 246.23,197.78 SITE3.122
  L05_SIGNAL w0.071: v1(212.03,203.56) 212.03,203.16 212.1,203.09 213.16,203.09 213.82,202.43 213.82,169.36 203.13,158.68 190.93,158.68 185.82,153.56 147.23,153.56 144.49,150.82 144.49,109.44 147.42,106.51 151.24,106.51 158.64,99.11 201.91,99.11 202.56,99.76 202.56,101.16 201.75,101.97 192.64,101.97 191.28,103.34 191.28,105.67 192.69,107.09 201.96,107.09 208.44,100.6 208.44,56.58 198.47,46.6 185.2,46.6 182.1,49.7 182.1,54.12 D119.09
  L32_SIGNAL w0.071: v1(245.11,203.69) 244.7,203.69 244.63,203.76 244.63,206.24 242.9,207.97 237.41,207.97 234.68,210.7 226.44,210.7 218.83,203.09 212.1,203.09 212.03,203.16 v1(212.03,203.56)
D11910: length 385
  TOP w0.086: v1(242.12,209.08) 241.66,208.63 241.66,206.13 242.87,204.93 242.87,202.13 245.35,199.65 245.35,197.86 245.43,197.78 SITE3.124
  L05_SIGNAL w0.071: v1(198.44,203.56) 198.44,203.16 198.37,203.09 197.26,203.09 196.9,202.73 196.9,168.76 185.47,157.33 143.87,157.33 141.94,155.4 141.94,83.07 142.88,82.13 144.69,82.13 145.27,82.71 145.27,103.38 146.19,104.3 147.68,104.3 148.88,103.1 148.88,94.99 150.77,93.1 154.1,93.1 157.69,96.69 203.04,96.69 206.3,93.43 206.3,66.72 201.95,62.37 185.68,62.37 185.12,61.82 185.12,60.66 D119.10
  L28_SIGNAL w0.071: v1(198.44,203.56) 198.44,203.16 198.51,203.09 199.75,203.09 201.93,205.26 223.69,205.26 228.33,209.9 233.41,209.9 234.6,211.1 240.81,211.1 241.64,210.26 241.64,209.16 241.71,209.08 v1(242.12,209.08)
D11911: length 385
  TOP w0.086: v1(243.96,203.69) 244.42,203.24 244.42,201.93 245.91,200.44 245.91,197.86 245.83,197.78 SITE3.123
  L05_SIGNAL w0.071: D119.11 184.09,54.55 182.82,54.55 182.3,54.03 182.3,49.79 185.28,46.8 198.39,46.8 208.24,56.66 208.24,100.52 201.88,106.89 192.78,106.89 191.48,105.59 191.48,103.42 192.72,102.17 201.84,102.17 202.76,101.25 202.76,99.68 201.99,98.91 158.55,98.91 151.16,106.31 147.34,106.31 144.29,109.36 144.29,150.9 147.15,153.76 185.74,153.76 190.85,158.87 203.05,158.87 213.63,169.45 213.63,202.34 213.08,202.89 212.1,202.89 212.03,202.82 v1(212.03,202.42)
  L32_SIGNAL w0.071: v1(212.03,202.42) 212.03,202.82 212.1,202.89 218.91,202.89 226.52,210.5 234.6,210.5 237.32,207.77 242.82,207.77 244.44,206.16 244.44,203.76 244.36,203.69 v1(243.96,203.69)
D11912: length 385
  TOP w0.086: v1(240.97,209.08) 241.43,208.63 241.43,206.04 242.63,204.83 242.63,202.03 245.11,199.55 245.11,197.86 245.03,197.78 SITE3.125
  L05_SIGNAL w0.071: v1(198.44,202.42) 198.44,202.82 198.37,202.89 197.34,202.89 197.1,202.65 197.1,168.68 185.55,157.13 143.95,157.13 142.14,155.32 142.14,83.15 142.96,82.32 144.6,82.32 145.07,82.79 145.07,103.46 146.11,104.5 147.76,104.5 149.08,103.18 149.08,95.08 150.85,93.3 154.02,93.3 157.61,96.89 203.12,96.89 206.5,93.51 206.5,66.64 202.03,62.18 185.76,62.18 185.32,61.73 185.32,60.22 185.78,59.75 186.63,59.75 D119.12
  L28_SIGNAL w0.071: v1(240.97,209.08) 241.37,209.08 241.45,209.16 241.45,210.18 240.72,210.9 234.69,210.9 233.49,209.7 228.41,209.7 223.77,205.07 202.01,205.07 199.83,202.89 198.51,202.89 198.44,202.82 v1(198.44,202.42)
D11913: length 353.4
  TOP w0.086: SITE3.10 245.83,171.48 245.75,171.4 245.75,168.95 243.58,166.78 243.58,162.51 v1(244.03,162.06)
  L03_SIGNAL w0.071: D119.13 192.37,54.01 192.37,48.24 193.21,47.4 203.58,47.4 216.21,34.77 221.76,34.77 222.33,34.21 222.33,33.56 221.85,33.09 219.27,33.09 218.33,32.15 218.33,31.2 219.16,30.36 273.32,30.36 276.09,33.14 276.09,90.08 261.33,104.84 260.55,104.84 259.26,106.13 259.26,107.24 255.28,111.22 215.62,111.22 204.85,121.99 204.85,126.76 199.22,132.4 199.22,139.72 194.19,144.75 194.19,147.62 194.85,148.28 195.19,148.28 195.26,148.21 v1(195.26,147.81)
  L30_SIGNAL w0.071: v1(244.03,162.06) 243.63,162.06 243.56,161.99 243.56,158.6 242.03,157.07 208.38,157.07 202.37,151.06 198.03,151.06 197.28,150.31 197.28,148.89 196.68,148.28 195.33,148.28 195.26,148.21 v1(195.26,147.81)
D11914: length 353.4
  TOP w0.086: SITE3.12 246.63,171.48 246.55,171.4 246.55,167.84 245.57,166.86 245.57,159.77 v1(246.02,159.32)
  L03_SIGNAL w0.071: D119.14 195.47,60.85 195.47,61.65 196.23,62.41 204.05,62.41 205.99,60.47 205.99,52.74 215.76,42.96 271.09,42.96 272.71,44.59 272.71,48.43 270.7,50.45 232.51,50.45 229.37,53.59 229.37,105.11 227.92,106.55 216.53,106.55 202.59,120.49 202.59,123.83 195.75,130.67 195.75,138.68 191.99,142.44 188.81,142.44 182.97,148.28 181.75,148.28 181.67,148.21 v1(181.67,147.81)
  L28_SIGNAL w0.071: v1(246.02,159.32) 245.62,159.32 245.55,159.24 245.55,157.4 241.97,153.82 188.5,153.82 182.96,148.28 181.75,148.28 181.67,148.21 v1(181.67,147.81)
D11915: length 353.4
  TOP w0.086: v1(242.89,162.06) 243.34,162.51 243.34,166.88 245.51,169.05 245.51,171.4 245.43,171.48 SITE3.9
  L03_SIGNAL w0.071: D119.15 193.97,54.27 193.64,54.27 192.57,53.2 192.57,48.32 193.29,47.6 203.67,47.6 216.29,34.97 221.84,34.97 222.52,34.29 222.52,33.48 221.93,32.89 219.35,32.89 218.52,32.07 218.52,31.28 219.24,30.56 273.23,30.56 275.9,33.22 275.9,90 261.25,104.64 260.46,104.64 259.06,106.05 259.06,107.16 255.2,111.02 215.54,111.02 204.65,121.91 204.65,126.68 199.02,132.31 199.02,139.64 193.99,144.67 193.99,147.71 194.77,148.48 195.19,148.48 195.26,148.55 v1(195.26,148.95)
  L30_SIGNAL w0.071: v1(195.26,148.95) 195.26,148.55 195.33,148.48 196.6,148.48 197.09,148.97 197.09,150.39 197.95,151.26 202.29,151.26 208.3,157.27 241.95,157.27 243.36,158.68 243.36,161.99 243.29,162.06 v1(242.89,162.06)
D11916: length 353.4
  TOP w0.086: v1(244.88,159.32) 245.33,159.77 245.33,166.96 246.31,167.94 246.31,171.4 246.23,171.48 SITE3.11
  L03_SIGNAL w0.071: D119.16 195.67,60.87 195.67,61.57 196.32,62.22 203.97,62.22 205.79,60.39 205.79,52.65 215.68,42.77 271.17,42.77 272.91,44.5 272.91,48.52 270.78,50.65 232.59,50.65 229.56,53.67 229.56,105.19 228,106.75 216.61,106.75 202.79,120.57 202.79,123.91 195.95,130.75 195.95,138.77 192.08,142.63 188.9,142.63 183.05,148.48 181.75,148.48 181.67,148.55 v1(181.67,148.95)
  L28_SIGNAL w0.071: v1(181.67,148.95) 181.67,148.55 181.75,148.48 182.88,148.48 188.42,154.02 241.89,154.02 245.35,157.48 245.35,159.24 245.28,159.32 v1(244.88,159.32)
D12001: length 439
  TOP w0.086: SITE3.2 242.63,171.48 242.55,171.4 242.55,171.04 241.9,170.39 228.05,170.39 v1(227.59,169.94)
  L03_SIGNAL w0.071: D120.01 161.12,34.46 161.99,34.46 162.57,33.88 162.57,32.01 163.56,31.02 168.35,31.02 170.89,28.47 170.89,25.92 168.02,23.05 159.82,23.05 156.96,20.19 156.96,9.16 152.11,4.31 78.2,4.31 77.84,4.67 77.84,5.81 78.31,6.28 135.92,6.28 143.08,13.44 143.08,135.59 165.63,158.14 190.75,158.14 194.61,162 195.19,162 195.26,161.93 v1(195.26,161.52)
  L32_SIGNAL w0.071: v1(195.26,161.52) 195.26,161.93 195.33,162 196.58,162 196.93,161.64 196.93,160.39 198.62,158.7 214.61,158.7 226.32,170.41 227.52,170.41 227.59,170.34 v1(227.59,169.94)
D12002: length 439
  TOP w0.086: SITE3.168 237.68,179.23 237.6,179.31 233.36,179.31 232.18,180.49 231.43,180.49 v1(230.98,180.03)
  L03_SIGNAL w0.071: D120.02 164.08,39.62 164.08,42.28 163.23,43.14 159.23,43.14 157.2,41.11 157.2,34.52 155.82,33.14 154.35,33.14 153.04,34.44 153.04,41.18 152.47,41.75 151.36,41.75 151,41.39 151,30.61 151.83,29.79 167.73,29.79 169.09,28.42 169.09,27.28 167.19,25.38 158.02,25.38 155.16,22.51 155.16,9.22 152.54,6.61 148.3,6.61 146.4,8.5 146.4,18.54 149.35,21.49 149.35,41.91 148.24,43.02 146.95,43.02 145.63,41.7 145.63,6.79 144.84,6 142.39,6 141.47,6.92 141.47,9.45 144.39,12.37 144.39,131.83 163.61,151.04 179.46,151.04 180.21,150.29 180.21,149 179.49,148.28 178.57,148.28 178.5,148.21 v1(178.5,147.81)
  L30_SIGNAL w0.071: v1(230.98,180.03) 230.98,180.43 230.91,180.51 226.97,180.51 223.85,177.38 217.72,177.38 216.65,176.31 216.65,172.06 203.06,158.47 184.81,158.47 180.14,153.8 180.14,148.64 179.79,148.28 178.57,148.28 178.5,148.21 v1(178.5,147.81)
D12003: length 439
  TOP w0.086: SITE3.1 242.23,171.48 242.31,171.4 242.31,171.14 241.8,170.63 228.05,170.63 v1(227.59,171.09)
  L03_SIGNAL w0.071: D120.03 162.77,33.23 162.77,32.09 163.64,31.21 168.43,31.21 171.09,28.55 171.09,25.84 168.1,22.85 159.9,22.85 157.16,20.11 157.16,9.07 152.19,4.11 78.12,4.11 77.64,4.59 77.64,5.89 78.22,6.48 135.84,6.48 142.89,13.52 142.89,135.67 165.55,158.34 190.67,158.34 194.53,162.2 195.19,162.2 195.26,162.27 v1(195.26,162.67)
  L32_SIGNAL w0.071: v1(195.26,162.67) 195.26,162.27 195.33,162.2 196.66,162.2 197.13,161.73 197.13,160.47 198.7,158.9 214.53,158.9 226.24,170.61 227.52,170.61 227.59,170.68 v1(227.59,171.09)
D12004: length 439
  TOP w0.086: v1(230.98,181.18) 231.43,180.72 232.28,180.72 233.45,179.55 237.6,179.55 237.68,179.63 SITE3.167
  L03_SIGNAL w0.071: v1(178.5,148.95) 178.5,148.55 178.57,148.48 179.41,148.48 180.01,149.08 180.01,150.21 179.38,150.84 163.69,150.84 144.59,131.74 144.59,12.29 141.67,9.37 141.67,7 142.47,6.2 144.76,6.2 145.44,6.87 145.44,41.79 146.87,43.22 148.33,43.22 149.55,41.99 149.55,21.41 146.6,18.46 146.6,8.58 148.38,6.81 152.46,6.81 154.96,9.3 154.96,22.6 157.94,25.58 167.11,25.58 168.89,27.36 168.89,28.34 167.65,29.59 151.74,29.59 150.8,30.53 150.8,41.48 151.28,41.95 152.55,41.95 153.24,41.26 153.24,34.53 154.43,33.34 155.74,33.34 157,34.6 157,41.19 159.15,43.34 163.31,43.34 164.28,42.37 164.28,41.09 165.56,39.81 165.93,39.81 D120.04
  L30_SIGNAL w0.071: v1(230.98,181.18) 230.98,180.77 230.91,180.7 226.89,180.7 223.77,177.58 217.64,177.58 216.45,176.39 216.45,172.14 202.97,158.66 184.73,158.66 179.95,153.88 179.95,148.72 179.7,148.48 178.57,148.48 178.5,148.55 v1(178.5,148.95)
D12005: length 439
  TOP w0.086: SITE3.174 237.68,176.83 237.6,176.91 234.63,176.91 232.6,174.88 228.05,174.88 v1(227.59,174.42)
  L03_SIGNAL w0.071: D120.05 171.7,34.04 171.97,34.04 173.6,32.4 173.6,26.79 167.4,20.58 159.92,20.58 158.5,19.16 158.5,8.54 152.56,2.6 77.51,2.6 76.53,3.58 76.53,6.78 77.89,8.15 135.28,8.15 141.5,14.36 141.5,139.52 161.96,159.99 179.63,159.99 180.14,160.5 180.14,161.61 180.53,162 181.6,162 181.67,161.93 v1(181.67,161.52)
  L32_SIGNAL w0.071: v1(181.67,161.52) 181.67,161.93 181.75,162 182.4,162 182.78,162.38 182.78,163.89 183.52,164.62 193.16,164.62 200.98,172.44 212.57,172.44 217.53,177.4 222.78,177.4 225.28,174.9 227.52,174.9 227.59,174.83 v1(227.59,174.42)
D12006: length 439
  TOP w0.086: SITE3.170 237.68,178.43 237.6,178.51 228.05,178.51 v1(227.59,178.06)
  L03_SIGNAL w0.071: D120.06 175.55,40.93 175.55,43.42 172.99,45.97 149.01,45.97 146.03,48.95 146.03,115.86 147.71,117.54 153.57,117.54 155.01,116.11 156.45,116.11 158.14,117.8 185.49,117.8 187.37,115.92 187.37,112.36 185.53,110.52 182.11,110.52 181.17,111.45 162.1,111.45 161.11,110.46 161.11,108.62 162.49,107.23 170.93,107.23 172.15,108.45 187.57,108.45 189.34,106.68 190.48,106.68 192.13,108.33 192.13,123.32 190.74,124.71 163.58,124.71 160.32,127.98 160.32,135.99 162.29,137.96 179.81,137.96 181.38,139.53 181.38,142.52 179.96,143.95 163.68,143.95 163.25,144.37 163.25,145.78 163.79,146.31 176.3,146.31 177.15,147.16 177.15,148.11 176,149.26 167.19,149.26 166.2,148.28 164.98,148.28 164.91,148.21 v1(164.91,147.81)
  L28_SIGNAL w0.071: v1(164.91,147.81) 164.91,148.21 164.98,148.28 166.43,148.28 171.08,152.93 171.08,158.68 179.68,167.28 204.53,167.28 208.94,171.69 211.97,171.69 217.63,177.35 222.89,177.35 224.07,178.53 227.52,178.53 227.59,178.46 v1(227.59,178.06)
D12007: length 439
  TOP w0.086: v1(227.59,175.57) 228.05,175.12 232.5,175.12 234.53,177.15 237.6,177.15 237.68,177.23 SITE3.173
  L03_SIGNAL w0.071: D120.07 173.8,34.1 173.8,26.7 167.48,20.38 160,20.38 158.7,19.08 158.7,8.46 152.64,2.4 77.43,2.4 76.33,3.5 76.33,6.87 77.81,8.35 135.2,8.35 141.3,14.44 141.3,139.6 161.88,160.19 179.55,160.19 179.95,160.58 179.95,161.69 180.45,162.2 181.6,162.2 181.67,162.27 v1(181.67,162.67)
  L32_SIGNAL w0.071: v1(227.59,175.57) 227.59,175.17 227.52,175.1 225.36,175.1 222.86,177.6 217.44,177.6 212.48,172.64 200.89,172.64 193.07,164.82 183.44,164.82 182.59,163.97 182.59,162.46 182.32,162.2 181.75,162.2 181.67,162.27 v1(181.67,162.67)
D12008: length 439
  TOP w0.086: v1(227.59,179.2) 228.05,178.75 237.6,178.75 237.68,178.83 SITE3.169
  L03_SIGNAL w0.071: D120.08 175.75,40.15 175.75,43.5 173.08,46.17 149.09,46.17 146.23,49.04 146.23,115.78 147.8,117.35 153.49,117.35 154.92,115.91 156.54,115.91 158.22,117.6 185.41,117.6 187.17,115.84 187.17,112.44 185.45,110.72 182.19,110.72 181.26,111.65 162.02,111.65 160.91,110.54 160.91,108.53 162.41,107.03 171.01,107.03 172.23,108.25 187.49,108.25 189.25,106.48 190.56,106.48 192.33,108.25 192.33,123.4 190.82,124.91 163.67,124.91 160.51,128.06 160.51,135.9 162.38,137.77 179.89,137.77 181.58,139.45 181.58,142.6 180.04,144.14 163.76,144.14 163.45,144.45 163.45,145.69 163.87,146.11 176.38,146.11 177.35,147.08 177.35,148.19 176.08,149.46 167.11,149.46 166.12,148.48 164.98,148.48 164.91,148.55 v1(164.91,148.95)
  L28_SIGNAL w0.071: v1(227.59,179.2) 227.59,178.8 227.52,178.73 223.99,178.73 222.81,177.55 217.55,177.55 211.89,171.89 208.86,171.89 204.45,167.48 179.6,167.48 170.88,158.77 170.88,153.02 166.34,148.48 164.98,148.48 164.91,148.55 v1(164.91,148.95)
D12009: length 353.4
  TOP w0.086: v1(247.8,162.06) 247.35,162.51 247.35,171.4 247.43,171.48 SITE3.14
  L03_SIGNAL w0.071: D120.09 182,33.9 182,26.57 186.78,21.78 275.93,21.78 284.24,30.09 284.24,104.84 266.64,122.43 217.49,122.43 212.92,127.01 212.92,131.28 209.43,134.77 209.43,146.73 211.24,148.53 212.21,148.53 212.28,148.46 v1(212.28,148.06)
  L30_SIGNAL w0.071: v1(212.28,148.06) 212.28,148.46 212.35,148.53 214.68,148.53 221.12,154.97 245.1,154.97 247.33,157.2 247.33,161.99 247.4,162.06 v1(247.8,162.06)
D12010: length 353.4
  TOP w0.086: SITE3.16 248.23,171.48 248.15,171.4 248.15,163.49 249.52,162.12 249.52,159.77 v1(249.98,159.32)
  L03_SIGNAL w0.071: v1(198.69,148.06) 198.69,148.46 198.76,148.53 199.68,148.53 202.67,145.55 202.67,137.66 201.48,136.48 201.48,134 202.67,132.82 202.67,131.61 206.85,127.43 206.85,122.93 215.54,114.24 255,114.24 277.16,92.07 277.16,32.58 273.83,29.25 217.9,29.25 201.66,45.49 186.66,45.49 185.35,44.17 185.35,40.57 D120.10
  L28_SIGNAL w0.071: v1(249.98,159.32) 249.57,159.32 249.5,159.24 249.5,156.64 244.99,152.12 203.64,152.12 200.05,148.53 198.76,148.53 198.69,148.46 v1(198.69,148.06)
D12011: length 353.4
  TOP w0.086: v1(246.66,162.06) 247.11,162.51 247.11,171.4 247.03,171.48 SITE3.13
  L03_SIGNAL w0.071: D120.11 182.2,32.34 182.2,26.65 186.87,21.98 275.85,21.98 284.04,30.17 284.04,104.75 266.56,122.24 217.41,122.24 212.72,126.92 212.72,131.19 209.23,134.68 209.23,146.81 211.16,148.73 212.21,148.73 212.28,148.8 v1(212.28,149.21)
  L30_SIGNAL w0.071: v1(246.66,162.06) 247.06,162.06 247.13,161.99 247.13,157.29 245.02,155.17 221.04,155.17 214.6,148.73 212.35,148.73 212.28,148.8 v1(212.28,149.21)
D12012: length 353.4
  TOP w0.086: SITE3.15 247.83,171.48 247.91,171.4 247.91,163.39 249.28,162.02 249.28,159.77 v1(248.83,159.32)
  L03_SIGNAL w0.071: v1(198.69,149.21) 198.69,148.8 198.76,148.73 199.76,148.73 202.87,145.63 202.87,137.58 201.68,136.4 201.68,134.08 202.87,132.9 202.87,131.69 207.05,127.51 207.05,123.01 215.62,114.44 255.08,114.44 277.36,92.16 277.36,32.5 273.92,29.05 217.82,29.05 201.58,45.29 186.75,45.29 185.54,44.09 185.54,40.52 D120.12
  L28_SIGNAL w0.071: v1(248.83,159.32) 249.23,159.32 249.3,159.24 249.3,156.72 244.91,152.32 203.56,152.32 199.97,148.73 198.76,148.73 198.69,148.8 v1(198.69,149.21)
D12013: length 439
  TOP w0.086: v1(230.98,176.32) 231.43,176.77 232.68,176.77 233.62,177.71 237.6,177.71 237.68,177.63 SITE3.172
  L03_SIGNAL w0.071: v1(212.28,161.52) 212.28,161.93 212.21,162 211.6,162 210.78,162.82 210.78,164.23 211.55,165.01 223.04,165.01 223.83,165.81 223.83,170.55 226.08,172.8 227.67,172.8 229.76,174.89 231.72,174.89 232.76,173.84 232.76,171.8 233.4,171.16 236.03,171.16 236.97,172.11 236.97,179.49 238.8,181.31 238.8,187.15 238.2,187.75 234.33,187.75 233,186.41 233,183.44 231.87,182.32 229.71,182.32 228.14,180.74 212.53,180.74 207.35,175.56 207.35,139.27 205.74,137.67 205.74,134.93 211.36,129.31 211.36,124.32 216.29,119.38 265.59,119.38 281.74,103.22 281.74,30.43 275.58,24.27 200.44,24.27 192.61,32.1 192.61,33.45 D120.13
  L30_SIGNAL w0.071: v1(212.28,161.52) 212.28,161.93 212.35,162 218.92,162 224.4,167.49 224.4,175.05 226.14,176.79 230.91,176.79 230.98,176.72 v1(230.98,176.32)
D12014: length 439
  TOP w0.086: SITE3.176 237.68,176.03 237.6,176.11 236.22,176.11 232.94,172.83 231.43,172.83 v1(230.98,172.38)
  L03_SIGNAL w0.071: v1(198.69,161.52) 198.69,161.93 198.76,162 199.87,162 202.91,165.04 202.91,177.96 206.14,181.19 206.14,196.66 209.28,199.8 217.28,199.8 220,197.08 220,195.18 216.49,191.67 216.49,188.09 204.32,175.92 204.32,132.31 208.96,127.67 208.96,123.23 215.46,116.73 263.75,116.73 279.4,101.08 279.4,31.75 274.93,27.28 206.67,27.28 203.97,29.97 203.97,39.79 200.32,43.44 196.97,43.44 195.39,41.86 195.39,39.77 195.2,39.57 194.51,39.57 D120.14
  L32_SIGNAL w0.071: v1(230.98,172.38) 230.98,172.78 230.91,172.85 226.02,172.85 223.12,169.95 214.24,169.95 208.73,164.44 200.15,164.44 199.78,164.07 199.78,162.4 199.38,162 198.76,162 198.69,161.93 v1(198.69,161.52)
D12015: length 439
  TOP w0.086: SITE3.171 237.68,178.03 237.6,177.95 233.52,177.95 232.58,177.01 231.43,177.01 v1(230.98,177.46)
  L03_SIGNAL w0.071: D120.15 194.03,34.01 193.92,34.01 192.81,32.9 192.81,32.18 200.52,24.47 275.5,24.47 281.55,30.51 281.55,103.14 265.51,119.18 216.21,119.18 211.16,124.24 211.16,129.23 205.54,134.85 205.54,137.75 207.15,139.36 207.15,175.64 212.45,180.94 228.05,180.94 229.63,182.52 231.79,182.52 232.8,183.52 232.8,186.5 234.25,187.95 238.28,187.95 239,187.23 239,181.23 237.17,179.4 237.17,172.02 236.11,170.97 233.32,170.97 232.57,171.72 232.57,173.76 231.64,174.69 229.84,174.69 227.76,172.6 226.16,172.6 224.03,170.47 224.03,165.72 223.12,164.81 211.64,164.81 210.97,164.15 210.97,162.9 211.68,162.2 212.21,162.2 212.28,162.27 v1(212.28,162.67)
  L30_SIGNAL w0.071: v1(212.28,162.67) 212.28,162.27 212.35,162.2 218.83,162.2 224.21,167.57 224.21,175.14 226.06,176.99 230.91,176.99 230.98,177.06 v1(230.98,177.46)
D12016: length 439
  TOP w0.086: v1(230.98,173.52) 231.43,173.07 232.84,173.07 236.12,176.35 237.6,176.35 237.68,176.43 SITE3.175
  L03_SIGNAL w0.071: D120.16 195.59,40.63 195.59,41.78 197.05,43.24 200.24,43.24 203.77,39.71 203.77,29.89 206.58,27.08 275.01,27.08 279.59,31.66 279.59,101.16 263.83,116.93 215.54,116.93 209.16,123.31 209.16,127.75 204.52,132.39 204.52,175.84 216.69,188 216.69,191.59 220.2,195.1 220.2,197.16 217.36,200 209.2,200 205.94,196.74 205.94,181.27 202.72,178.04 202.72,165.13 199.79,162.2 198.76,162.2 198.69,162.27 v1(198.69,162.67)
  L32_SIGNAL w0.071: v1(198.69,162.67) 198.69,162.27 198.76,162.2 199.29,162.2 199.58,162.48 199.58,164.15 200.06,164.64 208.65,164.64 214.16,170.14 223.04,170.14 225.94,173.05 230.91,173.05 230.98,173.12 v1(230.98,173.52)
D12201: length 385
  TOP w0.086: SITE3.81 263.98,190.43 264.06,190.51 267.99,190.51 270.02,192.53 277.07,192.53 v1(277.52,192.08)
  L05_SIGNAL w0.071: v1(250.81,142.94) 250.4,142.94 250.33,142.87 250.33,141.73 249.53,140.93 238.18,140.93 226.23,152.88 211.47,152.88 208.79,150.21 151.01,150.21 149.35,148.54 149.35,147.47 148.71,146.83 148.01,146.83 147.44,147.4 147.44,150.36 147.06,150.74 146.5,150.74 146.04,150.28 146.04,125.6 155.03,116.61 155.03,107.18 160.98,101.23 186.49,101.23 187.49,102.24 187.49,107.8 188.82,109.12 204.17,109.12 210.6,102.7 210.6,75.14 213.26,72.47 235.78,72.47 237.02,73.72 237.02,74.38 236.63,74.77 235.11,74.77 D122.01
  L28_SIGNAL w0.071: v1(250.81,142.94) 250.4,142.94 250.33,142.87 250.33,141.98 250.75,141.56 255.21,141.56 258.2,144.56 268.92,144.56 280.57,156.21 280.57,190.54 278.55,192.55 277.59,192.55 277.52,192.48 v1(277.52,192.08)
D12202: length 385
  TOP w0.086: v1(274.19,190.14) 273.74,190.59 269.94,190.59 269.05,189.71 264.06,189.71 263.98,189.63 SITE3.79
  L05_SIGNAL w0.071: D122.02 238.29,80.81 238.29,82.09 237.94,82.43 215.15,82.43 212.63,84.96 212.63,103.23 205.2,110.67 188.59,110.67 185.47,107.55 185.47,103.69 184.07,102.3 162.02,102.3 160.94,103.37 160.94,104.26 161.78,105.09 173.92,105.09 174.51,105.68 174.51,108.41 173.99,108.93 159.94,108.93 157.65,111.21 157.65,117.52 147.19,127.98 147.19,144 148.04,144.85 206.77,144.85 216.62,135 225.55,135 227.5,136.95 234.42,136.95 239.07,132.29 244.03,132.29 245.32,131 249.42,131 250.33,130.09 250.33,129.42 250.4,129.35 v1(250.81,129.35)
  L30_SIGNAL w0.071: v1(274.19,190.14) 274.19,190.54 274.12,190.61 265.61,190.61 262.18,187.18 262.18,170.11 258.31,166.24 258.31,145.1 251.97,138.76 251.97,132.35 250.33,130.71 250.33,129.42 250.4,129.35 v1(250.81,129.35)
D12203: length 385
  TOP w0.086: SITE3.82 263.98,190.83 264.06,190.75 267.9,190.75 269.92,192.77 277.07,192.77 v1(277.52,193.22)
  L05_SIGNAL w0.071: D122.03 237.22,74.66 237.22,73.63 235.86,72.27 213.18,72.27 210.4,75.06 210.4,102.62 204.09,108.93 188.9,108.93 187.69,107.72 187.69,102.16 186.57,101.04 160.9,101.04 154.83,107.1 154.83,116.53 145.84,125.52 145.84,150.37 146.42,150.94 147.14,150.94 147.64,150.44 147.64,147.48 148.1,147.03 148.63,147.03 149.15,147.55 149.15,148.63 150.93,150.4 208.71,150.4 211.39,153.08 226.32,153.08 238.26,141.13 249.45,141.13 250.14,141.82 250.14,142.87 250.06,142.94 v1(249.66,142.94)
  L28_SIGNAL w0.071: v1(249.66,142.94) 250.06,142.94 250.14,142.87 250.14,141.9 250.67,141.36 255.29,141.36 258.29,144.36 269,144.36 280.77,156.13 280.77,190.62 278.64,192.75 277.59,192.75 277.52,192.82 v1(277.52,193.22)
D12204: length 385
  TOP w0.086: SITE3.80 263.98,190.03 264.06,189.95 268.95,189.95 269.84,190.83 273.74,190.83 v1(274.19,191.28)
  L05_SIGNAL w0.071: D122.04 239.94,80.1 239.9,80.1 238.49,81.51 238.49,82.17 238.03,82.63 215.24,82.63 212.83,85.04 212.83,103.32 205.28,110.86 188.51,110.86 185.27,107.63 185.27,103.78 183.99,102.5 162.1,102.5 161.14,103.45 161.14,104.18 161.86,104.89 174,104.89 174.71,105.6 174.71,108.49 174.07,109.13 160.02,109.13 157.85,111.29 157.85,117.6 147.39,128.06 147.39,143.92 148.12,144.66 206.69,144.66 216.54,134.81 225.64,134.81 227.58,136.75 234.33,136.75 238.99,132.1 243.95,132.1 245.24,130.81 249.34,130.81 250.14,130.01 250.14,129.42 250.06,129.35 v1(249.66,129.35)
  L30_SIGNAL w0.071: v1(249.66,129.35) 250.06,129.35 250.14,129.42 250.14,130.79 251.77,132.43 251.77,138.84 258.11,145.18 258.11,166.33 261.98,170.19 261.98,187.26 265.53,190.81 274.12,190.81 274.19,190.88 v1(274.19,191.28)
D12205: length 385
  TOP w0.086: v1(263.07,209.11) 262.61,208.66 262.61,204.3 257.75,199.44 257.75,197.86 257.83,197.78 SITE3.93
  L07_SIGNAL w0.071: v1(198.44,217.02) 198.44,216.62 198.51,216.55 198.97,216.55 199.28,216.86 200.28,216.86 200.59,216.54 200.59,215.74 196.89,212.04 196.89,200.61 193.87,197.59 193.87,144.95 201.09,137.72 201.09,128.74 201.87,127.97 201.87,122.89 199.18,120.21 199.18,109.37 211.91,96.65 211.91,70.75 207.2,66.04 207.2,25.77 211.07,21.9 221.82,21.9 225.41,25.49 225.41,43.98 230.07,48.64 230.07,67.33 235.06,72.32 245.85,72.32 246.28,72.76 246.28,73.76 D122.05
  L32_SIGNAL w0.071: v1(198.44,217.02) 198.44,216.62 198.51,216.55 198.94,216.55 199.26,216.87 199.26,218.66 200.22,219.62 233.6,219.62 236.94,216.28 259.02,216.28 262.59,212.71 262.59,209.18 262.66,209.11 v1(263.07,209.11)
D12206: length 385
  TOP w0.086: v1(225.81,199.77) 226.27,199.32 231.06,199.32 237.23,193.15 237.6,193.15 237.68,193.23 SITE3.133
  L07_SIGNAL w0.071: D122.06 248.52,80.88 248.52,82.34 248.37,82.48 233.01,82.48 228.56,78.04 228.56,49.55 224.06,45.05 224.06,26.56 220.65,23.15 212.05,23.15 208.88,26.32 208.88,65.45 213.38,69.95 213.38,97.62 200.73,110.27 200.73,119.69 204.69,123.65 204.69,135.89 196.56,144.02 196.56,167.36 195.58,168.34 195.58,185.8 195,186.37 195,196.98 199.28,201.27 199.28,213.03 202.8,216.55 203.15,216.55 203.72,215.99 203.72,215.64 200.4,212.33 200.4,200.14 196.89,196.63 196.89,189.71 197.48,189.12 198.37,189.12 198.44,189.19 v1(198.44,189.59)
  L28_SIGNAL w0.071: v1(225.81,199.77) 225.81,199.37 225.74,199.3 209.99,199.3 199.81,189.12 198.51,189.12 198.44,189.19 v1(198.44,189.59)
D12207: length 385
  TOP w0.086: SITE3.94 257.43,197.78 257.51,197.86 257.51,199.54 262.37,204.4 262.37,208.66 v1(261.92,209.11)
  L07_SIGNAL w0.071: v1(198.44,215.88) 198.44,216.28 198.51,216.35 199.06,216.35 199.36,216.66 200.19,216.66 200.39,216.46 200.39,215.82 196.69,212.12 196.69,200.69 193.67,197.67 193.67,144.86 200.9,137.64 200.9,128.66 201.67,127.89 201.67,122.97 198.99,120.29 198.99,109.29 211.71,96.57 211.71,70.83 207,66.12 207,25.68 210.99,21.7 221.9,21.7 225.61,25.41 225.61,43.9 230.27,48.56 230.27,67.25 235.15,72.13 245.93,72.13 246.48,72.68 246.48,73.76 D122.07
  L32_SIGNAL w0.071: v1(198.44,215.88) 198.44,216.28 198.51,216.35 199.02,216.35 199.46,216.79 199.46,218.57 200.3,219.42 233.52,219.42 236.85,216.09 258.93,216.09 262.39,212.62 262.39,209.18 262.32,209.11 v1(261.92,209.11)
D12208: length 385
  TOP w0.086: v1(225.81,198.63) 226.27,199.08 230.96,199.08 237.13,192.91 237.6,192.91 237.68,192.83 SITE3.134
  L07_SIGNAL w0.071: D122.08 249.68,80.52 249.54,80.52 248.71,81.35 248.71,82.42 248.46,82.68 232.93,82.68 228.37,78.12 228.37,49.64 223.86,45.13 223.86,26.65 220.57,23.35 212.14,23.35 209.08,26.41 209.08,65.37 213.58,69.87 213.58,97.7 200.93,110.36 200.93,119.61 204.89,123.57 204.89,135.98 196.76,144.1 196.76,167.44 195.78,168.42 195.78,185.88 195.2,186.46 195.2,196.9 199.48,201.18 199.48,212.95 202.89,216.35 203.07,216.35 203.52,215.9 203.52,215.73 200.2,212.41 200.2,200.22 196.69,196.71 196.69,189.62 197.39,188.92 198.37,188.92 198.44,188.85 v1(198.44,188.45)
  L28_SIGNAL w0.071: v1(198.44,188.45) 198.44,188.85 198.51,188.92 199.89,188.92 210.08,199.1 225.74,199.1 225.81,199.03 v1(225.81,198.63)
D12209: length 385
  TOP w0.086: v1(264.67,206.34) 264.22,205.88 264.22,202.77 263.16,201.72 261.27,201.72 258.55,199 258.55,197.86 258.63,197.78 SITE3.91
  L07_SIGNAL w0.071: D122.09 255.71,74.49 255.71,72.77 256.3,72.17 275.1,72.17 277.68,74.75 277.68,95.05 275,97.73 233.16,97.73 225,89.57 225,66.88 222.44,64.32 218.69,64.32 216.29,66.73 216.29,100.04 205.51,110.82 205.51,119.39 212.16,126.04 212.16,135.81 204.66,143.31 204.66,210.97 206.78,213.09 212,213.09 213.78,214.87 213.78,216.13 213.36,216.55 212.1,216.55 212.03,216.62 v1(212.03,217.02)
  L30_SIGNAL w0.071: v1(264.67,206.34) 264.27,206.34 264.2,206.41 264.2,209.58 264.84,210.22 264.84,211.23 264.11,211.97 259.01,211.97 255.03,215.94 224.03,215.94 223.67,216.31 223.67,217.83 222.6,218.89 218.09,218.89 215.75,216.55 212.1,216.55 212.03,216.62 v1(212.03,217.02)
D12210: length 385
  TOP w0.086: SITE3.137 237.68,191.63 237.6,191.55 236.17,191.55 232.64,195.08 226.27,195.08 v1(225.81,195.53)
  L07_SIGNAL w0.071: v1(198.69,176.13) 198.69,175.73 198.62,175.66 197.47,175.66 197.04,176.08 197.04,178.6 197.81,179.36 199.34,179.36 200.21,178.5 200.21,143.03 207.8,135.44 207.8,124.31 202.27,118.79 202.27,110.84 214.75,98.35 214.75,69.36 210.29,64.89 210.29,27.16 212.57,24.88 219.91,24.88 222.6,27.57 222.6,45.77 227.29,50.46 227.29,86.35 234.81,93.87 272.27,93.87 275.81,90.32 275.81,83.25 275.23,82.67 260.47,82.67 259.58,81.78 259.58,80.95 258.51,79.88 257.68,79.88 D122.10
  L28_SIGNAL w0.071: v1(198.69,176.13) 198.69,175.73 198.76,175.66 200.43,175.66 205.22,180.44 205.22,188.15 212.13,195.06 225.74,195.06 225.81,195.13 v1(225.81,195.53)
D12211: length 385
  TOP w0.086: SITE3.92 258.23,197.78 258.31,197.86 258.31,199.1 261.17,201.96 263.07,201.96 263.98,202.87 263.98,205.88 v1(263.52,206.34)
  L07_SIGNAL w0.071: D122.11 257.85,74.97 256.65,74.97 255.91,74.23 255.91,72.85 256.39,72.37 275.01,72.37 277.48,74.84 277.48,94.97 274.91,97.54 233.25,97.54 225.2,89.49 225.2,66.8 222.52,64.12 218.61,64.12 216.09,66.65 216.09,99.96 205.31,110.74 205.31,119.47 211.96,126.12 211.96,135.73 204.46,143.22 204.46,211.05 206.69,213.28 211.92,213.28 213.59,214.95 213.59,216.05 213.28,216.35 212.1,216.35 212.03,216.28 v1(212.03,215.88)
  L30_SIGNAL w0.071: v1(212.03,215.88) 212.03,216.28 212.1,216.35 215.83,216.35 218.17,218.7 222.52,218.7 223.47,217.75 223.47,216.23 223.95,215.74 254.95,215.74 258.92,211.77 264.03,211.77 264.64,211.15 264.64,210.31 264,209.66 264,206.41 263.93,206.34 v1(263.52,206.34)
D12212: length 385
  TOP w0.086: SITE3.138 237.68,191.23 237.6,191.31 236.07,191.31 232.55,194.84 226.27,194.84 v1(225.81,194.39)
  L07_SIGNAL w0.071: D122.12 259.78,80.58 259.78,81.7 260.55,82.47 275.32,82.47 276.01,83.17 276.01,90.4 272.35,94.07 234.73,94.07 227.09,86.43 227.09,50.54 222.4,45.85 222.4,27.65 219.82,25.07 212.65,25.07 210.48,27.24 210.48,64.81 214.95,69.28 214.95,98.44 202.47,110.92 202.47,118.7 207.99,124.23 207.99,135.52 200.4,143.11 200.4,178.59 199.43,179.56 197.73,179.56 196.84,178.68 196.84,176 197.39,175.46 198.62,175.46 198.69,175.39 v1(198.69,174.99)
  L28_SIGNAL w0.071: v1(225.81,194.39) 225.81,194.79 225.74,194.86 212.21,194.86 205.42,188.07 205.42,180.36 200.52,175.46 198.76,175.46 198.69,175.39 v1(198.69,174.99)
D12213: length 385
  TOP w0.086: v1(277.52,196.03) 277.07,196.49 270.12,196.49 265.74,192.11 264.06,192.11 263.98,192.03 SITE3.85
  L05_SIGNAL w0.071: D122.13 266.56,73.8 266.56,72.47 266.86,72.17 275.07,72.17 280.49,77.59 280.49,93.8 277.41,96.88 226.2,96.88 208.78,114.29 172.11,114.29 170.38,116.02 170.38,132.61 179.63,141.87 202.43,141.87 211.75,132.54 211.75,130.02 216.25,125.52 262.4,125.52 268.43,131.56 268.43,139.36 263.29,144.5 263.29,145.91 263.36,145.99 v1(263.76,145.99)
  L28_SIGNAL w0.071: v1(263.76,145.99) 263.36,145.99 263.29,146.06 263.29,148.34 267.84,152.89 275.64,152.89 279.18,156.44 279.18,172.1 275.82,175.46 275.82,195.53 276.8,196.51 277.45,196.51 277.52,196.44 v1(277.52,196.03)
