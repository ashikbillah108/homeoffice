# Allegro board 8880F5-0830.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
D10714: length 353.4
  TOP w0.086: SITE4.8 325.03,171.48 324.95,171.4 324.95,170.08 321.42,166.55 321.42,159.77 v1(321.88,159.32)
  L03_SIGNAL w0.071: v1(391.43,129.1) 391.03,129.1 390.96,129.17 390.96,129.98 391.28,130.3 395.77,130.3 422.99,103.08 422.99,87.86 429.44,81.42 445.21,81.42 445.97,82.17 445.97,83.73 444.49,85.21 444.49,86.49 445.38,87.38 459.15,87.38 460.51,88.74 460.51,90 458.9,91.61 432.78,91.61 431.93,92.46 431.93,93.77 432.98,94.83 459.61,94.83 462.68,91.76 462.68,64.33 460.65,62.3 417.36,62.3 416.81,61.75 416.81,60.55 415.74,59.48 415.08,59.48 D107.14
  L28_SIGNAL w0.071: v1(391.43,129.1) 391.03,129.1 390.96,129.17 390.96,130.68 387.36,134.28 342.35,134.28 321.4,155.23 321.4,159.24 321.47,159.32 v1(321.88,159.32)
D10715: length 353.4
  TOP w0.086: v1(318.55,162.06) 319,162.51 319,165.76 323.91,170.67 323.91,171.4 323.83,171.48 SITE4.5
  L03_SIGNAL w0.071: D107.15 415.36,54.68 415.14,54.68 413.47,53.01 413.47,51.95 414.8,50.61 462.86,50.61 466.29,54.04 466.29,97.55 460.5,103.33 433.88,103.33 433.17,102.63 433.17,101.47 433.83,100.82 454.56,100.82 455.69,99.68 455.69,98.44 454.59,97.34 430.77,97.34 398.61,129.51 398.61,133.69 390.76,141.54 390.76,142.61 390.69,142.68 v1(390.29,142.68)
  L30_SIGNAL w0.071: v1(390.29,142.68) 390.69,142.68 390.76,142.76 390.76,144.23 389.58,145.41 378.46,145.41 371.81,152.06 357.5,152.06 356.57,152.99 331.66,152.99 330.59,151.92 320.84,151.92 319.02,153.74 319.02,161.99 318.95,162.06 v1(318.55,162.06)
D10716: length 353.4
  TOP w0.086: v1(320.73,159.32) 321.18,159.77 321.18,166.65 324.71,170.18 324.71,171.4 324.63,171.48 SITE4.7
  L03_SIGNAL w0.071: D107.16 417,60.51 417,61.67 417.44,62.1 460.73,62.1 462.87,64.25 462.87,91.84 459.69,95.03 432.9,95.03 431.73,93.85 431.73,92.38 432.7,91.41 458.82,91.41 460.31,89.91 460.31,88.82 459.07,87.58 445.3,87.58 444.29,86.57 444.29,85.13 445.77,83.65 445.77,82.25 445.13,81.61 429.52,81.61 423.19,87.95 423.19,103.16 395.85,130.5 391.2,130.5 390.76,130.06 390.76,129.17 390.69,129.1 v1(390.29,129.1)
  L28_SIGNAL w0.071: v1(390.29,129.1) 390.69,129.1 390.76,129.17 390.76,130.6 387.28,134.08 342.26,134.08 321.2,155.14 321.2,159.24 321.13,159.32 v1(320.73,159.32)
D10801: length 439
  TOP w0.086: SITE4.168 317.68,179.23 317.6,179.31 313.35,179.31 312.18,180.49 311.43,180.49 v1(310.98,180.03)
  L03_SIGNAL w0.071: v1(311.89,156.84) 311.49,156.84 311.42,156.77 311.42,155.6 314.45,152.57 314.45,139.23 313.76,138.54 308.69,138.54 307.69,139.53 307.69,151.07 305.77,152.99 303.25,152.99 298.6,157.65 291.81,157.65 291.24,158.23 281.41,158.23 277.01,153.82 261.56,153.82 259.49,151.76 256.45,151.76 252.14,147.45 252.14,127.34 252.64,126.84 253,126.84 253.49,127.33 253.49,133.74 254.12,134.37 254.94,134.37 255.38,133.93 255.38,129.35 257.58,127.14 272.43,127.14 275.01,124.56 275.01,120.18 288.35,106.85 288.35,24.22 291.15,21.41 299.7,21.41 302.69,18.43 302.69,9.12 306.3,5.51 371.86,5.51 375.75,9.41 375.75,23.36 384.27,31.87 384.27,32.84 383.18,33.89 382.67,33.89 D108.01
  L30_SIGNAL w0.071: v1(310.98,180.03) 310.98,180.43 310.91,180.51 306.49,180.51 305.63,179.65 305.63,162.35 308.97,159.02 310.12,159.02 311.42,157.72 311.42,156.92 311.49,156.84 v1(311.89,156.84)
D10802: length 439
  TOP w0.086: v1(310.98,172.38) 311.43,172.83 312.94,172.83 316.22,176.11 317.6,176.11 317.68,176.03 SITE4.176
  L03_SIGNAL w0.071: D108.02 385.67,40.23 385.67,42.11 384.69,43.1 381.35,43.1 378.95,40.7 378.95,30.74 355.99,7.77 308.21,7.77 304.09,11.89 304.09,19.24 297.22,26.11 297.22,100.24 277.42,120.04 277.42,126.68 274.13,129.98 262.37,129.98 260.84,131.51 260.84,147.46 263.71,150.33 288.65,150.33 291.17,152.85 300.15,152.85 305.86,147.15 305.86,131.12 306.59,130.39 324.34,130.39 324.92,129.81 324.92,128.91 324.99,128.84 v1(325.39,128.84)
  L32_SIGNAL w0.071: v1(325.39,128.84) 324.99,128.84 324.92,128.91 324.92,129.33 324.34,129.91 303.84,129.91 301.42,132.34 301.42,165.81 304.63,169.03 304.63,170.63 306.86,172.85 310.91,172.85 310.98,172.78 v1(310.98,172.38)
D10803: length 439
  TOP w0.086: v1(310.98,181.18) 311.43,180.72 312.28,180.72 313.45,179.55 317.6,179.55 317.68,179.63 SITE4.167
  L03_SIGNAL w0.071: v1(310.75,156.84) 311.15,156.84 311.22,156.77 311.22,155.51 314.25,152.49 314.25,139.31 313.67,138.73 308.77,138.73 307.89,139.61 307.89,151.15 305.85,153.19 303.33,153.19 298.68,157.84 291.9,157.84 291.32,158.42 281.33,158.42 276.93,154.02 261.48,154.02 259.41,151.96 256.37,151.96 251.94,147.53 251.94,127.26 252.56,126.64 253.09,126.64 253.69,127.24 253.69,133.66 254.2,134.17 254.85,134.17 255.18,133.84 255.18,129.27 257.5,126.95 272.35,126.95 274.81,124.48 274.81,120.1 288.15,106.77 288.15,24.13 291.07,21.21 299.62,21.21 302.49,18.35 302.49,9.04 306.21,5.31 371.94,5.31 375.95,9.33 375.95,23.28 384.47,31.79 384.47,33.95 D108.03
  L30_SIGNAL w0.071: v1(310.98,181.18) 310.98,180.77 310.91,180.7 306.41,180.7 305.44,179.73 305.44,162.27 308.88,158.82 310.04,158.82 311.22,157.64 311.22,156.92 311.15,156.84 v1(310.75,156.84)
D10804: length 439
  TOP w0.086: SITE4.175 317.68,176.43 317.6,176.35 316.12,176.35 312.84,173.07 311.43,173.07 v1(310.98,173.52)
  L03_SIGNAL w0.071: D108.04 386.56,40.16 386.41,40.16 385.87,40.7 385.87,42.19 384.77,43.29 381.26,43.29 378.75,40.78 378.75,30.82 355.9,7.97 308.29,7.97 304.29,11.97 304.29,19.32 297.42,26.19 297.42,100.32 277.62,120.12 277.62,126.76 274.21,130.18 262.46,130.18 261.04,131.6 261.04,147.38 263.8,150.14 288.73,150.14 291.25,152.65 300.07,152.65 305.66,147.06 305.66,131.04 306.5,130.2 324.26,130.2 324.72,129.73 324.72,128.91 324.65,128.84 v1(324.25,128.84)
  L32_SIGNAL w0.071: v1(324.25,128.84) 324.65,128.84 324.72,128.91 324.72,129.25 324.26,129.71 303.76,129.71 301.22,132.26 301.22,165.89 304.44,169.11 304.44,170.71 306.77,173.05 310.91,173.05 310.98,173.12 v1(310.98,173.52)
D10805: length 439
  TOP w0.086: SITE4.170 317.68,178.43 317.6,178.51 308.05,178.51 v1(307.59,178.06)
  L03_SIGNAL w0.071: v1(311.89,143.26) 311.49,143.26 311.42,143.18 311.42,141.8 310.68,141.06 309.48,141.06 308.65,141.88 308.65,153.58 302.74,159.49 290.06,159.49 287.7,161.86 276.34,161.86 269.61,155.13 255.82,155.13 249.09,148.4 249.09,147.02 247.78,145.71 247.78,128.26 251.28,124.76 270.77,124.76 272.18,123.36 272.18,121.02 286.64,106.56 286.64,20.77 304.49,2.91 375.09,2.91 378.09,5.92 378.09,20.16 380.38,22.45 391.89,22.45 394.42,24.98 394.42,32.88 393.12,34.11 392.61,34.11 D108.05
  L28_SIGNAL w0.071: v1(311.89,143.26) 311.49,143.26 311.42,143.33 311.42,144.93 310.12,146.23 310.12,153.87 305.07,158.92 305.07,177.85 305.75,178.53 307.52,178.53 307.59,178.46 v1(307.59,178.06)
D10806: length 439
  TOP w0.086: v1(307.59,174.42) 308.05,174.88 312.6,174.88 314.63,176.91 317.6,176.91 317.68,176.83 SITE4.174
  L03_SIGNAL w0.071: D108.06 395.62,40.02 395.62,44.8 398.78,47.96 462.23,47.96 467.68,53.41 467.68,98.61 461.65,104.64 425.24,104.64 401.53,128.35 401.53,134.2 398.64,137.09 398.64,147.59 401.27,150.23 407.85,150.23 418.03,160.41 418.03,163.02 418.58,163.57 420.6,163.57 421.7,162.48 421.7,160.92 421.77,160.85 v1(422.17,160.85)
  L32_SIGNAL w0.071: v1(307.59,174.42) 307.59,174.83 307.67,174.9 321.52,174.9 326.35,179.74 326.35,187.39 329.95,190.99 346.4,190.99 351.8,196.39 355.37,196.39 357.32,194.44 358.52,194.44 361.36,191.6 361.36,169.58 378.11,152.84 418.17,152.84 419.41,154.08 419.41,157.61 421.7,159.9 421.7,160.77 421.77,160.85 v1(422.17,160.85)
D10807: length 439
  TOP w0.086: SITE4.169 317.68,178.83 317.6,178.75 308.05,178.75 v1(307.59,179.2)
  L03_SIGNAL w0.071: D108.07 394.62,33.94 394.62,24.9 391.97,22.25 380.46,22.25 378.29,20.08 378.29,5.84 375.17,2.72 304.41,2.72 286.45,20.68 286.45,106.47 271.98,120.94 271.98,123.28 270.69,124.57 251.2,124.57 247.58,128.18 247.58,145.79 248.89,147.1 248.89,148.48 255.74,155.33 269.53,155.33 276.26,162.06 287.78,162.06 290.14,159.69 302.83,159.69 308.85,153.66 308.85,141.96 309.56,141.26 310.6,141.26 311.22,141.89 311.22,143.18 311.15,143.26 v1(310.75,143.26)
  L28_SIGNAL w0.071: v1(307.59,179.2) 307.59,178.8 307.52,178.73 305.67,178.73 304.87,177.93 304.87,158.83 309.92,153.78 309.92,146.15 311.22,144.85 311.22,143.33 311.15,143.26 v1(310.75,143.26)
D10808: length 439
  TOP w0.086: v1(307.59,175.57) 308.05,175.12 312.5,175.12 314.53,177.15 317.6,177.15 317.68,177.23 SITE4.173
  L03_SIGNAL w0.071: D108.08 397.2,39.68 396.22,39.68 395.82,40.09 395.82,44.72 398.86,47.76 462.31,47.76 467.88,53.33 467.88,98.69 461.73,104.84 425.32,104.84 401.72,128.44 401.72,134.29 398.83,137.18 398.83,147.51 401.35,150.03 407.93,150.03 418.23,160.33 418.23,162.93 418.66,163.37 420.52,163.37 421.5,162.39 421.5,160.92 421.43,160.85 v1(421.02,160.85)
  L32_SIGNAL w0.071: v1(307.59,175.57) 307.59,175.17 307.67,175.1 321.43,175.1 326.16,179.82 326.16,187.48 329.87,191.19 346.31,191.19 351.72,196.59 355.45,196.59 357.4,194.64 358.6,194.64 361.56,191.68 361.56,169.67 378.19,153.03 418.08,153.03 419.21,154.16 419.21,157.69 421.5,159.98 421.5,160.77 421.43,160.85 v1(421.02,160.85)
D10809: length 353.4
  TOP w0.086: v1(327.8,162.06) 327.35,162.51 327.35,171.4 327.43,171.48 SITE4.14
  L03_SIGNAL w0.071: v1(417.85,142.68) 417.45,142.68 417.38,142.61 417.38,141.64 435.7,123.32 468.46,123.32 476.07,115.71 476.07,36.55 465.26,25.74 406.42,25.74 403.41,28.76 403.41,33.47 D108.09
  L30_SIGNAL w0.071: v1(327.8,162.06) 327.4,162.06 327.33,161.99 327.33,158.19 327.95,157.56 334.71,157.56 335.4,156.87 339.07,156.87 340.61,158.41 365.51,158.41 366.34,157.58 369.67,157.58 370.81,158.72 376.78,158.72 383.72,151.77 412.74,151.77 416.83,147.69 416.83,145.76 417.38,145.22 417.38,142.76 417.45,142.68 v1(417.85,142.68)
D10810: length 353.4
  TOP w0.086: v1(326.02,159.32) 325.57,159.77 325.57,166.86 326.55,167.84 326.55,171.4 326.63,171.48 SITE4.12
  L03_SIGNAL w0.071: v1(404.64,129.1) 404.24,129.1 404.17,129.17 404.17,129.93 404.42,130.18 404.75,130.18 427.11,107.81 443.26,107.81 448.23,112.78 469.21,112.78 471.34,110.65 471.34,38.44 463.28,30.38 426.91,30.38 425.89,31.4 425.89,42.14 422.49,45.55 407.99,45.55 406.97,44.52 406.97,41 405.64,39.68 405.44,39.68 D108.10
  L28_SIGNAL w0.071: v1(326.02,159.32) 325.62,159.32 325.55,159.24 325.55,154.87 344.94,135.48 367.35,135.48 369.68,137.81 397.12,137.81 404.17,130.75 404.17,129.17 404.24,129.1 v1(404.64,129.1)
D10811: length 353.4
  TOP w0.086: v1(326.66,162.06) 327.11,162.51 327.11,171.4 327.03,171.48 SITE4.13
  L03_SIGNAL w0.071: D108.11 405.13,34.29 404.54,34.29 403.6,33.36 403.6,28.84 406.5,25.94 465.18,25.94 475.87,36.63 475.87,115.62 468.37,123.12 435.62,123.12 417.18,141.56 417.18,142.61 417.11,142.68 v1(416.71,142.68)
  L30_SIGNAL w0.071: v1(416.71,142.68) 417.11,142.68 417.18,142.76 417.18,145.14 416.64,145.68 416.64,147.6 412.66,151.58 383.64,151.58 376.69,158.52 370.89,158.52 369.75,157.38 366.26,157.38 365.43,158.21 340.69,158.21 339.15,156.67 335.32,156.67 334.63,157.36 327.87,157.36 327.13,158.1 327.13,161.99 327.06,162.06 v1(326.66,162.06)
D10812: length 353.4
  TOP w0.086: v1(324.88,159.32) 325.33,159.77 325.33,166.96 326.31,167.94 326.31,171.4 326.23,171.48 SITE4.11
  L03_SIGNAL w0.071: v1(403.5,129.1) 403.9,129.1 403.97,129.17 403.97,130.01 404.34,130.38 404.83,130.38 427.2,108.01 443.18,108.01 448.15,112.97 469.3,112.97 471.54,110.73 471.54,38.36 463.36,30.18 426.83,30.18 425.7,31.32 425.7,42.06 422.41,45.35 408.08,45.35 407.16,44.44 407.16,39.88 D108.12
  L28_SIGNAL w0.071: v1(403.5,129.1) 403.9,129.1 403.97,129.17 403.97,130.67 397.03,137.61 369.76,137.61 367.43,135.28 344.86,135.28 325.35,154.79 325.35,159.24 325.28,159.32 v1(324.88,159.32)
D10813: length 353.4
  TOP w0.086: SITE4.10 325.83,171.48 325.75,171.4 325.75,168.95 323.58,166.78 323.58,162.51 v1(324.03,162.06)
  L03_SIGNAL w0.071: D108.13 413.33,33.71 413.33,29.14 415.54,26.94 464.96,26.94 474.69,36.67 474.69,114.32 468.72,120.28 434.77,120.28 420.51,134.54 406.06,134.54 405.63,134.98 405.63,135.5 406.13,136 410.5,136 411.02,136.52 411.02,137.23 410.51,137.74 407.56,137.74 404.17,141.13 404.17,142.61 404.24,142.68 v1(404.64,142.68)
  L30_SIGNAL w0.071: v1(324.03,162.06) 323.63,162.06 323.56,161.99 323.56,156.99 325.21,155.35 372.92,155.35 378.73,149.54 401.63,149.54 403.27,147.9 403.27,145.43 404.17,144.54 404.17,142.76 404.24,142.68 v1(404.64,142.68)
D10814: length 353.4
  TOP w0.086: v1(329.98,159.32) 329.52,159.77 329.52,162.12 328.15,163.49 328.15,171.4 328.23,171.48 SITE4.16
  L03_SIGNAL w0.071: D108.14 415.16,39.24 415.37,39.24 417.1,40.97 417.1,43.05 417.94,43.89 421.66,43.89 424.17,41.38 424.17,30.46 425.61,29.01 464.53,29.01 472.92,37.4 472.92,113.53 468.43,118.02 438.7,118.02 438.14,117.46 438.14,116.89 438.65,116.38 441.44,116.38 442.04,115.78 442.04,114.42 441.17,113.54 438.35,113.54 421.85,130.04 417.85,130.04 417.38,129.56 417.38,129.17 417.45,129.1 v1(417.85,129.1)
  L28_SIGNAL w0.071: v1(417.85,129.1) 417.45,129.1 417.38,129.17 417.38,130.45 406.19,141.64 370.19,141.64 365.78,137.22 351.45,137.22 347.69,140.98 343.88,140.98 329.5,155.36 329.5,159.24 329.57,159.32 v1(329.98,159.32)
D10815: length 353.4
  TOP w0.086: v1(322.89,162.06) 323.34,162.51 323.34,166.88 325.51,169.05 325.51,171.4 325.43,171.48 SITE4.9
  L03_SIGNAL w0.071: D108.15 415.18,34.18 414.9,34.18 413.53,32.81 413.53,29.23 415.62,27.14 464.88,27.14 474.49,36.75 474.49,114.23 468.64,120.08 434.69,120.08 420.43,134.35 405.98,134.35 405.43,134.9 405.43,135.58 406.04,136.2 410.42,136.2 410.82,136.6 410.82,137.15 410.43,137.54 407.48,137.54 403.97,141.05 403.97,142.61 403.9,142.68 v1(403.5,142.68)
  L30_SIGNAL w0.071: v1(403.5,142.68) 403.9,142.68 403.97,142.76 403.97,144.45 403.07,145.35 403.07,147.82 401.55,149.34 378.64,149.34 372.84,155.15 325.12,155.15 323.36,156.91 323.36,161.99 323.29,162.06 v1(322.89,162.06)
D10816: length 353.4
  TOP w0.086: v1(328.83,159.32) 329.28,159.77 329.28,162.02 327.91,163.39 327.91,171.4 327.83,171.48 SITE4.15
  L03_SIGNAL w0.071: D108.16 417.3,39.9 417.3,42.97 418.02,43.69 421.58,43.69 423.97,41.3 423.97,30.38 425.53,28.82 464.61,28.82 473.11,37.32 473.11,113.61 468.51,118.22 438.62,118.22 437.94,117.54 437.94,116.81 438.57,116.18 441.36,116.18 441.84,115.7 441.84,114.5 441.08,113.74 438.43,113.74 421.94,130.24 417.77,130.24 417.18,129.65 417.18,129.17 417.11,129.1 v1(416.71,129.1)
  L28_SIGNAL w0.071: v1(416.71,129.1) 417.11,129.1 417.18,129.17 417.18,130.36 406.1,141.44 370.28,141.44 365.86,137.02 351.36,137.02 347.61,140.78 343.8,140.78 329.3,155.27 329.3,159.24 329.23,159.32 v1(328.83,159.32)
D10901: length 439
  TOP w0.086: v1(310.98,240.03) 311.43,240.48 312.18,240.48 313.35,239.31 317.6,239.31 317.68,239.23 SITE2.168
  L03_SIGNAL w0.071: D109.01 420.25,334.13 419.41,334.13 418.61,334.92 418.61,336.72 420.46,338.56 435.88,338.56 457.55,316.9 457.55,273.37 460.65,270.27 460.65,243.37 459.02,241.74 450.52,241.74 445.67,236.89 445.67,228.83 443.88,227.04 426.13,227.04 425.66,226.57 425.66,225.57 426.3,224.93 446.03,224.93 446.43,224.53 446.43,223.81 445.95,223.33 421.87,223.33 421.42,222.88 421.42,221.57 421.91,221.08 445.78,221.08 446.37,220.49 446.37,219.88 445.66,219.16 421.36,219.16 420.25,220.27 420.25,248.6 417.12,251.73 417.12,251.83 417.19,251.9 v1(417.6,251.9)
  L30_SIGNAL w0.071: v1(310.98,240.03) 310.98,240.43 311.05,240.51 314.71,240.51 316.83,238.39 334.61,238.39 339.64,243.42 345.94,243.42 350.53,238.82 359.89,238.82 360.55,239.48 406.27,239.48 417.12,250.34 417.12,251.83 417.19,251.9 v1(417.6,251.9)
D10902: length 439
  TOP w0.086: SITE2.170 317.68,238.43 317.6,238.51 308.05,238.51 v1(307.59,238.06)
  L03_SIGNAL w0.071: v1(417.6,238.32) 417.19,238.32 417.12,238.39 417.12,239.1 416.55,239.67 415.68,239.67 414.96,238.95 414.96,230.17 413.8,229.01 413.22,229.01 411.8,230.43 411.8,294.91 410.88,295.83 409.64,295.83 408.39,294.58 408.39,267.34 407.85,266.8 407.85,234.09 407.17,233.4 406.74,233.4 405.74,234.4 405.74,296.42 407.62,298.3 413.18,298.3 414.38,297.1 414.38,282.39 417.85,278.92 425.44,278.92 428.72,282.19 428.72,304.77 417.08,316.4 417.08,328.18 D109.02
  L28_SIGNAL w0.071: v1(307.59,238.06) 307.59,238.46 307.67,238.53 318.63,238.53 325.01,232.16 352.33,232.16 354.96,229.53 412.78,229.53 417.12,233.87 417.12,238.24 417.19,238.32 v1(417.6,238.32)
D10903: length 439
  TOP w0.086: v1(310.98,241.18) 311.43,240.72 312.28,240.72 313.45,239.55 317.6,239.55 317.68,239.63 SITE2.167
  L03_SIGNAL w0.071: v1(416.45,251.9) 416.85,251.9 416.92,251.83 416.92,251.65 420.05,248.52 420.05,220.19 421.28,218.97 445.74,218.97 446.57,219.8 446.57,220.57 445.86,221.28 421.99,221.28 421.62,221.65 421.62,222.8 421.95,223.13 446.03,223.13 446.63,223.72 446.63,224.61 446.11,225.13 426.38,225.13 425.86,225.66 425.86,226.49 426.21,226.84 443.96,226.84 445.87,228.75 445.87,236.81 450.61,241.55 459.11,241.55 460.85,243.29 460.85,270.36 457.75,273.46 457.75,316.98 435.97,338.76 420.38,338.76 418.42,336.8 418.42,334.6 D109.03
  L30_SIGNAL w0.071: v1(416.45,251.9) 416.85,251.9 416.92,251.83 416.92,250.42 406.18,239.68 360.46,239.68 359.81,239.02 350.61,239.02 346.02,243.62 339.56,243.62 334.53,238.59 316.91,238.59 314.8,240.7 311.05,240.7 310.98,240.77 v1(310.98,241.18)
D10904: length 439
  TOP w0.086: SITE2.169 317.68,238.83 317.6,238.75 308.05,238.75 v1(307.59,239.2)
  L03_SIGNAL w0.071: D109.04 416.88,327.34 416.88,316.32 428.52,304.68 428.52,282.28 425.36,279.12 417.93,279.12 414.58,282.47 414.58,297.19 413.26,298.5 407.54,298.5 405.54,296.5 405.54,234.32 406.66,233.21 407.25,233.21 408.05,234.01 408.05,266.72 408.59,267.26 408.59,294.5 409.72,295.63 410.8,295.63 411.6,294.83 411.6,230.35 413.13,228.82 413.88,228.82 415.16,230.09 415.16,238.87 415.76,239.47 416.47,239.47 416.92,239.01 416.92,238.39 416.85,238.32 v1(416.45,238.32)
  L28_SIGNAL w0.071: v1(416.45,238.32) 416.85,238.32 416.92,238.24 416.92,233.95 412.7,229.72 355.04,229.72 352.41,232.35 325.09,232.35 318.72,238.73 307.67,238.73 307.59,238.8 v1(307.59,239.2)
D10905: length 353.4
  TOP w0.086: v1(319.69,222.06) 319.24,222.51 319.24,225.66 324.15,230.57 324.15,231.4 324.23,231.48 SITE2.6
  L03_SIGNAL w0.071: D109.05 410.24,333.98 408.94,333.98 408.35,334.57 408.35,338.53 410.7,340.88 436.51,340.88 464.69,312.7 464.69,242.32 460.3,237.93 451.18,237.93 448.07,234.82 448.07,215.62 442.58,210.13 427.87,210.13 403.15,234.84 403.15,235.83 403.22,235.9 v1(403.63,235.9)
  L30_SIGNAL w0.071: v1(403.63,235.9) 403.22,235.9 403.15,235.83 403.15,234.49 400.17,231.5 366.07,231.5 365.2,232.37 324.45,232.37 319.22,227.14 319.22,222.13 319.29,222.06 v1(319.69,222.06)
D10906: length 353.4
  TOP w0.086: SITE2.14 327.43,231.48 327.35,231.4 327.35,222.51 v1(327.8,222.06)
  L03_SIGNAL w0.071: D109.06 406.52,327.78 406.52,307.55 400.89,301.93 400.89,231.51 407.93,224.48 410.83,224.48 414.36,220.95 414.36,215.37 411.59,212.6 397.75,212.6 394.23,209.08 394.23,202.54 397.85,198.91 414.05,198.91 414.98,197.99 414.98,194.26 414.04,193.32 392.69,193.32 391.21,194.81 391.21,207.74 397.5,214.03 409.28,214.03 412.34,217.1 412.34,221.18 411.3,222.22 410.61,222.22 410.01,221.63 410.01,220.48 410.08,220.41 v1(410.48,220.41)
  L30_SIGNAL w0.071: v1(410.48,220.41) 410.08,220.41 410.01,220.34 410.01,218.76 407.59,216.34 399.93,216.34 398.07,218.21 343.65,218.21 341.59,220.26 331.08,220.26 328.38,222.96 327.77,222.96 327.33,222.52 327.33,222.13 327.4,222.06 v1(327.8,222.06)
D10907: length 353.4
  TOP w0.086: SITE2.5 323.83,231.48 323.91,231.4 323.91,230.67 319,225.76 319,222.51 v1(318.55,222.06)
  L03_SIGNAL w0.071: D109.07 408.16,334.5 408.16,338.62 410.62,341.08 436.6,341.08 464.89,312.78 464.89,242.23 460.39,237.73 451.27,237.73 448.27,234.74 448.27,215.54 442.66,209.93 427.79,209.93 402.95,234.76 402.95,235.83 402.88,235.9 v1(402.48,235.9)
  L30_SIGNAL w0.071: v1(402.48,235.9) 402.88,235.9 402.95,235.83 402.95,234.57 400.09,231.7 366.15,231.7 365.28,232.57 324.37,232.57 319.02,227.22 319.02,222.13 318.95,222.06 v1(318.55,222.06)
D10908: length 353.4
  TOP w0.086: SITE2.13 327.03,231.48 327.11,231.4 327.11,222.51 v1(326.66,222.06)
  L03_SIGNAL w0.071: v1(409.34,220.41) 409.74,220.41 409.81,220.48 409.81,221.71 410.53,222.42 411.38,222.42 412.54,221.26 412.54,217.02 409.36,213.84 397.58,213.84 391.41,207.66 391.41,194.89 392.78,193.52 413.96,193.52 414.78,194.34 414.78,197.91 413.97,198.71 397.77,198.71 394.03,202.45 394.03,209.16 397.67,212.8 411.51,212.8 414.16,215.45 414.16,220.87 410.75,224.28 407.85,224.28 400.69,231.43 400.69,302.01 406.32,307.63 406.32,327.74 D109.08
  L30_SIGNAL w0.071: v1(409.34,220.41) 409.74,220.41 409.81,220.34 409.81,218.84 407.51,216.54 400.01,216.54 398.15,218.4 343.73,218.4 341.67,220.46 331.16,220.46 328.46,223.16 327.69,223.16 327.13,222.6 327.13,222.13 327.06,222.06 v1(326.66,222.06)
D10909: length 439
  TOP w0.086: SITE2.176 317.68,236.03 317.6,236.11 316.22,236.11 312.94,232.83 311.43,232.83 v1(310.98,232.38)
  L03_SIGNAL w0.071: v1(390.16,222.06) 389.76,222.06 389.69,221.99 389.69,220.76 389.22,220.3 387.72,220.3 385.37,222.65 381.72,222.65 377.84,226.53 377.84,240.22 374.57,243.5 368.05,243.5 366.03,245.52 366.03,265.69 354.74,276.97 330.85,276.97 327.29,280.53 327.29,303.31 311.66,318.94 311.66,323.06 313.96,325.36 347.08,325.36 350.74,329.02 350.74,335.99 349.07,337.66 316.85,337.66 315.8,338.7 315.8,340.93 316.87,342.01 399.16,342.01 400.08,341.09 400.08,333.98 D109.09
  L32_SIGNAL w0.071: v1(310.98,232.38) 310.98,232.78 311.05,232.85 321.6,232.85 322.43,232.02 351.28,232.02 364.1,219.19 376.41,219.19 380.53,223.31 383.84,223.31 387.29,219.85 389.03,219.85 389.7,220.52 389.7,221.88 389.69,221.89 389.69,221.99 389.76,222.06 v1(390.16,222.06)
D10910: length 353.4
  TOP w0.086: SITE2.8 325.03,231.48 324.95,231.4 324.95,230.08 321.42,226.55 321.42,219.77 v1(321.88,219.32)
  L03_SIGNAL w0.071: v1(403.63,222.31) 403.22,222.31 403.15,222.39 403.15,223.53 403.7,224.07 404.2,224.07 404.64,223.63 404.64,216.9 403.96,216.22 394.07,216.22 385.48,207.63 385.48,187.8 387.72,185.56 402.38,185.56 403.3,186.49 403.3,188.99 402.6,189.69 391.09,189.69 388.1,192.68 388.1,205.97 390.96,208.84 390.96,209.94 395.98,214.96 405.17,214.96 407.21,217 407.21,223.37 397.74,232.83 397.74,313.15 396.36,314.54 396.36,327.78 D109.10
  L28_SIGNAL w0.071: v1(403.63,222.31) 403.22,222.31 403.15,222.24 403.15,219.73 398.51,215.09 369.64,215.09 365.2,219.53 347.65,219.53 346.77,220.42 321.87,220.42 321.4,219.95 321.4,219.39 321.47,219.32 v1(321.88,219.32)
D10911: length 439
  TOP w0.086: SITE2.175 317.68,236.43 317.6,236.35 316.12,236.35 312.84,233.07 311.43,233.07 v1(310.98,233.52)
  L03_SIGNAL w0.071: D109.11 397.56,334.06 398.64,334.06 399.88,335.3 399.88,341.01 399.08,341.81 316.96,341.81 316,340.85 316,338.79 316.93,337.86 349.15,337.86 350.94,336.07 350.94,328.94 347.16,325.16 314.04,325.16 311.86,322.98 311.86,319.02 327.49,303.39 327.49,280.61 330.93,277.17 354.83,277.17 366.23,265.77 366.23,245.6 368.13,243.69 374.65,243.69 378.04,240.3 378.04,226.61 381.81,222.85 385.45,222.85 387.8,220.49 389.14,220.49 389.49,220.84 389.49,221.99 389.42,222.06 v1(389.02,222.06)
  L32_SIGNAL w0.071: v1(389.02,222.06) 389.42,222.06 389.49,221.99 389.49,221.81 389.5,221.8 389.5,220.6 388.95,220.05 387.38,220.05 383.92,223.51 380.45,223.51 376.33,219.39 364.19,219.39 351.36,232.21 322.51,232.21 321.68,233.05 311.05,233.05 310.98,233.12 v1(310.98,233.52)
D10912: length 353.4
  TOP w0.086: SITE2.7 324.63,231.48 324.71,231.4 324.71,230.18 321.18,226.65 321.18,219.77 v1(320.73,219.32)
  L03_SIGNAL w0.071: D109.12 396.16,327.74 396.16,314.46 397.55,313.07 397.55,232.74 407.01,223.28 407.01,217.08 405.09,215.16 395.9,215.16 390.77,210.02 390.77,208.92 387.9,206.05 387.9,192.6 391.01,189.49 402.52,189.49 403.1,188.91 403.1,186.57 402.3,185.76 387.8,185.76 385.68,187.88 385.68,207.55 394.15,216.02 404.04,216.02 404.84,216.82 404.84,223.71 404.28,224.27 403.61,224.27 402.95,223.61 402.95,222.39 402.88,222.31 v1(402.48,222.31)
  L28_SIGNAL w0.071: v1(320.73,219.32) 321.13,219.32 321.2,219.39 321.2,220.03 321.79,220.61 346.85,220.61 347.73,219.73 365.28,219.73 369.72,215.29 398.43,215.29 402.95,219.82 402.95,222.24 402.88,222.31 v1(402.48,222.31)
D10913: length 439
  TOP w0.086: SITE2.172 317.68,237.63 317.6,237.71 313.62,237.71 312.68,236.77 311.43,236.77 v1(310.98,236.32)
  L03_SIGNAL w0.071: D109.13 389.7,334.2 389.7,337.73 387.31,340.12 357.87,340.12 353.23,335.48 353.23,327.54 349.19,323.5 318.04,323.5 315.67,321.13 315.67,317.22 327.23,305.67 387.99,305.67 388.65,305.01 388.65,304 387.79,303.14 332.38,303.14 328.37,299.13 328.37,282.35 330.55,280.18 354.03,280.18 367.06,267.15 367.06,248.96 369.57,246.46 373.22,246.46 381.27,238.41 384.07,238.41 387.78,234.7 389.28,234.7 389.69,235.11 389.69,235.58 389.76,235.65 v1(390.16,235.65)
  L30_SIGNAL w0.071: v1(310.98,236.32) 310.98,236.72 311.05,236.79 319.71,236.79 322.74,233.75 388.55,233.75 389.69,234.9 389.69,235.58 389.76,235.65 v1(390.16,235.65)
D10914: length 353.4
  TOP w0.086: v1(324.03,222.06) 323.58,222.51 323.58,226.78 325.75,228.95 325.75,231.4 325.83,231.48 SITE2.10
  L03_SIGNAL w0.071: D109.14 387.24,328.82 387.24,328.72 387.24,312.8 393.4,306.63 393.4,232.88 400.93,225.36 400.93,219.95 399.06,218.08 394.82,218.08 384.79,208.05 384.79,186.69 388.71,182.76 392.65,182.76 393.49,181.92 393.49,179.54 392.39,178.43 380.61,178.43 378.35,180.7 378.35,207.64 386.49,215.78 391.09,215.78 394.55,219.24 398,219.24 399.26,220.5 399.26,222.07 398.41,222.92 397.08,222.92 396.3,222.13 396.3,220.23 396.37,220.15 v1(396.77,220.15)
  L30_SIGNAL w0.071: v1(396.77,220.15) 396.37,220.15 396.3,220.23 396.3,222.75 388.65,230.4 341.76,230.4 339.2,227.84 324.19,227.84 321.06,224.72 321.06,220.93 321.54,220.45 322.86,220.45 323.56,221.14 323.56,221.99 323.63,222.06 v1(324.03,222.06)
D10915: length 439
  TOP w0.086: SITE2.171 317.68,238.03 317.6,237.95 313.52,237.95 312.58,237.01 311.43,237.01 v1(310.98,237.46)
  L03_SIGNAL w0.071: v1(389.02,235.65) 389.42,235.65 389.49,235.58 389.49,235.19 389.19,234.89 387.86,234.89 384.15,238.61 381.35,238.61 373.31,246.65 369.65,246.65 367.26,249.05 367.26,267.23 354.11,280.38 330.63,280.38 328.57,282.44 328.57,299.05 332.47,302.94 387.87,302.94 388.85,303.92 388.85,305.09 388.07,305.87 327.31,305.87 315.87,317.31 315.87,321.04 318.13,323.3 349.27,323.3 353.43,327.45 353.43,335.4 357.95,339.92 387.22,339.92 389.5,337.64 389.5,334.77 388.75,334.01 387.35,334.01 D109.15
  L30_SIGNAL w0.071: v1(389.02,235.65) 389.42,235.65 389.49,235.58 389.49,234.98 388.47,233.95 322.83,233.95 319.79,236.99 311.05,236.99 310.98,237.06 v1(310.98,237.46)
D10916: length 353.4
  TOP w0.086: SITE2.9 325.43,231.48 325.51,231.4 325.51,229.05 323.34,226.88 323.34,222.51 v1(322.89,222.06)
  L03_SIGNAL w0.071: D109.16 384.7,329.04 385.45,329.04 387.04,327.46 387.04,312.71 393.2,306.55 393.2,232.8 400.73,225.27 400.73,220.03 398.98,218.28 394.74,218.28 384.59,208.13 384.59,186.6 388.63,182.56 392.57,182.56 393.3,181.84 393.3,179.62 392.3,178.63 380.69,178.63 378.54,180.78 378.54,207.56 386.57,215.59 391.17,215.59 394.63,219.05 398.08,219.05 399.45,220.42 399.45,222.16 398.5,223.12 397,223.12 396.1,222.22 396.1,220.23 396.03,220.15 v1(395.62,220.15)
  L30_SIGNAL w0.071: v1(395.62,220.15) 396.03,220.15 396.1,220.23 396.1,222.67 388.57,230.2 341.84,230.2 339.29,227.64 324.27,227.64 321.26,224.64 321.26,221.01 321.62,220.65 322.78,220.65 323.36,221.23 323.36,221.99 323.29,222.06 v1(322.89,222.06)
D11001: length 353.4
  TOP w0.086: SITE2.16 328.23,231.48 328.15,231.4 328.15,223.49 329.52,222.12 329.52,219.77 v1(329.98,219.32)
  L03_SIGNAL w0.071: D110.01 420.27,354.43 419.44,354.43 418.22,355.65 418.22,357 420.45,359.24 426.66,359.24 473.23,312.67 473.23,210.2 467.85,204.83 410.66,204.83 410.01,205.48 410.01,206.75 410.08,206.82 v1(410.48,206.82)
  L28_SIGNAL w0.071: v1(410.48,206.82) 410.08,206.82 410.01,206.89 410.01,207.82 404.6,213.24 364.19,213.24 359.77,217.65 330.01,217.65 329.5,218.16 329.5,219.24 329.57,219.32 v1(329.98,219.32)
D11002: length 353.4
  TOP w0.086: v1(326.02,219.32) 325.57,219.77 325.57,226.86 326.55,227.84 326.55,231.4 326.63,231.48 SITE2.12
  L03_SIGNAL w0.071: D110.02 416.66,348.08 416.66,345.27 417.46,344.46 437.7,344.46 466.03,316.14 466.03,256.07 471.72,250.38 471.72,238.94 469.97,237.19 462.33,237.19 461.26,236.12 461.26,211.26 463.27,209.25 463.27,208.2 462.19,207.12 418.24,207.12 414.3,211.05 399.68,211.05 396.3,207.67 396.3,206.64 396.37,206.57 v1(396.77,206.57)
  L28_SIGNAL w0.071: v1(326.02,219.32) 325.62,219.32 325.55,219.24 325.55,217.67 328.17,215.04 343.32,215.04 344.03,215.76 358.72,215.76 363.92,210.56 393.86,210.56 396.29,208.12 396.29,206.64 396.37,206.57 v1(396.77,206.57)
D11003: length 353.4
  TOP w0.086: SITE2.15 327.83,231.48 327.91,231.4 327.91,223.39 329.28,222.02 329.28,219.77 v1(328.83,219.32)
  L03_SIGNAL w0.071: v1(409.34,206.82) 409.74,206.82 409.81,206.75 409.81,205.4 410.58,204.63 467.93,204.63 473.42,210.12 473.42,312.75 426.74,359.43 420.37,359.43 418.02,357.08 418.02,354.52 D110.03
  L28_SIGNAL w0.071: v1(328.83,219.32) 329.23,219.32 329.3,219.24 329.3,218.07 329.92,217.45 359.69,217.45 364.11,213.04 404.51,213.04 409.81,207.74 409.81,206.89 409.74,206.82 v1(409.34,206.82)
D11004: length 353.4
  TOP w0.086: v1(324.88,219.32) 325.33,219.77 325.33,226.96 326.31,227.94 326.31,231.4 326.23,231.48 SITE2.11
  L03_SIGNAL w0.071: D110.04 416.46,348.08 416.46,345.19 417.38,344.26 437.62,344.26 465.83,316.05 465.83,255.99 471.52,250.3 471.52,239.02 469.88,237.38 462.25,237.38 461.07,236.2 461.07,211.18 463.08,209.17 463.08,208.28 462.11,207.31 418.32,207.31 414.38,211.25 399.6,211.25 396.1,207.75 396.1,206.64 396.03,206.57 v1(395.62,206.57)
  L28_SIGNAL w0.071: v1(324.88,219.32) 325.28,219.32 325.35,219.24 325.35,217.59 328.09,214.85 343.4,214.85 344.11,215.56 358.63,215.56 363.84,210.36 393.78,210.36 396.1,208.04 396.1,206.64 396.03,206.57 v1(395.62,206.57)
D11005: length 385
  TOP w0.086: v1(329.8,268.11) 329.35,267.66 329.35,257.86 329.43,257.78 SITE2.114
  L05_SIGNAL w0.071: v1(389.02,286.32) 389.42,286.32 389.49,286.39 389.49,287.52 397.59,295.62 402.64,295.62 413.68,306.66 441.24,306.66 449.76,315.19 449.76,344.44 449.4,344.79 448.34,344.79 447.88,344.33 447.88,315.05 447.34,314.5 446.54,314.5 446.14,314.9 446.14,372.63 445.35,373.42 444.77,373.42 444.13,372.78 444.13,340.93 443.55,340.34 442.49,340.34 441.99,340.84 441.99,364.24 440.03,366.2 431.21,366.2 425.62,360.61 411.14,360.61 408.02,357.49 408.02,355.7 409.22,354.51 410.03,354.51 D110.05
  L30_SIGNAL w0.071: v1(329.8,268.11) 329.4,268.11 329.33,268.18 329.33,272.67 332.2,275.54 373.56,275.54 386.38,288.36 388.77,288.36 389.49,287.64 389.49,286.39 389.42,286.32 v1(389.02,286.32)
D11006: length 385
  TOP w0.086: v1(321.53,263.69) 321.08,263.24 321.08,262.2 324.55,258.72 324.55,257.86 324.63,257.78 SITE2.126
  L05_SIGNAL w0.071: D110.06 407.72,349.3 406.6,349.3 405.71,348.41 405.71,345.36 406.4,344.67 432.76,344.67 438.48,338.95 438.48,324.34 438.78,324.04 439.45,324.04 439.79,324.39 439.79,363.87 440.09,364.17 440.61,364.17 440.92,363.86 440.92,312.31 441.32,311.92 441.78,311.92 442.25,312.4 442.25,337.93 443.17,338.85 444.09,338.85 445.05,337.9 445.05,313.08 440.24,308.27 406.56,308.27 400.3,302.01 400.3,298.92 400.77,298.45 402.33,298.45 402.95,299.08 402.95,299.84 402.88,299.91 v1(402.48,299.91)
  L32_SIGNAL w0.071: v1(321.53,263.69) 321.13,263.69 321.06,263.76 321.06,266.66 319.99,267.73 319.99,273.51 325.46,278.97 351.62,278.97 353.92,281.27 353.92,289.25 359.33,294.66 377.98,294.66 385.24,301.92 402.46,301.92 402.95,301.42 402.95,299.98 402.88,299.91 v1(402.48,299.91)
D11007: length 385
  TOP w0.086: v1(328.66,268.11) 329.11,267.66 329.11,257.86 329.03,257.78 SITE2.115
  L05_SIGNAL w0.071: v1(390.16,286.32) 389.76,286.32 389.69,286.39 389.69,287.44 397.67,295.42 402.72,295.42 413.76,306.46 441.32,306.46 449.96,315.1 449.96,344.52 449.48,344.99 448.26,344.99 447.69,344.42 447.69,315.13 447.26,314.7 446.62,314.7 446.34,314.98 446.34,372.71 445.43,373.62 444.69,373.62 443.94,372.87 443.94,341.01 443.46,340.54 442.57,340.54 442.18,340.93 442.18,364.32 440.11,366.4 431.13,366.4 425.54,360.8 411.06,360.8 407.83,357.57 407.83,354.49 D110.07
  L30_SIGNAL w0.071: v1(390.16,286.32) 389.76,286.32 389.69,286.39 389.69,287.72 388.85,288.56 386.3,288.56 373.48,275.74 332.12,275.74 329.13,272.75 329.13,268.18 329.06,268.11 v1(328.66,268.11)
D11008: length 385
  TOP w0.086: v1(320.39,263.69) 320.84,263.24 320.84,262.1 324.31,258.63 324.31,257.86 324.23,257.78 SITE2.127
  L05_SIGNAL w0.071: D110.08 405.51,348.87 405.51,345.28 406.32,344.47 432.68,344.47 438.28,338.87 438.28,324.26 438.7,323.85 439.53,323.85 439.99,324.3 439.99,363.78 440.18,363.97 440.53,363.97 440.73,363.78 440.73,312.23 441.23,311.72 441.86,311.72 442.45,312.31 442.45,337.85 443.26,338.65 444.01,338.65 444.85,337.81 444.85,313.16 440.16,308.47 406.48,308.47 400.11,302.1 400.11,298.84 400.69,298.26 402.41,298.26 403.15,299 403.15,299.84 403.22,299.91 v1(403.63,299.91)
  L32_SIGNAL w0.071: v1(320.39,263.69) 320.79,263.69 320.86,263.76 320.86,266.58 319.79,267.65 319.79,273.59 325.37,279.17 351.54,279.17 353.72,281.35 353.72,289.34 359.25,294.86 377.9,294.86 385.15,302.12 402.54,302.12 403.15,301.51 403.15,299.98 403.22,299.91 v1(403.63,299.91)
D11009: length 385
  TOP w0.086: v1(325.36,269.08) 324.91,268.63 324.91,266.21 326.95,264.17 326.95,257.86 327.03,257.78 SITE2.120
  L05_SIGNAL w0.071: D110.09 398.87,355.51 398.87,360.04 397.76,361.16 382.55,361.16 377.87,356.49 377.87,349.09 380.71,346.26 393.49,346.26 394.88,344.88 394.88,339.08 393.59,337.79 380.26,337.79 377.87,335.4 377.87,329.18 381.29,325.77 420.03,325.77 420.75,325.05 420.75,313.62 421.75,312.61 422.84,312.61 424.08,313.85 424.08,334.19 424.32,334.43 425.14,334.43 425.49,334.09 425.49,313.1 423.87,311.47 405.05,311.47 386.15,292.57 386.15,274.07 389.49,270.73 389.49,270.39 389.42,270.32 v1(389.02,270.32)
  L30_SIGNAL w0.071: v1(325.36,269.08) 324.96,269.08 324.89,269.16 324.89,273.22 331.17,279.49 354.08,279.49 356.23,277.35 370.69,277.35 373.78,280.44 373.78,288.32 376.64,291.17 390.78,291.17 392.8,289.15 392.8,275.04 389.49,271.73 389.49,270.39 389.42,270.32 v1(389.02,270.32)
D11010: length 385
  TOP w0.086: SITE2.116 328.63,257.78 328.55,257.86 328.55,266.82 326.96,268.41 326.96,270.72 v1(327.41,271.17)
  L05_SIGNAL w0.071: v1(389.02,283.91) 389.42,283.91 389.49,283.84 389.49,282.76 389.32,282.59 388.04,282.59 387.52,283.12 387.52,290.89 406.16,309.53 437.69,309.53 439.89,311.73 439.89,322.82 439.6,323.11 439.03,323.11 438.78,322.85 438.78,312.62 437.5,311.35 436.7,311.35 436.21,311.84 436.21,338.96 435.44,339.73 434.62,339.73 433.8,338.91 433.8,322.37 433.02,321.59 432.29,321.59 431.79,322.09 431.79,342.27 431.24,342.82 430.25,342.82 429.71,342.27 429.71,322.87 428.89,322.06 427.93,322.06 426.84,323.15 426.84,334.77 423.69,337.92 408.89,337.92 408.31,338.5 408.31,339.27 408.9,339.86 423.12,339.86 423.86,340.6 423.86,341.91 423.16,342.61 398.02,342.61 396.35,344.28 396.35,348.09 D110.10
  L28_SIGNAL w0.071: v1(327.41,271.17) 327.01,271.17 326.94,271.1 326.94,270.72 326.58,270.36 325.43,270.36 324.98,270.81 324.98,273.27 328.07,276.36 352.72,276.36 365.19,263.89 377.3,263.89 388.13,274.72 388.13,281.59 389.49,282.95 389.49,283.84 389.42,283.91 v1(389.02,283.91)
D11011: length 385
  TOP w0.086: SITE2.121 326.63,257.78 326.71,257.86 326.71,264.07 324.67,266.11 324.67,268.63 v1(324.22,269.08)
  L05_SIGNAL w0.071: D110.11 398.68,355.5 398.68,359.96 397.67,360.96 382.63,360.96 378.07,356.4 378.07,349.18 380.79,346.46 393.57,346.46 395.07,344.96 395.07,338.99 393.68,337.6 380.35,337.6 378.07,335.32 378.07,329.27 381.37,325.97 420.11,325.97 420.95,325.13 420.95,313.7 421.84,312.81 422.76,312.81 423.88,313.94 423.88,334.27 424.24,334.63 425.23,334.63 425.69,334.17 425.69,313.02 423.95,311.28 405.13,311.28 386.35,292.49 386.35,274.15 389.69,270.81 389.69,270.39 389.76,270.32 v1(390.16,270.32)
  L30_SIGNAL w0.071: v1(324.22,269.08) 324.62,269.08 324.69,269.16 324.69,273.3 331.09,279.69 354.17,279.69 356.31,277.55 370.61,277.55 373.58,280.52 373.58,288.4 376.56,291.37 390.86,291.37 393,289.23 393,274.96 389.69,271.65 389.69,270.39 389.76,270.32 v1(390.16,270.32)
D11012: length 385
  TOP w0.086: v1(326.26,271.17) 326.72,270.72 326.72,268.31 328.31,266.72 328.31,257.86 328.23,257.78 SITE2.117
  L05_SIGNAL w0.071: v1(390.16,283.91) 389.76,283.91 389.69,283.84 389.69,282.68 389.4,282.4 387.96,282.4 387.32,283.03 387.32,290.97 406.08,309.73 437.61,309.73 439.7,311.81 439.7,322.73 439.52,322.91 439.11,322.91 438.98,322.77 438.98,312.54 437.59,311.15 436.62,311.15 436.01,311.76 436.01,338.88 435.36,339.53 434.7,339.53 434,338.83 434,322.29 433.1,321.39 432.21,321.39 431.59,322.01 431.59,342.19 431.16,342.62 430.33,342.62 429.9,342.19 429.9,322.79 428.97,321.86 427.85,321.86 426.64,323.06 426.64,334.69 423.61,337.72 408.81,337.72 408.11,338.42 408.11,339.35 408.81,340.06 423.04,340.06 423.66,340.68 423.66,341.83 423.08,342.41 397.94,342.41 396.15,344.19 396.15,348.07 D110.12
  L28_SIGNAL w0.071: v1(326.26,271.17) 326.65,271.17 326.74,271.08 326.74,270.81 326.49,270.56 325.51,270.56 325.18,270.89 325.18,273.18 328.15,276.16 352.64,276.16 365.1,263.69 377.38,263.69 388.33,274.64 388.33,281.51 389.69,282.87 389.69,283.84 389.76,283.91 v1(390.16,283.91)
D11013: length 439
  TOP w0.086: SITE2.174 317.68,236.83 317.6,236.91 314.63,236.91 312.6,234.88 308.05,234.88 v1(307.59,234.42)
  L03_SIGNAL w0.071: v1(376.45,221.81) 376.05,221.81 375.98,221.73 375.98,220.56 375.65,220.23 361.54,220.23 358.92,217.61 333.21,217.61 331.81,216.22 315.31,216.22 312.45,219.08 292.01,219.08 288.96,222.12 288.96,287.43 280.6,295.79 280.6,352.78 291.78,363.95 385.18,363.95 389.72,359.41 389.72,354.5 D110.13
  L32_SIGNAL w0.071: v1(307.59,234.42) 307.59,234.83 307.67,234.9 322.42,234.9 324.3,233.01 353.57,233.01 366.37,220.21 375.37,220.21 375.98,220.82 375.98,221.73 376.05,221.81 v1(376.45,221.81)
D11014: length 439
  TOP w0.086: SITE2.2 322.63,231.48 322.55,231.4 322.55,231.04 321.9,230.39 308.05,230.39 v1(307.59,229.94)
  L03_SIGNAL w0.071: D110.14 386.87,348.77 386.87,346.91 386.13,346.18 381.04,346.18 369.38,357.83 307.04,357.83 305.05,355.83 305.05,347.96 307.02,345.99 342.81,345.99 343.41,345.39 343.41,344.66 342.83,344.08 307.09,344.08 305.05,342.03 305.05,323.49 326.23,302.3 326.23,277.59 328.43,275.39 354.53,275.39 364.76,265.16 364.76,238.62 366.37,237.01 375.42,237.01 375.98,236.45 375.98,235.47 376.05,235.39 v1(376.45,235.39)
  L32_SIGNAL w0.071: v1(307.59,229.94) 307.59,230.34 307.52,230.41 305.63,230.41 304.9,231.14 304.9,235.56 306.35,237 308.02,237 309.85,238.83 330.21,238.83 334.67,234.38 348.96,234.38 351.49,236.91 375.49,236.91 375.98,236.43 375.98,235.47 376.05,235.39 v1(376.45,235.39)
D11015: length 439
  TOP w0.086: v1(307.59,235.57) 308.05,235.12 312.5,235.12 314.53,237.15 317.6,237.15 317.68,237.23 SITE2.173
  L03_SIGNAL w0.071: v1(375.3,221.81) 375.71,221.81 375.78,221.73 375.78,220.64 375.57,220.43 361.45,220.43 358.83,217.81 333.12,217.81 331.73,216.42 315.39,216.42 312.54,219.27 292.09,219.27 289.16,222.2 289.16,287.51 280.8,295.88 280.8,352.69 291.86,363.75 385.1,363.75 389.52,359.33 389.52,355.08 388.92,354.48 387.5,354.48 D110.15
  L32_SIGNAL w0.071: v1(307.59,235.57) 307.59,235.17 307.67,235.1 322.5,235.1 324.38,233.21 353.65,233.21 366.45,220.41 375.28,220.41 375.78,220.9 375.78,221.73 375.71,221.81 v1(375.3,221.81)
D11016: length 439
  TOP w0.086: v1(307.59,231.08) 308.05,230.63 321.8,230.63 322.31,231.14 322.31,231.4 322.23,231.48 SITE2.1
  L03_SIGNAL w0.071: v1(375.3,235.39) 375.71,235.39 375.78,235.47 375.78,236.37 375.33,236.81 366.28,236.81 364.56,238.53 364.56,265.08 354.44,275.2 328.35,275.2 326.04,277.51 326.04,302.22 304.85,323.41 304.85,342.11 307.01,344.28 342.75,344.28 343.21,344.74 343.21,345.3 342.72,345.79 306.94,345.79 304.85,347.88 304.85,355.92 306.96,358.03 369.47,358.03 381.12,346.37 386.05,346.37 386.67,346.99 386.67,348.79 386.08,349.39 384.67,349.39 D110.16
  L32_SIGNAL w0.071: v1(307.59,231.08) 307.59,230.68 307.52,230.61 305.71,230.61 305.1,231.22 305.1,235.47 306.43,236.8 308.1,236.8 309.93,238.63 330.13,238.63 334.58,234.18 349.04,234.18 351.57,236.71 375.41,236.71 375.78,236.35 375.78,235.47 375.71,235.39 v1(375.3,235.39)
D11101: length 385
  TOP w0.086: v1(357.52,256.03) 357.07,256.49 350.12,256.49 345.74,252.11 344.06,252.11 343.98,252.03 SITE2.85
  L05_SIGNAL w0.071: D111.01 420.16,374.86 419.69,374.86 418.35,376.2 418.35,380.82 420.31,382.79 479.22,382.79 485.33,376.68 485.33,299.21 483.93,297.81 424.34,297.81 413.58,287.04 413.58,283.39 414.69,282.29 431.63,282.29 436.04,277.87 436.04,262.05 432.56,258.57 405.93,258.57 402.95,255.59 402.95,254.64 402.88,254.57 v1(402.48,254.57)
  L28_SIGNAL w0.071: v1(357.52,256.03) 357.52,256.44 357.59,256.51 363.12,256.51 369.79,249.84 379.87,249.84 386.04,256.02 402.36,256.02 402.95,255.43 402.95,254.64 402.88,254.57 v1(402.48,254.57)
D11102: length 246.2
  L05_SIGNAL w0.071: D111.02 417.66,369.4 416.65,369.4 416.19,368.94 416.19,366.9 417.3,365.79 421.82,365.79 424.21,368.17 424.21,377.56 427.69,381.04 442.82,381.04 453.33,370.53 453.33,313.31 443.21,303.19 417.27,303.19 414.95,300.86 414.95,299.42 415.39,298.98 416.67,298.98 416.92,299.23 416.92,299.84 416.85,299.91 v1(416.45,299.91)
  L32_SIGNAL w0.071: v1(388.49,259.59) 388.49,260.94 388.56,261.01 416.98,261.01 419.64,263.67 419.64,274.05 414.56,279.13 414.56,301.37 415.51,302.31 416.29,302.31 416.92,301.68 416.92,299.98 416.85,299.91 v1(416.45,299.91)
  BOTTOM w0.119: v1(388.49,259.59) UNK2K43.6
D11103: length 385
  TOP w0.086: SITE2.86 343.98,252.43 344.06,252.35 345.64,252.35 350.02,256.73 357.07,256.73 v1(357.52,257.18)
  L05_SIGNAL w0.071: v1(403.63,254.57) 403.22,254.57 403.15,254.64 403.15,255.51 406.01,258.37 432.65,258.37 436.24,261.97 436.24,277.95 431.71,282.49 414.77,282.49 413.78,283.48 413.78,286.96 424.43,297.61 484.01,297.61 485.52,299.12 485.52,376.77 479.31,382.98 420.23,382.98 418.15,380.9 418.15,374.97 D111.03
  L28_SIGNAL w0.071: v1(357.52,257.18) 357.52,256.78 357.59,256.7 363.21,256.7 369.87,250.04 379.78,250.04 385.96,256.22 402.45,256.22 403.15,255.51 403.15,254.64 403.22,254.57 v1(403.63,254.57)
D11104: length 246.2
  L05_SIGNAL w0.071: v1(417.6,299.91) 417.19,299.91 417.12,299.84 417.12,299.15 416.76,298.79 415.3,298.79 414.75,299.34 414.75,300.94 417.19,303.38 443.13,303.38 453.13,313.39 453.13,370.45 442.74,380.84 427.77,380.84 424.41,377.48 424.41,368.09 421.91,365.59 417.22,365.59 415.99,366.82 415.99,368.87 D111.04
  L32_SIGNAL w0.071: v1(417.6,299.91) 417.19,299.91 417.12,299.98 417.12,301.76 416.37,302.51 415.42,302.51 414.37,301.46 414.37,279.05 419.44,273.97 419.44,263.75 416.9,261.21 388.56,261.21 388.49,261.28 v1(388.49,262.63)
  BOTTOM w0.119: v1(388.49,262.63) UNK2K43.3
D11105: length 385
  TOP w0.086: SITE2.75 343.98,248.03 344.06,248.11 357.07,248.11 v1(357.52,247.66)
  L05_SIGNAL w0.071: v1(416.45,286.32) 416.85,286.32 416.92,286.39 416.92,287.03 421.54,291.64 437.59,291.64 441.39,287.85 489.06,287.85 490.14,288.92 490.14,378.9 484.01,385.03 416.57,385.03 408.89,377.34 408.89,375.97 D111.05
  L32_SIGNAL w0.071: v1(416.45,286.32) 416.85,286.32 416.92,286.39 416.92,287.02 417.38,287.48 419.1,287.48 422.39,284.19 422.39,250.01 419.33,246.96 363.91,246.96 362.74,248.13 357.59,248.13 357.52,248.06 v1(357.52,247.66)
D11106: length 385
  TOP w0.086: SITE2.83 343.98,251.23 344.06,251.31 346.61,251.31 349.53,254.22 353.35,254.22 v1(353.81,253.77)
  L05_SIGNAL w0.071: v1(402.48,268.16) 402.88,268.16 402.95,268.09 402.95,266.76 409.83,259.88 430.6,259.88 433.78,263.07 433.78,276.63 429.71,280.7 414.83,280.7 411.9,283.63 411.9,289.69 413.4,291.19 413.4,301.2 417.22,305.02 442.2,305.02 451.54,314.36 451.54,369.64 450.85,370.33 450.08,370.33 449.64,369.89 449.64,346.79 449.22,346.36 448.27,346.36 447.83,346.8 447.83,373.35 441.38,379.8 428.6,379.8 426.35,377.55 426.35,364.5 425.11,363.25 409.28,363.25 407.46,365.07 407.46,369.36 D111.06
  L30_SIGNAL w0.071: v1(402.48,268.16) 402.88,268.16 402.95,268.09 402.95,267.41 402.08,266.53 381.8,266.53 376.09,260.82 368.35,260.82 362.51,254.98 356.36,254.98 355.08,256.26 352.82,256.26 352.2,255.63 352.2,254.68 352.63,254.24 353.73,254.24 353.81,254.17 v1(353.81,253.77)
D11107: length 385
  TOP w0.086: v1(357.52,248.8) 357.07,248.35 344.06,248.35 343.98,248.43 SITE2.76
  L05_SIGNAL w0.071: D111.07 407.83,374.81 408.6,374.81 408.69,374.9 408.69,377.42 416.49,385.23 484.09,385.23 490.33,378.98 490.33,288.84 489.14,287.65 441.31,287.65 437.51,291.45 421.63,291.45 417.12,286.94 417.12,286.39 417.19,286.32 v1(417.6,286.32)
  L32_SIGNAL w0.071: v1(417.6,286.32) 417.19,286.32 417.12,286.39 417.12,286.94 417.46,287.28 419.02,287.28 422.19,284.11 422.19,250.09 419.25,247.15 363.99,247.15 362.82,248.33 357.59,248.33 357.52,248.4 v1(357.52,248.8)
D11108: length 385
  TOP w0.086: v1(353.81,254.92) 353.35,254.46 349.43,254.46 346.51,251.55 344.06,251.55 343.98,251.63 SITE2.84
  L05_SIGNAL w0.071: v1(403.63,268.16) 403.22,268.16 403.15,268.09 403.15,266.85 409.92,260.08 430.52,260.08 433.58,263.15 433.58,276.55 429.63,280.5 414.75,280.5 411.7,283.55 411.7,289.78 413.2,291.28 413.2,301.28 417.13,305.21 442.12,305.21 451.34,314.44 451.34,369.56 450.77,370.13 450.17,370.13 449.84,369.81 449.84,346.71 449.3,346.17 448.19,346.17 447.64,346.72 447.64,373.27 441.3,379.6 428.68,379.6 426.55,377.47 426.55,364.41 425.19,363.06 409.19,363.06 407.26,364.98 407.26,367.81 405.61,369.33 405.37,369.33 D111.08
  L30_SIGNAL w0.071: v1(353.81,254.92) 353.81,254.51 353.73,254.44 352.71,254.44 352.4,254.76 352.4,255.55 352.91,256.06 355,256.06 356.27,254.78 362.59,254.78 368.43,260.62 376.17,260.62 381.89,266.33 402.16,266.33 403.15,267.32 403.15,268.09 403.22,268.16 v1(403.63,268.16)
D11109: length 385
  TOP w0.086: v1(357.52,252.08) 357.07,252.53 350.02,252.53 347.99,250.51 344.06,250.51 343.98,250.43 SITE2.81
  L05_SIGNAL w0.071: v1(375.3,238.32) 375.71,238.32 375.78,238.39 375.78,239.63 378.13,241.99 378.13,259.86 370.74,267.26 370.74,289.35 361.4,298.69 361.4,361.9 352.05,371.24 352.05,377.75 350.19,379.61 309.69,379.61 307.99,381.31 307.99,385.53 309.23,386.78 347.25,386.78 350.13,389.66 350.13,406.88 353.38,410.13 372.6,410.13 376.25,406.48 376.25,388.43 381.28,383.4 395.05,383.4 399.19,379.26 399.19,375.51 D111.09
  L28_SIGNAL w0.071: v1(357.52,252.08) 357.52,252.48 357.59,252.55 359.25,252.55 367.43,244.37 371.06,244.37 375.78,239.65 375.78,238.39 375.71,238.32 v1(375.3,238.32)
D11110: length 385
  TOP w0.086: v1(325.11,263.69) 324.65,263.24 324.65,262.03 326.15,260.53 326.15,257.86 326.23,257.78 SITE2.122
  L05_SIGNAL w0.071: D111.10 397.32,369.38 397.32,365.89 394.65,363.21 381.19,363.21 375.97,357.99 375.97,348.51 379.2,345.27 392.8,345.27 393.66,344.42 393.66,340.02 392.77,339.14 379.59,339.14 376.59,336.14 376.59,327.04 391.88,311.75 391.88,304.76 385.42,298.29 373.71,298.29 368.95,303.04 368.95,367.43 368.31,368.08 367.44,368.08 366.76,367.4 366.76,302.39 370.88,298.26 370.88,296.22 378.16,288.94 378.16,283.43 377.44,282.7 376.27,282.7 376.03,282.94 376.03,283.84 375.96,283.91 v1(375.56,283.91)
  L32_SIGNAL w0.071: v1(375.56,283.91) 375.96,283.91 376.03,283.84 376.03,283.3 375.72,282.98 374.28,282.98 373.09,281.8 373.09,279.8 369.74,276.46 334.44,276.46 322.46,264.48 322.46,262.62 322.94,262.14 324.13,262.14 324.63,262.65 324.63,263.62 324.7,263.69 v1(325.11,263.69)
D11111: length 385
  TOP w0.086: SITE2.82 343.98,250.83 344.06,250.75 347.89,250.75 349.92,252.77 357.07,252.77 v1(357.52,253.22)
  L05_SIGNAL w0.071: v1(376.45,238.32) 376.05,238.32 375.98,238.39 375.98,239.55 378.33,241.91 378.33,259.94 370.94,267.34 370.94,289.43 361.59,298.77 361.59,361.98 352.25,371.32 352.25,377.83 350.28,379.81 309.77,379.81 308.19,381.39 308.19,385.45 309.32,386.58 347.33,386.58 350.33,389.58 350.33,406.79 353.46,409.93 372.52,409.93 376.05,406.4 376.05,388.35 381.2,383.2 394.97,383.2 398.99,379.18 398.99,376.01 397.98,374.99 397.85,374.99 D111.11
  L28_SIGNAL w0.071: v1(357.52,253.22) 357.52,252.82 357.59,252.75 359.33,252.75 367.52,244.57 371.14,244.57 375.97,239.73 375.97,238.39 376.05,238.32 v1(376.45,238.32)
D11112: length 385
  TOP w0.086: SITE2.123 325.83,257.78 325.91,257.86 325.91,260.44 324.42,261.93 324.42,263.24 v1(323.96,263.69)
  L05_SIGNAL w0.071: v1(376.7,283.91) 376.3,283.91 376.23,283.84 376.23,283.03 376.35,282.9 377.36,282.9 377.96,283.51 377.96,288.86 370.69,296.13 370.69,298.18 366.56,302.31 366.56,367.48 367.35,368.27 368.39,368.27 369.15,367.52 369.15,303.12 373.79,298.49 385.34,298.49 391.69,304.84 391.69,311.66 376.39,326.96 376.39,336.22 379.51,339.33 392.69,339.33 393.46,340.11 393.46,344.34 392.72,345.08 379.12,345.08 375.77,348.43 375.77,358.07 381.1,363.41 394.56,363.41 397.13,365.97 397.13,368.29 396.12,369.24 395.3,369.24 D111.12
  L32_SIGNAL w0.071: v1(323.96,263.69) 324.36,263.69 324.44,263.62 324.44,262.73 324.05,262.34 323.03,262.34 322.66,262.7 322.66,264.4 334.52,276.26 369.83,276.26 373.29,279.72 373.29,281.71 374.36,282.78 375.8,282.78 376.23,283.21 376.23,283.84 376.3,283.91 v1(376.7,283.91)
D11113: length 385
  TOP w0.086: v1(322.12,269.08) 321.66,268.63 321.66,266.13 322.87,264.93 322.87,262.13 325.35,259.65 325.35,257.86 325.43,257.78 SITE2.124
  L05_SIGNAL w0.071: v1(375.56,270.32) 375.96,270.32 376.03,270.39 376.03,271.42 372.48,274.97 372.48,290.04 362.9,299.62 362.9,362.97 353.32,372.55 353.32,378.24 350.64,380.92 310.79,380.92 309.72,381.99 309.72,384.61 310.55,385.44 347.85,385.44 351.63,389.22 351.63,405.71 354.63,408.71 371.78,408.71 374.81,405.68 374.81,387.35 380.4,381.76 394.13,381.76 395.04,380.85 395.04,379.71 394.04,378.71 389.79,378.71 388.72,377.64 388.72,375.82 D111.13
  L28_SIGNAL w0.071: v1(322.12,269.08) 321.71,269.08 321.64,269.16 321.64,272.1 326.72,277.18 370.48,277.18 376.03,271.63 376.03,270.39 375.96,270.32 v1(375.56,270.32)
D11114: length 385
  TOP w0.086: v1(353.81,258.17) 353.35,258.62 350.67,258.62 344.96,252.91 344.06,252.91 343.98,252.83 SITE2.87
  L05_SIGNAL w0.071: v1(375.3,267.91) 375.71,267.91 375.78,267.83 375.78,267.08 376.13,266.72 378.12,266.72 378.65,267.26 378.65,272.18 373.9,276.94 373.9,290.65 364.7,299.85 364.7,364.54 355.22,374.02 355.22,379.78 352.75,382.25 311.79,382.25 311.5,382.54 311.5,383.6 311.81,383.91 349.09,383.91 353.53,388.36 353.53,405.03 355.38,406.87 371.76,406.87 373.04,405.6 373.04,404.66 372.02,403.64 357.74,403.64 356.97,402.88 356.97,401.55 357.68,400.84 372.3,400.84 373.11,400.03 373.11,371.72 379.07,365.77 385.15,365.77 385.92,366.55 385.92,368.35 387.19,369.61 387.39,369.61 D111.14
  L30_SIGNAL w0.071: v1(353.81,258.17) 353.81,258.57 353.73,258.64 352.88,258.64 352.52,258.29 352.52,257.63 352.95,257.2 355.09,257.2 360.43,262.54 371.7,262.54 375.78,266.62 375.78,267.83 375.71,267.91 v1(375.3,267.91)
